* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_onehot_counter clk count[0] count[1]
+ count[2] count[3] count[4] count[5] count[6] count[7] enable
+ rst_n
X_22_ net4 net11 net2 VSS VSS VDD VDD _00_ sky130_fd_sc_hd__mux2_1
X_23_ net5 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__inv_1
X_24_ net2 VSS VSS VDD VDD _09_ sky130_fd_sc_hd__buf_6
X_25_ net11 _09_ net4 VSS VSS VDD VDD _10_ sky130_fd_sc_hd__nand3b_1
X_26_ _08_ _09_ _10_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__o21ai_0
X_27_ net6 VSS VSS VDD VDD _11_ sky130_fd_sc_hd__inv_1
X_28_ net11 net5 _09_ VSS VSS VDD VDD _12_ sky130_fd_sc_hd__nand3b_1
X_29_ _11_ _09_ _12_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__o21ai_0
X_30_ net7 VSS VSS VDD VDD _13_ sky130_fd_sc_hd__inv_1
X_31_ net11 net6 _09_ VSS VSS VDD VDD _14_ sky130_fd_sc_hd__nand3b_1
X_32_ _13_ _09_ _14_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__o21ai_0
X_33_ net8 VSS VSS VDD VDD _15_ sky130_fd_sc_hd__inv_1
X_34_ net11 net7 net2 VSS VSS VDD VDD _16_ sky130_fd_sc_hd__nand3b_1
X_35_ _15_ _09_ _16_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__o21ai_0
X_36_ net9 VSS VSS VDD VDD _17_ sky130_fd_sc_hd__inv_1
X_37_ net11 net8 net2 VSS VSS VDD VDD _18_ sky130_fd_sc_hd__nand3b_1
X_38_ _17_ _09_ _18_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__o21ai_0
X_39_ net10 VSS VSS VDD VDD _19_ sky130_fd_sc_hd__inv_1
X_40_ net11 net9 net2 VSS VSS VDD VDD _20_ sky130_fd_sc_hd__nand3b_1
X_41_ _19_ _09_ _20_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__o21ai_0
X_42_ net10 net2 VSS VSS VDD VDD _21_ sky130_fd_sc_hd__nand2_1
X_43_ _21_ _09_ net11 VSS VSS VDD VDD _07_ sky130_fd_sc_hd__mux2i_1
Xcounter_reg\[0\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _00_ net3
+ VSS VSS VDD VDD net4 sky130_fd_sc_hd__dfstp_1
Xcounter_reg\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _01_ net1
+ VSS VSS VDD VDD net5 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _02_ net1
+ VSS VSS VDD VDD net6 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _03_ net1
+ VSS VSS VDD VDD net7 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _04_ net1
+ VSS VSS VDD VDD net8 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[5\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _05_ net1
+ VSS VSS VDD VDD net9 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[6\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _06_ net1
+ VSS VSS VDD VDD net10 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[7\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _07_ net1
+ VSS VSS VDD VDD net11 sky130_fd_sc_hd__dfrtp_2
Xhold1 net3 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 enable VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput2 net12 VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xoutput3 net4 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net5 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net6 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net7 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput7 net8 VSS VSS VDD VDD count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net9 VSS VSS VDD VDD count[5] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net10 VSS VSS VDD VDD count[6] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net11 VSS VSS VDD VDD count[7] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net12 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_onehot_counter
