* cell ddr_controller
* pin VDD,phy_cke,phy_dqs_p[0],phy_dqs_p[1],phy_dqs_p[2],phy_dqs_p[3],phy_dqs_p[4],phy_dqs_p[5],phy_dqs_p[6],phy_dqs_p[7],phy_odt
* pin VSS,phy_bank_group[0],phy_bank_group[1],phy_dqs_n[0],phy_dqs_n[1],phy_dqs_n[2],phy_dqs_n[3],phy_dqs_n[4],phy_dqs_n[5],phy_dqs_n[6],phy_dqs_n[7]
* pin cmd_burst_len[1]
* pin cmd_burst_len[2]
* pin cmd_burst_len[0]
* pin phy_cs_n
* pin cmd_addr[9]
* pin cmd_addr[16]
* pin cmd_addr[23]
* pin phy_addr[9]
* pin cmd_addr[26]
* pin cmd_addr[7]
* pin cmd_addr[4]
* pin cmd_addr[6]
* pin cmd_addr[17]
* pin cmd_addr[18]
* pin cmd_addr[27]
* pin cmd_addr[24]
* pin cmd_addr[5]
* pin cmd_addr[0]
* pin cmd_addr[14]
* pin phy_addr[13]
* pin cmd_addr[21]
* pin cmd_addr[19]
* pin phy_addr[0]
* pin cmd_addr[20]
* pin phy_addr[3]
* pin phy_addr[10]
* pin cmd_addr[11]
* pin wr_mask[0]
* pin phy_dm[0]
* pin cmd_addr[3]
* pin phy_addr[12]
* pin phy_dm[5]
* pin wr_mask[5]
* pin wr_mask[3]
* pin phy_dm[3]
* pin wr_mask[1]
* pin phy_dm[1]
* pin wr_mask[6]
* pin phy_dm[6]
* pin phy_addr[4]
* pin phy_addr[2]
* pin cmd_burst_len[3]
* pin cmd_addr[13]
* pin state[0]
* pin init_done
* pin state[1]
* pin cmd_addr[2]
* pin phy_addr[7]
* pin cmd_ready
* pin clk
* pin phy_addr[6]
* pin phy_reset_n
* pin phy_addr[5]
* pin cmd_addr[8]
* pin cmd_addr[1]
* pin cmd_addr[25]
* pin cmd_addr[15]
* pin cmd_addr[22]
* pin phy_ras_n
* pin phy_cas_n
* pin phy_addr[1]
* pin phy_addr[11]
* pin cmd_valid
* pin cmd_write
* pin phy_we_n
* pin wr_valid
* pin rd_ready
* pin wr_data[4]
* pin phy_dq[33]
* pin cmd_addr[12]
* pin phy_dq[4]
* pin wr_ready
* pin rd_valid
* pin rd_data[33]
* pin wr_data[51]
* pin rd_data[58]
* pin wr_data[33]
* pin rd_data[51]
* pin phy_dq[51]
* pin rst_n
* pin wr_data[47]
* pin phy_dq[47]
* pin phy_bank[0]
* pin rd_data[47]
* pin phy_addr[8]
* pin wr_data[62]
* pin wr_data[42]
* pin rd_data[4]
* pin phy_bank[1]
* pin rd_data[19]
* pin rd_data[49]
* pin wr_data[54]
* pin phy_dq[42]
* pin rd_data[17]
* pin rd_data[62]
* pin rd_data[5]
* pin rd_data[54]
* pin wr_data[61]
* pin rd_data[46]
* pin rd_data[59]
* pin rd_data[34]
* pin rd_data[26]
* pin phy_dq[62]
* pin rd_data[42]
* pin rd_data[61]
* pin phy_dq[54]
* pin rd_data[38]
* pin rd_data[25]
* pin wr_data[60]
* pin rd_data[40]
* pin rd_data[1]
* pin rd_data[23]
* pin rd_data[60]
* pin rd_data[9]
* pin rd_data[55]
* pin rd_data[13]
* pin rd_data[2]
* pin rd_data[14]
* pin rd_data[28]
* pin wr_data[5]
* pin rd_data[8]
* pin wr_data[8]
* pin phy_dq[5]
* pin phy_dq[60]
* pin rd_data[3]
* pin rd_data[35]
* pin rd_data[44]
* pin phy_dq[8]
* pin rd_data[43]
* pin rd_data[29]
* pin rd_data[6]
* pin rd_data[27]
* pin rd_data[52]
* pin rd_data[39]
* pin rd_data[11]
* pin phy_dq[9]
* pin wr_data[6]
* pin rd_data[15]
* pin rd_data[18]
* pin rd_data[21]
* pin rd_data[63]
* pin rd_data[45]
* pin rd_data[20]
* pin rd_data[0]
* pin rd_data[22]
* pin rd_data[57]
* pin wr_data[9]
* pin phy_dq[10]
* pin rd_data[37]
* pin rd_data[36]
* pin rd_data[7]
* pin rd_data[16]
* pin rd_data[31]
* pin rd_data[53]
* pin wr_data[52]
* pin rd_data[12]
* pin rd_data[50]
* pin phy_dq[52]
* pin rd_data[48]
* pin rd_data[10]
* pin wr_mask[4]
* pin wr_data[3]
* pin wr_data[53]
* pin phy_dq[7]
* pin wr_data[36]
* pin wr_data[7]
* pin phy_dq[58]
* pin wr_data[63]
* pin rd_data[32]
* pin phy_dm[4]
* pin rd_data[41]
* pin wr_data[43]
* pin rd_data[24]
* pin phy_dq[56]
* pin wr_data[56]
* pin phy_dq[53]
* pin wr_data[37]
* pin wr_data[57]
* pin phy_dq[16]
* pin wr_data[16]
* pin phy_dq[63]
* pin wr_data[12]
* pin phy_dq[48]
* pin wr_data[10]
* pin wr_data[48]
* pin phy_dq[37]
* pin wr_data[41]
* pin wr_mask[2]
* pin wr_mask[7]
* pin phy_dq[11]
* pin phy_dq[28]
* pin phy_dq[14]
* pin wr_data[0]
* pin phy_dq[45]
* pin phy_dq[13]
* pin wr_data[13]
* pin wr_data[44]
* pin phy_dq[18]
* pin wr_data[58]
* pin phy_dm[2]
* pin wr_data[26]
* pin wr_data[23]
* pin phy_dq[36]
* pin phy_dq[15]
* pin phy_dq[46]
* pin wr_data[11]
* pin phy_dq[44]
* pin wr_data[18]
* pin phy_dq[21]
* pin phy_dq[49]
* pin phy_dq[3]
* pin phy_dq[40]
* pin wr_data[40]
* pin wr_data[14]
* pin wr_data[45]
* pin wr_data[50]
* pin phy_dq[23]
* pin wr_data[21]
* pin phy_dq[41]
* pin phy_dq[26]
* pin wr_data[29]
* pin wr_data[20]
* pin wr_data[22]
* pin phy_dq[27]
* pin wr_data[34]
* pin wr_data[27]
* pin wr_data[32]
* pin wr_data[35]
* pin wr_data[39]
* pin wr_data[17]
* pin wr_data[31]
* pin phy_dq[59]
* pin phy_dq[19]
* pin phy_dq[29]
* pin wr_data[19]
* pin phy_dq[1]
* pin phy_dq[50]
* pin phy_dq[39]
* pin phy_dm[7]
* pin rd_data[56]
* pin phy_dq[30]
* pin wr_data[1]
* pin phy_dq[24]
* pin wr_data[30]
* pin wr_data[24]
* pin wr_data[46]
* pin wr_data[25]
* pin phy_dq[31]
* pin phy_dq[25]
* pin wr_data[59]
* pin wr_data[49]
* pin phy_dq[20]
* pin phy_dq[17]
* pin phy_dq[2]
* pin phy_dq[38]
* pin phy_dq[55]
* pin wr_data[2]
* pin wr_data[55]
* pin wr_data[28]
* pin phy_dq[32]
* pin phy_dq[57]
* pin phy_clk
* pin phy_dq[22]
* pin phy_dq[43]
* pin phy_dq[34]
* pin phy_bank[2]
* pin phy_dq[35]
* pin phy_dq[0]
* pin wr_data[38]
* pin phy_dq[12]
* pin phy_dq[6]
* pin wr_data[15]
* pin rd_data[30]
* pin phy_dq[61]
.SUBCKT ddr_controller 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22
+ 23 24 25 26 27 28 29 30 31 32 33 36 47 49 50 136 157 197 211 296 354 374 399
+ 400 459 461 473 481 514 517 519 603 614 620 646 659 660 684 691 692 696 732
+ 740 784 820 821 839 844 845 860 886 887 888 909 910 925 926 935 937 939 942
+ 948 952 955 963 964 968 969 974 977 981 985 986 991 995 998 1000 1001 1003
+ 1004 1009 1010 1012 1015 1016 1017 1036 1039 1040 1041 1042 1044 1045 1046
+ 1047 1048 1050 1052 1054 1055 1057 1058 1061 1067 1069 1077 1080 1081 1082
+ 1085 1087 1088 1090 1091 1092 1099 1102 1103 1107 1110 1113 1118 1120 1124
+ 1127 1129 1130 1131 1137 1138 1140 1141 1142 1143 1144 1146 1148 1150 1152
+ 1154 1155 1157 1159 1161 1162 1163 1164 1167 1168 1169 1171 1172 1175 1176
+ 1177 1179 1180 1181 1182 1183 1184 1185 1186 1187 1189 1190 1191 1192 1193
+ 1194 1195 1196 1197 1198 1199 1200 1201 1202 1203 1204 1205 1206 1207 1208
+ 1209 1210 1211 1212 1213 1214 1215 1216 1217 1218 1219 1220 1221 1222 1223
+ 1224 1226 1227 1228 1229 1230 1231 1232 1233 1234 1235 1236 1237 1238 1239
+ 1240 1241 1242 1243 1244 1245 1246 1247 1248 1249 1250 1251 1252 1253 1254
+ 1255 1256 1257 1258 1259 1260 1261 1262 1263 1264 1265 1266 1267 1268 1269
+ 1270 1271 1272 1273 1274 1275 1276 1277 1278 1279
* net 1 VDD,phy_cke,phy_dqs_p[0],phy_dqs_p[1],phy_dqs_p[2],phy_dqs_p[3],phy_dqs_p[4],phy_dqs_p[5],phy_dqs_p[6],phy_dqs_p[7],phy_odt
* net 2 VSS,phy_bank_group[0],phy_bank_group[1],phy_dqs_n[0],phy_dqs_n[1],phy_dqs_n[2],phy_dqs_n[3],phy_dqs_n[4],phy_dqs_n[5],phy_dqs_n[6],phy_dqs_n[7]
* net 3 cmd_burst_len[1]
* net 4 cmd_burst_len[2]
* net 5 cmd_burst_len[0]
* net 6 phy_cs_n
* net 7 cmd_addr[9]
* net 8 cmd_addr[16]
* net 9 cmd_addr[23]
* net 10 phy_addr[9]
* net 11 cmd_addr[26]
* net 12 cmd_addr[7]
* net 13 cmd_addr[4]
* net 14 cmd_addr[6]
* net 15 cmd_addr[17]
* net 16 cmd_addr[18]
* net 17 cmd_addr[27]
* net 18 cmd_addr[24]
* net 19 cmd_addr[5]
* net 20 cmd_addr[0]
* net 21 cmd_addr[14]
* net 22 phy_addr[13]
* net 23 cmd_addr[21]
* net 24 cmd_addr[19]
* net 25 phy_addr[0]
* net 26 cmd_addr[20]
* net 27 phy_addr[3]
* net 28 phy_addr[10]
* net 29 cmd_addr[11]
* net 30 wr_mask[0]
* net 31 phy_dm[0]
* net 32 cmd_addr[3]
* net 33 phy_addr[12]
* net 36 phy_dm[5]
* net 47 wr_mask[5]
* net 49 wr_mask[3]
* net 50 phy_dm[3]
* net 136 wr_mask[1]
* net 157 phy_dm[1]
* net 197 wr_mask[6]
* net 211 phy_dm[6]
* net 296 phy_addr[4]
* net 354 phy_addr[2]
* net 374 cmd_burst_len[3]
* net 399 cmd_addr[13]
* net 400 state[0]
* net 459 init_done
* net 461 state[1]
* net 473 cmd_addr[2]
* net 481 phy_addr[7]
* net 514 cmd_ready
* net 517 clk
* net 519 phy_addr[6]
* net 603 phy_reset_n
* net 614 phy_addr[5]
* net 620 cmd_addr[8]
* net 646 cmd_addr[1]
* net 659 cmd_addr[25]
* net 660 cmd_addr[15]
* net 684 cmd_addr[22]
* net 691 phy_ras_n
* net 692 phy_cas_n
* net 696 phy_addr[1]
* net 732 phy_addr[11]
* net 740 cmd_valid
* net 784 cmd_write
* net 820 phy_we_n
* net 821 wr_valid
* net 839 rd_ready
* net 844 wr_data[4]
* net 845 phy_dq[33]
* net 860 cmd_addr[12]
* net 886 phy_dq[4]
* net 887 wr_ready
* net 888 rd_valid
* net 909 rd_data[33]
* net 910 wr_data[51]
* net 925 rd_data[58]
* net 926 wr_data[33]
* net 935 rd_data[51]
* net 937 phy_dq[51]
* net 939 rst_n
* net 942 wr_data[47]
* net 948 phy_dq[47]
* net 952 phy_bank[0]
* net 955 rd_data[47]
* net 963 phy_addr[8]
* net 964 wr_data[62]
* net 968 wr_data[42]
* net 969 rd_data[4]
* net 974 phy_bank[1]
* net 977 rd_data[19]
* net 981 rd_data[49]
* net 985 wr_data[54]
* net 986 phy_dq[42]
* net 991 rd_data[17]
* net 995 rd_data[62]
* net 998 rd_data[5]
* net 1000 rd_data[54]
* net 1001 wr_data[61]
* net 1003 rd_data[46]
* net 1004 rd_data[59]
* net 1009 rd_data[34]
* net 1010 rd_data[26]
* net 1012 phy_dq[62]
* net 1015 rd_data[42]
* net 1016 rd_data[61]
* net 1017 phy_dq[54]
* net 1036 rd_data[38]
* net 1039 rd_data[25]
* net 1040 wr_data[60]
* net 1041 rd_data[40]
* net 1042 rd_data[1]
* net 1044 rd_data[23]
* net 1045 rd_data[60]
* net 1046 rd_data[9]
* net 1047 rd_data[55]
* net 1048 rd_data[13]
* net 1050 rd_data[2]
* net 1052 rd_data[14]
* net 1054 rd_data[28]
* net 1055 wr_data[5]
* net 1057 rd_data[8]
* net 1058 wr_data[8]
* net 1061 phy_dq[5]
* net 1067 phy_dq[60]
* net 1069 rd_data[3]
* net 1077 rd_data[35]
* net 1080 rd_data[44]
* net 1081 phy_dq[8]
* net 1082 rd_data[43]
* net 1085 rd_data[29]
* net 1087 rd_data[6]
* net 1088 rd_data[27]
* net 1090 rd_data[52]
* net 1091 rd_data[39]
* net 1092 rd_data[11]
* net 1099 phy_dq[9]
* net 1102 wr_data[6]
* net 1103 rd_data[15]
* net 1107 rd_data[18]
* net 1110 rd_data[21]
* net 1113 rd_data[63]
* net 1118 rd_data[45]
* net 1120 rd_data[20]
* net 1124 rd_data[0]
* net 1127 rd_data[22]
* net 1129 rd_data[57]
* net 1130 wr_data[9]
* net 1131 phy_dq[10]
* net 1137 rd_data[37]
* net 1138 rd_data[36]
* net 1140 rd_data[7]
* net 1141 rd_data[16]
* net 1142 rd_data[31]
* net 1143 rd_data[53]
* net 1144 wr_data[52]
* net 1146 rd_data[12]
* net 1148 rd_data[50]
* net 1150 phy_dq[52]
* net 1152 rd_data[48]
* net 1154 rd_data[10]
* net 1155 wr_mask[4]
* net 1157 wr_data[3]
* net 1159 wr_data[53]
* net 1161 phy_dq[7]
* net 1162 wr_data[36]
* net 1163 wr_data[7]
* net 1164 phy_dq[58]
* net 1167 wr_data[63]
* net 1168 rd_data[32]
* net 1169 phy_dm[4]
* net 1171 rd_data[41]
* net 1172 wr_data[43]
* net 1175 rd_data[24]
* net 1176 phy_dq[56]
* net 1177 wr_data[56]
* net 1179 phy_dq[53]
* net 1180 wr_data[37]
* net 1181 wr_data[57]
* net 1182 phy_dq[16]
* net 1183 wr_data[16]
* net 1184 phy_dq[63]
* net 1185 wr_data[12]
* net 1186 phy_dq[48]
* net 1187 wr_data[10]
* net 1189 wr_data[48]
* net 1190 phy_dq[37]
* net 1191 wr_data[41]
* net 1192 wr_mask[2]
* net 1193 wr_mask[7]
* net 1194 phy_dq[11]
* net 1195 phy_dq[28]
* net 1196 phy_dq[14]
* net 1197 wr_data[0]
* net 1198 phy_dq[45]
* net 1199 phy_dq[13]
* net 1200 wr_data[13]
* net 1201 wr_data[44]
* net 1202 phy_dq[18]
* net 1203 wr_data[58]
* net 1204 phy_dm[2]
* net 1205 wr_data[26]
* net 1206 wr_data[23]
* net 1207 phy_dq[36]
* net 1208 phy_dq[15]
* net 1209 phy_dq[46]
* net 1210 wr_data[11]
* net 1211 phy_dq[44]
* net 1212 wr_data[18]
* net 1213 phy_dq[21]
* net 1214 phy_dq[49]
* net 1215 phy_dq[3]
* net 1216 phy_dq[40]
* net 1217 wr_data[40]
* net 1218 wr_data[14]
* net 1219 wr_data[45]
* net 1220 wr_data[50]
* net 1221 phy_dq[23]
* net 1222 wr_data[21]
* net 1223 phy_dq[41]
* net 1224 phy_dq[26]
* net 1226 wr_data[29]
* net 1227 wr_data[20]
* net 1228 wr_data[22]
* net 1229 phy_dq[27]
* net 1230 wr_data[34]
* net 1231 wr_data[27]
* net 1232 wr_data[32]
* net 1233 wr_data[35]
* net 1234 wr_data[39]
* net 1235 wr_data[17]
* net 1236 wr_data[31]
* net 1237 phy_dq[59]
* net 1238 phy_dq[19]
* net 1239 phy_dq[29]
* net 1240 wr_data[19]
* net 1241 phy_dq[1]
* net 1242 phy_dq[50]
* net 1243 phy_dq[39]
* net 1244 phy_dm[7]
* net 1245 rd_data[56]
* net 1246 phy_dq[30]
* net 1247 wr_data[1]
* net 1248 phy_dq[24]
* net 1249 wr_data[30]
* net 1250 wr_data[24]
* net 1251 wr_data[46]
* net 1252 wr_data[25]
* net 1253 phy_dq[31]
* net 1254 phy_dq[25]
* net 1255 wr_data[59]
* net 1256 wr_data[49]
* net 1257 phy_dq[20]
* net 1258 phy_dq[17]
* net 1259 phy_dq[2]
* net 1260 phy_dq[38]
* net 1261 phy_dq[55]
* net 1262 wr_data[2]
* net 1263 wr_data[55]
* net 1264 wr_data[28]
* net 1265 phy_dq[32]
* net 1266 phy_dq[57]
* net 1267 phy_clk
* net 1268 phy_dq[22]
* net 1269 phy_dq[43]
* net 1270 phy_dq[34]
* net 1271 phy_bank[2]
* net 1272 phy_dq[35]
* net 1273 phy_dq[0]
* net 1274 wr_data[38]
* net 1275 phy_dq[12]
* net 1276 phy_dq[6]
* net 1277 wr_data[15]
* net 1278 rd_data[30]
* net 1279 phy_dq[61]
* cell instance $26 r0 *1 1.38,29.92
X$26 2 68 246 52 278 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $27 r0 *1 10.58,29.92
X$27 1 64 246 278 2 1 2 sky130_fd_sc_hd__nor2b_1
* cell instance $29 r0 *1 13.8,29.92
X$29 1 247 236 281 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $31 r0 *1 15.64,29.92
X$31 1 188 236 247 1 249 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $32 r0 *1 17.48,29.92
X$32 1 248 249 250 174 1 280 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $33 r0 *1 20.24,29.92
X$33 1 250 283 174 1 137 2 2 sky130_fd_sc_hd__o21a_1
* cell instance $34 r0 *1 23,29.92
X$34 1 234 188 247 2 1 283 2 sky130_fd_sc_hd__a21oi_1
* cell instance $35 r0 *1 24.84,29.92
X$35 2 68 286 52 285 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $38 r0 *1 39.56,29.92
X$38 1 140 220 269 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $39 r0 *1 40.94,29.92
X$39 1 251 221 268 287 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $42 r0 *1 44.16,29.92
X$42 1 269 251 205 221 2 218 1 2 sky130_fd_sc_hd__nor4_1
* cell instance $43 r0 *1 46.46,29.92
X$43 1 270 140 271 268 2 1 2 sky130_fd_sc_hd__nand3b_1
* cell instance $44 r0 *1 49.22,29.92
X$44 2 264 265 224 140 272 80 1 1 2 sky130_fd_sc_hd__a221oi_1
* cell instance $45 r0 *1 52.44,29.92
X$45 2 68 279 273 288 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $47 r0 *1 62.1,29.92
X$47 1 252 207 245 243 223 267 1 2 2 sky130_fd_sc_hd__o221ai_1
* cell instance $48 r0 *1 65.32,29.92
X$48 1 193 145 252 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $49 r0 *1 66.7,29.92
X$49 2 292 74 46 244 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $53 r0 *1 76.36,29.92
X$53 1 440 82 294 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $54 r0 *1 79.58,29.92
X$54 2 196 295 43 44 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $55 r0 *1 90.62,29.92
X$55 1 274 295 275 1 263 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $56 r0 *1 92.46,29.92
X$56 1 43 1 2 1281 2 sky130_fd_sc_hd__clkinv_1
* cell instance $58 r0 *1 94.76,29.92
X$58 1 253 304 293 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $61 r0 *1 98.44,29.92
X$61 2 210 43 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $62 r0 *1 107.64,29.92
X$62 1 126 130 289 291 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $64 r0 *1 110.4,29.92
X$64 1 71 216 256 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $65 r0 *1 111.78,29.92
X$65 1 262 256 302 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $66 r0 *1 113.16,29.92
X$66 2 35 284 59 193 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $70 r0 *1 126.04,29.92
X$70 2 97 282 59 215 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $71 r0 *1 137.08,29.92
X$71 2 66 258 59 215 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $74 r0 *1 149.5,29.92
X$74 1 279 2 1 296 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $79 m0 *1 8.74,35.36
X$79 1 64 317 297 2 1 2 sky130_fd_sc_hd__nor2b_1
* cell instance $80 m0 *1 11.04,35.36
X$80 2 68 308 298 300 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $82 m0 *1 20.7,35.36
X$82 1 286 327 234 248 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $83 m0 *1 22.54,35.36
X$83 1 52 1 2 2 sky130_fd_sc_hd__clkinvlp_4
* cell instance $84 m0 *1 25.3,35.36
X$84 1 64 286 285 2 1 2 sky130_fd_sc_hd__nor2b_1
* cell instance $92 m0 *1 34.5,35.36
X$92 2 68 270 52 322 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $94 m0 *1 44.16,35.36
X$94 1 58 1 2 2 sky130_fd_sc_hd__inv_6
* cell instance $95 m0 *1 47.38,35.36
X$95 2 210 58 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $98 m0 *1 57.04,35.36
X$98 2 331 266 224 140 272 45 1 1 2 sky130_fd_sc_hd__a221oi_1
* cell instance $99 m0 *1 60.26,35.36
X$99 1 290 279 145 2 1 346 2 sky130_fd_sc_hd__a21oi_1
* cell instance $101 m0 *1 63.02,35.36
X$101 1 272 144 223 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $104 m0 *1 65.78,35.36
X$104 2 68 325 273 307 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $107 m0 *1 77.28,35.36
X$107 1 306 294 186 242 2 326 1 2 sky130_fd_sc_hd__nor4_1
* cell instance $114 m0 *1 86.02,35.36
X$114 2 196 305 228 37 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $115 m0 *1 97.06,35.36
X$115 1 274 305 275 1 333 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $117 m0 *1 99.36,35.36
X$117 2 147 303 228 193 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $122 m0 *1 112.24,35.36
X$122 1 126 276 302 323 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $125 m0 *1 115.46,35.36
X$125 1 40 277 276 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $127 m0 *1 118.68,35.36
X$127 2 210 59 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $128 m0 *1 127.88,35.36
X$128 2 277 260 284 71 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $130 m0 *1 132.48,35.36
X$130 1 321 71 230 2 1 254 2 sky130_fd_sc_hd__a21oi_1
* cell instance $131 m0 *1 134.32,35.36
X$131 2 301 282 259 40 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $138 m0 *1 141.22,35.36
X$138 2 196 257 299 215 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $163 m0 *1 38.64,8.16
X$163 2 68 48 58 1 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $168 r0 *1 7.36,51.68
X$168 1 447 2 1 459 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $169 r0 *1 11.04,51.68
X$169 1 401 2 1 461 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $173 r0 *1 16.56,51.68
X$173 1 460 1 2 448 2 sky130_fd_sc_hd__inv_1
* cell instance $174 r0 *1 17.94,51.68
X$174 1 448 413 462 1 430 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $175 r0 *1 19.78,51.68
X$175 1 401 413 462 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $177 r0 *1 21.62,51.68
X$177 1 463 412 439 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $178 r0 *1 23,51.68
X$178 1 463 1 2 224 2 sky130_fd_sc_hd__buf_4
* cell instance $180 r0 *1 26.22,51.68
X$180 2 68 450 298 464 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $181 r0 *1 35.42,51.68
X$181 1 392 451 349 465 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $183 r0 *1 37.72,51.68
X$183 1 431 432 427 1 413 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $188 r0 *1 43.24,51.68
X$188 2 68 451 273 469 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $190 r0 *1 54.28,51.68
X$190 1 427 432 243 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $192 r0 *1 57.5,51.68
X$192 1 357 144 394 1 368 2 2 sky130_fd_sc_hd__a21oi_2
* cell instance $193 r0 *1 60.72,51.68
X$193 1 243 470 471 1 442 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $196 r0 *1 66.7,51.68
X$196 1 444 445 407 453 2 1 472 2 sky130_fd_sc_hd__a31oi_1
* cell instance $197 r0 *1 69,51.68
X$197 1 224 433 445 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $201 r0 *1 74.98,51.68
X$201 2 147 454 228 434 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $202 r0 *1 86.02,51.68
X$202 1 454 122 443 1 435 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $204 r0 *1 88.32,51.68
X$204 2 436 435 443 468 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $210 r0 *1 102.12,51.68
X$210 1 71 441 486 2 1 2 sky130_fd_sc_hd__nand2b_1
* cell instance $211 r0 *1 104.42,51.68
X$211 1 126 71 352 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $215 r0 *1 109.02,51.68
X$215 2 108 467 299 325 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $216 r0 *1 120.06,51.68
X$216 1 71 437 422 466 2 1 2 sky130_fd_sc_hd__nor3b_1
* cell instance $218 r0 *1 123.28,51.68
X$218 1 316 421 274 455 2 1 416 2 sky130_fd_sc_hd__a31oi_1
* cell instance $222 r0 *1 131.56,51.68
X$222 1 437 274 420 2 1 404 2 sky130_fd_sc_hd__a21oi_1
* cell instance $225 r0 *1 135.7,51.68
X$225 1 456 417 455 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $226 r0 *1 137.08,51.68
X$226 2 35 457 299 325 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $234 m0 *1 3.68,57.12
X$234 2 68 447 298 446 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $235 m0 *1 12.88,57.12
X$235 1 355 447 446 2 1 2 sky130_fd_sc_hd__nand2b_1
* cell instance $245 m0 *1 30.82,57.12
X$245 1 450 365 451 449 464 1 2 2 sky130_fd_sc_hd__a31o_2
* cell instance $248 m0 *1 35.42,57.12
X$248 1 392 451 485 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $250 m0 *1 37.72,57.12
X$250 1 365 449 367 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $251 m0 *1 39.1,57.12
X$251 1 424 393 452 474 1 2 2 sky130_fd_sc_hd__or3_1
* cell instance $254 m0 *1 45.54,57.12
X$254 2 469 414 451 367 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $258 m0 *1 54.74,57.12
X$258 1 475 427 432 1 2 145 2 sky130_fd_sc_hd__o21ai_1
* cell instance $261 m0 *1 57.04,57.12
X$261 1 427 432 144 1 2 2 sky130_fd_sc_hd__and2_1
* cell instance $264 m0 *1 63.94,57.12
X$264 2 410 434 273 472 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $265 m0 *1 73.14,57.12
X$265 2 147 478 273 406 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $269 m0 *1 85.1,57.12
X$269 1 478 429 443 454 518 2 1 2 sky130_fd_sc_hd__o22ai_1
* cell instance $272 m0 *1 91.54,57.12
X$272 2 109 487 228 100 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $273 m0 *1 102.58,57.12
X$273 1 487 352 486 275 2 571 1 2 sky130_fd_sc_hd__a22o_1
* cell instance $282 m0 *1 118.68,57.12
X$282 1 316 467 71 466 2 1 502 2 sky130_fd_sc_hd__a31oi_1
* cell instance $283 m0 *1 120.98,57.12
X$283 2 108 484 299 406 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $289 m0 *1 141.68,57.12
X$289 1 126 71 458 480 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $291 m0 *1 143.98,57.12
X$291 2 458 482 457 40 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $294 m0 *1 150.42,57.12
X$294 1 325 2 1 481 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $308 r0 *1 1.38,13.6
X$308 1 136 1 2 166 2 sky130_fd_sc_hd__buf_4
* cell instance $311 r0 *1 10.12,13.6
X$311 1 64 113 149 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $313 r0 *1 11.96,13.6
X$313 1 64 114 107 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $318 r0 *1 17.02,13.6
X$318 1 117 93 114 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $319 r0 *1 20.24,13.6
X$319 1 53 89 129 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $320 r0 *1 21.62,13.6
X$320 1 93 117 103 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $323 r0 *1 25.76,13.6
X$323 1 103 102 110 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $324 r0 *1 27.14,13.6
X$324 1 78 102 104 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $325 r0 *1 28.52,13.6
X$325 1 94 104 119 1 96 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $326 r0 *1 30.36,13.6
X$326 1 119 94 104 112 1 2 2 sky130_fd_sc_hd__or3_1
* cell instance $333 r0 *1 44.16,13.6
X$333 1 4 2 1 154 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $335 r0 *1 48.76,13.6
X$335 1 5 2 1 134 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $338 r0 *1 57.96,13.6
X$338 2 68 34 58 133 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $344 r0 *1 71.3,13.6
X$344 1 19 2 1 433 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $347 r0 *1 79.58,13.6
X$347 2 109 131 43 44 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $352 r0 *1 102.12,13.6
X$352 1 40 105 130 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $355 r0 *1 108.1,13.6
X$355 2 108 128 59 34 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $363 r0 *1 129.26,13.6
X$363 2 97 106 59 56 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $371 m0 *1 2.3,19.04
X$371 2 68 115 52 149 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $372 m0 *1 11.5,19.04
X$372 1 150 115 1 113 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $373 m0 *1 14.72,19.04
X$373 1 138 137 150 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $374 m0 *1 16.1,19.04
X$374 1 138 89 115 137 1 117 2 2 sky130_fd_sc_hd__nand4_1
* cell instance $375 m0 *1 18.4,19.04
X$375 1 116 89 1 86 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $376 m0 *1 21.62,19.04
X$376 1 129 116 94 1 2 2 sky130_fd_sc_hd__or2_2
* cell instance $377 m0 *1 23.92,19.04
X$377 1 57 103 169 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $379 m0 *1 25.76,19.04
X$379 1 64 118 172 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $380 m0 *1 27.14,19.04
X$380 1 139 119 78 174 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $385 m0 *1 29.44,19.04
X$385 2 118 103 78 139 102 119 1 1 2 sky130_fd_sc_hd__a41oi_1
* cell instance $389 m0 *1 41.86,19.04
X$389 1 140 79 152 1 141 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $390 m0 *1 43.7,19.04
X$390 1 140 142 152 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $392 m0 *1 45.54,19.04
X$392 1 154 140 206 2 1 2 sky130_fd_sc_hd__nand2b_1
* cell instance $393 m0 *1 47.84,19.04
X$393 1 143 1 2 176 2 sky130_fd_sc_hd__inv_1
* cell instance $394 m0 *1 49.22,19.04
X$394 1 155 132 219 1 161 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $396 m0 *1 51.98,19.04
X$396 1 140 143 202 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $406 m0 *1 61.18,19.04
X$406 1 140 144 100 145 1 135 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $407 m0 *1 63.94,19.04
X$407 1 181 120 133 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $408 m0 *1 65.32,19.04
X$408 1 146 182 120 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $409 m0 *1 66.7,19.04
X$409 2 68 56 58 156 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $411 m0 *1 76.82,19.04
X$411 1 121 146 186 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $421 m0 *1 90.62,19.04
X$421 1 71 126 85 185 2 1 2 sky130_fd_sc_hd__nand3b_1
* cell instance $423 m0 *1 94.3,19.04
X$423 2 147 180 43 56 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $425 m0 *1 105.8,19.04
X$425 1 200 122 123 1 121 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $434 m0 *1 116.84,19.04
X$434 1 177 40 126 127 2 153 1 2 sky130_fd_sc_hd__a211oi_1
* cell instance $435 m0 *1 119.6,19.04
X$435 1 126 124 153 2 1 123 2 sky130_fd_sc_hd__a21o_1
* cell instance $436 m0 *1 122.36,19.04
X$436 1 148 40 71 127 2 1 2 sky130_fd_sc_hd__nor3b_1
* cell instance $438 m0 *1 125.58,19.04
X$438 2 109 171 59 56 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $442 m0 *1 136.62,19.04
X$442 1 126 69 125 2 1 173 2 sky130_fd_sc_hd__a21o_1
* cell instance $445 m0 *1 140.3,19.04
X$445 1 151 40 126 168 2 125 1 2 sky130_fd_sc_hd__a211oi_1
* cell instance $457 r0 *1 15.64,57.12
X$457 2 449 520 272 137 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $462 r0 *1 26.68,57.12
X$462 1 492 329 491 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $466 r0 *1 31.28,57.12
X$466 2 488 450 451 474 68 1 1 2 sky130_fd_sc_hd__o31a_1
* cell instance $467 r0 *1 34.5,57.12
X$467 2 507 431 450 483 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $468 r0 *1 36.8,57.12
X$468 1 349 474 492 1 524 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $470 r0 *1 39.1,57.12
X$470 1 424 393 452 508 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $471 r0 *1 40.94,57.12
X$471 1 349 492 365 1 493 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $474 r0 *1 45.08,57.12
X$474 1 140 224 492 2 1 511 2 sky130_fd_sc_hd__a21oi_1
* cell instance $475 r0 *1 46.92,57.12
X$475 1 491 512 511 1 2 221 2 sky130_fd_sc_hd__o21ai_1
* cell instance $476 r0 *1 48.76,57.12
X$476 1 393 452 494 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $478 r0 *1 53.82,57.12
X$478 1 492 494 475 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $479 r0 *1 55.2,57.12
X$479 1 427 432 475 2 1 394 2 sky130_fd_sc_hd__o21a_2
* cell instance $481 r0 *1 62.1,57.12
X$481 1 144 452 394 2 1 495 2 sky130_fd_sc_hd__a21oi_1
* cell instance $482 r0 *1 63.94,57.12
X$482 1 365 452 394 476 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $483 r0 *1 65.78,57.12
X$483 1 140 495 407 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $486 r0 *1 68.54,57.12
X$486 1 434 394 476 1 453 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $490 r0 *1 78.2,57.12
X$490 1 477 496 361 326 1 545 2 2 sky130_fd_sc_hd__nand4_1
* cell instance $491 r0 *1 80.5,57.12
X$491 1 326 477 361 496 2 1 244 2 sky130_fd_sc_hd__and4_1
* cell instance $493 r0 *1 84.64,57.12
X$493 1 74 1 2 513 2 sky130_fd_sc_hd__inv_1
* cell instance $494 r0 *1 86.02,57.12
X$494 1 478 122 429 1 509 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $503 r0 *1 103.5,57.12
X$503 2 196 506 497 325 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $504 r0 *1 114.54,57.12
X$504 1 274 506 275 1 479 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $505 r0 *1 116.38,57.12
X$505 1 40 71 304 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $507 r0 *1 118.22,57.12
X$507 1 480 502 505 479 1 504 2 2 sky130_fd_sc_hd__nand4_1
* cell instance $514 r0 *1 130.18,57.12
X$514 1 316 484 71 500 2 1 501 2 sky130_fd_sc_hd__a31oi_1
* cell instance $517 r0 *1 137.08,57.12
X$517 2 66 482 499 325 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $523 m0 *1 1.38,62.56
X$523 1 488 2 1 603 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $528 m0 *1 14.72,62.56
X$528 1 520 2 1 514 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $531 m0 *1 20.7,62.56
X$531 1 365 489 536 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $532 m0 *1 22.08,62.56
X$532 1 449 508 490 489 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $533 m0 *1 23.92,62.56
X$533 1 515 465 490 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $536 m0 *1 26.68,62.56
X$536 1 140 224 365 272 2 503 1 2 sky130_fd_sc_hd__nor4_1
* cell instance $542 m0 *1 37.72,62.56
X$542 1 485 524 510 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $543 m0 *1 39.1,62.56
X$543 1 365 567 432 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $546 m0 *1 45.08,62.56
X$546 1 272 280 527 1 2 2 sky130_fd_sc_hd__and2_1
* cell instance $548 m0 *1 47.84,62.56
X$548 1 365 527 512 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $550 m0 *1 49.68,62.56
X$550 1 414 357 452 1 2 2 sky130_fd_sc_hd__or2_2
* cell instance $551 m0 *1 51.98,62.56
X$551 1 224 272 528 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $557 m0 *1 57.04,62.56
X$557 1 140 368 365 414 1 607 2 2 sky130_fd_sc_hd__a211o_1
* cell instance $559 m0 *1 60.72,62.56
X$559 1 272 452 539 1 529 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $560 m0 *1 62.56,62.56
X$560 2 410 531 516 530 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $561 m0 *1 71.76,62.56
X$561 2 517 210 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $569 m0 *1 87.4,62.56
X$569 2 574 429 509 522 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $572 m0 *1 93.38,62.56
X$572 2 66 525 497 100 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $573 m0 *1 104.42,62.56
X$573 2 526 525 71 304 498 523 1 1 2 sky130_fd_sc_hd__a32o_1
* cell instance $580 m0 *1 118.22,62.56
X$580 1 274 569 505 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $582 m0 *1 120.52,62.56
X$582 2 65 521 499 406 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $583 m0 *1 131.56,62.56
X$583 1 71 437 521 500 2 1 2 sky130_fd_sc_hd__nor3b_1
* cell instance $592 m0 *1 143.06,62.56
X$592 1 406 2 1 519 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $615 r0 *1 21.16,116.96
X$615 1 893 951 956 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $616 r0 *1 22.54,116.96
X$616 2 410 975 817 978 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $617 r0 *1 31.74,116.96
X$617 1 507 965 971 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $618 r0 *1 33.12,116.96
X$618 1 507 954 973 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $619 r0 *1 36.34,116.96
X$619 1 980 947 966 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $620 r0 *1 39.56,116.96
X$620 1 893 966 982 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $628 r0 *1 56.58,116.96
X$628 1 819 2 1 974 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $646 r0 *1 102.58,116.96
X$646 2 875 972 862 967 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $647 r0 *1 113.62,116.96
X$647 1 972 2 1 981 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $652 r0 *1 126.04,116.96
X$652 1 960 2 1 1080 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $656 r0 *1 138,116.96
X$656 2 875 979 862 970 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $657 r0 *1 149.04,116.96
X$657 1 968 2 1 959 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $665 m0 *1 10.12,122.4
X$665 1 964 2 1 976 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $670 m0 *1 23.92,122.4
X$670 1 893 983 978 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $674 m0 *1 29.44,122.4
X$674 1 958 975 983 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $675 m0 *1 32.66,122.4
X$675 1 954 947 975 953 921 1 2 2 sky130_fd_sc_hd__or4_1
* cell instance $676 m0 *1 35.42,122.4
X$676 1 954 928 980 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $678 m0 *1 37.72,122.4
X$678 2 410 947 826 982 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $691 m0 *1 71.3,122.4
X$691 2 875 996 862 976 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $696 m0 *1 85.1,122.4
X$696 1 996 2 1 995 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $702 m0 *1 99.36,122.4
X$702 2 875 993 862 994 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $707 m0 *1 112.24,122.4
X$707 1 993 2 1 991 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $710 m0 *1 123.28,122.4
X$710 2 875 989 862 990 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $716 m0 *1 139.84,122.4
X$716 2 875 987 862 988 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $717 m0 *1 150.88,122.4
X$717 1 987 2 1 977 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $733 r0 *1 9.2,40.8
X$733 1 374 2 1 328 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $737 r0 *1 15.64,40.8
X$737 1 377 1 2 272 2 sky130_fd_sc_hd__buf_4
* cell instance $739 r0 *1 19.32,40.8
X$739 1 339 355 378 2 1 348 2 sky130_fd_sc_hd__a21oi_1
* cell instance $740 r0 *1 21.16,40.8
X$740 1 298 1 2 2 sky130_fd_sc_hd__inv_6
* cell instance $741 r0 *1 24.38,40.8
X$741 1 348 1 2 64 2 sky130_fd_sc_hd__buf_4
* cell instance $742 r0 *1 27.14,40.8
X$742 2 68 392 298 380 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $743 r0 *1 36.34,40.8
X$743 1 349 367 340 1 2 2 sky130_fd_sc_hd__and2_1
* cell instance $748 r0 *1 43.7,40.8
X$748 2 68 357 273 382 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $751 r0 *1 55.66,40.8
X$751 1 368 385 359 1 358 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $752 r0 *1 57.5,40.8
X$752 2 68 215 273 358 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $754 r0 *1 67.16,40.8
X$754 1 272 350 395 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $755 r0 *1 68.54,40.8
X$755 1 224 83 387 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $760 r0 *1 76.36,40.8
X$760 1 371 81 1 388 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $764 r0 *1 82.8,40.8
X$764 1 389 122 351 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $765 r0 *1 84.18,40.8
X$765 1 254 351 371 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $768 r0 *1 86.94,40.8
X$768 2 109 353 228 37 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $770 r0 *1 98.44,40.8
X$770 1 353 352 360 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $771 r0 *1 99.82,40.8
X$771 2 109 384 228 193 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $772 r0 *1 110.86,40.8
X$772 2 97 315 299 193 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $777 r0 *1 130.64,40.8
X$777 1 71 381 372 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $778 r0 *1 132.02,40.8
X$778 1 316 372 379 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $780 r0 *1 133.86,40.8
X$780 2 196 375 299 279 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $783 r0 *1 149.5,40.8
X$783 1 215 2 1 354 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $788 m0 *1 1.38,46.24
X$788 1 473 2 1 366 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $790 m0 *1 5.52,46.24
X$790 1 362 2 1 400 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $793 m0 *1 10.58,46.24
X$793 1 401 1 2 363 2 sky130_fd_sc_hd__inv_1
* cell instance $794 m0 *1 11.96,46.24
X$794 2 1285 377 362 363 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $795 m0 *1 16.56,46.24
X$795 2 460 364 390 363 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $797 m0 *1 21.62,46.24
X$797 1 364 1 2 365 2 sky130_fd_sc_hd__buf_4
* cell instance $798 m0 *1 24.38,46.24
X$798 1 272 365 378 2 1 2 sky130_fd_sc_hd__nand2b_1
* cell instance $804 m0 *1 31.28,46.24
X$804 2 380 349 392 367 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $806 m0 *1 36.34,46.24
X$806 2 68 393 298 423 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $807 m0 *1 45.54,46.24
X$807 2 382 393 357 367 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $809 m0 *1 51.52,46.24
X$809 1 140 365 224 366 1 405 2 2 sky130_fd_sc_hd__a211o_1
* cell instance $810 m0 *1 54.74,46.24
X$810 1 405 272 369 2 1 385 2 sky130_fd_sc_hd__a21oi_1
* cell instance $813 m0 *1 57.04,46.24
X$813 2 369 81 366 244 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $814 m0 *1 61.18,46.24
X$814 2 470 370 224 140 272 77 1 1 2 sky130_fd_sc_hd__a221oi_1
* cell instance $815 m0 *1 64.4,46.24
X$815 2 370 62 77 244 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $818 m0 *1 73.14,46.24
X$818 2 147 389 228 215 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $823 m0 *1 86.02,46.24
X$823 2 122 71 40 126 1 1 2 sky130_fd_sc_hd__or3_4
* cell instance $824 m0 *1 90.16,46.24
X$824 2 97 409 228 37 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $825 m0 *1 101.2,46.24
X$825 1 409 304 316 408 71 386 2 1 2 sky130_fd_sc_hd__a32oi_1
* cell instance $828 m0 *1 108.56,46.24
X$828 1 384 352 383 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $835 m0 *1 121.44,46.24
X$835 2 108 381 299 279 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $836 m0 *1 132.48,46.24
X$836 1 404 373 379 419 2 1 2 sky130_fd_sc_hd__nand3b_1
* cell instance $838 m0 *1 136.16,46.24
X$838 1 262 397 376 71 126 373 1 2 2 sky130_fd_sc_hd__o221ai_1
* cell instance $841 m0 *1 139.84,46.24
X$841 1 402 1 2 376 2 sky130_fd_sc_hd__inv_1
* cell instance $842 m0 *1 141.22,46.24
X$842 1 375 71 397 2 1 2 sky130_fd_sc_hd__nor2b_1
* cell instance $845 m0 *1 147.66,46.24
X$845 1 398 1 2 126 2 sky130_fd_sc_hd__buf_4
* cell instance $846 m0 *1 150.42,46.24
X$846 1 399 2 1 398 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $867 r0 *1 21.16,138.72
X$867 2 875 1109 862 1097 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $868 r0 *1 32.2,138.72
X$868 1 1109 2 1 1110 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $871 r0 *1 38.64,138.72
X$871 1 1094 2 1 1113 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $876 r0 *1 47.38,138.72
X$876 1 1021 1 2 1099 2 sky130_fd_sc_hd__buf_4
* cell instance $878 r0 *1 53.82,138.72
X$878 2 875 1122 862 1100 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $883 r0 *1 72.68,138.72
X$883 1 1093 2 1 1127 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $887 r0 *1 79.58,138.72
X$887 1 1126 2 1 1129 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $888 r0 *1 83.26,138.72
X$888 2 875 1128 862 1101 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $891 r0 *1 98.44,138.72
X$891 1 1128 2 1 1124 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $893 r0 *1 105.8,138.72
X$893 2 875 1116 862 1123 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $900 r0 *1 126.96,138.72
X$900 2 875 1111 862 1112 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $901 r0 *1 138,138.72
X$901 2 875 1105 862 1108 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $903 r0 *1 149.5,138.72
X$903 1 1105 2 1 1103 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $906 m0 *1 1.38,144.16
X$906 1 1130 2 1 1021 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $907 m0 *1 5.06,144.16
X$907 1 1096 2 1 1137 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $909 m0 *1 10.58,144.16
X$909 2 875 1096 862 1133 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $916 m0 *1 34.04,144.16
X$916 2 875 1145 862 1132 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $917 m0 *1 45.08,144.16
X$917 1 1144 2 1 1106 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $919 m0 *1 49.68,144.16
X$919 1 1106 1 2 1150 2 sky130_fd_sc_hd__buf_4
* cell instance $924 m0 *1 57.04,144.16
X$924 1 1151 1 2 862 2 sky130_fd_sc_hd__buf_4
* cell instance $927 m0 *1 64.4,144.16
X$927 1 1122 2 1 1154 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $936 m0 *1 84.64,144.16
X$936 1 1153 2 1 1152 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $937 m0 *1 88.32,144.16
X$937 2 875 1147 862 1149 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $941 m0 *1 105.34,144.16
X$941 1 1072 1 2 1276 2 sky130_fd_sc_hd__buf_4
* cell instance $942 m0 *1 108.1,144.16
X$942 1 1102 2 1 1072 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $947 m0 *1 119.6,144.16
X$947 1 1116 2 1 1141 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $948 m0 *1 123.28,144.16
X$948 1 1115 2 1 1143 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $953 m0 *1 135.7,144.16
X$953 1 1111 2 1 1278 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $957 m0 *1 140.76,144.16
X$957 2 875 1136 862 1139 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $958 m0 *1 151.8,144.16
X$958 1 1083 2 1 1057 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $974 r0 *1 11.96,24.48
X$974 1 137 212 231 64 2 233 1 2 sky130_fd_sc_hd__a211oi_1
* cell instance $977 r0 *1 15.64,24.48
X$977 2 212 235 213 188 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $979 r0 *1 21.16,24.48
X$979 1 57 190 235 236 2 1 2 sky130_fd_sc_hd__nor3b_1
* cell instance $980 r0 *1 23.92,24.48
X$980 1 160 57 190 1 234 2 2 sky130_fd_sc_hd__o21a_1
* cell instance $982 r0 *1 27.6,24.48
X$982 1 94 191 160 1 237 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $983 r0 *1 29.44,24.48
X$983 2 68 160 58 238 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $986 r0 *1 41.4,24.48
X$986 1 217 1 2 201 2 sky130_fd_sc_hd__inv_1
* cell instance $989 r0 *1 43.7,24.48
X$989 1 218 241 205 132 1 239 2 2 sky130_fd_sc_hd__a211o_1
* cell instance $990 r0 *1 46.92,24.48
X$990 1 205 217 143 271 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $991 r0 *1 48.76,24.48
X$991 1 251 221 143 1 219 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $992 r0 *1 50.6,24.48
X$992 1 140 205 225 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $995 r0 *1 53.36,24.48
X$995 2 68 44 58 222 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $998 r0 *1 64.86,24.48
X$998 1 244 223 182 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1000 r0 *1 66.7,24.48
X$1000 1 140 224 208 2 1 245 2 sky130_fd_sc_hd__a21oi_1
* cell instance $1003 r0 *1 70.84,24.48
X$1003 2 207 63 208 244 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $1006 r0 *1 75.9,24.48
X$1006 2 147 209 43 44 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1008 r0 *1 87.4,24.48
X$1008 1 209 122 203 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1009 r0 *1 88.78,24.48
X$1009 2 210 228 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $1013 r0 *1 103.04,24.48
X$1013 2 66 216 43 193 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1022 r0 *1 132.02,24.48
X$1022 2 108 232 59 215 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1033 m0 *1 9.2,29.92
X$1033 1 188 137 231 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1034 m0 *1 10.58,29.92
X$1034 2 68 188 52 233 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1035 m0 *1 19.78,29.92
X$1035 2 68 190 52 214 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1040 m0 *1 30.82,29.92
X$1040 1 64 237 261 2 1 238 2 sky130_fd_sc_hd__a21oi_1
* cell instance $1043 m0 *1 34.96,29.92
X$1043 2 68 205 52 239 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1045 m0 *1 44.62,29.92
X$1045 1 251 221 217 1 240 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $1046 m0 *1 46.46,29.92
X$1046 2 225 241 220 206 221 251 1 1 2 sky130_fd_sc_hd__o32ai_1
* cell instance $1048 m0 *1 50.6,29.92
X$1048 1 243 264 226 1 222 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $1049 m0 *1 52.44,29.92
X$1049 2 265 98 80 244 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $1052 m0 *1 57.04,29.92
X$1052 1 290 44 145 2 1 226 2 sky130_fd_sc_hd__a21oi_1
* cell instance $1053 m0 *1 58.88,29.92
X$1053 2 266 82 45 244 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $1056 m0 *1 65.32,29.92
X$1056 2 68 193 58 267 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1058 m0 *1 76.36,29.92
X$1058 1 227 98 1 242 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $1063 m0 *1 84.64,29.92
X$1063 2 97 253 43 44 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1064 m0 *1 95.68,29.92
X$1064 2 66 255 43 37 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1065 m0 *1 106.72,29.92
X$1065 1 262 229 289 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $1066 m0 *1 108.1,29.92
X$1066 1 71 255 229 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $1072 m0 *1 112.7,29.92
X$1072 2 65 260 59 193 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1075 m0 *1 125.12,29.92
X$1075 2 65 259 59 215 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1083 m0 *1 144.44,29.92
X$1083 2 258 257 230 40 318 126 232 1 1 2 sky130_fd_sc_hd__mux4_2
* cell instance $1103 r0 *1 15.64,106.08
X$1103 2 410 884 817 911 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1105 r0 *1 26.68,106.08
X$1105 1 871 902 764 928 1 2 2 sky130_fd_sc_hd__or3_1
* cell instance $1106 r0 *1 28.98,106.08
X$1106 2 544 871 902 921 930 1 1 2 sky130_fd_sc_hd__nor4b_4
* cell instance $1107 r0 *1 37.72,106.08
X$1107 1 904 923 921 483 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $1108 r0 *1 39.56,106.08
X$1108 1 904 923 930 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1114 r0 *1 49.22,106.08
X$1114 2 410 870 826 916 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1115 r0 *1 58.42,106.08
X$1115 2 410 900 826 931 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1116 r0 *1 67.62,106.08
X$1116 1 746 906 905 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1117 r0 *1 69,106.08
X$1117 1 746 837 908 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1119 r0 *1 70.84,106.08
X$1119 1 908 906 695 868 2 1 924 2 sky130_fd_sc_hd__a31oi_1
* cell instance $1120 r0 *1 73.14,106.08
X$1120 1 694 924 932 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1121 r0 *1 74.52,106.08
X$1121 1 694 917 918 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1122 r0 *1 75.9,106.08
X$1122 2 410 895 722 918 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1124 r0 *1 86.94,106.08
X$1124 2 35 914 722 601 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1140 r0 *1 134.78,106.08
X$1140 2 875 927 862 912 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1143 r0 *1 148.12,106.08
X$1143 1 910 2 1 912 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1153 m0 *1 17.94,111.52
X$1153 2 410 913 817 919 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1154 m0 *1 27.14,111.52
X$1154 1 893 920 928 2 1 919 2 sky130_fd_sc_hd__a21oi_1
* cell instance $1159 m0 *1 30.82,111.52
X$1159 2 933 923 921 902 871 801 1 1 2 sky130_fd_sc_hd__o41a_1
* cell instance $1160 m0 *1 34.96,111.52
X$1160 1 922 507 904 933 2 1 929 2 sky130_fd_sc_hd__a31oi_1
* cell instance $1161 m0 *1 37.26,111.52
X$1161 1 923 921 922 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1164 m0 *1 40.94,111.52
X$1164 2 410 923 826 915 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1172 m0 *1 64.4,111.52
X$1172 1 694 899 931 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1174 m0 *1 66.24,111.52
X$1174 1 694 938 946 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1175 m0 *1 67.62,111.52
X$1175 1 905 710 837 934 2 1 938 2 sky130_fd_sc_hd__a31oi_1
* cell instance $1179 m0 *1 73.14,111.52
X$1179 2 410 868 722 932 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1207 m0 *1 143.98,111.52
X$1207 1 927 2 1 935 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1208 m0 *1 147.66,111.52
X$1208 1 912 1 2 937 2 sky130_fd_sc_hd__buf_4
* cell instance $1209 m0 *1 150.42,111.52
X$1209 1 936 2 1 925 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1231 r0 *1 21.62,8.16
X$1231 1 64 91 55 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1233 r0 *1 23.92,8.16
X$1233 1 64 75 76 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1234 r0 *1 25.3,8.16
X$1234 2 68 78 52 76 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1239 r0 *1 43.24,8.16
X$1239 1 3 2 1 79 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1243 r0 *1 55.2,8.16
X$1243 1 7 2 1 80 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1244 r0 *1 58.88,8.16
X$1244 1 8 2 1 81 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1246 r0 *1 63.02,8.16
X$1246 1 11 2 1 111 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1247 r0 *1 66.7,8.16
X$1247 1 16 2 1 82 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1249 r0 *1 70.84,8.16
X$1249 1 20 2 1 83 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1250 r0 *1 74.52,8.16
X$1250 1 21 2 1 313 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1253 r0 *1 80.96,8.16
X$1253 2 65 85 43 44 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1254 r0 *1 92,8.16
X$1254 2 84 73 42 40 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $1259 r0 *1 100.74,8.16
X$1259 2 66 72 43 34 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1260 r0 *1 111.78,8.16
X$1260 2 65 70 59 34 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1264 r0 *1 126.04,8.16
X$1264 2 65 67 59 56 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1265 r0 *1 137.08,8.16
X$1265 2 88 106 69 40 54 71 67 1 1 2 sky130_fd_sc_hd__mux4_2
* cell instance $1274 m0 *1 8.28,13.6
X$1274 2 68 89 52 90 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1275 m0 *1 17.48,13.6
X$1275 1 64 86 90 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1277 m0 *1 19.32,13.6
X$1277 1 53 1 2 93 2 sky130_fd_sc_hd__inv_1
* cell instance $1279 m0 *1 21.16,13.6
X$1279 1 94 57 1 91 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $1282 m0 *1 25.76,13.6
X$1282 1 110 78 1 75 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $1285 m0 *1 29.44,13.6
X$1285 1 64 96 112 2 1 87 2 sky130_fd_sc_hd__a21oi_1
* cell instance $1286 m0 *1 31.28,13.6
X$1286 2 68 119 58 87 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1296 m0 *1 57.96,13.6
X$1296 1 9 2 1 98 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1299 m0 *1 63.02,13.6
X$1299 1 100 2 1 33 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1302 m0 *1 68.08,13.6
X$1302 1 32 2 1 208 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1304 m0 *1 72.68,13.6
X$1304 1 18 2 1 163 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1307 m0 *1 77.74,13.6
X$1307 1 24 2 1 101 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1315 m0 *1 92.92,13.6
X$1315 2 65 99 43 37 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1316 m0 *1 103.96,13.6
X$1316 2 105 99 61 71 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $1321 m0 *1 112.24,13.6
X$1321 2 97 95 59 34 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1322 m0 *1 123.28,13.6
X$1322 1 29 2 1 92 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1324 m0 *1 127.42,13.6
X$1324 2 66 88 59 56 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1355 r0 *1 31.74,122.4
X$1355 2 875 1002 862 984 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1357 r0 *1 43.24,122.4
X$1357 2 875 1005 862 997 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1361 r0 *1 59.34,122.4
X$1361 1 1008 2 1 1009 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1368 r0 *1 74.06,122.4
X$1368 1 976 1 2 1012 2 sky130_fd_sc_hd__buf_4
* cell instance $1370 r0 *1 77.74,122.4
X$1370 2 875 1011 862 992 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1372 r0 *1 89.7,122.4
X$1372 1 1011 2 1 1010 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1381 r0 *1 109.02,122.4
X$1381 2 875 1006 862 1007 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1382 r0 *1 120.06,122.4
X$1382 1 1006 2 1 1004 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1387 r0 *1 130.18,122.4
X$1387 1 989 2 1 1003 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1390 r0 *1 139.38,122.4
X$1390 1 1001 2 1 999 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1391 r0 *1 143.06,122.4
X$1391 1 957 2 1 1015 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1392 r0 *1 146.74,122.4
X$1392 1 985 2 1 970 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1393 r0 *1 150.42,122.4
X$1393 1 970 1 2 1017 2 sky130_fd_sc_hd__buf_4
* cell instance $1408 m0 *1 33.58,127.84
X$1408 2 875 1025 862 1023 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1409 m0 *1 44.62,127.84
X$1409 1 1025 2 1 998 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1417 m0 *1 59.8,127.84
X$1417 2 875 1008 862 1029 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1418 m0 *1 70.84,127.84
X$1418 2 875 1013 862 1030 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1425 m0 *1 86.94,127.84
X$1425 2 875 1037 862 1035 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1427 m0 *1 99.82,127.84
X$1427 2 875 1032 862 1038 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1434 m0 *1 118.68,127.84
X$1434 2 875 1028 862 1031 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1441 m0 *1 139.84,127.84
X$1441 2 875 1020 862 999 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1442 m0 *1 150.88,127.84
X$1442 1 979 2 1 1000 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1454 r0 *1 3.22,68
X$1454 1 646 2 1 551 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1457 r0 *1 10.58,68
X$1457 1 560 140 647 578 2 1 2 sky130_fd_sc_hd__nand3b_1
* cell instance $1461 r0 *1 16.1,68
X$1461 2 329 662 578 593 140 606 1 1 2 sky130_fd_sc_hd__o32ai_1
* cell instance $1464 r0 *1 20.7,68
X$1464 1 604 1 2 593 2 sky130_fd_sc_hd__inv_1
* cell instance $1465 r0 *1 22.08,68
X$1465 1 593 339 542 1 2 595 2 sky130_fd_sc_hd__o21ai_1
* cell instance $1466 r0 *1 23.92,68
X$1466 1 280 604 542 1 2 570 2 sky130_fd_sc_hd__o21bai_1
* cell instance $1467 r0 *1 26.68,68
X$1467 1 580 449 244 542 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $1469 r0 *1 28.98,68
X$1469 1 606 543 579 615 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $1470 r0 *1 30.82,68
X$1470 1 546 244 339 1 579 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $1471 r0 *1 32.66,68
X$1471 1 546 545 649 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1472 r0 *1 34.04,68
X$1472 1 339 546 617 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $1473 r0 *1 35.42,68
X$1473 1 580 507 483 546 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $1478 r0 *1 45.08,68
X$1478 1 140 356 583 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $1480 r0 *1 46.92,68
X$1480 1 492 356 140 1 586 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $1484 r0 *1 55.2,68
X$1484 2 410 601 516 600 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $1485 r0 *1 64.4,68
X$1485 2 619 587 551 244 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $1489 r0 *1 74.52,68
X$1489 2 147 554 497 100 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1490 r0 *1 85.56,68
X$1490 2 706 610 602 518 612 1 1 2 sky130_fd_sc_hd__o31a_1
* cell instance $1491 r0 *1 88.78,68
X$1491 1 126 40 71 612 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $1497 r0 *1 100.74,68
X$1497 1 126 71 572 2 1 616 2 sky130_fd_sc_hd__a21oi_1
* cell instance $1498 r0 *1 102.58,68
X$1498 1 599 126 262 616 2 598 1 2 sky130_fd_sc_hd__a211oi_1
* cell instance $1501 r0 *1 106.72,68
X$1501 2 109 597 499 325 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1507 r0 *1 127.88,68
X$1507 2 196 592 499 406 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1510 r0 *1 143.52,68
X$1510 1 434 2 1 614 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1517 m0 *1 2.3,73.44
X$1517 1 620 2 1 622 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1518 m0 *1 5.98,73.44
X$1518 2 68 630 577 615 1 1 2 sky130_fd_sc_hd__dfstp_2
* cell instance $1519 m0 *1 15.64,73.44
X$1519 2 1284 605 631 492 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $1520 m0 *1 20.24,73.44
X$1520 1 606 605 584 1 633 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $1531 m0 *1 32.2,73.44
X$1531 1 224 1 2 606 2 sky130_fd_sc_hd__inv_1
* cell instance $1543 m0 *1 57.04,73.44
X$1543 2 607 618 272 643 622 224 1 1 2 sky130_fd_sc_hd__a221oi_2
* cell instance $1544 m0 *1 62.56,73.44
X$1544 2 645 550 607 608 394 644 1 1 2 sky130_fd_sc_hd__o221a_1
* cell instance $1545 m0 *1 66.7,73.44
X$1545 1 625 609 244 608 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $1549 m0 *1 71.76,73.44
X$1549 2 147 626 516 644 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1553 m0 *1 82.8,73.44
X$1553 1 626 122 611 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1556 m0 *1 85.1,73.44
X$1556 1 626 609 641 627 610 2 1 2 sky130_fd_sc_hd__o22ai_1
* cell instance $1558 m0 *1 87.86,73.44
X$1558 1 587 1 2 641 2 sky130_fd_sc_hd__inv_1
* cell instance $1559 m0 *1 89.24,73.44
X$1559 1 613 640 611 639 1 2 555 2 sky130_fd_sc_hd__o31ai_1
* cell instance $1562 m0 *1 93.38,73.44
X$1562 1 638 122 672 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $1564 m0 *1 95.22,73.44
X$1564 2 35 636 497 100 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1565 m0 *1 106.26,73.44
X$1565 2 599 671 636 71 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $1574 m0 *1 117.3,73.44
X$1574 1 635 316 658 498 1 632 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $1575 m0 *1 120.06,73.44
X$1575 2 97 590 499 406 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1582 m0 *1 137.08,73.44
X$1582 1 274 629 262 1 628 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $1585 m0 *1 139.84,73.44
X$1585 1 660 2 1 587 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1590 r0 *1 1.84,149.6
X$1590 1 1156 2 1 1204 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1594 r0 *1 7.82,149.6
X$1594 1 1205 2 1 992 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1595 r0 *1 11.5,149.6
X$1595 1 1206 2 1 1059 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1599 r0 *1 18.4,149.6
X$1599 1 1132 1 2 1242 2 sky130_fd_sc_hd__buf_4
* cell instance $1600 r0 *1 21.16,149.6
X$1600 1 1076 1 2 1194 2 sky130_fd_sc_hd__buf_4
* cell instance $1602 r0 *1 24.84,149.6
X$1602 1 997 1 2 1195 2 sky130_fd_sc_hd__buf_4
* cell instance $1603 r0 *1 27.6,149.6
X$1603 1 1210 2 1 1076 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1604 r0 *1 31.28,149.6
X$1604 1 1026 1 2 1196 2 sky130_fd_sc_hd__buf_4
* cell instance $1606 r0 *1 34.96,149.6
X$1606 1 1097 1 2 1213 2 sky130_fd_sc_hd__buf_4
* cell instance $1609 r0 *1 39.1,149.6
X$1609 1 1078 1 2 1215 2 sky130_fd_sc_hd__buf_4
* cell instance $1612 r0 *1 43.24,149.6
X$1612 1 1218 2 1 1026 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1614 r0 *1 47.84,149.6
X$1614 1 1220 2 1 1132 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1615 r0 *1 51.52,149.6
X$1615 1 1079 1 2 1266 2 sky130_fd_sc_hd__buf_4
* cell instance $1617 r0 *1 56.12,149.6
X$1617 1 1222 2 1 1097 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1618 r0 *1 59.8,149.6
X$1618 1 1075 1 2 1268 2 sky130_fd_sc_hd__buf_4
* cell instance $1621 r0 *1 63.94,149.6
X$1621 1 1197 2 1 1101 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1622 r0 *1 67.62,149.6
X$1622 1 992 1 2 1224 2 sky130_fd_sc_hd__buf_4
* cell instance $1626 r0 *1 73.6,149.6
X$1626 1 1158 1 2 1223 2 sky130_fd_sc_hd__buf_4
* cell instance $1629 r0 *1 77.74,149.6
X$1629 1 1059 1 2 1221 2 sky130_fd_sc_hd__buf_4
* cell instance $1631 r0 *1 81.42,149.6
X$1631 1 1262 2 1 1074 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1632 r0 *1 85.1,149.6
X$1632 1 1101 1 2 1273 2 sky130_fd_sc_hd__buf_4
* cell instance $1634 r0 *1 89.7,149.6
X$1634 1 1219 2 1 1125 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1636 r0 *1 95.22,149.6
X$1636 1 1125 1 2 1198 2 sky130_fd_sc_hd__buf_4
* cell instance $1638 r0 *1 98.44,149.6
X$1638 1 1217 2 1 1038 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1639 r0 *1 102.12,149.6
X$1639 1 1038 1 2 1216 2 sky130_fd_sc_hd__buf_4
* cell instance $1641 r0 *1 105.8,149.6
X$1641 1 967 1 2 1214 2 sky130_fd_sc_hd__buf_4
* cell instance $1642 r0 *1 108.56,149.6
X$1642 1 1034 1 2 1199 2 sky130_fd_sc_hd__buf_4
* cell instance $1644 r0 *1 111.78,149.6
X$1644 1 1200 2 1 1034 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1645 r0 *1 115.46,149.6
X$1645 1 1212 2 1 1064 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1646 r0 *1 119.14,149.6
X$1646 1 962 1 2 1211 2 sky130_fd_sc_hd__buf_4
* cell instance $1648 r0 *1 122.82,149.6
X$1648 1 990 1 2 1209 2 sky130_fd_sc_hd__buf_4
* cell instance $1652 r0 *1 127.42,149.6
X$1652 1 1201 2 1 962 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1655 r0 *1 133.4,149.6
X$1655 1 1277 2 1 1108 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1658 r0 *1 139.38,149.6
X$1658 1 1108 1 2 1208 2 sky130_fd_sc_hd__buf_4
* cell instance $1661 r0 *1 143.52,149.6
X$1661 1 1064 1 2 1202 2 sky130_fd_sc_hd__buf_4
* cell instance $1662 r0 *1 146.28,149.6
X$1662 1 1203 2 1 943 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1663 r0 *1 149.96,149.6
X$1663 1 1139 1 2 1207 2 sky130_fd_sc_hd__buf_4
* cell instance $1668 m0 *1 3.22,155.04
X$1668 1 1193 1 2 1225 2 sky130_fd_sc_hd__buf_4
* cell instance $1670 m0 *1 6.44,155.04
X$1670 1 1104 1 2 1239 2 sky130_fd_sc_hd__buf_4
* cell instance $1673 m0 *1 11.5,155.04
X$1673 1 1225 2 1 1244 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1675 m0 *1 15.64,155.04
X$1675 1 1226 2 1 1104 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1676 m0 *1 19.32,155.04
X$1676 1 1033 1 2 1243 2 sky130_fd_sc_hd__buf_4
* cell instance $1678 m0 *1 22.54,155.04
X$1678 1 1227 2 1 1114 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1679 m0 *1 26.22,155.04
X$1679 1 1173 1 2 1248 2 sky130_fd_sc_hd__buf_4
* cell instance $1684 m0 *1 29.44,155.04
X$1684 1 1250 2 1 1173 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1686 m0 *1 34.04,155.04
X$1686 1 1263 2 1 984 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1689 m0 *1 39.1,155.04
X$1689 1 1252 2 1 1068 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1692 m0 *1 44.16,155.04
X$1692 1 1068 1 2 1254 2 sky130_fd_sc_hd__buf_4
* cell instance $1693 m0 *1 46.92,155.04
X$1693 1 1135 1 2 1265 2 sky130_fd_sc_hd__buf_4
* cell instance $1694 m0 *1 49.68,155.04
X$1694 1 1114 1 2 1257 2 sky130_fd_sc_hd__buf_4
* cell instance $1696 m0 *1 52.9,155.04
X$1696 1 1228 2 1 1075 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1701 m0 *1 57.04,155.04
X$1701 1 1056 1 2 1229 2 sky130_fd_sc_hd__buf_4
* cell instance $1703 m0 *1 60.26,155.04
X$1703 1 1230 2 1 1029 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1704 m0 *1 63.94,155.04
X$1704 1 1029 1 2 1270 2 sky130_fd_sc_hd__buf_4
* cell instance $1705 m0 *1 66.7,155.04
X$1705 1 1231 2 1 1056 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1708 m0 *1 71.3,155.04
X$1708 1 1232 2 1 1135 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1709 m0 *1 74.98,155.04
X$1709 1 1030 1 2 1272 2 sky130_fd_sc_hd__buf_4
* cell instance $1710 m0 *1 77.74,155.04
X$1710 1 984 1 2 1261 2 sky130_fd_sc_hd__buf_4
* cell instance $1711 m0 *1 80.5,155.04
X$1711 1 1233 2 1 1030 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1716 m0 *1 84.64,155.04
X$1716 1 1234 2 1 1033 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1717 m0 *1 88.32,155.04
X$1717 1 1274 2 1 1035 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1719 m0 *1 92.46,155.04
X$1719 1 1035 1 2 1260 2 sky130_fd_sc_hd__buf_4
* cell instance $1720 m0 *1 95.22,155.04
X$1720 1 1074 1 2 1259 2 sky130_fd_sc_hd__buf_4
* cell instance $1723 m0 *1 98.9,155.04
X$1723 1 1235 2 1 994 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1724 m0 *1 102.58,155.04
X$1724 1 994 1 2 1258 2 sky130_fd_sc_hd__buf_4
* cell instance $1725 m0 *1 105.34,155.04
X$1725 1 1256 2 1 967 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1732 m0 *1 112.24,155.04
X$1732 1 1255 2 1 1007 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1733 m0 *1 115.92,155.04
X$1733 1 1236 2 1 1134 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1734 m0 *1 119.6,155.04
X$1734 1 1134 1 2 1253 2 sky130_fd_sc_hd__buf_4
* cell instance $1735 m0 *1 122.36,155.04
X$1735 1 1007 1 2 1237 2 sky130_fd_sc_hd__buf_4
* cell instance $1739 m0 *1 126.5,155.04
X$1739 1 1249 2 1 1112 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1742 m0 *1 132.94,155.04
X$1742 1 1247 2 1 1014 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1746 m0 *1 136.62,155.04
X$1746 1 1112 1 2 1246 2 sky130_fd_sc_hd__buf_4
* cell instance $1748 m0 *1 139.84,155.04
X$1748 1 1014 1 2 1241 2 sky130_fd_sc_hd__buf_4
* cell instance $1750 m0 *1 144.44,155.04
X$1750 1 1240 2 1 988 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1752 m0 *1 148.58,155.04
X$1752 1 988 1 2 1238 2 sky130_fd_sc_hd__buf_4
* cell instance $1758 r0 *1 4.14,144.16
X$1758 2 875 1170 862 1135 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1760 r0 *1 15.64,144.16
X$1760 1 1167 2 1 1065 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1762 r0 *1 23,144.16
X$1762 2 875 1174 862 1173 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1765 r0 *1 35.42,144.16
X$1765 1 1100 1 2 1131 2 sky130_fd_sc_hd__buf_4
* cell instance $1770 r0 *1 44.16,144.16
X$1770 1 1145 2 1 1148 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1772 r0 *1 48.3,144.16
X$1772 1 1065 1 2 1184 2 sky130_fd_sc_hd__buf_4
* cell instance $1775 r0 *1 53.36,144.16
X$1775 1 1267 2 1 1151 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1778 r0 *1 59.34,144.16
X$1778 2 875 1098 862 1158 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1783 r0 *1 76.82,144.16
X$1783 2 875 1153 862 1188 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1787 r0 *1 91.08,144.16
X$1787 1 1149 1 2 1275 2 sky130_fd_sc_hd__buf_4
* cell instance $1791 r0 *1 98.44,144.16
X$1791 1 1147 2 1 1146 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1797 r0 *1 114.54,144.16
X$1797 2 875 1178 862 1134 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1799 r0 *1 126.04,144.16
X$1799 1 1178 2 1 1142 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1802 r0 *1 132.48,144.16
X$1802 2 875 1166 862 1160 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1803 r0 *1 143.52,144.16
X$1803 1 1166 2 1 1140 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1806 r0 *1 149.5,144.16
X$1806 1 1136 2 1 1138 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1811 m0 *1 2.76,149.6
X$1811 1 1192 1 2 1156 2 sky130_fd_sc_hd__buf_4
* cell instance $1812 m0 *1 5.52,149.6
X$1812 1 1155 1 2 1165 2 sky130_fd_sc_hd__buf_4
* cell instance $1815 m0 *1 10.58,149.6
X$1815 1 1165 2 1 1169 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1817 m0 *1 14.72,149.6
X$1817 1 1170 2 1 1168 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1818 m0 *1 18.4,149.6
X$1818 1 1098 2 1 1171 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1822 m0 *1 25.3,149.6
X$1822 1 1172 2 1 1018 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1826 m0 *1 30.36,149.6
X$1826 1 1174 2 1 1175 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1828 m0 *1 34.96,149.6
X$1828 1 1157 2 1 1078 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1829 m0 *1 38.64,149.6
X$1829 1 1264 2 1 997 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1832 m0 *1 43.7,149.6
X$1832 1 1180 2 1 1133 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1834 m0 *1 48.3,149.6
X$1834 1 1181 2 1 1079 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1836 m0 *1 52.9,149.6
X$1836 1 1187 2 1 1100 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1842 m0 *1 62.1,149.6
X$1842 1 1018 1 2 1269 2 sky130_fd_sc_hd__buf_4
* cell instance $1844 m0 *1 66.7,149.6
X$1844 1 1133 1 2 1190 2 sky130_fd_sc_hd__buf_4
* cell instance $1846 m0 *1 70.38,149.6
X$1846 1 1191 2 1 1158 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1848 m0 *1 74.98,149.6
X$1848 1 1189 2 1 1188 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1851 m0 *1 80.04,149.6
X$1851 1 1188 1 2 1186 2 sky130_fd_sc_hd__buf_4
* cell instance $1858 m0 *1 90.16,149.6
X$1858 1 1185 2 1 1149 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1862 m0 *1 103.04,149.6
X$1862 1 1183 2 1 1123 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1863 m0 *1 106.72,149.6
X$1863 1 1123 1 2 1182 2 sky130_fd_sc_hd__buf_4
* cell instance $1870 m0 *1 115,149.6
X$1870 1 1159 2 1 1117 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1871 m0 *1 118.68,149.6
X$1871 1 1117 1 2 1179 2 sky130_fd_sc_hd__buf_4
* cell instance $1873 m0 *1 121.9,149.6
X$1873 1 1251 2 1 990 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1875 m0 *1 126.5,149.6
X$1875 1 1177 2 1 1066 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1877 m0 *1 131.1,149.6
X$1877 1 1066 1 2 1176 2 sky130_fd_sc_hd__buf_4
* cell instance $1879 m0 *1 135.7,149.6
X$1879 1 1160 1 2 1161 2 sky130_fd_sc_hd__buf_4
* cell instance $1883 m0 *1 139.84,149.6
X$1883 1 1163 2 1 1160 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1884 m0 *1 143.52,149.6
X$1884 1 999 1 2 1279 2 sky130_fd_sc_hd__buf_4
* cell instance $1886 m0 *1 146.74,149.6
X$1886 1 1162 2 1 1139 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1889 m0 *1 151.8,149.6
X$1889 1 943 1 2 1164 2 sky130_fd_sc_hd__buf_4
* cell instance $1903 r0 *1 4.14,127.84
X$1903 2 875 1043 862 1018 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1906 r0 *1 16.56,127.84
X$1906 1 1019 2 1 1044 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1907 r0 *1 20.24,127.84
X$1907 2 875 1022 862 1021 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1908 r0 *1 31.28,127.84
X$1908 1 1022 2 1 1046 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1910 r0 *1 36.8,127.84
X$1910 1 1002 2 1 1047 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1916 r0 *1 45.54,127.84
X$1916 2 875 1027 862 1026 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1917 r0 *1 56.58,127.84
X$1917 1 1027 2 1 1052 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1920 r0 *1 63.02,127.84
X$1920 1 1005 2 1 1054 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1926 r0 *1 79.12,127.84
X$1926 2 875 1051 862 1033 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1928 r0 *1 90.62,127.84
X$1928 1 1037 2 1 1036 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1933 r0 *1 105.8,127.84
X$1933 2 875 1049 862 1034 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1936 r0 *1 119.6,127.84
X$1936 1 1032 2 1 1041 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1942 r0 *1 128.8,127.84
X$1942 1 1028 2 1 1045 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1945 r0 *1 134.78,127.84
X$1945 2 875 1024 862 1014 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1946 r0 *1 145.82,127.84
X$1946 1 1024 2 1 1042 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1947 r0 *1 149.5,127.84
X$1947 1 1020 2 1 1016 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1952 m0 *1 4.14,133.28
X$1952 1 1055 2 1 1023 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1955 m0 *1 9.2,133.28
X$1955 2 875 1019 862 1059 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1956 m0 *1 20.24,133.28
X$1956 1 1023 1 2 1061 2 sky130_fd_sc_hd__buf_4
* cell instance $1967 m0 *1 38.64,133.28
X$1967 2 875 1071 862 1068 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1968 m0 *1 49.68,133.28
X$1968 1 1071 2 1 1039 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1979 m0 *1 63.02,133.28
X$1979 2 875 1053 862 1076 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1990 m0 *1 92,133.28
X$1990 2 875 1073 862 1074 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $1992 m0 *1 103.96,133.28
X$1992 1 1073 2 1 1050 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2001 m0 *1 115,133.28
X$2001 1 1049 2 1 1048 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2003 m0 *1 120.52,133.28
X$2003 1 1040 2 1 1031 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2004 m0 *1 124.2,133.28
X$2004 2 875 1063 862 1066 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2005 m0 *1 135.24,133.28
X$2005 1 1063 2 1 1245 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2018 r0 *1 5.98,73.44
X$2018 2 68 631 577 648 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2021 r0 *1 16.1,73.44
X$2021 1 449 662 649 339 604 621 2 1 2 sky130_fd_sc_hd__a32oi_1
* cell instance $2023 r0 *1 19.78,73.44
X$2023 1 623 650 339 649 1 648 2 2 sky130_fd_sc_hd__a211o_1
* cell instance $2025 r0 *1 23.46,73.44
X$2025 1 503 634 623 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2027 r0 *1 25.3,73.44
X$2027 1 679 634 617 2 1 650 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2031 r0 *1 34.96,73.44
X$2031 1 568 606 617 665 1 624 2 2 sky130_fd_sc_hd__nand4_1
* cell instance $2032 r0 *1 37.26,73.44
X$2032 1 365 566 492 624 1 668 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $2038 r0 *1 44.62,73.44
X$2038 1 224 339 503 652 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $2039 r0 *1 46.46,73.44
X$2039 1 439 449 583 2 1 674 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2040 r0 *1 48.3,73.44
X$2040 1 586 670 493 652 796 1 2 2 sky130_fd_sc_hd__o211ai_1
* cell instance $2043 r0 *1 55.66,73.44
X$2043 1 272 1 2 625 2 sky130_fd_sc_hd__inv_1
* cell instance $2044 r0 *1 57.04,73.44
X$2044 2 643 654 622 244 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $2045 r0 *1 61.18,73.44
X$2045 2 410 644 516 645 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2048 r0 *1 71.3,73.44
X$2048 2 147 638 516 601 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2050 r0 *1 82.8,73.44
X$2050 1 654 638 642 2 1 2 sky130_fd_sc_hd__nand2b_1
* cell instance $2051 r0 *1 85.1,73.44
X$2051 1 613 1 2 609 2 sky130_fd_sc_hd__inv_1
* cell instance $2053 r0 *1 88.32,73.44
X$2053 2 676 656 477 675 655 1 1 2 sky130_fd_sc_hd__and4bb_1
* cell instance $2054 r0 *1 92.92,73.44
X$2054 1 673 683 672 637 654 1 655 2 2 sky130_fd_sc_hd__a311oi_1
* cell instance $2060 r0 *1 107.64,73.44
X$2060 2 109 635 499 434 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2061 r0 *1 118.68,73.44
X$2061 2 667 669 71 316 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2062 r0 *1 120.98,73.44
X$2062 1 499 1 2 2 sky130_fd_sc_hd__inv_6
* cell instance $2063 r0 *1 124.2,73.44
X$2063 1 657 1 2 1282 2 sky130_fd_sc_hd__clkinv_1
* cell instance $2065 r0 *1 126.04,73.44
X$2065 1 71 632 666 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2067 r0 *1 127.88,73.44
X$2067 2 196 629 499 434 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2068 r0 *1 138.92,73.44
X$2068 1 628 126 663 456 664 2 1 2 sky130_fd_sc_hd__o22ai_1
* cell instance $2071 r0 *1 142.6,73.44
X$2071 1 659 2 1 613 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2073 r0 *1 146.74,73.44
X$2073 2 663 661 697 40 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $2079 m0 *1 3.22,78.88
X$2079 1 677 2 1 692 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2083 m0 *1 10.12,78.88
X$2083 1 677 630 647 2 1 2 sky130_fd_sc_hd__nor2b_1
* cell instance $2087 m0 *1 15.64,78.88
X$2087 1 140 686 685 665 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $2090 m0 *1 19.78,78.88
X$2090 2 633 634 365 678 719 140 1 1 2 sky130_fd_sc_hd__a221oi_2
* cell instance $2091 m0 *1 25.3,78.88
X$2091 1 679 564 687 1 678 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2092 m0 *1 27.14,78.88
X$2092 1 700 564 687 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2099 m0 *1 35.88,78.88
X$2099 1 701 606 617 568 1 840 2 2 sky130_fd_sc_hd__nand4_1
* cell instance $2100 m0 *1 38.18,78.88
X$2100 1 670 1 2 651 2 sky130_fd_sc_hd__inv_1
* cell instance $2101 m0 *1 39.56,78.88
X$2101 1 140 651 701 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2105 m0 *1 44.16,78.88
X$2105 1 365 224 272 689 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $2106 m0 *1 46,78.88
X$2106 1 689 693 568 1 690 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2107 m0 *1 47.84,78.88
X$2107 1 690 140 703 2 1 653 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2108 m0 *1 49.68,78.88
X$2108 1 680 439 584 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2111 m0 *1 53.36,78.88
X$2111 1 680 365 494 2 1 704 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2118 m0 *1 59.8,78.88
X$2118 2 681 357 40 272 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $2120 m0 *1 65.32,78.88
X$2120 2 224 705 410 449 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2123 m0 *1 73.14,78.88
X$2123 2 147 627 497 531 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2128 m0 *1 86.02,78.88
X$2128 1 627 122 641 1 682 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2130 m0 *1 88.78,78.88
X$2130 2 675 641 682 688 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $2131 m0 *1 92.46,78.88
X$2131 1 683 654 637 673 1 656 2 2 sky130_fd_sc_hd__nand4_1
* cell instance $2132 m0 *1 94.76,78.88
X$2132 2 65 671 497 100 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2136 m0 *1 109.02,78.88
X$2136 1 126 40 275 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2142 m0 *1 114.08,78.88
X$2142 2 108 667 657 434 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2143 m0 *1 125.12,78.88
X$2143 2 65 699 657 434 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2149 m0 *1 139.84,78.88
X$2149 2 66 661 657 434 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2150 m0 *1 150.88,78.88
X$2150 1 684 2 1 654 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2165 r0 *1 4.6,78.88
X$2165 1 630 2 1 691 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2171 r0 *1 15.64,78.88
X$2171 1 685 686 492 491 2 1 717 2 sky130_fd_sc_hd__a31oi_1
* cell instance $2172 r0 *1 17.94,78.88
X$2172 1 717 679 751 449 719 2 1 2 sky130_fd_sc_hd__o22ai_1
* cell instance $2175 r0 *1 21.62,78.88
X$2175 2 679 700 698 492 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $2179 r0 *1 31.28,78.88
X$2179 1 140 329 720 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2186 r0 *1 43.7,78.88
X$2186 1 449 580 625 1 693 2 2 sky130_fd_sc_hd__o21a_1
* cell instance $2188 r0 *1 47.38,78.88
X$2188 1 491 449 670 1 2 703 2 sky130_fd_sc_hd__o21bai_1
* cell instance $2189 r0 *1 50.14,78.88
X$2189 1 680 329 449 140 2 1 694 2 sky130_fd_sc_hd__and4_1
* cell instance $2190 r0 *1 53.36,78.88
X$2190 1 693 704 708 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2193 r0 *1 56.12,78.88
X$2193 1 365 272 680 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2195 r0 *1 59.34,78.88
X$2195 1 126 339 724 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2198 r0 *1 63.48,78.88
X$2198 1 674 272 365 728 2 695 1 2 sky130_fd_sc_hd__nor4_1
* cell instance $2203 r0 *1 71.76,78.88
X$2203 1 725 705 147 1 2 2 sky130_fd_sc_hd__and2_1
* cell instance $2208 r0 *1 85.56,78.88
X$2208 2 706 676 613 712 707 640 1 1 2 sky130_fd_sc_hd__a2111oi_0
* cell instance $2209 r0 *1 88.78,78.88
X$2209 2 210 722 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $2211 r0 *1 98.44,78.88
X$2211 2 210 497 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $2214 r0 *1 109.02,78.88
X$2214 2 97 658 657 434 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2216 r0 *1 120.52,78.88
X$2216 1 664 669 666 702 2 468 1 2 sky130_fd_sc_hd__nor4_1
* cell instance $2217 r0 *1 122.82,78.88
X$2217 1 71 437 699 702 2 1 2 sky130_fd_sc_hd__nor3b_1
* cell instance $2219 r0 *1 126.04,78.88
X$2219 2 210 499 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $2221 r0 *1 135.7,78.88
X$2221 1 126 71 456 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2222 r0 *1 137.08,78.88
X$2222 2 35 697 657 434 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2225 r0 *1 149.5,78.88
X$2225 1 531 2 1 696 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2232 m0 *1 10.12,84.32
X$2232 2 686 560 647 544 1 1 2 sky130_fd_sc_hd__nand3_2
* cell instance $2233 m0 *1 13.8,84.32
X$2233 1 449 686 733 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2234 m0 *1 15.18,84.32
X$2234 1 733 685 716 686 670 2 1 2 sky130_fd_sc_hd__o22ai_1
* cell instance $2243 m0 *1 30.82,84.32
X$2243 1 492 541 720 2 1 721 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2250 m0 *1 46.92,84.32
X$2250 1 527 653 757 1 2 723 2 sky130_fd_sc_hd__o21bai_1
* cell instance $2258 m0 *1 57.96,84.32
X$2258 1 527 708 727 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2260 m0 *1 60.26,84.32
X$2260 1 724 708 727 729 709 2 1 2 sky130_fd_sc_hd__o22ai_1
* cell instance $2263 m0 *1 63.94,84.32
X$2263 1 728 680 674 710 2 1 2 sky130_fd_sc_hd__and3b_1
* cell instance $2264 m0 *1 67.16,84.32
X$2264 2 728 725 729 711 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $2265 m0 *1 71.76,84.32
X$2265 2 1290 739 760 711 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $2266 m0 *1 76.36,84.32
X$2266 1 739 705 738 1 2 2 sky130_fd_sc_hd__and2_1
* cell instance $2269 m0 *1 81.42,84.32
X$2269 1 738 1 2 97 2 sky130_fd_sc_hd__buf_4
* cell instance $2275 m0 *1 87.86,84.32
X$2275 1 274 713 275 1 673 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2276 m0 *1 89.7,84.32
X$2276 1 497 1 2 2 sky130_fd_sc_hd__inv_6
* cell instance $2277 m0 *1 92.92,84.32
X$2277 2 65 737 497 601 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2285 m0 *1 115,84.32
X$2285 1 736 714 734 640 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $2287 m0 *1 117.3,84.32
X$2287 2 108 718 657 531 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2288 m0 *1 128.34,84.32
X$2288 2 210 657 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $2290 m0 *1 137.54,84.32
X$2290 1 274 748 262 1 715 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2294 m0 *1 141.22,84.32
X$2294 1 644 2 1 732 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2313 r0 *1 4.6,100.64
X$2313 1 876 2 1 887 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2316 r0 *1 12.42,100.64
X$2316 1 811 1 2 875 2 sky130_fd_sc_hd__buf_4
* cell instance $2321 r0 *1 21.62,100.64
X$2321 1 515 1 2 824 2 sky130_fd_sc_hd__inv_1
* cell instance $2325 r0 *1 28.06,100.64
X$2325 1 801 871 890 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2328 r0 *1 34.96,100.64
X$2328 1 507 483 879 1 2 2 sky130_fd_sc_hd__and2_1
* cell instance $2330 r0 *1 37.72,100.64
X$2330 1 365 840 492 2 893 1 2 sky130_fd_sc_hd__o21ai_2
* cell instance $2333 r0 *1 43.24,100.64
X$2333 2 410 853 817 880 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2334 r0 *1 52.44,100.64
X$2334 2 853 871 870 766 827 1 1 2 sky130_fd_sc_hd__or4_4
* cell instance $2336 r0 *1 57.5,100.64
X$2336 2 410 872 826 897 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2337 r0 *1 66.7,100.64
X$2337 2 838 872 900 71 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $2342 r0 *1 74.06,100.64
X$2342 1 873 805 710 2 1 898 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2343 r0 *1 75.9,100.64
X$2343 2 410 873 722 896 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2344 r0 *1 85.1,100.64
X$2344 2 881 873 895 71 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $2348 r0 *1 93.84,100.64
X$2348 1 126 71 874 683 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $2352 r0 *1 98.44,100.64
X$2352 2 874 892 914 40 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $2361 r0 *1 126.04,100.64
X$2361 2 35 864 657 531 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2363 r0 *1 137.54,100.64
X$2363 2 875 878 862 846 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2365 r0 *1 149.5,100.64
X$2365 1 878 2 1 909 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2371 m0 *1 6.44,106.08
X$2371 2 410 883 817 847 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2372 m0 *1 15.64,106.08
X$2372 1 883 2 1 888 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2375 m0 *1 20.7,106.08
X$2375 1 893 901 911 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2376 m0 *1 22.08,106.08
X$2376 1 890 884 901 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $2377 m0 *1 25.3,106.08
X$2377 1 884 871 764 913 1 2 920 2 sky130_fd_sc_hd__o31ai_1
* cell instance $2382 m0 *1 30.36,106.08
X$2382 2 801 507 871 902 1 1 2 sky130_fd_sc_hd__nor3_4
* cell instance $2383 m0 *1 36.34,106.08
X$2383 1 365 840 903 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2384 m0 *1 37.72,106.08
X$2384 1 903 929 915 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2388 m0 *1 46.92,106.08
X$2388 1 827 766 801 894 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $2389 m0 *1 48.76,106.08
X$2389 1 851 492 857 2 1 916 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2391 m0 *1 51.06,106.08
X$2391 1 764 766 827 853 2 869 1 2 sky130_fd_sc_hd__nor4_1
* cell instance $2399 m0 *1 61.64,106.08
X$2399 1 694 885 897 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2401 m0 *1 63.94,106.08
X$2401 1 905 695 837 900 2 1 899 2 sky130_fd_sc_hd__a31oi_1
* cell instance $2402 m0 *1 66.24,106.08
X$2402 1 872 710 907 2 1 885 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2403 m0 *1 68.08,106.08
X$2403 1 746 837 906 907 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $2404 m0 *1 69.92,106.08
X$2404 1 760 819 906 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2406 m0 *1 74.98,106.08
X$2406 1 694 898 896 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2407 m0 *1 76.36,106.08
X$2407 1 895 783 710 2 1 917 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2413 m0 *1 84.64,106.08
X$2413 1 40 934 882 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2415 m0 *1 89.7,106.08
X$2415 2 66 892 722 601 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2424 m0 *1 123.28,106.08
X$2424 2 66 891 657 531 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2433 m0 *1 143.06,106.08
X$2433 1 860 2 889 1 2 sky130_fd_sc_hd__buf_2
* cell instance $2437 m0 *1 148.12,106.08
X$2437 1 926 2 1 846 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2438 m0 *1 151.8,106.08
X$2438 1 877 2 1 969 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2452 r0 *1 4.6,46.24
X$2452 2 68 362 298 411 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2453 r0 *1 13.8,46.24
X$2453 1 362 1 2 390 2 sky130_fd_sc_hd__inv_1
* cell instance $2456 r0 *1 16.1,46.24
X$2456 2 1292 412 362 401 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $2457 r0 *1 20.7,46.24
X$2457 1 391 390 413 2 1 411 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2460 r0 *1 23.92,46.24
X$2460 2 224 391 272 448 413 244 1 1 2 sky130_fd_sc_hd__a2111oi_0
* cell instance $2463 r0 *1 32.66,46.24
X$2463 2 68 424 298 403 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2469 r0 *1 46.46,46.24
X$2469 2 68 414 273 425 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2472 r0 *1 57.04,46.24
X$2472 2 414 290 365 394 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2475 r0 *1 61.64,46.24
X$2475 1 290 406 145 2 1 471 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2478 r0 *1 66.24,46.24
X$2478 1 37 394 476 1 396 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2479 r0 *1 68.08,46.24
X$2479 1 395 407 387 396 2 1 428 2 sky130_fd_sc_hd__a31oi_1
* cell instance $2481 r0 *1 70.84,46.24
X$2481 2 410 37 228 428 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2484 r0 *1 84.18,46.24
X$2484 1 62 1 2 429 2 sky130_fd_sc_hd__inv_1
* cell instance $2487 r0 *1 86.94,46.24
X$2487 2 108 408 228 37 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2491 r0 *1 101.2,46.24
X$2491 2 147 426 228 279 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2494 r0 *1 114.54,46.24
X$2494 2 109 421 299 279 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2497 r0 *1 127.88,46.24
X$2497 2 97 402 299 279 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2499 r0 *1 139.38,46.24
X$2499 2 35 418 299 279 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2507 m0 *1 6.44,51.68
X$2507 1 410 1 2 68 2 sky130_fd_sc_hd__buf_4
* cell instance $2508 m0 *1 9.2,51.68
X$2508 2 68 401 298 430 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2509 m0 *1 18.4,51.68
X$2509 2 1288 463 390 401 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $2510 m0 *1 23,51.68
X$2510 1 412 1 2 140 2 sky130_fd_sc_hd__buf_4
* cell instance $2518 m0 *1 31.74,51.68
X$2518 1 365 431 355 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2521 m0 *1 34.5,51.68
X$2521 2 403 392 424 367 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $2523 m0 *1 39.1,51.68
X$2523 2 423 424 393 367 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $2526 m0 *1 47.38,51.68
X$2526 2 425 357 414 367 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $2533 m0 *1 57.96,51.68
X$2533 2 410 406 273 442 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2534 m0 *1 67.16,51.68
X$2534 1 272 415 444 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2536 m0 *1 69,51.68
X$2536 2 415 101 433 244 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $2543 m0 *1 85.1,51.68
X$2543 1 101 1 2 443 2 sky130_fd_sc_hd__inv_1
* cell instance $2546 m0 *1 92,51.68
X$2546 2 196 441 228 100 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2550 m0 *1 106.26,51.68
X$2550 2 416 419 440 122 426 1 1 2 sky130_fd_sc_hd__o2bb2ai_2
* cell instance $2553 m0 *1 112.24,51.68
X$2553 2 65 422 299 325 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2554 m0 *1 123.28,51.68
X$2554 2 65 420 299 279 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2560 m0 *1 139.84,51.68
X$2560 2 66 438 299 279 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2561 m0 *1 150.88,51.68
X$2561 2 417 438 418 40 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $2573 r0 *1 1.84,2.72
X$2573 1 47 1 2 38 2 sky130_fd_sc_hd__buf_4
* cell instance $2576 r0 *1 5.52,2.72
X$2576 1 38 2 1 36 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2610 r0 *1 46,2.72
X$2610 1 60 2 1 6 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2620 r0 *1 58.88,2.72
X$2620 1 13 2 1 45 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2622 r0 *1 64.4,2.72
X$2622 1 12 2 1 46 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2627 r0 *1 71.76,2.72
X$2627 1 34 2 1 22 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2628 r0 *1 75.44,2.72
X$2628 1 37 2 1 25 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2629 r0 *1 79.12,2.72
X$2629 1 56 2 1 28 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2633 r0 *1 84.64,2.72
X$2633 2 35 42 43 44 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2639 r0 *1 100.74,2.72
X$2639 2 35 41 43 34 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2647 r0 *1 126.04,2.72
X$2647 1 92 1 2 40 2 sky130_fd_sc_hd__buf_4
* cell instance $2650 r0 *1 132.94,2.72
X$2650 1 30 1 2 39 2 sky130_fd_sc_hd__buf_4
* cell instance $2651 r0 *1 135.7,2.72
X$2651 1 39 2 1 31 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2657 r0 *1 149.96,2.72
X$2657 1 49 1 2 51 2 sky130_fd_sc_hd__buf_4
* cell instance $2676 m0 *1 9.66,8.16
X$2676 2 68 53 52 107 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2677 m0 *1 18.86,8.16
X$2677 2 68 57 52 55 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2686 m0 *1 47.84,8.16
X$2686 1 48 1 2 60 2 sky130_fd_sc_hd__inv_1
* cell instance $2696 m0 *1 57.5,8.16
X$2696 1 44 2 1 10 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2698 m0 *1 63.02,8.16
X$2698 1 14 2 1 77 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2701 m0 *1 69,8.16
X$2701 1 15 2 1 63 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2703 m0 *1 76.36,8.16
X$2703 1 23 2 1 74 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2704 m0 *1 80.04,8.16
X$2704 1 26 2 1 62 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2710 m0 *1 84.64,8.16
X$2710 2 66 73 43 44 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2711 m0 *1 95.68,8.16
X$2711 2 35 61 43 37 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2721 m0 *1 114.54,8.16
X$2721 2 72 95 124 40 41 71 70 1 1 2 sky130_fd_sc_hd__mux4_2
* cell instance $2724 m0 *1 124.2,8.16
X$2724 2 35 54 59 56 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2736 m0 *1 150.42,8.16
X$2736 1 51 2 1 50 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2742 r0 *1 2.76,84.32
X$2742 1 740 2 1 580 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2744 r0 *1 7.36,84.32
X$2744 2 741 685 686 1 1 2 sky130_fd_sc_hd__nor2b_4
* cell instance $2745 r0 *1 12.42,84.32
X$2745 1 686 631 716 749 2 1 2 sky130_fd_sc_hd__nor3b_1
* cell instance $2747 r0 *1 15.64,84.32
X$2747 1 749 356 741 2 1 751 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2751 r0 *1 23.46,84.32
X$2751 1 580 584 742 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2752 r0 *1 24.84,84.32
X$2752 1 449 742 752 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2755 r0 *1 27.6,84.32
X$2755 1 726 745 755 1 754 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2756 r0 *1 29.44,84.32
X$2756 1 743 565 365 721 2 1 744 2 sky130_fd_sc_hd__a31oi_1
* cell instance $2757 r0 *1 31.74,84.32
X$2757 1 449 584 701 2 1 745 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2758 r0 *1 33.58,84.32
X$2758 1 541 1 2 726 2 sky130_fd_sc_hd__inv_1
* cell instance $2762 r0 *1 38.18,84.32
X$2762 1 449 584 756 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2763 r0 *1 39.56,84.32
X$2763 1 449 701 493 541 778 1 2 2 sky130_fd_sc_hd__o211ai_1
* cell instance $2772 r0 *1 57.5,84.32
X$2772 1 746 727 758 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2773 r0 *1 58.88,84.32
X$2773 1 758 727 681 2 1 759 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2774 r0 *1 60.72,84.32
X$2774 2 410 760 516 709 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2780 r0 *1 76.82,84.32
X$2780 2 747 196 729 705 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2783 r0 *1 83.26,84.32
X$2783 2 196 713 722 601 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2784 r0 *1 94.3,84.32
X$2784 1 722 1 2 2 sky130_fd_sc_hd__clkinvlp_4
* cell instance $2789 r0 *1 101.2,84.32
X$2789 1 71 437 737 781 2 1 2 sky130_fd_sc_hd__nor3b_1
* cell instance $2790 r0 *1 103.96,84.32
X$2790 2 65 730 722 644 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2791 r0 *1 115,84.32
X$2791 1 735 437 777 1 736 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2792 r0 *1 116.84,84.32
X$2792 1 274 730 735 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2797 r0 *1 126.5,84.32
X$2797 1 316 718 71 731 2 1 753 2 sky130_fd_sc_hd__a31oi_1
* cell instance $2798 r0 *1 128.8,84.32
X$2798 2 196 750 657 644 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2799 r0 *1 139.84,84.32
X$2799 2 196 748 657 531 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2806 m0 *1 2.76,89.76
X$2806 1 784 2 1 604 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2808 m0 *1 10.12,89.76
X$2808 1 647 791 685 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2811 m0 *1 13.8,89.76
X$2811 1 686 716 761 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2812 m0 *1 15.18,89.76
X$2812 1 762 741 761 492 1 2 771 2 sky130_fd_sc_hd__o31ai_1
* cell instance $2814 m0 *1 18.4,89.76
X$2814 1 595 763 772 1 794 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2815 m0 *1 20.24,89.76
X$2815 1 515 752 798 1 763 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2817 m0 *1 23,89.76
X$2817 1 752 743 775 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2818 m0 *1 24.38,89.76
X$2818 1 492 774 764 743 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $2819 m0 *1 26.22,89.76
X$2819 1 595 775 754 744 795 1 2 2 sky130_fd_sc_hd__o211ai_1
* cell instance $2822 m0 *1 29.44,89.76
X$2822 2 210 577 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $2824 m0 *1 39.1,89.76
X$2824 1 776 778 756 1 2 765 2 sky130_fd_sc_hd__o21bai_1
* cell instance $2825 m0 *1 41.86,89.76
X$2825 2 780 765 779 570 625 1 1 2 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $2828 m0 *1 47.38,89.76
X$2828 2 410 766 577 723 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2831 m0 *1 57.04,89.76
X$2831 2 410 746 516 759 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2834 m0 *1 73.6,89.76
X$2834 1 760 1 2 729 2 sky130_fd_sc_hd__inv_1
* cell instance $2835 m0 *1 74.98,89.76
X$2835 2 747 768 760 705 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2836 m0 *1 77.28,89.76
X$2836 2 783 767 729 705 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2837 m0 *1 79.58,89.76
X$2837 1 767 1 2 108 2 sky130_fd_sc_hd__buf_4
* cell instance $2841 m0 *1 84.64,89.76
X$2841 1 768 1 2 66 2 sky130_fd_sc_hd__buf_4
* cell instance $2843 m0 *1 89.24,89.76
X$2843 2 108 782 497 601 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2844 m0 *1 100.28,89.76
X$2844 1 316 782 769 71 781 1 637 2 2 sky130_fd_sc_hd__a311oi_1
* cell instance $2845 m0 *1 103.5,89.76
X$2845 1 71 816 769 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2853 m0 *1 115.92,89.76
X$2853 1 71 793 316 777 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $2855 m0 *1 118.22,89.76
X$2855 2 65 773 657 531 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2856 m0 *1 129.26,89.76
X$2856 1 71 437 773 731 2 1 2 sky130_fd_sc_hd__nor3b_1
* cell instance $2859 m0 *1 133.4,89.76
X$2859 1 715 126 863 456 792 2 1 2 sky130_fd_sc_hd__o22a_1
* cell instance $2862 m0 *1 137.08,89.76
X$2862 1 456 790 770 126 734 2 1 2 sky130_fd_sc_hd__o22ai_1
* cell instance $2864 m0 *1 139.84,89.76
X$2864 1 274 750 262 1 770 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2882 r0 *1 2.76,89.76
X$2882 1 821 2 1 807 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2883 r0 *1 6.44,89.76
X$2883 1 807 1 2 809 2 sky130_fd_sc_hd__inv_1
* cell instance $2885 r0 *1 8.74,89.76
X$2885 1 560 809 808 1 791 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2886 r0 *1 10.58,89.76
X$2886 1 140 560 647 2 1 811 2 sky130_fd_sc_hd__and3_2
* cell instance $2891 r0 *1 17.02,89.76
X$2891 1 762 492 798 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2892 r0 *1 18.4,89.76
X$2892 1 561 798 814 771 140 772 2 1 2 sky130_fd_sc_hd__a32oi_1
* cell instance $2893 r0 *1 21.62,89.76
X$2893 1 631 1 2 698 2 sky130_fd_sc_hd__inv_1
* cell instance $2894 r0 *1 23,89.76
X$2894 2 577 1 1 2 sky130_fd_sc_hd__clkinv_8
* cell instance $2895 r0 *1 28.98,89.76
X$2895 2 210 817 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $2897 r0 *1 40.02,89.76
X$2897 1 493 541 449 776 2 1 779 2 sky130_fd_sc_hd__a31oi_1
* cell instance $2901 r0 *1 43.7,89.76
X$2901 1 766 801 544 785 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $2903 r0 *1 46.46,89.76
X$2903 1 785 766 801 2 1 757 2 sky130_fd_sc_hd__a21oi_1
* cell instance $2904 r0 *1 48.3,89.76
X$2904 1 449 493 818 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2905 r0 *1 49.68,89.76
X$2905 1 766 764 827 1 802 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2906 r0 *1 51.52,89.76
X$2906 2 818 786 788 796 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2907 r0 *1 53.82,89.76
X$2907 1 492 802 787 788 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $2909 r0 *1 56.58,89.76
X$2909 1 804 727 803 1 854 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $2910 r0 *1 58.42,89.76
X$2910 2 210 516 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $2911 r0 *1 67.62,89.76
X$2911 1 727 529 803 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2916 r0 *1 71.76,89.76
X$2916 2 783 789 760 705 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2918 r0 *1 74.98,89.76
X$2918 2 805 65 760 705 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2919 r0 *1 77.28,89.76
X$2919 2 805 109 729 705 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $2921 r0 *1 83.26,89.76
X$2921 1 789 1 2 35 2 sky130_fd_sc_hd__buf_4
* cell instance $2923 r0 *1 87.86,89.76
X$2923 1 126 40 437 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2925 r0 *1 92.92,89.76
X$2925 1 40 1 2 262 2 sky130_fd_sc_hd__clkinv_1
* cell instance $2928 r0 *1 96.6,89.76
X$2928 1 71 1 2 274 2 sky130_fd_sc_hd__inv_1
* cell instance $2933 r0 *1 103.5,89.76
X$2933 1 40 126 498 2 1 2 sky130_fd_sc_hd__nor2b_1
* cell instance $2934 r0 *1 105.8,89.76
X$2934 2 108 793 722 644 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2935 r0 *1 116.84,89.76
X$2935 1 71 815 714 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $2939 r0 *1 126.04,89.76
X$2939 1 71 850 792 753 688 1 2 2 sky130_fd_sc_hd__o211ai_1
* cell instance $2942 r0 *1 133.4,89.76
X$2942 2 66 810 657 644 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2943 r0 *1 144.44,89.76
X$2943 2 790 810 848 40 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $2951 m0 *1 2.76,95.2
X$2951 1 560 2 1 820 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2954 m0 *1 8.74,95.2
X$2954 1 560 883 822 808 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $2956 m0 *1 11.5,95.2
X$2956 1 356 449 822 813 2 1 812 2 sky130_fd_sc_hd__a31oi_1
* cell instance $2957 m0 *1 13.8,95.2
X$2957 1 544 823 797 449 2 1 813 2 sky130_fd_sc_hd__a31oi_1
* cell instance $2958 m0 *1 16.1,95.2
X$2958 1 797 823 716 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2960 m0 *1 18.4,95.2
X$2960 1 824 449 356 814 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $2961 m0 *1 20.24,95.2
X$2961 2 762 799 698 824 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $2963 m0 *1 25.76,95.2
X$2963 1 800 825 799 801 2 1 2 sky130_fd_sc_hd__or3b_2
* cell instance $2966 m0 *1 29.44,95.2
X$2966 2 817 1 1 2 sky130_fd_sc_hd__clkinv_8
* cell instance $2967 m0 *1 35.42,95.2
X$2967 1 774 764 755 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2968 m0 *1 36.8,95.2
X$2968 1 799 800 776 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $2970 m0 *1 40.94,95.2
X$2970 2 410 800 826 780 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2972 m0 *1 50.6,95.2
X$2972 1 827 766 764 787 1 2 2 sky130_fd_sc_hd__or3_1
* cell instance $2973 m0 *1 52.9,95.2
X$2973 1 826 1 2 2 sky130_fd_sc_hd__inv_6
* cell instance $2977 m0 *1 57.04,95.2
X$2977 2 516 1 1 2 sky130_fd_sc_hd__inv_8
* cell instance $2978 m0 *1 61.18,95.2
X$2978 2 1289 805 746 804 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $2979 m0 *1 65.78,95.2
X$2979 2 837 711 828 804 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $2980 m0 *1 70.38,95.2
X$2980 2 1286 747 828 819 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $2981 m0 *1 74.98,95.2
X$2981 2 410 829 722 830 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $2985 m0 *1 85.56,95.2
X$2985 1 262 838 836 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $2986 m0 *1 86.94,95.2
X$2986 1 806 836 126 866 2 1 707 2 sky130_fd_sc_hd__a31oi_1
* cell instance $2987 m0 *1 89.24,95.2
X$2987 1 262 274 829 806 1 2 2 sky130_fd_sc_hd__or3_1
* cell instance $2988 m0 *1 91.54,95.2
X$2988 2 109 835 722 601 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2989 m0 *1 102.58,95.2
X$2989 1 835 316 832 498 1 816 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $2995 m0 *1 112.24,95.2
X$2995 2 97 834 657 644 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2996 m0 *1 123.28,95.2
X$2996 2 97 833 657 531 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $2997 m0 *1 134.32,95.2
X$2997 1 849 1 2 316 2 sky130_fd_sc_hd__buf_4
* cell instance $3005 m0 *1 143.06,95.2
X$3005 1 889 1 2 71 2 sky130_fd_sc_hd__buf_4
* cell instance $3022 r0 *1 2.76,95.2
X$3022 1 839 2 1 822 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3025 r0 *1 10.58,95.2
X$3025 1 811 812 847 1 2 2 sky130_fd_sc_hd__and2_1
* cell instance $3029 r0 *1 15.64,95.2
X$3029 2 1291 797 631 824 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $3031 r0 *1 21.16,95.2
X$3031 1 698 824 823 764 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $3032 r0 *1 23,95.2
X$3032 1 800 631 515 825 1 2 774 2 sky130_fd_sc_hd__o31ai_1
* cell instance $3033 r0 *1 25.76,95.2
X$3033 2 410 825 577 795 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3034 r0 *1 34.96,95.2
X$3034 1 825 800 823 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3036 r0 *1 36.8,95.2
X$3036 1 492 840 365 510 1 851 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $3043 r0 *1 45.54,95.2
X$3043 1 894 853 856 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $3045 r0 *1 49.68,95.2
X$3045 2 210 826 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $3046 r0 *1 58.88,95.2
X$3046 2 410 819 826 854 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3048 r0 *1 69,95.2
X$3048 1 746 1 2 828 2 sky130_fd_sc_hd__inv_1
* cell instance $3051 r0 *1 71.76,95.2
X$3051 1 694 841 830 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3052 r0 *1 73.14,95.2
X$3052 1 829 783 695 2 1 841 2 sky130_fd_sc_hd__a21oi_1
* cell instance $3053 r0 *1 74.98,95.2
X$3053 2 410 843 722 855 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3054 r0 *1 84.18,95.2
X$3054 1 842 867 831 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3055 r0 *1 85.56,95.2
X$3055 1 843 437 842 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3056 r0 *1 86.94,95.2
X$3056 1 71 831 712 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3065 r0 *1 104.88,95.2
X$3065 2 109 852 722 644 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3066 r0 *1 115.92,95.2
X$3066 1 852 316 834 498 1 815 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $3074 r0 *1 127.42,95.2
X$3074 1 865 316 833 498 1 850 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $3076 r0 *1 130.64,95.2
X$3076 1 126 40 849 2 1 2 sky130_fd_sc_hd__nor2b_1
* cell instance $3078 r0 *1 134.78,95.2
X$3078 2 35 848 657 644 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3079 r0 *1 145.82,95.2
X$3079 1 844 2 1 859 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3081 r0 *1 150.42,95.2
X$3081 1 846 1 2 845 2 sky130_fd_sc_hd__buf_4
* cell instance $3084 m0 *1 1.38,100.64
X$3084 2 410 876 817 861 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3088 m0 *1 16.56,100.64
X$3088 1 365 621 861 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3089 m0 *1 17.94,100.64
X$3089 2 410 515 577 794 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3097 m0 *1 34.04,100.64
X$3097 1 799 823 581 1 2 2 sky130_fd_sc_hd__and2_1
* cell instance $3099 m0 *1 37.26,100.64
X$3099 1 879 1 2 449 2 sky130_fd_sc_hd__buf_4
* cell instance $3101 m0 *1 41.86,100.64
X$3101 1 668 856 880 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3102 m0 *1 43.24,100.64
X$3102 2 410 827 826 786 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3103 m0 *1 52.44,100.64
X$3103 1 869 870 857 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $3112 m0 *1 62.1,100.64
X$3112 1 819 1 2 804 2 sky130_fd_sc_hd__inv_1
* cell instance $3115 m0 *1 68.08,100.64
X$3115 2 1287 783 746 819 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $3118 m0 *1 74.98,100.64
X$3118 1 694 858 855 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3119 m0 *1 76.36,100.64
X$3119 1 843 805 695 2 1 858 2 sky130_fd_sc_hd__a21oi_1
* cell instance $3125 m0 *1 82.34,100.64
X$3125 1 126 868 40 867 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $3128 m0 *1 85.1,100.64
X$3128 2 866 882 40 126 71 881 1 1 2 sky130_fd_sc_hd__a221oi_1
* cell instance $3131 m0 *1 92.46,100.64
X$3131 2 97 832 722 601 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3141 m0 *1 116.84,100.64
X$3141 2 109 865 657 531 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3145 m0 *1 134.32,100.64
X$3145 2 863 891 864 40 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $3152 m0 *1 139.84,100.64
X$3152 2 875 877 862 859 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3154 m0 *1 152.72,100.64
X$3154 1 859 1 2 886 2 sky130_fd_sc_hd__buf_4
* cell instance $3157 r0 *1 2.76,19.04
X$3157 1 166 2 1 157 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3160 r0 *1 9.2,19.04
X$3160 1 64 158 167 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3161 r0 *1 10.58,19.04
X$3161 1 137 159 158 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $3165 r0 *1 15.64,19.04
X$3165 1 159 115 188 137 1 116 2 2 sky130_fd_sc_hd__nand4_1
* cell instance $3167 r0 *1 18.86,19.04
X$3167 1 115 89 53 160 2 1 247 2 sky130_fd_sc_hd__and4_1
* cell instance $3170 r0 *1 23.46,19.04
X$3170 2 160 102 190 57 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $3171 r0 *1 25.76,19.04
X$3171 2 68 139 52 172 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3176 r0 *1 43.24,19.04
X$3176 1 132 141 240 1 175 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3177 r0 *1 45.08,19.04
X$3177 2 68 143 58 161 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3179 r0 *1 54.74,19.04
X$3179 2 68 100 58 179 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3181 r0 *1 64.4,19.04
X$3181 1 140 144 34 145 1 181 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $3182 r0 *1 67.16,19.04
X$3182 1 204 162 156 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3184 r0 *1 69,19.04
X$3184 1 163 182 162 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3187 r0 *1 71.76,19.04
X$3187 1 17 2 1 146 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3190 r0 *1 76.82,19.04
X$3190 1 164 163 187 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $3193 r0 *1 81.42,19.04
X$3193 2 108 184 43 44 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3194 r0 *1 92.46,19.04
X$3194 2 165 131 184 71 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $3195 r0 *1 96.14,19.04
X$3195 1 40 183 195 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3200 r0 *1 102.58,19.04
X$3200 1 180 122 173 2 164 1 2 sky130_fd_sc_hd__o21ai_2
* cell instance $3201 r0 *1 105.8,19.04
X$3201 2 109 178 59 34 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3204 r0 *1 118.22,19.04
X$3204 2 177 178 128 71 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $3207 r0 *1 126.04,19.04
X$3207 2 108 170 59 56 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3208 r0 *1 137.08,19.04
X$3208 2 151 171 170 71 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $3210 r0 *1 141.22,19.04
X$3210 1 199 40 71 168 2 1 2 sky130_fd_sc_hd__nor3b_1
* cell instance $3217 m0 *1 1.84,24.48
X$3217 2 68 159 52 167 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3219 m0 *1 11.96,24.48
X$3219 2 1283 138 159 188 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $3220 m0 *1 16.56,24.48
X$3220 1 159 1 2 213 2 sky130_fd_sc_hd__inv_1
* cell instance $3223 m0 *1 22.08,24.48
X$3223 1 64 189 214 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3224 m0 *1 23.46,24.48
X$3224 1 169 190 1 189 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $3226 m0 *1 27.6,24.48
X$3226 1 190 57 191 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3230 m0 *1 30.36,24.48
X$3230 1 160 94 191 261 1 2 2 sky130_fd_sc_hd__or3_1
* cell instance $3233 m0 *1 37.26,24.48
X$3233 2 68 217 58 175 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3234 m0 *1 46.46,24.48
X$3234 2 142 220 176 201 1 1 2 sky130_fd_sc_hd__ha_1
* cell instance $3235 m0 *1 51.06,24.48
X$3235 1 140 134 202 1 155 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3241 m0 *1 61.18,24.48
X$3241 1 135 192 179 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3244 m0 *1 64.86,24.48
X$3244 1 111 182 192 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3246 m0 *1 66.7,24.48
X$3246 1 140 144 56 145 1 204 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $3250 m0 *1 77.28,24.48
X$3250 1 193 2 1 27 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3257 m0 *1 88.32,24.48
X$3257 1 126 165 185 1 183 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3258 m0 *1 90.16,24.48
X$3258 2 227 293 263 203 194 195 1 1 2 sky130_fd_sc_hd__a41oi_1
* cell instance $3259 m0 *1 93.38,24.48
X$3259 1 126 71 84 194 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $3261 m0 *1 95.68,24.48
X$3261 2 147 200 43 34 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3267 m0 *1 112.24,24.48
X$3267 2 196 148 59 34 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3271 m0 *1 128.34,24.48
X$3271 2 196 199 59 56 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3277 m0 *1 147.66,24.48
X$3277 1 197 1 2 198 2 sky130_fd_sc_hd__buf_4
* cell instance $3278 m0 *1 150.42,24.48
X$3278 1 198 2 1 211 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3293 r0 *1 2.76,35.36
X$3293 2 68 317 298 297 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3294 r0 *1 11.96,35.36
X$3294 1 308 338 317 246 327 1 2 2 sky130_fd_sc_hd__or4_1
* cell instance $3298 r0 *1 16.1,35.36
X$3298 1 64 308 300 2 1 2 sky130_fd_sc_hd__nor2b_1
* cell instance $3300 r0 *1 18.86,35.36
X$3300 2 339 174 281 137 272 1 1 2 sky130_fd_sc_hd__o211a_1
* cell instance $3301 r0 *1 22.54,35.36
X$3301 2 210 52 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $3305 r0 *1 39.56,35.36
X$3305 1 287 310 270 132 1 322 2 2 sky130_fd_sc_hd__a211o_1
* cell instance $3308 r0 *1 44.16,35.36
X$3308 2 309 310 271 330 221 251 1 1 2 sky130_fd_sc_hd__o32ai_1
* cell instance $3309 r0 *1 47.38,35.36
X$3309 1 251 221 2 1 132 2 sky130_fd_sc_hd__or2_4
* cell instance $3311 r0 *1 51.52,35.36
X$3311 1 243 331 346 1 288 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3312 r0 *1 53.36,35.36
X$3312 2 210 273 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $3314 r0 *1 63.02,35.36
X$3314 1 243 332 311 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3315 r0 *1 64.4,35.36
X$3315 1 140 224 46 2 1 332 2 sky130_fd_sc_hd__a21oi_1
* cell instance $3316 r0 *1 66.24,35.36
X$3316 1 223 292 312 1 307 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3317 r0 *1 68.08,35.36
X$3317 1 311 325 145 2 1 312 2 sky130_fd_sc_hd__a21oi_1
* cell instance $3322 r0 *1 76.36,35.36
X$3322 1 344 313 1 306 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $3323 r0 *1 79.58,35.36
X$3323 1 324 63 1 347 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $3326 r0 *1 85.56,35.36
X$3326 2 147 314 228 37 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3327 r0 *1 96.6,35.36
X$3327 1 314 122 345 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3330 r0 *1 98.9,35.36
X$3330 2 196 334 228 193 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3331 r0 *1 109.94,35.36
X$3331 2 324 383 341 342 323 335 1 1 2 sky130_fd_sc_hd__a41oi_1
* cell instance $3332 r0 *1 113.16,35.36
X$3332 1 315 304 316 336 71 335 2 1 2 sky130_fd_sc_hd__a32oi_1
* cell instance $3333 r0 *1 116.38,35.36
X$3333 2 210 299 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $3335 r0 *1 126.04,35.36
X$3335 1 299 1 2 1280 2 sky130_fd_sc_hd__clkinv_1
* cell instance $3338 r0 *1 131.56,35.36
X$3338 2 321 301 320 71 126 316 1 1 2 sky130_fd_sc_hd__a221oi_1
* cell instance $3339 r0 *1 134.78,35.36
X$3339 1 319 1 2 320 2 sky130_fd_sc_hd__inv_1
* cell instance $3341 r0 *1 136.62,35.36
X$3341 2 35 318 299 215 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3347 m0 *1 1.84,40.8
X$3347 2 68 338 298 337 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3348 m0 *1 11.04,40.8
X$3348 1 64 338 337 2 1 2 sky130_fd_sc_hd__nor2b_1
* cell instance $3352 m0 *1 18.4,40.8
X$3352 1 286 327 250 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3353 m0 *1 19.78,40.8
X$3353 2 210 298 1 1 2 sky130_fd_sc_hd__clkbuf_16
* cell instance $3357 m0 *1 30.36,40.8
X$3357 1 328 140 330 2 1 2 sky130_fd_sc_hd__nand2b_1
* cell instance $3358 m0 *1 32.66,40.8
X$3358 2 68 349 273 340 1 1 2 sky130_fd_sc_hd__dfstp_2
* cell instance $3360 m0 *1 42.78,40.8
X$3360 1 140 270 309 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3361 m0 *1 44.16,40.8
X$3361 1 220 343 329 1 2 2 sky130_fd_sc_hd__and2_1
* cell instance $3362 m0 *1 46.46,40.8
X$3362 1 220 343 356 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3363 m0 *1 47.84,40.8
X$3363 1 270 205 343 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3366 m0 *1 53.36,40.8
X$3366 1 273 1 2 2 sky130_fd_sc_hd__inv_6
* cell instance $3371 m0 *1 59.8,40.8
X$3371 1 215 145 359 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3375 m0 *1 70.38,40.8
X$3375 2 350 313 83 244 1 1 2 sky130_fd_sc_hd__mux2_2
* cell instance $3378 m0 *1 78.66,40.8
X$3378 2 361 388 187 436 347 1 1 2 sky130_fd_sc_hd__nor4_2
* cell instance $3384 m0 *1 90.16,40.8
X$3384 2 228 1 1 2 sky130_fd_sc_hd__bufinv_16
* cell instance $3385 m0 *1 101.2,40.8
X$3385 2 344 360 333 345 291 386 1 1 2 sky130_fd_sc_hd__a41oi_1
* cell instance $3387 m0 *1 108.1,40.8
X$3387 1 303 122 342 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3390 m0 *1 109.94,40.8
X$3390 1 274 334 275 1 341 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3392 m0 *1 112.24,40.8
X$3392 2 108 336 299 193 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3394 m0 *1 123.74,40.8
X$3394 2 109 319 299 215 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3416 r0 *1 2.76,133.28
X$3416 1 1043 2 1 1082 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3419 r0 *1 7.82,133.28
X$3419 1 1084 2 1 1085 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3425 r0 *1 21.62,133.28
X$3425 1 1060 2 1 1088 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3426 r0 *1 25.3,133.28
X$3426 1 1089 2 1 1090 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3427 r0 *1 28.98,133.28
X$3427 2 875 1094 862 1065 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3431 r0 *1 43.24,133.28
X$3431 1 1095 2 1 1069 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3433 r0 *1 47.84,133.28
X$3433 2 875 1060 862 1056 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3434 r0 *1 58.88,133.28
X$3434 2 875 1093 862 1075 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3440 r0 *1 75.9,133.28
X$3440 1 1053 2 1 1092 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3442 r0 *1 80.5,133.28
X$3442 1 1013 2 1 1077 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3445 r0 *1 89.7,133.28
X$3445 1 1051 2 1 1091 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3451 r0 *1 102.58,133.28
X$3451 2 875 1070 862 1072 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3452 r0 *1 113.62,133.28
X$3452 1 1070 2 1 1087 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3455 r0 *1 122.82,133.28
X$3455 1 1031 1 2 1067 2 sky130_fd_sc_hd__buf_4
* cell instance $3457 r0 *1 126.04,133.28
X$3457 2 875 1086 862 1064 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3460 r0 *1 139.84,133.28
X$3460 2 875 1083 862 1062 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3466 m0 *1 5.06,138.72
X$3466 2 875 1084 862 1104 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3467 m0 *1 16.1,138.72
X$3467 2 875 1089 862 1106 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3474 m0 *1 34.5,138.72
X$3474 2 875 1095 862 1078 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3475 m0 *1 45.54,138.72
X$3475 2 875 1119 862 1114 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3481 m0 *1 60.26,138.72
X$3481 1 1119 2 1 1120 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3485 m0 *1 67.16,138.72
X$3485 2 875 1126 862 1079 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3495 m0 *1 93.38,138.72
X$3495 2 875 1121 862 1125 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3498 m0 *1 105.8,138.72
X$3498 1 1121 2 1 1118 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3504 m0 *1 114.08,138.72
X$3504 2 875 1115 862 1117 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3509 m0 *1 135.24,138.72
X$3509 1 1086 2 1 1107 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3516 m0 *1 147.66,138.72
X$3516 1 1062 1 2 1081 2 sky130_fd_sc_hd__buf_4
* cell instance $3517 m0 *1 150.42,138.72
X$3517 1 1058 2 1 1062 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3532 r0 *1 2.76,62.56
X$3532 2 68 677 298 532 1 1 2 sky130_fd_sc_hd__dfstp_2
* cell instance $3539 r0 *1 21.62,62.56
X$3539 1 541 538 536 561 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $3540 r0 *1 23.46,62.56
X$3540 1 515 492 503 1 538 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3542 r0 *1 27.14,62.56
X$3542 1 508 465 564 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3546 r0 *1 31.74,62.56
X$3546 1 449 508 485 565 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $3548 r0 *1 34.04,62.56
X$3548 1 449 508 465 1 566 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3549 r0 *1 35.88,62.56
X$3549 1 465 508 365 503 2 1 568 2 sky130_fd_sc_hd__a31oi_1
* cell instance $3553 r0 *1 43.24,62.56
X$3553 1 339 545 546 2 1 251 2 sky130_fd_sc_hd__o21a_2
* cell instance $3554 r0 *1 46.46,62.56
X$3554 1 140 251 533 532 1 2 2 sky130_fd_sc_hd__or3_1
* cell instance $3557 r0 *1 50.14,62.56
X$3557 1 365 548 547 1 533 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3558 r0 *1 51.98,62.56
X$3558 1 528 224 492 2 1 548 2 sky130_fd_sc_hd__a21oi_1
* cell instance $3559 r0 *1 53.82,62.56
X$3559 1 449 2 1 492 2 sky130_fd_sc_hd__inv_2
* cell instance $3562 r0 *1 57.5,62.56
X$3562 1 414 357 394 365 1 550 2 2 sky130_fd_sc_hd__nand4b_1
* cell instance $3565 r0 *1 63.48,62.56
X$3565 1 272 71 539 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3566 r0 *1 64.86,62.56
X$3566 1 272 619 552 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3567 r0 *1 66.24,62.56
X$3567 1 552 576 407 534 2 1 530 2 sky130_fd_sc_hd__a31oi_1
* cell instance $3568 r0 *1 68.54,62.56
X$3568 1 531 394 476 1 534 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3572 r0 *1 73.14,62.56
X$3572 2 147 553 516 325 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3574 r0 *1 84.64,62.56
X$3574 1 553 122 513 1 573 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3575 r0 *1 86.48,62.56
X$3575 2 496 555 574 575 535 1 1 2 sky130_fd_sc_hd__nor4_2
* cell instance $3576 r0 *1 91.08,62.56
X$3576 2 535 513 573 504 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $3581 r0 *1 98.44,62.56
X$3581 2 97 523 497 100 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3582 r0 *1 109.48,62.56
X$3582 2 97 537 499 325 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3589 r0 *1 130.64,62.56
X$3589 1 71 563 501 562 522 1 2 2 sky130_fd_sc_hd__o211ai_1
* cell instance $3592 r0 *1 138.92,62.56
X$3592 2 35 559 499 406 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3600 m0 *1 4.14,68
X$3600 2 68 560 577 540 1 1 2 sky130_fd_sc_hd__dfstp_2
* cell instance $3604 m0 *1 21.62,68
X$3604 1 593 492 224 1 541 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3605 m0 *1 23.46,68
X$3605 1 593 280 542 272 1 2 596 2 sky130_fd_sc_hd__o31ai_1
* cell instance $3606 m0 *1 26.22,68
X$3606 1 541 543 596 540 1 2 2 sky130_fd_sc_hd__nand3_1
* cell instance $3614 m0 *1 39.1,68
X$3614 1 439 581 544 2 1 567 2 sky130_fd_sc_hd__a21oi_1
* cell instance $3615 m0 *1 40.94,68
X$3615 1 581 544 582 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3616 m0 *1 42.32,68
X$3616 2 427 582 583 584 585 1 1 2 sky130_fd_sc_hd__o211a_1
* cell instance $3617 m0 *1 46,68
X$3617 1 546 272 280 1 2 585 2 sky130_fd_sc_hd__o21ai_1
* cell instance $3619 m0 *1 48.3,68
X$3619 2 547 543 584 586 1 1 2 sky130_fd_sc_hd__and3_1
* cell instance $3620 m0 *1 50.6,68
X$3620 1 492 494 365 1 547 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3626 m0 *1 57.96,68
X$3626 1 549 618 600 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3628 m0 *1 59.8,68
X$3628 1 601 394 550 1 549 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3631 m0 *1 64.4,68
X$3631 1 224 551 576 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3639 m0 *1 82.8,68
X$3639 1 111 1 2 588 2 sky130_fd_sc_hd__inv_1
* cell instance $3641 m0 *1 84.64,68
X$3641 1 642 554 513 553 588 602 1 2 2 sky130_fd_sc_hd__o221ai_1
* cell instance $3642 m0 *1 87.86,68
X$3642 1 554 122 589 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3643 m0 *1 89.24,68
X$3643 1 111 556 589 575 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $3644 m0 *1 91.08,68
X$3644 1 111 556 639 1 2 2 sky130_fd_sc_hd__nand2_1
* cell instance $3645 m0 *1 92.46,68
X$3645 2 108 572 497 100 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3647 m0 *1 104.42,68
X$3647 1 526 571 598 556 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $3655 m0 *1 115.46,68
X$3655 1 597 316 537 498 2 569 1 2 sky130_fd_sc_hd__a22o_1
* cell instance $3656 m0 *1 118.68,68
X$3656 2 109 594 499 406 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3657 m0 *1 129.72,68
X$3657 1 594 316 590 498 1 563 2 2 sky130_fd_sc_hd__a22oi_1
* cell instance $3659 m0 *1 134.32,68
X$3659 1 274 592 262 1 557 2 2 sky130_fd_sc_hd__o21ai_0
* cell instance $3660 m0 *1 136.16,68
X$3660 1 557 126 558 456 562 2 1 2 sky130_fd_sc_hd__o22a_1
* cell instance $3663 m0 *1 139.84,68
X$3663 2 66 591 499 406 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3664 m0 *1 150.88,68
X$3664 2 558 591 559 40 1 1 2 sky130_fd_sc_hd__mux2i_1
* cell instance $3676 r0 *1 3.22,111.52
X$3676 1 949 1 2 410 2 sky130_fd_sc_hd__buf_4
* cell instance $3687 r0 *1 26.22,111.52
X$3687 1 913 884 902 1 2 2 sky130_fd_sc_hd__or2_2
* cell instance $3692 r0 *1 35.42,111.52
X$3692 1 923 921 928 940 2 1 2 sky130_fd_sc_hd__nor3_1
* cell instance $3693 r0 *1 37.26,111.52
X$3693 1 940 904 941 1 2 2 sky130_fd_sc_hd__xnor2_1
* cell instance $3694 r0 *1 40.48,111.52
X$3694 1 893 941 945 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3697 r0 *1 43.24,111.52
X$3697 2 410 904 826 945 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3700 r0 *1 53.82,111.52
X$3700 1 746 2 1 952 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3702 r0 *1 61.18,111.52
X$3702 2 410 934 826 946 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3727 r0 *1 129.26,111.52
X$3727 2 875 950 862 944 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3728 r0 *1 140.3,111.52
X$3728 2 875 936 862 943 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3733 m0 *1 1.84,116.96
X$3733 1 939 1 949 2 2 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3740 m0 *1 19.78,116.96
X$3740 2 410 953 817 956 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3746 m0 *1 30.36,116.96
X$3746 1 971 953 1 951 2 2 sky130_fd_sc_hd__xor2_1
* cell instance $3747 m0 *1 33.58,116.96
X$3747 1 928 947 954 953 2 958 1 2 sky130_fd_sc_hd__nor4_1
* cell instance $3748 m0 *1 35.88,116.96
X$3748 1 954 947 965 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3750 m0 *1 38.18,116.96
X$3750 1 893 973 961 2 1 2 sky130_fd_sc_hd__nor2_1
* cell instance $3752 m0 *1 40.48,116.96
X$3752 2 410 954 826 961 1 1 2 sky130_fd_sc_hd__dfrtp_1
* cell instance $3765 m0 *1 65.78,116.96
X$3765 1 601 2 1 963 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3766 m0 *1 69.46,116.96
X$3766 1 760 2 1 1271 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3789 m0 *1 116.84,116.96
X$3789 2 875 960 862 962 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3791 m0 *1 128.34,116.96
X$3791 2 875 957 862 959 1 1 2 sky130_fd_sc_hd__edfxtp_1
* cell instance $3797 m0 *1 140.3,116.96
X$3797 1 950 2 1 955 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3799 m0 *1 144.44,116.96
X$3799 1 942 2 1 944 2 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3801 m0 *1 148.58,116.96
X$3801 1 944 1 2 948 2 sky130_fd_sc_hd__buf_4
* cell instance $3803 m0 *1 152.26,116.96
X$3803 1 959 1 2 986 2 sky130_fd_sc_hd__buf_4
.ENDS ddr_controller

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__o2bb2ai_2
* pin VGND
* pin A1_N
* pin A2_N
* pin Y
* pin B1
* pin B2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2bb2ai_2 1 2 4 7 8 9 10 12 13
* net 1 VGND
* net 2 A1_N
* net 4 A2_N
* net 7 Y
* net 8 B1
* net 9 B2
* net 10 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 2 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=535000000000P PS=3830000U PD=3070000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 10 4 5 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 2.7,1.985 pfet_01v8_hvt
M$5 7 5 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=535000000000P
+ AD=287500000000P PS=3070000U PD=2575000U
* device instance $7 r0 *1 3.575,1.985 pfet_01v8_hvt
M$7 11 8 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=287500000000P
+ AD=420000000000P PS=2575000U PD=3840000U
* device instance $8 r0 *1 3.995,1.985 pfet_01v8_hvt
M$8 7 9 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $11 r0 *1 2.7,0.56 nfet_01v8
M$11 7 5 6 13 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=186875000000P
+ PS=2760000U PD=1875000U
* device instance $13 r0 *1 3.575,0.56 nfet_01v8
M$13 1 8 6 13 nfet_01v8 L=150000U W=1300000U AS=186875000000P AD=256750000000P
+ PS=1875000U PD=2740000U
* device instance $14 r0 *1 3.995,0.56 nfet_01v8
M$14 6 9 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 3 2 1 13 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=256750000000P
+ PS=2780000U PD=2740000U
* device instance $18 r0 *1 0.91,0.56 nfet_01v8
M$18 5 4 3 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
.ENDS sky130_fd_sc_hd__o2bb2ai_2

* cell sky130_fd_sc_hd__or3_4
* pin VGND
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or3_4 1 3 4 5 6 7 8 11
* net 1 VGND
* net 3 X
* net 4 C
* net 5 B
* net 6 A
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 2 8 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 5 10 8 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 6 9 8 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=400000000000P PS=1270000U PD=1800000U
* device instance $4 r0 *1 2.26,1.985 pfet_01v8_hvt
M$4 3 2 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=805000000000P
+ AD=765000000000P PS=5610000U PD=6530000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 4 2 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $9 r0 *1 0.89,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 1 6 2 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=260000000000P
+ PS=920000U PD=1450000U
* device instance $11 r0 *1 2.26,0.56 nfet_01v8
M$11 3 2 1 11 nfet_01v8 L=150000U W=2600000U AS=523250000000P AD=468000000000P
+ PS=4210000U PD=4690000U
.ENDS sky130_fd_sc_hd__or3_4

* cell sky130_fd_sc_hd__and4bb_1
* pin VGND
* pin C
* pin D
* pin X
* pin B_N
* pin A_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4bb_1 1 4 5 6 7 12 13 14 15
* net 1 VGND
* net 4 C
* net 5 D
* net 6 X
* net 7 B_N
* net 12 A_N
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 2.07,2.275 pfet_01v8_hvt
M$1 8 2 13 14 pfet_01v8_hvt L=150000U W=420000U AS=121800000000P
+ AD=58800000000P PS=1420000U PD=700000U
* device instance $2 r0 *1 2.5,2.275 pfet_01v8_hvt
M$2 13 3 8 14 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=73500000000P
+ PS=700000U PD=770000U
* device instance $3 r0 *1 3,2.275 pfet_01v8_hvt
M$3 8 4 13 14 pfet_01v8_hvt L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $4 r0 *1 3.52,2.275 pfet_01v8_hvt
M$4 8 5 13 14 pfet_01v8_hvt L=150000U W=420000U AS=172000000000P
+ AD=77700000000P PS=1460000U PD=790000U
* device instance $5 r0 *1 4.13,1.985 pfet_01v8_hvt
M$5 6 8 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=172000000000P
+ AD=260000000000P PS=1460000U PD=2520000U
* device instance $6 r0 *1 0.61,2.275 pfet_01v8_hvt
M$6 13 12 2 14 pfet_01v8_hvt L=150000U W=420000U AS=168000000000P
+ AD=58800000000P PS=1640000U PD=700000U
* device instance $7 r0 *1 1.04,2.275 pfet_01v8_hvt
M$7 3 7 13 14 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P
+ AD=134400000000P PS=700000U PD=1480000U
* device instance $8 r0 *1 2.07,0.675 nfet_01v8
M$8 9 2 8 15 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=58800000000P
+ PS=1400000U PD=700000U
* device instance $9 r0 *1 2.5,0.675 nfet_01v8
M$9 10 3 9 15 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=73500000000P
+ PS=700000U PD=770000U
* device instance $10 r0 *1 3,0.675 nfet_01v8
M$10 11 4 10 15 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $11 r0 *1 3.52,0.675 nfet_01v8
M$11 11 5 1 15 nfet_01v8 L=150000U W=420000U AS=126500000000P AD=77700000000P
+ PS=1110000U PD=790000U
* device instance $12 r0 *1 4.13,0.56 nfet_01v8
M$12 6 8 1 15 nfet_01v8 L=150000U W=650000U AS=126500000000P AD=165400000000P
+ PS=1110000U PD=1820000U
* device instance $13 r0 *1 0.61,0.445 nfet_01v8
M$13 1 12 2 15 nfet_01v8 L=150000U W=420000U AS=168000000000P AD=58800000000P
+ PS=1640000U PD=700000U
* device instance $14 r0 *1 1.04,0.445 nfet_01v8
M$14 3 7 1 15 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=138600000000P
+ PS=700000U PD=1500000U
.ENDS sky130_fd_sc_hd__and4bb_1

* cell sky130_fd_sc_hd__a32o_1
* pin VGND
* pin X
* pin A2
* pin A1
* pin B1
* pin A3
* pin B2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a32o_1 1 2 3 4 5 7 8 13 14 15
* net 1 VGND
* net 2 X
* net 3 A2
* net 4 A1
* net 5 B1
* net 7 A3
* net 8 B2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.54,1.985 pfet_01v8_hvt
M$1 13 6 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=330000000000P
+ AD=242500000000P PS=2660000U PD=1485000U
* device instance $2 r0 *1 1.175,1.985 pfet_01v8_hvt
M$2 12 7 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=242500000000P
+ AD=165000000000P PS=1485000U PD=1330000U
* device instance $3 r0 *1 1.655,1.985 pfet_01v8_hvt
M$3 13 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=225000000000P PS=1330000U PD=1450000U
* device instance $4 r0 *1 2.255,1.985 pfet_01v8_hvt
M$4 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=185000000000P PS=1450000U PD=1370000U
* device instance $5 r0 *1 2.775,1.985 pfet_01v8_hvt
M$5 6 5 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=185000000000P
+ AD=140000000000P PS=1370000U PD=1280000U
* device instance $6 r0 *1 3.205,1.985 pfet_01v8_hvt
M$6 12 8 6 14 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $7 r0 *1 0.54,0.56 nfet_01v8
M$7 1 6 2 15 nfet_01v8 L=150000U W=650000U AS=214500000000P AD=167375000000P
+ PS=1960000U PD=1165000U
* device instance $8 r0 *1 1.205,0.56 nfet_01v8
M$8 9 7 1 15 nfet_01v8 L=150000U W=650000U AS=167375000000P AD=97500000000P
+ PS=1165000U PD=950000U
* device instance $9 r0 *1 1.655,0.56 nfet_01v8
M$9 11 3 9 15 nfet_01v8 L=150000U W=650000U AS=97500000000P AD=146250000000P
+ PS=950000U PD=1100000U
* device instance $10 r0 *1 2.255,0.56 nfet_01v8
M$10 6 4 11 15 nfet_01v8 L=150000U W=650000U AS=146250000000P AD=143000000000P
+ PS=1100000U PD=1090000U
* device instance $11 r0 *1 2.845,0.56 nfet_01v8
M$11 10 5 6 15 nfet_01v8 L=150000U W=650000U AS=143000000000P AD=68250000000P
+ PS=1090000U PD=860000U
* device instance $12 r0 *1 3.205,0.56 nfet_01v8
M$12 1 8 10 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=172250000000P
+ PS=860000U PD=1830000U
.ENDS sky130_fd_sc_hd__a32o_1

* cell sky130_fd_sc_hd__mux4_2
* pin VGND
* pin A2
* pin A0
* pin X
* pin S0
* pin A3
* pin S1
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux4_2 1 3 8 9 14 15 16 17 18 19 24
* net 1 VGND
* net 3 A2
* net 8 A0
* net 9 X
* net 14 S0
* net 15 A3
* net 16 S1
* net 17 A1
* net 18 VPWR
* net 19 VPB
* device instance $1 r0 *1 5.225,2.165 pfet_01v8_hvt
M$1 22 17 18 19 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=137750000000P PS=1800000U PD=1165000U
* device instance $2 r0 *1 5.9,2.275 pfet_01v8_hvt
M$2 7 2 22 19 pfet_01v8_hvt L=150000U W=420000U AS=137750000000P
+ AD=56700000000P PS=1165000U PD=690000U
* device instance $3 r0 *1 6.32,2.275 pfet_01v8_hvt
M$3 7 14 23 19 pfet_01v8_hvt L=150000U W=420000U AS=105350000000P
+ AD=56700000000P PS=995000U PD=690000U
* device instance $4 r0 *1 6.825,2.165 pfet_01v8_hvt
M$4 23 8 18 19 pfet_01v8_hvt L=150000U W=640000U AS=154000000000P
+ AD=105350000000P PS=1335000U PD=995000U
* device instance $5 r0 *1 7.31,1.985 pfet_01v8_hvt
M$5 9 6 18 19 pfet_01v8_hvt L=150000U W=2000000U AS=289000000000P
+ AD=475000000000P PS=2605000U PD=3950000U
* device instance $7 r0 *1 3.865,1.85 pfet_01v8_hvt
M$7 6 5 4 19 pfet_01v8_hvt L=150000U W=540000U AS=140400000000P AD=72900000000P
+ PS=1600000U PD=810000U
* device instance $8 r0 *1 4.285,1.85 pfet_01v8_hvt
M$8 7 16 6 19 pfet_01v8_hvt L=150000U W=540000U AS=72900000000P
+ AD=140400000000P PS=810000U PD=1600000U
* device instance $9 r0 *1 2.505,2.045 pfet_01v8_hvt
M$9 18 15 21 19 pfet_01v8_hvt L=150000U W=640000U AS=164500000000P
+ AD=86400000000P PS=1330000U PD=910000U
* device instance $10 r0 *1 2.925,2.045 pfet_01v8_hvt
M$10 5 16 18 19 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $11 r0 *1 0.47,2.165 pfet_01v8_hvt
M$11 18 14 2 19 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $12 r0 *1 0.89,2.165 pfet_01v8_hvt
M$12 20 3 18 19 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=95750000000P PS=910000U PD=965000U
* device instance $13 r0 *1 1.365,2.275 pfet_01v8_hvt
M$13 4 14 20 19 pfet_01v8_hvt L=150000U W=420000U AS=95750000000P
+ AD=56700000000P PS=965000U PD=690000U
* device instance $14 r0 *1 1.785,2.275 pfet_01v8_hvt
M$14 4 2 21 19 pfet_01v8_hvt L=150000U W=420000U AS=164500000000P
+ AD=56700000000P PS=1330000U PD=690000U
* device instance $15 r0 *1 1.365,0.415 nfet_01v8
M$15 4 2 10 24 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=71100000000P
+ PS=745000U PD=755000U
* device instance $16 r0 *1 1.91,0.415 nfet_01v8
M$16 11 14 4 24 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=67050000000P
+ PS=755000U PD=750000U
* device instance $17 r0 *1 0.47,0.445 nfet_01v8
M$17 1 14 2 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $18 r0 *1 0.89,0.445 nfet_01v8
M$18 10 3 1 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=66000000000P
+ PS=690000U PD=745000U
* device instance $19 r0 *1 2.39,0.445 nfet_01v8
M$19 1 15 11 24 nfet_01v8 L=150000U W=420000U AS=67050000000P AD=81900000000P
+ PS=750000U PD=810000U
* device instance $20 r0 *1 2.93,0.445 nfet_01v8
M$20 5 16 1 24 nfet_01v8 L=150000U W=420000U AS=81900000000P AD=113400000000P
+ PS=810000U PD=1380000U
* device instance $21 r0 *1 5.78,0.415 nfet_01v8
M$21 7 14 13 24 nfet_01v8 L=150000U W=360000U AS=78600000000P AD=72000000000P
+ PS=805000U PD=760000U
* device instance $22 r0 *1 6.33,0.415 nfet_01v8
M$22 12 2 7 24 nfet_01v8 L=150000U W=360000U AS=72000000000P AD=66000000000P
+ PS=760000U PD=745000U
* device instance $23 r0 *1 5.245,0.445 nfet_01v8
M$23 13 17 1 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=78600000000P
+ PS=1360000U PD=805000U
* device instance $24 r0 *1 6.805,0.445 nfet_01v8
M$24 1 8 12 24 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=106750000000P
+ PS=745000U PD=1005000U
* device instance $25 r0 *1 7.31,0.56 nfet_01v8
M$25 9 6 1 24 nfet_01v8 L=150000U W=1300000U AS=194500000000P AD=308750000000P
+ PS=1925000U PD=2900000U
* device instance $27 r0 *1 3.88,0.445 nfet_01v8
M$27 6 16 4 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=57750000000P
+ PS=1360000U PD=695000U
* device instance $28 r0 *1 4.305,0.445 nfet_01v8
M$28 7 5 6 24 nfet_01v8 L=150000U W=420000U AS=57750000000P AD=109200000000P
+ PS=695000U PD=1360000U
.ENDS sky130_fd_sc_hd__mux4_2

* cell sky130_fd_sc_hd__nor4_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_2 1 2 3 4 5 6 8 11 12
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 5 C
* net 6 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.57,1.985 pfet_01v8_hvt
M$3 2 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 8 3 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 9 4 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.57,0.56 nfet_01v8
M$11 2 6 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 2 3 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $15 r0 *1 1.33,0.56 nfet_01v8
M$15 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nor4_2

* cell sky130_fd_sc_hd__a22o_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a22o_1 1 2 3 4 5 6 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 VGND
* net 9 X
* net 10 VPWR
* device instance $1 r0 *1 1.82,1.985 pfet_01v8_hvt
M$1 7 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=252900000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $2 r0 *1 2.29,1.985 pfet_01v8_hvt
M$2 10 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=155000000000P PS=1320000U PD=1310000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 8 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=252850000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 1.79,0.56 nfet_01v8
M$6 12 4 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=113750000000P
+ PS=1820000U PD=1000000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 5 12 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $8 r0 *1 2.75,0.56 nfet_01v8
M$8 9 8 6 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=169000000000P
+ PS=960000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 13 2 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $10 r0 *1 0.85,0.56 nfet_01v8
M$10 8 3 13 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22o_1

* cell sky130_fd_sc_hd__bufinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__bufinv_16 1 5 6 7 8
* net 1 VGND
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 5 2 7 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 3 2 6 7 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=810000000000P PS=7620000U PD=7620000U
* device instance $10 r0 *1 4.25,1.985 pfet_01v8_hvt
M$10 4 3 6 7 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 5 2 8 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $29 r0 *1 1.73,0.56 nfet_01v8
M$29 3 2 1 8 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=526500000000P
+ PS=5520000U PD=5520000U
* device instance $35 r0 *1 4.25,0.56 nfet_01v8
M$35 4 3 1 8 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__bufinv_16

* cell sky130_fd_sc_hd__or2_4
* pin VPB
* pin A
* pin B
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or2_4 1 2 3 4 5 6 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 VGND
* net 5 VPWR
* net 6 X
* device instance $1 r0 *1 0.53,1.985 pfet_01v8_hvt
M$1 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=105000000000P PS=2560000U PD=1210000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 5 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=177500000000P PS=1210000U PD=1355000U
* device instance $3 r0 *1 1.395,1.985 pfet_01v8_hvt
M$3 6 7 5 1 pfet_01v8_hvt L=150000U W=4000000U AS=582500000000P
+ AD=685000000000P PS=5165000U PD=6370000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 7 3 4 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 0.89,0.56 nfet_01v8
M$8 4 2 7 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=115375000000P
+ PS=920000U PD=1005000U
* device instance $9 r0 *1 1.395,0.56 nfet_01v8
M$9 6 7 4 8 nfet_01v8 L=150000U W=2600000U AS=378625000000P AD=432250000000P
+ PS=3765000U PD=4580000U
.ENDS sky130_fd_sc_hd__or2_4

* cell sky130_fd_sc_hd__o221ai_1
* pin VPB
* pin C1
* pin B1
* pin A2
* pin A1
* pin B2
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o221ai_1 1 2 3 4 5 6 8 10 11 12
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 B2
* net 8 Y
* net 10 VPWR
* net 11 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=380000000000P PS=2560000U PD=1760000U
* device instance $2 r0 *1 1.4,1.985 pfet_01v8_hvt
M$2 14 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=380000000000P
+ AD=120000000000P PS=1760000U PD=1240000U
* device instance $3 r0 *1 1.79,1.985 pfet_01v8_hvt
M$3 8 6 14 1 pfet_01v8_hvt L=150000U W=1000000U AS=120000000000P
+ AD=225000000000P PS=1240000U PD=1450000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 13 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=105000000000P PS=1450000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.4,0.56 nfet_01v8
M$6 9 3 7 12 nfet_01v8 L=150000U W=650000U AS=165200000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.82,0.56 nfet_01v8
M$7 7 6 9 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=117000000000P
+ PS=920000U PD=1010000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 11 4 7 12 nfet_01v8 L=150000U W=650000U AS=117000000000P AD=87750000000P
+ PS=1010000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 5 11 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 9 2 8 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=165400000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221ai_1

* cell sky130_fd_sc_hd__a41oi_1
* pin VGND
* pin Y
* pin A3
* pin A2
* pin B1
* pin A4
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_1 1 2 3 4 8 9 10 11 12 14
* net 1 VGND
* net 2 Y
* net 3 A3
* net 4 A2
* net 8 B1
* net 9 A4
* net 10 A1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 13 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=212500000000P PS=2520000U PD=1425000U
* device instance $2 r0 *1 1.045,1.985 pfet_01v8_hvt
M$2 11 9 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=205000000000P PS=1425000U PD=1410000U
* device instance $3 r0 *1 1.605,1.985 pfet_01v8_hvt
M$3 13 3 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=155000000000P PS=1410000U PD=1310000U
* device instance $4 r0 *1 2.065,1.985 pfet_01v8_hvt
M$4 11 4 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=212500000000P PS=1310000U PD=1425000U
* device instance $5 r0 *1 2.64,1.985 pfet_01v8_hvt
M$5 13 10 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=370000000000P PS=1425000U PD=2740000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 8 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=169000000000P
+ PS=1175000U PD=1820000U
* device instance $7 r0 *1 1.105,0.56 nfet_01v8
M$7 5 9 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=113750000000P
+ PS=1175000U PD=1000000U
* device instance $8 r0 *1 1.605,0.56 nfet_01v8
M$8 7 3 5 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $9 r0 *1 2.065,0.56 nfet_01v8
M$9 6 4 7 14 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=138125000000P
+ PS=960000U PD=1075000U
* device instance $10 r0 *1 2.64,0.56 nfet_01v8
M$10 2 10 6 14 nfet_01v8 L=150000U W=650000U AS=138125000000P AD=240500000000P
+ PS=1075000U PD=2040000U
.ENDS sky130_fd_sc_hd__a41oi_1

* cell sky130_fd_sc_hd__a211oi_1
* pin VPB
* pin A2
* pin A1
* pin C1
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A2
* net 3 A1
* net 4 C1
* net 5 B1
* net 6 VGND
* net 7 Y
* net 9 VPWR
* device instance $1 r0 *1 0.62,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.05,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 1.48,1.985 pfet_01v8_hvt
M$3 11 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 1.94,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.62,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=266500000000P AD=91000000000P
+ PS=2120000U PD=930000U
* device instance $6 r0 *1 1.05,0.56 nfet_01v8
M$6 7 3 12 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $7 r0 *1 1.48,0.56 nfet_01v8
M$7 6 5 7 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $8 r0 *1 1.94,0.56 nfet_01v8
M$8 7 4 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211oi_1

* cell sky130_fd_sc_hd__a31o_2
* pin VPB
* pin B1
* pin A1
* pin A2
* pin A3
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a31o_2 1 2 3 4 5 6 7 8 11
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 A3
* net 6 X
* net 7 VPWR
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 10 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 7 4 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $5 r0 *1 2.21,1.985 pfet_01v8_hvt
M$5 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $6 r0 *1 2.69,1.985 pfet_01v8_hvt
M$6 10 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=320000000000P PS=1330000U PD=2640000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 6 10 8 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $9 r0 *1 1.31,0.56 nfet_01v8
M$9 13 5 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 1.73,0.56 nfet_01v8
M$10 12 4 13 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $11 r0 *1 2.21,0.56 nfet_01v8
M$11 10 3 12 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=126750000000P
+ PS=980000U PD=1040000U
* device instance $12 r0 *1 2.75,0.56 nfet_01v8
M$12 8 2 10 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=169000000000P
+ PS=1040000U PD=1820000U
.ENDS sky130_fd_sc_hd__a31o_2

* cell sky130_fd_sc_hd__o32ai_1
* pin VGND
* pin B1
* pin Y
* pin B2
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32ai_1 1 2 4 5 6 7 8 9 10 12
* net 1 VGND
* net 2 B1
* net 4 Y
* net 5 B2
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 4 5 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=305000000000P PS=1210000U PD=1610000U
* device instance $3 r0 *1 1.59,1.985 pfet_01v8_hvt
M$3 13 6 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=245000000000P PS=1610000U PD=1490000U
* device instance $4 r0 *1 2.23,1.985 pfet_01v8_hvt
M$4 14 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=245000000000P
+ AD=135000000000P PS=1490000U PD=1270000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 9 8 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=280000000000P PS=1270000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 4 2 3 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 0.945,0.56 nfet_01v8
M$7 3 5 4 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=100750000000P
+ PS=975000U PD=960000U
* device instance $8 r0 *1 1.405,0.56 nfet_01v8
M$8 1 6 3 12 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=219375000000P
+ PS=960000U PD=1325000U
* device instance $9 r0 *1 2.23,0.56 nfet_01v8
M$9 3 7 1 12 nfet_01v8 L=150000U W=650000U AS=219375000000P AD=87750000000P
+ PS=1325000U PD=920000U
* device instance $10 r0 *1 2.65,0.56 nfet_01v8
M$10 1 8 3 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=234000000000P
+ PS=920000U PD=2020000U
.ENDS sky130_fd_sc_hd__o32ai_1

* cell sky130_fd_sc_hd__nand3b_1
* pin VPB
* pin A_N
* pin C
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A_N
* net 3 C
* net 4 B
* net 5 Y
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 8 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 8 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 5 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=280000000000P PS=1385000U PD=2560000U
* device instance $5 r0 *1 0.6,0.675 nfet_01v8
M$5 6 2 7 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $6 r0 *1 1.085,0.56 nfet_01v8
M$6 11 3 7 9 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $8 r0 *1 2.04,0.56 nfet_01v8
M$8 5 6 10 9 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=182000000000P
+ PS=1035000U PD=1860000U
.ENDS sky130_fd_sc_hd__nand3b_1

* cell sky130_fd_sc_hd__o31a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31a_1 1 2 5 6 7 8 9 10 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.65,1.985 pfet_01v8_hvt
M$1 9 4 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=360000000000P
+ AD=195000000000P PS=2720000U PD=1390000U
* device instance $2 r0 *1 1.19,1.985 pfet_01v8_hvt
M$2 12 5 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=135000000000P PS=1390000U PD=1270000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 11 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.09,1.985 pfet_01v8_hvt
M$4 4 7 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=212500000000P PS=1330000U PD=1425000U
* device instance $5 r0 *1 2.665,1.985 pfet_01v8_hvt
M$5 9 8 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=345000000000P PS=1425000U PD=2690000U
* device instance $6 r0 *1 0.65,0.56 nfet_01v8
M$6 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=234000000000P AD=126750000000P
+ PS=2020000U PD=1040000U
* device instance $7 r0 *1 1.19,0.56 nfet_01v8
M$7 3 5 1 13 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.61,0.56 nfet_01v8
M$8 1 6 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 2.09,0.56 nfet_01v8
M$9 3 7 1 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.57,0.56 nfet_01v8
M$10 4 8 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=201500000000P
+ PS=980000U PD=1920000U
.ENDS sky130_fd_sc_hd__o31a_1

* cell sky130_fd_sc_hd__inv_2
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_2 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 VPWR
* net 5 Y
* device instance $1 r0 *1 0.48,1.985 pfet_01v8_hvt
M$1 5 2 4 1 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $3 r0 *1 0.48,0.56 nfet_01v8
M$3 5 2 3 6 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__inv_2

* cell sky130_fd_sc_hd__o211a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211a_1 1 2 5 6 7 8 10 11 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 B1
* net 8 C1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 12 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=162500000000P PS=2520000U PD=1325000U
* device instance $2 r0 *1 1.885,1.985 pfet_01v8_hvt
M$2 4 6 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=220000000000P PS=1325000U PD=1440000U
* device instance $3 r0 *1 2.475,1.985 pfet_01v8_hvt
M$3 10 7 4 11 pfet_01v8_hvt L=150000U W=1000000U AS=220000000000P
+ AD=175000000000P PS=1440000U PD=1350000U
* device instance $4 r0 *1 2.975,1.985 pfet_01v8_hvt
M$4 4 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=300000000000P PS=1350000U PD=2600000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 1.885,0.56 nfet_01v8
M$7 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=143000000000P
+ PS=975000U PD=1090000U
* device instance $8 r0 *1 2.475,0.56 nfet_01v8
M$8 9 7 3 13 nfet_01v8 L=150000U W=650000U AS=143000000000P AD=113750000000P
+ PS=1090000U PD=1000000U
* device instance $9 r0 *1 2.975,0.56 nfet_01v8
M$9 4 8 9 13 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=195000000000P
+ PS=1000000U PD=1900000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o211a_1

* cell sky130_fd_sc_hd__o221a_1
* pin VGND
* pin X
* pin C1
* pin B1
* pin B2
* pin A2
* pin A1
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o221a_1 1 5 6 7 8 9 10 11 12 15
* net 1 VGND
* net 5 X
* net 6 C1
* net 7 B1
* net 8 B2
* net 9 A2
* net 10 A1
* net 11 VPB
* net 12 VPWR
* device instance $1 r0 *1 0.67,1.985 pfet_01v8_hvt
M$1 12 6 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=340000000000P
+ AD=165000000000P PS=2680000U PD=1330000U
* device instance $2 r0 *1 1.15,1.985 pfet_01v8_hvt
M$2 13 7 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=105000000000P PS=1330000U PD=1210000U
* device instance $3 r0 *1 1.51,1.985 pfet_01v8_hvt
M$3 2 8 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=412500000000P PS=1210000U PD=1825000U
* device instance $4 r0 *1 2.485,1.985 pfet_01v8_hvt
M$4 14 9 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=412500000000P
+ AD=105000000000P PS=1825000U PD=1210000U
* device instance $5 r0 *1 2.845,1.985 pfet_01v8_hvt
M$5 12 10 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $6 r0 *1 3.325,1.985 pfet_01v8_hvt
M$6 5 2 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=280000000000P PS=1330000U PD=2560000U
* device instance $7 r0 *1 2.485,0.56 nfet_01v8
M$7 4 9 1 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.905,0.56 nfet_01v8
M$8 1 10 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 3.325,0.56 nfet_01v8
M$9 5 2 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
* device instance $10 r0 *1 0.67,0.56 nfet_01v8
M$10 3 6 2 15 nfet_01v8 L=150000U W=650000U AS=201500000000P AD=99125000000P
+ PS=1920000U PD=955000U
* device instance $11 r0 *1 1.125,0.56 nfet_01v8
M$11 4 7 3 15 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=87750000000P
+ PS=955000U PD=920000U
* device instance $12 r0 *1 1.545,0.56 nfet_01v8
M$12 3 8 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221a_1

* cell sky130_fd_sc_hd__nand4b_1
* pin VPB
* pin A_N
* pin B
* pin C
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_1 1 2 3 4 6 7 8 9 10
* net 1 VPB
* net 2 A_N
* net 3 B
* net 4 C
* net 6 D
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=195000000000P PS=1385000U PD=1390000U
* device instance $5 r0 *1 2.58,1.985 pfet_01v8_hvt
M$5 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $6 r0 *1 0.545,0.675 nfet_01v8
M$6 5 2 9 10 nfet_01v8 L=150000U W=420000U AS=118125000000P AD=111300000000P
+ PS=1040000U PD=1370000U
* device instance $7 r0 *1 1.085,0.56 nfet_01v8
M$7 11 6 9 10 nfet_01v8 L=150000U W=650000U AS=118125000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.505,0.56 nfet_01v8
M$8 13 4 11 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $9 r0 *1 2.04,0.56 nfet_01v8
M$9 12 3 13 10 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=126750000000P
+ PS=1035000U PD=1040000U
* device instance $10 r0 *1 2.58,0.56 nfet_01v8
M$10 8 5 12 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=227500000000P
+ PS=1040000U PD=2000000U
.ENDS sky130_fd_sc_hd__nand4b_1

* cell sky130_fd_sc_hd__a21oi_2
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_2 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=275000000000P PS=3830000U PD=2550000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 6 2 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=275000000000P PS=2560000U PD=2550000U
* device instance $5 r0 *1 2.19,1.985 pfet_01v8_hvt
M$5 7 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=495000000000P PS=2540000U PD=3990000U
* device instance $7 r0 *1 0.495,0.56 nfet_01v8
M$7 10 4 8 9 nfet_01v8 L=150000U W=650000U AS=185250000000P AD=89375000000P
+ PS=1870000U PD=925000U
* device instance $8 r0 *1 0.92,0.56 nfet_01v8
M$8 7 2 10 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $9 r0 *1 1.35,0.56 nfet_01v8
M$9 11 2 7 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=68250000000P
+ PS=930000U PD=860000U
* device instance $10 r0 *1 1.71,0.56 nfet_01v8
M$10 8 4 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=107250000000P
+ PS=860000U PD=980000U
* device instance $11 r0 *1 2.19,0.56 nfet_01v8
M$11 7 3 8 9 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=347750000000P
+ PS=1900000U PD=3020000U
.ENDS sky130_fd_sc_hd__a21oi_2

* cell sky130_fd_sc_hd__o21ai_1
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 VGND
* net 8 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 8 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=174000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.37,2.135 pfet_01v8_hvt
M$3 5 3 8 1 pfet_01v8_hvt L=150000U W=700000U AS=174000000000P AD=182000000000P
+ PS=1390000U PD=1920000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $5 r0 *1 0.95,0.56 nfet_01v8
M$5 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 8 3 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21ai_1

* cell sky130_fd_sc_hd__o21a_2
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__o21a_2 1 3 4 5 6 7 8 10
* net 1 VPB
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=397500000000P
+ AD=537500000000P PS=3795000U PD=3075000U
* device instance $3 r0 *1 1.845,1.985 pfet_01v8_hvt
M$3 2 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=400000000000P
+ AD=140000000000P PS=1800000U PD=1280000U
* device instance $4 r0 *1 2.275,1.985 pfet_01v8_hvt
M$4 11 4 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=160000000000P PS=1280000U PD=1320000U
* device instance $5 r0 *1 2.745,1.985 pfet_01v8_hvt
M$5 7 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=265000000000P PS=1320000U PD=2530000U
* device instance $6 r0 *1 1.845,0.56 nfet_01v8
M$6 9 3 2 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $7 r0 *1 2.275,0.56 nfet_01v8
M$7 6 4 9 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=104000000000P
+ PS=930000U PD=970000U
* device instance $8 r0 *1 2.745,0.56 nfet_01v8
M$8 9 5 6 10 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=172250000000P
+ PS=970000U PD=1830000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 8 2 6 10 nfet_01v8 L=150000U W=1300000U AS=258375000000P AD=261625000000P
+ PS=2745000U PD=2755000U
.ENDS sky130_fd_sc_hd__o21a_2

* cell sky130_fd_sc_hd__dfstp_2
* pin VGND
* pin SET_B
* pin Q
* pin CLK
* pin D
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__dfstp_2 1 6 10 16 17 19 20 24
* net 1 VGND
* net 6 SET_B
* net 10 Q
* net 16 CLK
* net 17 D
* net 19 VPB
* net 20 VPWR
* device instance $1 r0 *1 8.345,1.985 pfet_01v8_hvt
M$1 20 8 9 19 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 8.765,1.985 pfet_01v8_hvt
M$2 10 9 20 19 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $4 r0 *1 6.905,2.275 pfet_01v8_hvt
M$4 8 6 20 19 pfet_01v8_hvt L=150000U W=420000U AS=120750000000P
+ AD=109200000000P PS=1165000U PD=1360000U
* device instance $5 r0 *1 7.38,2.065 pfet_01v8_hvt
M$5 18 8 20 19 pfet_01v8_hvt L=150000U W=840000U AS=120750000000P
+ AD=222600000000P PS=1165000U PD=2210000U
* device instance $6 r0 *1 0.47,2.135 pfet_01v8_hvt
M$6 20 16 2 19 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $7 r0 *1 0.89,2.135 pfet_01v8_hvt
M$7 3 2 20 19 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $8 r0 *1 1.83,2.065 pfet_01v8_hvt
M$8 4 17 20 19 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=124950000000P PS=2200000U PD=1175000U
* device instance $9 r0 *1 2.315,2.275 pfet_01v8_hvt
M$9 5 3 4 19 pfet_01v8_hvt L=150000U W=420000U AS=124950000000P AD=56700000000P
+ PS=1175000U PD=690000U
* device instance $10 r0 *1 2.735,2.275 pfet_01v8_hvt
M$10 21 2 5 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=94500000000P PS=690000U PD=870000U
* device instance $11 r0 *1 3.335,2.275 pfet_01v8_hvt
M$11 20 7 21 19 pfet_01v8_hvt L=150000U W=420000U AS=94500000000P
+ AD=79800000000P PS=870000U PD=800000U
* device instance $12 r0 *1 3.865,2.275 pfet_01v8_hvt
M$12 7 6 20 19 pfet_01v8_hvt L=150000U W=420000U AS=79800000000P
+ AD=56700000000P PS=800000U PD=690000U
* device instance $13 r0 *1 4.285,2.275 pfet_01v8_hvt
M$13 20 5 7 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $14 r0 *1 4.705,2.275 pfet_01v8_hvt
M$14 22 5 20 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=44100000000P PS=690000U PD=630000U
* device instance $15 r0 *1 5.065,2.275 pfet_01v8_hvt
M$15 8 2 22 19 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=81900000000P PS=630000U PD=810000U
* device instance $16 r0 *1 5.605,2.275 pfet_01v8_hvt
M$16 23 3 8 19 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P
+ AD=44100000000P PS=810000U PD=630000U
* device instance $17 r0 *1 5.965,2.275 pfet_01v8_hvt
M$17 20 18 23 19 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=109200000000P PS=630000U PD=1360000U
* device instance $18 r0 *1 8.345,0.56 nfet_01v8
M$18 1 8 9 24 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $19 r0 *1 8.765,0.56 nfet_01v8
M$19 10 9 1 24 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $21 r0 *1 2.305,0.415 nfet_01v8
M$21 5 2 4 24 nfet_01v8 L=150000U W=360000U AS=93500000000P AD=72000000000P
+ PS=965000U PD=760000U
* device instance $22 r0 *1 2.855,0.415 nfet_01v8
M$22 12 3 5 24 nfet_01v8 L=150000U W=360000U AS=72000000000P AD=67050000000P
+ PS=760000U PD=750000U
* device instance $23 r0 *1 3.335,0.445 nfet_01v8
M$23 1 7 12 24 nfet_01v8 L=150000U W=420000U AS=67050000000P AD=88200000000P
+ PS=750000U PD=840000U
* device instance $24 r0 *1 3.905,0.445 nfet_01v8
M$24 15 6 1 24 nfet_01v8 L=150000U W=420000U AS=88200000000P AD=44100000000P
+ PS=840000U PD=630000U
* device instance $25 r0 *1 4.265,0.445 nfet_01v8
M$25 7 5 15 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=109200000000P
+ PS=630000U PD=1360000U
* device instance $26 r0 *1 1.83,0.555 nfet_01v8
M$26 4 17 1 24 nfet_01v8 L=150000U W=640000U AS=166400000000P AD=93500000000P
+ PS=1800000U PD=965000U
* device instance $27 r0 *1 5.205,0.445 nfet_01v8
M$27 13 5 1 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $28 r0 *1 5.565,0.445 nfet_01v8
M$28 8 3 13 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=73500000000P
+ PS=630000U PD=770000U
* device instance $29 r0 *1 6.065,0.445 nfet_01v8
M$29 14 2 8 24 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=44100000000P
+ PS=770000U PD=630000U
* device instance $30 r0 *1 6.425,0.445 nfet_01v8
M$30 11 18 14 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $31 r0 *1 6.785,0.445 nfet_01v8
M$31 1 6 11 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=113700000000P
+ PS=630000U PD=1010000U
* device instance $32 r0 *1 7.405,0.505 nfet_01v8
M$32 18 8 1 24 nfet_01v8 L=150000U W=540000U AS=113700000000P AD=140400000000P
+ PS=1010000U PD=1600000U
* device instance $33 r0 *1 0.47,0.445 nfet_01v8
M$33 1 16 2 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $34 r0 *1 0.89,0.445 nfet_01v8
M$34 3 2 1 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dfstp_2

* cell sky130_fd_sc_hd__a211o_1
* pin VPB
* pin B1
* pin C1
* pin A1
* pin A2
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a211o_1 1 2 3 4 5 7 8 9 11
* net 1 VPB
* net 2 B1
* net 3 C1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 X
* net 9 VGND
* device instance $1 r0 *1 1.425,1.985 pfet_01v8_hvt
M$1 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.855,1.985 pfet_01v8_hvt
M$2 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 2.285,1.985 pfet_01v8_hvt
M$3 12 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 2.745,1.985 pfet_01v8_hvt
M$4 6 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.475,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=265000000000P PS=2530000U PD=2530000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 9 6 8 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=260000000000P
+ PS=1830000U PD=1450000U
* device instance $7 r0 *1 1.425,0.56 nfet_01v8
M$7 13 5 9 11 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=91000000000P
+ PS=1450000U PD=930000U
* device instance $8 r0 *1 1.855,0.56 nfet_01v8
M$8 6 4 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $9 r0 *1 2.285,0.56 nfet_01v8
M$9 9 2 6 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $10 r0 *1 2.745,0.56 nfet_01v8
M$10 6 3 9 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211o_1

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__and3b_1
* pin VPB
* pin C
* pin B
* pin A_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__and3b_1 1 2 3 5 7 8 9 10
* net 1 VPB
* net 2 C
* net 3 B
* net 5 A_N
* net 7 X
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 2.275,1.695 pfet_01v8_hvt
M$1 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=142225000000P
+ PS=815000U PD=1335000U
* device instance $2 r0 *1 1.38,1.765 pfet_01v8_hvt
M$2 9 4 6 1 pfet_01v8_hvt L=150000U W=420000U AS=108500000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 1.8,1.765 pfet_01v8_hvt
M$3 9 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 2.75,1.985 pfet_01v8_hvt
M$4 7 6 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,2.275 pfet_01v8_hvt
M$5 4 5 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=108700000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.405,0.475 nfet_01v8
M$6 12 4 6 10 nfet_01v8 L=150000U W=420000U AS=107825000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 1.765,0.475 nfet_01v8
M$7 11 3 12 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 2.17,0.475 nfet_01v8
M$8 11 2 8 10 nfet_01v8 L=150000U W=420000U AS=122275000000P AD=53550000000P
+ PS=1080000U PD=675000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 6 8 10 nfet_01v8 L=150000U W=650000U AS=122275000000P AD=169000000000P
+ PS=1080000U PD=1820000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=107850000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and3b_1

* cell sky130_fd_sc_hd__a2bb2oi_1
* pin VGND
* pin Y
* pin B2
* pin A1_N
* pin A2_N
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2bb2oi_1 1 3 4 5 6 7 10 11 13
* net 1 VGND
* net 3 Y
* net 4 B2
* net 5 A1_N
* net 6 A2_N
* net 7 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.91,1.985 pfet_01v8_hvt
M$1 9 2 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=340000000000P
+ AD=135000000000P PS=2680000U PD=1270000U
* device instance $2 r0 *1 2.33,1.985 pfet_01v8_hvt
M$2 10 4 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 12 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $5 r0 *1 0.83,1.985 pfet_01v8_hvt
M$5 2 6 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 5 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 1 6 2 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=282750000000P
+ PS=920000U PD=1520000U
* device instance $8 r0 *1 1.91,0.56 nfet_01v8
M$8 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=282750000000P AD=87750000000P
+ PS=1520000U PD=920000U
* device instance $9 r0 *1 2.33,0.56 nfet_01v8
M$9 8 4 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 1 7 8 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__a2bb2oi_1

* cell sky130_fd_sc_hd__or4_4
* pin VGND
* pin D
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or4_4 1 2 4 5 6 7 8 9 13
* net 1 VGND
* net 2 D
* net 4 X
* net 5 C
* net 6 B
* net 7 A
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 2 3 9 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=190000000000P PS=2520000U PD=1380000U
* device instance $2 r0 *1 1.025,1.985 pfet_01v8_hvt
M$2 12 5 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $3 r0 *1 1.445,1.985 pfet_01v8_hvt
M$3 11 6 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.865,1.985 pfet_01v8_hvt
M$4 8 7 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=190000000000P PS=1270000U PD=1380000U
* device instance $5 r0 *1 2.395,1.985 pfet_01v8_hvt
M$5 4 3 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=595000000000P
+ AD=675000000000P PS=5190000U PD=6350000U
* device instance $9 r0 *1 0.495,0.56 nfet_01v8
M$9 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=123500000000P
+ PS=1820000U PD=1030000U
* device instance $10 r0 *1 1.025,0.56 nfet_01v8
M$10 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=87750000000P
+ PS=1030000U PD=920000U
* device instance $11 r0 *1 1.445,0.56 nfet_01v8
M$11 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $12 r0 *1 1.865,0.56 nfet_01v8
M$12 1 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $13 r0 *1 2.395,0.56 nfet_01v8
M$13 4 3 1 13 nfet_01v8 L=150000U W=2600000U AS=386750000000P AD=442000000000P
+ PS=3790000U PD=4610000U
.ENDS sky130_fd_sc_hd__or4_4

* cell sky130_fd_sc_hd__inv_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__inv_8 1 2 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.635,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=8000000U AS=1.205e+12P AD=1.205e+12P
+ PS=11410000U PD=11410000U
* device instance $9 r0 *1 0.635,0.56 nfet_01v8
M$9 3 2 1 6 nfet_01v8 L=150000U W=5200000U AS=783250000000P AD=783250000000P
+ PS=8260000U PD=8260000U
.ENDS sky130_fd_sc_hd__inv_8

* cell sky130_fd_sc_hd__clkinv_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_8 1 3 4 5 6
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 4 5 pfet_01v8_hvt L=150000U W=12000000U AS=1.7475e+12P AD=1.7475e+12P
+ PS=16495000U PD=16495000U
* device instance $13 r0 *1 1.415,0.445 nfet_01v8
M$13 2 3 1 6 nfet_01v8 L=150000U W=3360000U AS=522900000000P AD=522900000000P
+ PS=6270000U PD=6270000U
.ENDS sky130_fd_sc_hd__clkinv_8

* cell sky130_fd_sc_hd__or3b_2
* pin VPB
* pin B
* pin A
* pin C_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or3b_2 1 2 3 5 6 8 9 10
* net 1 VPB
* net 2 B
* net 3 A
* net 5 C_N
* net 6 X
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 1.865,1.695 pfet_01v8_hvt
M$1 12 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=148250000000P AD=56700000000P
+ PS=1340000U PD=690000U
* device instance $2 r0 *1 2.285,1.695 pfet_01v8_hvt
M$2 11 2 12 1 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $3 r0 *1 2.705,1.695 pfet_01v8_hvt
M$3 7 4 11 1 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $4 r0 *1 0.47,2.01 pfet_01v8_hvt
M$4 4 5 9 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $5 r0 *1 0.955,1.985 pfet_01v8_hvt
M$5 6 7 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=280750000000P
+ AD=283250000000P PS=2605000U PD=2610000U
* device instance $7 r0 *1 0.47,0.445 nfet_01v8
M$7 8 5 4 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $8 r0 *1 1.865,0.475 nfet_01v8
M$8 7 3 8 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $9 r0 *1 2.285,0.475 nfet_01v8
M$9 8 2 7 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $10 r0 *1 2.705,0.475 nfet_01v8
M$10 7 4 8 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $11 r0 *1 0.955,0.56 nfet_01v8
M$11 6 7 8 10 nfet_01v8 L=150000U W=1300000U AS=188000000000P AD=189625000000P
+ PS=1905000U PD=1910000U
.ENDS sky130_fd_sc_hd__or3b_2

* cell sky130_fd_sc_hd__nor2b_4
* pin VGND
* pin Y
* pin A
* pin B_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_4 1 3 4 5 7 8 9
* net 1 VGND
* net 3 Y
* net 4 A
* net 5 B_N
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 4.4,1.985 pfet_01v8_hvt
M$1 7 5 2 8 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=280000000000P PS=2540000U PD=2560000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 7 4 6 8 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $6 r0 *1 2.17,1.985 pfet_01v8_hvt
M$6 3 2 6 8 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=685000000000P PS=5080000U PD=6370000U
* device instance $10 r0 *1 0.49,0.56 nfet_01v8
M$10 3 4 1 9 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $14 r0 *1 2.17,0.56 nfet_01v8
M$14 3 2 1 9 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $18 r0 *1 4.4,0.56 nfet_01v8
M$18 1 5 2 9 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=175500000000P
+ PS=1860000U PD=1840000U
.ENDS sky130_fd_sc_hd__nor2b_4

* cell sky130_fd_sc_hd__nand3_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_2 1 3 5 6 7 8 9 10
* net 1 VGND
* net 3 Y
* net 5 A
* net 6 B
* net 7 C
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 3 7 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=445000000000P PS=3790000U PD=3890000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 3 6 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $7 r0 *1 2.67,0.56 nfet_01v8
M$7 4 7 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=289250000000P
+ PS=2740000U PD=2840000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 5 2 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.31,0.56 nfet_01v8
M$11 4 6 2 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand3_2

* cell sky130_fd_sc_hd__and3_2
* pin VPB
* pin A
* pin B
* pin C
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and3_2 1 2 3 4 6 7 8 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 1.375,1.695 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=150750000000P
+ PS=815000U PD=1345000U
* device instance $2 r0 *1 0.48,1.765 pfet_01v8_hvt
M$2 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 0.9,1.765 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 1.87,1.985 pfet_01v8_hvt
M$4 8 5 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=285750000000P
+ AD=395000000000P PS=2615000U PD=3790000U
* device instance $6 r0 *1 0.485,0.475 nfet_01v8
M$6 11 2 5 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 0.845,0.475 nfet_01v8
M$7 10 3 11 9 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 1.25,0.475 nfet_01v8
M$8 10 4 6 9 nfet_01v8 L=150000U W=420000U AS=130400000000P AD=53550000000P
+ PS=1105000U PD=675000U
* device instance $9 r0 *1 1.855,0.56 nfet_01v8
M$9 8 5 6 9 nfet_01v8 L=150000U W=1300000U AS=218150000000P AD=266500000000P
+ PS=2025000U PD=2770000U
.ENDS sky130_fd_sc_hd__and3_2

* cell sky130_fd_sc_hd__nor4b_4
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_4 1 3 4 6 7 8 9 12 13
* net 1 VGND
* net 3 Y
* net 4 A
* net 6 B
* net 7 C
* net 8 D_N
* net 9 VPWR
* net 12 VPB
* device instance $1 r0 *1 8.23,1.985 pfet_01v8_hvt
M$1 9 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=280000000000P PS=2520000U PD=2560000U
* device instance $2 r0 *1 4.35,1.985 pfet_01v8_hvt
M$2 10 7 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $6 r0 *1 6.03,1.985 pfet_01v8_hvt
M$6 3 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $10 r0 *1 0.47,1.985 pfet_01v8_hvt
M$10 9 4 5 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $14 r0 *1 2.15,1.985 pfet_01v8_hvt
M$14 10 6 5 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $18 r0 *1 0.47,0.56 nfet_01v8
M$18 3 4 1 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $22 r0 *1 2.15,0.56 nfet_01v8
M$22 3 6 1 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $26 r0 *1 4.35,0.56 nfet_01v8
M$26 3 7 1 13 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $30 r0 *1 6.03,0.56 nfet_01v8
M$30 3 2 1 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $34 r0 *1 8.23,0.56 nfet_01v8
M$34 1 8 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=182000000000P
+ PS=1820000U PD=1860000U
.ENDS sky130_fd_sc_hd__nor4b_4

* cell sky130_fd_sc_hd__or2_2
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or2_2 1 2 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 4 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.53,1.695 pfet_01v8_hvt
M$1 9 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.89,1.695 pfet_01v8_hvt
M$2 6 2 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=155750000000P
+ PS=630000U PD=1355000U
* device instance $3 r0 *1 1.395,1.985 pfet_01v8_hvt
M$3 5 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=290750000000P
+ AD=395000000000P PS=2625000U PD=3790000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 3 4 7 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.89,0.445 nfet_01v8
M$6 7 2 3 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=106750000000P
+ PS=690000U PD=1005000U
* device instance $7 r0 *1 1.395,0.56 nfet_01v8
M$7 5 3 7 8 nfet_01v8 L=150000U W=1300000U AS=194500000000P AD=256750000000P
+ PS=1925000U PD=2740000U
.ENDS sky130_fd_sc_hd__or2_2

* cell sky130_fd_sc_hd__nor3_4
* pin VGND
* pin A
* pin Y
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3_4 1 2 3 4 5 7 9 10
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 B
* net 5 C
* net 7 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 7 2 6 9 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $5 r0 *1 2.17,1.985 pfet_01v8_hvt
M$5 8 4 6 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $8 r0 *1 3.43,1.985 pfet_01v8_hvt
M$8 3 5 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 3 2 1 10 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $17 r0 *1 2.17,0.56 nfet_01v8
M$17 3 4 1 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $20 r0 *1 3.43,0.56 nfet_01v8
M$20 1 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
.ENDS sky130_fd_sc_hd__nor3_4

* cell sky130_fd_sc_hd__o41a_1
* pin VGND
* pin X
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o41a_1 1 2 5 6 7 8 9 10 11 15
* net 1 VGND
* net 2 X
* net 5 B1
* net 6 A4
* net 7 A3
* net 8 A2
* net 9 A1
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 0.8,1.985 pfet_01v8_hvt
M$1 11 3 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=425000000000P
+ AD=135000000000P PS=2850000U PD=1270000U
* device instance $2 r0 *1 1.22,1.985 pfet_01v8_hvt
M$2 3 5 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=1520000U
* device instance $3 r0 *1 1.89,1.985 pfet_01v8_hvt
M$3 12 6 3 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=220000000000P PS=1520000U PD=1440000U
* device instance $4 r0 *1 2.48,1.985 pfet_01v8_hvt
M$4 13 7 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=220000000000P
+ AD=195000000000P PS=1440000U PD=1390000U
* device instance $5 r0 *1 3.02,1.985 pfet_01v8_hvt
M$5 14 8 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $6 r0 *1 3.56,1.985 pfet_01v8_hvt
M$6 11 9 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $7 r0 *1 1.53,0.56 nfet_01v8
M$7 4 5 3 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 1.95,0.56 nfet_01v8
M$8 1 6 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $9 r0 *1 2.48,0.56 nfet_01v8
M$9 4 7 1 15 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=126750000000P
+ PS=1030000U PD=1040000U
* device instance $10 r0 *1 3.02,0.56 nfet_01v8
M$10 1 8 4 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 3.56,0.56 nfet_01v8
M$11 4 9 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=195000000000P
+ PS=1040000U PD=1900000U
* device instance $12 r0 *1 0.59,0.56 nfet_01v8
M$12 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=247000000000P AD=169000000000P
+ PS=2060000U PD=1820000U
.ENDS sky130_fd_sc_hd__o41a_1

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__a32oi_1
* pin VPB
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a32oi_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A3
* net 5 A2
* net 6 A1
* net 8 Y
* net 9 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=215000000000P PS=1270000U PD=1430000U
* device instance $3 r0 *1 1.47,1.985 pfet_01v8_hvt
M$3 10 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=135000000000P PS=1430000U PD=1270000U
* device instance $4 r0 *1 1.89,1.985 pfet_01v8_hvt
M$4 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=140000000000P PS=1270000U PD=1280000U
* device instance $5 r0 *1 2.32,1.985 pfet_01v8_hvt
M$5 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=260000000000P PS=1280000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $7 r0 *1 0.85,0.56 nfet_01v8
M$7 8 3 14 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=152750000000P
+ PS=880000U PD=1120000U
* device instance $8 r0 *1 1.47,0.56 nfet_01v8
M$8 12 6 8 11 nfet_01v8 L=150000U W=650000U AS=152750000000P AD=71500000000P
+ PS=1120000U PD=870000U
* device instance $9 r0 *1 1.84,0.56 nfet_01v8
M$9 13 5 12 11 nfet_01v8 L=150000U W=650000U AS=71500000000P AD=107250000000P
+ PS=870000U PD=980000U
* device instance $10 r0 *1 2.32,0.56 nfet_01v8
M$10 9 4 13 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a32oi_1

* cell sky130_fd_sc_hd__or4_1
* pin VPB
* pin A
* pin B
* pin C
* pin D
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or4_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 D
* net 7 X
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 13 5 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $2 r0 *1 0.95,1.695 pfet_01v8_hvt
M$2 12 4 13 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $3 r0 *1 1.31,1.695 pfet_01v8_hvt
M$3 11 3 12 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $4 r0 *1 1.79,1.695 pfet_01v8_hvt
M$4 8 2 11 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $5 r0 *1 2.28,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=270000000000P PS=1340000U PD=2540000U
* device instance $6 r0 *1 0.47,0.475 nfet_01v8
M$6 6 5 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $7 r0 *1 0.95,0.475 nfet_01v8
M$7 9 4 6 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $8 r0 *1 1.37,0.475 nfet_01v8
M$8 6 3 9 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $9 r0 *1 1.79,0.475 nfet_01v8
M$9 6 2 9 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $10 r0 *1 2.28,0.56 nfet_01v8
M$10 7 6 9 10 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=175500000000P
+ PS=990000U PD=1840000U
.ENDS sky130_fd_sc_hd__or4_1

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__o21ai_2
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_2 1 2 3 4 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 7 VGND
* net 8 Y
* net 9 VPWR
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 6 2 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=440000000000P
+ AD=300000000000P PS=3880000U PD=2600000U
* device instance $2 r0 *1 0.915,1.985 pfet_01v8_hvt
M$2 8 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=315000000000P PS=2560000U PD=2630000U
* device instance $5 r0 *1 2.315,1.985 pfet_01v8_hvt
M$5 8 4 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=405000000000P PS=2600000U PD=3810000U
* device instance $7 r0 *1 0.485,0.56 nfet_01v8
M$7 7 2 5 10 nfet_01v8 L=150000U W=1300000U AS=299000000000P AD=182000000000P
+ PS=2870000U PD=1860000U
* device instance $8 r0 *1 0.915,0.56 nfet_01v8
M$8 5 3 7 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=217750000000P
+ PS=1860000U PD=1970000U
* device instance $11 r0 *1 2.315,0.56 nfet_01v8
M$11 8 4 5 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__o21ai_2

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__buf_2
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_2 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.125 pfet_01v8_hvt
M$1 2 3 6 1 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P AD=166400000000P
+ PS=1325000U PD=1800000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=284000000000P
+ AD=400000000000P PS=2595000U PD=3800000U
* device instance $4 r0 *1 0.47,0.445 nfet_01v8
M$4 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $5 r0 *1 0.945,0.56 nfet_01v8
M$5 5 2 4 7 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=260000000000P
+ PS=1895000U PD=2750000U
.ENDS sky130_fd_sc_hd__buf_2

* cell sky130_fd_sc_hd__o22a_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22a_1 1 2 3 4 5 6 7 10 11
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 6 X
* net 7 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=372500000000P PS=2560000U PD=1745000U
* device instance $2 r0 *1 1.385,1.985 pfet_01v8_hvt
M$2 13 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=372500000000P
+ AD=117500000000P PS=1745000U PD=1235000U
* device instance $3 r0 *1 1.77,1.985 pfet_01v8_hvt
M$3 8 3 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=117500000000P
+ AD=235000000000P PS=1235000U PD=1470000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=235000000000P
+ AD=105000000000P PS=1470000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 8 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.83,0.56 nfet_01v8
M$7 9 3 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 7 4 9 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=87750000000P
+ PS=1000000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 9 5 7 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 7 8 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22a_1

* cell sky130_fd_sc_hd__a311oi_1
* pin VPB
* pin A3
* pin A2
* pin B1
* pin A1
* pin C1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_1 1 2 3 4 5 6 7 9 10 11
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 B1
* net 5 A1
* net 6 C1
* net 7 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 0.895,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 1.325,1.985 pfet_01v8_hvt
M$3 8 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=165000000000P PS=1280000U PD=1330000U
* device instance $4 r0 *1 1.805,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=172500000000P PS=1330000U PD=1345000U
* device instance $5 r0 *1 2.3,1.985 pfet_01v8_hvt
M$5 9 6 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=260000000000P PS=1345000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 10 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=89375000000P
+ PS=1820000U PD=925000U
* device instance $7 r0 *1 0.895,0.56 nfet_01v8
M$7 13 3 14 11 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 1.325,0.56 nfet_01v8
M$8 9 5 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=115375000000P
+ PS=930000U PD=1005000U
* device instance $9 r0 *1 1.83,0.56 nfet_01v8
M$9 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=112125000000P
+ PS=1005000U PD=995000U
* device instance $10 r0 *1 2.325,0.56 nfet_01v8
M$10 9 6 10 11 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=169000000000P
+ PS=995000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311oi_1

* cell sky130_fd_sc_hd__clkinv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.47,2.065 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1680000U AS=331800000000P
+ AD=348600000000P PS=3310000U PD=3350000U
* device instance $3 r0 *1 0.885,0.445 nfet_01v8
M$3 4 2 5 6 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=119700000000P
+ PS=1360000U PD=1410000U
.ENDS sky130_fd_sc_hd__clkinv_1

* cell sky130_fd_sc_hd__inv_6
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__inv_6 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 3 2 4 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.105e+12P AD=945000000000P
+ PS=9210000U PD=8890000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 3 2 5 6 nfet_01v8 L=150000U W=3900000U AS=685750000000P AD=614250000000P
+ PS=6660000U PD=6440000U
.ENDS sky130_fd_sc_hd__inv_6

* cell sky130_fd_sc_hd__clkinvlp_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinvlp_4 1 2 3 4 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.525,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=250000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 0.475,0.51 nfet_01v8
M$5 8 2 4 6 nfet_01v8 L=150000U W=550000U AS=145750000000P AD=57750000000P
+ PS=1630000U PD=760000U
* device instance $6 r0 *1 0.835,0.51 nfet_01v8
M$6 5 2 8 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=77000000000P
+ PS=760000U PD=830000U
* device instance $7 r0 *1 1.265,0.51 nfet_01v8
M$7 7 2 5 6 nfet_01v8 L=150000U W=550000U AS=77000000000P AD=57750000000P
+ PS=830000U PD=760000U
* device instance $8 r0 *1 1.625,0.51 nfet_01v8
M$8 4 2 7 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=145750000000P
+ PS=760000U PD=1630000U
.ENDS sky130_fd_sc_hd__clkinvlp_4

* cell sky130_fd_sc_hd__or3_1
* pin VPB
* pin A
* pin B
* pin C
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.48,1.695 pfet_01v8_hvt
M$1 11 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.84,1.695 pfet_01v8_hvt
M$2 10 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $3 r0 *1 1.32,1.695 pfet_01v8_hvt
M$3 6 2 10 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $4 r0 *1 1.81,1.985 pfet_01v8_hvt
M$4 5 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=280000000000P PS=1340000U PD=2560000U
* device instance $5 r0 *1 0.48,0.475 nfet_01v8
M$5 7 4 8 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.9,0.475 nfet_01v8
M$6 8 3 7 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $7 r0 *1 1.32,0.475 nfet_01v8
M$7 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $8 r0 *1 1.81,0.56 nfet_01v8
M$8 5 8 7 9 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=182000000000P
+ PS=990000U PD=1860000U
.ENDS sky130_fd_sc_hd__or3_1

* cell sky130_fd_sc_hd__mux2_2
* pin VGND
* pin X
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_2 1 2 4 5 6 10 11 14
* net 1 VGND
* net 2 X
* net 4 A0
* net 5 A1
* net 6 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=312800000000P PS=3790000U PD=2685000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 12 9 10 11 pfet_01v8_hvt L=150000U W=640000U AS=177800000000P
+ AD=228800000000P PS=1415000U PD=1355000U
* device instance $4 r0 *1 2.32,2.165 pfet_01v8_hvt
M$4 3 5 12 11 pfet_01v8_hvt L=150000U W=640000U AS=228800000000P
+ AD=131200000000P PS=1355000U PD=1050000U
* device instance $5 r0 *1 2.88,2.165 pfet_01v8_hvt
M$5 13 4 3 11 pfet_01v8_hvt L=150000U W=640000U AS=131200000000P
+ AD=67200000000P PS=1050000U PD=850000U
* device instance $6 r0 *1 3.24,2.165 pfet_01v8_hvt
M$6 10 6 13 11 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=86400000000P PS=850000U PD=910000U
* device instance $7 r0 *1 3.66,2.165 pfet_01v8_hvt
M$7 9 6 10 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=172800000000P PS=910000U PD=1820000U
* device instance $8 r0 *1 1.365,0.445 nfet_01v8
M$8 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=68250000000P
+ PS=975000U PD=745000U
* device instance $9 r0 *1 1.84,0.445 nfet_01v8
M$9 3 4 7 14 nfet_01v8 L=150000U W=420000U AS=68250000000P AD=173250000000P
+ PS=745000U PD=1245000U
* device instance $10 r0 *1 2.815,0.445 nfet_01v8
M$10 8 5 3 14 nfet_01v8 L=150000U W=420000U AS=173250000000P AD=57750000000P
+ PS=1245000U PD=695000U
* device instance $11 r0 *1 3.24,0.445 nfet_01v8
M$11 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=57750000000P AD=56700000000P
+ PS=695000U PD=690000U
* device instance $12 r0 *1 3.66,0.445 nfet_01v8
M$12 9 6 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=113400000000P
+ PS=690000U PD=1380000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 2 3 1 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=184750000000P
+ PS=2740000U PD=1895000U
.ENDS sky130_fd_sc_hd__mux2_2

* cell sky130_fd_sc_hd__a221oi_1
* pin VGND
* pin Y
* pin B1
* pin A1
* pin C1
* pin B2
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_1 1 2 3 4 5 6 7 10 11 14
* net 1 VGND
* net 2 Y
* net 3 B1
* net 4 A1
* net 5 C1
* net 6 B2
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 13 4 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=152500000000P PS=2520000U PD=1305000U
* device instance $2 r0 *1 2.705,1.985 pfet_01v8_hvt
M$2 11 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=305000000000P PS=1305000U PD=2610000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 12 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 13 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 12 3 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 2.25,0.56 nfet_01v8
M$6 9 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=99125000000P
+ PS=1820000U PD=955000U
* device instance $7 r0 *1 2.705,0.56 nfet_01v8
M$7 1 7 9 14 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=198250000000P
+ PS=955000U PD=1910000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $9 r0 *1 0.945,0.56 nfet_01v8
M$9 8 6 1 14 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=69875000000P
+ PS=975000U PD=865000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 2 3 8 14 nfet_01v8 L=150000U W=650000U AS=69875000000P AD=169000000000P
+ PS=865000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221oi_1

* cell sky130_fd_sc_hd__a22oi_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=300000000000P PS=1270000U PD=2600000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 1.83,0.56 nfet_01v8
M$5 11 4 8 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 2.19,0.56 nfet_01v8
M$6 9 5 11 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=234000000000P
+ PS=860000U PD=2020000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 12 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 3 12 10 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22oi_1

* cell sky130_fd_sc_hd__clkdlybuf4s50_1
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkdlybuf4s50_1 1 2 4 7 8 9
* net 1 VPB
* net 2 A
* net 4 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 2.465,2.075 pfet_01v8_hvt
M$1 6 5 7 1 pfet_01v8_hvt L=500000U W=820000U AS=155750000000P AD=217300000000P
+ PS=1325000U PD=2170000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=155750000000P
+ AD=355000000000P PS=1325000U PD=2710000U
* device instance $3 r0 *1 0.48,1.985 pfet_01v8_hvt
M$3 7 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=170100000000P PS=2540000U PD=1360000U
* device instance $4 r0 *1 1.165,2.075 pfet_01v8_hvt
M$4 5 3 7 1 pfet_01v8_hvt L=500000U W=820000U AS=170100000000P AD=217300000000P
+ PS=1360000U PD=2170000U
* device instance $5 r0 *1 3.115,0.445 nfet_01v8
M$5 8 6 4 9 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=149100000000P
+ PS=975000U PD=1550000U
* device instance $6 r0 *1 2.465,0.56 nfet_01v8
M$6 4 5 6 9 nfet_01v8 L=500000U W=650000U AS=172250000000P AD=97000000000P
+ PS=1830000U PD=975000U
* device instance $7 r0 *1 0.48,0.445 nfet_01v8
M$7 4 2 3 9 nfet_01v8 L=150000U W=420000U AS=113400000000P AD=104350000000P
+ PS=1380000U PD=1010000U
* device instance $8 r0 *1 1.165,0.56 nfet_01v8
M$8 5 3 4 9 nfet_01v8 L=500000U W=650000U AS=104350000000P AD=169000000000P
+ PS=1010000U PD=1820000U
.ENDS sky130_fd_sc_hd__clkdlybuf4s50_1

* cell sky130_fd_sc_hd__clkbuf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_16 1 3 4 5 6 7
* net 1 VGND
* net 3 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $5 r0 *1 2.195,1.985 pfet_01v8_hvt
M$5 4 2 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.2375e+12P AD=2.3625e+12P
+ PS=20475000U PD=21725000U
* device instance $21 r0 *1 0.475,0.445 nfet_01v8
M$21 2 3 1 7 nfet_01v8 L=150000U W=1680000U AS=287700000000P AD=235200000000P
+ PS=3470000U PD=2800000U
* device instance $25 r0 *1 2.195,0.445 nfet_01v8
M$25 4 2 1 7 nfet_01v8 L=150000U W=6720000U AS=939750000000P AD=992250000000P
+ PS=11195000U PD=11865000U
.ENDS sky130_fd_sc_hd__clkbuf_16

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 2.64,0.415 nfet_01v8
M$16 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $17 r0 *1 3.12,0.415 nfet_01v8
M$17 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $18 r0 *1 5.465,0.415 nfet_01v8
M$18 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $19 r0 *1 6.01,0.415 nfet_01v8
M$19 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $20 r0 *1 2.165,0.445 nfet_01v8
M$20 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $21 r0 *1 3.95,0.445 nfet_01v8
M$21 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $22 r0 *1 4.31,0.445 nfet_01v8
M$22 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $23 r0 *1 6.49,0.445 nfet_01v8
M$23 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $24 r0 *1 7.235,0.445 nfet_01v8
M$24 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $25 r0 *1 7.69,0.445 nfet_01v8
M$25 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $26 r0 *1 4.97,0.555 nfet_01v8
M$26 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
* device instance $27 r0 *1 0.47,0.445 nfet_01v8
M$27 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $28 r0 *1 0.89,0.445 nfet_01v8
M$28 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__edfxtp_1
* pin VGND
* pin DE
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__edfxtp_1 1 5 11 17 18 19 20 26
* net 1 VGND
* net 5 DE
* net 11 Q
* net 17 CLK
* net 18 D
* net 19 VPWR
* net 20 VPB
* device instance $1 r0 *1 9.925,2.165 pfet_01v8_hvt
M$1 7 10 19 20 pfet_01v8_hvt L=150000U W=640000U AS=154000000000P
+ AD=172800000000P PS=1335000U PD=1820000U
* device instance $2 r0 *1 10.41,1.985 pfet_01v8_hvt
M$2 11 10 19 20 pfet_01v8_hvt L=150000U W=1000000U AS=154000000000P
+ AD=280000000000P PS=1335000U PD=2560000U
* device instance $3 r0 *1 7.425,2.275 pfet_01v8_hvt
M$3 24 9 19 20 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=64050000000P PS=1360000U PD=725000U
* device instance $4 r0 *1 7.88,2.275 pfet_01v8_hvt
M$4 10 2 24 20 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P
+ AD=56700000000P PS=725000U PD=690000U
* device instance $5 r0 *1 8.3,2.275 pfet_01v8_hvt
M$5 25 3 10 20 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=88200000000P PS=690000U PD=840000U
* device instance $6 r0 *1 8.87,2.275 pfet_01v8_hvt
M$6 19 7 25 20 pfet_01v8_hvt L=150000U W=420000U AS=88200000000P
+ AD=111300000000P PS=840000U PD=1370000U
* device instance $7 r0 *1 1.83,2.165 pfet_01v8_hvt
M$7 21 18 4 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=67200000000P PS=1800000U PD=850000U
* device instance $8 r0 *1 2.19,2.165 pfet_01v8_hvt
M$8 19 6 21 20 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=166400000000P PS=850000U PD=1800000U
* device instance $9 r0 *1 0.47,2.135 pfet_01v8_hvt
M$9 19 17 2 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $10 r0 *1 0.89,2.135 pfet_01v8_hvt
M$10 3 2 19 20 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $11 r0 *1 3.13,2.165 pfet_01v8_hvt
M$11 19 5 6 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=92800000000P PS=1800000U PD=930000U
* device instance $12 r0 *1 3.57,2.165 pfet_01v8_hvt
M$12 22 5 19 20 pfet_01v8_hvt L=150000U W=640000U AS=92800000000P
+ AD=115200000000P PS=930000U PD=1000000U
* device instance $13 r0 *1 4.08,2.165 pfet_01v8_hvt
M$13 4 7 22 20 pfet_01v8_hvt L=150000U W=640000U AS=115200000000P
+ AD=159850000000P PS=1000000U PD=1265000U
* device instance $14 r0 *1 4.855,2.275 pfet_01v8_hvt
M$14 8 3 4 20 pfet_01v8_hvt L=150000U W=420000U AS=159850000000P
+ AD=64050000000P PS=1265000U PD=725000U
* device instance $15 r0 *1 5.31,2.275 pfet_01v8_hvt
M$15 23 2 8 20 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P
+ AD=76650000000P PS=725000U PD=785000U
* device instance $16 r0 *1 5.825,2.275 pfet_01v8_hvt
M$16 23 9 19 20 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=76650000000P PS=1260000U PD=785000U
* device instance $17 r0 *1 6.485,2.11 pfet_01v8_hvt
M$17 9 8 19 20 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=195000000000P PS=1260000U PD=2020000U
* device instance $18 r0 *1 9.925,0.445 nfet_01v8
M$18 1 10 7 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $19 r0 *1 10.41,0.56 nfet_01v8
M$19 11 10 1 26 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=182000000000P
+ PS=985000U PD=1860000U
* device instance $20 r0 *1 7.98,0.415 nfet_01v8
M$20 10 3 15 26 nfet_01v8 L=150000U W=360000U AS=67800000000P AD=68400000000P
+ PS=755000U PD=740000U
* device instance $21 r0 *1 8.51,0.415 nfet_01v8
M$21 13 2 10 26 nfet_01v8 L=150000U W=360000U AS=68400000000P AD=66000000000P
+ PS=740000U PD=745000U
* device instance $22 r0 *1 7.495,0.445 nfet_01v8
M$22 15 9 1 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=67800000000P
+ PS=1360000U PD=755000U
* device instance $23 r0 *1 8.985,0.445 nfet_01v8
M$23 1 7 13 26 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=109200000000P
+ PS=745000U PD=1360000U
* device instance $24 r0 *1 0.47,0.445 nfet_01v8
M$24 1 17 2 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $25 r0 *1 0.89,0.445 nfet_01v8
M$25 3 2 1 26 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $26 r0 *1 1.83,0.445 nfet_01v8
M$26 12 18 4 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $27 r0 *1 2.19,0.445 nfet_01v8
M$27 1 5 12 26 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=109200000000P
+ PS=630000U PD=1360000U
* device instance $28 r0 *1 4.99,0.415 nfet_01v8
M$28 8 2 4 26 nfet_01v8 L=150000U W=360000U AS=144600000000P AD=52200000000P
+ PS=1180000U PD=650000U
* device instance $29 r0 *1 5.43,0.415 nfet_01v8
M$29 16 3 8 26 nfet_01v8 L=150000U W=360000U AS=52200000000P AD=75900000000P
+ PS=650000U PD=800000U
* device instance $30 r0 *1 3.13,0.445 nfet_01v8
M$30 1 5 6 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $31 r0 *1 3.57,0.445 nfet_01v8
M$31 14 6 1 26 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=75600000000P
+ PS=710000U PD=780000U
* device instance $32 r0 *1 4.08,0.445 nfet_01v8
M$32 4 7 14 26 nfet_01v8 L=150000U W=420000U AS=75600000000P AD=144600000000P
+ PS=780000U PD=1180000U
* device instance $33 r0 *1 5.96,0.445 nfet_01v8
M$33 1 9 16 26 nfet_01v8 L=150000U W=420000U AS=75900000000P AD=120950000000P
+ PS=800000U PD=1085000U
* device instance $34 r0 *1 6.555,0.555 nfet_01v8
M$34 9 8 1 26 nfet_01v8 L=150000U W=640000U AS=120950000000P AD=166400000000P
+ PS=1085000U PD=1800000U
.ENDS sky130_fd_sc_hd__edfxtp_1

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4

* cell sky130_fd_sc_hd__ha_1
* pin VGND
* pin SUM
* pin COUT
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_1 1 2 5 8 9 10 11 13
* net 1 VGND
* net 2 SUM
* net 5 COUT
* net 8 A
* net 9 B
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=236050000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,2.275 pfet_01v8_hvt
M$2 3 7 10 11 pfet_01v8_hvt L=150000U W=420000U AS=236050000000P
+ AD=56700000000P PS=1765000U PD=690000U
* device instance $3 r0 *1 1.805,2.275 pfet_01v8_hvt
M$3 12 9 3 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=84000000000P
+ PS=690000U PD=820000U
* device instance $4 r0 *1 2.355,2.275 pfet_01v8_hvt
M$4 10 8 12 11 pfet_01v8_hvt L=150000U W=420000U AS=84000000000P
+ AD=149100000000P PS=820000U PD=1130000U
* device instance $5 r0 *1 3.215,2.275 pfet_01v8_hvt
M$5 7 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=149100000000P
+ AD=60900000000P PS=1130000U PD=710000U
* device instance $6 r0 *1 3.655,2.275 pfet_01v8_hvt
M$6 7 8 10 11 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=60900000000P PS=1325000U PD=710000U
* device instance $7 r0 *1 4.13,1.985 pfet_01v8_hvt
M$7 5 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $8 r0 *1 3.295,0.445 nfet_01v8
M$8 6 9 7 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 3.655,0.445 nfet_01v8
M$9 1 8 6 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $10 r0 *1 4.13,0.56 nfet_01v8
M$10 5 7 1 13 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 0.47,0.56 nfet_01v8
M$11 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $12 r0 *1 1.41,0.445 nfet_01v8
M$12 4 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $13 r0 *1 1.83,0.445 nfet_01v8
M$13 1 9 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $14 r0 *1 2.25,0.445 nfet_01v8
M$14 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__ha_1

* cell sky130_fd_sc_hd__o21bai_1
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21bai_1 1 2 4 5 7 8 9 10
* net 1 VPB
* net 2 B1_N
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 VGND
* net 9 Y
* device instance $1 r0 *1 0.86,1.97 pfet_01v8_hvt
M$1 3 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=178250000000P AD=109200000000P
+ PS=1400000U PD=1360000U
* device instance $2 r0 *1 1.41,1.985 pfet_01v8_hvt
M$2 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=178250000000P
+ AD=152500000000P PS=1400000U PD=1305000U
* device instance $3 r0 *1 1.865,1.985 pfet_01v8_hvt
M$3 11 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=127500000000P PS=1305000U PD=1255000U
* device instance $4 r0 *1 2.27,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=127500000000P
+ AD=280000000000P PS=1255000U PD=2560000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 5 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.675 nfet_01v8
M$8 3 2 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__o21bai_1

* cell sky130_fd_sc_hd__a221oi_2
* pin VGND
* pin C1
* pin Y
* pin B2
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_2 1 2 3 4 6 7 9 10 11 14
* net 1 VGND
* net 2 C1
* net 3 Y
* net 4 B2
* net 6 B1
* net 7 A2
* net 9 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.84,1.985 pfet_01v8_hvt
M$1 12 4 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=310000000000P PS=3790000U PD=2620000U
* device instance $2 r0 *1 2.26,1.985 pfet_01v8_hvt
M$2 13 6 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 3.6,1.985 pfet_01v8_hvt
M$5 10 7 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $6 r0 *1 4.02,1.985 pfet_01v8_hvt
M$6 13 9 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 0.48,1.985 pfet_01v8_hvt
M$9 3 2 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=395000000000P PS=3810000U PD=3790000U
* device instance $11 r0 *1 0.48,0.56 nfet_01v8
M$11 3 2 1 14 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=344500000000P
+ PS=2760000U PD=2360000U
* device instance $13 r0 *1 1.84,0.56 nfet_01v8
M$13 5 4 1 14 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=201500000000P
+ PS=2360000U PD=1920000U
* device instance $14 r0 *1 2.26,0.56 nfet_01v8
M$14 3 6 5 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 3.6,0.56 nfet_01v8
M$17 8 7 1 14 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $18 r0 *1 4.02,0.56 nfet_01v8
M$18 3 9 8 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
.ENDS sky130_fd_sc_hd__a221oi_2

* cell sky130_fd_sc_hd__a2111oi_0
* pin VGND
* pin D1
* pin Y
* pin A1
* pin C1
* pin B1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_0 1 2 3 4 6 7 8 9 10 14
* net 1 VGND
* net 2 D1
* net 3 Y
* net 4 A1
* net 6 C1
* net 7 B1
* net 8 A2
* net 9 VPB
* net 10 VPWR
* device instance $1 r0 *1 0.77,2.165 pfet_01v8_hvt
M$1 12 2 3 9 pfet_01v8_hvt L=150000U W=640000U AS=188800000000P AD=67200000000P
+ PS=1870000U PD=850000U
* device instance $2 r0 *1 1.13,2.165 pfet_01v8_hvt
M$2 13 6 12 9 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P AD=67200000000P
+ PS=850000U PD=850000U
* device instance $3 r0 *1 1.49,2.165 pfet_01v8_hvt
M$3 11 7 13 9 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P AD=89600000000P
+ PS=850000U PD=920000U
* device instance $4 r0 *1 1.92,2.165 pfet_01v8_hvt
M$4 10 4 11 9 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P
+ AD=121600000000P PS=920000U PD=1020000U
* device instance $5 r0 *1 2.45,2.165 pfet_01v8_hvt
M$5 11 8 10 9 pfet_01v8_hvt L=150000U W=640000U AS=121600000000P
+ AD=195200000000P PS=1020000U PD=1890000U
* device instance $6 r0 *1 0.7,0.445 nfet_01v8
M$6 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=126000000000P AD=58800000000P
+ PS=1440000U PD=700000U
* device instance $7 r0 *1 1.13,0.445 nfet_01v8
M$7 1 6 3 14 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=73500000000P
+ PS=700000U PD=770000U
* device instance $8 r0 *1 1.63,0.445 nfet_01v8
M$8 3 7 1 14 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=58800000000P
+ PS=770000U PD=700000U
* device instance $9 r0 *1 2.06,0.445 nfet_01v8
M$9 5 4 3 14 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=44100000000P
+ PS=700000U PD=630000U
* device instance $10 r0 *1 2.42,0.445 nfet_01v8
M$10 1 8 5 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=119700000000P
+ PS=630000U PD=1410000U
.ENDS sky130_fd_sc_hd__a2111oi_0

* cell sky130_fd_sc_hd__nor4_1
* pin VPB
* pin D
* pin B
* pin A
* pin C
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 D
* net 3 B
* net 4 A
* net 5 C
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=130000000000P PS=2520000U PD=1260000U
* device instance $2 r0 *1 0.88,1.985 pfet_01v8_hvt
M$2 10 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=130000000000P
+ AD=190000000000P PS=1260000U PD=1380000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 12 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 8 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=118625000000P
+ PS=1820000U PD=1015000U
* device instance $6 r0 *1 0.985,0.56 nfet_01v8
M$6 6 5 7 9 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=89375000000P
+ PS=1015000U PD=925000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 7 3 6 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=87750000000P
+ PS=925000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor4_1

* cell sky130_fd_sc_hd__xnor2_1
* pin VPB
* pin B
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_1 1 2 3 4 5 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 Y
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.51,1.985 pfet_01v8_hvt
M$1 8 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=135000000000P PS=2600000U PD=1270000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=365000000000P PS=1270000U PD=1730000U
* device instance $3 r0 *1 1.81,1.985 pfet_01v8_hvt
M$3 10 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=105000000000P PS=1730000U PD=1210000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 4 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 5 8 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=360000000000P PS=1330000U PD=2720000U
* device instance $6 r0 *1 2.29,0.56 nfet_01v8
M$6 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 4 8 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=195000000000P
+ PS=920000U PD=1900000U
* device instance $8 r0 *1 0.57,0.56 nfet_01v8
M$8 11 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $9 r0 *1 0.93,0.56 nfet_01v8
M$9 7 3 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=87750000000P
+ PS=860000U PD=920000U
* device instance $10 r0 *1 1.35,0.56 nfet_01v8
M$10 6 3 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor2_1

* cell sky130_fd_sc_hd__xor2_1
* pin VPB
* pin B
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xor2_1 1 2 3 6 7 8 9
* net 1 VPB
* net 2 B
* net 3 A
* net 6 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=300000000000P PS=2520000U PD=2600000U
* device instance $2 r0 *1 0.51,1.985 pfet_01v8_hvt
M$2 10 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $3 r0 *1 0.93,1.985 pfet_01v8_hvt
M$3 6 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.35,1.985 pfet_01v8_hvt
M$4 5 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.77,1.985 pfet_01v8_hvt
M$5 6 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.51,0.56 nfet_01v8
M$6 4 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.93,0.56 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.35,0.56 nfet_01v8
M$8 11 3 8 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 1.77,0.56 nfet_01v8
M$9 7 2 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=250250000000P
+ PS=920000U PD=1420000U
* device instance $10 r0 *1 2.69,0.56 nfet_01v8
M$10 8 4 7 9 nfet_01v8 L=150000U W=650000U AS=250250000000P AD=208000000000P
+ PS=1420000U PD=1940000U
.ENDS sky130_fd_sc_hd__xor2_1

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 0.89,0.56 nfet_01v8
M$8 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
* device instance $9 r0 *1 1.85,0.56 nfet_01v8
M$9 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 2.27,0.56 nfet_01v8
M$10 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__o21a_1
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21a_1 1 2 3 4 5 7 8 10
* net 1 VPB
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=327500000000P PS=2560000U PD=1655000U
* device instance $2 r0 *1 1.295,1.985 pfet_01v8_hvt
M$2 9 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=327500000000P
+ AD=195000000000P PS=1655000U PD=1390000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=152500000000P PS=1390000U PD=1305000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 5 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=260000000000P PS=1305000U PD=2520000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 3 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 8 9 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21a_1

* cell sky130_fd_sc_hd__nor3b_1
* pin VPB
* pin B
* pin A
* pin C_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 C_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 2.055,1.86 pfet_01v8_hvt
M$1 8 4 7 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 11 8 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=320000000000P
+ AD=135000000000P PS=2640000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 10 2 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.57,1.985 pfet_01v8_hvt
M$4 7 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $5 r0 *1 0.73,0.56 nfet_01v8
M$5 6 8 5 9 nfet_01v8 L=150000U W=650000U AS=221000000000P AD=87750000000P
+ PS=1980000U PD=920000U
* device instance $6 r0 *1 1.15,0.56 nfet_01v8
M$6 5 2 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.57,0.56 nfet_01v8
M$7 6 3 5 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $8 r0 *1 2.055,0.675 nfet_01v8
M$8 8 4 6 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor3b_1

* cell sky130_fd_sc_hd__and4_1
* pin VPB
* pin D
* pin C
* pin B
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and4_1 1 3 4 5 6 7 8 9 10
* net 1 VPB
* net 3 D
* net 4 C
* net 5 B
* net 6 A
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 2 6 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=73500000000P
+ PS=1360000U PD=770000U
* device instance $2 r0 *1 0.97,2.275 pfet_01v8_hvt
M$2 8 5 2 1 pfet_01v8_hvt L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $3 r0 *1 1.49,2.275 pfet_01v8_hvt
M$3 2 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=77700000000P AD=58800000000P
+ PS=790000U PD=700000U
* device instance $4 r0 *1 1.92,2.275 pfet_01v8_hvt
M$4 2 3 8 1 pfet_01v8_hvt L=150000U W=420000U AS=312450000000P AD=58800000000P
+ PS=1680000U PD=700000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=312450000000P
+ AD=260000000000P PS=1680000U PD=2520000U
* device instance $6 r0 *1 0.47,0.445 nfet_01v8
M$6 13 6 2 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $7 r0 *1 0.91,0.445 nfet_01v8
M$7 11 5 13 10 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=79800000000P
+ PS=710000U PD=800000U
* device instance $8 r0 *1 1.44,0.445 nfet_01v8
M$8 12 4 11 10 nfet_01v8 L=150000U W=420000U AS=79800000000P AD=69300000000P
+ PS=800000U PD=750000U
* device instance $9 r0 *1 1.92,0.445 nfet_01v8
M$9 7 3 12 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=196275000000P
+ PS=750000U PD=1330000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 9 2 7 10 nfet_01v8 L=150000U W=650000U AS=196275000000P AD=169000000000P
+ PS=1330000U PD=1820000U
.ENDS sky130_fd_sc_hd__and4_1

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__and2_1
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 X
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.65,2.065 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $2 r0 *1 1.07,2.065 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=166550000000P AD=56700000000P
+ PS=1390000U PD=690000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=166550000000P
+ AD=475000000000P PS=1390000U PD=2950000U
* device instance $4 r0 *1 0.65,0.585 nfet_01v8
M$4 9 2 6 8 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $5 r0 *1 1.07,0.585 nfet_01v8
M$5 9 3 7 8 nfet_01v8 L=150000U W=420000U AS=111800000000P AD=56700000000P
+ PS=1040000U PD=690000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 4 6 7 8 nfet_01v8 L=150000U W=650000U AS=111800000000P AD=182000000000P
+ PS=1040000U PD=1860000U
.ENDS sky130_fd_sc_hd__and2_1

* cell sky130_fd_sc_hd__nor3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 6 4 5 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $6 r0 *1 1.31,0.56 nfet_01v8
M$6 6 2 5 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor3_1
