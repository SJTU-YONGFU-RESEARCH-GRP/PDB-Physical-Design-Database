* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT configurable_lfsr clk enable load_seed parallel_out[0]
+ parallel_out[1] parallel_out[2] parallel_out[3] parallel_out[4]
+ parallel_out[5] parallel_out[6] parallel_out[7] rst_n seed[0]
+ seed[1] seed[2] seed[3] seed[4] seed[5] seed[6] seed[7] serial_out
+ tap_pattern[0] tap_pattern[1] tap_pattern[2] tap_pattern[3]
+ tap_pattern[4] tap_pattern[5] tap_pattern[6] tap_pattern[7]
X_42_ net2 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_2
X_43_ enable VSS VSS VDD VDD _09_ sky130_fd_sc_hd__clkbuf_4
X_44_ net27 net20 _09_ VSS VSS VDD VDD _10_ sky130_fd_sc_hd__mux2i_1
X_45_ _08_ net3 VSS VSS VDD VDD _11_ sky130_fd_sc_hd__nand2_1
X_46_ _08_ _10_ _11_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__o21ai_0
X_47_ net20 net21 _09_ VSS VSS VDD VDD _12_ sky130_fd_sc_hd__mux2i_1
X_48_ _08_ net4 VSS VSS VDD VDD _13_ sky130_fd_sc_hd__nand2_1
X_49_ _08_ _12_ _13_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__o21ai_0
X_50_ net21 net22 _09_ VSS VSS VDD VDD _14_ sky130_fd_sc_hd__mux2i_1
X_51_ _08_ net5 VSS VSS VDD VDD _15_ sky130_fd_sc_hd__nand2_1
X_52_ _08_ _14_ _15_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__o21ai_0
X_53_ net22 net23 _09_ VSS VSS VDD VDD _16_ sky130_fd_sc_hd__mux2i_1
X_54_ _08_ net6 VSS VSS VDD VDD _17_ sky130_fd_sc_hd__nand2_1
X_55_ net2 _16_ _17_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__o21ai_0
X_56_ net23 net24 _09_ VSS VSS VDD VDD _18_ sky130_fd_sc_hd__mux2i_1
X_57_ _08_ net7 VSS VSS VDD VDD _19_ sky130_fd_sc_hd__nand2_1
X_58_ net2 _18_ _19_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__o21ai_0
X_59_ net24 net25 _09_ VSS VSS VDD VDD _20_ sky130_fd_sc_hd__mux2i_1
X_60_ _08_ net8 VSS VSS VDD VDD _21_ sky130_fd_sc_hd__nand2_1
X_61_ net2 _20_ _21_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__o21ai_0
X_62_ net25 net26 _09_ VSS VSS VDD VDD _22_ sky130_fd_sc_hd__mux2i_1
X_63_ _08_ net9 VSS VSS VDD VDD _23_ sky130_fd_sc_hd__nand2_1
X_64_ net2 _22_ _23_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__o21ai_0
X_65_ net24 net16 VSS VSS VDD VDD _24_ sky130_fd_sc_hd__nand2_1
X_66_ net22 net14 VSS VSS VDD VDD _25_ sky130_fd_sc_hd__nand2_1
X_67_ _24_ _25_ VSS VSS VDD VDD _26_ sky130_fd_sc_hd__xor2_1
X_68_ net25 net17 VSS VSS VDD VDD _27_ sky130_fd_sc_hd__nand2_1
X_69_ net23 net15 VSS VSS VDD VDD _28_ sky130_fd_sc_hd__nand2_1
X_70_ _27_ _28_ VSS VSS VDD VDD _29_ sky130_fd_sc_hd__xnor2_1
X_71_ _26_ _29_ VSS VSS VDD VDD _30_ sky130_fd_sc_hd__xnor2_1
X_72_ net20 net12 VSS VSS VDD VDD _31_ sky130_fd_sc_hd__nand2_1
X_73_ net11 net27 VSS VSS VDD VDD _32_ sky130_fd_sc_hd__nand2_1
X_74_ _31_ _32_ VSS VSS VDD VDD _33_ sky130_fd_sc_hd__xor2_1
X_75_ net26 net18 VSS VSS VDD VDD _34_ sky130_fd_sc_hd__nand2_1
X_76_ net21 net13 VSS VSS VDD VDD _35_ sky130_fd_sc_hd__nand2_1
X_77_ _34_ _35_ VSS VSS VDD VDD _36_ sky130_fd_sc_hd__xnor2_1
X_78_ _33_ _36_ VSS VSS VDD VDD _37_ sky130_fd_sc_hd__xnor2_1
X_79_ _30_ _37_ VSS VSS VDD VDD _38_ sky130_fd_sc_hd__xnor2_1
X_80_ net2 _09_ VSS VSS VDD VDD _39_ sky130_fd_sc_hd__nand2b_1
X_81_ net2 _09_ VSS VSS VDD VDD _40_ sky130_fd_sc_hd__nor2_1
X_82_ net2 net10 _40_ net26 VSS VSS VDD VDD _41_ sky130_fd_sc_hd__a22oi_1
X_83_ _38_ _39_ _41_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__o21ai_0
X_84_ net27 VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xshift_reg\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _00_ net1
+ VSS VSS VDD VDD net27 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _01_ net1
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD net21 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _03_ net1
+ VSS VSS VDD VDD net22 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _04_ net1
+ VSS VSS VDD VDD net23 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[5\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _05_ net1
+ VSS VSS VDD VDD net24 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _06_ net1
+ VSS VSS VDD VDD net25 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _07_ net1
+ VSS VSS VDD VDD net26 sky130_fd_sc_hd__dfrtp_1
Xhold1 net28 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 load_seed VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput2 seed[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 seed[1] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 seed[2] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 seed[3] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 seed[4] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 seed[5] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 seed[6] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 seed[7] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 tap_pattern[0] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 tap_pattern[1] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 tap_pattern[2] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput13 tap_pattern[3] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput14 tap_pattern[4] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput15 tap_pattern[5] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput16 tap_pattern[6] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput17 tap_pattern[7] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD parallel_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD parallel_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net21 VSS VSS VDD VDD parallel_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net22 VSS VSS VDD VDD parallel_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput22 net23 VSS VSS VDD VDD parallel_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput23 net24 VSS VSS VDD VDD parallel_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput24 net25 VSS VSS VDD VDD parallel_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput25 net26 VSS VSS VDD VDD parallel_out[7] sky130_fd_sc_hd__clkbuf_1
Xoutput26 net27 VSS VSS VDD VDD serial_out sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xhold2 rst_n VSS VSS VDD VDD net28 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS configurable_lfsr
