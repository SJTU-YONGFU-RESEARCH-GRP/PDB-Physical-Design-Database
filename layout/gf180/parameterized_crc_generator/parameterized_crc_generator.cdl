* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_crc_generator clk crc_init crc_out[0]
+ crc_out[1] crc_out[2] crc_out[3] crc_out[4] crc_out[5] crc_out[6]
+ crc_out[7] data_in[0] data_in[1] data_in[2] data_in[3] data_in[4]
+ data_in[5] data_in[6] data_in[7] data_valid rst_n
X_42_ net9 crc_reflected\[6\] _08_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_43_ crc_reflected\[0\] net3 _09_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_44_ _08_ _09_ _10_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_45_ net10 crc_reflected\[7\] _10_ _11_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_46_ net11 crc_reflected\[0\] _12_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_47_ net11 _11_ _12_ net2 _00_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_48_ net2 _13_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_49_ _13_ crc_reflected\[1\] _14_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_50_ net2 crc_reflected\[1\] _15_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_51_ net4 _08_ _09_ _16_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor3_2
X_52_ net11 _16_ _17_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_53_ _14_ _15_ _17_ _01_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_54_ net5 crc_reflected\[2\] _18_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_55_ crc_reflected\[1\] net4 _19_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_56_ _10_ _18_ _19_ _20_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor3_2
X_57_ net11 crc_reflected\[2\] _21_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_58_ net11 _20_ _21_ net2 _02_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_59_ _13_ crc_reflected\[3\] _22_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_60_ net2 crc_reflected\[3\] _23_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_61_ net10 crc_reflected\[7\] net6 _24_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor3_2
X_62_ _18_ _19_ _24_ _25_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_63_ net11 _25_ _26_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_64_ _22_ _23_ _26_ _03_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_65_ net7 crc_reflected\[4\] _27_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_66_ net6 crc_reflected\[3\] _28_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_67_ _18_ _27_ _28_ _29_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_68_ crc_reflected\[4\] _29_ net11 _30_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_69_ _13_ _30_ _04_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_70_ _13_ crc_reflected\[5\] _31_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_71_ net2 crc_reflected\[5\] _32_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_72_ net8 _27_ _28_ _33_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_73_ net11 _33_ _34_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_74_ _31_ _32_ _34_ _05_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_75_ net8 crc_reflected\[5\] _35_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_76_ _08_ _27_ _35_ _36_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor3_2
X_77_ crc_reflected\[6\] _36_ net11 _37_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_78_ _13_ _37_ _06_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_79_ _13_ crc_reflected\[7\] _38_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_80_ net2 crc_reflected\[7\] _39_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_81_ net10 _08_ _35_ _40_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor3_2
X_82_ net11 _40_ _41_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_83_ _38_ _39_ _41_ _07_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xcrc_out\[0\]$_DFF_PN0_ crc_reflected\[0\] net1 clknet_1_0__leaf_clk
+ net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_out\[1\]$_DFF_PN0_ crc_reflected\[1\] net1 clknet_1_0__leaf_clk
+ net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_out\[2\]$_DFF_PN0_ crc_reflected\[2\] net1 clknet_1_0__leaf_clk
+ net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_out\[3\]$_DFF_PN0_ crc_reflected\[3\] net1 clknet_1_1__leaf_clk
+ net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_out\[4\]$_DFF_PN0_ crc_reflected\[4\] net1 clknet_1_1__leaf_clk
+ net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_out\[5\]$_DFF_PN0_ crc_reflected\[5\] net1 clknet_1_1__leaf_clk
+ net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_out\[6\]$_DFF_PN0_ crc_reflected\[6\] net1 clknet_1_1__leaf_clk
+ net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_out\[7\]$_DFF_PN0_ crc_reflected\[7\] net1 clknet_1_1__leaf_clk
+ net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_reg\[0\]$_DFFE_PN0P_ _00_ net1 clknet_1_0__leaf_clk crc_reflected\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_reg\[1\]$_DFFE_PN0P_ _01_ net1 clknet_1_0__leaf_clk crc_reflected\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_reg\[2\]$_DFFE_PN0P_ _02_ net1 clknet_1_0__leaf_clk crc_reflected\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_reg\[3\]$_DFFE_PN0P_ _03_ net1 clknet_1_1__leaf_clk crc_reflected\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_reg\[4\]$_DFFE_PN0P_ _04_ net1 clknet_1_1__leaf_clk crc_reflected\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_reg\[5\]$_DFFE_PN0P_ _05_ net1 clknet_1_1__leaf_clk crc_reflected\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_reg\[6\]$_DFFE_PN0P_ _06_ net1 clknet_1_1__leaf_clk crc_reflected\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcrc_reg\[7\]$_DFFE_PN0P_ _07_ net1 clknet_1_0__leaf_clk crc_reflected\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xhold1 net20 net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 crc_init net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput2 data_in[0] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput3 data_in[1] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 data_in[2] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 data_in[3] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput6 data_in[4] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 data_in[5] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput8 data_in[6] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput9 data_in[7] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput10 data_valid net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xoutput11 net12 crc_out[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput12 net13 crc_out[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput13 net14 crc_out[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput14 net15 crc_out[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput15 net16 crc_out[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput16 net17 crc_out[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput17 net18 crc_out[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput18 net19 crc_out[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkload0 clknet_1_0__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xhold2 rst_n net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS parameterized_crc_generator
