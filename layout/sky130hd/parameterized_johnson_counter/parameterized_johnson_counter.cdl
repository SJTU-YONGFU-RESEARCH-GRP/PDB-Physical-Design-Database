* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_johnson_counter clk count[0] count[1]
+ count[2] count[3] enable rst_n
X_5_ net3 VSS VSS VDD VDD _4_ sky130_fd_sc_hd__inv_1
X_6_ _4_ net6 net2 VSS VSS VDD VDD _0_ sky130_fd_sc_hd__mux2i_1
X_7_ net4 net3 net2 VSS VSS VDD VDD _1_ sky130_fd_sc_hd__mux2_1
X_8_ net5 net4 net2 VSS VSS VDD VDD _2_ sky130_fd_sc_hd__mux2_1
X_9_ net6 net5 net2 VSS VSS VDD VDD _3_ sky130_fd_sc_hd__mux2_1
Xcounter_reg\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _0_ net1
+ VSS VSS VDD VDD net3 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _1_ net1
+ VSS VSS VDD VDD net4 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _2_ net1
+ VSS VSS VDD VDD net5 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _3_ net1
+ VSS VSS VDD VDD net6 sky130_fd_sc_hd__dfrtp_1
Xhold1 net7 VSS VSS VDD VDD net1 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 enable VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xoutput2 net3 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput3 net4 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net5 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net6 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xhold2 rst_n VSS VSS VDD VDD net7 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_johnson_counter
