* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT pulse_width_detector clk pulse_detected rst signal_in
+ threshold[0] threshold[1] threshold[2] threshold[3] threshold[4]
+ threshold[5] threshold[6] threshold[7]
X_089_ net1 _000_ VDD VSS INV_X4
X_090_ net3 _084_ VDD VSS INV_X1
X_091_ net2 _013_ VDD VSS BUF_X4
X_092_ _013_ signal_prev _014_ VDD VSS NOR2_X2
X_093_ counter\[0\] _014_ _015_ VDD VSS NAND2_X1
X_094_ _013_ signal_prev _016_ VDD VSS NAND2_X2
X_095_ counter\[3\] counter\[2\] _087_ _017_ VDD VSS AND3_X1
X_096_ counter\[4\] _018_ VDD VSS BUF_X2
X_097_ counter\[5\] _018_ counter\[6\] counter\[7\] _019_
+ VDD VSS AND4_X1
X_098_ _017_ _019_ _020_ VDD VSS AND2_X1
X_099_ counter\[0\] _020_ _021_ VDD VSS XOR2_X1
X_100_ _015_ _016_ _021_ _001_ VDD VSS OAI21_X1
X_101_ _088_ counter\[1\] _020_ _022_ VDD VSS MUX2_X1
X_102_ _013_ signal_prev _023_ VDD VSS AND2_X1
X_103_ counter\[1\] _014_ _022_ _023_ _024_ VDD VSS AOI22_X1
X_104_ _024_ _002_ VDD VSS INV_X1
X_105_ _013_ signal_prev _025_ VDD VSS XOR2_X2
X_106_ _013_ counter\[2\] _087_ _026_ VDD VSS NAND3_X1
X_107_ _020_ _026_ _027_ VDD VSS NOR2_X1
X_108_ counter\[2\] _087_ _013_ _028_ VDD VSS AOI21_X1
X_109_ _025_ _027_ _028_ _003_ VDD VSS NOR3_X1
X_110_ counter\[2\] counter\[0\] counter\[1\] _029_ VDD VSS
+ NAND3_X1
X_111_ _013_ counter\[3\] _030_ VDD VSS NAND2_X1
X_112_ _029_ _030_ _017_ _019_ _031_ VDD VSS AOI211_X2
X_113_ counter\[3\] _032_ VDD VSS INV_X1
X_114_ _016_ _029_ _032_ _033_ VDD VSS AOI21_X1
X_115_ _033_ _014_ counter\[3\] _034_ VDD VSS AOI21_X1
X_116_ _031_ _034_ _004_ VDD VSS NOR2_X1
X_117_ _018_ _014_ _035_ VDD VSS NAND2_X1
X_118_ _018_ _017_ _036_ VDD VSS OR2_X1
X_119_ _018_ _017_ _037_ VDD VSS NAND2_X1
X_120_ _036_ _037_ _019_ _038_ VDD VSS OAI21_X1
X_121_ _035_ _038_ _016_ _005_ VDD VSS OAI21_X1
X_122_ _018_ _031_ _039_ VDD VSS NAND2_X1
X_123_ counter\[5\] _039_ _040_ VDD VSS XOR2_X1
X_124_ _025_ _040_ _006_ VDD VSS NOR2_X1
X_125_ counter\[6\] _014_ _041_ VDD VSS NAND2_X1
X_126_ counter\[5\] _018_ _017_ _042_ VDD VSS NAND3_X1
X_127_ counter\[7\] _042_ _043_ VDD VSS NOR2_X1
X_128_ _042_ _043_ counter\[6\] _044_ VDD VSS MUX2_X1
X_129_ _041_ _044_ _016_ _007_ VDD VSS OAI21_X1
X_130_ counter\[5\] _018_ counter\[6\] _031_ _045_ VDD VSS
+ NAND4_X1
X_131_ counter\[7\] _045_ _046_ VDD VSS XOR2_X1
X_132_ _025_ _046_ _008_ VDD VSS NOR2_X1
X_133_ net11 _047_ VDD VSS INV_X1
X_134_ _065_ _068_ _071_ _074_ _048_ VDD VSS NAND4_X1
X_135_ _077_ _080_ _083_ _086_ _049_ VDD VSS NAND4_X1
X_136_ _047_ _048_ _049_ _050_ VDD VSS OAI21_X1
X_137_ net11 _014_ _050_ _023_ _051_ VDD VSS AOI22_X1
X_138_ _082_ _052_ VDD VSS INV_X1
X_139_ _083_ _053_ VDD VSS INV_X1
X_140_ _052_ _085_ _053_ _054_ VDD VSS OAI21_X1
X_141_ _077_ _080_ _054_ _055_ VDD VSS NAND3_X1
X_142_ _076_ _079_ _077_ _056_ VDD VSS AOI21_X1
X_143_ _048_ _055_ _056_ _057_ VDD VSS AOI21_X1
X_144_ _065_ _058_ VDD VSS INV_X1
X_145_ _073_ _068_ _071_ _059_ VDD VSS NAND3_X1
X_146_ _067_ _070_ _068_ _010_ VDD VSS AOI21_X1
X_147_ _058_ _059_ _010_ _011_ VDD VSS AOI21_X1
X_148_ _064_ _016_ _011_ _012_ VDD VSS OR3_X1
X_149_ _051_ _057_ _012_ _009_ VDD VSS OAI21_X1
X_150_ _063_ net10 _064_ _065_ VDD VSS HA_X1
X_151_ _066_ net9 _067_ _068_ VDD VSS HA_X1
X_152_ _069_ net8 _070_ _071_ VDD VSS HA_X1
X_153_ _072_ net7 _073_ _074_ VDD VSS HA_X1
X_154_ _075_ net6 _076_ _077_ VDD VSS HA_X1
X_155_ _078_ net5 _079_ _080_ VDD VSS HA_X1
X_156_ _081_ net4 _082_ _083_ VDD VSS HA_X1
X_157_ counter\[0\] _084_ _085_ _086_ VDD VSS HA_X1
X_158_ counter\[0\] counter\[1\] _087_ _088_ VDD VSS HA_X1
Xcounter\[0\]$_DFFE_PP0P_ _001_ _000_ clknet_1_0__leaf_clk
+ counter\[0\] _062_ VDD VSS DFFR_X2
Xcounter\[1\]$_DFFE_PP0P_ _002_ _000_ clknet_1_1__leaf_clk
+ counter\[1\] _081_ VDD VSS DFFR_X1
Xcounter\[2\]$_DFFE_PP0P_ _003_ _000_ clknet_1_1__leaf_clk
+ counter\[2\] _078_ VDD VSS DFFR_X1
Xcounter\[3\]$_DFFE_PP0P_ _004_ _000_ clknet_1_1__leaf_clk
+ counter\[3\] _075_ VDD VSS DFFR_X1
Xcounter\[4\]$_DFFE_PP0P_ _005_ _000_ clknet_1_1__leaf_clk
+ counter\[4\] _072_ VDD VSS DFFR_X1
Xcounter\[5\]$_DFFE_PP0P_ _006_ _000_ clknet_1_0__leaf_clk
+ counter\[5\] _069_ VDD VSS DFFR_X1
Xcounter\[6\]$_DFFE_PP0P_ _007_ _000_ clknet_1_1__leaf_clk
+ counter\[6\] _066_ VDD VSS DFFR_X1
Xcounter\[7\]$_DFFE_PP0P_ _008_ _000_ clknet_1_0__leaf_clk
+ counter\[7\] _063_ VDD VSS DFFR_X1
Xpulse_detected$_DFFE_PP0P_ _009_ _000_ clknet_1_1__leaf_clk
+ net11 _061_ VDD VSS DFFR_X1
Xsignal_prev$_DFF_PP0_ net2 _000_ clknet_1_0__leaf_clk signal_prev
+ _060_ VDD VSS DFFR_X2
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_51 VDD VSS TAPCELL_X1
Xinput1 net12 net1 VDD VSS BUF_X1
Xinput2 signal_in net2 VDD VSS BUF_X1
Xinput3 threshold[0] net3 VDD VSS BUF_X1
Xinput4 threshold[1] net4 VDD VSS BUF_X1
Xinput5 threshold[2] net5 VDD VSS BUF_X1
Xinput6 threshold[3] net6 VDD VSS BUF_X1
Xinput7 threshold[4] net7 VDD VSS BUF_X1
Xinput8 threshold[5] net8 VDD VSS BUF_X1
Xinput9 threshold[6] net9 VDD VSS BUF_X1
Xinput10 threshold[7] net10 VDD VSS BUF_X1
Xoutput11 net11 pulse_detected VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_1_0__leaf_clk _unconnected_0 VDD VSS INV_X1
Xhold1 rst net12 VDD VSS CLKBUF_X1
.ENDS pulse_width_detector
