* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT leading_zero_counter data_in[0] data_in[10] data_in[11]
+ data_in[12] data_in[13] data_in[14] data_in[15] data_in[16]
+ data_in[17] data_in[18] data_in[19] data_in[1] data_in[20]
+ data_in[21] data_in[22] data_in[23] data_in[24] data_in[25]
+ data_in[26] data_in[27] data_in[28] data_in[29] data_in[2]
+ data_in[30] data_in[31] data_in[3] data_in[4] data_in[5] data_in[6]
+ data_in[7] data_in[8] data_in[9] valid_input zero_count[0]
+ zero_count[1] zero_count[2] zero_count[3] zero_count[4] zero_count[5]
X_061_ net32 net31 _006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_062_ net3 net2 _006_ _007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_063_ net5 net4 net7 net6 _008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_064_ net30 net29 _009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_065_ net26 net23 _010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_066_ net12 net1 _011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_067_ net28 net27 _012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_068_ _009_ _010_ _011_ _012_ _013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_069_ _013_ _014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_070_ _007_ _008_ _014_ net38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_071_ net9 _015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_072_ net8 _016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_073_ net11 net10 _017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_074_ net14 net13 net16 net15 _018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_075_ _015_ _016_ _017_ _018_ _019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_076_ net18 net17 net20 net19 _020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_077_ net22 net21 _021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_078_ net25 net24 _021_ _022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_079_ net38 _019_ _020_ _022_ net39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_080_ net38 _019_ _020_ _022_ net33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_081_ net19 _023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_082_ net22 _024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_083_ _024_ net24 net21 net19 _025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_084_ net20 _023_ _025_ net18 _026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_085_ net13 net15 net17 _027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_086_ net13 _028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_087_ net13 net15 _029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_088_ net7 net9 net11 _030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_089_ net14 _028_ net16 _029_ _030_ _031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_090_ _026_ _027_ _031_ _032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_091_ net30 _033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_092_ _033_ net31 net29 _034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_093_ net1 net23 net27 _035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_094_ net28 _034_ _035_ _036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_095_ _015_ net10 _037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_096_ _016_ _037_ net7 _038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_097_ net2 net4 net6 _039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_098_ _036_ _038_ _039_ _040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_099_ net4 _041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_100_ net5 _041_ net3 _042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_101_ net2 _042_ _043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_102_ net28 net30 net32 _044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_103_ _043_ _044_ _036_ _045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_104_ net23 _046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_105_ net26 _046_ net12 _047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_106_ net1 _047_ _048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_107_ _032_ _040_ _045_ _048_ net34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_108_ net20 net19 _049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_109_ _049_ _021_ net18 net17 _050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_110_ net14 net13 _051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_111_ net16 net15 _050_ _051_ _052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_112_ net5 net4 net9 net8 _053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_113_ _017_ _052_ _053_ _054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_114_ _009_ _010_ _055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_115_ net7 net6 _056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_116_ net5 net4 _056_ _057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_117_ net3 net2 _055_ _057_ _058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_118_ _006_ _009_ _059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_119_ net28 net27 _059_ _010_ _060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_120_ _054_ _058_ _060_ _011_ net35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_121_ _009_ _012_ _000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_122_ net9 net8 net11 net10 _001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_123_ _018_ _020_ _001_ _002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_124_ _008_ _002_ _003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_125_ _007_ _003_ _004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_126_ _000_ _004_ _010_ _011_ net36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_127_ _019_ _005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_128_ _007_ _008_ _005_ _013_ net37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Right_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Left_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 data_in[0] net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xinput2 data_in[10] net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput3 data_in[11] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 data_in[12] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput5 data_in[13] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput6 data_in[14] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 data_in[15] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput8 data_in[16] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput9 data_in[17] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput10 data_in[18] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput11 data_in[19] net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput12 data_in[1] net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput13 data_in[20] net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput14 data_in[21] net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput15 data_in[22] net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput16 data_in[23] net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput17 data_in[24] net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput18 data_in[25] net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput19 data_in[26] net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput20 data_in[27] net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput21 data_in[28] net21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput22 data_in[29] net22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput23 data_in[2] net23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xinput24 data_in[30] net24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput25 data_in[31] net25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput26 data_in[3] net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput27 data_in[4] net27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput28 data_in[5] net28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput29 data_in[6] net29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput30 data_in[7] net30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xinput31 data_in[8] net31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput32 data_in[9] net32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput33 net33 valid_input VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput34 net34 zero_count[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput35 net35 zero_count[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput36 net36 zero_count[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput37 net37 zero_count[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput38 net38 zero_count[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput39 net39 zero_count[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS leading_zero_counter
