* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT gray_counter binary_out[0] binary_out[1] binary_out[2]
+ binary_out[3] clk data_in[0] data_in[1] data_in[2] data_in[3]
+ direction enable gray_out[0] gray_out[1] gray_out[2] gray_out[3]
+ load rst_n
X_48_ enable VSS VSS VDD VDD _07_ sky130_fd_sc_hd__buf_2
X_49_ _07_ net8 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__xnor2_1
X_50_ net7 net2 VSS VSS VDD VDD _09_ sky130_fd_sc_hd__nand2_1
X_51_ net7 _08_ _09_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__o21ai_0
X_52_ net9 _43_ _07_ VSS VSS VDD VDD _10_ sky130_fd_sc_hd__mux2i_1
X_53_ net7 net3 VSS VSS VDD VDD _11_ sky130_fd_sc_hd__nand2_1
X_54_ net7 _10_ _11_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__o21ai_0
X_55_ _07_ VSS VSS VDD VDD _12_ sky130_fd_sc_hd__clkinv_2
X_56_ _47_ _42_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__xnor2_2
X_57_ _12_ _13_ VSS VSS VDD VDD _14_ sky130_fd_sc_hd__nor2_1
X_58_ _12_ net10 _14_ VSS VSS VDD VDD _15_ sky130_fd_sc_hd__a21oi_1
X_59_ net7 net4 VSS VSS VDD VDD _16_ sky130_fd_sc_hd__nand2_1
X_60_ net7 _15_ _16_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__o21ai_0
X_61_ net7 VSS VSS VDD VDD _17_ sky130_fd_sc_hd__clkinv_2
X_62_ net8 _47_ _45_ VSS VSS VDD VDD _18_ sky130_fd_sc_hd__nand3_1
X_63_ _47_ _44_ _46_ VSS VSS VDD VDD _19_ sky130_fd_sc_hd__a21oi_1
X_64_ net6 VSS VSS VDD VDD _20_ sky130_fd_sc_hd__inv_1
X_65_ _18_ _19_ _20_ VSS VSS VDD VDD _21_ sky130_fd_sc_hd__a21oi_1
X_66_ _20_ _18_ _19_ VSS VSS VDD VDD _22_ sky130_fd_sc_hd__and3_1
X_67_ _12_ _21_ _22_ net11 VSS VSS VDD VDD _23_ sky130_fd_sc_hd__o31ai_1
X_68_ _12_ net11 _21_ _22_ VSS VSS VDD VDD _24_ sky130_fd_sc_hd__or4_1
X_69_ _17_ net5 VSS VSS VDD VDD _25_ sky130_fd_sc_hd__nor2_1
X_70_ _17_ _23_ _24_ _25_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__a31oi_1
X_71_ net8 _43_ VSS VSS VDD VDD _26_ sky130_fd_sc_hd__xor2_1
X_72_ _12_ _26_ VSS VSS VDD VDD _27_ sky130_fd_sc_hd__nor2_1
X_73_ _12_ net12 _27_ VSS VSS VDD VDD _28_ sky130_fd_sc_hd__a21oi_1
X_74_ net2 net3 VSS VSS VDD VDD _29_ sky130_fd_sc_hd__xor2_1
X_75_ _17_ _29_ VSS VSS VDD VDD _30_ sky130_fd_sc_hd__nor2_1
X_76_ _17_ _28_ _30_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__a21oi_1
X_77_ _43_ _13_ VSS VSS VDD VDD _31_ sky130_fd_sc_hd__xnor2_1
X_78_ net13 _31_ _07_ VSS VSS VDD VDD _32_ sky130_fd_sc_hd__mux2i_1
X_79_ net3 net4 VSS VSS VDD VDD _33_ sky130_fd_sc_hd__xor2_1
X_80_ _17_ _33_ VSS VSS VDD VDD _34_ sky130_fd_sc_hd__nor2_1
X_81_ _17_ _32_ _34_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__a21oi_1
X_82_ _17_ _07_ VSS VSS VDD VDD _35_ sky130_fd_sc_hd__nand2_1
X_83_ net11 _13_ VSS VSS VDD VDD _36_ sky130_fd_sc_hd__xnor2_1
X_84_ _21_ _22_ _35_ _36_ VSS VSS VDD VDD _37_ sky130_fd_sc_hd__or4_1
X_85_ _21_ _22_ _36_ _07_ _17_ VSS VSS VDD VDD _38_ sky130_fd_sc_hd__o2111ai_1
X_86_ net4 net5 VSS VSS VDD VDD _39_ sky130_fd_sc_hd__xnor2_1
X_87_ _17_ _39_ VSS VSS VDD VDD _40_ sky130_fd_sc_hd__nor2_1
X_88_ _17_ _12_ net14 _40_ VSS VSS VDD VDD _41_ sky130_fd_sc_hd__a31oi_1
X_89_ _37_ _38_ _41_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__nand3_1
X_90_ net8 net9 net6 VSS VSS VDD VDD _42_ _43_ sky130_fd_sc_hd__fa_2
X_91_ net9 net6 VSS VSS VDD VDD _44_ _45_ sky130_fd_sc_hd__ha_1
X_92_ net10 net6 VSS VSS VDD VDD _46_ _47_ sky130_fd_sc_hd__ha_1
X_93_ net11 VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xbinary_count\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _00_ net1
+ VSS VSS VDD VDD net8 sky130_fd_sc_hd__dfrtp_4
Xbinary_count\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1
+ VSS VSS VDD VDD net9 sky130_fd_sc_hd__dfrtp_2
Xbinary_count\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD net10 sky130_fd_sc_hd__dfrtp_1
Xbinary_count\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _03_ net1
+ VSS VSS VDD VDD net11 sky130_fd_sc_hd__dfrtp_2
Xgray_out\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _04_ net1
+ VSS VSS VDD VDD net12 sky130_fd_sc_hd__dfrtp_1
Xgray_out\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _05_ net1
+ VSS VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xgray_out\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _06_ net1
+ VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xhold1 net16 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 data_in[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput3 data_in[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_2
Xinput4 data_in[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput5 direction VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_2
Xinput6 load VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_2
Xoutput7 net8 VSS VSS VDD VDD binary_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net9 VSS VSS VDD VDD binary_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net10 VSS VSS VDD VDD binary_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net11 VSS VSS VDD VDD binary_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net12 VSS VSS VDD VDD gray_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD gray_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD gray_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD gray_out[3] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net16 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS gray_counter
