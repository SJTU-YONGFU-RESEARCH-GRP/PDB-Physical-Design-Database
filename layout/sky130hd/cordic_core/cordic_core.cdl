* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT cordic_core x_in[0] x_in[10] x_in[11] x_in[12] x_in[13]
+ x_in[14] x_in[15] x_in[1] x_in[2] x_in[3] x_in[4] x_in[5]
+ x_in[6] x_in[7] x_in[8] x_in[9] x_out[0] x_out[10] x_out[11]
+ x_out[12] x_out[13] x_out[14] x_out[15] x_out[1] x_out[2]
+ x_out[3] x_out[4] x_out[5] x_out[6] x_out[7] x_out[8] x_out[9]
+ y_in[0] y_in[10] y_in[11] y_in[12] y_in[13] y_in[14] y_in[15]
+ y_in[1] y_in[2] y_in[3] y_in[4] y_in[5] y_in[6] y_in[7] y_in[8]
+ y_in[9] y_out[0] y_out[10] y_out[11] y_out[12] y_out[13] y_out[14]
+ y_out[15] y_out[1] y_out[2] y_out[3] y_out[4] y_out[5] y_out[6]
+ y_out[7] y_out[8] y_out[9] z_in[0] z_in[10] z_in[11] z_in[12]
+ z_in[13] z_in[14] z_in[15] z_in[1] z_in[2] z_in[3] z_in[4]
+ z_in[5] z_in[6] z_in[7] z_in[8] z_in[9]
X_3747_ net68 VSS VSS VDD VDD _3684_ sky130_fd_sc_hd__inv_1
X_3748_ net70 net69 net62 VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__nor3_1
X_3749_ net74 net73 net72 net71 VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__nor4_2
X_3750_ _0000_ _0001_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__and2_0
X_3751_ net66 net65 net64 net63 VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__nor4_2
X_3752_ _3687_ net68 VSS VSS VDD VDD _0004_ sky130_fd_sc_hd__and2b_2
X_3753_ net77 net76 net75 VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__or3_4
X_3754_ _0004_ _3685_ net67 _0005_ VSS VSS VDD VDD _0006_
+ sky130_fd_sc_hd__nor4_4
X_3755_ _0006_ _0003_ _0002_ _3685_ net68 VSS VSS VDD VDD
+ _0007_ sky130_fd_sc_hd__a32o_4
X_3756_ _0007_ VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__inv_6
X_3757_ _0008_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__buf_8
X_3758_ _0009_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__buf_12
X_3759_ _0010_ VSS VSS VDD VDD _2091_ sky130_fd_sc_hd__buf_8
X_3760_ _2081_ _2091_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__nand2_1
X_3761_ _0007_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__buf_4
X_3762_ _0012_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__clkbuf_4
X_3763_ _0013_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__clkbuf_4
X_3764_ _0014_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__clkbuf_4
X_3765_ _0015_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__clkbuf_4
X_3766_ _2085_ _0016_ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__nand2_1
X_3767_ _0011_ _0017_ VSS VSS VDD VDD _2207_ sky130_fd_sc_hd__nand2_1
X_3768_ _2207_ VSS VSS VDD VDD _2096_ sky130_fd_sc_hd__inv_1
X_3769_ _2086_ _2201_ VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__nor2b_1
X_3770_ _2219_ VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__clkbuf_2
X_3771_ _2211_ VSS VSS VDD VDD _0020_ sky130_fd_sc_hd__buf_2
X_3772_ _0019_ _2218_ _0020_ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__o21a_1
X_3773_ _2202_ _2218_ _0018_ _0021_ VSS VSS VDD VDD _0022_
+ sky130_fd_sc_hd__o31a_2
X_3774_ _2202_ _0018_ _0019_ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__o21a_1
X_3775_ _0020_ _2218_ _0023_ VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__nor3_1
X_3776_ _0022_ _0024_ VSS VSS VDD VDD _0025_ sky130_fd_sc_hd__nor2_1
X_3777_ _0019_ _2201_ _2199_ VSS VSS VDD VDD _0026_ sky130_fd_sc_hd__nor3b_1
X_3778_ _0019_ _2205_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__nor2b_1
X_3779_ _2223_ _0026_ _0027_ VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__nor3_1
X_3780_ _0020_ _0028_ VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__xnor2_2
X_3781_ _0015_ _0029_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__nor2_1
X_3782_ _0015_ _0025_ _0030_ VSS VSS VDD VDD _0031_ sky130_fd_sc_hd__a21oi_1
X_3783_ _0031_ VSS VSS VDD VDD _2272_ sky130_fd_sc_hd__inv_1
X_3784_ _0019_ VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__clkbuf_4
X_3785_ _2084_ VSS VSS VDD VDD _0033_ sky130_fd_sc_hd__buf_2
X_3786_ _2087_ _0014_ VSS VSS VDD VDD _0034_ sky130_fd_sc_hd__nand2_1
X_3787_ _0033_ _0014_ _0034_ VSS VSS VDD VDD _0035_ sky130_fd_sc_hd__o21ai_0
X_3788_ _0032_ _0035_ VSS VSS VDD VDD _2276_ sky130_fd_sc_hd__xnor2_1
X_3789_ _2085_ _2091_ VSS VSS VDD VDD _0036_ sky130_fd_sc_hd__nand2_1
X_3790_ _2088_ _0016_ VSS VSS VDD VDD _0037_ sky130_fd_sc_hd__nand2_1
X_3791_ _0036_ _0037_ VSS VSS VDD VDD _2101_ sky130_fd_sc_hd__nand2_2
X_3792_ _2101_ VSS VSS VDD VDD _2105_ sky130_fd_sc_hd__inv_1
X_3793_ net67 VSS VSS VDD VDD _3683_ sky130_fd_sc_hd__inv_2
X_3794_ _0000_ _0001_ VSS VSS VDD VDD _0038_ sky130_fd_sc_hd__nand2_1
X_3795_ _0038_ _0005_ VSS VSS VDD VDD _0039_ sky130_fd_sc_hd__or2_0
X_3796_ _3685_ _0004_ VSS VSS VDD VDD _0040_ sky130_fd_sc_hd__nor2_1
X_3797_ _0040_ VSS VSS VDD VDD _0041_ sky130_fd_sc_hd__buf_2
X_3798_ net65 net64 net63 _0039_ _0041_ VSS VSS VDD VDD _0042_
+ sky130_fd_sc_hd__o41ai_2
X_3799_ net66 _0042_ VSS VSS VDD VDD _2089_ sky130_fd_sc_hd__xnor2_2
X_3800_ _2089_ VSS VSS VDD VDD _2284_ sky130_fd_sc_hd__inv_1
X_3801_ _0033_ _0015_ VSS VSS VDD VDD _0043_ sky130_fd_sc_hd__nand2_1
X_3802_ _2080_ _0015_ _0043_ VSS VSS VDD VDD _0044_ sky130_fd_sc_hd__o21ai_1
X_3803_ _0032_ _0044_ VSS VSS VDD VDD _2279_ sky130_fd_sc_hd__xnor2_2
X_3804_ _2279_ VSS VSS VDD VDD _2227_ sky130_fd_sc_hd__inv_1
X_3805_ _2276_ VSS VSS VDD VDD _2231_ sky130_fd_sc_hd__inv_1
X_3806_ _2092_ VSS VSS VDD VDD _0045_ sky130_fd_sc_hd__buf_12
X_3807_ _0045_ VSS VSS VDD VDD _2111_ sky130_fd_sc_hd__clkinv_8
X_3808_ _2233_ _2276_ _2111_ VSS VSS VDD VDD _2234_ sky130_fd_sc_hd__mux2_1
X_3809_ _2234_ VSS VSS VDD VDD _2095_ sky130_fd_sc_hd__inv_1
X_3810_ _2230_ _2097_ VSS VSS VDD VDD _2237_ sky130_fd_sc_hd__xnor2_2
X_3811_ _2237_ VSS VSS VDD VDD _2428_ sky130_fd_sc_hd__inv_1
X_3812_ _2241_ VSS VSS VDD VDD _0046_ sky130_fd_sc_hd__clkbuf_4
X_3813_ _0046_ VSS VSS VDD VDD _0047_ sky130_fd_sc_hd__clkinvlp_4
X_3814_ _0046_ _2249_ VSS VSS VDD VDD _0048_ sky130_fd_sc_hd__nor2b_1
X_3815_ _2210_ _0022_ _0048_ VSS VSS VDD VDD _0049_ sky130_fd_sc_hd__o21a_1
X_3816_ _0047_ _2210_ _2248_ _0022_ VSS VSS VDD VDD _0050_
+ sky130_fd_sc_hd__nor4_1
X_3817_ _2249_ VSS VSS VDD VDD _0051_ sky130_fd_sc_hd__buf_4
X_3818_ _0051_ _0047_ _2248_ VSS VSS VDD VDD _0052_ sky130_fd_sc_hd__nor3_1
X_3819_ _0047_ _2248_ _0049_ _0050_ _0052_ VSS VSS VDD VDD
+ _0053_ sky130_fd_sc_hd__a2111oi_4
X_3820_ _0020_ VSS VSS VDD VDD _0054_ sky130_fd_sc_hd__inv_1
X_3821_ _2223_ _0026_ _0027_ _0054_ VSS VSS VDD VDD _0055_
+ sky130_fd_sc_hd__o31a_2
X_3822_ _2215_ _0046_ VSS VSS VDD VDD _0056_ sky130_fd_sc_hd__nand2b_1
X_3823_ _0046_ VSS VSS VDD VDD _0057_ sky130_fd_sc_hd__buf_2
X_3824_ _0051_ _0057_ VSS VSS VDD VDD _0058_ sky130_fd_sc_hd__nor2_1
X_3825_ _2223_ _0026_ _0027_ _0058_ _0054_ VSS VSS VDD VDD
+ _0059_ sky130_fd_sc_hd__o311ai_1
X_3826_ _2249_ _2215_ VSS VSS VDD VDD _0060_ sky130_fd_sc_hd__nor2b_1
X_3827_ _2253_ _0057_ _0051_ VSS VSS VDD VDD _0061_ sky130_fd_sc_hd__and3b_1
X_3828_ _0046_ _2253_ VSS VSS VDD VDD _0062_ sky130_fd_sc_hd__nor2b_1
X_3829_ _0047_ _0060_ _0061_ _0062_ VSS VSS VDD VDD _0063_
+ sky130_fd_sc_hd__a211oi_1
X_3830_ _2253_ _0055_ _0056_ _0059_ _0063_ VSS VSS VDD VDD
+ _0064_ sky130_fd_sc_hd__o311a_2
X_3831_ net172 _0064_ VSS VSS VDD VDD _0065_ sky130_fd_sc_hd__nand2_1
X_3832_ net172 _0053_ _0065_ VSS VSS VDD VDD _2264_ sky130_fd_sc_hd__o21ai_2
X_3833_ _2257_ VSS VSS VDD VDD _0066_ sky130_fd_sc_hd__buf_2
X_3834_ _2251_ _2243_ VSS VSS VDD VDD _0067_ sky130_fd_sc_hd__or2_0
X_3835_ _2080_ _0019_ VSS VSS VDD VDD _0068_ sky130_fd_sc_hd__nor2b_1
X_3836_ _0020_ _2213_ _0051_ VSS VSS VDD VDD _0069_ sky130_fd_sc_hd__o21a_1
X_3837_ _2221_ _2213_ _0068_ _0069_ VSS VSS VDD VDD _0070_
+ sky130_fd_sc_hd__o31a_2
X_3838_ _0057_ _2243_ _0067_ _0070_ VSS VSS VDD VDD _0071_
+ sky130_fd_sc_hd__o22a_1
X_3839_ _0066_ _0071_ VSS VSS VDD VDD _0072_ sky130_fd_sc_hd__xnor2_1
X_3840_ _2257_ VSS VSS VDD VDD _0073_ sky130_fd_sc_hd__clkinvlp_4
X_3841_ _0019_ _0033_ _2223_ VSS VSS VDD VDD _0074_ sky130_fd_sc_hd__o21bai_1
X_3842_ _0020_ _2249_ VSS VSS VDD VDD _0075_ sky130_fd_sc_hd__nor2_1
X_3843_ _0074_ _0075_ _2253_ _0060_ VSS VSS VDD VDD _0076_
+ sky130_fd_sc_hd__a211o_1
X_3844_ _0047_ _0076_ _2245_ VSS VSS VDD VDD _0077_ sky130_fd_sc_hd__a21oi_1
X_3845_ _0073_ _0077_ VSS VSS VDD VDD _0078_ sky130_fd_sc_hd__xnor2_2
X_3846_ _0010_ _0078_ VSS VSS VDD VDD _0079_ sky130_fd_sc_hd__nor2_1
X_3847_ _0010_ _0072_ _0079_ VSS VSS VDD VDD _2392_ sky130_fd_sc_hd__a21oi_2
X_3848_ _2079_ _2201_ VSS VSS VDD VDD _0080_ sky130_fd_sc_hd__nor2b_2
X_3849_ _0019_ _2221_ _0020_ VSS VSS VDD VDD _0081_ sky130_fd_sc_hd__o21a_1
X_3850_ _2221_ _2203_ _0080_ _0081_ VSS VSS VDD VDD _0082_
+ sky130_fd_sc_hd__o31a_1
X_3851_ _2251_ _0057_ VSS VSS VDD VDD _0083_ sky130_fd_sc_hd__nand2b_1
X_3852_ _2221_ _2203_ _0080_ _0081_ _0048_ VSS VSS VDD VDD
+ _0084_ sky130_fd_sc_hd__o311ai_1
X_3853_ _0051_ _2251_ _0057_ VSS VSS VDD VDD _0085_ sky130_fd_sc_hd__nor3b_1
X_3854_ _0047_ _2251_ _2213_ _0048_ _0085_ VSS VSS VDD VDD
+ _0086_ sky130_fd_sc_hd__a221oi_1
X_3855_ _2213_ _0082_ _0083_ _0084_ _0086_ VSS VSS VDD VDD
+ _0087_ sky130_fd_sc_hd__o311ai_2
X_3856_ _0064_ _0013_ VSS VSS VDD VDD _0088_ sky130_fd_sc_hd__nand2b_1
X_3857_ _0014_ _0087_ _0088_ VSS VSS VDD VDD _2396_ sky130_fd_sc_hd__o21a_1
X_3858_ _0054_ _0074_ _2215_ VSS VSS VDD VDD _0089_ sky130_fd_sc_hd__a21oi_1
X_3859_ _0051_ _0089_ VSS VSS VDD VDD _0090_ sky130_fd_sc_hd__xnor2_2
X_3860_ _2221_ _0068_ _0020_ VSS VSS VDD VDD _0091_ sky130_fd_sc_hd__o21ai_0
X_3861_ _0051_ _2213_ VSS VSS VDD VDD _0092_ sky130_fd_sc_hd__nor2_1
X_3862_ _0091_ _0092_ _0070_ VSS VSS VDD VDD _0093_ sky130_fd_sc_hd__a21oi_1
X_3863_ _0016_ _0093_ VSS VSS VDD VDD _0094_ sky130_fd_sc_hd__nor2_1
X_3864_ _0016_ _0090_ _0094_ VSS VSS VDD VDD _2400_ sky130_fd_sc_hd__a21oi_2
X_3865_ _2221_ _2203_ _0080_ _0081_ VSS VSS VDD VDD _0095_
+ sky130_fd_sc_hd__o31ai_4
X_3866_ _2221_ VSS VSS VDD VDD _0096_ sky130_fd_sc_hd__inv_1
X_3867_ _2203_ _0080_ _0032_ VSS VSS VDD VDD _0097_ sky130_fd_sc_hd__o21ai_0
X_3868_ _0054_ _0096_ _0097_ VSS VSS VDD VDD _0098_ sky130_fd_sc_hd__nand3_1
X_3869_ _0095_ _0098_ _0014_ VSS VSS VDD VDD _0099_ sky130_fd_sc_hd__a21oi_1
X_3870_ _0015_ _0029_ _0099_ VSS VSS VDD VDD _2317_ sky130_fd_sc_hd__a21oi_2
X_3871_ _0032_ _2080_ VSS VSS VDD VDD _0100_ sky130_fd_sc_hd__xnor2_1
X_3872_ _2081_ _0100_ VSS VSS VDD VDD _0101_ sky130_fd_sc_hd__nor2_1
X_3873_ _0095_ _0098_ _0087_ _0013_ _0093_ VSS VSS VDD VDD
+ _0102_ sky130_fd_sc_hd__a2111oi_0
X_3874_ _0032_ _0033_ VSS VSS VDD VDD _0103_ sky130_fd_sc_hd__xor2_1
X_3875_ _2085_ _0103_ VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__nor2_1
X_3876_ _0029_ _0090_ _0104_ VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__nand3_1
X_3877_ _0101_ _0102_ _0105_ _0088_ VSS VSS VDD VDD _0106_
+ sky130_fd_sc_hd__o2bb2ai_1
X_3878_ net16 _0106_ VSS VSS VDD VDD _0107_ sky130_fd_sc_hd__nor2_1
X_3879_ _2392_ _0107_ VSS VSS VDD VDD _2263_ sky130_fd_sc_hd__xnor2_1
X_3880_ _2087_ _0019_ VSS VSS VDD VDD _0108_ sky130_fd_sc_hd__nor2b_1
X_3881_ _2218_ _0108_ _0020_ VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__o21ai_0
X_3882_ _0051_ _2210_ VSS VSS VDD VDD _0110_ sky130_fd_sc_hd__nor2_1
X_3883_ _0020_ _2210_ _2249_ VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__o21a_1
X_3884_ _2218_ _2210_ _0108_ _0111_ VSS VSS VDD VDD _0112_
+ sky130_fd_sc_hd__o31a_2
X_3885_ _0109_ _0110_ _0112_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__a21oi_1
X_3886_ _0016_ _0113_ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__nand2_1
X_3887_ _0015_ _0090_ _0114_ VSS VSS VDD VDD _2268_ sky130_fd_sc_hd__o21ai_1
X_3888_ _0045_ VSS VSS VDD VDD _0115_ sky130_fd_sc_hd__buf_2
X_3889_ _0095_ _0098_ _0093_ _0014_ VSS VSS VDD VDD _0116_
+ sky130_fd_sc_hd__a211oi_1
X_3890_ _0013_ _0029_ _0090_ VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__and3_1
X_3891_ _0116_ _0117_ _2280_ VSS VSS VDD VDD _0118_ sky130_fd_sc_hd__o21ai_1
X_3892_ _0115_ _0118_ VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__nand2_1
X_3893_ _2396_ _0119_ VSS VSS VDD VDD _2267_ sky130_fd_sc_hd__xor2_1
X_3894_ _2085_ _0033_ _0014_ VSS VSS VDD VDD _0120_ sky130_fd_sc_hd__nand3b_1
X_3895_ _2081_ _2080_ _0014_ _0120_ _0032_ VSS VSS VDD VDD
+ _0121_ sky130_fd_sc_hd__o311a_1
X_3896_ _2081_ _0015_ VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__nor2_1
X_3897_ _2085_ _0033_ net172 VSS VSS VDD VDD _0123_ sky130_fd_sc_hd__nor3_1
X_3898_ _2080_ _0122_ _0123_ _0032_ VSS VSS VDD VDD _0124_
+ sky130_fd_sc_hd__a211oi_1
X_3899_ _0045_ VSS VSS VDD VDD _0125_ sky130_fd_sc_hd__buf_2
X_3900_ _2317_ _0121_ _0124_ _0125_ VSS VSS VDD VDD _0126_
+ sky130_fd_sc_hd__o31ai_1
X_3901_ _2400_ _0126_ VSS VSS VDD VDD _2271_ sky130_fd_sc_hd__xor2_1
X_3902_ _2111_ _2280_ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__nor2_1
X_3903_ _2317_ _0127_ VSS VSS VDD VDD _2275_ sky130_fd_sc_hd__xnor2_1
X_3904_ _0115_ _2279_ VSS VSS VDD VDD _0128_ sky130_fd_sc_hd__nor2_1
X_3905_ _0115_ _2281_ _0128_ VSS VSS VDD VDD _2100_ sky130_fd_sc_hd__a21oi_2
X_3906_ _2104_ VSS VSS VDD VDD _2099_ sky130_fd_sc_hd__inv_1
X_3907_ _2104_ _2283_ VSS VSS VDD VDD _0129_ sky130_fd_sc_hd__nor2b_1
X_3908_ _2282_ _0129_ _2278_ VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__o21ai_0
X_3909_ _2274_ _2277_ VSS VSS VDD VDD _0131_ sky130_fd_sc_hd__nor2_1
X_3910_ _2278_ _2277_ _2274_ VSS VSS VDD VDD _0132_ sky130_fd_sc_hd__o21a_1
X_3911_ _2277_ _2282_ _0129_ _0132_ VSS VSS VDD VDD _0133_
+ sky130_fd_sc_hd__o31a_1
X_3912_ _0130_ _0131_ _0133_ VSS VSS VDD VDD _2420_ sky130_fd_sc_hd__a21oi_2
X_3913_ _2420_ VSS VSS VDD VDD _2328_ sky130_fd_sc_hd__inv_1
X_3914_ _2278_ _2102_ VSS VSS VDD VDD _2424_ sky130_fd_sc_hd__xor2_2
X_3915_ _2424_ VSS VSS VDD VDD _2327_ sky130_fd_sc_hd__inv_1
X_3916_ _2273_ _0133_ _2270_ VSS VSS VDD VDD _0134_ sky130_fd_sc_hd__o21ai_0
X_3917_ _2266_ _2269_ VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__nor2_1
X_3918_ _2270_ _2269_ _2266_ VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__o21a_1
X_3919_ _2269_ _2273_ _0133_ _0136_ VSS VSS VDD VDD _0137_
+ sky130_fd_sc_hd__o31a_1
X_3920_ _0134_ _0135_ _0137_ VSS VSS VDD VDD _2412_ sky130_fd_sc_hd__a21oi_2
X_3921_ net62 VSS VSS VDD VDD _0138_ sky130_fd_sc_hd__buf_8
X_3922_ _0138_ VSS VSS VDD VDD _2122_ sky130_fd_sc_hd__clkinv_8
X_3923_ _2472_ _3685_ _0004_ net70 VSS VSS VDD VDD _0139_
+ sky130_fd_sc_hd__o31a_1
X_3924_ net70 _2472_ _3685_ _0004_ VSS VSS VDD VDD _0140_
+ sky130_fd_sc_hd__nor4_1
X_3925_ _0139_ _0140_ VSS VSS VDD VDD _2110_ sky130_fd_sc_hd__nor2_1
X_3926_ _2294_ VSS VSS VDD VDD _0141_ sky130_fd_sc_hd__inv_1
X_3927_ _2313_ _2314_ _2312_ VSS VSS VDD VDD _0142_ sky130_fd_sc_hd__a21oi_2
X_3928_ _0139_ _0140_ _2313_ _2315_ VSS VSS VDD VDD _0143_
+ sky130_fd_sc_hd__o211ai_1
X_3929_ _0143_ _0142_ _2310_ VSS VSS VDD VDD _0144_ sky130_fd_sc_hd__a21boi_4
X_3930_ _2307_ VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__inv_1
X_3931_ _2301_ VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__inv_1
X_3932_ _2298_ _2304_ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__nand2_1
X_3933_ _0145_ _0146_ _0147_ VSS VSS VDD VDD _0148_ sky130_fd_sc_hd__nor3_2
X_3934_ _0144_ _2309_ _0148_ VSS VSS VDD VDD _0149_ sky130_fd_sc_hd__o21ai_4
X_3935_ _2304_ _2306_ _2303_ VSS VSS VDD VDD _0150_ sky130_fd_sc_hd__a21oi_2
X_3936_ _0146_ _0150_ _2300_ VSS VSS VDD VDD _0151_ sky130_fd_sc_hd__o21bai_1
X_3937_ _0151_ _2298_ _2297_ VSS VSS VDD VDD _0152_ sky130_fd_sc_hd__a21oi_2
X_3938_ _2295_ _2294_ _2292_ VSS VSS VDD VDD _0153_ sky130_fd_sc_hd__o21ai_0
X_3939_ _0149_ _0141_ _0152_ _0153_ VSS VSS VDD VDD _0154_
+ sky130_fd_sc_hd__a31oi_4
X_3940_ _0045_ _2093_ VSS VSS VDD VDD _0155_ sky130_fd_sc_hd__xnor2_1
X_3941_ _2289_ _2288_ _2286_ VSS VSS VDD VDD _0156_ sky130_fd_sc_hd__o21ai_0
X_3942_ _0155_ _0156_ _2225_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__o21bai_1
X_3943_ _2225_ _2288_ _0154_ _2291_ _0157_ VSS VSS VDD VDD
+ _0158_ sky130_fd_sc_hd__o41a_4
X_3944_ _0158_ VSS VSS VDD VDD _0159_ sky130_fd_sc_hd__inv_6
X_3945_ _0159_ VSS VSS VDD VDD _2443_ sky130_fd_sc_hd__buf_6
X_3946_ _2236_ _2331_ _2235_ VSS VSS VDD VDD _0160_ sky130_fd_sc_hd__a21o_1
X_3947_ _2230_ _0160_ _2229_ VSS VSS VDD VDD _0161_ sky130_fd_sc_hd__a21oi_1
X_3948_ _2319_ _0161_ VSS VSS VDD VDD _2320_ sky130_fd_sc_hd__xnor2_2
X_3949_ _2320_ VSS VSS VDD VDD _2427_ sky130_fd_sc_hd__inv_1
X_3950_ _2112_ _2333_ _2332_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__a21o_1
X_3951_ _2326_ _0162_ _2325_ VSS VSS VDD VDD _0163_ sky130_fd_sc_hd__a21oi_2
X_3952_ _2323_ _0163_ VSS VSS VDD VDD _2336_ sky130_fd_sc_hd__xnor2_1
X_3953_ _2336_ VSS VSS VDD VDD _2646_ sky130_fd_sc_hd__inv_1
X_3954_ _2341_ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__clkbuf_4
X_3955_ _0164_ VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__clkinvlp_4
X_3956_ _2248_ _2240_ _2256_ VSS VSS VDD VDD _0166_ sky130_fd_sc_hd__or3_2
X_3957_ _0051_ _2248_ _0066_ _0057_ VSS VSS VDD VDD _0167_
+ sky130_fd_sc_hd__o211ai_1
X_3958_ _0066_ _2240_ _2256_ VSS VSS VDD VDD _0168_ sky130_fd_sc_hd__a21oi_1
X_3959_ _0167_ _0168_ VSS VSS VDD VDD _0169_ sky130_fd_sc_hd__nand2_1
X_3960_ _2210_ _0022_ _0166_ _0169_ VSS VSS VDD VDD _0170_
+ sky130_fd_sc_hd__o31ai_2
X_3961_ _0165_ _0170_ VSS VSS VDD VDD _0171_ sky130_fd_sc_hd__xnor2_1
X_3962_ _2253_ _2249_ VSS VSS VDD VDD _0172_ sky130_fd_sc_hd__nor2b_1
X_3963_ _0046_ _2257_ _0172_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__nor3_2
X_3964_ _2245_ _0046_ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__nand2b_1
X_3965_ _2245_ _2253_ _0060_ _0174_ _0073_ VSS VSS VDD VDD
+ _0175_ sky130_fd_sc_hd__o311a_2
X_3966_ _0055_ _0173_ _0175_ _2261_ VSS VSS VDD VDD _0176_
+ sky130_fd_sc_hd__a211oi_2
X_3967_ _0165_ _0176_ VSS VSS VDD VDD _0177_ sky130_fd_sc_hd__xnor2_2
X_3968_ _0016_ _0177_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__nor2_1
X_3969_ _0016_ _0171_ _0178_ VSS VSS VDD VDD _2356_ sky130_fd_sc_hd__a21oi_1
X_3970_ _2349_ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__clkbuf_4
X_3971_ _2251_ _2243_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__nor2_1
X_3972_ _0164_ _2259_ _2343_ VSS VSS VDD VDD _0181_ sky130_fd_sc_hd__a21oi_1
X_3973_ _0180_ _0181_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__nand2_1
X_3974_ _0057_ _2243_ _0066_ _0164_ VSS VSS VDD VDD _0183_
+ sky130_fd_sc_hd__o211ai_1
X_3975_ _0181_ _0183_ VSS VSS VDD VDD _0184_ sky130_fd_sc_hd__nand2_1
X_3976_ _0070_ _0182_ _0184_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__o21ai_0
X_3977_ _2245_ _0046_ VSS VSS VDD VDD _0186_ sky130_fd_sc_hd__nor2b_1
X_3978_ _0066_ _0186_ _2261_ VSS VSS VDD VDD _0187_ sky130_fd_sc_hd__o21bai_1
X_3979_ _0165_ _0187_ _2345_ VSS VSS VDD VDD _0188_ sky130_fd_sc_hd__a21o_1
X_3980_ _2245_ _2261_ _2345_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__nor3_1
X_3981_ _0076_ _0189_ VSS VSS VDD VDD _0190_ sky130_fd_sc_hd__nand2b_1
X_3982_ _0188_ _0190_ _0009_ VSS VSS VDD VDD _0191_ sky130_fd_sc_hd__a21oi_1
X_3983_ _0013_ _0185_ _0191_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__o21bai_2
X_3984_ _0179_ _0192_ VSS VSS VDD VDD _2384_ sky130_fd_sc_hd__xor2_4
X_3985_ _2213_ _0067_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__nor2_1
X_3986_ _0051_ _2251_ _0057_ VSS VSS VDD VDD _0194_ sky130_fd_sc_hd__o21a_1
X_3987_ _2243_ _0194_ _0066_ VSS VSS VDD VDD _0195_ sky130_fd_sc_hd__o21ai_0
X_3988_ _0095_ _0193_ _0195_ VSS VSS VDD VDD _0196_ sky130_fd_sc_hd__a21oi_1
X_3989_ _2259_ _0196_ VSS VSS VDD VDD _0197_ sky130_fd_sc_hd__nor2_1
X_3990_ _0165_ _0197_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__xnor2_1
X_3991_ net176 _0177_ VSS VSS VDD VDD _0199_ sky130_fd_sc_hd__nor2_1
X_3992_ net176 _0198_ _0199_ VSS VSS VDD VDD _2388_ sky130_fd_sc_hd__a21oi_2
X_3993_ _0010_ _0078_ _0177_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__nor3_1
X_3994_ _2213_ _2259_ VSS VSS VDD VDD _0201_ sky130_fd_sc_hd__nor2_1
X_3995_ _2243_ _2259_ _0194_ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__nor3_1
X_3996_ _0180_ _0095_ _0201_ _0202_ VSS VSS VDD VDD _0203_
+ sky130_fd_sc_hd__a31oi_1
X_3997_ _0164_ _0203_ VSS VSS VDD VDD _0204_ sky130_fd_sc_hd__xnor2_1
X_3998_ _0066_ _0009_ _0071_ _0204_ VSS VSS VDD VDD _0205_
+ sky130_fd_sc_hd__and4_1
X_3999_ _0164_ _2259_ VSS VSS VDD VDD _0206_ sky130_fd_sc_hd__xor2_1
X_4000_ _0066_ _0013_ _0071_ _0206_ VSS VSS VDD VDD _0207_
+ sky130_fd_sc_hd__nor4_1
X_4001_ _0200_ _0205_ _0207_ _0106_ VSS VSS VDD VDD _0208_
+ sky130_fd_sc_hd__o31ai_2
X_4002_ _0115_ _0208_ VSS VSS VDD VDD _0209_ sky130_fd_sc_hd__nand2_1
X_4003_ _2384_ _0209_ VSS VSS VDD VDD _2355_ sky130_fd_sc_hd__xor2_1
X_4004_ _2248_ _0112_ VSS VSS VDD VDD _0210_ sky130_fd_sc_hd__or2_0
X_4005_ _2248_ _0112_ _0073_ _0057_ VSS VSS VDD VDD _0211_
+ sky130_fd_sc_hd__o211ai_1
X_4006_ _0057_ _0073_ _2240_ VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__nor3_1
X_4007_ _0073_ _2240_ _0212_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__a21oi_1
X_4008_ _0073_ _2240_ _0210_ _0211_ _0213_ VSS VSS VDD VDD
+ _0214_ sky130_fd_sc_hd__o311a_1
X_4009_ _0016_ _0078_ VSS VSS VDD VDD _0215_ sky130_fd_sc_hd__nor2_1
X_4010_ _0016_ _0214_ _0215_ VSS VSS VDD VDD _2360_ sky130_fd_sc_hd__a21oi_1
X_4011_ _2392_ _2396_ _0118_ VSS VSS VDD VDD _0216_ sky130_fd_sc_hd__nor3_1
X_4012_ _0216_ _0045_ VSS VSS VDD VDD _0217_ sky130_fd_sc_hd__nand2b_1
X_4013_ _2388_ _0217_ VSS VSS VDD VDD _2359_ sky130_fd_sc_hd__xor2_1
X_4014_ _2265_ _0137_ _2362_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__o21ai_1
X_4015_ _2361_ _0218_ VSS VSS VDD VDD _0219_ sky130_fd_sc_hd__nor2b_1
X_4016_ _2358_ _0219_ VSS VSS VDD VDD _2404_ sky130_fd_sc_hd__xnor2_2
X_4017_ _2341_ _2256_ _2340_ _2240_ _2248_ VSS VSS VDD VDD
+ _0220_ sky130_fd_sc_hd__a2111o_1
X_4018_ _0046_ _2240_ _2341_ _0066_ VSS VSS VDD VDD _0221_
+ sky130_fd_sc_hd__o211ai_1
X_4019_ _2341_ _2256_ _2340_ VSS VSS VDD VDD _0222_ sky130_fd_sc_hd__a21oi_1
X_4020_ _0221_ _0222_ VSS VSS VDD VDD _0223_ sky130_fd_sc_hd__nand2_1
X_4021_ _2349_ _2373_ VSS VSS VDD VDD _0224_ sky130_fd_sc_hd__and2_1
X_4022_ _0112_ _0220_ _0223_ _0224_ VSS VSS VDD VDD _0225_
+ sky130_fd_sc_hd__o211a_1
X_4023_ _2373_ VSS VSS VDD VDD _0226_ sky130_fd_sc_hd__buf_4
X_4024_ _0226_ _2348_ _2372_ VSS VSS VDD VDD _0227_ sky130_fd_sc_hd__a21o_1
X_4025_ _0225_ _0227_ _0012_ VSS VSS VDD VDD _0228_ sky130_fd_sc_hd__o21ai_0
X_4026_ _2377_ VSS VSS VDD VDD _0229_ sky130_fd_sc_hd__buf_2
X_4027_ _2373_ _2353_ VSS VSS VDD VDD _0230_ sky130_fd_sc_hd__nor2b_2
X_4028_ _0229_ _0230_ VSS VSS VDD VDD _0231_ sky130_fd_sc_hd__nor2_1
X_4029_ _2245_ _2261_ _2345_ VSS VSS VDD VDD _0232_ sky130_fd_sc_hd__or3_1
X_4030_ _2345_ VSS VSS VDD VDD _0233_ sky130_fd_sc_hd__inv_2
X_4031_ _2261_ _2345_ _2257_ VSS VSS VDD VDD _0234_ sky130_fd_sc_hd__nor3b_1
X_4032_ _2341_ _0233_ _2349_ _2373_ _0234_ VSS VSS VDD VDD
+ _0235_ sky130_fd_sc_hd__a2111oi_4
X_4033_ _0046_ _0189_ VSS VSS VDD VDD _0236_ sky130_fd_sc_hd__nand2_1
X_4034_ _0076_ _0232_ _0235_ _0236_ VSS VSS VDD VDD _0237_
+ sky130_fd_sc_hd__o211ai_1
X_4035_ _0008_ _0231_ _0237_ VSS VSS VDD VDD _0238_ sky130_fd_sc_hd__nand3_1
X_4036_ _2365_ VSS VSS VDD VDD _0239_ sky130_fd_sc_hd__clkbuf_4
X_4037_ _0239_ VSS VSS VDD VDD _0240_ sky130_fd_sc_hd__inv_1
X_4038_ _0228_ _0238_ _0240_ VSS VSS VDD VDD _0241_ sky130_fd_sc_hd__a21oi_1
X_4039_ _0240_ _0228_ _0238_ VSS VSS VDD VDD _0242_ sky130_fd_sc_hd__and3_1
X_4040_ _0241_ _0242_ VSS VSS VDD VDD _2570_ sky130_fd_sc_hd__nor2_1
X_4041_ _2349_ _2345_ VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__nand2b_1
X_4042_ _2353_ _0243_ VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__nand2b_2
X_4043_ _0164_ _0179_ _0244_ VSS VSS VDD VDD _0245_ sky130_fd_sc_hd__o21bai_1
X_4044_ _0055_ _0173_ _0175_ _0244_ _2261_ VSS VSS VDD VDD
+ _0246_ sky130_fd_sc_hd__a2111o_1
X_4045_ _0009_ _0245_ _0246_ VSS VSS VDD VDD _0247_ sky130_fd_sc_hd__nand3_1
X_4046_ _0164_ _0179_ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__nand2_1
X_4047_ _0179_ _2340_ _2348_ VSS VSS VDD VDD _0249_ sky130_fd_sc_hd__a21oi_1
X_4048_ _0170_ _0248_ _0249_ _0012_ VSS VSS VDD VDD _0250_
+ sky130_fd_sc_hd__o211ai_1
X_4049_ _0226_ _0247_ _0250_ VSS VSS VDD VDD _0251_ sky130_fd_sc_hd__nand3b_1
X_4050_ _0247_ _0250_ _0226_ VSS VSS VDD VDD _0252_ sky130_fd_sc_hd__a21bo_1
X_4051_ _0251_ _0252_ VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__and2_0
X_4052_ _0253_ VSS VSS VDD VDD _2502_ sky130_fd_sc_hd__inv_1
X_4053_ _0188_ _0190_ _0007_ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__a21oi_1
X_4054_ _0112_ _0220_ _0223_ VSS VSS VDD VDD _0255_ sky130_fd_sc_hd__o21ai_0
X_4055_ _0008_ _0255_ VSS VSS VDD VDD _0256_ sky130_fd_sc_hd__nor2_1
X_4056_ _0179_ _0254_ _0256_ VSS VSS VDD VDD _0257_ sky130_fd_sc_hd__nor3_1
X_4057_ _0254_ _0256_ _0179_ VSS VSS VDD VDD _0258_ sky130_fd_sc_hd__o21a_1
X_4058_ _0257_ _0258_ VSS VSS VDD VDD _2506_ sky130_fd_sc_hd__nor2_1
X_4059_ _0181_ _0179_ VSS VSS VDD VDD _0259_ sky130_fd_sc_hd__nor2b_1
X_4060_ _0164_ _0179_ _0196_ _0259_ _2351_ VSS VSS VDD VDD
+ _0260_ sky130_fd_sc_hd__a311oi_1
X_4061_ _0012_ _0245_ _0246_ VSS VSS VDD VDD _0261_ sky130_fd_sc_hd__and3_1
X_4062_ _0009_ _0260_ _0261_ VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__a21oi_2
X_4063_ _0226_ _0262_ VSS VSS VDD VDD _2379_ sky130_fd_sc_hd__xor2_4
X_4064_ _2382_ VSS VSS VDD VDD _0263_ sky130_fd_sc_hd__inv_1
X_4065_ _2230_ _2319_ _0160_ VSS VSS VDD VDD _0264_ sky130_fd_sc_hd__and3_1
X_4066_ _2393_ _2397_ VSS VSS VDD VDD _0265_ sky130_fd_sc_hd__nor2_1
X_4067_ _2319_ _2229_ _2318_ VSS VSS VDD VDD _0266_ sky130_fd_sc_hd__a21oi_1
X_4068_ _2401_ _0265_ _0266_ VSS VSS VDD VDD _0267_ sky130_fd_sc_hd__nand3b_1
X_4069_ _2402_ VSS VSS VDD VDD _0268_ sky130_fd_sc_hd__buf_2
X_4070_ _0268_ _2401_ _2398_ VSS VSS VDD VDD _0269_ sky130_fd_sc_hd__o21ai_0
X_4071_ _2394_ _2393_ VSS VSS VDD VDD _0270_ sky130_fd_sc_hd__nor2_1
X_4072_ _0265_ _0269_ _0270_ VSS VSS VDD VDD _0271_ sky130_fd_sc_hd__a21oi_1
X_4073_ _0264_ _0267_ _0271_ VSS VSS VDD VDD _0272_ sky130_fd_sc_hd__o21ai_4
X_4074_ _2386_ _2390_ VSS VSS VDD VDD _0273_ sky130_fd_sc_hd__nand2_1
X_4075_ _2386_ _2389_ _2385_ VSS VSS VDD VDD _0274_ sky130_fd_sc_hd__a21oi_1
X_4076_ _0272_ _0273_ _0274_ VSS VSS VDD VDD _0275_ sky130_fd_sc_hd__o21ai_1
X_4077_ _0263_ _0275_ VSS VSS VDD VDD _2594_ sky130_fd_sc_hd__xnor2_2
X_4078_ _2097_ _2230_ VSS VSS VDD VDD _0276_ sky130_fd_sc_hd__nor2b_1
X_4079_ _2229_ _0276_ _2319_ _2398_ _0268_ VSS VSS VDD VDD
+ _0277_ sky130_fd_sc_hd__o2111ai_4
X_4080_ _0268_ _2318_ _2401_ VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__a21o_1
X_4081_ _2398_ _0278_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__nand2_1
X_4082_ _0265_ _0277_ _0279_ _0270_ VSS VSS VDD VDD _0280_
+ sky130_fd_sc_hd__a31oi_4
X_4083_ _2390_ _0280_ _2389_ VSS VSS VDD VDD _0281_ sky130_fd_sc_hd__a21oi_2
X_4084_ _2386_ _0281_ VSS VSS VDD VDD _2598_ sky130_fd_sc_hd__xnor2_4
X_4085_ _2390_ _0272_ VSS VSS VDD VDD _2602_ sky130_fd_sc_hd__xnor2_2
X_4086_ _0277_ _0279_ VSS VSS VDD VDD _0282_ sky130_fd_sc_hd__nand2_1
X_4087_ _2397_ _0282_ VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__nor2_2
X_4088_ _2394_ _0283_ VSS VSS VDD VDD _2606_ sky130_fd_sc_hd__xnor2_4
X_4089_ _0264_ _0266_ VSS VSS VDD VDD _0284_ sky130_fd_sc_hd__nand2b_1
X_4090_ _0268_ _0284_ _2401_ VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__a21oi_2
X_4091_ _2398_ _0285_ VSS VSS VDD VDD _2610_ sky130_fd_sc_hd__xnor2_4
X_4092_ _2230_ VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__inv_1
X_4093_ _2318_ _0268_ VSS VSS VDD VDD _0287_ sky130_fd_sc_hd__nand2b_1
X_4094_ _2229_ _0287_ _2097_ VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__o21ai_0
X_4095_ _0268_ _2319_ VSS VSS VDD VDD _0289_ sky130_fd_sc_hd__nor2b_1
X_4096_ _2097_ _0289_ _2230_ VSS VSS VDD VDD _0290_ sky130_fd_sc_hd__o21ai_0
X_4097_ _0268_ _0266_ _0287_ _2319_ _0290_ VSS VSS VDD VDD
+ _0291_ sky130_fd_sc_hd__o221ai_1
X_4098_ _0286_ _0288_ _0291_ _2320_ VSS VSS VDD VDD _0292_
+ sky130_fd_sc_hd__a211oi_2
X_4099_ _2602_ _2606_ _2610_ _0292_ VSS VSS VDD VDD _0293_
+ sky130_fd_sc_hd__nor4b_2
X_4100_ _0293_ VSS VSS VDD VDD _0294_ sky130_fd_sc_hd__inv_1
X_4101_ _0158_ VSS VSS VDD VDD _0295_ sky130_fd_sc_hd__buf_6
X_4102_ _2598_ _0294_ net18 VSS VSS VDD VDD _0296_ sky130_fd_sc_hd__o21ai_0
X_4103_ _2594_ _0296_ VSS VSS VDD VDD _2403_ sky130_fd_sc_hd__xor2_1
X_4104_ _2270_ VSS VSS VDD VDD _0297_ sky130_fd_sc_hd__inv_1
X_4105_ _2278_ _2102_ _2277_ VSS VSS VDD VDD _0298_ sky130_fd_sc_hd__a21o_1
X_4106_ _2274_ _0298_ _2273_ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__a21oi_2
X_4107_ _0297_ _0299_ _2269_ VSS VSS VDD VDD _0300_ sky130_fd_sc_hd__o21bai_1
X_4108_ _2266_ _0300_ _2265_ VSS VSS VDD VDD _0301_ sky130_fd_sc_hd__a21oi_1
X_4109_ _2362_ _0301_ VSS VSS VDD VDD _2408_ sky130_fd_sc_hd__xnor2_2
X_4110_ _2229_ _0276_ _2319_ VSS VSS VDD VDD _0302_ sky130_fd_sc_hd__o21ai_0
X_4111_ _2318_ _0302_ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__nand2b_1
X_4112_ _0268_ _0303_ VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__xnor2_1
X_4113_ _0304_ VSS VSS VDD VDD _2478_ sky130_fd_sc_hd__inv_1
X_4114_ _2429_ _0304_ VSS VSS VDD VDD _0305_ sky130_fd_sc_hd__nand2_1
X_4115_ _2602_ _2606_ _2610_ _0305_ VSS VSS VDD VDD _0306_
+ sky130_fd_sc_hd__or4_2
X_4116_ net18 _0306_ VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__nand2_1
X_4117_ _2598_ _0307_ VSS VSS VDD VDD _2407_ sky130_fd_sc_hd__xor2_1
X_4118_ _2606_ _2610_ VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__nor2_1
X_4119_ _0292_ _0308_ net2 VSS VSS VDD VDD _0309_ sky130_fd_sc_hd__a21oi_1
X_4120_ _2602_ _0309_ VSS VSS VDD VDD _2411_ sky130_fd_sc_hd__xnor2_1
X_4121_ _2610_ _0305_ _0295_ VSS VSS VDD VDD _0310_ sky130_fd_sc_hd__o21ai_0
X_4122_ _2606_ _0310_ VSS VSS VDD VDD _2415_ sky130_fd_sc_hd__xor2_1
X_4123_ net2 _0292_ VSS VSS VDD VDD _0311_ sky130_fd_sc_hd__nor2_1
X_4124_ _2610_ _0311_ VSS VSS VDD VDD _2419_ sky130_fd_sc_hd__xnor2_1
X_4125_ _2429_ net2 VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__nor2_1
X_4126_ _2478_ _0312_ VSS VSS VDD VDD _2423_ sky130_fd_sc_hd__xnor2_1
X_4127_ _0295_ _2427_ VSS VSS VDD VDD _0313_ sky130_fd_sc_hd__nor2_1
X_4128_ _2430_ _0295_ _0313_ VSS VSS VDD VDD _2117_ sky130_fd_sc_hd__a21o_1
X_4129_ _2117_ VSS VSS VDD VDD _2121_ sky130_fd_sc_hd__inv_1
X_4130_ _2425_ VSS VSS VDD VDD _0314_ sky130_fd_sc_hd__inv_1
X_4131_ _2116_ _2432_ VSS VSS VDD VDD _0315_ sky130_fd_sc_hd__nor2b_1
X_4132_ _2431_ _0315_ _2426_ VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__o21ai_0
X_4133_ _0314_ _0316_ _2422_ VSS VSS VDD VDD _0317_ sky130_fd_sc_hd__a21boi_1
X_4134_ _2421_ _0317_ _2418_ VSS VSS VDD VDD _0318_ sky130_fd_sc_hd__o21a_1
X_4135_ _2417_ _0318_ VSS VSS VDD VDD _0319_ sky130_fd_sc_hd__nor2_1
X_4136_ _2414_ _0319_ VSS VSS VDD VDD _2630_ sky130_fd_sc_hd__xnor2_2
X_4137_ _2119_ _2426_ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__nand2b_1
X_4138_ _0314_ _0320_ _2422_ VSS VSS VDD VDD _0321_ sky130_fd_sc_hd__a21boi_0
X_4139_ _2421_ _0321_ VSS VSS VDD VDD _0322_ sky130_fd_sc_hd__nor2_1
X_4140_ _2418_ _0322_ VSS VSS VDD VDD _2634_ sky130_fd_sc_hd__xnor2_1
X_4141_ _2634_ VSS VSS VDD VDD _2493_ sky130_fd_sc_hd__inv_1
X_4142_ _0314_ _0316_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__nand2_1
X_4143_ _2422_ _0323_ VSS VSS VDD VDD _0324_ sky130_fd_sc_hd__nor2_1
X_4144_ _0317_ _0324_ VSS VSS VDD VDD _2638_ sky130_fd_sc_hd__nor2_2
X_4145_ _2638_ VSS VSS VDD VDD _2492_ sky130_fd_sc_hd__inv_1
X_4146_ _2414_ _2413_ _2410_ VSS VSS VDD VDD _0325_ sky130_fd_sc_hd__o21a_1
X_4147_ _2409_ _2413_ _2417_ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__nor3_1
X_4148_ _0318_ _0326_ VSS VSS VDD VDD _0327_ sky130_fd_sc_hd__nand2b_1
X_4149_ _2409_ _0325_ _0327_ VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__o21ai_1
X_4150_ _2406_ _0328_ VSS VSS VDD VDD _2622_ sky130_fd_sc_hd__xnor2_2
X_4151_ _2110_ VSS VSS VDD VDD _2106_ sky130_fd_sc_hd__inv_1
X_4152_ net69 VSS VSS VDD VDD _2471_ sky130_fd_sc_hd__inv_1
X_4153_ _2473_ _0041_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__nand2_1
X_4154_ _2471_ _0041_ _0329_ VSS VSS VDD VDD _2474_ sky130_fd_sc_hd__o21ai_2
X_4155_ _2474_ VSS VSS VDD VDD _2123_ sky130_fd_sc_hd__inv_1
X_4156_ _2463_ VSS VSS VDD VDD _0330_ sky130_fd_sc_hd__inv_1
X_4157_ _2468_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__inv_1
X_4158_ _2476_ net62 _2475_ VSS VSS VDD VDD _0332_ sky130_fd_sc_hd__a21o_1
X_4159_ _2470_ _0332_ _2469_ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__a21oi_4
X_4160_ _0333_ _0331_ _2467_ VSS VSS VDD VDD _0334_ sky130_fd_sc_hd__o21bai_1
X_4161_ _0334_ _2466_ _2465_ VSS VSS VDD VDD _0335_ sky130_fd_sc_hd__a21oi_2
X_4162_ _0335_ _0330_ _2462_ VSS VSS VDD VDD _0336_ sky130_fd_sc_hd__o21bai_1
X_4163_ _0336_ _2460_ _2459_ _2456_ VSS VSS VDD VDD _0337_
+ sky130_fd_sc_hd__a211o_1
X_4164_ _2457_ _2456_ _0337_ _2454_ VSS VSS VDD VDD _0338_
+ sky130_fd_sc_hd__o211ai_2
X_4165_ _2447_ _2450_ _2453_ VSS VSS VDD VDD _0339_ sky130_fd_sc_hd__nor3_1
X_4166_ _2451_ _2447_ _2450_ VSS VSS VDD VDD _0340_ sky130_fd_sc_hd__nor3_1
X_4167_ _2448_ _2447_ VSS VSS VDD VDD _0341_ sky130_fd_sc_hd__nor2_1
X_4168_ _0339_ _0338_ _0340_ _0341_ VSS VSS VDD VDD _0342_
+ sky130_fd_sc_hd__a211o_4
X_4169_ _2435_ _2445_ _2438_ _2441_ VSS VSS VDD VDD _0343_
+ sky130_fd_sc_hd__nand4_4
X_4170_ _2441_ _2444_ _2440_ VSS VSS VDD VDD _0344_ sky130_fd_sc_hd__a21oi_1
X_4171_ _0344_ _2438_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__nor2b_1
X_4172_ _2437_ _0345_ _2435_ VSS VSS VDD VDD _0346_ sky130_fd_sc_hd__o21ai_0
X_4173_ _2434_ _0346_ VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__nand2b_1
X_4174_ _0343_ _0342_ _0347_ VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__o21bai_4
X_4175_ net174 VSS VSS VDD VDD _2665_ sky130_fd_sc_hd__inv_6
X_4176_ _2323_ VSS VSS VDD VDD _0349_ sky130_fd_sc_hd__inv_1
X_4177_ _2326_ _2114_ _2325_ VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__a21oi_1
X_4178_ _0349_ _0350_ _2322_ VSS VSS VDD VDD _0351_ sky130_fd_sc_hd__o21bai_1
X_4179_ _2480_ _0351_ VSS VSS VDD VDD _2481_ sky130_fd_sc_hd__xor2_1
X_4180_ _2481_ VSS VSS VDD VDD _2645_ sky130_fd_sc_hd__inv_1
X_4181_ _2129_ _2491_ _2490_ VSS VSS VDD VDD _0352_ sky130_fd_sc_hd__a21o_1
X_4182_ _2487_ _0352_ _2486_ VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__a21oi_2
X_4183_ _2484_ _0353_ VSS VSS VDD VDD _2499_ sky130_fd_sc_hd__xnor2_2
X_4184_ _2499_ VSS VSS VDD VDD _2842_ sky130_fd_sc_hd__inv_1
X_4185_ _0239_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__clkbuf_2
X_4186_ _0226_ _2351_ _2375_ VSS VSS VDD VDD _0355_ sky130_fd_sc_hd__a21o_1
X_4187_ _0354_ _0070_ _0182_ _0355_ VSS VSS VDD VDD _0356_
+ sky130_fd_sc_hd__nor4_1
X_4188_ _0354_ _0224_ _0355_ VSS VSS VDD VDD _0357_ sky130_fd_sc_hd__nor3_1
X_4189_ _0354_ _0355_ _0357_ VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__a21o_1
X_4190_ _0354_ _0184_ _0355_ VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__nor3_1
X_4191_ _0070_ _0182_ _0224_ _0184_ _0354_ VSS VSS VDD VDD
+ _0360_ sky130_fd_sc_hd__o2111a_1
X_4192_ _0356_ _0358_ _0359_ _0360_ VSS VSS VDD VDD _0361_
+ sky130_fd_sc_hd__or4_2
X_4193_ _0354_ _0235_ _0236_ VSS VSS VDD VDD _0362_ sky130_fd_sc_hd__and3_1
X_4194_ _0235_ _0236_ _0354_ _0229_ _0230_ VSS VSS VDD VDD
+ _0363_ sky130_fd_sc_hd__a2111oi_2
X_4195_ _0239_ _0229_ _0230_ VSS VSS VDD VDD _0364_ sky130_fd_sc_hd__or3_1
X_4196_ _0229_ _0230_ _0354_ VSS VSS VDD VDD _0365_ sky130_fd_sc_hd__o21ai_0
X_4197_ _0076_ _0232_ _0364_ _0365_ VSS VSS VDD VDD _0366_
+ sky130_fd_sc_hd__o31ai_2
X_4198_ _0190_ _0362_ _0363_ _0366_ net171 VSS VSS VDD VDD
+ _0367_ sky130_fd_sc_hd__a2111oi_4
X_4199_ net176 _0361_ _0367_ VSS VSS VDD VDD _2530_ sky130_fd_sc_hd__a21oi_2
X_4200_ _2384_ _0208_ _2379_ VSS VSS VDD VDD _0368_ sky130_fd_sc_hd__or3_1
X_4201_ _0115_ _0368_ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__nand2_1
X_4202_ _2530_ _0369_ VSS VSS VDD VDD _2501_ sky130_fd_sc_hd__xor2_1
X_4203_ _2384_ _2388_ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__nor2_1
X_4204_ _0216_ _0370_ VSS VSS VDD VDD _0371_ sky130_fd_sc_hd__nand2_1
X_4205_ _0115_ _0371_ VSS VSS VDD VDD _0372_ sky130_fd_sc_hd__nand2_1
X_4206_ _2379_ _0372_ VSS VSS VDD VDD _2505_ sky130_fd_sc_hd__xor2_1
X_4207_ _2504_ VSS VSS VDD VDD _0373_ sky130_fd_sc_hd__inv_1
X_4208_ _2358_ _2508_ VSS VSS VDD VDD _0374_ sky130_fd_sc_hd__nand2_1
X_4209_ _2358_ _2361_ _2357_ VSS VSS VDD VDD _0375_ sky130_fd_sc_hd__a21o_1
X_4210_ _2508_ _0375_ _2507_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__a21oi_1
X_4211_ _0218_ _0374_ _0376_ VSS VSS VDD VDD _0377_ sky130_fd_sc_hd__o21ai_1
X_4212_ _0373_ _0377_ VSS VSS VDD VDD _2534_ sky130_fd_sc_hd__xnor2_2
X_4213_ _2519_ _2369_ VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__nor2b_1
X_4214_ _2523_ _0378_ VSS VSS VDD VDD _0379_ sky130_fd_sc_hd__nor2_1
X_4215_ _0231_ _0237_ _0239_ _2519_ VSS VSS VDD VDD _0380_
+ sky130_fd_sc_hd__a211o_1
X_4216_ _0379_ _0380_ VSS VSS VDD VDD _0381_ sky130_fd_sc_hd__and2_1
X_4217_ _2511_ VSS VSS VDD VDD _0382_ sky130_fd_sc_hd__clkbuf_4
X_4218_ _0382_ VSS VSS VDD VDD _0383_ sky130_fd_sc_hd__clkinvlp_4
X_4219_ _0383_ _0007_ VSS VSS VDD VDD _0384_ sky130_fd_sc_hd__nor2_1
X_4220_ _0382_ _0007_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__nor2_1
X_4221_ _0379_ _0380_ _0385_ VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__a21boi_1
X_4222_ _2519_ VSS VSS VDD VDD _0387_ sky130_fd_sc_hd__buf_4
X_4223_ _0387_ _2364_ _2518_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__a21oi_1
X_4224_ _0239_ _2519_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__and2_0
X_4225_ _0225_ _0227_ _0389_ VSS VSS VDD VDD _0390_ sky130_fd_sc_hd__o21ai_0
X_4226_ _0383_ _0007_ _0388_ _0390_ VSS VSS VDD VDD _0391_
+ sky130_fd_sc_hd__and4_1
X_4227_ _0382_ _0007_ VSS VSS VDD VDD _0392_ sky130_fd_sc_hd__nand2_1
X_4228_ _0388_ _0390_ _0392_ VSS VSS VDD VDD _0393_ sky130_fd_sc_hd__a21oi_1
X_4229_ _0381_ _0384_ _0386_ _0391_ _0393_ VSS VSS VDD VDD
+ _2566_ sky130_fd_sc_hd__a2111oi_4
X_4230_ _2261_ _2369_ _0229_ VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__nor3_1
X_4231_ _2353_ _0243_ _0394_ VSS VSS VDD VDD _0395_ sky130_fd_sc_hd__nand3b_1
X_4232_ _0055_ _0173_ _0175_ _0395_ VSS VSS VDD VDD _0396_
+ sky130_fd_sc_hd__a211oi_4
X_4233_ _0229_ VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__inv_1
X_4234_ _0226_ _0397_ _0239_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__a21oi_1
X_4235_ _2369_ _0229_ VSS VSS VDD VDD _0399_ sky130_fd_sc_hd__nor2_1
X_4236_ _0164_ _2349_ _0399_ VSS VSS VDD VDD _0400_ sky130_fd_sc_hd__o21ai_1
X_4237_ _2369_ _0398_ _0400_ _0244_ VSS VSS VDD VDD _0401_
+ sky130_fd_sc_hd__o22ai_4
X_4238_ _0396_ _0401_ VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__or2_0
X_4239_ _0164_ _0179_ _0226_ _0239_ VSS VSS VDD VDD _0403_
+ sky130_fd_sc_hd__and4_1
X_4240_ _2210_ _0022_ _0166_ _0403_ _0169_ VSS VSS VDD VDD
+ _0404_ sky130_fd_sc_hd__o311ai_4
X_4241_ _0226_ _0239_ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__nand2_1
X_4242_ _0249_ _0405_ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__nor2_1
X_4243_ _0239_ _2372_ _2364_ _0406_ VSS VSS VDD VDD _0407_
+ sky130_fd_sc_hd__a211oi_2
X_4244_ _0007_ _0404_ _0407_ VSS VSS VDD VDD _0408_ sky130_fd_sc_hd__nand3_1
X_4245_ _0012_ _0402_ _0408_ VSS VSS VDD VDD _0409_ sky130_fd_sc_hd__o21ai_1
X_4246_ _0387_ _0409_ VSS VSS VDD VDD _2574_ sky130_fd_sc_hd__xnor2_2
X_4247_ _0396_ _0401_ VSS VSS VDD VDD _0410_ sky130_fd_sc_hd__nor2_1
X_4248_ _2343_ _0179_ _2351_ _2375_ VSS VSS VDD VDD _0411_
+ sky130_fd_sc_hd__a211o_1
X_4249_ _0226_ _2375_ _0411_ _0354_ VSS VSS VDD VDD _0412_
+ sky130_fd_sc_hd__o211ai_1
X_4250_ _2259_ _0403_ _2367_ VSS VSS VDD VDD _0413_ sky130_fd_sc_hd__a21oi_1
X_4251_ _0412_ _0413_ VSS VSS VDD VDD _0414_ sky130_fd_sc_hd__nand2_1
X_4252_ _2243_ _0194_ _0403_ _0066_ VSS VSS VDD VDD _0415_
+ sky130_fd_sc_hd__o211ai_1
X_4253_ _0095_ _0193_ _0415_ VSS VSS VDD VDD _0416_ sky130_fd_sc_hd__a21oi_2
X_4254_ _0414_ _0416_ VSS VSS VDD VDD _0417_ sky130_fd_sc_hd__or2_0
X_4255_ _0014_ _0417_ VSS VSS VDD VDD _0418_ sky130_fd_sc_hd__nor2_1
X_4256_ _0014_ _0410_ _0418_ VSS VSS VDD VDD _0419_ sky130_fd_sc_hd__a21oi_1
X_4257_ _0387_ _0419_ VSS VSS VDD VDD _0420_ sky130_fd_sc_hd__xnor2_2
X_4258_ _0420_ VSS VSS VDD VDD _2525_ sky130_fd_sc_hd__inv_1
X_4259_ _2386_ _2382_ _2390_ VSS VSS VDD VDD _0421_ sky130_fd_sc_hd__nand3_1
X_4260_ _0263_ _0274_ _2381_ VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__o21bai_1
X_4261_ _0272_ _0421_ _0422_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__o21bai_1
X_4262_ _2532_ _0423_ _2531_ VSS VSS VDD VDD _0424_ sky130_fd_sc_hd__a21oi_1
X_4263_ _2528_ _0424_ VSS VSS VDD VDD _2586_ sky130_fd_sc_hd__xnor2_2
X_4264_ _2386_ _2382_ _2390_ _0280_ _0422_ VSS VSS VDD VDD
+ _0425_ sky130_fd_sc_hd__a41oi_4
X_4265_ _2532_ _0425_ VSS VSS VDD VDD _2590_ sky130_fd_sc_hd__xnor2_2
X_4266_ _2594_ _2598_ _2590_ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__nor3_1
X_4267_ _0293_ _0426_ net2 VSS VSS VDD VDD _0427_ sky130_fd_sc_hd__a21oi_1
X_4268_ _2586_ _0427_ VSS VSS VDD VDD _2533_ sky130_fd_sc_hd__xnor2_1
X_4269_ _2266_ _0300_ _2361_ _2357_ _2265_ VSS VSS VDD VDD
+ _0428_ sky130_fd_sc_hd__a2111oi_2
X_4270_ _2362_ _2357_ _2361_ VSS VSS VDD VDD _0429_ sky130_fd_sc_hd__nor3_1
X_4271_ _2358_ _2357_ VSS VSS VDD VDD _0430_ sky130_fd_sc_hd__nor2_1
X_4272_ _0428_ _0429_ _0430_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__nor3_2
X_4273_ _2508_ _0431_ VSS VSS VDD VDD _2538_ sky130_fd_sc_hd__xor2_4
X_4274_ _2594_ _2598_ _0306_ net18 VSS VSS VDD VDD _0432_
+ sky130_fd_sc_hd__o31ai_1
X_4275_ _2590_ _0432_ VSS VSS VDD VDD _2537_ sky130_fd_sc_hd__xor2_1
X_4276_ _2405_ _2539_ VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__nor2_1
X_4277_ _0326_ _0433_ VSS VSS VDD VDD _0434_ sky130_fd_sc_hd__nand2_1
X_4278_ _2409_ _0325_ _2406_ VSS VSS VDD VDD _0435_ sky130_fd_sc_hd__o21ai_1
X_4279_ _0435_ _0433_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__nand2_1
X_4280_ _2540_ _2539_ _0318_ _0434_ _0436_ VSS VSS VDD VDD
+ _0437_ sky130_fd_sc_hd__o221ai_4
X_4281_ _2536_ _0437_ VSS VSS VDD VDD _0438_ sky130_fd_sc_hd__xor2_2
X_4282_ _0438_ VSS VSS VDD VDD _2614_ sky130_fd_sc_hd__inv_1
X_4283_ _2543_ VSS VSS VDD VDD _0439_ sky130_fd_sc_hd__clkbuf_4
X_4284_ _0382_ _2551_ _0224_ _0389_ VSS VSS VDD VDD _0440_
+ sky130_fd_sc_hd__and4_1
X_4285_ _0112_ _0220_ _0223_ _0440_ VSS VSS VDD VDD _0441_
+ sky130_fd_sc_hd__o211a_1
X_4286_ _0382_ _2551_ VSS VSS VDD VDD _0442_ sky130_fd_sc_hd__nand2_1
X_4287_ _2551_ _2510_ _2550_ VSS VSS VDD VDD _0443_ sky130_fd_sc_hd__a21oi_1
X_4288_ _0387_ VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__inv_1
X_4289_ _0240_ _0444_ _0442_ VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__nor3_1
X_4290_ _0227_ _0445_ VSS VSS VDD VDD _0446_ sky130_fd_sc_hd__nand2_1
X_4291_ _0388_ _0442_ _0443_ _0446_ VSS VSS VDD VDD _0447_
+ sky130_fd_sc_hd__o211ai_1
X_4292_ _0239_ _0387_ _2511_ _2551_ VSS VSS VDD VDD _0448_
+ sky130_fd_sc_hd__nor4_2
X_4293_ _0076_ _0232_ _0235_ _0236_ _0448_ VSS VSS VDD VDD
+ _0449_ sky130_fd_sc_hd__o2111a_1
X_4294_ _2551_ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__clkinv_4
X_4295_ _2523_ _0378_ _0383_ _0450_ VSS VSS VDD VDD _0451_
+ sky130_fd_sc_hd__o211ai_1
X_4296_ _2515_ _0450_ _2555_ VSS VSS VDD VDD _0452_ sky130_fd_sc_hd__a21oi_1
X_4297_ _0229_ _0230_ _0448_ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__o21ai_0
X_4298_ _0451_ _0452_ _0453_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__nand3_1
X_4299_ _0449_ _0454_ _0008_ VSS VSS VDD VDD _0455_ sky130_fd_sc_hd__o21ai_0
X_4300_ _0008_ _0441_ _0447_ _0455_ VSS VSS VDD VDD _0456_
+ sky130_fd_sc_hd__o31ai_2
X_4301_ _0439_ _0456_ VSS VSS VDD VDD _2558_ sky130_fd_sc_hd__xnor2_2
X_4302_ _0449_ _0454_ _0013_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__o21ai_0
X_4303_ _0387_ _0382_ _2367_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__nand3_1
X_4304_ _0382_ _2521_ _2513_ VSS VSS VDD VDD _0459_ sky130_fd_sc_hd__a21oi_2
X_4305_ _0458_ _0459_ _0450_ VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__a21oi_1
X_4306_ _0355_ _0445_ _0460_ _2553_ VSS VSS VDD VDD _0461_
+ sky130_fd_sc_hd__a211oi_1
X_4307_ _0070_ _0182_ _0440_ _0184_ VSS VSS VDD VDD _0462_
+ sky130_fd_sc_hd__o211ai_1
X_4308_ net171 _0461_ _0462_ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__nand3_1
X_4309_ _0457_ _0463_ VSS VSS VDD VDD _0464_ sky130_fd_sc_hd__nand2_1
X_4310_ _0439_ _0464_ VSS VSS VDD VDD _2736_ sky130_fd_sc_hd__xnor2_2
X_4311_ _0383_ _2523_ _2515_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__a21oi_1
X_4312_ _0387_ _2511_ _0396_ _0401_ _0465_ VSS VSS VDD VDD
+ _0466_ sky130_fd_sc_hd__o41ai_4
X_4313_ _0412_ _0413_ _0459_ VSS VSS VDD VDD _0467_ sky130_fd_sc_hd__nand3_1
X_4314_ _0444_ _0383_ _0459_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__o21ai_0
X_4315_ _0416_ _0467_ _0468_ net171 VSS VSS VDD VDD _0469_
+ sky130_fd_sc_hd__o211ai_1
X_4316_ net171 _0466_ _0469_ VSS VSS VDD VDD _0470_ sky130_fd_sc_hd__o21ai_2
X_4317_ _0450_ _0470_ VSS VSS VDD VDD _2724_ sky130_fd_sc_hd__xnor2_4
X_4318_ _0070_ _0182_ _0224_ _0184_ VSS VSS VDD VDD _0471_
+ sky130_fd_sc_hd__o211ai_1
X_4319_ _2367_ _2521_ _0355_ VSS VSS VDD VDD _0472_ sky130_fd_sc_hd__nor3_1
X_4320_ _0354_ _2367_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__or2_0
X_4321_ _0387_ _0473_ _2521_ VSS VSS VDD VDD _0474_ sky130_fd_sc_hd__a21oi_1
X_4322_ _0471_ _0472_ _0474_ VSS VSS VDD VDD _0475_ sky130_fd_sc_hd__a21oi_1
X_4323_ _0384_ _0385_ _0475_ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__mux2i_2
X_4324_ _0383_ _0013_ _0379_ _0380_ VSS VSS VDD VDD _0477_
+ sky130_fd_sc_hd__nand4_1
X_4325_ _0381_ _0392_ _0476_ _0477_ VSS VSS VDD VDD _2578_
+ sky130_fd_sc_hd__o211ai_4
X_4326_ net36 net52 VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__xnor2_4
X_4327_ _0450_ _0466_ _2555_ _2547_ VSS VSS VDD VDD _0479_
+ sky130_fd_sc_hd__a211oi_1
X_4328_ _2547_ _0439_ VSS VSS VDD VDD _0480_ sky130_fd_sc_hd__nor2b_1
X_4329_ _0414_ _0416_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__nor2_1
X_4330_ _0387_ _0382_ _2551_ _0439_ VSS VSS VDD VDD _0482_
+ sky130_fd_sc_hd__nand4_1
X_4331_ _0450_ _0459_ _2553_ VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__o21bai_1
X_4332_ _0439_ _0483_ _2545_ VSS VSS VDD VDD _0484_ sky130_fd_sc_hd__a21oi_1
X_4333_ _0481_ _0482_ _0484_ net171 VSS VSS VDD VDD _0485_
+ sky130_fd_sc_hd__o211ai_1
X_4334_ _0008_ _0479_ _0480_ _0485_ VSS VSS VDD VDD _0486_
+ sky130_fd_sc_hd__o31a_2
X_4335_ _0478_ _0486_ VSS VSS VDD VDD _0487_ sky130_fd_sc_hd__xnor2_1
X_4336_ _2379_ _2530_ _0371_ _2578_ VSS VSS VDD VDD _0488_
+ sky130_fd_sc_hd__nor4_1
X_4337_ _0420_ _0488_ VSS VSS VDD VDD _0489_ sky130_fd_sc_hd__nand2_1
X_4338_ _2736_ _2724_ _0489_ _0115_ VSS VSS VDD VDD _0490_
+ sky130_fd_sc_hd__o31ai_1
X_4339_ _0487_ _0490_ VSS VSS VDD VDD _2557_ sky130_fd_sc_hd__xnor2_1
X_4340_ _0382_ _2518_ _2510_ VSS VSS VDD VDD _0491_ sky130_fd_sc_hd__a21oi_1
X_4341_ _0387_ _2518_ _0382_ VSS VSS VDD VDD _0492_ sky130_fd_sc_hd__o21ai_0
X_4342_ _2510_ VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__inv_1
X_4343_ _0404_ _0407_ _0491_ _0492_ _0493_ VSS VSS VDD VDD
+ _0494_ sky130_fd_sc_hd__a32o_1
X_4344_ _0466_ _0494_ _0012_ VSS VSS VDD VDD _0495_ sky130_fd_sc_hd__mux2i_2
X_4345_ _0450_ _0495_ VSS VSS VDD VDD _2562_ sky130_fd_sc_hd__xnor2_2
X_4346_ _2384_ _0208_ _2379_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__nor3_1
X_4347_ net176 _0361_ _0417_ _0402_ _0367_ VSS VSS VDD VDD
+ _0497_ sky130_fd_sc_hd__a32oi_1
X_4348_ net176 _0361_ _0481_ _0410_ _0367_ VSS VSS VDD VDD
+ _0498_ sky130_fd_sc_hd__a32oi_1
X_4349_ _0497_ _0498_ _0444_ VSS VSS VDD VDD _0499_ sky130_fd_sc_hd__mux2_1
X_4350_ _2578_ _0499_ VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__nor2_1
X_4351_ _0496_ _0500_ VSS VSS VDD VDD _0501_ sky130_fd_sc_hd__nand2_1
X_4352_ _2724_ _0501_ net4 VSS VSS VDD VDD _0502_ sky130_fd_sc_hd__o21ai_1
X_4353_ _2736_ _0502_ VSS VSS VDD VDD _2561_ sky130_fd_sc_hd__xor2_1
X_4354_ _0115_ _0489_ VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__nand2_1
X_4355_ _2724_ _0503_ VSS VSS VDD VDD _2565_ sky130_fd_sc_hd__xor2_1
X_4356_ _0368_ _0499_ net4 VSS VSS VDD VDD _0504_ sky130_fd_sc_hd__o21ai_0
X_4357_ _2578_ _0504_ VSS VSS VDD VDD _2573_ sky130_fd_sc_hd__xor2_1
X_4358_ _2379_ _2530_ _0371_ _0125_ VSS VSS VDD VDD _0505_
+ sky130_fd_sc_hd__o31ai_1
X_4359_ _0420_ _0505_ VSS VSS VDD VDD _2569_ sky130_fd_sc_hd__xnor2_1
X_4360_ _2508_ _2357_ _2507_ VSS VSS VDD VDD _0506_ sky130_fd_sc_hd__a21o_1
X_4361_ _2504_ _0506_ _2503_ VSS VSS VDD VDD _0507_ sky130_fd_sc_hd__a21oi_1
X_4362_ _2265_ _2361_ VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__nor2_1
X_4363_ _0507_ _0508_ VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__nand2_1
X_4364_ _2266_ _0300_ _0509_ VSS VSS VDD VDD _0510_ sky130_fd_sc_hd__a21oi_1
X_4365_ _2362_ _2361_ VSS VSS VDD VDD _0511_ sky130_fd_sc_hd__nor2_1
X_4366_ _0373_ _0374_ _0511_ _0507_ VSS VSS VDD VDD _0512_
+ sky130_fd_sc_hd__o31a_1
X_4367_ _2576_ _2568_ _2572_ VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__nand3_1
X_4368_ _0510_ _0512_ _0513_ VSS VSS VDD VDD _0514_ sky130_fd_sc_hd__nor3_1
X_4369_ _2576_ _2568_ _2571_ VSS VSS VDD VDD _0515_ sky130_fd_sc_hd__and3_1
X_4370_ _2568_ _2575_ _0514_ _0515_ _2567_ VSS VSS VDD VDD
+ _0516_ sky130_fd_sc_hd__a2111o_1
X_4371_ _2564_ _0516_ _2563_ VSS VSS VDD VDD _0517_ sky130_fd_sc_hd__a21oi_1
X_4372_ _2560_ _0517_ VSS VSS VDD VDD _2756_ sky130_fd_sc_hd__xnor2_2
X_4373_ _0373_ _0374_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__nor2_1
X_4374_ _2265_ _0137_ _0518_ _2362_ VSS VSS VDD VDD _0519_
+ sky130_fd_sc_hd__o211ai_1
X_4375_ _0373_ _0376_ VSS VSS VDD VDD _0520_ sky130_fd_sc_hd__nor2_1
X_4376_ _2503_ _0520_ VSS VSS VDD VDD _0521_ sky130_fd_sc_hd__nor2_1
X_4377_ _2572_ VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__clkinvlp_4
X_4378_ _0519_ _0521_ _0522_ VSS VSS VDD VDD _0523_ sky130_fd_sc_hd__a21o_1
X_4379_ _2571_ _2575_ VSS VSS VDD VDD _0524_ sky130_fd_sc_hd__nor2_1
X_4380_ _2576_ _2575_ _2568_ VSS VSS VDD VDD _0525_ sky130_fd_sc_hd__o21ai_0
X_4381_ _0523_ _0524_ _0525_ VSS VSS VDD VDD _0526_ sky130_fd_sc_hd__a21oi_1
X_4382_ _2567_ _0526_ VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__or2_1
X_4383_ _2564_ _0527_ VSS VSS VDD VDD _2764_ sky130_fd_sc_hd__xor2_2
X_4384_ _2571_ VSS VSS VDD VDD _0528_ sky130_fd_sc_hd__inv_1
X_4385_ _0522_ _0510_ _0512_ _0528_ VSS VSS VDD VDD _0529_
+ sky130_fd_sc_hd__o31ai_1
X_4386_ _2576_ _0529_ _2575_ VSS VSS VDD VDD _0530_ sky130_fd_sc_hd__a21oi_1
X_4387_ _2568_ _0530_ VSS VSS VDD VDD _2760_ sky130_fd_sc_hd__xnor2_2
X_4388_ _0528_ _0523_ VSS VSS VDD VDD _0531_ sky130_fd_sc_hd__nand2_1
X_4389_ _2576_ _0531_ VSS VSS VDD VDD _2728_ sky130_fd_sc_hd__xor2_4
X_4390_ _0510_ _0512_ VSS VSS VDD VDD _0532_ sky130_fd_sc_hd__nor2_1
X_4391_ _0522_ _0532_ VSS VSS VDD VDD _2732_ sky130_fd_sc_hd__xnor2_4
X_4392_ _2532_ _2531_ _2528_ VSS VSS VDD VDD _0533_ sky130_fd_sc_hd__o21ai_1
X_4393_ _2531_ _0425_ VSS VSS VDD VDD _0534_ sky130_fd_sc_hd__nor2b_1
X_4394_ _2527_ VSS VSS VDD VDD _0535_ sky130_fd_sc_hd__inv_1
X_4395_ _0533_ _0534_ _0535_ VSS VSS VDD VDD _0536_ sky130_fd_sc_hd__o21ai_1
X_4396_ _2580_ _0536_ VSS VSS VDD VDD _0537_ sky130_fd_sc_hd__xnor2_2
X_4397_ _0537_ VSS VSS VDD VDD _2581_ sky130_fd_sc_hd__inv_1
X_4398_ _2480_ _0351_ _2479_ VSS VSS VDD VDD _0538_ sky130_fd_sc_hd__a21oi_2
X_4399_ _2604_ _2608_ _2612_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__nand3_1
X_4400_ _2604_ _2607_ _2603_ VSS VSS VDD VDD _0540_ sky130_fd_sc_hd__a21o_1
X_4401_ _2604_ _2608_ _2611_ _0540_ VSS VSS VDD VDD _0541_
+ sky130_fd_sc_hd__a31oi_2
X_4402_ _0538_ _0539_ _0541_ VSS VSS VDD VDD _0542_ sky130_fd_sc_hd__o21ai_4
X_4403_ _2592_ _2596_ _2599_ VSS VSS VDD VDD _0543_ sky130_fd_sc_hd__nand3_1
X_4404_ _2592_ _2595_ VSS VSS VDD VDD _0544_ sky130_fd_sc_hd__nand2_1
X_4405_ _0543_ _0544_ VSS VSS VDD VDD _0545_ sky130_fd_sc_hd__nand2_1
X_4406_ _2592_ _2596_ _2600_ _0542_ _0545_ VSS VSS VDD VDD
+ _0546_ sky130_fd_sc_hd__a41oi_4
X_4407_ _2584_ _2587_ _2591_ VSS VSS VDD VDD _0547_ sky130_fd_sc_hd__nor3_1
X_4408_ _2584_ _2588_ _2587_ VSS VSS VDD VDD _0548_ sky130_fd_sc_hd__nor3_1
X_4409_ _2587_ _2591_ VSS VSS VDD VDD _0549_ sky130_fd_sc_hd__nor2_1
X_4410_ _2588_ _2587_ _2584_ VSS VSS VDD VDD _0550_ sky130_fd_sc_hd__o21ai_1
X_4411_ _0546_ _0549_ _0550_ VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__a21oi_2
X_4412_ _0546_ _0547_ _0548_ _0551_ VSS VSS VDD VDD _2772_
+ sky130_fd_sc_hd__a211oi_4
X_4413_ _2595_ _2599_ VSS VSS VDD VDD _0552_ sky130_fd_sc_hd__nor2_1
X_4414_ _2322_ _2479_ _2611_ VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__nor3_1
X_4415_ _0349_ _0163_ _0553_ VSS VSS VDD VDD _0554_ sky130_fd_sc_hd__o21ai_1
X_4416_ _2612_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__inv_1
X_4417_ _2480_ _2479_ VSS VSS VDD VDD _0556_ sky130_fd_sc_hd__nor2_1
X_4418_ _2611_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__inv_1
X_4419_ _0555_ _0556_ _0557_ VSS VSS VDD VDD _0558_ sky130_fd_sc_hd__o21ai_1
X_4420_ _2604_ _2608_ _0554_ _0558_ _0540_ VSS VSS VDD VDD
+ _0559_ sky130_fd_sc_hd__a41oi_2
X_4421_ _2600_ _2599_ _2596_ VSS VSS VDD VDD _0560_ sky130_fd_sc_hd__o21a_1
X_4422_ _2595_ _0560_ VSS VSS VDD VDD _0561_ sky130_fd_sc_hd__nor2_1
X_4423_ _0552_ _0559_ _0561_ VSS VSS VDD VDD _0562_ sky130_fd_sc_hd__a21oi_1
X_4424_ _2592_ _0562_ _2591_ VSS VSS VDD VDD _0563_ sky130_fd_sc_hd__a21oi_1
X_4425_ _2588_ _0563_ VSS VSS VDD VDD _2802_ sky130_fd_sc_hd__xnor2_2
X_4426_ _2600_ _0542_ _2599_ VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__a21o_1
X_4427_ _2596_ _0564_ _2595_ VSS VSS VDD VDD _0565_ sky130_fd_sc_hd__a21oi_1
X_4428_ _2592_ _0565_ VSS VSS VDD VDD _2778_ sky130_fd_sc_hd__xnor2_2
X_4429_ _0559_ _2600_ VSS VSS VDD VDD _0566_ sky130_fd_sc_hd__nor2b_1
X_4430_ _2599_ _0566_ VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__nor2_1
X_4431_ _2596_ _0567_ VSS VSS VDD VDD _2782_ sky130_fd_sc_hd__xnor2_2
X_4432_ _2600_ _0542_ VSS VSS VDD VDD _2786_ sky130_fd_sc_hd__xor2_2
X_4433_ _2646_ _2645_ VSS VSS VDD VDD _0568_ sky130_fd_sc_hd__nand2_1
X_4434_ _2608_ _0554_ _0558_ _2607_ VSS VSS VDD VDD _0569_
+ sky130_fd_sc_hd__a31oi_2
X_4435_ _2604_ _0569_ VSS VSS VDD VDD _2790_ sky130_fd_sc_hd__xnor2_2
X_4436_ _0555_ _0538_ _0557_ VSS VSS VDD VDD _0570_ sky130_fd_sc_hd__o21ai_1
X_4437_ _2608_ _0570_ VSS VSS VDD VDD _0571_ sky130_fd_sc_hd__xnor2_2
X_4438_ _0349_ _0163_ _2322_ VSS VSS VDD VDD _0572_ sky130_fd_sc_hd__o21bai_1
X_4439_ _2480_ _0572_ _2479_ VSS VSS VDD VDD _0573_ sky130_fd_sc_hd__a21oi_1
X_4440_ _0555_ _0573_ VSS VSS VDD VDD _0574_ sky130_fd_sc_hd__xnor2_1
X_4441_ _0571_ _0574_ VSS VSS VDD VDD _0575_ sky130_fd_sc_hd__nand2_1
X_4442_ _2786_ _2790_ _0575_ VSS VSS VDD VDD _0576_ sky130_fd_sc_hd__nor3_1
X_4443_ _2802_ _2778_ _2782_ _0576_ VSS VSS VDD VDD _0577_
+ sky130_fd_sc_hd__or4b_1
X_4444_ net174 VSS VSS VDD VDD _0578_ sky130_fd_sc_hd__buf_2
X_4445_ _0568_ _0577_ _0578_ VSS VSS VDD VDD _0579_ sky130_fd_sc_hd__o21ai_0
X_4446_ _2772_ _0579_ VSS VSS VDD VDD _2613_ sky130_fd_sc_hd__xor2_1
X_4447_ _0574_ VSS VSS VDD VDD _2696_ sky130_fd_sc_hd__inv_1
X_4448_ _2647_ VSS VSS VDD VDD _0580_ sky130_fd_sc_hd__inv_1
X_4449_ _2782_ _0576_ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__nand2b_1
X_4450_ _0580_ _2778_ _0581_ net6 VSS VSS VDD VDD _0582_ sky130_fd_sc_hd__o31a_1
X_4451_ _2802_ _0582_ VSS VSS VDD VDD _2617_ sky130_fd_sc_hd__xnor2_1
X_4452_ _0568_ _0581_ _0578_ VSS VSS VDD VDD _0583_ sky130_fd_sc_hd__o21ai_0
X_4453_ _2778_ _0583_ VSS VSS VDD VDD _2621_ sky130_fd_sc_hd__xor2_1
X_4454_ _2647_ _0576_ _2665_ VSS VSS VDD VDD _0584_ sky130_fd_sc_hd__a21oi_1
X_4455_ _2782_ _0584_ VSS VSS VDD VDD _2625_ sky130_fd_sc_hd__xnor2_1
X_4456_ _0568_ _2790_ _0575_ _0578_ VSS VSS VDD VDD _0585_
+ sky130_fd_sc_hd__o31ai_1
X_4457_ _2786_ _0585_ VSS VSS VDD VDD _2629_ sky130_fd_sc_hd__xor2_1
X_4458_ _0580_ _0575_ net174 VSS VSS VDD VDD _0586_ sky130_fd_sc_hd__o21ai_0
X_4459_ _2790_ _0586_ VSS VSS VDD VDD _2633_ sky130_fd_sc_hd__xor2_1
X_4460_ _0568_ _2696_ _0578_ VSS VSS VDD VDD _0587_ sky130_fd_sc_hd__o21ai_0
X_4461_ _0571_ _0587_ VSS VSS VDD VDD _2637_ sky130_fd_sc_hd__xnor2_1
X_4462_ _2647_ _2665_ VSS VSS VDD VDD _0588_ sky130_fd_sc_hd__nor2_1
X_4463_ _2696_ _0588_ VSS VSS VDD VDD _2641_ sky130_fd_sc_hd__xnor2_1
X_4464_ _0348_ VSS VSS VDD VDD _2652_ sky130_fd_sc_hd__buf_6
X_4465_ net9 _2645_ VSS VSS VDD VDD _0589_ sky130_fd_sc_hd__nor2_1
X_4466_ _2648_ net9 _0589_ VSS VSS VDD VDD _2132_ sky130_fd_sc_hd__a21oi_2
X_4467_ _2627_ VSS VSS VDD VDD _0590_ sky130_fd_sc_hd__inv_1
X_4468_ _2635_ VSS VSS VDD VDD _0591_ sky130_fd_sc_hd__inv_1
X_4469_ _2643_ VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__inv_1
X_4470_ _2337_ _2650_ VSS VSS VDD VDD _0593_ sky130_fd_sc_hd__nor2b_1
X_4471_ _2649_ _0593_ _2644_ VSS VSS VDD VDD _0594_ sky130_fd_sc_hd__o21ai_0
X_4472_ _0592_ _0594_ _2640_ VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__a21boi_0
X_4473_ _2639_ _0595_ _2636_ VSS VSS VDD VDD _0596_ sky130_fd_sc_hd__o21ai_0
X_4474_ _0591_ _0596_ _2632_ VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__a21boi_0
X_4475_ _2631_ _0597_ _2628_ VSS VSS VDD VDD _0598_ sky130_fd_sc_hd__o21ai_1
X_4476_ _2624_ _2620_ _2616_ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__nand3_1
X_4477_ _0590_ _0598_ _0599_ VSS VSS VDD VDD _0600_ sky130_fd_sc_hd__a21o_1
X_4478_ _2620_ _2616_ _2623_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__and3_1
X_4479_ _2616_ _2619_ _0601_ VSS VSS VDD VDD _0602_ sky130_fd_sc_hd__a21oi_1
X_4480_ _0600_ _0602_ VSS VSS VDD VDD _0603_ sky130_fd_sc_hd__nand2_1
X_4481_ _0590_ _0598_ VSS VSS VDD VDD _0604_ sky130_fd_sc_hd__nand2_2
X_4482_ _2624_ _0604_ _2623_ VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__a21o_1
X_4483_ _2620_ _0605_ _2619_ _2616_ VSS VSS VDD VDD _0606_
+ sky130_fd_sc_hd__a211oi_1
X_4484_ _0603_ _0606_ VSS VSS VDD VDD _2848_ sky130_fd_sc_hd__nor2_2
X_4485_ _0591_ _0596_ VSS VSS VDD VDD _0607_ sky130_fd_sc_hd__nand2_1
X_4486_ _2632_ _0607_ VSS VSS VDD VDD _0608_ sky130_fd_sc_hd__nor2_1
X_4487_ _0597_ _0608_ VSS VSS VDD VDD _2826_ sky130_fd_sc_hd__nor2_1
X_4488_ _2826_ VSS VSS VDD VDD _2715_ sky130_fd_sc_hd__inv_1
X_4489_ _2134_ _2644_ _2643_ VSS VSS VDD VDD _0609_ sky130_fd_sc_hd__a21o_1
X_4490_ _2640_ _0609_ _2639_ VSS VSS VDD VDD _0610_ sky130_fd_sc_hd__a21oi_1
X_4491_ _2636_ _0610_ VSS VSS VDD VDD _2830_ sky130_fd_sc_hd__xnor2_2
X_4492_ _2830_ VSS VSS VDD VDD _2714_ sky130_fd_sc_hd__inv_1
X_4493_ _2678_ VSS VSS VDD VDD _0611_ sky130_fd_sc_hd__inv_1
X_4494_ _2684_ VSS VSS VDD VDD _0612_ sky130_fd_sc_hd__inv_1
X_4495_ _2690_ VSS VSS VDD VDD _0613_ sky130_fd_sc_hd__inv_1
X_4496_ net62 _2694_ VSS VSS VDD VDD _0614_ sky130_fd_sc_hd__nor2b_1
X_4497_ _0614_ _2693_ _2691_ VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__o21ai_1
X_4498_ _0615_ _0613_ _2688_ VSS VSS VDD VDD _0616_ sky130_fd_sc_hd__a21boi_2
X_4499_ _0616_ _2687_ _2685_ VSS VSS VDD VDD _0617_ sky130_fd_sc_hd__o21ai_2
X_4500_ _0612_ _0617_ _2682_ VSS VSS VDD VDD _0618_ sky130_fd_sc_hd__a21boi_2
X_4501_ _0618_ _2681_ _2679_ VSS VSS VDD VDD _0619_ sky130_fd_sc_hd__o21ai_2
X_4502_ _2673_ _2676_ VSS VSS VDD VDD _0620_ sky130_fd_sc_hd__nand2_1
X_4503_ _0611_ _0619_ _0620_ VSS VSS VDD VDD _0621_ sky130_fd_sc_hd__a21oi_2
X_4504_ _2673_ _2675_ _2672_ VSS VSS VDD VDD _0622_ sky130_fd_sc_hd__a21o_1
X_4505_ _0622_ _0621_ _2670_ VSS VSS VDD VDD _0623_ sky130_fd_sc_hd__o21ai_1
X_4506_ _2669_ _0623_ VSS VSS VDD VDD _0624_ sky130_fd_sc_hd__nand2b_1
X_4507_ _0624_ _2667_ _2666_ VSS VSS VDD VDD _0625_ sky130_fd_sc_hd__a21o_1
X_4508_ _0625_ _2663_ _2662_ VSS VSS VDD VDD _0626_ sky130_fd_sc_hd__a21o_1
X_4509_ _2654_ _2657_ VSS VSS VDD VDD _0627_ sky130_fd_sc_hd__and2_0
X_4510_ _2654_ _2656_ _2659_ _0627_ VSS VSS VDD VDD _0628_
+ sky130_fd_sc_hd__a22o_1
X_4511_ _2660_ _0627_ _0626_ _0628_ _2653_ VSS VSS VDD VDD
+ _0629_ sky130_fd_sc_hd__a311o_4
X_4512_ _0629_ VSS VSS VDD VDD _2868_ sky130_fd_sc_hd__clkinv_4
X_4513_ _2421_ _0321_ _2418_ VSS VSS VDD VDD _0630_ sky130_fd_sc_hd__o21ai_1
X_4514_ _0630_ _0326_ _0435_ VSS VSS VDD VDD _0631_ sky130_fd_sc_hd__a21oi_1
X_4515_ _2405_ _0631_ _2540_ VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__o21a_1
X_4516_ _2540_ _2405_ _0631_ VSS VSS VDD VDD _0633_ sky130_fd_sc_hd__nor3_1
X_4517_ _0632_ _0633_ VSS VSS VDD VDD _2618_ sky130_fd_sc_hd__nor2_2
X_4518_ _2487_ VSS VSS VDD VDD _0634_ sky130_fd_sc_hd__inv_1
X_4519_ _2127_ _2497_ _2496_ VSS VSS VDD VDD _0635_ sky130_fd_sc_hd__a21o_1
X_4520_ _2491_ _0635_ _2490_ VSS VSS VDD VDD _0636_ sky130_fd_sc_hd__a21oi_1
X_4521_ _0634_ _0636_ _2486_ VSS VSS VDD VDD _0637_ sky130_fd_sc_hd__o21bai_1
X_4522_ _2484_ _0637_ _2483_ VSS VSS VDD VDD _0638_ sky130_fd_sc_hd__a21oi_2
X_4523_ _2698_ _0638_ VSS VSS VDD VDD _2699_ sky130_fd_sc_hd__xnor2_2
X_4524_ _2699_ VSS VSS VDD VDD _2841_ sky130_fd_sc_hd__inv_1
X_4525_ _2636_ VSS VSS VDD VDD _0639_ sky130_fd_sc_hd__inv_1
X_4526_ _0639_ _0610_ _0591_ VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__o21ai_0
X_4527_ _2632_ _0640_ _2631_ VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__a21oi_2
X_4528_ _2628_ _0641_ VSS VSS VDD VDD _2822_ sky130_fd_sc_hd__xnor2_2
X_4529_ _2624_ _0604_ VSS VSS VDD VDD _2818_ sky130_fd_sc_hd__xor2_4
X_4530_ _2709_ VSS VSS VDD VDD _0642_ sky130_fd_sc_hd__inv_1
X_4531_ _2136_ _2719_ _2718_ VSS VSS VDD VDD _0643_ sky130_fd_sc_hd__a21o_1
X_4532_ _2713_ _0643_ _2712_ VSS VSS VDD VDD _0644_ sky130_fd_sc_hd__a21oi_1
X_4533_ _0642_ _0644_ _2708_ VSS VSS VDD VDD _0645_ sky130_fd_sc_hd__o21bai_1
X_4534_ _2705_ _0645_ _2704_ VSS VSS VDD VDD _0646_ sky130_fd_sc_hd__a21oi_2
X_4535_ _2702_ _0646_ VSS VSS VDD VDD _2721_ sky130_fd_sc_hd__xnor2_2
X_4536_ _2721_ VSS VSS VDD VDD _3024_ sky130_fd_sc_hd__inv_1
X_4537_ _2386_ _2389_ _2531_ _2381_ _2385_ VSS VSS VDD VDD
+ _0647_ sky130_fd_sc_hd__a2111oi_1
X_4538_ _2382_ _2381_ _2531_ VSS VSS VDD VDD _0648_ sky130_fd_sc_hd__nor3_1
X_4539_ _0533_ _0647_ _0648_ _0535_ VSS VSS VDD VDD _0649_
+ sky130_fd_sc_hd__o31ai_1
X_4540_ _2580_ _0649_ _2579_ VSS VSS VDD VDD _0650_ sky130_fd_sc_hd__a21o_1
X_4541_ _0421_ _0533_ VSS VSS VDD VDD _0651_ sky130_fd_sc_hd__nor2_1
X_4542_ _2580_ _0651_ VSS VSS VDD VDD _0652_ sky130_fd_sc_hd__nand2_1
X_4543_ _0272_ _0652_ VSS VSS VDD VDD _0653_ sky130_fd_sc_hd__nor2_1
X_4544_ _0650_ _0653_ VSS VSS VDD VDD _0654_ sky130_fd_sc_hd__nor2_1
X_4545_ _2726_ _0654_ VSS VSS VDD VDD _2744_ sky130_fd_sc_hd__xnor2_2
X_4546_ _2586_ _0426_ VSS VSS VDD VDD _0655_ sky130_fd_sc_hd__nor2b_1
X_4547_ _0293_ _0537_ _0655_ _0159_ VSS VSS VDD VDD _0656_
+ sky130_fd_sc_hd__a31oi_1
X_4548_ _2744_ _0656_ VSS VSS VDD VDD _2727_ sky130_fd_sc_hd__xnor2_1
X_4549_ _0306_ _0655_ VSS VSS VDD VDD _0657_ sky130_fd_sc_hd__nor2b_1
X_4550_ net2 _0657_ VSS VSS VDD VDD _0658_ sky130_fd_sc_hd__nor2_1
X_4551_ _2581_ _0658_ VSS VSS VDD VDD _2731_ sky130_fd_sc_hd__xnor2_1
X_4552_ _2536_ _2734_ VSS VSS VDD VDD _0659_ sky130_fd_sc_hd__nand2_1
X_4553_ _2734_ _2535_ _2733_ VSS VSS VDD VDD _0660_ sky130_fd_sc_hd__a21oi_1
X_4554_ _0437_ _0659_ _0660_ VSS VSS VDD VDD _0661_ sky130_fd_sc_hd__o21ai_2
X_4555_ _2730_ _0661_ VSS VSS VDD VDD _2748_ sky130_fd_sc_hd__xor2_4
X_4556_ _2726_ _0650_ _2725_ VSS VSS VDD VDD _0662_ sky130_fd_sc_hd__a21oi_1
X_4557_ _2580_ _2726_ _0280_ _0651_ VSS VSS VDD VDD _0663_
+ sky130_fd_sc_hd__nand4_1
X_4558_ _0662_ _0663_ VSS VSS VDD VDD _0664_ sky130_fd_sc_hd__nand2_1
X_4559_ _2738_ _0664_ VSS VSS VDD VDD _2739_ sky130_fd_sc_hd__xor2_4
X_4560_ _2583_ _0551_ _2746_ VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__o21a_1
X_4561_ _2745_ _0665_ VSS VSS VDD VDD _0666_ sky130_fd_sc_hd__nor2_1
X_4562_ _2742_ _0666_ VSS VSS VDD VDD _2768_ sky130_fd_sc_hd__xnor2_4
X_4563_ _2592_ _0562_ _0549_ VSS VSS VDD VDD _0667_ sky130_fd_sc_hd__a21boi_0
X_4564_ _0550_ _0667_ _2583_ VSS VSS VDD VDD _0668_ sky130_fd_sc_hd__o21bai_2
X_4565_ _2746_ _0668_ VSS VSS VDD VDD _2798_ sky130_fd_sc_hd__xor2_4
X_4566_ _2772_ _0568_ _0577_ _2798_ VSS VSS VDD VDD _0669_
+ sky130_fd_sc_hd__or4_1
X_4567_ _0578_ _0669_ VSS VSS VDD VDD _0670_ sky130_fd_sc_hd__nand2_1
X_4568_ _2768_ _0670_ VSS VSS VDD VDD _2747_ sky130_fd_sc_hd__xor2_1
X_4569_ _2539_ _0632_ _2536_ VSS VSS VDD VDD _0671_ sky130_fd_sc_hd__o21ai_2
X_4570_ _2535_ _0671_ VSS VSS VDD VDD _0672_ sky130_fd_sc_hd__nand2b_1
X_4571_ _2734_ _0672_ VSS VSS VDD VDD _2752_ sky130_fd_sc_hd__xor2_2
X_4572_ _0580_ _2772_ _0577_ VSS VSS VDD VDD _0673_ sky130_fd_sc_hd__or3_1
X_4573_ _0578_ _0673_ VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__nand2_1
X_4574_ _2798_ _0674_ VSS VSS VDD VDD _2751_ sky130_fd_sc_hd__xor2_1
X_4575_ _2615_ _0603_ _2754_ VSS VSS VDD VDD _0675_ sky130_fd_sc_hd__o21ai_1
X_4576_ _2750_ _2753_ VSS VSS VDD VDD _0676_ sky130_fd_sc_hd__nor2_1
X_4577_ _2615_ _2753_ VSS VSS VDD VDD _0677_ sky130_fd_sc_hd__nor2_1
X_4578_ _2754_ _2753_ _2750_ VSS VSS VDD VDD _0678_ sky130_fd_sc_hd__o21ai_1
X_4579_ _0600_ _0602_ _0677_ _0678_ VSS VSS VDD VDD _0679_
+ sky130_fd_sc_hd__a31oi_2
X_4580_ _0675_ _0676_ _0679_ VSS VSS VDD VDD _2806_ sky130_fd_sc_hd__a21oi_4
X_4581_ _0012_ _0053_ _0171_ _0214_ VSS VSS VDD VDD _0680_
+ sky130_fd_sc_hd__and4_1
X_4582_ _0012_ _0064_ _0078_ _0177_ VSS VSS VDD VDD _0681_
+ sky130_fd_sc_hd__nor4_2
X_4583_ _0257_ _0258_ _0680_ _0681_ VSS VSS VDD VDD _0682_
+ sky130_fd_sc_hd__o22ai_4
X_4584_ _0241_ _0242_ _0251_ _0252_ VSS VSS VDD VDD _0683_
+ sky130_fd_sc_hd__o211ai_2
X_4585_ _2566_ _2574_ _0682_ _0683_ VSS VSS VDD VDD _0684_
+ sky130_fd_sc_hd__nor4_2
X_4586_ _0032_ _2087_ VSS VSS VDD VDD _0685_ sky130_fd_sc_hd__xnor2_1
X_4587_ _2088_ _0025_ _0113_ _0685_ VSS VSS VDD VDD _0686_
+ sky130_fd_sc_hd__nor4_1
X_4588_ _0013_ _0105_ VSS VSS VDD VDD _0687_ sky130_fd_sc_hd__nor2_1
X_4589_ _0013_ _0686_ _0687_ VSS VSS VDD VDD _0688_ sky130_fd_sc_hd__a21oi_4
X_4590_ net16 _2558_ _2562_ _0688_ VSS VSS VDD VDD _0689_
+ sky130_fd_sc_hd__nor4_2
X_4591_ _0226_ _0439_ VSS VSS VDD VDD _0690_ sky130_fd_sc_hd__nor2_1
X_4592_ _0245_ _0246_ _0448_ _0690_ VSS VSS VDD VDD _0691_
+ sky130_fd_sc_hd__nand4_1
X_4593_ _0229_ _0448_ VSS VSS VDD VDD _0692_ sky130_fd_sc_hd__nand2_1
X_4594_ _0451_ _0452_ _0692_ _0439_ VSS VSS VDD VDD _0693_
+ sky130_fd_sc_hd__a31oi_1
X_4595_ _2547_ _0012_ _0693_ VSS VSS VDD VDD _0694_ sky130_fd_sc_hd__nor3_1
X_4596_ _0450_ _0491_ VSS VSS VDD VDD _0695_ sky130_fd_sc_hd__nor2_1
X_4597_ _2550_ _2542_ _0695_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__nor3_1
X_4598_ _2510_ _2550_ VSS VSS VDD VDD _0697_ sky130_fd_sc_hd__nor2_1
X_4599_ _2551_ _2550_ _0439_ VSS VSS VDD VDD _0698_ sky130_fd_sc_hd__o21ai_0
X_4600_ _0492_ _0697_ _0698_ VSS VSS VDD VDD _0699_ sky130_fd_sc_hd__a21oi_1
X_4601_ _2542_ _0699_ VSS VSS VDD VDD _0700_ sky130_fd_sc_hd__nor2_1
X_4602_ _0404_ _0407_ _0696_ _0700_ VSS VSS VDD VDD _0701_
+ sky130_fd_sc_hd__a31oi_1
X_4603_ _0691_ _0694_ _0701_ _0012_ VSS VSS VDD VDD _0702_
+ sky130_fd_sc_hd__a22oi_2
X_4604_ _0478_ _0702_ VSS VSS VDD VDD _0703_ sky130_fd_sc_hd__xnor2_2
X_4605_ net4 _0703_ VSS VSS VDD VDD _0704_ sky130_fd_sc_hd__nor2_1
X_4606_ net4 _0703_ VSS VSS VDD VDD _0705_ sky130_fd_sc_hd__and2_0
X_4607_ _2580_ _2726_ _0651_ VSS VSS VDD VDD _0706_ sky130_fd_sc_hd__nand3_1
X_4608_ _0272_ _0706_ _0662_ VSS VSS VDD VDD _0707_ sky130_fd_sc_hd__o21ai_0
X_4609_ _2738_ _0707_ _2737_ VSS VSS VDD VDD _0708_ sky130_fd_sc_hd__a21oi_1
X_4610_ _0478_ _0486_ _0708_ VSS VSS VDD VDD _0709_ sky130_fd_sc_hd__xnor3_1
X_4611_ _0684_ _0689_ _0704_ _0705_ _0709_ VSS VSS VDD VDD
+ _0710_ sky130_fd_sc_hd__a2111oi_4
X_4612_ _0709_ _0684_ _0689_ VSS VSS VDD VDD _0711_ sky130_fd_sc_hd__and3_1
X_4613_ _0704_ _0705_ _0709_ VSS VSS VDD VDD _0712_ sky130_fd_sc_hd__o21a_1
X_4614_ _0710_ _0711_ _0712_ VSS VSS VDD VDD _0713_ sky130_fd_sc_hd__or3_4
X_4615_ _2744_ VSS VSS VDD VDD _0714_ sky130_fd_sc_hd__inv_1
X_4616_ _0537_ _0714_ _0657_ VSS VSS VDD VDD _0715_ sky130_fd_sc_hd__nand3_1
X_4617_ _0295_ VSS VSS VDD VDD _2124_ sky130_fd_sc_hd__buf_8
X_4618_ _2739_ _0715_ net23 VSS VSS VDD VDD _0716_ sky130_fd_sc_hd__o21ai_0
X_4619_ _0710_ _0711_ _0712_ net3 VSS VSS VDD VDD _0717_ sky130_fd_sc_hd__o31ai_2
X_4620_ _0713_ _0716_ _0717_ VSS VSS VDD VDD _2755_ sky130_fd_sc_hd__o21a_1
X_4621_ _0710_ _0711_ _0712_ VSS VSS VDD VDD _0718_ sky130_fd_sc_hd__nor3_1
X_4622_ _2744_ _2739_ VSS VSS VDD VDD _0719_ sky130_fd_sc_hd__nor2_1
X_4623_ _0293_ _0537_ _0655_ _0719_ net3 VSS VSS VDD VDD _0720_
+ sky130_fd_sc_hd__a41o_1
X_4624_ _0718_ _0720_ VSS VSS VDD VDD _2763_ sky130_fd_sc_hd__xnor2_1
X_4625_ _0537_ _0714_ _0657_ _0159_ VSS VSS VDD VDD _0721_
+ sky130_fd_sc_hd__a31oi_1
X_4626_ _2739_ _0721_ VSS VSS VDD VDD _2759_ sky130_fd_sc_hd__xnor2_1
X_4627_ _2535_ _2729_ _2733_ VSS VSS VDD VDD _0722_ sky130_fd_sc_hd__nor3_1
X_4628_ _2734_ _2729_ _2733_ VSS VSS VDD VDD _0723_ sky130_fd_sc_hd__nor3_1
X_4629_ _2730_ _2729_ VSS VSS VDD VDD _0724_ sky130_fd_sc_hd__nor2_1
X_4630_ _0671_ _0722_ _0723_ _0724_ VSS VSS VDD VDD _0725_
+ sky130_fd_sc_hd__a211oi_4
X_4631_ _2762_ _0725_ _2761_ VSS VSS VDD VDD _0726_ sky130_fd_sc_hd__a21o_1
X_4632_ _2766_ _0726_ _2765_ VSS VSS VDD VDD _0727_ sky130_fd_sc_hd__a21oi_2
X_4633_ _2758_ _0727_ VSS VSS VDD VDD _2944_ sky130_fd_sc_hd__xnor2_4
X_4634_ _2730_ _0661_ _2729_ VSS VSS VDD VDD _0728_ sky130_fd_sc_hd__a21o_1
X_4635_ _2762_ _0728_ _2761_ VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__a21oi_4
X_4636_ _2766_ _0729_ VSS VSS VDD VDD _2928_ sky130_fd_sc_hd__xnor2_4
X_4637_ _2762_ VSS VSS VDD VDD _0730_ sky130_fd_sc_hd__inv_1
X_4638_ _0730_ _0725_ VSS VSS VDD VDD _2932_ sky130_fd_sc_hd__xnor2_4
X_4639_ _2788_ VSS VSS VDD VDD _0731_ sky130_fd_sc_hd__inv_1
X_4640_ _2796_ VSS VSS VDD VDD _0732_ sky130_fd_sc_hd__inv_1
X_4641_ _2484_ VSS VSS VDD VDD _0733_ sky130_fd_sc_hd__inv_1
X_4642_ _0733_ _0353_ _2483_ VSS VSS VDD VDD _0734_ sky130_fd_sc_hd__o21bai_1
X_4643_ _2698_ _0734_ _2697_ VSS VSS VDD VDD _0735_ sky130_fd_sc_hd__a21oi_2
X_4644_ _0732_ _0735_ _2795_ VSS VSS VDD VDD _0736_ sky130_fd_sc_hd__o21bai_1
X_4645_ _2792_ _0736_ _2791_ VSS VSS VDD VDD _0737_ sky130_fd_sc_hd__a21oi_1
X_4646_ _0731_ _0737_ _2787_ VSS VSS VDD VDD _0738_ sky130_fd_sc_hd__o21bai_1
X_4647_ _2784_ _0738_ _2783_ VSS VSS VDD VDD _0739_ sky130_fd_sc_hd__a21oi_2
X_4648_ _2804_ _2780_ VSS VSS VDD VDD _0740_ sky130_fd_sc_hd__nand2_1
X_4649_ _2804_ _2779_ _2803_ VSS VSS VDD VDD _0741_ sky130_fd_sc_hd__a21oi_1
X_4650_ _0739_ _0740_ _0741_ VSS VSS VDD VDD _0742_ sky130_fd_sc_hd__o21ai_2
X_4651_ _2776_ _0742_ _2773_ VSS VSS VDD VDD _0743_ sky130_fd_sc_hd__a21o_1
X_4652_ _2800_ _0743_ _2799_ VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__a21oi_1
X_4653_ _2770_ _0744_ VSS VSS VDD VDD _2948_ sky130_fd_sc_hd__xnor2_2
X_4654_ _2804_ _2776_ VSS VSS VDD VDD _0745_ sky130_fd_sc_hd__nand2_1
X_4655_ _2698_ VSS VSS VDD VDD _0746_ sky130_fd_sc_hd__inv_1
X_4656_ _0746_ _0638_ _2697_ VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__o21bai_1
X_4657_ _2796_ _0747_ _2795_ _2791_ VSS VSS VDD VDD _0748_
+ sky130_fd_sc_hd__a211oi_1
X_4658_ _2792_ _2791_ _2788_ VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__o21ai_0
X_4659_ _0748_ _0749_ _2787_ VSS VSS VDD VDD _0750_ sky130_fd_sc_hd__o21bai_2
X_4660_ _2784_ _0750_ _2783_ VSS VSS VDD VDD _0751_ sky130_fd_sc_hd__a21o_1
X_4661_ _2780_ _0751_ _2779_ VSS VSS VDD VDD _0752_ sky130_fd_sc_hd__a21oi_2
X_4662_ _2774_ _2803_ _2773_ VSS VSS VDD VDD _0753_ sky130_fd_sc_hd__a21oi_1
X_4663_ _0745_ _0752_ _0753_ VSS VSS VDD VDD _0754_ sky130_fd_sc_hd__o21ai_1
X_4664_ _2800_ _0754_ VSS VSS VDD VDD _2974_ sky130_fd_sc_hd__xor2_2
X_4665_ _2776_ _0742_ VSS VSS VDD VDD _2952_ sky130_fd_sc_hd__xor2_4
X_4666_ _2804_ _0752_ VSS VSS VDD VDD _2978_ sky130_fd_sc_hd__xnor2_2
X_4667_ _2780_ _0739_ VSS VSS VDD VDD _2958_ sky130_fd_sc_hd__xnor2_2
X_4668_ _2784_ _0750_ VSS VSS VDD VDD _2962_ sky130_fd_sc_hd__xor2_2
X_4669_ _2796_ _0747_ _2795_ VSS VSS VDD VDD _0755_ sky130_fd_sc_hd__a21oi_1
X_4670_ _2792_ _0755_ VSS VSS VDD VDD _2970_ sky130_fd_sc_hd__xnor2_2
X_4671_ _2788_ _0737_ VSS VSS VDD VDD _2966_ sky130_fd_sc_hd__xnor2_2
X_4672_ _2970_ _2966_ VSS VSS VDD VDD _0756_ sky130_fd_sc_hd__or2_0
X_4673_ _2962_ _0756_ VSS VSS VDD VDD _0757_ sky130_fd_sc_hd__or2_0
X_4674_ _2796_ _0735_ VSS VSS VDD VDD _2896_ sky130_fd_sc_hd__xnor2_2
X_4675_ _2499_ _2699_ _2896_ VSS VSS VDD VDD _0758_ sky130_fd_sc_hd__or3_1
X_4676_ _2958_ _0757_ _0758_ VSS VSS VDD VDD _0759_ sky130_fd_sc_hd__or3_1
X_4677_ _2952_ _2978_ _0759_ VSS VSS VDD VDD _0760_ sky130_fd_sc_hd__or3_1
X_4678_ _2948_ _2974_ _0760_ net13 VSS VSS VDD VDD _0761_
+ sky130_fd_sc_hd__o31a_1
X_4679_ _2417_ _0630_ VSS VSS VDD VDD _0762_ sky130_fd_sc_hd__nand2b_1
X_4680_ _2414_ _0762_ _2413_ VSS VSS VDD VDD _0763_ sky130_fd_sc_hd__a21oi_2
X_4681_ _2410_ _0763_ VSS VSS VDD VDD _2626_ sky130_fd_sc_hd__xnor2_4
X_4682_ _2630_ _2634_ _2638_ VSS VSS VDD VDD _0764_ sky130_fd_sc_hd__or3_1
X_4683_ _2622_ _2618_ _2626_ _0764_ VSS VSS VDD VDD _0765_
+ sky130_fd_sc_hd__nor4_1
X_4684_ _0438_ _0765_ VSS VSS VDD VDD _0766_ sky130_fd_sc_hd__nand2_1
X_4685_ _2748_ _2752_ _0766_ VSS VSS VDD VDD _0767_ sky130_fd_sc_hd__or3_1
X_4686_ _2944_ _2928_ _2932_ _0767_ VSS VSS VDD VDD _0768_
+ sky130_fd_sc_hd__nor4_1
X_4687_ _2758_ _2766_ VSS VSS VDD VDD _0769_ sky130_fd_sc_hd__nand2_1
X_4688_ _2758_ _2765_ _2757_ VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__a21oi_1
X_4689_ _0729_ _0769_ _0770_ VSS VSS VDD VDD _0771_ sky130_fd_sc_hd__o21ai_2
X_4690_ _0713_ _0720_ _0771_ _0717_ VSS VSS VDD VDD _0772_
+ sky130_fd_sc_hd__o211ai_4
X_4691_ _0710_ _0711_ _0712_ _0720_ VSS VSS VDD VDD _0773_
+ sky130_fd_sc_hd__nor4b_1
X_4692_ net18 _0713_ _0773_ _0771_ VSS VSS VDD VDD _0774_
+ sky130_fd_sc_hd__a211o_2
X_4693_ _2564_ _0527_ _2563_ VSS VSS VDD VDD _0775_ sky130_fd_sc_hd__a21o_1
X_4694_ _2560_ _0775_ _2559_ VSS VSS VDD VDD _0776_ sky130_fd_sc_hd__a21oi_2
X_4695_ net16 _2736_ _2724_ VSS VSS VDD VDD _0777_ sky130_fd_sc_hd__nor3_1
X_4696_ net16 _0478_ VSS VSS VDD VDD _0778_ sky130_fd_sc_hd__xnor2_1
X_4697_ _0486_ _0778_ VSS VSS VDD VDD _0779_ sky130_fd_sc_hd__xnor2_1
X_4698_ _0496_ _0500_ _0777_ _0779_ VSS VSS VDD VDD _0780_
+ sky130_fd_sc_hd__a31oi_2
X_4699_ _0703_ _0780_ VSS VSS VDD VDD _0781_ sky130_fd_sc_hd__xnor2_2
X_4700_ _0776_ _0781_ VSS VSS VDD VDD _0782_ sky130_fd_sc_hd__xor2_4
X_4701_ _0772_ _0774_ _0782_ VSS VSS VDD VDD _0783_ sky130_fd_sc_hd__a21oi_2
X_4702_ _0772_ _0774_ _0782_ VSS VSS VDD VDD _0784_ sky130_fd_sc_hd__and3_1
X_4703_ _2665_ _0768_ _0783_ _0784_ VSS VSS VDD VDD _0785_
+ sky130_fd_sc_hd__or4_2
X_4704_ _0783_ _0784_ _2665_ VSS VSS VDD VDD _0786_ sky130_fd_sc_hd__o21ai_2
X_4705_ _2769_ _2799_ VSS VSS VDD VDD _0787_ sky130_fd_sc_hd__nor2_1
X_4706_ _0745_ _0752_ _0753_ _0787_ VSS VSS VDD VDD _0788_
+ sky130_fd_sc_hd__o211ai_1
X_4707_ _2800_ _2769_ _2799_ VSS VSS VDD VDD _0789_ sky130_fd_sc_hd__or3_1
X_4708_ _2770_ _2769_ _0788_ _0789_ VSS VSS VDD VDD _0790_
+ sky130_fd_sc_hd__o211ai_1
X_4709_ _2764_ _2760_ _2728_ _2732_ VSS VSS VDD VDD _0791_
+ sky130_fd_sc_hd__nor4_1
X_4710_ _2270_ _0299_ VSS VSS VDD VDD _2416_ sky130_fd_sc_hd__xnor2_2
X_4711_ _2420_ _2424_ _2416_ VSS VSS VDD VDD _0792_ sky130_fd_sc_hd__or3_1
X_4712_ _2412_ _2408_ _0792_ VSS VSS VDD VDD _0793_ sky130_fd_sc_hd__or3_1
X_4713_ _2404_ _2534_ _2538_ _0793_ VSS VSS VDD VDD _0794_
+ sky130_fd_sc_hd__or4_1
X_4714_ _2756_ _0794_ VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__nor2_1
X_4715_ _0791_ _0795_ net3 VSS VSS VDD VDD _0796_ sky130_fd_sc_hd__a21oi_2
X_4716_ net3 _0796_ _0782_ VSS VSS VDD VDD _0797_ sky130_fd_sc_hd__mux2i_4
X_4717_ _2746_ _0668_ _2745_ VSS VSS VDD VDD _0798_ sky130_fd_sc_hd__a21o_1
X_4718_ _2742_ _0798_ _2741_ VSS VSS VDD VDD _0799_ sky130_fd_sc_hd__a21oi_2
X_4719_ _0713_ _0799_ VSS VSS VDD VDD _0800_ sky130_fd_sc_hd__xnor2_4
X_4720_ _0790_ _0797_ _0800_ VSS VSS VDD VDD _0801_ sky130_fd_sc_hd__xnor3_1
X_4721_ _0785_ _0786_ _0801_ VSS VSS VDD VDD _0802_ sky130_fd_sc_hd__a21oi_4
X_4722_ _0785_ _0786_ _0801_ VSS VSS VDD VDD _0803_ sky130_fd_sc_hd__and3_2
X_4723_ _0802_ _0803_ VSS VSS VDD VDD _0804_ sky130_fd_sc_hd__or2_0
X_4724_ _0761_ _0804_ VSS VSS VDD VDD _2805_ sky130_fd_sc_hd__xor2_1
X_4725_ _2628_ VSS VSS VDD VDD _0805_ sky130_fd_sc_hd__inv_1
X_4726_ _0805_ _0641_ _0590_ VSS VSS VDD VDD _0806_ sky130_fd_sc_hd__o21ai_0
X_4727_ _2624_ _0806_ _2623_ VSS VSS VDD VDD _0807_ sky130_fd_sc_hd__a21oi_1
X_4728_ _0807_ _2620_ VSS VSS VDD VDD _0808_ sky130_fd_sc_hd__nor2b_1
X_4729_ _2619_ _0808_ _2616_ VSS VSS VDD VDD _0809_ sky130_fd_sc_hd__o21a_1
X_4730_ _2615_ _0809_ VSS VSS VDD VDD _0810_ sky130_fd_sc_hd__nor2_2
X_4731_ _2754_ _0810_ VSS VSS VDD VDD _2810_ sky130_fd_sc_hd__xnor2_4
X_4732_ _0629_ VSS VSS VDD VDD _2852_ sky130_fd_sc_hd__buf_6
X_4733_ _2896_ _2843_ VSS VSS VDD VDD _0811_ sky130_fd_sc_hd__nand2b_1
X_4734_ _2978_ _2958_ _0757_ _0811_ VSS VSS VDD VDD _0812_
+ sky130_fd_sc_hd__nor4_1
X_4735_ _2974_ _2952_ VSS VSS VDD VDD _0813_ sky130_fd_sc_hd__nor2_1
X_4736_ _0812_ _0813_ VSS VSS VDD VDD _0814_ sky130_fd_sc_hd__nand2_1
X_4737_ net12 _0814_ VSS VSS VDD VDD _0815_ sky130_fd_sc_hd__nand2_1
X_4738_ _2948_ _0815_ VSS VSS VDD VDD _2809_ sky130_fd_sc_hd__xor2_1
X_4739_ _0629_ VSS VSS VDD VDD _0816_ sky130_fd_sc_hd__buf_2
X_4740_ _0816_ _0760_ VSS VSS VDD VDD _0817_ sky130_fd_sc_hd__nand2_1
X_4741_ _2974_ _0817_ VSS VSS VDD VDD _2847_ sky130_fd_sc_hd__xor2_1
X_4742_ net1 _0812_ VSS VSS VDD VDD _0818_ sky130_fd_sc_hd__nor2_1
X_4743_ _2952_ _0818_ VSS VSS VDD VDD _2813_ sky130_fd_sc_hd__xnor2_1
X_4744_ _0816_ _0759_ VSS VSS VDD VDD _0819_ sky130_fd_sc_hd__nand2_1
X_4745_ _2978_ _0819_ VSS VSS VDD VDD _2817_ sky130_fd_sc_hd__xor2_1
X_4746_ _0757_ _0811_ _0816_ VSS VSS VDD VDD _0820_ sky130_fd_sc_hd__o21ai_0
X_4747_ _2958_ _0820_ VSS VSS VDD VDD _2821_ sky130_fd_sc_hd__xor2_1
X_4748_ _0756_ _0758_ _0816_ VSS VSS VDD VDD _0821_ sky130_fd_sc_hd__o21ai_0
X_4749_ _2962_ _0821_ VSS VSS VDD VDD _2825_ sky130_fd_sc_hd__xor2_1
X_4750_ _2970_ _0811_ _0816_ VSS VSS VDD VDD _0822_ sky130_fd_sc_hd__o21ai_0
X_4751_ _2966_ _0822_ VSS VSS VDD VDD _2829_ sky130_fd_sc_hd__xor2_1
X_4752_ _0816_ _0758_ VSS VSS VDD VDD _0823_ sky130_fd_sc_hd__nand2_1
X_4753_ _2970_ _0823_ VSS VSS VDD VDD _2833_ sky130_fd_sc_hd__xor2_1
X_4754_ _2843_ _2868_ VSS VSS VDD VDD _0824_ sky130_fd_sc_hd__nor2_1
X_4755_ _2896_ _0824_ VSS VSS VDD VDD _2837_ sky130_fd_sc_hd__xnor2_1
X_4756_ _2844_ _0816_ VSS VSS VDD VDD _0825_ sky130_fd_sc_hd__nand2_1
X_4757_ _0816_ _2841_ _0825_ VSS VSS VDD VDD _2141_ sky130_fd_sc_hd__o21ai_1
X_4758_ _2141_ VSS VSS VDD VDD _2145_ sky130_fd_sc_hd__inv_1
X_4759_ _2823_ VSS VSS VDD VDD _0826_ sky130_fd_sc_hd__inv_1
X_4760_ _2831_ VSS VSS VDD VDD _0827_ sky130_fd_sc_hd__inv_1
X_4761_ _2839_ VSS VSS VDD VDD _0828_ sky130_fd_sc_hd__inv_1
X_4762_ _2140_ _2846_ VSS VSS VDD VDD _0829_ sky130_fd_sc_hd__nor2b_1
X_4763_ _2845_ _0829_ _2840_ VSS VSS VDD VDD _0830_ sky130_fd_sc_hd__o21ai_1
X_4764_ _0828_ _0830_ _2836_ VSS VSS VDD VDD _0831_ sky130_fd_sc_hd__a21boi_0
X_4765_ _2835_ _0831_ _2832_ VSS VSS VDD VDD _0832_ sky130_fd_sc_hd__o21ai_1
X_4766_ _0827_ _0832_ _2828_ VSS VSS VDD VDD _0833_ sky130_fd_sc_hd__a21boi_1
X_4767_ _2827_ _0833_ _2824_ VSS VSS VDD VDD _0834_ sky130_fd_sc_hd__o21ai_1
X_4768_ _0826_ _0834_ _2820_ VSS VSS VDD VDD _0835_ sky130_fd_sc_hd__a21boi_1
X_4769_ _2819_ _0835_ _2816_ VSS VSS VDD VDD _0836_ sky130_fd_sc_hd__o21ai_0
X_4770_ _2815_ _0836_ VSS VSS VDD VDD _0837_ sky130_fd_sc_hd__nand2b_1
X_4771_ _2850_ _0837_ _2849_ VSS VSS VDD VDD _0838_ sky130_fd_sc_hd__a21o_1
X_4772_ _2812_ _0838_ _2811_ VSS VSS VDD VDD _0839_ sky130_fd_sc_hd__a21o_2
X_4773_ _2808_ _0839_ VSS VSS VDD VDD _3034_ sky130_fd_sc_hd__xor2_4
X_4774_ _2850_ _0837_ VSS VSS VDD VDD _2992_ sky130_fd_sc_hd__xor2_2
X_4775_ _0826_ _0834_ VSS VSS VDD VDD _0840_ sky130_fd_sc_hd__nand2_1
X_4776_ _2820_ _0840_ VSS VSS VDD VDD _0841_ sky130_fd_sc_hd__nor2_1
X_4777_ _0835_ _0841_ VSS VSS VDD VDD _3000_ sky130_fd_sc_hd__nor2_2
X_4778_ _2827_ VSS VSS VDD VDD _0842_ sky130_fd_sc_hd__inv_1
X_4779_ _2835_ VSS VSS VDD VDD _0843_ sky130_fd_sc_hd__inv_1
X_4780_ _2143_ _2840_ VSS VSS VDD VDD _0844_ sky130_fd_sc_hd__nor2b_1
X_4781_ _2839_ _0844_ _2836_ VSS VSS VDD VDD _0845_ sky130_fd_sc_hd__o21ai_0
X_4782_ _0843_ _0845_ _2832_ VSS VSS VDD VDD _0846_ sky130_fd_sc_hd__a21boi_0
X_4783_ _2831_ _0846_ _2828_ VSS VSS VDD VDD _0847_ sky130_fd_sc_hd__o21ai_0
X_4784_ _0842_ _0847_ _2824_ VSS VSS VDD VDD _0848_ sky130_fd_sc_hd__a21boi_0
X_4785_ _0842_ _0847_ VSS VSS VDD VDD _0849_ sky130_fd_sc_hd__nand2_1
X_4786_ _2824_ _0849_ VSS VSS VDD VDD _0850_ sky130_fd_sc_hd__nor2_1
X_4787_ _0848_ _0850_ VSS VSS VDD VDD _3004_ sky130_fd_sc_hd__nor2_1
X_4788_ _3004_ VSS VSS VDD VDD _2919_ sky130_fd_sc_hd__inv_1
X_4789_ _0827_ _0832_ VSS VSS VDD VDD _0851_ sky130_fd_sc_hd__nand2_1
X_4790_ _2828_ _0851_ VSS VSS VDD VDD _0852_ sky130_fd_sc_hd__nor2_1
X_4791_ _0833_ _0852_ VSS VSS VDD VDD _3008_ sky130_fd_sc_hd__nor2_2
X_4792_ _3008_ VSS VSS VDD VDD _2918_ sky130_fd_sc_hd__inv_1
X_4793_ _2863_ VSS VSS VDD VDD _0853_ sky130_fd_sc_hd__inv_1
X_4794_ _2870_ VSS VSS VDD VDD _0854_ sky130_fd_sc_hd__inv_1
X_4795_ _2876_ VSS VSS VDD VDD _0855_ sky130_fd_sc_hd__inv_1
X_4796_ _2882_ VSS VSS VDD VDD _0856_ sky130_fd_sc_hd__inv_1
X_4797_ _2888_ VSS VSS VDD VDD _0857_ sky130_fd_sc_hd__inv_1
X_4798_ _2894_ net62 _2893_ VSS VSS VDD VDD _0858_ sky130_fd_sc_hd__a21o_1
X_4799_ _0858_ _2891_ _2890_ VSS VSS VDD VDD _0859_ sky130_fd_sc_hd__a21oi_2
X_4800_ _2887_ VSS VSS VDD VDD _0860_ sky130_fd_sc_hd__inv_1
X_4801_ _0857_ _0859_ _0860_ VSS VSS VDD VDD _0861_ sky130_fd_sc_hd__o21ai_1
X_4802_ _0861_ _2885_ _2884_ VSS VSS VDD VDD _0862_ sky130_fd_sc_hd__a21oi_2
X_4803_ _0856_ _0862_ _2881_ VSS VSS VDD VDD _0863_ sky130_fd_sc_hd__o21bai_1
X_4804_ _0863_ _2879_ _2878_ VSS VSS VDD VDD _0864_ sky130_fd_sc_hd__a21oi_2
X_4805_ _0864_ _0855_ _2875_ VSS VSS VDD VDD _0865_ sky130_fd_sc_hd__o21bai_1
X_4806_ _0865_ _2873_ _2872_ VSS VSS VDD VDD _0866_ sky130_fd_sc_hd__a21oi_2
X_4807_ _0854_ _0866_ _2869_ VSS VSS VDD VDD _0867_ sky130_fd_sc_hd__o21bai_1
X_4808_ _0867_ _2866_ _2865_ VSS VSS VDD VDD _0868_ sky130_fd_sc_hd__a21oi_2
X_4809_ _0868_ _0853_ _2862_ VSS VSS VDD VDD _0869_ sky130_fd_sc_hd__o21bai_1
X_4810_ _0869_ _2860_ _2859_ VSS VSS VDD VDD _0870_ sky130_fd_sc_hd__a21oi_2
X_4811_ _2854_ _2857_ VSS VSS VDD VDD _0871_ sky130_fd_sc_hd__nand2_1
X_4812_ _2854_ _2856_ _2853_ VSS VSS VDD VDD _0872_ sky130_fd_sc_hd__a21oi_1
X_4813_ _0871_ _0870_ _0872_ VSS VSS VDD VDD _0873_ sky130_fd_sc_hd__o21ai_4
X_4814_ _0873_ VSS VSS VDD VDD _3057_ sky130_fd_sc_hd__clkinv_4
X_4815_ _2620_ _0807_ VSS VSS VDD VDD _2814_ sky130_fd_sc_hd__xnor2_2
X_4816_ _2705_ VSS VSS VDD VDD _0874_ sky130_fd_sc_hd__inv_1
X_4817_ _2713_ _2138_ _2712_ VSS VSS VDD VDD _0875_ sky130_fd_sc_hd__a21oi_1
X_4818_ _0642_ _0875_ VSS VSS VDD VDD _0876_ sky130_fd_sc_hd__nor2_1
X_4819_ _2708_ _0876_ VSS VSS VDD VDD _0877_ sky130_fd_sc_hd__nor2_1
X_4820_ _0874_ _0877_ _2704_ VSS VSS VDD VDD _0878_ sky130_fd_sc_hd__o21bai_1
X_4821_ _2702_ _0878_ _2701_ VSS VSS VDD VDD _0879_ sky130_fd_sc_hd__a21oi_1
X_4822_ _2898_ _0879_ VSS VSS VDD VDD _2899_ sky130_fd_sc_hd__xnor2_2
X_4823_ _2899_ VSS VSS VDD VDD _3023_ sky130_fd_sc_hd__inv_1
X_4824_ _2819_ VSS VSS VDD VDD _0880_ sky130_fd_sc_hd__inv_1
X_4825_ _2823_ _0848_ _2820_ VSS VSS VDD VDD _0881_ sky130_fd_sc_hd__o21ai_0
X_4826_ _0880_ _0881_ _2816_ VSS VSS VDD VDD _0882_ sky130_fd_sc_hd__a21boi_1
X_4827_ _0880_ _0881_ VSS VSS VDD VDD _0883_ sky130_fd_sc_hd__nand2_1
X_4828_ _2816_ _0883_ VSS VSS VDD VDD _0884_ sky130_fd_sc_hd__nor2_1
X_4829_ _0882_ _0884_ VSS VSS VDD VDD _2996_ sky130_fd_sc_hd__nor2_2
X_4830_ _2849_ VSS VSS VDD VDD _0885_ sky130_fd_sc_hd__inv_1
X_4831_ _2815_ _0882_ _2850_ VSS VSS VDD VDD _0886_ sky130_fd_sc_hd__o21ai_0
X_4832_ _0885_ _0886_ _2812_ VSS VSS VDD VDD _0887_ sky130_fd_sc_hd__a21boi_1
X_4833_ _0885_ _0886_ VSS VSS VDD VDD _0888_ sky130_fd_sc_hd__nand2_1
X_4834_ _2812_ _0888_ VSS VSS VDD VDD _0889_ sky130_fd_sc_hd__nor2_1
X_4835_ _0887_ _0889_ VSS VSS VDD VDD _2986_ sky130_fd_sc_hd__nor2_2
X_4836_ _2909_ VSS VSS VDD VDD _0890_ sky130_fd_sc_hd__inv_1
X_4837_ _2913_ VSS VSS VDD VDD _0891_ sky130_fd_sc_hd__inv_1
X_4838_ _2148_ _2917_ _2916_ VSS VSS VDD VDD _0892_ sky130_fd_sc_hd__a21oi_1
X_4839_ _0891_ _0892_ VSS VSS VDD VDD _0893_ sky130_fd_sc_hd__nor2_1
X_4840_ _2912_ _0893_ VSS VSS VDD VDD _0894_ sky130_fd_sc_hd__nor2_1
X_4841_ _0890_ _0894_ _2908_ VSS VSS VDD VDD _0895_ sky130_fd_sc_hd__o21bai_1
X_4842_ _2905_ _0895_ _2904_ VSS VSS VDD VDD _0896_ sky130_fd_sc_hd__a21oi_2
X_4843_ _2902_ _0896_ VSS VSS VDD VDD _2925_ sky130_fd_sc_hd__xnor2_4
X_4844_ _2925_ VSS VSS VDD VDD _3192_ sky130_fd_sc_hd__inv_1
X_4845_ _2768_ _0669_ _0800_ net6 VSS VSS VDD VDD _0897_ sky130_fd_sc_hd__o211a_1
X_4846_ _2768_ _0669_ net6 VSS VSS VDD VDD _0898_ sky130_fd_sc_hd__o21ai_0
X_4847_ _0800_ _0898_ VSS VSS VDD VDD _0899_ sky130_fd_sc_hd__nor2_1
X_4848_ _0897_ _0899_ _0797_ VSS VSS VDD VDD _0900_ sky130_fd_sc_hd__mux2i_4
X_4849_ net6 _0800_ VSS VSS VDD VDD _0901_ sky130_fd_sc_hd__nor2_1
X_4850_ _2665_ _0800_ VSS VSS VDD VDD _0902_ sky130_fd_sc_hd__and2_0
X_4851_ _0901_ _0902_ _0797_ VSS VSS VDD VDD _0903_ sky130_fd_sc_hd__mux2i_4
X_4852_ _0900_ _0903_ VSS VSS VDD VDD _2927_ sky130_fd_sc_hd__and2_0
X_4853_ _0797_ _0800_ VSS VSS VDD VDD _0904_ sky130_fd_sc_hd__xnor2_1
X_4854_ _2768_ _2798_ _0673_ _0578_ VSS VSS VDD VDD _0905_
+ sky130_fd_sc_hd__o31ai_2
X_4855_ _0904_ _0905_ VSS VSS VDD VDD _2931_ sky130_fd_sc_hd__xor2_1
X_4856_ _2749_ _0679_ _2934_ VSS VSS VDD VDD _0906_ sky130_fd_sc_hd__o21ai_0
X_4857_ _2933_ _0906_ VSS VSS VDD VDD _0907_ sky130_fd_sc_hd__nand2b_1
X_4858_ _2930_ _0907_ VSS VSS VDD VDD _0908_ sky130_fd_sc_hd__xnor2_2
X_4859_ _0908_ VSS VSS VDD VDD _2936_ sky130_fd_sc_hd__inv_1
X_4860_ _0802_ _0803_ _0761_ VSS VSS VDD VDD _0909_ sky130_fd_sc_hd__o21ai_2
X_4861_ net13 _0802_ _0803_ VSS VSS VDD VDD _0910_ sky130_fd_sc_hd__or3_2
X_4862_ _0909_ _0910_ VSS VSS VDD VDD _2935_ sky130_fd_sc_hd__and2_0
X_4863_ _2754_ _2749_ _2753_ VSS VSS VDD VDD _0911_ sky130_fd_sc_hd__nor3_1
X_4864_ _2750_ _2749_ VSS VSS VDD VDD _0912_ sky130_fd_sc_hd__nor2_1
X_4865_ _0911_ _0912_ VSS VSS VDD VDD _0913_ sky130_fd_sc_hd__nor2_1
X_4866_ _2615_ _2749_ _2753_ _0809_ _0913_ VSS VSS VDD VDD
+ _0914_ sky130_fd_sc_hd__o41ai_4
X_4867_ _2934_ _0914_ VSS VSS VDD VDD _2940_ sky130_fd_sc_hd__xnor2_2
X_4868_ _2948_ _0814_ _0804_ _0816_ VSS VSS VDD VDD _0915_
+ sky130_fd_sc_hd__o211ai_1
X_4869_ _0910_ _0915_ VSS VSS VDD VDD _2939_ sky130_fd_sc_hd__and2_0
X_4870_ _2942_ _2807_ _2941_ VSS VSS VDD VDD _0916_ sky130_fd_sc_hd__a21o_1
X_4871_ _2808_ _2942_ _0839_ _0916_ VSS VSS VDD VDD _0917_
+ sky130_fd_sc_hd__a31oi_4
X_4872_ _2938_ _0917_ VSS VSS VDD VDD _2981_ sky130_fd_sc_hd__xnor2_4
X_4873_ _0904_ _0905_ _0903_ VSS VSS VDD VDD _2943_ sky130_fd_sc_hd__o21a_1
X_4874_ _2934_ VSS VSS VDD VDD _0918_ sky130_fd_sc_hd__inv_1
X_4875_ _0918_ _0914_ _2933_ VSS VSS VDD VDD _0919_ sky130_fd_sc_hd__o21bai_1
X_4876_ _2930_ _0919_ _2929_ VSS VSS VDD VDD _0920_ sky130_fd_sc_hd__a21oi_1
X_4877_ _2946_ _0920_ VSS VSS VDD VDD _0921_ sky130_fd_sc_hd__xor2_1
X_4878_ _0921_ VSS VSS VDD VDD _3117_ sky130_fd_sc_hd__inv_1
X_4879_ _2956_ VSS VSS VDD VDD _0922_ sky130_fd_sc_hd__inv_1
X_4880_ _2960_ VSS VSS VDD VDD _0923_ sky130_fd_sc_hd__inv_1
X_4881_ _2968_ VSS VSS VDD VDD _0924_ sky130_fd_sc_hd__inv_1
X_4882_ _2898_ VSS VSS VDD VDD _0925_ sky130_fd_sc_hd__inv_1
X_4883_ _0925_ _0879_ _2897_ VSS VSS VDD VDD _0926_ sky130_fd_sc_hd__o21bai_1
X_4884_ _2972_ _0926_ _2971_ VSS VSS VDD VDD _0927_ sky130_fd_sc_hd__a21oi_1
X_4885_ _0924_ _0927_ _2967_ VSS VSS VDD VDD _0928_ sky130_fd_sc_hd__o21bai_1
X_4886_ _2964_ _0928_ _2963_ VSS VSS VDD VDD _0929_ sky130_fd_sc_hd__a21oi_1
X_4887_ _0923_ _0929_ _2959_ VSS VSS VDD VDD _0930_ sky130_fd_sc_hd__o21bai_1
X_4888_ _2980_ _0930_ _2979_ VSS VSS VDD VDD _0931_ sky130_fd_sc_hd__a21oi_2
X_4889_ _0922_ _0931_ _2953_ VSS VSS VDD VDD _0932_ sky130_fd_sc_hd__o21bai_1
X_4890_ _2976_ _0932_ _2975_ VSS VSS VDD VDD _0933_ sky130_fd_sc_hd__a21oi_2
X_4891_ _2950_ _0933_ VSS VSS VDD VDD _3126_ sky130_fd_sc_hd__xnor2_4
X_4892_ _2964_ VSS VSS VDD VDD _0934_ sky130_fd_sc_hd__inv_1
X_4893_ _2972_ VSS VSS VDD VDD _0935_ sky130_fd_sc_hd__inv_1
X_4894_ _2702_ VSS VSS VDD VDD _0936_ sky130_fd_sc_hd__inv_1
X_4895_ _0936_ _0646_ _2701_ VSS VSS VDD VDD _0937_ sky130_fd_sc_hd__o21bai_1
X_4896_ _2898_ _0937_ _2897_ VSS VSS VDD VDD _0938_ sky130_fd_sc_hd__a21oi_2
X_4897_ _0935_ _0938_ _2971_ VSS VSS VDD VDD _0939_ sky130_fd_sc_hd__o21bai_1
X_4898_ _2968_ _0939_ _2967_ VSS VSS VDD VDD _0940_ sky130_fd_sc_hd__a21oi_1
X_4899_ _0934_ _0940_ _2963_ VSS VSS VDD VDD _0941_ sky130_fd_sc_hd__o21bai_1
X_4900_ _2960_ _0941_ _2959_ VSS VSS VDD VDD _0942_ sky130_fd_sc_hd__a21oi_4
X_4901_ _2980_ _2956_ VSS VSS VDD VDD _0943_ sky130_fd_sc_hd__nand2_1
X_4902_ _2954_ _2979_ _2953_ VSS VSS VDD VDD _0944_ sky130_fd_sc_hd__a21oi_2
X_4903_ _0942_ _0943_ _0944_ VSS VSS VDD VDD _0945_ sky130_fd_sc_hd__o21ai_4
X_4904_ _2976_ _0945_ VSS VSS VDD VDD _3130_ sky130_fd_sc_hd__xor2_4
X_4905_ _2956_ _0931_ VSS VSS VDD VDD _3134_ sky130_fd_sc_hd__xnor2_4
X_4906_ _2980_ _0942_ VSS VSS VDD VDD _3152_ sky130_fd_sc_hd__xnor2_4
X_4907_ _2960_ _0929_ VSS VSS VDD VDD _3138_ sky130_fd_sc_hd__xnor2_2
X_4908_ _2964_ _0940_ VSS VSS VDD VDD _3142_ sky130_fd_sc_hd__xnor2_2
X_4909_ _2968_ _0927_ VSS VSS VDD VDD _3146_ sky130_fd_sc_hd__xnor2_2
X_4910_ _0772_ _0774_ VSS VSS VDD VDD _0946_ sky130_fd_sc_hd__and2_0
X_4911_ _2946_ _2929_ _2945_ VSS VSS VDD VDD _0947_ sky130_fd_sc_hd__a21o_1
X_4912_ _2930_ _2946_ _0907_ _0947_ VSS VSS VDD VDD _0948_
+ sky130_fd_sc_hd__a31oi_1
X_4913_ _0946_ _0782_ _0948_ VSS VSS VDD VDD _0949_ sky130_fd_sc_hd__xor3_1
X_4914_ _0900_ _0903_ _0949_ VSS VSS VDD VDD _0950_ sky130_fd_sc_hd__a21oi_4
X_4915_ _0900_ _0903_ _0949_ VSS VSS VDD VDD _0951_ sky130_fd_sc_hd__and3_2
X_4916_ net13 _0950_ _0951_ VSS VSS VDD VDD _0952_ sky130_fd_sc_hd__or3_2
X_4917_ _2826_ _2830_ _2822_ VSS VSS VDD VDD _0953_ sky130_fd_sc_hd__or3_1
X_4918_ _2818_ _2814_ _0953_ VSS VSS VDD VDD _0954_ sky130_fd_sc_hd__or3_1
X_4919_ _2848_ _2810_ _0954_ VSS VSS VDD VDD _0955_ sky130_fd_sc_hd__or3_1
X_4920_ _2806_ _2940_ _0955_ VSS VSS VDD VDD _0956_ sky130_fd_sc_hd__nor3_1
X_4921_ _0908_ _0921_ _0956_ net1 VSS VSS VDD VDD _0957_ sky130_fd_sc_hd__a31oi_2
X_4922_ _0950_ _0951_ _0957_ VSS VSS VDD VDD _0958_ sky130_fd_sc_hd__o21ai_2
X_4923_ _2950_ _2976_ _0945_ VSS VSS VDD VDD _0959_ sky130_fd_sc_hd__nand3_1
X_4924_ _2950_ _2975_ _2949_ VSS VSS VDD VDD _0960_ sky130_fd_sc_hd__a21oi_1
X_4925_ _0959_ _0960_ VSS VSS VDD VDD _0961_ sky130_fd_sc_hd__nand2_1
X_4926_ _0802_ _0803_ _0961_ VSS VSS VDD VDD _0962_ sky130_fd_sc_hd__o21ai_2
X_4927_ _0802_ _0803_ _0961_ VSS VSS VDD VDD _0963_ sky130_fd_sc_hd__or3_1
X_4928_ _0952_ _0958_ _0962_ _0963_ VSS VSS VDD VDD _0964_
+ sky130_fd_sc_hd__a22oi_4
X_4929_ _0952_ _0958_ _0962_ _0963_ VSS VSS VDD VDD _0965_
+ sky130_fd_sc_hd__and4_2
X_4930_ _3024_ _3023_ VSS VSS VDD VDD _0966_ sky130_fd_sc_hd__nand2_1
X_4931_ _2972_ _0938_ VSS VSS VDD VDD _3082_ sky130_fd_sc_hd__xnor2_4
X_4932_ _3146_ _3082_ VSS VSS VDD VDD _0967_ sky130_fd_sc_hd__nor2_1
X_4933_ _3142_ _0967_ VSS VSS VDD VDD _0968_ sky130_fd_sc_hd__nand2b_1
X_4934_ _3138_ _0968_ VSS VSS VDD VDD _0969_ sky130_fd_sc_hd__nor2_1
X_4935_ _3152_ _0969_ VSS VSS VDD VDD _0970_ sky130_fd_sc_hd__nand2b_1
X_4936_ _3130_ _3134_ _0966_ _0970_ VSS VSS VDD VDD _0971_
+ sky130_fd_sc_hd__or4_1
X_4937_ _0873_ VSS VSS VDD VDD _0972_ sky130_fd_sc_hd__buf_6
X_4938_ _0964_ _0965_ _0971_ _3126_ net17 VSS VSS VDD VDD
+ _0973_ sky130_fd_sc_hd__o221ai_4
X_4939_ _0873_ _0964_ _0965_ VSS VSS VDD VDD _0974_ sky130_fd_sc_hd__or3_2
X_4940_ _0973_ _0974_ VSS VSS VDD VDD _2982_ sky130_fd_sc_hd__and2_0
X_4941_ _2811_ _0887_ _2808_ VSS VSS VDD VDD _0975_ sky130_fd_sc_hd__o21ai_0
X_4942_ _2807_ _0975_ VSS VSS VDD VDD _0976_ sky130_fd_sc_hd__nand2b_2
X_4943_ _2942_ _0976_ VSS VSS VDD VDD _3029_ sky130_fd_sc_hd__xor2_4
X_4944_ _0964_ _0965_ VSS VSS VDD VDD _0977_ sky130_fd_sc_hd__or2_1
X_4945_ _3134_ _0970_ VSS VSS VDD VDD _0978_ sky130_fd_sc_hd__nor2_1
X_4946_ _3025_ _0978_ VSS VSS VDD VDD _0979_ sky130_fd_sc_hd__nand2_1
X_4947_ _3126_ _3130_ _0979_ VSS VSS VDD VDD _0980_ sky130_fd_sc_hd__nor3_1
X_4948_ _3057_ _0980_ VSS VSS VDD VDD _0981_ sky130_fd_sc_hd__nor2_1
X_4949_ _0977_ _0981_ _0974_ VSS VSS VDD VDD _3030_ sky130_fd_sc_hd__a21boi_0
X_4950_ _0973_ _0974_ VSS VSS VDD VDD _3033_ sky130_fd_sc_hd__and2_0
X_4951_ _0977_ _0981_ VSS VSS VDD VDD _2985_ sky130_fd_sc_hd__xor2_1
X_4952_ _0972_ VSS VSS VDD VDD _3038_ sky130_fd_sc_hd__buf_6
X_4953_ net24 _0971_ VSS VSS VDD VDD _0982_ sky130_fd_sc_hd__nand2_1
X_4954_ _3126_ _0982_ VSS VSS VDD VDD _2991_ sky130_fd_sc_hd__xor2_1
X_4955_ net24 _0979_ VSS VSS VDD VDD _0983_ sky130_fd_sc_hd__nand2_1
X_4956_ _3130_ _0983_ VSS VSS VDD VDD _2995_ sky130_fd_sc_hd__xor2_1
X_4957_ _0966_ _0970_ net17 VSS VSS VDD VDD _0984_ sky130_fd_sc_hd__o21ai_0
X_4958_ _3134_ _0984_ VSS VSS VDD VDD _2999_ sky130_fd_sc_hd__xor2_1
X_4959_ _3025_ _0969_ _3057_ VSS VSS VDD VDD _0985_ sky130_fd_sc_hd__a21oi_1
X_4960_ _3152_ _0985_ VSS VSS VDD VDD _3003_ sky130_fd_sc_hd__xnor2_1
X_4961_ _0966_ _0968_ net17 VSS VSS VDD VDD _0986_ sky130_fd_sc_hd__o21ai_0
X_4962_ _3138_ _0986_ VSS VSS VDD VDD _3007_ sky130_fd_sc_hd__xor2_1
X_4963_ _3025_ _0967_ _3057_ VSS VSS VDD VDD _0987_ sky130_fd_sc_hd__a21oi_1
X_4964_ _3142_ _0987_ VSS VSS VDD VDD _3011_ sky130_fd_sc_hd__xnor2_1
X_4965_ _0966_ _3082_ _0972_ VSS VSS VDD VDD _0988_ sky130_fd_sc_hd__o21ai_0
X_4966_ _3146_ _0988_ VSS VSS VDD VDD _3015_ sky130_fd_sc_hd__xor2_1
X_4967_ _3025_ _3057_ VSS VSS VDD VDD _0989_ sky130_fd_sc_hd__nor2_1
X_4968_ _3082_ _0989_ VSS VSS VDD VDD _3019_ sky130_fd_sc_hd__xnor2_1
X_4969_ _3026_ net26 VSS VSS VDD VDD _0990_ sky130_fd_sc_hd__nand2_1
X_4970_ _0972_ _3023_ _0990_ VSS VSS VDD VDD _2151_ sky130_fd_sc_hd__o21ai_2
X_4971_ _2151_ VSS VSS VDD VDD _2155_ sky130_fd_sc_hd__inv_1
X_4972_ _3021_ VSS VSS VDD VDD _0991_ sky130_fd_sc_hd__inv_1
X_4973_ _2150_ _3028_ VSS VSS VDD VDD _0992_ sky130_fd_sc_hd__nor2b_1
X_4974_ _3027_ _0992_ _3022_ VSS VSS VDD VDD _0993_ sky130_fd_sc_hd__o21ai_0
X_4975_ _0991_ _0993_ _3018_ VSS VSS VDD VDD _0994_ sky130_fd_sc_hd__a21boi_0
X_4976_ _3017_ _0994_ _3014_ VSS VSS VDD VDD _0995_ sky130_fd_sc_hd__o21ai_0
X_4977_ _3013_ _0995_ VSS VSS VDD VDD _0996_ sky130_fd_sc_hd__nand2b_1
X_4978_ _3010_ _0996_ _3009_ VSS VSS VDD VDD _0997_ sky130_fd_sc_hd__a21o_1
X_4979_ _3006_ _0997_ _3005_ VSS VSS VDD VDD _0998_ sky130_fd_sc_hd__a21o_1
X_4980_ _3002_ _0998_ VSS VSS VDD VDD _0999_ sky130_fd_sc_hd__nand2_1
X_4981_ _3001_ _0999_ VSS VSS VDD VDD _1000_ sky130_fd_sc_hd__nand2b_1
X_4982_ _2998_ _1000_ _2997_ VSS VSS VDD VDD _1001_ sky130_fd_sc_hd__a21o_1
X_4983_ _2990_ _2994_ _1001_ VSS VSS VDD VDD _1002_ sky130_fd_sc_hd__nand3_1
X_4984_ _2988_ _2993_ _2987_ VSS VSS VDD VDD _1003_ sky130_fd_sc_hd__a21oi_1
X_4985_ _1002_ _1003_ VSS VSS VDD VDD _1004_ sky130_fd_sc_hd__nand2_1
X_4986_ _3036_ _1004_ _3035_ VSS VSS VDD VDD _1005_ sky130_fd_sc_hd__a21o_1
X_4987_ _3032_ _1005_ _3031_ VSS VSS VDD VDD _1006_ sky130_fd_sc_hd__a21oi_1
X_4988_ _2984_ _1006_ VSS VSS VDD VDD _3197_ sky130_fd_sc_hd__xnor2_2
X_4989_ _2993_ VSS VSS VDD VDD _1007_ sky130_fd_sc_hd__inv_1
X_4990_ _2152_ _3022_ VSS VSS VDD VDD _1008_ sky130_fd_sc_hd__nor2b_1
X_4991_ _3021_ _1008_ _3018_ VSS VSS VDD VDD _1009_ sky130_fd_sc_hd__o21ai_0
X_4992_ _3017_ _1009_ VSS VSS VDD VDD _1010_ sky130_fd_sc_hd__nand2b_1
X_4993_ _3014_ _1010_ _3013_ VSS VSS VDD VDD _1011_ sky130_fd_sc_hd__a21o_1
X_4994_ _3010_ _1011_ _3009_ VSS VSS VDD VDD _1012_ sky130_fd_sc_hd__a21o_1
X_4995_ _3006_ _1012_ _3005_ VSS VSS VDD VDD _1013_ sky130_fd_sc_hd__a21o_1
X_4996_ _3002_ _1013_ _3001_ VSS VSS VDD VDD _1014_ sky130_fd_sc_hd__a21o_1
X_4997_ _2998_ _1014_ _2997_ VSS VSS VDD VDD _1015_ sky130_fd_sc_hd__a21o_1
X_4998_ _2994_ _1015_ VSS VSS VDD VDD _1016_ sky130_fd_sc_hd__nand2_1
X_4999_ _1007_ _1016_ _2990_ VSS VSS VDD VDD _1017_ sky130_fd_sc_hd__a21boi_1
X_5000_ _2987_ _1017_ _3036_ VSS VSS VDD VDD _1018_ sky130_fd_sc_hd__o21a_1
X_5001_ _3035_ _1018_ VSS VSS VDD VDD _1019_ sky130_fd_sc_hd__nor2_1
X_5002_ _3032_ _1019_ VSS VSS VDD VDD _3201_ sky130_fd_sc_hd__xnor2_2
X_5003_ _2998_ _2990_ _2994_ VSS VSS VDD VDD _1020_ sky130_fd_sc_hd__nand3_1
X_5004_ _2994_ VSS VSS VDD VDD _1021_ sky130_fd_sc_hd__inv_2
X_5005_ _2998_ _3001_ _2997_ VSS VSS VDD VDD _1022_ sky130_fd_sc_hd__a21oi_1
X_5006_ _1021_ _1022_ _1007_ VSS VSS VDD VDD _1023_ sky130_fd_sc_hd__o21ai_0
X_5007_ _2988_ _1023_ _2987_ VSS VSS VDD VDD _1024_ sky130_fd_sc_hd__a21oi_1
X_5008_ _0999_ _1020_ _1024_ VSS VSS VDD VDD _1025_ sky130_fd_sc_hd__o21ai_2
X_5009_ _3036_ _1025_ VSS VSS VDD VDD _3205_ sky130_fd_sc_hd__xor2_4
X_5010_ _1007_ _1016_ VSS VSS VDD VDD _1026_ sky130_fd_sc_hd__nand2_1
X_5011_ _2990_ _1026_ VSS VSS VDD VDD _1027_ sky130_fd_sc_hd__nor2_1
X_5012_ _1017_ _1027_ VSS VSS VDD VDD _3159_ sky130_fd_sc_hd__nor2_2
X_5013_ _1021_ _1001_ VSS VSS VDD VDD _3209_ sky130_fd_sc_hd__xnor2_4
X_5014_ _3002_ _0998_ VSS VSS VDD VDD _3167_ sky130_fd_sc_hd__xor2_2
X_5015_ _3167_ VSS VSS VDD VDD _3108_ sky130_fd_sc_hd__inv_1
X_5016_ _3006_ _1012_ VSS VSS VDD VDD _3172_ sky130_fd_sc_hd__xor2_4
X_5017_ _3172_ VSS VSS VDD VDD _3109_ sky130_fd_sc_hd__inv_1
X_5018_ _3045_ VSS VSS VDD VDD _1028_ sky130_fd_sc_hd__inv_1
X_5019_ _3051_ VSS VSS VDD VDD _1029_ sky130_fd_sc_hd__inv_1
X_5020_ _3058_ VSS VSS VDD VDD _1030_ sky130_fd_sc_hd__inv_1
X_5021_ _3064_ VSS VSS VDD VDD _1031_ sky130_fd_sc_hd__inv_1
X_5022_ _3070_ VSS VSS VDD VDD _1032_ sky130_fd_sc_hd__inv_1
X_5023_ _3076_ VSS VSS VDD VDD _1033_ sky130_fd_sc_hd__inv_1
X_5024_ net62 _3080_ VSS VSS VDD VDD _1034_ sky130_fd_sc_hd__nor2b_1
X_5025_ _1034_ _3079_ _3077_ VSS VSS VDD VDD _1035_ sky130_fd_sc_hd__o21ai_1
X_5026_ _1035_ _1033_ _3074_ VSS VSS VDD VDD _1036_ sky130_fd_sc_hd__a21boi_2
X_5027_ _1036_ _3073_ _3071_ VSS VSS VDD VDD _1037_ sky130_fd_sc_hd__o21ai_2
X_5028_ _1037_ _1032_ _3068_ VSS VSS VDD VDD _1038_ sky130_fd_sc_hd__a21boi_2
X_5029_ _1038_ _3067_ _3065_ VSS VSS VDD VDD _1039_ sky130_fd_sc_hd__o21ai_2
X_5030_ _1039_ _1031_ _3062_ VSS VSS VDD VDD _1040_ sky130_fd_sc_hd__a21boi_2
X_5031_ _1040_ _3061_ _3059_ VSS VSS VDD VDD _1041_ sky130_fd_sc_hd__o21ai_2
X_5032_ _1041_ _1030_ _3055_ VSS VSS VDD VDD _1042_ sky130_fd_sc_hd__a21boi_2
X_5033_ _1042_ _3054_ _3052_ VSS VSS VDD VDD _1043_ sky130_fd_sc_hd__o21ai_2
X_5034_ _1043_ _1029_ _3049_ VSS VSS VDD VDD _1044_ sky130_fd_sc_hd__a21boi_2
X_5035_ _1044_ _3048_ _3046_ VSS VSS VDD VDD _1045_ sky130_fd_sc_hd__o21ai_2
X_5036_ _1028_ _1045_ _3043_ VSS VSS VDD VDD _1046_ sky130_fd_sc_hd__a21boi_2
X_5037_ _3042_ _1046_ _3040_ VSS VSS VDD VDD _1047_ sky130_fd_sc_hd__o21a_1
X_5038_ _3039_ _1047_ VSS VSS VDD VDD _1048_ sky130_fd_sc_hd__or2_4
X_5039_ _1048_ VSS VSS VDD VDD _3213_ sky130_fd_sc_hd__buf_12
X_5040_ _3213_ VSS VSS VDD VDD _1049_ sky130_fd_sc_hd__clkinv_8
X_5041_ _1049_ VSS VSS VDD VDD _3235_ sky130_fd_sc_hd__buf_12
X_5042_ _2905_ VSS VSS VDD VDD _1050_ sky130_fd_sc_hd__inv_1
X_5043_ _2146_ _2923_ _2922_ VSS VSS VDD VDD _1051_ sky130_fd_sc_hd__a21o_1
X_5044_ _2917_ _1051_ _2916_ VSS VSS VDD VDD _1052_ sky130_fd_sc_hd__a21oi_1
X_5045_ _0891_ _1052_ _2912_ VSS VSS VDD VDD _1053_ sky130_fd_sc_hd__o21bai_1
X_5046_ _2909_ _1053_ _2908_ VSS VSS VDD VDD _1054_ sky130_fd_sc_hd__a21oi_1
X_5047_ _1050_ _1054_ _2904_ VSS VSS VDD VDD _1055_ sky130_fd_sc_hd__o21bai_1
X_5048_ _2902_ _1055_ _2901_ VSS VSS VDD VDD _1056_ sky130_fd_sc_hd__a21oi_2
X_5049_ _3084_ _1056_ VSS VSS VDD VDD _3086_ sky130_fd_sc_hd__xnor2_2
X_5050_ _3086_ VSS VSS VDD VDD _3191_ sky130_fd_sc_hd__inv_1
X_5051_ _2998_ _1014_ VSS VSS VDD VDD _3163_ sky130_fd_sc_hd__xor2_4
X_5052_ _3095_ VSS VSS VDD VDD _1057_ sky130_fd_sc_hd__inv_1
X_5053_ _3103_ VSS VSS VDD VDD _1058_ sky130_fd_sc_hd__inv_1
X_5054_ _2156_ _3113_ _3112_ VSS VSS VDD VDD _1059_ sky130_fd_sc_hd__a21o_1
X_5055_ _3107_ _1059_ _3106_ VSS VSS VDD VDD _1060_ sky130_fd_sc_hd__a21oi_1
X_5056_ _1058_ _1060_ _3102_ VSS VSS VDD VDD _1061_ sky130_fd_sc_hd__o21bai_1
X_5057_ _3099_ _1061_ _3098_ VSS VSS VDD VDD _1062_ sky130_fd_sc_hd__a21oi_1
X_5058_ _1057_ _1062_ _3094_ VSS VSS VDD VDD _1063_ sky130_fd_sc_hd__o21bai_1
X_5059_ _3091_ _1063_ _3090_ VSS VSS VDD VDD _1064_ sky130_fd_sc_hd__a21oi_2
X_5060_ _3088_ _1064_ VSS VSS VDD VDD _3115_ sky130_fd_sc_hd__xnor2_2
X_5061_ _0910_ _0915_ VSS VSS VDD VDD _3118_ sky130_fd_sc_hd__and2_0
X_5062_ _2942_ _0976_ _2941_ VSS VSS VDD VDD _1065_ sky130_fd_sc_hd__a21o_1
X_5063_ _2938_ _1065_ _2937_ VSS VSS VDD VDD _1066_ sky130_fd_sc_hd__a21o_1
X_5064_ _3120_ _1066_ VSS VSS VDD VDD _3121_ sky130_fd_sc_hd__xor2_4
X_5065_ _0977_ _0981_ _0974_ VSS VSS VDD VDD _3122_ sky130_fd_sc_hd__a21boi_0
X_5066_ _3150_ VSS VSS VDD VDD _1067_ sky130_fd_sc_hd__inv_1
X_5067_ _3140_ VSS VSS VDD VDD _1068_ sky130_fd_sc_hd__inv_1
X_5068_ _3148_ VSS VSS VDD VDD _1069_ sky130_fd_sc_hd__inv_1
X_5069_ _2902_ VSS VSS VDD VDD _1070_ sky130_fd_sc_hd__inv_1
X_5070_ _1070_ _0896_ _2901_ VSS VSS VDD VDD _1071_ sky130_fd_sc_hd__o21bai_1
X_5071_ _3084_ _1071_ _3083_ VSS VSS VDD VDD _1072_ sky130_fd_sc_hd__a21oi_1
X_5072_ _1069_ _1072_ _3147_ VSS VSS VDD VDD _1073_ sky130_fd_sc_hd__o21bai_1
X_5073_ _3144_ _1073_ _3143_ VSS VSS VDD VDD _1074_ sky130_fd_sc_hd__a21oi_1
X_5074_ _1068_ _1074_ _3139_ VSS VSS VDD VDD _1075_ sky130_fd_sc_hd__o21bai_1
X_5075_ _3154_ _1075_ _3153_ VSS VSS VDD VDD _1076_ sky130_fd_sc_hd__a21oi_2
X_5076_ _1067_ _1076_ _3135_ VSS VSS VDD VDD _1077_ sky130_fd_sc_hd__o21bai_1
X_5077_ _3132_ _1077_ _3131_ VSS VSS VDD VDD _1078_ sky130_fd_sc_hd__a21oi_2
X_5078_ _3128_ _1078_ VSS VSS VDD VDD _3294_ sky130_fd_sc_hd__xnor2_4
X_5079_ _3132_ VSS VSS VDD VDD _1079_ sky130_fd_sc_hd__inv_1
X_5080_ _3154_ VSS VSS VDD VDD _1080_ sky130_fd_sc_hd__inv_1
X_5081_ _3144_ VSS VSS VDD VDD _1081_ sky130_fd_sc_hd__inv_1
X_5082_ _3084_ VSS VSS VDD VDD _1082_ sky130_fd_sc_hd__inv_1
X_5083_ _1082_ _1056_ _3083_ VSS VSS VDD VDD _1083_ sky130_fd_sc_hd__o21bai_1
X_5084_ _3148_ _1083_ _3147_ VSS VSS VDD VDD _1084_ sky130_fd_sc_hd__a21oi_2
X_5085_ _1081_ _1084_ _3143_ VSS VSS VDD VDD _1085_ sky130_fd_sc_hd__o21bai_1
X_5086_ _3140_ _1085_ _3139_ VSS VSS VDD VDD _1086_ sky130_fd_sc_hd__a21oi_2
X_5087_ _1080_ _1086_ _3153_ VSS VSS VDD VDD _1087_ sky130_fd_sc_hd__o21bai_1
X_5088_ _3136_ _1087_ _3135_ VSS VSS VDD VDD _1088_ sky130_fd_sc_hd__a21oi_2
X_5089_ _1079_ _1088_ VSS VSS VDD VDD _1089_ sky130_fd_sc_hd__xnor2_2
X_5090_ _1089_ VSS VSS VDD VDD _3310_ sky130_fd_sc_hd__inv_1
X_5091_ _3150_ _1076_ VSS VSS VDD VDD _3298_ sky130_fd_sc_hd__xnor2_4
X_5092_ _3154_ _1086_ VSS VSS VDD VDD _3316_ sky130_fd_sc_hd__xnor2_2
X_5093_ _3140_ _1074_ VSS VSS VDD VDD _3302_ sky130_fd_sc_hd__xnor2_2
X_5094_ _3144_ _1084_ VSS VSS VDD VDD _3306_ sky130_fd_sc_hd__xnor2_2
X_5095_ _3032_ VSS VSS VDD VDD _1090_ sky130_fd_sc_hd__inv_1
X_5096_ _1090_ _1019_ _3031_ VSS VSS VDD VDD _1091_ sky130_fd_sc_hd__o21bai_1
X_5097_ _2984_ _1091_ _2983_ VSS VSS VDD VDD _1092_ sky130_fd_sc_hd__a21o_1
X_5098_ _3124_ _1092_ VSS VSS VDD VDD _3156_ sky130_fd_sc_hd__xor2_1
X_5099_ _3148_ _1072_ VSS VSS VDD VDD _3257_ sky130_fd_sc_hd__xnor2_2
X_5100_ _2938_ _3120_ VSS VSS VDD VDD _1093_ sky130_fd_sc_hd__nand2_1
X_5101_ _3120_ _2937_ _3119_ VSS VSS VDD VDD _1094_ sky130_fd_sc_hd__a21oi_1
X_5102_ _0917_ _1093_ _1094_ VSS VSS VDD VDD _1095_ sky130_fd_sc_hd__o21ai_0
X_5103_ _0950_ _0951_ _1095_ VSS VSS VDD VDD _1096_ sky130_fd_sc_hd__o21ba_1
X_5104_ _0950_ _0951_ _1095_ VSS VSS VDD VDD _1097_ sky130_fd_sc_hd__nor3b_2
X_5105_ _0909_ _0910_ _1096_ _1097_ VSS VSS VDD VDD _1098_
+ sky130_fd_sc_hd__a211oi_2
X_5106_ _1096_ _1097_ _0909_ _0910_ VSS VSS VDD VDD _1099_
+ sky130_fd_sc_hd__o211a_1
X_5107_ _3000_ _3004_ _3008_ VSS VSS VDD VDD _1100_ sky130_fd_sc_hd__nor3_1
X_5108_ _1100_ VSS VSS VDD VDD _1101_ sky130_fd_sc_hd__inv_1
X_5109_ _2992_ _2996_ VSS VSS VDD VDD _1102_ sky130_fd_sc_hd__or2_0
X_5110_ _3034_ _2986_ _1101_ _1102_ VSS VSS VDD VDD _1103_
+ sky130_fd_sc_hd__or4_1
X_5111_ _2981_ _3029_ _3121_ _1103_ net17 VSS VSS VDD VDD
+ _1104_ sky130_fd_sc_hd__o41ai_1
X_5112_ _1098_ _1099_ _1104_ VSS VSS VDD VDD _1105_ sky130_fd_sc_hd__nor3_2
X_5113_ _1098_ _1099_ _3057_ VSS VSS VDD VDD _1106_ sky130_fd_sc_hd__o21a_2
X_5114_ _0952_ _0958_ VSS VSS VDD VDD _2973_ sky130_fd_sc_hd__nand2_1
X_5115_ _0962_ _0963_ VSS VSS VDD VDD _1107_ sky130_fd_sc_hd__nand2_1
X_5116_ _1079_ _1088_ _3131_ VSS VSS VDD VDD _1108_ sky130_fd_sc_hd__o21bai_1
X_5117_ _3128_ _1108_ _3127_ VSS VSS VDD VDD _1109_ sky130_fd_sc_hd__a21oi_2
X_5118_ _2973_ _1107_ _1109_ VSS VSS VDD VDD _1110_ sky130_fd_sc_hd__xnor3_4
X_5119_ _1105_ _1106_ _1110_ VSS VSS VDD VDD _1111_ sky130_fd_sc_hd__o21a_1
X_5120_ _1105_ _1106_ _1110_ VSS VSS VDD VDD _1112_ sky130_fd_sc_hd__nor3_4
X_5121_ _1111_ _1112_ VSS VSS VDD VDD _1113_ sky130_fd_sc_hd__or2_1
X_5122_ _3306_ _3257_ VSS VSS VDD VDD _1114_ sky130_fd_sc_hd__nor2_1
X_5123_ _3193_ _1114_ VSS VSS VDD VDD _1115_ sky130_fd_sc_hd__nand2_1
X_5124_ _3316_ _3302_ _1115_ VSS VSS VDD VDD _1116_ sky130_fd_sc_hd__nor3_1
X_5125_ _3298_ _1116_ VSS VSS VDD VDD _1117_ sky130_fd_sc_hd__nor2b_1
X_5126_ _1089_ _1117_ net25 VSS VSS VDD VDD _1118_ sky130_fd_sc_hd__a21oi_1
X_5127_ _3294_ _1118_ VSS VSS VDD VDD _1119_ sky130_fd_sc_hd__nor2_1
X_5128_ net11 _1119_ VSS VSS VDD VDD _1120_ sky130_fd_sc_hd__nor2_1
X_5129_ _1111_ net10 _1112_ VSS VSS VDD VDD _1121_ sky130_fd_sc_hd__nor3_4
X_5130_ _1113_ _1120_ _1121_ VSS VSS VDD VDD _3155_ sky130_fd_sc_hd__a21oi_1
X_5131_ _3302_ VSS VSS VDD VDD _1122_ sky130_fd_sc_hd__inv_1
X_5132_ _3192_ _3191_ _1122_ _1114_ VSS VSS VDD VDD _1123_
+ sky130_fd_sc_hd__nand4_1
X_5133_ _3298_ _3316_ _1123_ VSS VSS VDD VDD _1124_ sky130_fd_sc_hd__nor3_1
X_5134_ _1089_ _1124_ VSS VSS VDD VDD _1125_ sky130_fd_sc_hd__nand2_1
X_5135_ _3294_ _1125_ VSS VSS VDD VDD _1126_ sky130_fd_sc_hd__nor2_1
X_5136_ net25 _1126_ VSS VSS VDD VDD _1127_ sky130_fd_sc_hd__nor2_1
X_5137_ _1111_ _1112_ _1127_ VSS VSS VDD VDD _1128_ sky130_fd_sc_hd__o21a_2
X_5138_ _1121_ _1128_ VSS VSS VDD VDD _3198_ sky130_fd_sc_hd__nor2_2
X_5139_ _1113_ _1120_ _1121_ VSS VSS VDD VDD _3202_ sky130_fd_sc_hd__a21oi_1
X_5140_ _1121_ _1128_ VSS VSS VDD VDD _3206_ sky130_fd_sc_hd__nor2_1
X_5141_ _1113_ _1120_ _1121_ VSS VSS VDD VDD _3160_ sky130_fd_sc_hd__a21oi_1
X_5142_ _1113_ _1127_ VSS VSS VDD VDD _1129_ sky130_fd_sc_hd__nor2_1
X_5143_ _1128_ _1129_ VSS VSS VDD VDD _3210_ sky130_fd_sc_hd__nor2_1
X_5144_ _3294_ _1118_ VSS VSS VDD VDD _3164_ sky130_fd_sc_hd__xnor2_1
X_5145_ net11 _1124_ VSS VSS VDD VDD _1130_ sky130_fd_sc_hd__nor2_1
X_5146_ _3310_ _1130_ VSS VSS VDD VDD _3168_ sky130_fd_sc_hd__xnor2_1
X_5147_ net11 _1116_ VSS VSS VDD VDD _1131_ sky130_fd_sc_hd__nor2_1
X_5148_ _3298_ _1131_ VSS VSS VDD VDD _3171_ sky130_fd_sc_hd__xnor2_1
X_5149_ net10 _1123_ VSS VSS VDD VDD _1132_ sky130_fd_sc_hd__nand2_1
X_5150_ _3316_ _1132_ VSS VSS VDD VDD _3175_ sky130_fd_sc_hd__xor2_1
X_5151_ net19 _1115_ VSS VSS VDD VDD _1133_ sky130_fd_sc_hd__nand2_1
X_5152_ _1122_ _1133_ VSS VSS VDD VDD _3179_ sky130_fd_sc_hd__xnor2_1
X_5153_ _2925_ _3086_ _3257_ VSS VSS VDD VDD _1134_ sky130_fd_sc_hd__nor3_1
X_5154_ net11 _1134_ VSS VSS VDD VDD _1135_ sky130_fd_sc_hd__nor2_1
X_5155_ _3306_ _1135_ VSS VSS VDD VDD _3184_ sky130_fd_sc_hd__xnor2_1
X_5156_ _3193_ _3235_ VSS VSS VDD VDD _1136_ sky130_fd_sc_hd__nor2_1
X_5157_ _3257_ _1136_ VSS VSS VDD VDD _3187_ sky130_fd_sc_hd__xnor2_1
X_5158_ _3194_ _3086_ _3235_ VSS VSS VDD VDD _2161_ sky130_fd_sc_hd__mux2i_4
X_5159_ _3204_ VSS VSS VDD VDD _1137_ sky130_fd_sc_hd__inv_1
X_5160_ _3162_ VSS VSS VDD VDD _1138_ sky130_fd_sc_hd__inv_1
X_5161_ _3166_ VSS VSS VDD VDD _1139_ sky130_fd_sc_hd__inv_1
X_5162_ _3174_ VSS VSS VDD VDD _1140_ sky130_fd_sc_hd__inv_1
X_5163_ _3182_ VSS VSS VDD VDD _1141_ sky130_fd_sc_hd__inv_1
X_5164_ _2163_ _3190_ _3189_ VSS VSS VDD VDD _1142_ sky130_fd_sc_hd__a21o_1
X_5165_ _3186_ _1142_ _3185_ VSS VSS VDD VDD _1143_ sky130_fd_sc_hd__a21oi_1
X_5166_ _1141_ _1143_ _3181_ VSS VSS VDD VDD _1144_ sky130_fd_sc_hd__o21bai_1
X_5167_ _3178_ _1144_ _3177_ VSS VSS VDD VDD _1145_ sky130_fd_sc_hd__a21oi_1
X_5168_ _1140_ _1145_ _3173_ VSS VSS VDD VDD _1146_ sky130_fd_sc_hd__o21bai_1
X_5169_ _3170_ _1146_ _3169_ VSS VSS VDD VDD _1147_ sky130_fd_sc_hd__a21oi_2
X_5170_ _1139_ _1147_ _3165_ VSS VSS VDD VDD _1148_ sky130_fd_sc_hd__o21bai_1
X_5171_ _3212_ _1148_ _3211_ VSS VSS VDD VDD _1149_ sky130_fd_sc_hd__a21oi_2
X_5172_ _1138_ _1149_ _3161_ VSS VSS VDD VDD _1150_ sky130_fd_sc_hd__o21bai_1
X_5173_ _3208_ _1150_ _3207_ VSS VSS VDD VDD _1151_ sky130_fd_sc_hd__a21oi_2
X_5174_ _1137_ _1151_ _3203_ VSS VSS VDD VDD _1152_ sky130_fd_sc_hd__o21bai_1
X_5175_ _3200_ _1152_ _3199_ VSS VSS VDD VDD _1153_ sky130_fd_sc_hd__a21oi_2
X_5176_ _3158_ _1153_ VSS VSS VDD VDD _3321_ sky130_fd_sc_hd__xnor2_4
X_5177_ _2165_ VSS VSS VDD VDD _2162_ sky130_fd_sc_hd__inv_1
X_5178_ _2162_ _3196_ _3195_ VSS VSS VDD VDD _1154_ sky130_fd_sc_hd__a21o_1
X_5179_ _3190_ _1154_ _3189_ VSS VSS VDD VDD _1155_ sky130_fd_sc_hd__a21o_1
X_5180_ _1155_ _3186_ _3185_ VSS VSS VDD VDD _1156_ sky130_fd_sc_hd__a21oi_2
X_5181_ _1141_ _1156_ _3181_ VSS VSS VDD VDD _1157_ sky130_fd_sc_hd__o21bai_2
X_5182_ _3178_ _1157_ _3177_ VSS VSS VDD VDD _1158_ sky130_fd_sc_hd__a21oi_2
X_5183_ _1140_ _1158_ _3173_ VSS VSS VDD VDD _1159_ sky130_fd_sc_hd__o21bai_2
X_5184_ _1159_ _3170_ _3169_ VSS VSS VDD VDD _1160_ sky130_fd_sc_hd__a21oi_2
X_5185_ _1139_ _1160_ _3165_ VSS VSS VDD VDD _1161_ sky130_fd_sc_hd__o21bai_4
X_5186_ _1161_ _3212_ _3211_ VSS VSS VDD VDD _1162_ sky130_fd_sc_hd__a21oi_2
X_5187_ _1138_ _1162_ _3161_ VSS VSS VDD VDD _1163_ sky130_fd_sc_hd__o21bai_4
X_5188_ _3208_ _1163_ _3207_ VSS VSS VDD VDD _1164_ sky130_fd_sc_hd__a21oi_2
X_5189_ _1164_ _1137_ _3203_ VSS VSS VDD VDD _1165_ sky130_fd_sc_hd__o21bai_4
X_5190_ _3200_ _1165_ VSS VSS VDD VDD _3361_ sky130_fd_sc_hd__xor2_4
X_5191_ _3204_ _1151_ VSS VSS VDD VDD _3365_ sky130_fd_sc_hd__xnor2_4
X_5192_ _3208_ _1163_ VSS VSS VDD VDD _3368_ sky130_fd_sc_hd__xor2_4
X_5193_ _3162_ _1149_ VSS VSS VDD VDD _3324_ sky130_fd_sc_hd__xnor2_4
X_5194_ _3212_ _1161_ VSS VSS VDD VDD _3372_ sky130_fd_sc_hd__xor2_4
X_5195_ _3166_ _1147_ VSS VSS VDD VDD _3328_ sky130_fd_sc_hd__xnor2_2
X_5196_ _3170_ _1159_ VSS VSS VDD VDD _3376_ sky130_fd_sc_hd__xor2_2
X_5197_ _3219_ VSS VSS VDD VDD _1166_ sky130_fd_sc_hd__inv_1
X_5198_ _3225_ VSS VSS VDD VDD _1167_ sky130_fd_sc_hd__inv_1
X_5199_ _3231_ VSS VSS VDD VDD _1168_ sky130_fd_sc_hd__inv_1
X_5200_ _3238_ VSS VSS VDD VDD _1169_ sky130_fd_sc_hd__inv_1
X_5201_ _3244_ VSS VSS VDD VDD _1170_ sky130_fd_sc_hd__inv_1
X_5202_ _3250_ VSS VSS VDD VDD _1171_ sky130_fd_sc_hd__inv_1
X_5203_ _3256_ net62 _3255_ VSS VSS VDD VDD _1172_ sky130_fd_sc_hd__a21o_1
X_5204_ _1172_ _3253_ _3252_ VSS VSS VDD VDD _1173_ sky130_fd_sc_hd__a21oi_2
X_5205_ _1173_ _1171_ _3249_ VSS VSS VDD VDD _1174_ sky130_fd_sc_hd__o21bai_1
X_5206_ _1174_ _3247_ _3246_ VSS VSS VDD VDD _1175_ sky130_fd_sc_hd__a21oi_2
X_5207_ _1175_ _1170_ _3243_ VSS VSS VDD VDD _1176_ sky130_fd_sc_hd__o21bai_1
X_5208_ _1176_ _3241_ _3240_ VSS VSS VDD VDD _1177_ sky130_fd_sc_hd__a21oi_2
X_5209_ _1177_ _1169_ _3237_ VSS VSS VDD VDD _1178_ sky130_fd_sc_hd__o21bai_1
X_5210_ _1178_ _3234_ _3233_ VSS VSS VDD VDD _1179_ sky130_fd_sc_hd__a21oi_2
X_5211_ _1179_ _1168_ _3230_ VSS VSS VDD VDD _1180_ sky130_fd_sc_hd__o21bai_1
X_5212_ _1180_ _3228_ _3227_ VSS VSS VDD VDD _1181_ sky130_fd_sc_hd__a21oi_2
X_5213_ _1167_ _1181_ _3224_ VSS VSS VDD VDD _1182_ sky130_fd_sc_hd__o21bai_1
X_5214_ _1182_ _3222_ _3221_ VSS VSS VDD VDD _1183_ sky130_fd_sc_hd__a21oi_2
X_5215_ _1183_ _1166_ _3218_ VSS VSS VDD VDD _1184_ sky130_fd_sc_hd__o21bai_1
X_5216_ _1184_ _3216_ _3215_ VSS VSS VDD VDD _1185_ sky130_fd_sc_hd__a21o_2
X_5217_ _1185_ VSS VSS VDD VDD _1186_ sky130_fd_sc_hd__inv_4
X_5218_ _1186_ VSS VSS VDD VDD _3405_ sky130_fd_sc_hd__buf_8
X_5219_ _3091_ VSS VSS VDD VDD _1187_ sky130_fd_sc_hd__inv_1
X_5220_ _3099_ VSS VSS VDD VDD _1188_ sky130_fd_sc_hd__inv_1
X_5221_ _3107_ _2158_ _3106_ VSS VSS VDD VDD _1189_ sky130_fd_sc_hd__a21oi_1
X_5222_ _1058_ _1189_ VSS VSS VDD VDD _1190_ sky130_fd_sc_hd__nor2_1
X_5223_ _3102_ _1190_ VSS VSS VDD VDD _1191_ sky130_fd_sc_hd__nor2_1
X_5224_ _1188_ _1191_ _3098_ VSS VSS VDD VDD _1192_ sky130_fd_sc_hd__o21bai_1
X_5225_ _3095_ _1192_ _3094_ VSS VSS VDD VDD _1193_ sky130_fd_sc_hd__a21oi_1
X_5226_ _1187_ _1193_ _3090_ VSS VSS VDD VDD _1194_ sky130_fd_sc_hd__o21bai_1
X_5227_ _3088_ _1194_ _3087_ VSS VSS VDD VDD _1195_ sky130_fd_sc_hd__a21oi_2
X_5228_ _3260_ _1195_ VSS VSS VDD VDD _3262_ sky130_fd_sc_hd__xnor2_2
X_5229_ _3376_ VSS VSS VDD VDD _3286_ sky130_fd_sc_hd__inv_1
X_5230_ _3328_ VSS VSS VDD VDD _3285_ sky130_fd_sc_hd__inv_1
X_5231_ _3268_ VSS VSS VDD VDD _1196_ sky130_fd_sc_hd__inv_1
X_5232_ _3276_ VSS VSS VDD VDD _1197_ sky130_fd_sc_hd__inv_1
X_5233_ _3280_ VSS VSS VDD VDD _1198_ sky130_fd_sc_hd__inv_1
X_5234_ _2168_ _3284_ _3283_ VSS VSS VDD VDD _1199_ sky130_fd_sc_hd__a21oi_1
X_5235_ _1198_ _1199_ VSS VSS VDD VDD _1200_ sky130_fd_sc_hd__nor2_1
X_5236_ _3279_ _1200_ VSS VSS VDD VDD _1201_ sky130_fd_sc_hd__nor2_1
X_5237_ _1197_ _1201_ _3275_ VSS VSS VDD VDD _1202_ sky130_fd_sc_hd__o21bai_1
X_5238_ _3272_ _1202_ _3271_ VSS VSS VDD VDD _1203_ sky130_fd_sc_hd__a21oi_2
X_5239_ _1196_ _1203_ _3267_ VSS VSS VDD VDD _1204_ sky130_fd_sc_hd__o21bai_1
X_5240_ _1204_ _3432_ _3431_ VSS VSS VDD VDD _1205_ sky130_fd_sc_hd__a21oi_2
X_5241_ net113 net194 VSS VSS VDD VDD _3292_ sky130_fd_sc_hd__xnor2_4
X_5242_ _3292_ VSS VSS VDD VDD _3460_ sky130_fd_sc_hd__inv_1
X_5243_ _3315_ VSS VSS VDD VDD _1206_ sky130_fd_sc_hd__inv_1
X_5244_ _3305_ VSS VSS VDD VDD _1207_ sky130_fd_sc_hd__inv_1
X_5245_ _3260_ VSS VSS VDD VDD _1208_ sky130_fd_sc_hd__inv_1
X_5246_ _1208_ _1195_ _3259_ VSS VSS VDD VDD _1209_ sky130_fd_sc_hd__o21bai_1
X_5247_ _3309_ _1209_ _3308_ VSS VSS VDD VDD _1210_ sky130_fd_sc_hd__a21oi_2
X_5248_ _1207_ _1210_ _3304_ VSS VSS VDD VDD _1211_ sky130_fd_sc_hd__o21bai_1
X_5249_ _3319_ _1211_ _3318_ VSS VSS VDD VDD _1212_ sky130_fd_sc_hd__a21oi_2
X_5250_ _1206_ _1212_ _3300_ VSS VSS VDD VDD _1213_ sky130_fd_sc_hd__o21bai_1
X_5251_ _3313_ _1213_ _3312_ VSS VSS VDD VDD _1214_ sky130_fd_sc_hd__a21oi_2
X_5252_ _3297_ _1214_ VSS VSS VDD VDD _3581_ sky130_fd_sc_hd__xnor2_4
X_5253_ _3319_ VSS VSS VDD VDD _1215_ sky130_fd_sc_hd__inv_1
X_5254_ _3309_ VSS VSS VDD VDD _1216_ sky130_fd_sc_hd__inv_1
X_5255_ _3088_ VSS VSS VDD VDD _1217_ sky130_fd_sc_hd__inv_1
X_5256_ _1217_ _1064_ _3087_ VSS VSS VDD VDD _1218_ sky130_fd_sc_hd__o21bai_1
X_5257_ _3260_ _1218_ _3259_ VSS VSS VDD VDD _1219_ sky130_fd_sc_hd__a21oi_2
X_5258_ _1216_ _1219_ _3308_ VSS VSS VDD VDD _1220_ sky130_fd_sc_hd__o21bai_1
X_5259_ _1220_ _3305_ _3304_ VSS VSS VDD VDD _1221_ sky130_fd_sc_hd__a21oi_2
X_5260_ _1215_ _1221_ _3318_ VSS VSS VDD VDD _1222_ sky130_fd_sc_hd__o21bai_1
X_5261_ _1222_ _3301_ _3300_ VSS VSS VDD VDD _1223_ sky130_fd_sc_hd__a21oi_2
X_5262_ _3313_ net114 VSS VSS VDD VDD _3565_ sky130_fd_sc_hd__xnor2_4
X_5263_ _3315_ _1212_ VSS VSS VDD VDD _3549_ sky130_fd_sc_hd__xnor2_4
X_5264_ _3319_ net128 VSS VSS VDD VDD _3533_ sky130_fd_sc_hd__xnor2_4
X_5265_ _3305_ _1210_ VSS VSS VDD VDD _3465_ sky130_fd_sc_hd__xnor2_2
X_5266_ _3309_ _1219_ VSS VSS VDD VDD _3424_ sky130_fd_sc_hd__xnor2_2
X_5267_ _3115_ VSS VSS VDD VDD _3354_ sky130_fd_sc_hd__inv_1
X_5268_ _1096_ _1097_ VSS VSS VDD VDD _1224_ sky130_fd_sc_hd__nor2_1
X_5269_ _3036_ _1025_ _3035_ VSS VSS VDD VDD _1225_ sky130_fd_sc_hd__a21oi_1
X_5270_ _1090_ _1225_ VSS VSS VDD VDD _1226_ sky130_fd_sc_hd__nor2_1
X_5271_ _3031_ _1226_ _2984_ VSS VSS VDD VDD _1227_ sky130_fd_sc_hd__o21ai_0
X_5272_ _2983_ _1227_ VSS VSS VDD VDD _1228_ sky130_fd_sc_hd__nand2b_1
X_5273_ _3124_ _1228_ _3123_ VSS VSS VDD VDD _1229_ sky130_fd_sc_hd__a21oi_1
X_5274_ _2935_ _1224_ _1229_ VSS VSS VDD VDD _1230_ sky130_fd_sc_hd__xnor3_4
X_5275_ _0973_ _0974_ _1230_ VSS VSS VDD VDD _1231_ sky130_fd_sc_hd__a21oi_2
X_5276_ _0973_ _0974_ _1230_ VSS VSS VDD VDD _1232_ sky130_fd_sc_hd__and3_1
X_5277_ net10 _1231_ _1232_ VSS VSS VDD VDD _1233_ sky130_fd_sc_hd__nor3_4
X_5278_ _3156_ VSS VSS VDD VDD _1234_ sky130_fd_sc_hd__inv_1
X_5279_ _3167_ _3172_ _3163_ VSS VSS VDD VDD _1235_ sky130_fd_sc_hd__nor3_2
X_5280_ _3205_ _3159_ _3209_ VSS VSS VDD VDD _1236_ sky130_fd_sc_hd__nor3_1
X_5281_ _3201_ _1236_ VSS VSS VDD VDD _1237_ sky130_fd_sc_hd__nor2b_1
X_5282_ _3197_ _1237_ VSS VSS VDD VDD _1238_ sky130_fd_sc_hd__nor2b_1
X_5283_ _1234_ _1235_ _1238_ net25 VSS VSS VDD VDD _1239_
+ sky130_fd_sc_hd__a31oi_2
X_5284_ _1231_ _1232_ _1239_ VSS VSS VDD VDD _1240_ sky130_fd_sc_hd__o21a_1
X_5285_ _1105_ _1106_ VSS VSS VDD VDD _3129_ sky130_fd_sc_hd__or2_1
X_5286_ _3313_ VSS VSS VDD VDD _1241_ sky130_fd_sc_hd__inv_1
X_5287_ _1241_ _1223_ _3312_ VSS VSS VDD VDD _1242_ sky130_fd_sc_hd__o21bai_1
X_5288_ _3297_ _1242_ _3296_ VSS VSS VDD VDD _1243_ sky130_fd_sc_hd__a21oi_1
X_5289_ _3129_ _1110_ _1243_ VSS VSS VDD VDD _1244_ sky130_fd_sc_hd__xnor3_4
X_5290_ _1233_ _1240_ _1244_ VSS VSS VDD VDD _1245_ sky130_fd_sc_hd__o21a_1
X_5291_ _1233_ _1240_ _1244_ VSS VSS VDD VDD _1246_ sky130_fd_sc_hd__nor3_2
X_5292_ _1245_ _1246_ VSS VSS VDD VDD _1247_ sky130_fd_sc_hd__or2_0
X_5293_ _1247_ VSS VSS VDD VDD _1248_ sky130_fd_sc_hd__clkbuf_2
X_5294_ _3465_ _3424_ VSS VSS VDD VDD _1249_ sky130_fd_sc_hd__nor2_1
X_5295_ _3356_ _1249_ VSS VSS VDD VDD _1250_ sky130_fd_sc_hd__nand2_1
X_5296_ _3549_ _3533_ _1250_ VSS VSS VDD VDD _1251_ sky130_fd_sc_hd__nor3_1
X_5297_ _3581_ _3565_ VSS VSS VDD VDD _1252_ sky130_fd_sc_hd__nor2_1
X_5298_ _1251_ _1252_ _1186_ VSS VSS VDD VDD _1253_ sky130_fd_sc_hd__a21oi_2
X_5299_ _1185_ VSS VSS VDD VDD _3380_ sky130_fd_sc_hd__buf_6
X_5300_ net7 _1248_ VSS VSS VDD VDD _1254_ sky130_fd_sc_hd__nor2_2
X_5301_ _1248_ _1253_ _1254_ VSS VSS VDD VDD _3320_ sky130_fd_sc_hd__a21oi_1
X_5302_ _3115_ _3262_ _3424_ VSS VSS VDD VDD _1255_ sky130_fd_sc_hd__or3_1
X_5303_ _3533_ _3465_ _1255_ VSS VSS VDD VDD _1256_ sky130_fd_sc_hd__nor3_1
X_5304_ _3565_ _3549_ _1256_ VSS VSS VDD VDD _1257_ sky130_fd_sc_hd__or3b_1
X_5305_ _3581_ _1257_ VSS VSS VDD VDD _1258_ sky130_fd_sc_hd__nor2_1
X_5306_ _1186_ _1258_ VSS VSS VDD VDD _1259_ sky130_fd_sc_hd__nor2_2
X_5307_ _1248_ _1259_ _1254_ VSS VSS VDD VDD _3360_ sky130_fd_sc_hd__a21oi_1
X_5308_ _1248_ _1253_ _1254_ VSS VSS VDD VDD _3364_ sky130_fd_sc_hd__a21oi_1
X_5309_ _1248_ _1259_ _1254_ VSS VSS VDD VDD _3369_ sky130_fd_sc_hd__a21oi_1
X_5310_ _1248_ _1253_ _1254_ VSS VSS VDD VDD _3325_ sky130_fd_sc_hd__a21oi_1
X_5311_ _1248_ _1259_ _1254_ VSS VSS VDD VDD _3373_ sky130_fd_sc_hd__a21oi_1
X_5312_ _1248_ _1253_ VSS VSS VDD VDD _3329_ sky130_fd_sc_hd__xor2_1
X_5313_ net20 _1257_ VSS VSS VDD VDD _1260_ sky130_fd_sc_hd__nand2_1
X_5314_ _3581_ _1260_ VSS VSS VDD VDD _3377_ sky130_fd_sc_hd__xor2_1
X_5315_ _3405_ _1251_ VSS VSS VDD VDD _1261_ sky130_fd_sc_hd__nor2_1
X_5316_ _3565_ _1261_ VSS VSS VDD VDD _3333_ sky130_fd_sc_hd__xnor2_1
X_5317_ net8 _1256_ VSS VSS VDD VDD _1262_ sky130_fd_sc_hd__nor2_1
X_5318_ _3549_ _1262_ VSS VSS VDD VDD _3339_ sky130_fd_sc_hd__xnor2_1
X_5319_ net20 _1250_ VSS VSS VDD VDD _1263_ sky130_fd_sc_hd__nand2_1
X_5320_ _3533_ _1263_ VSS VSS VDD VDD _3342_ sky130_fd_sc_hd__xor2_1
X_5321_ _3380_ _1255_ VSS VSS VDD VDD _1264_ sky130_fd_sc_hd__nand2_1
X_5322_ _3465_ _1264_ VSS VSS VDD VDD _3347_ sky130_fd_sc_hd__xor2_1
X_5323_ _3356_ _3405_ VSS VSS VDD VDD _1265_ sky130_fd_sc_hd__nor2_1
X_5324_ _3424_ _1265_ VSS VSS VDD VDD _3351_ sky130_fd_sc_hd__xnor2_1
X_5325_ _3262_ VSS VSS VDD VDD _3355_ sky130_fd_sc_hd__inv_1
X_5326_ _3357_ _3262_ _3405_ VSS VSS VDD VDD _2171_ sky130_fd_sc_hd__mux2i_4
X_5327_ _3367_ VSS VSS VDD VDD _1266_ sky130_fd_sc_hd__inv_1
X_5328_ _2172_ _3353_ _3352_ VSS VSS VDD VDD _1267_ sky130_fd_sc_hd__a21o_1
X_5329_ _3349_ _1267_ _3348_ VSS VSS VDD VDD _1268_ sky130_fd_sc_hd__a21oi_2
X_5330_ _1268_ _3345_ VSS VSS VDD VDD _1269_ sky130_fd_sc_hd__nor2b_1
X_5331_ _3344_ _1269_ _3341_ VSS VSS VDD VDD _1270_ sky130_fd_sc_hd__o21ai_0
X_5332_ _3340_ _1270_ VSS VSS VDD VDD _1271_ sky130_fd_sc_hd__nand2b_1
X_5333_ _3337_ _1271_ _3334_ VSS VSS VDD VDD _1272_ sky130_fd_sc_hd__a21o_1
X_5334_ _3379_ _1272_ _3378_ VSS VSS VDD VDD _1273_ sky130_fd_sc_hd__a21oi_4
X_5335_ _1273_ _3331_ VSS VSS VDD VDD _1274_ sky130_fd_sc_hd__nor2b_1
X_5336_ _3330_ _1274_ _3375_ VSS VSS VDD VDD _1275_ sky130_fd_sc_hd__o21a_1
X_5337_ _3374_ _1275_ _3327_ VSS VSS VDD VDD _1276_ sky130_fd_sc_hd__o21ai_0
X_5338_ _3326_ _1276_ VSS VSS VDD VDD _1277_ sky130_fd_sc_hd__nand2b_1
X_5339_ _3371_ _1277_ _3370_ VSS VSS VDD VDD _1278_ sky130_fd_sc_hd__a21oi_2
X_5340_ _1266_ _1278_ _3366_ VSS VSS VDD VDD _1279_ sky130_fd_sc_hd__o21bai_1
X_5341_ _3363_ _1279_ _3362_ VSS VSS VDD VDD _1280_ sky130_fd_sc_hd__a21oi_2
X_5342_ _3323_ _1280_ VSS VSS VDD VDD _3665_ sky130_fd_sc_hd__xnor2_2
X_5343_ _2174_ VSS VSS VDD VDD _2170_ sky130_fd_sc_hd__inv_1
X_5344_ _3359_ _2170_ _3358_ VSS VSS VDD VDD _1281_ sky130_fd_sc_hd__a21o_1
X_5345_ _1281_ _3353_ _3352_ VSS VSS VDD VDD _1282_ sky130_fd_sc_hd__a21o_1
X_5346_ _3349_ _1282_ _3348_ VSS VSS VDD VDD _1283_ sky130_fd_sc_hd__a21o_1
X_5347_ _1283_ _3345_ _3344_ VSS VSS VDD VDD _1284_ sky130_fd_sc_hd__a21o_1
X_5348_ _3335_ _3340_ _3334_ VSS VSS VDD VDD _1285_ sky130_fd_sc_hd__a21o_1
X_5349_ _3341_ _1284_ _3337_ _1285_ VSS VSS VDD VDD _1286_
+ sky130_fd_sc_hd__a31oi_4
X_5350_ _1286_ _3379_ VSS VSS VDD VDD _1287_ sky130_fd_sc_hd__nor2b_1
X_5351_ _1287_ _3378_ _3331_ VSS VSS VDD VDD _1288_ sky130_fd_sc_hd__o21ai_1
X_5352_ _3330_ _1288_ VSS VSS VDD VDD _1289_ sky130_fd_sc_hd__nand2b_2
X_5353_ _1289_ _3375_ _3374_ VSS VSS VDD VDD _1290_ sky130_fd_sc_hd__a21o_1
X_5354_ _1290_ _3327_ _3326_ VSS VSS VDD VDD _1291_ sky130_fd_sc_hd__a21o_1
X_5355_ _1291_ _3371_ _3370_ VSS VSS VDD VDD _1292_ sky130_fd_sc_hd__a21oi_2
X_5356_ _1266_ _1292_ _3366_ VSS VSS VDD VDD _1293_ sky130_fd_sc_hd__o21bai_2
X_5357_ _3363_ net160 VSS VSS VDD VDD _3657_ sky130_fd_sc_hd__xor2_2
X_5358_ _3367_ _1278_ VSS VSS VDD VDD _3649_ sky130_fd_sc_hd__xnor2_2
X_5359_ _3371_ net140 VSS VSS VDD VDD _3641_ sky130_fd_sc_hd__xor2_2
X_5360_ _3374_ _1275_ VSS VSS VDD VDD _1294_ sky130_fd_sc_hd__nor2_1
X_5361_ _3327_ _1294_ VSS VSS VDD VDD _3633_ sky130_fd_sc_hd__xnor2_2
X_5362_ _3331_ net264 VSS VSS VDD VDD _3620_ sky130_fd_sc_hd__xnor2_4
X_5363_ _3389_ VSS VSS VDD VDD _1295_ sky130_fd_sc_hd__inv_1
X_5364_ _3400_ VSS VSS VDD VDD _1296_ sky130_fd_sc_hd__inv_1
X_5365_ _3407_ VSS VSS VDD VDD _1297_ sky130_fd_sc_hd__inv_1
X_5366_ _3413_ VSS VSS VDD VDD _1298_ sky130_fd_sc_hd__inv_1
X_5367_ _3423_ _2122_ _3422_ VSS VSS VDD VDD _1299_ sky130_fd_sc_hd__a21o_1
X_5368_ _1299_ _3420_ _3419_ VSS VSS VDD VDD _1300_ sky130_fd_sc_hd__a21o_1
X_5369_ _1300_ _3417_ _3416_ VSS VSS VDD VDD _1301_ sky130_fd_sc_hd__a21o_1
X_5370_ _3414_ _1301_ VSS VSS VDD VDD _1302_ sky130_fd_sc_hd__nand2_1
X_5371_ _1302_ _1298_ _3411_ VSS VSS VDD VDD _1303_ sky130_fd_sc_hd__a21boi_2
X_5372_ _3410_ _1303_ _3408_ VSS VSS VDD VDD _1304_ sky130_fd_sc_hd__o21ai_1
X_5373_ _1304_ _1297_ VSS VSS VDD VDD _1305_ sky130_fd_sc_hd__nand2_1
X_5374_ _1305_ _3404_ VSS VSS VDD VDD _1306_ sky130_fd_sc_hd__and2_4
X_5375_ _3403_ _1306_ _3401_ VSS VSS VDD VDD _1307_ sky130_fd_sc_hd__o21ai_2
X_5376_ _1296_ _1307_ VSS VSS VDD VDD _1308_ sky130_fd_sc_hd__nand2_1
X_5377_ _1308_ _3398_ _3397_ VSS VSS VDD VDD _1309_ sky130_fd_sc_hd__a21o_1
X_5378_ _1309_ _3395_ _3394_ VSS VSS VDD VDD _1310_ sky130_fd_sc_hd__a21o_1
X_5379_ _1310_ _3392_ _3391_ VSS VSS VDD VDD _1311_ sky130_fd_sc_hd__a21oi_2
X_5380_ _3388_ VSS VSS VDD VDD _1312_ sky130_fd_sc_hd__inv_1
X_5381_ _1295_ _1311_ _1312_ VSS VSS VDD VDD _1313_ sky130_fd_sc_hd__o21ai_2
X_5382_ _1313_ _3386_ _3385_ VSS VSS VDD VDD _1314_ sky130_fd_sc_hd__a21o_1
X_5383_ _1314_ _3383_ VSS VSS VDD VDD _1315_ sky130_fd_sc_hd__nand2_2
X_5384_ _3382_ _1315_ VSS VSS VDD VDD _1316_ sky130_fd_sc_hd__nand2b_4
Xclone2 _0159_ VSS VSS VDD VDD net2 sky130_fd_sc_hd__buf_2
X_5386_ _1316_ VSS VSS VDD VDD _1318_ sky130_fd_sc_hd__inv_8
X_5387_ _1318_ VSS VSS VDD VDD _1319_ sky130_fd_sc_hd__buf_6
X_5388_ _1319_ VSS VSS VDD VDD _3517_ sky130_fd_sc_hd__buf_6
X_5389_ net7 _1245_ _1246_ VSS VSS VDD VDD _1320_ sky130_fd_sc_hd__or3_2
X_5390_ _1245_ _1246_ _1259_ VSS VSS VDD VDD _1321_ sky130_fd_sc_hd__o21ai_2
X_5391_ _1165_ _3200_ _3199_ VSS VSS VDD VDD _1322_ sky130_fd_sc_hd__a21o_1
X_5392_ _1322_ _3158_ _3157_ VSS VSS VDD VDD _1323_ sky130_fd_sc_hd__a21oi_2
X_5393_ _2982_ _1230_ _1323_ VSS VSS VDD VDD _1324_ sky130_fd_sc_hd__xnor3_4
X_5394_ _1293_ _3363_ _3362_ VSS VSS VDD VDD _1325_ sky130_fd_sc_hd__a21o_1
X_5395_ _1325_ _3323_ _3322_ VSS VSS VDD VDD _1326_ sky130_fd_sc_hd__a21oi_2
X_5396_ _3198_ _1326_ _1324_ VSS VSS VDD VDD _1327_ sky130_fd_sc_hd__xor3_2
X_5397_ _1320_ _1321_ net177 VSS VSS VDD VDD _1328_ sky130_fd_sc_hd__a21oi_4
X_5398_ _1327_ _1321_ _1320_ VSS VSS VDD VDD _1329_ sky130_fd_sc_hd__and3_4
X_5399_ _1328_ _1329_ VSS VSS VDD VDD _1330_ sky130_fd_sc_hd__or2_4
X_5400_ _1330_ VSS VSS VDD VDD _3441_ sky130_fd_sc_hd__inv_4
X_5401_ _3272_ VSS VSS VDD VDD _1331_ sky130_fd_sc_hd__inv_1
X_5402_ _2166_ _3290_ _3289_ VSS VSS VDD VDD _1332_ sky130_fd_sc_hd__a21o_1
X_5403_ _3284_ _1332_ _3283_ VSS VSS VDD VDD _1333_ sky130_fd_sc_hd__a21oi_2
X_5404_ _1333_ _1198_ _3279_ VSS VSS VDD VDD _1334_ sky130_fd_sc_hd__o21bai_1
X_5405_ _3276_ _1334_ _3275_ VSS VSS VDD VDD _1335_ sky130_fd_sc_hd__a21oi_2
X_5406_ _1331_ _1335_ _3271_ VSS VSS VDD VDD _1336_ sky130_fd_sc_hd__o21bai_1
X_5407_ _3268_ _1336_ _3267_ VSS VSS VDD VDD _1337_ sky130_fd_sc_hd__a21oi_2
X_5408_ _3432_ _3429_ VSS VSS VDD VDD _1338_ sky130_fd_sc_hd__nand2_1
X_5409_ _3264_ _3431_ _3263_ VSS VSS VDD VDD _1339_ sky130_fd_sc_hd__a21oi_2
X_5410_ _1337_ _1338_ _1339_ VSS VSS VDD VDD _1340_ sky130_fd_sc_hd__o21ai_2
X_5411_ _3427_ net156 VSS VSS VDD VDD _3433_ sky130_fd_sc_hd__xor2_4
X_5412_ _3433_ VSS VSS VDD VDD _3459_ sky130_fd_sc_hd__inv_1
X_5413_ _3476_ VSS VSS VDD VDD _1341_ sky130_fd_sc_hd__inv_1
X_5414_ _3484_ VSS VSS VDD VDD _1342_ sky130_fd_sc_hd__inv_1
X_5415_ _3451_ VSS VSS VDD VDD _1343_ sky130_fd_sc_hd__inv_1
X_5416_ _2187_ _3457_ _3456_ VSS VSS VDD VDD _1344_ sky130_fd_sc_hd__a21o_1
X_5417_ _1344_ _3455_ _3454_ VSS VSS VDD VDD _1345_ sky130_fd_sc_hd__a21oi_2
X_5418_ _1343_ _1345_ _3450_ VSS VSS VDD VDD _1346_ sky130_fd_sc_hd__o21bai_1
X_5419_ _1346_ _3447_ _3446_ VSS VSS VDD VDD _1347_ sky130_fd_sc_hd__a21oi_2
X_5420_ _1342_ _1347_ _3483_ VSS VSS VDD VDD _1348_ sky130_fd_sc_hd__o21bai_1
X_5421_ _1348_ _3480_ _3479_ VSS VSS VDD VDD _1349_ sky130_fd_sc_hd__a21oi_2
X_5422_ _1341_ _1349_ _3475_ VSS VSS VDD VDD _1350_ sky130_fd_sc_hd__o21bai_2
X_5423_ _3439_ _1350_ _3438_ VSS VSS VDD VDD _1351_ sky130_fd_sc_hd__a21oi_4
X_5424_ _3436_ net117 VSS VSS VDD VDD _3724_ sky130_fd_sc_hd__xnor2_4
X_5425_ _3724_ VSS VSS VDD VDD _3486_ sky130_fd_sc_hd__inv_1
X_5426_ _1316_ VSS VSS VDD VDD _3489_ sky130_fd_sc_hd__buf_8
X_5427_ _3462_ _3489_ VSS VSS VDD VDD _1352_ sky130_fd_sc_hd__nand2_1
X_5428_ _3517_ _3433_ _1352_ VSS VSS VDD VDD _2180_ sky130_fd_sc_hd__a21boi_2
X_5429_ _2180_ VSS VSS VDD VDD _2177_ sky130_fd_sc_hd__inv_1
X_5430_ _1205_ _3429_ VSS VSS VDD VDD _1353_ sky130_fd_sc_hd__nor2b_1
X_5431_ _3263_ _1353_ _3427_ VSS VSS VDD VDD _1354_ sky130_fd_sc_hd__o21a_1
X_5432_ _3426_ _1354_ VSS VSS VDD VDD _1355_ sky130_fd_sc_hd__nor2_1
X_5433_ _3468_ _1355_ VSS VSS VDD VDD _3469_ sky130_fd_sc_hd__xnor2_2
X_5434_ _3375_ net130 VSS VSS VDD VDD _1356_ sky130_fd_sc_hd__xor2_4
X_5435_ _3633_ _3620_ _1356_ VSS VSS VDD VDD _1357_ sky130_fd_sc_hd__nor3_1
X_5436_ _3641_ _1357_ VSS VSS VDD VDD _1358_ sky130_fd_sc_hd__nor2b_1
X_5437_ _3649_ _1358_ VSS VSS VDD VDD _1359_ sky130_fd_sc_hd__nor2b_2
X_5438_ _3657_ _1359_ VSS VSS VDD VDD _1360_ sky130_fd_sc_hd__nor2b_4
X_5439_ _3665_ _1360_ VSS VSS VDD VDD _3440_ sky130_fd_sc_hd__nand2b_4
X_5440_ _1316_ _3440_ VSS VSS VDD VDD _1361_ sky130_fd_sc_hd__nand2_1
X_5441_ _3480_ VSS VSS VDD VDD _1362_ sky130_fd_sc_hd__inv_1
X_5442_ _3447_ VSS VSS VDD VDD _1363_ sky130_fd_sc_hd__inv_1
X_5443_ _2189_ _3455_ _3454_ VSS VSS VDD VDD _1364_ sky130_fd_sc_hd__a21o_1
X_5444_ _3451_ _1364_ _3450_ VSS VSS VDD VDD _1365_ sky130_fd_sc_hd__a21oi_2
X_5445_ _1363_ _1365_ _3446_ VSS VSS VDD VDD _1366_ sky130_fd_sc_hd__o21bai_1
X_5446_ _3484_ _1366_ _3483_ VSS VSS VDD VDD _1367_ sky130_fd_sc_hd__a21oi_2
X_5447_ _1362_ _1367_ _3479_ VSS VSS VDD VDD _1368_ sky130_fd_sc_hd__o21bai_2
X_5448_ _1368_ net115 _3475_ VSS VSS VDD VDD _1369_ sky130_fd_sc_hd__a21oi_4
X_5449_ _1369_ _3439_ VSS VSS VDD VDD _1370_ sky130_fd_sc_hd__nand2b_4
X_5450_ _3459_ _1370_ VSS VSS VDD VDD _1371_ sky130_fd_sc_hd__nor2_4
X_5451_ _1361_ _1371_ VSS VSS VDD VDD _1372_ sky130_fd_sc_hd__nand2_1
X_5452_ _1316_ _3440_ VSS VSS VDD VDD _1373_ sky130_fd_sc_hd__and2_0
X_5453_ net179 _1370_ VSS VSS VDD VDD _1374_ sky130_fd_sc_hd__nor2_4
X_5454_ _1373_ _1374_ VSS VSS VDD VDD _1375_ sky130_fd_sc_hd__nand2_1
X_5455_ _1372_ _1375_ net124 net148 VSS VSS VDD VDD _1376_
+ sky130_fd_sc_hd__a211o_1
X_5456_ _1318_ _1374_ VSS VSS VDD VDD _1377_ sky130_fd_sc_hd__nand2_1
X_5457_ net22 _1371_ VSS VSS VDD VDD _1378_ sky130_fd_sc_hd__nand2_1
X_5458_ net125 net135 _1377_ _1378_ VSS VSS VDD VDD _1379_
+ sky130_fd_sc_hd__a2bb2o_4
X_5459_ _3436_ _3438_ _3435_ VSS VSS VDD VDD _1380_ sky130_fd_sc_hd__a21oi_1
X_5460_ _1376_ _1379_ _1380_ VSS VSS VDD VDD _1381_ sky130_fd_sc_hd__nand3_2
X_5461_ _3472_ _1381_ VSS VSS VDD VDD _3728_ sky130_fd_sc_hd__xor2_2
X_5462_ _3417_ _1300_ VSS VSS VDD VDD _1382_ sky130_fd_sc_hd__xor2_1
X_5463_ _3523_ _1382_ _3522_ VSS VSS VDD VDD _1383_ sky130_fd_sc_hd__a21o_1
X_5464_ _3520_ _1383_ _3519_ VSS VSS VDD VDD _1384_ sky130_fd_sc_hd__a21oi_1
X_5465_ _1384_ _3516_ VSS VSS VDD VDD _1385_ sky130_fd_sc_hd__nor2b_1
X_5466_ _3515_ _1385_ _3513_ VSS VSS VDD VDD _1386_ sky130_fd_sc_hd__o21ai_0
X_5467_ _3512_ _1386_ VSS VSS VDD VDD _1387_ sky130_fd_sc_hd__nand2b_1
X_5468_ _3510_ _1387_ _3509_ VSS VSS VDD VDD _1388_ sky130_fd_sc_hd__a21oi_1
X_5469_ _1388_ _3507_ VSS VSS VDD VDD _1389_ sky130_fd_sc_hd__nor2b_1
X_5470_ _3506_ _1389_ _3504_ VSS VSS VDD VDD _1390_ sky130_fd_sc_hd__o21ai_0
X_5471_ _3503_ _1390_ VSS VSS VDD VDD _1391_ sky130_fd_sc_hd__nand2b_1
X_5472_ _3501_ _1391_ _3500_ VSS VSS VDD VDD _1392_ sky130_fd_sc_hd__a21oi_1
X_5473_ _1392_ _3498_ VSS VSS VDD VDD _1393_ sky130_fd_sc_hd__nor2b_1
X_5474_ _3497_ _1393_ _3495_ VSS VSS VDD VDD _1394_ sky130_fd_sc_hd__o21ai_0
X_5475_ _3494_ _1394_ VSS VSS VDD VDD _1395_ sky130_fd_sc_hd__nand2b_1
X_5476_ _3492_ _1395_ _3491_ VSS VSS VDD VDD _1396_ sky130_fd_sc_hd__a21oi_2
X_5477_ _1396_ VSS VSS VDD VDD _1397_ sky130_fd_sc_hd__clkbuf_4
X_5478_ _3492_ _1395_ _3491_ VSS VSS VDD VDD _1398_ sky130_fd_sc_hd__a21o_2
X_5479_ _3488_ _1398_ VSS VSS VDD VDD _1399_ sky130_fd_sc_hd__nand2_1
X_5480_ net159 _1397_ _1399_ VSS VSS VDD VDD _2186_ sky130_fd_sc_hd__a21boi_2
X_5481_ _2186_ VSS VSS VDD VDD _2182_ sky130_fd_sc_hd__inv_1
X_5482_ _1340_ _3427_ _3426_ VSS VSS VDD VDD _1400_ sky130_fd_sc_hd__a21o_1
X_5483_ _1400_ _3468_ _3467_ VSS VSS VDD VDD _1401_ sky130_fd_sc_hd__a21oi_2
X_5484_ _3536_ net127 VSS VSS VDD VDD _3537_ sky130_fd_sc_hd__xnor2_2
X_5485_ _1351_ _3459_ VSS VSS VDD VDD _1402_ sky130_fd_sc_hd__nor2_4
X_5486_ _1402_ _1361_ VSS VSS VDD VDD _1403_ sky130_fd_sc_hd__nand2_1
X_5487_ net178 _1351_ VSS VSS VDD VDD _1404_ sky130_fd_sc_hd__nor2_4
X_5488_ _1373_ _1404_ VSS VSS VDD VDD _1405_ sky130_fd_sc_hd__nand2_2
X_5489_ _1403_ _1405_ net126 net135 VSS VSS VDD VDD _1406_
+ sky130_fd_sc_hd__a211oi_2
X_5490_ _1318_ _1404_ VSS VSS VDD VDD _1407_ sky130_fd_sc_hd__nand2_1
X_5491_ net22 _1402_ VSS VSS VDD VDD _1408_ sky130_fd_sc_hd__nand2_1
X_5492_ net125 net135 _1407_ _1408_ VSS VSS VDD VDD _1409_
+ sky130_fd_sc_hd__a2bb2oi_1
X_5493_ _3435_ _3540_ VSS VSS VDD VDD _1410_ sky130_fd_sc_hd__nand2b_1
X_5494_ _3471_ _1406_ _1409_ _1410_ VSS VSS VDD VDD _1411_
+ sky130_fd_sc_hd__or4_4
X_5495_ _3540_ _3472_ VSS VSS VDD VDD _1412_ sky130_fd_sc_hd__nor2b_1
X_5496_ _1409_ _1406_ _1412_ VSS VSS VDD VDD _1413_ sky130_fd_sc_hd__o21ai_1
X_5497_ _3540_ VSS VSS VDD VDD _1414_ sky130_fd_sc_hd__inv_1
X_5498_ _3472_ _1414_ _3471_ VSS VSS VDD VDD _1415_ sky130_fd_sc_hd__nor3_1
X_5499_ _1414_ _3471_ _1412_ _3435_ _1415_ VSS VSS VDD VDD
+ _1416_ sky130_fd_sc_hd__a221oi_2
X_5500_ _1413_ _1411_ _1416_ VSS VSS VDD VDD _3732_ sky130_fd_sc_hd__nand3_2
X_5501_ _3426_ _1354_ _3468_ VSS VSS VDD VDD _1417_ sky130_fd_sc_hd__o21ai_0
X_5502_ _3467_ _1417_ VSS VSS VDD VDD _1418_ sky130_fd_sc_hd__nand2b_1
X_5503_ _3536_ _1418_ _3535_ VSS VSS VDD VDD _1419_ sky130_fd_sc_hd__a21oi_2
X_5504_ _3552_ _1419_ VSS VSS VDD VDD _3554_ sky130_fd_sc_hd__xnor2_2
X_5505_ _3471_ _3539_ _1380_ VSS VSS VDD VDD _1420_ sky130_fd_sc_hd__nor3b_1
X_5506_ net175 _1379_ _1420_ VSS VSS VDD VDD _1421_ sky130_fd_sc_hd__nand3_1
X_5507_ _3472_ _3471_ VSS VSS VDD VDD _1422_ sky130_fd_sc_hd__nor2_1
X_5508_ _1414_ _1422_ _3539_ VSS VSS VDD VDD _1423_ sky130_fd_sc_hd__o21bai_1
X_5509_ _1421_ _1423_ VSS VSS VDD VDD _1424_ sky130_fd_sc_hd__nand2_2
X_5510_ _3556_ _1424_ VSS VSS VDD VDD _3736_ sky130_fd_sc_hd__xnor2_4
X_5511_ _1401_ _3536_ VSS VSS VDD VDD _1425_ sky130_fd_sc_hd__nor2b_1
X_5512_ _3535_ _1425_ _3552_ VSS VSS VDD VDD _1426_ sky130_fd_sc_hd__o21ai_1
X_5513_ _3551_ _1426_ VSS VSS VDD VDD _1427_ sky130_fd_sc_hd__nand2b_2
X_5514_ _3568_ net141 VSS VSS VDD VDD _3569_ sky130_fd_sc_hd__xor2_4
X_5515_ _3198_ _1324_ net136 VSS VSS VDD VDD _1428_ sky130_fd_sc_hd__xnor3_1
X_5516_ _1320_ _1321_ _1428_ VSS VSS VDD VDD _1429_ sky130_fd_sc_hd__a21o_1
X_5517_ _1320_ _1321_ _1428_ VSS VSS VDD VDD _1430_ sky130_fd_sc_hd__nand3_2
X_5518_ net211 _1429_ _1430_ VSS VSS VDD VDD _1431_ sky130_fd_sc_hd__nand3_4
X_5519_ net123 net148 _1361_ VSS VSS VDD VDD _1432_ sky130_fd_sc_hd__or3_1
X_5520_ _1432_ VSS VSS VDD VDD _1433_ sky130_fd_sc_hd__buf_4
X_5521_ _3472_ _3540_ _1402_ VSS VSS VDD VDD _1434_ sky130_fd_sc_hd__and3_1
X_5522_ _1431_ _1433_ _1434_ VSS VSS VDD VDD _1435_ sky130_fd_sc_hd__nand3_1
X_5523_ _3472_ _3540_ _1404_ VSS VSS VDD VDD _1436_ sky130_fd_sc_hd__nand3_1
X_5524_ _1431_ _1433_ _1436_ VSS VSS VDD VDD _1437_ sky130_fd_sc_hd__a21o_1
X_5525_ _3472_ _3435_ _3471_ VSS VSS VDD VDD _1438_ sky130_fd_sc_hd__a21o_1
X_5526_ _3540_ _1438_ _3539_ VSS VSS VDD VDD _1439_ sky130_fd_sc_hd__a21oi_1
X_5527_ _3556_ VSS VSS VDD VDD _1440_ sky130_fd_sc_hd__inv_1
X_5528_ _1435_ _1437_ _1439_ _1440_ VSS VSS VDD VDD _1441_
+ sky130_fd_sc_hd__a31oi_1
X_5529_ _3572_ _3555_ VSS VSS VDD VDD _1442_ sky130_fd_sc_hd__or2_0
X_5530_ _3540_ _1438_ _3539_ VSS VSS VDD VDD _1443_ sky130_fd_sc_hd__a21o_1
X_5531_ _3555_ _1443_ VSS VSS VDD VDD _1444_ sky130_fd_sc_hd__nor2_1
X_5532_ _3556_ _3555_ VSS VSS VDD VDD _1445_ sky130_fd_sc_hd__or2_0
X_5533_ _3572_ _1445_ VSS VSS VDD VDD _1446_ sky130_fd_sc_hd__nand2_1
X_5534_ _1435_ _1437_ _1444_ _1446_ VSS VSS VDD VDD _1447_
+ sky130_fd_sc_hd__a31oi_2
X_5535_ _1441_ _1442_ _1447_ VSS VSS VDD VDD _3740_ sky130_fd_sc_hd__o21ba_1
X_5536_ _3552_ VSS VSS VDD VDD _1448_ sky130_fd_sc_hd__inv_1
X_5537_ _1448_ _1419_ _3551_ VSS VSS VDD VDD _1449_ sky130_fd_sc_hd__o21bai_1
X_5538_ _3568_ _1449_ _3567_ VSS VSS VDD VDD _1450_ sky130_fd_sc_hd__a21oi_2
X_5539_ _3584_ _1450_ VSS VSS VDD VDD _3585_ sky130_fd_sc_hd__xnor2_4
X_5540_ _3556_ _3572_ VSS VSS VDD VDD _1451_ sky130_fd_sc_hd__nand2_1
X_5541_ _3588_ VSS VSS VDD VDD _1452_ sky130_fd_sc_hd__inv_1
X_5542_ _1423_ _1421_ _1452_ _3555_ _3571_ VSS VSS VDD VDD
+ _1453_ sky130_fd_sc_hd__a2111o_1
X_5543_ _3556_ _1452_ _3555_ _3571_ VSS VSS VDD VDD _1454_
+ sky130_fd_sc_hd__or4_1
X_5544_ _3588_ _3571_ VSS VSS VDD VDD _1455_ sky130_fd_sc_hd__nor2b_1
X_5545_ _3572_ _1452_ _3555_ _1455_ VSS VSS VDD VDD _1456_
+ sky130_fd_sc_hd__a31oi_1
X_5546_ _3572_ _1452_ _3571_ _1454_ _1456_ VSS VSS VDD VDD
+ _1457_ sky130_fd_sc_hd__o311a_1
X_5547_ _3588_ _1424_ _1451_ _1453_ _1457_ VSS VSS VDD VDD
+ _3743_ sky130_fd_sc_hd__o311ai_4
X_5548_ _3372_ _3328_ _3376_ VSS VSS VDD VDD _1458_ sky130_fd_sc_hd__nor3_1
X_5549_ _3324_ _1458_ VSS VSS VDD VDD _1459_ sky130_fd_sc_hd__nand2b_1
X_5550_ _3365_ _3368_ VSS VSS VDD VDD _1460_ sky130_fd_sc_hd__or2_0
X_5551_ _3361_ _1459_ _1460_ VSS VSS VDD VDD _1461_ sky130_fd_sc_hd__or3_1
X_5552_ net139 _1128_ _1324_ VSS VSS VDD VDD _1462_ sky130_fd_sc_hd__or3_4
X_5553_ net139 _1128_ _1324_ VSS VSS VDD VDD _1463_ sky130_fd_sc_hd__o21ai_2
X_5554_ _3321_ _1461_ _1462_ _1463_ _1185_ VSS VSS VDD VDD
+ _1464_ sky130_fd_sc_hd__o2111ai_4
X_5555_ _1463_ _1462_ _1185_ VSS VSS VDD VDD _1465_ sky130_fd_sc_hd__a21o_2
X_5556_ _1233_ _1240_ VSS VSS VDD VDD _3311_ sky130_fd_sc_hd__or2_2
X_5557_ _3568_ _1427_ _3567_ VSS VSS VDD VDD _1466_ sky130_fd_sc_hd__a21o_1
X_5558_ _3584_ _1466_ _3583_ VSS VSS VDD VDD _1467_ sky130_fd_sc_hd__a21oi_2
X_5559_ _3311_ _1467_ _1244_ VSS VSS VDD VDD _1468_ sky130_fd_sc_hd__xor3_2
X_5560_ _1464_ _1465_ _1468_ VSS VSS VDD VDD _1469_ sky130_fd_sc_hd__a21oi_4
X_5561_ _1464_ _1465_ _1468_ VSS VSS VDD VDD _1470_ sky130_fd_sc_hd__and3_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5563_ _1469_ _1470_ VSS VSS VDD VDD _1472_ sky130_fd_sc_hd__nor2_8
X_5564_ _1472_ VSS VSS VDD VDD _3606_ sky130_fd_sc_hd__clkinv_4
X_5565_ _3469_ _3537_ _3461_ VSS VSS VDD VDD _1473_ sky130_fd_sc_hd__nor3b_1
X_5566_ _3554_ _3569_ _1473_ VSS VSS VDD VDD _1474_ sky130_fd_sc_hd__nor3b_1
X_5567_ net21 _1474_ VSS VSS VDD VDD _1475_ sky130_fd_sc_hd__nor2_1
X_5568_ _3585_ _1475_ _3489_ VSS VSS VDD VDD _1476_ sky130_fd_sc_hd__o21ai_0
X_5569_ net188 _1476_ VSS VSS VDD VDD _1477_ sky130_fd_sc_hd__nor2_4
X_5570_ net27 _1472_ _1477_ VSS VSS VDD VDD _3621_ sky130_fd_sc_hd__a21oi_1
X_5571_ _3442_ _3489_ VSS VSS VDD VDD _1478_ sky130_fd_sc_hd__and2_0
X_5572_ net21 _1429_ _1430_ _1478_ VSS VSS VDD VDD _1479_
+ sky130_fd_sc_hd__a31oi_4
X_5573_ net29 _1479_ VSS VSS VDD VDD _1480_ sky130_fd_sc_hd__xnor2_4
X_5574_ _3555_ _3571_ _1443_ VSS VSS VDD VDD _1481_ sky130_fd_sc_hd__nor3_1
X_5575_ _1435_ _1437_ _1481_ VSS VSS VDD VDD _1482_ sky130_fd_sc_hd__nand3_1
X_5576_ _3572_ _1445_ _3571_ VSS VSS VDD VDD _1483_ sky130_fd_sc_hd__a21oi_1
X_5577_ _1483_ VSS VSS VDD VDD _1484_ sky130_fd_sc_hd__inv_1
X_5578_ _3588_ _1480_ _1482_ _1484_ VSS VSS VDD VDD _1485_
+ sky130_fd_sc_hd__nand4_2
X_5579_ _3571_ _3587_ _1447_ _1480_ VSS VSS VDD VDD _1486_
+ sky130_fd_sc_hd__or4_2
X_5580_ _3588_ _3587_ _1480_ VSS VSS VDD VDD _1487_ sky130_fd_sc_hd__nor3_1
X_5581_ _3587_ _1480_ _1487_ VSS VSS VDD VDD _1488_ sky130_fd_sc_hd__a21oi_2
X_5582_ _1485_ _1486_ _1488_ VSS VSS VDD VDD _3598_ sky130_fd_sc_hd__nand3_1
X_5583_ _3292_ _3433_ _3469_ VSS VSS VDD VDD _1489_ sky130_fd_sc_hd__or3_1
X_5584_ _3537_ _3554_ _1489_ VSS VSS VDD VDD _1490_ sky130_fd_sc_hd__or3_4
X_5585_ _3569_ _1490_ _3585_ VSS VSS VDD VDD _1491_ sky130_fd_sc_hd__nor3_4
X_5586_ net21 net195 VSS VSS VDD VDD _1492_ sky130_fd_sc_hd__nor2_1
X_5587_ net21 _1492_ net192 VSS VSS VDD VDD _3640_ sky130_fd_sc_hd__mux2i_4
X_5588_ _2176_ _3464_ VSS VSS VDD VDD _1493_ sky130_fd_sc_hd__nor2b_1
X_5589_ _3463_ _1493_ _3532_ VSS VSS VDD VDD _1494_ sky130_fd_sc_hd__o21ai_1
X_5590_ _3531_ _1494_ VSS VSS VDD VDD _1495_ sky130_fd_sc_hd__nand2b_1
X_5591_ _1495_ _3548_ _3547_ VSS VSS VDD VDD _1496_ sky130_fd_sc_hd__a21o_1
X_5592_ _1496_ _3564_ _3563_ VSS VSS VDD VDD _1497_ sky130_fd_sc_hd__a21o_1
X_5593_ _1497_ _3580_ _3579_ VSS VSS VDD VDD _1498_ sky130_fd_sc_hd__a21o_1
X_5594_ _1498_ _3596_ _3595_ VSS VSS VDD VDD _1499_ sky130_fd_sc_hd__a21o_1
X_5595_ _3612_ _1499_ _3611_ VSS VSS VDD VDD _1500_ sky130_fd_sc_hd__a21o_1
X_5596_ _1500_ _3623_ _3622_ VSS VSS VDD VDD _1501_ sky130_fd_sc_hd__a21o_1
X_5597_ net145 _1356_ VSS VSS VDD VDD _1502_ sky130_fd_sc_hd__xnor2_4
X_5598_ _3640_ _1502_ VSS VSS VDD VDD _3629_ sky130_fd_sc_hd__xnor2_4
X_5599_ _3629_ VSS VSS VDD VDD _3673_ sky130_fd_sc_hd__inv_1
X_5600_ _3724_ _3732_ net157 VSS VSS VDD VDD _1503_ sky130_fd_sc_hd__or3_4
X_5601_ _3736_ _3740_ _1503_ _3743_ VSS VSS VDD VDD _1504_
+ sky130_fd_sc_hd__or4_4
X_5602_ _1485_ _1486_ _1488_ _1397_ VSS VSS VDD VDD _1505_
+ sky130_fd_sc_hd__a31oi_4
X_5603_ _1396_ _1485_ _1486_ _1488_ VSS VSS VDD VDD _1506_
+ sky130_fd_sc_hd__and4_1
X_5604_ _1506_ VSS VSS VDD VDD _1507_ sky130_fd_sc_hd__clkbuf_2
X_5605_ net180 _1505_ _1507_ VSS VSS VDD VDD _3628_ sky130_fd_sc_hd__a21oi_1
X_5606_ net27 _1472_ _1477_ VSS VSS VDD VDD _3632_ sky130_fd_sc_hd__a21oi_1
X_5607_ _2178_ _3532_ VSS VSS VDD VDD _1508_ sky130_fd_sc_hd__nor2b_1
X_5608_ _1508_ _3531_ _3548_ VSS VSS VDD VDD _1509_ sky130_fd_sc_hd__o21ai_1
X_5609_ _3547_ _1509_ VSS VSS VDD VDD _1510_ sky130_fd_sc_hd__nand2b_1
X_5610_ _1510_ _3564_ _3563_ VSS VSS VDD VDD _1511_ sky130_fd_sc_hd__a21o_1
X_5611_ _1511_ _3580_ _3579_ VSS VSS VDD VDD _1512_ sky130_fd_sc_hd__a21o_1
X_5612_ _1512_ _3596_ _3595_ VSS VSS VDD VDD _1513_ sky130_fd_sc_hd__a21o_1
X_5613_ _3612_ _1513_ _3611_ VSS VSS VDD VDD _1514_ sky130_fd_sc_hd__a21o_1
X_5614_ _1514_ _3623_ _3622_ VSS VSS VDD VDD _1515_ sky130_fd_sc_hd__a21o_1
X_5615_ _1316_ _1515_ VSS VSS VDD VDD _1516_ sky130_fd_sc_hd__or2_1
X_5616_ net149 net195 _1515_ VSS VSS VDD VDD _1517_ sky130_fd_sc_hd__nor3_4
X_5617_ net203 net199 _1517_ VSS VSS VDD VDD _1518_ sky130_fd_sc_hd__o21ai_2
X_5618_ _1356_ _1515_ VSS VSS VDD VDD _1519_ sky130_fd_sc_hd__or2_0
X_5619_ net193 _1516_ _1518_ _1519_ VSS VSS VDD VDD _1520_
+ sky130_fd_sc_hd__o211a_1
X_5620_ net212 _1356_ _1491_ VSS VSS VDD VDD _1521_ sky130_fd_sc_hd__nor3_1
X_5621_ net22 _1356_ VSS VSS VDD VDD _1522_ sky130_fd_sc_hd__nor2_1
X_5622_ _1521_ _1522_ net29 VSS VSS VDD VDD _1523_ sky130_fd_sc_hd__mux2i_1
X_5623_ _3635_ VSS VSS VDD VDD _1524_ sky130_fd_sc_hd__inv_1
X_5624_ _1523_ _1520_ _1524_ VSS VSS VDD VDD _1525_ sky130_fd_sc_hd__a21oi_2
X_5625_ net272 _1524_ _1523_ VSS VSS VDD VDD _1526_ sky130_fd_sc_hd__nand3_2
X_5626_ _1525_ _1526_ VSS VSS VDD VDD _3636_ sky130_fd_sc_hd__nand2b_4
X_5627_ _3487_ _1411_ net122 _1416_ VSS VSS VDD VDD _1527_
+ sky130_fd_sc_hd__nand4_2
X_5628_ _3736_ _1527_ _3743_ _3740_ VSS VSS VDD VDD _3597_
+ sky130_fd_sc_hd__or4_4
X_5629_ _1505_ _3597_ _1507_ VSS VSS VDD VDD _3637_ sky130_fd_sc_hd__a21oi_1
X_5630_ _1491_ VSS VSS VDD VDD _3605_ sky130_fd_sc_hd__inv_1
X_5631_ _1356_ _1501_ VSS VSS VDD VDD _1528_ sky130_fd_sc_hd__nand2_2
X_5632_ net204 net205 _3605_ net22 _1528_ VSS VSS VDD VDD
+ _1529_ sky130_fd_sc_hd__o2111a_2
X_5633_ net147 net206 VSS VSS VDD VDD _1530_ sky130_fd_sc_hd__nand2_2
X_5634_ net189 _1530_ net121 VSS VSS VDD VDD _1531_ sky130_fd_sc_hd__nor3_4
X_5635_ net145 _1356_ _3635_ VSS VSS VDD VDD _1532_ sky130_fd_sc_hd__o21ai_2
X_5636_ _3634_ VSS VSS VDD VDD _1533_ sky130_fd_sc_hd__inv_1
X_5637_ _1529_ net143 net146 _1533_ VSS VSS VDD VDD _1534_
+ sky130_fd_sc_hd__o31ai_4
X_5638_ _3643_ _1534_ VSS VSS VDD VDD _1535_ sky130_fd_sc_hd__xnor2_4
X_5639_ _1535_ VSS VSS VDD VDD _3645_ sky130_fd_sc_hd__inv_1
X_5640_ net181 _1505_ _1507_ VSS VSS VDD VDD _3644_ sky130_fd_sc_hd__a21oi_1
X_5641_ net27 net29 _1477_ VSS VSS VDD VDD _3648_ sky130_fd_sc_hd__a21oi_1
X_5642_ net193 net237 _1519_ _1518_ VSS VSS VDD VDD _1536_
+ sky130_fd_sc_hd__o211ai_2
X_5643_ _1521_ _1522_ net29 VSS VSS VDD VDD _1537_ sky130_fd_sc_hd__mux2_1
X_5644_ _3635_ _3643_ VSS VSS VDD VDD _1538_ sky130_fd_sc_hd__nand2_1
X_5645_ _3643_ _3634_ _3642_ VSS VSS VDD VDD _1539_ sky130_fd_sc_hd__a21oi_1
X_5646_ _1538_ _1537_ _1536_ _1539_ VSS VSS VDD VDD _1540_
+ sky130_fd_sc_hd__o31a_4
X_5647_ _3651_ _1540_ VSS VSS VDD VDD _3653_ sky130_fd_sc_hd__xnor2_4
X_5648_ _1505_ _3597_ _1507_ VSS VSS VDD VDD _3652_ sky130_fd_sc_hd__a21oi_1
X_5649_ net27 _1492_ _3606_ VSS VSS VDD VDD _3656_ sky130_fd_sc_hd__mux2i_1
X_5650_ net223 _1531_ _1532_ VSS VSS VDD VDD _1541_ sky130_fd_sc_hd__nor3_2
X_5651_ _3643_ _3642_ _3650_ VSS VSS VDD VDD _1542_ sky130_fd_sc_hd__nor3_1
X_5652_ _3651_ _3650_ VSS VSS VDD VDD _1543_ sky130_fd_sc_hd__nor2_1
X_5653_ _1542_ _1543_ VSS VSS VDD VDD _1544_ sky130_fd_sc_hd__nor2_1
X_5654_ _3634_ _1541_ _3650_ _3642_ _1544_ VSS VSS VDD VDD
+ _1545_ sky130_fd_sc_hd__o41ai_4
X_5655_ _3659_ net110 VSS VSS VDD VDD _3661_ sky130_fd_sc_hd__xnor2_4
X_5656_ net180 _1505_ _1507_ VSS VSS VDD VDD _3660_ sky130_fd_sc_hd__a21oi_1
X_5657_ net27 net188 _1477_ VSS VSS VDD VDD _3664_ sky130_fd_sc_hd__a21oi_1
X_5658_ _3651_ _3659_ VSS VSS VDD VDD _1546_ sky130_fd_sc_hd__nand2_1
X_5659_ _3650_ _3658_ _3667_ VSS VSS VDD VDD _1547_ sky130_fd_sc_hd__nor3b_1
X_5660_ _1536_ _1537_ _1538_ _1539_ _1547_ VSS VSS VDD VDD
+ _1548_ sky130_fd_sc_hd__o311ai_4
X_5661_ _3651_ _3650_ _3658_ _3667_ VSS VSS VDD VDD _1549_
+ sky130_fd_sc_hd__nor4b_1
X_5662_ _3659_ _3658_ _3667_ VSS VSS VDD VDD _1550_ sky130_fd_sc_hd__nor3b_1
X_5663_ _3658_ VSS VSS VDD VDD _1551_ sky130_fd_sc_hd__inv_1
X_5664_ _3667_ _3650_ _3659_ VSS VSS VDD VDD _1552_ sky130_fd_sc_hd__nand3b_1
X_5665_ _3667_ _1551_ _1552_ VSS VSS VDD VDD _1553_ sky130_fd_sc_hd__o21ai_0
X_5666_ _1549_ _1550_ _1553_ VSS VSS VDD VDD _1554_ sky130_fd_sc_hd__nor3_1
X_5667_ _3667_ _1540_ _1546_ _1548_ _1554_ VSS VSS VDD VDD
+ _3669_ sky130_fd_sc_hd__o311ai_4
X_5668_ _1398_ VSS VSS VDD VDD _1555_ sky130_fd_sc_hd__buf_2
X_5669_ _3599_ _1555_ _1507_ VSS VSS VDD VDD _3668_ sky130_fd_sc_hd__a21oi_1
X_5670_ _1469_ _1470_ net21 VSS VSS VDD VDD _1556_ sky130_fd_sc_hd__o21ai_1
X_5671_ _3607_ _3489_ VSS VSS VDD VDD _1557_ sky130_fd_sc_hd__nand2b_1
X_5672_ _1330_ _1556_ _1557_ VSS VSS VDD VDD _1558_ sky130_fd_sc_hd__nand3_1
X_5673_ _1556_ _1557_ _1330_ VSS VSS VDD VDD _1559_ sky130_fd_sc_hd__a21o_1
X_5674_ _1558_ _1559_ VSS VSS VDD VDD _1560_ sky130_fd_sc_hd__nand2_1
X_5675_ _3659_ _3667_ VSS VSS VDD VDD _1561_ sky130_fd_sc_hd__nand2_1
X_5676_ _3667_ _3658_ VSS VSS VDD VDD _1562_ sky130_fd_sc_hd__and2_0
X_5677_ _3666_ _1562_ _1559_ _1558_ VSS VSS VDD VDD _1563_
+ sky130_fd_sc_hd__o211ai_1
X_5678_ _1561_ _1560_ net111 _1563_ VSS VSS VDD VDD _1564_
+ sky130_fd_sc_hd__o31a_1
X_5679_ _3658_ _3666_ VSS VSS VDD VDD _1565_ sky130_fd_sc_hd__nor2_1
X_5680_ _3659_ _3658_ VSS VSS VDD VDD _1566_ sky130_fd_sc_hd__or2_0
X_5681_ _1558_ _1559_ _1566_ _3667_ _3666_ VSS VSS VDD VDD
+ _1567_ sky130_fd_sc_hd__a221oi_2
X_5682_ net112 _1560_ _1565_ _1567_ VSS VSS VDD VDD _1568_
+ sky130_fd_sc_hd__a31oi_4
X_5683_ _1564_ _1568_ VSS VSS VDD VDD _3705_ sky130_fd_sc_hd__and2_2
X_5684_ _3636_ VSS VSS VDD VDD _3672_ sky130_fd_sc_hd__clkinv_4
X_5685_ net239 VSS VSS VDD VDD _3679_ sky130_fd_sc_hd__inv_4
X_5686_ net78 VSS VSS VDD VDD _3680_ sky130_fd_sc_hd__inv_1
X_5687_ _2331_ VSS VSS VDD VDD _2094_ sky130_fd_sc_hd__inv_1
X_5688_ _2199_ VSS VSS VDD VDD _2083_ sky130_fd_sc_hd__inv_1
X_5689_ _2103_ VSS VSS VDD VDD _2118_ sky130_fd_sc_hd__inv_1
X_5690_ _2135_ VSS VSS VDD VDD _2142_ sky130_fd_sc_hd__inv_1
X_5691_ _2173_ VSS VSS VDD VDD _2175_ sky130_fd_sc_hd__inv_1
X_5692_ net30 VSS VSS VDD VDD _2195_ sky130_fd_sc_hd__inv_1
X_5693_ net37 VSS VSS VDD VDD _2078_ sky130_fd_sc_hd__inv_1
X_5694_ net39 VSS VSS VDD VDD _2209_ sky130_fd_sc_hd__inv_1
X_5695_ net38 VSS VSS VDD VDD _2217_ sky130_fd_sc_hd__inv_1
X_5696_ _3685_ _0004_ VSS VSS VDD VDD _1569_ sky130_fd_sc_hd__or2_0
X_5697_ net70 _2472_ VSS VSS VDD VDD _1570_ sky130_fd_sc_hd__nand2b_4
X_5698_ net73 net72 _1570_ net71 VSS VSS VDD VDD _1571_ sky130_fd_sc_hd__or4_4
X_5699_ net74 _1571_ _0005_ _0040_ VSS VSS VDD VDD _1572_
+ sky130_fd_sc_hd__o31ai_4
X_5700_ _0003_ _1569_ _1572_ VSS VSS VDD VDD _1573_ sky130_fd_sc_hd__o21ai_2
X_5701_ _1573_ _3683_ VSS VSS VDD VDD _2090_ sky130_fd_sc_hd__xnor2_2
X_5702_ net41 VSS VSS VDD VDD _2239_ sky130_fd_sc_hd__inv_1
X_5703_ net40 VSS VSS VDD VDD _2247_ sky130_fd_sc_hd__inv_1
X_5704_ net42 VSS VSS VDD VDD _2255_ sky130_fd_sc_hd__inv_1
X_5705_ net64 net63 _0041_ VSS VSS VDD VDD _1574_ sky130_fd_sc_hd__o21ai_0
X_5706_ _1572_ _1574_ VSS VSS VDD VDD _1575_ sky130_fd_sc_hd__nand2_1
X_5707_ net65 _1575_ VSS VSS VDD VDD _2287_ sky130_fd_sc_hd__xor2_1
X_5708_ net63 _0039_ _0041_ VSS VSS VDD VDD _1576_ sky130_fd_sc_hd__o21ai_0
X_5709_ net64 _1576_ VSS VSS VDD VDD _2290_ sky130_fd_sc_hd__xnor2_1
X_5710_ net63 _1572_ VSS VSS VDD VDD _2293_ sky130_fd_sc_hd__xnor2_1
X_5711_ net76 net75 _0038_ _0041_ VSS VSS VDD VDD _1577_ sky130_fd_sc_hd__o31ai_1
X_5712_ net77 _1577_ VSS VSS VDD VDD _2296_ sky130_fd_sc_hd__xnor2_1
X_5713_ net75 net74 _1571_ _0041_ VSS VSS VDD VDD _1578_ sky130_fd_sc_hd__o31ai_1
X_5714_ net76 _1578_ VSS VSS VDD VDD _2299_ sky130_fd_sc_hd__xnor2_1
X_5715_ _0038_ _0041_ VSS VSS VDD VDD _1579_ sky130_fd_sc_hd__nand2_1
X_5716_ net75 _1579_ VSS VSS VDD VDD _2302_ sky130_fd_sc_hd__xnor2_1
X_5717_ _0041_ _1571_ VSS VSS VDD VDD _1580_ sky130_fd_sc_hd__nand2_1
X_5718_ net74 _1580_ VSS VSS VDD VDD _2305_ sky130_fd_sc_hd__xnor2_1
X_5719_ net72 net71 VSS VSS VDD VDD _1581_ sky130_fd_sc_hd__nor2_1
X_5720_ _0000_ _1581_ _1569_ VSS VSS VDD VDD _1582_ sky130_fd_sc_hd__a21oi_1
X_5721_ net73 _1582_ VSS VSS VDD VDD _2308_ sky130_fd_sc_hd__xor2_1
X_5722_ net71 _1570_ _0041_ VSS VSS VDD VDD _1583_ sky130_fd_sc_hd__o21ai_0
X_5723_ net72 _1583_ VSS VSS VDD VDD _2311_ sky130_fd_sc_hd__xnor2_1
X_5724_ _0000_ _1569_ VSS VSS VDD VDD _1584_ sky130_fd_sc_hd__nor2_1
X_5725_ net71 _1584_ VSS VSS VDD VDD _2107_ sky130_fd_sc_hd__xor2_2
X_5726_ _2088_ _2091_ VSS VSS VDD VDD _1585_ sky130_fd_sc_hd__nor2_1
X_5727_ _2087_ _1585_ VSS VSS VDD VDD _1586_ sky130_fd_sc_hd__nand2_1
X_5728_ _2085_ _0033_ _0015_ _1586_ VSS VSS VDD VDD _1587_
+ sky130_fd_sc_hd__o31ai_1
X_5729_ _2085_ _0033_ _2091_ VSS VSS VDD VDD _1588_ sky130_fd_sc_hd__nand3b_1
X_5730_ _2088_ _2087_ _2091_ _1588_ _0032_ VSS VSS VDD VDD
+ _1589_ sky130_fd_sc_hd__o311ai_0
X_5731_ _0032_ _1587_ _1589_ VSS VSS VDD VDD _1590_ sky130_fd_sc_hd__o21ai_0
X_5732_ _2272_ _1590_ _0125_ VSS VSS VDD VDD _1591_ sky130_fd_sc_hd__o21ai_0
X_5733_ _2268_ _1591_ VSS VSS VDD VDD _2316_ sky130_fd_sc_hd__xnor2_1
X_5734_ _2329_ net15 VSS VSS VDD VDD _1592_ sky130_fd_sc_hd__nor2_1
X_5735_ _2416_ _1592_ VSS VSS VDD VDD _2324_ sky130_fd_sc_hd__xor2_1
X_5736_ net43 VSS VSS VDD VDD _2339_ sky130_fd_sc_hd__inv_1
X_5737_ net44 VSS VSS VDD VDD _2347_ sky130_fd_sc_hd__inv_1
X_5738_ net31 VSS VSS VDD VDD _2363_ sky130_fd_sc_hd__inv_1
X_5739_ net45 VSS VSS VDD VDD _2371_ sky130_fd_sc_hd__inv_1
X_5740_ _0025_ _0113_ VSS VSS VDD VDD _1593_ sky130_fd_sc_hd__or2_0
X_5741_ net172 _0029_ _0090_ VSS VSS VDD VDD _1594_ sky130_fd_sc_hd__nand3_1
X_5742_ _0010_ _1593_ _1594_ VSS VSS VDD VDD _1595_ sky130_fd_sc_hd__o21ai_2
X_5743_ _2232_ _1595_ VSS VSS VDD VDD _1596_ sky130_fd_sc_hd__nand2_2
X_5744_ _0682_ _1596_ _0125_ VSS VSS VDD VDD _1597_ sky130_fd_sc_hd__o21ai_0
X_5745_ _2502_ _1597_ VSS VSS VDD VDD _2383_ sky130_fd_sc_hd__xnor2_1
X_5746_ _0680_ _0681_ VSS VSS VDD VDD _1598_ sky130_fd_sc_hd__nor2_1
X_5747_ _1598_ _0688_ _0125_ VSS VSS VDD VDD _1599_ sky130_fd_sc_hd__o21ai_0
X_5748_ _2506_ _1599_ VSS VSS VDD VDD _2387_ sky130_fd_sc_hd__xnor2_1
X_5749_ _0015_ _0064_ _0078_ VSS VSS VDD VDD _1600_ sky130_fd_sc_hd__nor3_1
X_5750_ _0016_ _0053_ _0214_ _1600_ VSS VSS VDD VDD _1601_
+ sky130_fd_sc_hd__a31oi_1
X_5751_ _1596_ _1601_ _0125_ VSS VSS VDD VDD _1602_ sky130_fd_sc_hd__o21ai_0
X_5752_ _2356_ _1602_ VSS VSS VDD VDD _2391_ sky130_fd_sc_hd__xnor2_1
X_5753_ _2264_ _0688_ _0125_ VSS VSS VDD VDD _1603_ sky130_fd_sc_hd__o21ai_0
X_5754_ _2360_ _1603_ VSS VSS VDD VDD _2395_ sky130_fd_sc_hd__xnor2_1
X_5755_ _0115_ _1596_ VSS VSS VDD VDD _1604_ sky130_fd_sc_hd__nand2_1
X_5756_ _2264_ _1604_ VSS VSS VDD VDD _2399_ sky130_fd_sc_hd__xnor2_1
X_5757_ _2289_ VSS VSS VDD VDD _1605_ sky130_fd_sc_hd__inv_1
X_5758_ _2295_ VSS VSS VDD VDD _1606_ sky130_fd_sc_hd__inv_1
X_5759_ _2108_ _2313_ _2312_ VSS VSS VDD VDD _1607_ sky130_fd_sc_hd__a21o_1
X_5760_ _2310_ _1607_ _2309_ VSS VSS VDD VDD _1608_ sky130_fd_sc_hd__a21oi_1
X_5761_ _0145_ _1608_ _2306_ VSS VSS VDD VDD _1609_ sky130_fd_sc_hd__o21bai_1
X_5762_ _2304_ _1609_ _2303_ VSS VSS VDD VDD _1610_ sky130_fd_sc_hd__a21oi_1
X_5763_ _0146_ _1610_ _2300_ VSS VSS VDD VDD _1611_ sky130_fd_sc_hd__o21bai_1
X_5764_ _2298_ _1611_ _2297_ VSS VSS VDD VDD _1612_ sky130_fd_sc_hd__a21oi_1
X_5765_ _1606_ _1612_ _0141_ VSS VSS VDD VDD _1613_ sky130_fd_sc_hd__o21ai_0
X_5766_ _2292_ _1613_ _2291_ VSS VSS VDD VDD _1614_ sky130_fd_sc_hd__a21oi_1
X_5767_ _1605_ _1614_ _2288_ VSS VSS VDD VDD _1615_ sky130_fd_sc_hd__o21bai_1
X_5768_ _2286_ _1615_ _2285_ VSS VSS VDD VDD _1616_ sky130_fd_sc_hd__a21oi_1
X_5769_ _0155_ _1616_ VSS VSS VDD VDD _2433_ sky130_fd_sc_hd__xor2_1
X_5770_ _2291_ _0154_ VSS VSS VDD VDD _1617_ sky130_fd_sc_hd__nor2_1
X_5771_ _1605_ _1617_ VSS VSS VDD VDD _1618_ sky130_fd_sc_hd__nor2_1
X_5772_ _2288_ _1618_ VSS VSS VDD VDD _1619_ sky130_fd_sc_hd__nor2_1
X_5773_ _2286_ _1619_ VSS VSS VDD VDD _2436_ sky130_fd_sc_hd__xnor2_1
X_5774_ _2289_ _1614_ VSS VSS VDD VDD _2439_ sky130_fd_sc_hd__xnor2_1
X_5775_ _0149_ _0152_ _1606_ VSS VSS VDD VDD _1620_ sky130_fd_sc_hd__a21oi_1
X_5776_ _2292_ _2294_ _1620_ VSS VSS VDD VDD _1621_ sky130_fd_sc_hd__nor3_1
X_5777_ _0154_ _1621_ VSS VSS VDD VDD _2442_ sky130_fd_sc_hd__nor2_1
X_5778_ _2295_ _1612_ VSS VSS VDD VDD _2446_ sky130_fd_sc_hd__xnor2_1
X_5779_ _2309_ _0144_ VSS VSS VDD VDD _1622_ sky130_fd_sc_hd__nor2_1
X_5780_ _0145_ _1622_ VSS VSS VDD VDD _1623_ sky130_fd_sc_hd__nor2_1
X_5781_ _2304_ _2301_ _1623_ _0151_ VSS VSS VDD VDD _1624_
+ sky130_fd_sc_hd__a31oi_1
X_5782_ _2298_ _1624_ VSS VSS VDD VDD _2449_ sky130_fd_sc_hd__xnor2_1
X_5783_ _2301_ _1610_ VSS VSS VDD VDD _2452_ sky130_fd_sc_hd__xnor2_1
X_5784_ _2306_ _1623_ VSS VSS VDD VDD _1625_ sky130_fd_sc_hd__nor2_1
X_5785_ _2304_ _1625_ VSS VSS VDD VDD _2455_ sky130_fd_sc_hd__xnor2_1
X_5786_ _2307_ _1608_ VSS VSS VDD VDD _2458_ sky130_fd_sc_hd__xnor2_1
X_5787_ _0142_ _0143_ VSS VSS VDD VDD _1626_ sky130_fd_sc_hd__nand2_1
X_5788_ _2310_ _1626_ VSS VSS VDD VDD _1627_ sky130_fd_sc_hd__nor2_1
X_5789_ _0144_ _1627_ VSS VSS VDD VDD _2461_ sky130_fd_sc_hd__nor2_1
X_5790_ _2108_ _2313_ VSS VSS VDD VDD _2464_ sky130_fd_sc_hd__xor2_1
X_5791_ _2412_ _2416_ _2329_ VSS VSS VDD VDD _1628_ sky130_fd_sc_hd__nor3b_1
X_5792_ net2 _1628_ VSS VSS VDD VDD _1629_ sky130_fd_sc_hd__nor2_1
X_5793_ _2408_ _1629_ VSS VSS VDD VDD _2477_ sky130_fd_sc_hd__xor2_1
X_5794_ net9 _0764_ VSS VSS VDD VDD _1630_ sky130_fd_sc_hd__nand2_1
X_5795_ _2626_ _1630_ VSS VSS VDD VDD _2485_ sky130_fd_sc_hd__xnor2_1
X_5796_ _2326_ _2114_ VSS VSS VDD VDD _2488_ sky130_fd_sc_hd__xor2_1
X_5797_ net33 VSS VSS VDD VDD _2509_ sky130_fd_sc_hd__inv_1
X_5798_ net32 VSS VSS VDD VDD _2517_ sky130_fd_sc_hd__inv_1
X_5799_ _0682_ _0683_ _1596_ _0125_ VSS VSS VDD VDD _1631_
+ sky130_fd_sc_hd__o31ai_1
X_5800_ _2574_ _1631_ VSS VSS VDD VDD _2529_ sky130_fd_sc_hd__xnor2_1
X_5801_ net35 VSS VSS VDD VDD _2541_ sky130_fd_sc_hd__inv_1
X_5802_ net34 VSS VSS VDD VDD _2549_ sky130_fd_sc_hd__inv_1
X_5803_ _2232_ _0684_ _1595_ net16 VSS VSS VDD VDD _1632_
+ sky130_fd_sc_hd__a31o_1
X_5804_ _2562_ _1632_ VSS VSS VDD VDD _2577_ sky130_fd_sc_hd__xnor2_1
X_5805_ _2760_ _2728_ _2732_ _0794_ VSS VSS VDD VDD _1633_
+ sky130_fd_sc_hd__nor4_1
X_5806_ net2 _1633_ VSS VSS VDD VDD _1634_ sky130_fd_sc_hd__nor2_1
X_5807_ _2764_ _1634_ VSS VSS VDD VDD _2585_ sky130_fd_sc_hd__xor2_1
X_5808_ _2728_ _2732_ VSS VSS VDD VDD _1635_ sky130_fd_sc_hd__nor2_1
X_5809_ _2404_ _2408_ VSS VSS VDD VDD _1636_ sky130_fd_sc_hd__nor2_1
X_5810_ _1628_ _1636_ VSS VSS VDD VDD _1637_ sky130_fd_sc_hd__nand2_1
X_5811_ _2534_ _2538_ _1637_ VSS VSS VDD VDD _1638_ sky130_fd_sc_hd__nor3_1
X_5812_ _1635_ _1638_ _0159_ VSS VSS VDD VDD _1639_ sky130_fd_sc_hd__a21oi_1
X_5813_ _2760_ _1639_ VSS VSS VDD VDD _2589_ sky130_fd_sc_hd__xor2_1
X_5814_ _2732_ _0794_ net18 VSS VSS VDD VDD _1640_ sky130_fd_sc_hd__o21ai_1
X_5815_ _2728_ _1640_ VSS VSS VDD VDD _2593_ sky130_fd_sc_hd__xnor2_1
X_5816_ net2 _1638_ VSS VSS VDD VDD _1641_ sky130_fd_sc_hd__nor2_1
X_5817_ _2732_ _1641_ VSS VSS VDD VDD _2597_ sky130_fd_sc_hd__xor2_1
X_5818_ _2404_ _2538_ _0793_ _0295_ VSS VSS VDD VDD _1642_
+ sky130_fd_sc_hd__o31ai_2
X_5819_ _2534_ _1642_ VSS VSS VDD VDD _2601_ sky130_fd_sc_hd__xnor2_1
X_5820_ net23 _1637_ VSS VSS VDD VDD _1643_ sky130_fd_sc_hd__nand2_1
X_5821_ _2538_ _1643_ VSS VSS VDD VDD _2605_ sky130_fd_sc_hd__xnor2_1
X_5822_ net23 _0793_ VSS VSS VDD VDD _1644_ sky130_fd_sc_hd__nand2_1
X_5823_ _2404_ _1644_ VSS VSS VDD VDD _2609_ sky130_fd_sc_hd__xnor2_1
X_5824_ _2445_ VSS VSS VDD VDD _1645_ sky130_fd_sc_hd__inv_1
X_5825_ _2125_ VSS VSS VDD VDD _1646_ sky130_fd_sc_hd__inv_1
X_5826_ _1646_ _2470_ _2469_ VSS VSS VDD VDD _1647_ sky130_fd_sc_hd__a21oi_1
X_5827_ _0331_ _1647_ _2467_ VSS VSS VDD VDD _1648_ sky130_fd_sc_hd__o21bai_1
X_5828_ _2466_ _1648_ _2465_ VSS VSS VDD VDD _1649_ sky130_fd_sc_hd__a21oi_1
X_5829_ _0330_ _1649_ _2462_ VSS VSS VDD VDD _1650_ sky130_fd_sc_hd__o21bai_1
X_5830_ _2460_ _1650_ _2459_ VSS VSS VDD VDD _1651_ sky130_fd_sc_hd__a21o_1
X_5831_ _2457_ _1651_ _2456_ VSS VSS VDD VDD _1652_ sky130_fd_sc_hd__a21o_1
X_5832_ _2454_ _1652_ _2453_ VSS VSS VDD VDD _1653_ sky130_fd_sc_hd__a21o_1
X_5833_ _2451_ _1653_ _2450_ VSS VSS VDD VDD _1654_ sky130_fd_sc_hd__a21o_1
X_5834_ _2448_ _1654_ _2447_ VSS VSS VDD VDD _1655_ sky130_fd_sc_hd__a21oi_1
X_5835_ _1645_ _1655_ _2444_ VSS VSS VDD VDD _1656_ sky130_fd_sc_hd__o21bai_1
X_5836_ _2441_ _1656_ _2440_ VSS VSS VDD VDD _1657_ sky130_fd_sc_hd__a21o_1
X_5837_ _2438_ _1657_ _2437_ VSS VSS VDD VDD _1658_ sky130_fd_sc_hd__a21oi_1
X_5838_ _2435_ _1658_ VSS VSS VDD VDD _2651_ sky130_fd_sc_hd__xnor2_1
X_5839_ _1645_ _0342_ _2444_ VSS VSS VDD VDD _1659_ sky130_fd_sc_hd__o21bai_1
X_5840_ _2441_ _1659_ _2440_ VSS VSS VDD VDD _1660_ sky130_fd_sc_hd__a21oi_1
X_5841_ _2438_ _1660_ VSS VSS VDD VDD _2655_ sky130_fd_sc_hd__xnor2_1
X_5842_ _2441_ _1656_ VSS VSS VDD VDD _2658_ sky130_fd_sc_hd__xor2_1
X_5843_ _2445_ _0342_ VSS VSS VDD VDD _2661_ sky130_fd_sc_hd__xnor2_1
X_5844_ _2448_ _1654_ VSS VSS VDD VDD _2664_ sky130_fd_sc_hd__xor2_1
X_5845_ _2453_ _0338_ VSS VSS VDD VDD _1661_ sky130_fd_sc_hd__nand2b_1
X_5846_ _2451_ _1661_ VSS VSS VDD VDD _2668_ sky130_fd_sc_hd__xor2_1
X_5847_ _2454_ _1652_ VSS VSS VDD VDD _2671_ sky130_fd_sc_hd__xor2_1
X_5848_ _2460_ _0336_ _2459_ VSS VSS VDD VDD _1662_ sky130_fd_sc_hd__a21oi_1
X_5849_ _2457_ _1662_ VSS VSS VDD VDD _2674_ sky130_fd_sc_hd__xnor2_1
X_5850_ _2460_ _1650_ VSS VSS VDD VDD _2677_ sky130_fd_sc_hd__xor2_1
X_5851_ _2463_ _0335_ VSS VSS VDD VDD _2680_ sky130_fd_sc_hd__xnor2_1
X_5852_ _2466_ _1648_ VSS VSS VDD VDD _2683_ sky130_fd_sc_hd__xor2_1
X_5853_ _2468_ _0333_ VSS VSS VDD VDD _2686_ sky130_fd_sc_hd__xnor2_1
X_5854_ _2125_ _2470_ VSS VSS VDD VDD _2689_ sky130_fd_sc_hd__xnor2_1
X_5855_ _2126_ VSS VSS VDD VDD _2692_ sky130_fd_sc_hd__inv_1
X_5856_ _2622_ _2626_ _0764_ _0578_ VSS VSS VDD VDD _1663_
+ sky130_fd_sc_hd__o31ai_1
X_5857_ _2618_ _1663_ VSS VSS VDD VDD _2695_ sky130_fd_sc_hd__xnor2_1
X_5858_ _2822_ _2716_ VSS VSS VDD VDD _1664_ sky130_fd_sc_hd__nand2b_1
X_5859_ _2818_ _1664_ _0816_ VSS VSS VDD VDD _1665_ sky130_fd_sc_hd__o21ai_0
X_5860_ _2814_ _1665_ VSS VSS VDD VDD _2703_ sky130_fd_sc_hd__xnor2_1
X_5861_ _2487_ _0636_ VSS VSS VDD VDD _2706_ sky130_fd_sc_hd__xnor2_1
X_5862_ _2129_ _2491_ VSS VSS VDD VDD _2710_ sky130_fd_sc_hd__xor2_1
X_5863_ _2562_ _0684_ VSS VSS VDD VDD _1666_ sky130_fd_sc_hd__or2b_1
X_5864_ _1666_ _0688_ net4 VSS VSS VDD VDD _1667_ sky130_fd_sc_hd__o21ai_1
X_5865_ _2558_ _1667_ VSS VSS VDD VDD _2723_ sky130_fd_sc_hd__xnor2_1
X_5866_ _2558_ _1666_ _1596_ _0125_ VSS VSS VDD VDD _1668_
+ sky130_fd_sc_hd__o31ai_1
X_5867_ _0703_ _1668_ VSS VSS VDD VDD _2735_ sky130_fd_sc_hd__xnor2_1
X_5868_ _0782_ _0796_ VSS VSS VDD VDD _2743_ sky130_fd_sc_hd__xnor2_1
X_5869_ _2944_ _2928_ VSS VSS VDD VDD _1669_ sky130_fd_sc_hd__nor2_1
X_5870_ _2630_ _2626_ VSS VSS VDD VDD _1670_ sky130_fd_sc_hd__nor2_1
X_5871_ _2494_ _1670_ VSS VSS VDD VDD _1671_ sky130_fd_sc_hd__nand2_1
X_5872_ _2622_ _2618_ _1671_ VSS VSS VDD VDD _1672_ sky130_fd_sc_hd__nor3_1
X_5873_ _2614_ _2752_ VSS VSS VDD VDD _1673_ sky130_fd_sc_hd__nor2_1
X_5874_ _1672_ _1673_ VSS VSS VDD VDD _1674_ sky130_fd_sc_hd__nand2_1
X_5875_ _2748_ _2932_ _1674_ VSS VSS VDD VDD _1675_ sky130_fd_sc_hd__nor3_1
X_5876_ _1669_ _1675_ VSS VSS VDD VDD _1676_ sky130_fd_sc_hd__nand2_1
X_5877_ _0578_ _1676_ VSS VSS VDD VDD _1677_ sky130_fd_sc_hd__nand2_1
X_5878_ _0783_ _0784_ _1677_ _0786_ VSS VSS VDD VDD _2767_
+ sky130_fd_sc_hd__o31ai_1
X_5879_ _0783_ _0784_ VSS VSS VDD VDD _1678_ sky130_fd_sc_hd__nor2_1
X_5880_ _1678_ _1677_ VSS VSS VDD VDD _2771_ sky130_fd_sc_hd__xor2_1
X_5881_ _2665_ _1675_ VSS VSS VDD VDD _1679_ sky130_fd_sc_hd__nor2_1
X_5882_ _2928_ _1679_ VSS VSS VDD VDD _2777_ sky130_fd_sc_hd__xor2_1
X_5883_ net9 _0767_ VSS VSS VDD VDD _1680_ sky130_fd_sc_hd__nand2_1
X_5884_ _2932_ _1680_ VSS VSS VDD VDD _2781_ sky130_fd_sc_hd__xnor2_1
X_5885_ net9 _1674_ VSS VSS VDD VDD _1681_ sky130_fd_sc_hd__nand2_1
X_5886_ _2748_ _1681_ VSS VSS VDD VDD _2785_ sky130_fd_sc_hd__xnor2_1
X_5887_ net9 _0766_ VSS VSS VDD VDD _1682_ sky130_fd_sc_hd__nand2_1
X_5888_ _2752_ _1682_ VSS VSS VDD VDD _2789_ sky130_fd_sc_hd__xnor2_1
X_5889_ _2665_ _1672_ VSS VSS VDD VDD _1683_ sky130_fd_sc_hd__nor2_1
X_5890_ _0438_ _1683_ VSS VSS VDD VDD _2793_ sky130_fd_sc_hd__xnor2_1
X_5891_ _0785_ _0786_ VSS VSS VDD VDD _2797_ sky130_fd_sc_hd__nand2_1
X_5892_ _2928_ _2932_ _0767_ _0578_ VSS VSS VDD VDD _1684_
+ sky130_fd_sc_hd__o31ai_1
X_5893_ _2944_ _1684_ VSS VSS VDD VDD _2801_ sky130_fd_sc_hd__xnor2_1
X_5894_ _2337_ VSS VSS VDD VDD _2131_ sky130_fd_sc_hd__inv_1
X_5895_ _2476_ _0348_ VSS VSS VDD VDD _1685_ sky130_fd_sc_hd__nor2_1
X_5896_ _0138_ _2476_ _1685_ VSS VSS VDD VDD _1686_ sky130_fd_sc_hd__a21oi_1
X_5897_ _2691_ _1686_ _2690_ VSS VSS VDD VDD _1687_ sky130_fd_sc_hd__a21oi_1
X_5898_ _1687_ _2688_ VSS VSS VDD VDD _1688_ sky130_fd_sc_hd__nor2b_1
X_5899_ _2687_ _1688_ _2685_ VSS VSS VDD VDD _1689_ sky130_fd_sc_hd__o21ai_0
X_5900_ _0612_ _1689_ _2682_ VSS VSS VDD VDD _1690_ sky130_fd_sc_hd__a21boi_0
X_5901_ _2681_ _1690_ _2679_ VSS VSS VDD VDD _1691_ sky130_fd_sc_hd__o21a_1
X_5902_ _2678_ _1691_ _2676_ VSS VSS VDD VDD _1692_ sky130_fd_sc_hd__o21a_1
X_5903_ _2675_ _1692_ _2673_ VSS VSS VDD VDD _1693_ sky130_fd_sc_hd__o21a_1
X_5904_ _2672_ _1693_ _2670_ VSS VSS VDD VDD _1694_ sky130_fd_sc_hd__o21a_1
X_5905_ _2669_ _1694_ _2667_ VSS VSS VDD VDD _1695_ sky130_fd_sc_hd__o21a_1
X_5906_ _2666_ _1695_ _2663_ VSS VSS VDD VDD _1696_ sky130_fd_sc_hd__o21a_1
X_5907_ _2662_ _1696_ _2660_ VSS VSS VDD VDD _1697_ sky130_fd_sc_hd__o21ai_0
X_5908_ _2659_ _1697_ VSS VSS VDD VDD _1698_ sky130_fd_sc_hd__nand2b_1
X_5909_ _2657_ _1698_ _2656_ VSS VSS VDD VDD _1699_ sky130_fd_sc_hd__a21oi_1
X_5910_ _2654_ _1699_ VSS VSS VDD VDD _2851_ sky130_fd_sc_hd__xnor2_1
X_5911_ _2660_ _0626_ _2659_ VSS VSS VDD VDD _1700_ sky130_fd_sc_hd__a21oi_1
X_5912_ _2657_ _1700_ VSS VSS VDD VDD _2855_ sky130_fd_sc_hd__xnor2_1
X_5913_ _2662_ _1696_ VSS VSS VDD VDD _1701_ sky130_fd_sc_hd__nor2_1
X_5914_ _2660_ _1701_ VSS VSS VDD VDD _2858_ sky130_fd_sc_hd__xnor2_1
X_5915_ _2663_ _0625_ VSS VSS VDD VDD _2861_ sky130_fd_sc_hd__xor2_1
X_5916_ _2667_ _2669_ _1694_ VSS VSS VDD VDD _1702_ sky130_fd_sc_hd__nor3_1
X_5917_ _1695_ _1702_ VSS VSS VDD VDD _2864_ sky130_fd_sc_hd__nor2_1
X_5918_ _0621_ _0622_ VSS VSS VDD VDD _1703_ sky130_fd_sc_hd__nor2_1
X_5919_ _2670_ _1703_ VSS VSS VDD VDD _2867_ sky130_fd_sc_hd__xnor2_1
X_5920_ _2673_ _2675_ _1692_ VSS VSS VDD VDD _1704_ sky130_fd_sc_hd__nor3_1
X_5921_ _1693_ _1704_ VSS VSS VDD VDD _2871_ sky130_fd_sc_hd__nor2_1
X_5922_ _0611_ _0619_ VSS VSS VDD VDD _1705_ sky130_fd_sc_hd__nand2_1
X_5923_ _2676_ _1705_ VSS VSS VDD VDD _2874_ sky130_fd_sc_hd__xor2_1
X_5924_ _2679_ _2681_ _1690_ VSS VSS VDD VDD _1706_ sky130_fd_sc_hd__nor3_1
X_5925_ _1691_ _1706_ VSS VSS VDD VDD _2877_ sky130_fd_sc_hd__nor2_1
X_5926_ _0612_ _0617_ VSS VSS VDD VDD _1707_ sky130_fd_sc_hd__nand2_1
X_5927_ _2682_ _1707_ VSS VSS VDD VDD _1708_ sky130_fd_sc_hd__nor2_1
X_5928_ _0618_ _1708_ VSS VSS VDD VDD _2880_ sky130_fd_sc_hd__nor2_1
X_5929_ _2687_ _1688_ VSS VSS VDD VDD _1709_ sky130_fd_sc_hd__nor2_1
X_5930_ _2685_ _1709_ VSS VSS VDD VDD _2883_ sky130_fd_sc_hd__xnor2_1
X_5931_ _0613_ _0615_ VSS VSS VDD VDD _1710_ sky130_fd_sc_hd__nand2_1
X_5932_ _2688_ _1710_ VSS VSS VDD VDD _1711_ sky130_fd_sc_hd__nor2_1
X_5933_ _0616_ _1711_ VSS VSS VDD VDD _2886_ sky130_fd_sc_hd__nor2_1
X_5934_ _2691_ _1686_ VSS VSS VDD VDD _2889_ sky130_fd_sc_hd__xor2_1
X_5935_ _0138_ _2694_ VSS VSS VDD VDD _2892_ sky130_fd_sc_hd__xnor2_1
X_5936_ _2848_ _2818_ _2814_ _1664_ VSS VSS VDD VDD _1712_
+ sky130_fd_sc_hd__or4_1
X_5937_ net12 _1712_ VSS VSS VDD VDD _1713_ sky130_fd_sc_hd__nand2_1
X_5938_ _2810_ _1713_ VSS VSS VDD VDD _2895_ sky130_fd_sc_hd__xnor2_1
X_5939_ _1101_ _1102_ _0972_ VSS VSS VDD VDD _1714_ sky130_fd_sc_hd__o21ai_0
X_5940_ _2986_ _1714_ VSS VSS VDD VDD _2903_ sky130_fd_sc_hd__xnor2_1
X_5941_ _2705_ _0877_ VSS VSS VDD VDD _2906_ sky130_fd_sc_hd__xnor2_1
X_5942_ _2709_ _0644_ VSS VSS VDD VDD _2910_ sky130_fd_sc_hd__xnor2_1
X_5943_ _2713_ _2138_ VSS VSS VDD VDD _2914_ sky130_fd_sc_hd__xor2_1
X_5944_ _2940_ VSS VSS VDD VDD _1715_ sky130_fd_sc_hd__inv_1
X_5945_ _2806_ _2810_ _1712_ VSS VSS VDD VDD _1716_ sky130_fd_sc_hd__nor3_1
X_5946_ _0908_ _1715_ _1716_ VSS VSS VDD VDD _1717_ sky130_fd_sc_hd__nand3_1
X_5947_ _0950_ _0951_ VSS VSS VDD VDD _1718_ sky130_fd_sc_hd__or2_0
X_5948_ _3117_ _1717_ _1718_ net12 VSS VSS VDD VDD _1719_
+ sky130_fd_sc_hd__o211ai_1
X_5949_ _0952_ _1719_ VSS VSS VDD VDD _2947_ sky130_fd_sc_hd__nand2_1
X_5950_ _0952_ _1719_ VSS VSS VDD VDD _2951_ sky130_fd_sc_hd__nand2_1
X_5951_ net12 _1717_ VSS VSS VDD VDD _1720_ sky130_fd_sc_hd__nand2_1
X_5952_ _3117_ _1720_ VSS VSS VDD VDD _2957_ sky130_fd_sc_hd__xnor2_1
X_5953_ net1 _0956_ VSS VSS VDD VDD _1721_ sky130_fd_sc_hd__nor2_1
X_5954_ _0908_ _1721_ VSS VSS VDD VDD _2961_ sky130_fd_sc_hd__xnor2_1
X_5955_ net1 _1716_ VSS VSS VDD VDD _1722_ sky130_fd_sc_hd__nor2_1
X_5956_ _1715_ _1722_ VSS VSS VDD VDD _2965_ sky130_fd_sc_hd__xnor2_1
X_5957_ net12 _0955_ VSS VSS VDD VDD _1723_ sky130_fd_sc_hd__nand2_1
X_5958_ _2806_ _1723_ VSS VSS VDD VDD _2969_ sky130_fd_sc_hd__xnor2_1
X_5959_ _1718_ _0957_ VSS VSS VDD VDD _2977_ sky130_fd_sc_hd__xnor2_1
X_5960_ _2144_ VSS VSS VDD VDD _2154_ sky130_fd_sc_hd__inv_1
X_5961_ _2872_ VSS VSS VDD VDD _1724_ sky130_fd_sc_hd__inv_1
X_5962_ _2878_ VSS VSS VDD VDD _1725_ sky130_fd_sc_hd__inv_1
X_5963_ _0138_ _2694_ VSS VSS VDD VDD _1726_ sky130_fd_sc_hd__nand2_1
X_5964_ _2694_ net13 _1726_ VSS VSS VDD VDD _1727_ sky130_fd_sc_hd__o21ai_1
X_5965_ _2891_ _1727_ _2890_ VSS VSS VDD VDD _1728_ sky130_fd_sc_hd__a21oi_1
X_5966_ _0857_ _1728_ _0860_ VSS VSS VDD VDD _1729_ sky130_fd_sc_hd__o21ai_1
X_5967_ _2885_ _1729_ _2884_ VSS VSS VDD VDD _1730_ sky130_fd_sc_hd__a21oi_1
X_5968_ _0856_ _1730_ VSS VSS VDD VDD _1731_ sky130_fd_sc_hd__nor2_1
X_5969_ _2881_ _1731_ _2879_ VSS VSS VDD VDD _1732_ sky130_fd_sc_hd__o21ai_0
X_5970_ _1725_ _1732_ _0855_ VSS VSS VDD VDD _1733_ sky130_fd_sc_hd__a21oi_1
X_5971_ _2875_ _1733_ _2873_ VSS VSS VDD VDD _1734_ sky130_fd_sc_hd__o21ai_0
X_5972_ _1724_ _1734_ _0854_ VSS VSS VDD VDD _1735_ sky130_fd_sc_hd__a21oi_1
X_5973_ _2869_ _1735_ _2866_ VSS VSS VDD VDD _1736_ sky130_fd_sc_hd__o21a_1
X_5974_ _2865_ _1736_ _2863_ VSS VSS VDD VDD _1737_ sky130_fd_sc_hd__o21ai_0
X_5975_ _2862_ _1737_ VSS VSS VDD VDD _1738_ sky130_fd_sc_hd__nand2b_1
X_5976_ _2860_ _1738_ _2859_ VSS VSS VDD VDD _1739_ sky130_fd_sc_hd__a21o_1
X_5977_ _2857_ _1739_ _2856_ VSS VSS VDD VDD _1740_ sky130_fd_sc_hd__a21oi_1
X_5978_ _2854_ _1740_ VSS VSS VDD VDD _3037_ sky130_fd_sc_hd__xnor2_1
X_5979_ _2857_ _0870_ VSS VSS VDD VDD _3041_ sky130_fd_sc_hd__xnor2_1
X_5980_ _2860_ _1738_ VSS VSS VDD VDD _3044_ sky130_fd_sc_hd__xor2_1
X_5981_ _2863_ _0868_ VSS VSS VDD VDD _3047_ sky130_fd_sc_hd__xnor2_1
X_5982_ _2869_ _1735_ VSS VSS VDD VDD _1741_ sky130_fd_sc_hd__nor2_1
X_5983_ _2866_ _1741_ VSS VSS VDD VDD _3050_ sky130_fd_sc_hd__xnor2_1
X_5984_ _2870_ _0866_ VSS VSS VDD VDD _3053_ sky130_fd_sc_hd__xnor2_1
X_5985_ _2875_ _1733_ VSS VSS VDD VDD _1742_ sky130_fd_sc_hd__nor2_1
X_5986_ _2873_ _1742_ VSS VSS VDD VDD _3056_ sky130_fd_sc_hd__xnor2_1
X_5987_ _2876_ _0864_ VSS VSS VDD VDD _3060_ sky130_fd_sc_hd__xnor2_1
X_5988_ _2881_ _1731_ VSS VSS VDD VDD _1743_ sky130_fd_sc_hd__nor2_1
X_5989_ _2879_ _1743_ VSS VSS VDD VDD _3063_ sky130_fd_sc_hd__xnor2_1
X_5990_ _2882_ _0862_ VSS VSS VDD VDD _3066_ sky130_fd_sc_hd__xnor2_1
X_5991_ _2885_ _1729_ VSS VSS VDD VDD _3069_ sky130_fd_sc_hd__xor2_1
X_5992_ _2888_ _0859_ VSS VSS VDD VDD _3072_ sky130_fd_sc_hd__xnor2_1
X_5993_ _2891_ _1727_ VSS VSS VDD VDD _3075_ sky130_fd_sc_hd__xor2_1
X_5994_ _0138_ _2894_ VSS VSS VDD VDD _3078_ sky130_fd_sc_hd__xor2_2
X_5995_ net24 _1103_ VSS VSS VDD VDD _1744_ sky130_fd_sc_hd__nand2_1
X_5996_ _3029_ _1744_ VSS VSS VDD VDD _3081_ sky130_fd_sc_hd__xnor2_1
X_5997_ _1235_ _1237_ net25 VSS VSS VDD VDD _1745_ sky130_fd_sc_hd__a21oi_1
X_5998_ _3197_ _1745_ VSS VSS VDD VDD _3085_ sky130_fd_sc_hd__xor2_1
X_5999_ _3163_ _3110_ VSS VSS VDD VDD _1746_ sky130_fd_sc_hd__nor2b_2
X_6000_ _1236_ _1746_ _1049_ VSS VSS VDD VDD _1747_ sky130_fd_sc_hd__a21oi_1
X_6001_ _3201_ _1747_ VSS VSS VDD VDD _3089_ sky130_fd_sc_hd__xor2_1
X_6002_ _2905_ _1054_ VSS VSS VDD VDD _3092_ sky130_fd_sc_hd__xnor2_2
X_6003_ _2909_ _0894_ VSS VSS VDD VDD _3096_ sky130_fd_sc_hd__xnor2_2
X_6004_ _2913_ _1052_ VSS VSS VDD VDD _3100_ sky130_fd_sc_hd__xnor2_2
X_6005_ _2148_ _2917_ VSS VSS VDD VDD _3104_ sky130_fd_sc_hd__xor2_2
X_6006_ _1098_ _1099_ VSS VSS VDD VDD _1748_ sky130_fd_sc_hd__or2_1
X_6007_ _3000_ _2920_ VSS VSS VDD VDD _1749_ sky130_fd_sc_hd__nand2b_1
X_6008_ _2986_ _1102_ _1749_ VSS VSS VDD VDD _1750_ sky130_fd_sc_hd__nor3_1
X_6009_ _3034_ _3029_ VSS VSS VDD VDD _1751_ sky130_fd_sc_hd__nor2_1
X_6010_ _1750_ _1751_ VSS VSS VDD VDD _1752_ sky130_fd_sc_hd__nand2_1
X_6011_ _2981_ _3121_ _1752_ net17 VSS VSS VDD VDD _1753_
+ sky130_fd_sc_hd__o31ai_2
X_6012_ _1748_ _1753_ _1106_ VSS VSS VDD VDD _3125_ sky130_fd_sc_hd__o21bai_1
X_6013_ _1748_ _1753_ VSS VSS VDD VDD _3137_ sky130_fd_sc_hd__xnor2_1
X_6014_ _2981_ _3029_ _1103_ net24 VSS VSS VDD VDD _1754_
+ sky130_fd_sc_hd__o31ai_1
X_6015_ _3121_ _1754_ VSS VSS VDD VDD _3141_ sky130_fd_sc_hd__xnor2_1
X_6016_ net24 _1752_ VSS VSS VDD VDD _1755_ sky130_fd_sc_hd__nand2_1
X_6017_ _2981_ _1755_ VSS VSS VDD VDD _3145_ sky130_fd_sc_hd__xnor2_1
X_6018_ _1748_ _1753_ _1106_ VSS VSS VDD VDD _3133_ sky130_fd_sc_hd__o21bai_1
X_6019_ _1105_ _1106_ VSS VSS VDD VDD _3151_ sky130_fd_sc_hd__or2_0
X_6020_ _0991_ _0993_ VSS VSS VDD VDD _1756_ sky130_fd_sc_hd__nand2_1
X_6021_ _3018_ _1756_ VSS VSS VDD VDD _1757_ sky130_fd_sc_hd__nor2_1
X_6022_ _0994_ _1757_ VSS VSS VDD VDD _3183_ sky130_fd_sc_hd__nor2_1
X_6023_ _2153_ VSS VSS VDD VDD _2160_ sky130_fd_sc_hd__inv_1
X_6024_ _3057_ net28 _2894_ VSS VSS VDD VDD _1758_ sky130_fd_sc_hd__mux2i_2
X_6025_ _3077_ _1758_ _3076_ VSS VSS VDD VDD _1759_ sky130_fd_sc_hd__a21oi_1
X_6026_ _1759_ _3074_ VSS VSS VDD VDD _1760_ sky130_fd_sc_hd__nor2b_1
X_6027_ _3073_ _1760_ _3071_ VSS VSS VDD VDD _1761_ sky130_fd_sc_hd__o21ai_0
X_6028_ _1032_ _1761_ _3068_ VSS VSS VDD VDD _1762_ sky130_fd_sc_hd__a21boi_0
X_6029_ _3067_ _1762_ VSS VSS VDD VDD _1763_ sky130_fd_sc_hd__nor2_1
X_6030_ _3065_ _1763_ VSS VSS VDD VDD _3239_ sky130_fd_sc_hd__xnor2_1
X_6031_ net28 _3080_ VSS VSS VDD VDD _3254_ sky130_fd_sc_hd__xnor2_1
X_6032_ _3091_ _1193_ VSS VSS VDD VDD _3265_ sky130_fd_sc_hd__xnor2_1
X_6033_ _3368_ _1459_ net20 VSS VSS VDD VDD _1764_ sky130_fd_sc_hd__o21ai_0
X_6034_ _3365_ _1764_ VSS VSS VDD VDD _3269_ sky130_fd_sc_hd__xnor2_1
X_6035_ _3324_ _3372_ _3287_ VSS VSS VDD VDD _1765_ sky130_fd_sc_hd__nor3b_1
X_6036_ _3405_ _1765_ VSS VSS VDD VDD _1766_ sky130_fd_sc_hd__nor2_1
X_6037_ _3368_ _1766_ VSS VSS VDD VDD _3273_ sky130_fd_sc_hd__xor2_1
X_6038_ _1186_ _1458_ VSS VSS VDD VDD _1767_ sky130_fd_sc_hd__nor2_1
X_6039_ _3324_ _1767_ VSS VSS VDD VDD _3277_ sky130_fd_sc_hd__xor2_1
X_6040_ _3405_ _3287_ VSS VSS VDD VDD _1768_ sky130_fd_sc_hd__nor2_4
X_6041_ _3372_ _1768_ VSS VSS VDD VDD _3281_ sky130_fd_sc_hd__xor2_1
X_6042_ _3288_ _3380_ VSS VSS VDD VDD _1769_ sky130_fd_sc_hd__nand2_1
X_6043_ _3285_ _3380_ _1769_ VSS VSS VDD VDD _2167_ sky130_fd_sc_hd__o21ai_2
X_6044_ _3174_ _1145_ VSS VSS VDD VDD _3332_ sky130_fd_sc_hd__xnor2_1
X_6045_ _3178_ _1157_ VSS VSS VDD VDD _3338_ sky130_fd_sc_hd__xor2_1
X_6046_ _3186_ _1155_ VSS VSS VDD VDD _3346_ sky130_fd_sc_hd__xor2_1
X_6047_ _2163_ _3190_ VSS VSS VDD VDD _3350_ sky130_fd_sc_hd__xor2_1
X_6048_ _1462_ _1463_ VSS VSS VDD VDD _1770_ sky130_fd_sc_hd__nand2_4
X_6049_ _1460_ _1765_ VSS VSS VDD VDD _1771_ sky130_fd_sc_hd__nor2b_1
X_6050_ _3321_ _3361_ VSS VSS VDD VDD _1772_ sky130_fd_sc_hd__nor2_1
X_6051_ _1771_ _1772_ _1186_ VSS VSS VDD VDD _1773_ sky130_fd_sc_hd__a21oi_2
X_6052_ _1773_ _1770_ VSS VSS VDD VDD _3261_ sky130_fd_sc_hd__xor2_2
X_6053_ net7 _1461_ VSS VSS VDD VDD _1774_ sky130_fd_sc_hd__nand2_1
X_6054_ _3321_ _1774_ VSS VSS VDD VDD _3430_ sky130_fd_sc_hd__xnor2_1
X_6055_ _1319_ _1358_ VSS VSS VDD VDD _1775_ sky130_fd_sc_hd__nor2_1
X_6056_ _3649_ _1775_ VSS VSS VDD VDD _3444_ sky130_fd_sc_hd__xor2_1
X_6057_ _3280_ _1333_ VSS VSS VDD VDD _3448_ sky130_fd_sc_hd__xnor2_1
X_6058_ _3620_ _1356_ _3489_ VSS VSS VDD VDD _1776_ sky130_fd_sc_hd__o21ai_0
X_6059_ _3633_ _1776_ VSS VSS VDD VDD _3452_ sky130_fd_sc_hd__xnor2_1
X_6060_ _3432_ _1337_ VSS VSS VDD VDD _3473_ sky130_fd_sc_hd__xnor2_2
X_6061_ _1319_ _1360_ VSS VSS VDD VDD _1777_ sky130_fd_sc_hd__nor2_1
X_6062_ _3665_ _1777_ VSS VSS VDD VDD _3477_ sky130_fd_sc_hd__xor2_1
X_6063_ _1319_ _1359_ VSS VSS VDD VDD _1778_ sky130_fd_sc_hd__nor2_1
X_6064_ _3657_ _1778_ VSS VSS VDD VDD _3481_ sky130_fd_sc_hd__xor2_1
X_6065_ net214 VSS VSS VDD VDD _3485_ sky130_fd_sc_hd__inv_1
X_6066_ _3401_ VSS VSS VDD VDD _1779_ sky130_fd_sc_hd__inv_1
X_6067_ _3408_ VSS VSS VDD VDD _1780_ sky130_fd_sc_hd__inv_1
X_6068_ _3216_ _1184_ _3256_ _3215_ VSS VSS VDD VDD _1781_
+ sky130_fd_sc_hd__a211oi_1
X_6069_ net28 _3256_ VSS VSS VDD VDD _1782_ sky130_fd_sc_hd__nand2_1
X_6070_ _3420_ _1782_ VSS VSS VDD VDD _1783_ sky130_fd_sc_hd__nand2_1
X_6071_ _1781_ _1783_ _3419_ VSS VSS VDD VDD _1784_ sky130_fd_sc_hd__o21bai_1
X_6072_ _3417_ _1784_ _3416_ VSS VSS VDD VDD _1785_ sky130_fd_sc_hd__a21o_1
X_6073_ _3414_ _1785_ _3413_ VSS VSS VDD VDD _1786_ sky130_fd_sc_hd__a21o_1
X_6074_ _3411_ _1786_ _3410_ VSS VSS VDD VDD _1787_ sky130_fd_sc_hd__a21oi_1
X_6075_ _1780_ _1787_ _1297_ VSS VSS VDD VDD _1788_ sky130_fd_sc_hd__o21ai_0
X_6076_ _3404_ _1788_ _3403_ VSS VSS VDD VDD _1789_ sky130_fd_sc_hd__a21oi_1
X_6077_ _1779_ _1789_ _1296_ VSS VSS VDD VDD _1790_ sky130_fd_sc_hd__o21ai_0
X_6078_ _3398_ _1790_ _3397_ VSS VSS VDD VDD _1791_ sky130_fd_sc_hd__a21oi_1
X_6079_ _1791_ _3395_ VSS VSS VDD VDD _1792_ sky130_fd_sc_hd__nor2b_1
X_6080_ _3394_ _1792_ _3392_ VSS VSS VDD VDD _1793_ sky130_fd_sc_hd__o21ai_0
X_6081_ _3391_ _1793_ VSS VSS VDD VDD _1794_ sky130_fd_sc_hd__nand2b_1
X_6082_ _3389_ _1794_ VSS VSS VDD VDD _3496_ sky130_fd_sc_hd__xor2_1
X_6083_ _3392_ _1310_ VSS VSS VDD VDD _3499_ sky130_fd_sc_hd__xor2_1
X_6084_ _3414_ _1785_ VSS VSS VDD VDD _3521_ sky130_fd_sc_hd__xor2_1
X_6085_ _2179_ VSS VSS VDD VDD _2185_ sky130_fd_sc_hd__inv_1
X_6086_ _3461_ _3517_ VSS VSS VDD VDD _1795_ sky130_fd_sc_hd__nor2_2
X_6087_ _1795_ _3469_ VSS VSS VDD VDD _3529_ sky130_fd_sc_hd__xnor2_1
X_6088_ _1397_ _3487_ VSS VSS VDD VDD _1796_ sky130_fd_sc_hd__nor2_2
X_6089_ net137 _1796_ VSS VSS VDD VDD _3541_ sky130_fd_sc_hd__xnor2_1
X_6090_ _3489_ _1489_ VSS VSS VDD VDD _1797_ sky130_fd_sc_hd__nand2_1
X_6091_ _3537_ _1797_ VSS VSS VDD VDD _3545_ sky130_fd_sc_hd__xor2_1
X_6092_ _1431_ _1433_ VSS VSS VDD VDD _3553_ sky130_fd_sc_hd__nand2_1
X_6093_ _3548_ net155 VSS VSS VDD VDD _3557_ sky130_fd_sc_hd__xor2_1
X_6094_ _3517_ _1473_ VSS VSS VDD VDD _1798_ sky130_fd_sc_hd__nor2_1
X_6095_ _3554_ _1798_ VSS VSS VDD VDD _3561_ sky130_fd_sc_hd__xnor2_1
X_6096_ _3564_ net131 VSS VSS VDD VDD _3573_ sky130_fd_sc_hd__xor2_2
X_6097_ _3341_ _1284_ VSS VSS VDD VDD _3577_ sky130_fd_sc_hd__xor2_2
X_6098_ _3580_ _1497_ VSS VSS VDD VDD _3589_ sky130_fd_sc_hd__xor2_2
X_6099_ _3335_ _1271_ VSS VSS VDD VDD _3593_ sky130_fd_sc_hd__xor2_2
X_6100_ _3596_ net150 VSS VSS VDD VDD _3601_ sky130_fd_sc_hd__xor2_2
X_6101_ _3608_ _3489_ VSS VSS VDD VDD _1799_ sky130_fd_sc_hd__nand2_4
X_6102_ _1556_ _1799_ VSS VSS VDD VDD _3609_ sky130_fd_sc_hd__nand2_4
X_6103_ _1485_ _1486_ _1488_ _1504_ VSS VSS VDD VDD _3613_
+ sky130_fd_sc_hd__a31o_1
X_6104_ _3615_ _1397_ VSS VSS VDD VDD _1800_ sky130_fd_sc_hd__nor2_1
X_6105_ _1800_ _1507_ VSS VSS VDD VDD _3616_ sky130_fd_sc_hd__nor2_1
X_6106_ net213 net151 VSS VSS VDD VDD _3624_ sky130_fd_sc_hd__xor2_2
X_6107_ _3675_ _1555_ VSS VSS VDD VDD _1801_ sky130_fd_sc_hd__nand2_4
X_6108_ _1555_ net238 _1801_ VSS VSS VDD VDD _2192_ sky130_fd_sc_hd__o21ai_4
X_6109_ _2189_ _3455_ VSS VSS VDD VDD _3689_ sky130_fd_sc_hd__xor2_2
X_6110_ _3451_ _1345_ VSS VSS VDD VDD _3693_ sky130_fd_sc_hd__xnor2_2
X_6111_ _3674_ _1535_ VSS VSS VDD VDD _1802_ sky130_fd_sc_hd__nand2_1
X_6112_ _3653_ _1802_ _1555_ VSS VSS VDD VDD _1803_ sky130_fd_sc_hd__o21ai_0
X_6113_ _3661_ _1803_ VSS VSS VDD VDD _3697_ sky130_fd_sc_hd__xnor2_1
X_6114_ net153 _1525_ _1526_ net191 VSS VSS VDD VDD _1804_
+ sky130_fd_sc_hd__nand4bb_4
X_6115_ _3653_ _3661_ _1804_ _1555_ VSS VSS VDD VDD _1805_
+ sky130_fd_sc_hd__o31ai_2
X_6116_ _3669_ _1805_ VSS VSS VDD VDD _3701_ sky130_fd_sc_hd__xnor2_1
X_6117_ _3480_ _1367_ VSS VSS VDD VDD _3709_ sky130_fd_sc_hd__xnor2_2
X_6118_ net197 _1568_ _1398_ VSS VSS VDD VDD _1806_ sky130_fd_sc_hd__a21oi_2
X_6119_ _3715_ _1397_ _1806_ VSS VSS VDD VDD _3716_ sky130_fd_sc_hd__o21bai_1
X_6120_ _3439_ net161 VSS VSS VDD VDD _3720_ sky130_fd_sc_hd__xnor2_2
X_6121_ _3653_ _3661_ _3669_ _1804_ VSS VSS VDD VDD _1807_
+ sky130_fd_sc_hd__nor4_2
X_6122_ _1555_ net197 _1568_ VSS VSS VDD VDD _1808_ sky130_fd_sc_hd__nand3_1
X_6123_ _1807_ _1808_ _1806_ VSS VSS VDD VDD _3739_ sky130_fd_sc_hd__o21bai_1
X_6124_ net46 VSS VSS VDD VDD _2197_ sky130_fd_sc_hd__inv_1
X_6125_ net53 VSS VSS VDD VDD _2082_ sky130_fd_sc_hd__inv_1
X_6126_ net55 VSS VSS VDD VDD _2212_ sky130_fd_sc_hd__inv_1
X_6127_ net54 VSS VSS VDD VDD _2220_ sky130_fd_sc_hd__inv_1
X_6128_ _2232_ net16 VSS VSS VDD VDD _1809_ sky130_fd_sc_hd__nor2_1
X_6129_ _0031_ _1809_ VSS VSS VDD VDD _2228_ sky130_fd_sc_hd__xnor2_1
X_6130_ net57 VSS VSS VDD VDD _2242_ sky130_fd_sc_hd__inv_1
X_6131_ net56 VSS VSS VDD VDD _2250_ sky130_fd_sc_hd__inv_1
X_6132_ net58 VSS VSS VDD VDD _2258_ sky130_fd_sc_hd__inv_1
X_6133_ net23 _0792_ VSS VSS VDD VDD _1810_ sky130_fd_sc_hd__nand2_1
X_6134_ _2412_ _1810_ VSS VSS VDD VDD _2321_ sky130_fd_sc_hd__xnor2_1
X_6135_ _2330_ net23 VSS VSS VDD VDD _1811_ sky130_fd_sc_hd__nand2_1
X_6136_ _2328_ _2124_ _1811_ VSS VSS VDD VDD _2113_ sky130_fd_sc_hd__o21ai_1
X_6137_ _2196_ VSS VSS VDD VDD _2334_ sky130_fd_sc_hd__inv_1
X_6138_ net59 VSS VSS VDD VDD _2342_ sky130_fd_sc_hd__inv_1
X_6139_ net60 VSS VSS VDD VDD _2350_ sky130_fd_sc_hd__inv_1
X_6140_ net47 VSS VSS VDD VDD _2366_ sky130_fd_sc_hd__inv_1
X_6141_ net61 VSS VSS VDD VDD _2374_ sky130_fd_sc_hd__inv_1
X_6142_ _2502_ _0682_ _0688_ _0125_ VSS VSS VDD VDD _1812_
+ sky130_fd_sc_hd__o31ai_1
X_6143_ _2570_ _1812_ VSS VSS VDD VDD _2380_ sky130_fd_sc_hd__xnor2_1
X_6144_ net9 _1671_ VSS VSS VDD VDD _1813_ sky130_fd_sc_hd__nand2_1
X_6145_ _2622_ _1813_ VSS VSS VDD VDD _2482_ sky130_fd_sc_hd__xnor2_1
X_6146_ _2494_ _2665_ VSS VSS VDD VDD _1814_ sky130_fd_sc_hd__nor2_1
X_6147_ _2630_ _1814_ VSS VSS VDD VDD _2489_ sky130_fd_sc_hd__xor2_1
X_6148_ _2495_ net9 VSS VSS VDD VDD _1815_ sky130_fd_sc_hd__nand2_1
X_6149_ _2493_ net9 _1815_ VSS VSS VDD VDD _2128_ sky130_fd_sc_hd__o21ai_1
X_6150_ net49 VSS VSS VDD VDD _2512_ sky130_fd_sc_hd__inv_1
X_6151_ net48 VSS VSS VDD VDD _2520_ sky130_fd_sc_hd__inv_1
X_6152_ _2574_ _0682_ _0683_ _0688_ _0115_ VSS VSS VDD VDD
+ _1816_ sky130_fd_sc_hd__o41ai_1
X_6153_ _2566_ _1816_ VSS VSS VDD VDD _2526_ sky130_fd_sc_hd__xnor2_1
X_6154_ net51 VSS VSS VDD VDD _2544_ sky130_fd_sc_hd__inv_1
X_6155_ net50 VSS VSS VDD VDD _2552_ sky130_fd_sc_hd__inv_1
X_6156_ _0791_ _1638_ VSS VSS VDD VDD _1817_ sky130_fd_sc_hd__nand2_1
X_6157_ net23 _1817_ VSS VSS VDD VDD _1818_ sky130_fd_sc_hd__nand2_1
X_6158_ _2756_ _1818_ VSS VSS VDD VDD _2582_ sky130_fd_sc_hd__xnor2_1
X_6159_ _2119_ _2426_ VSS VSS VDD VDD _2642_ sky130_fd_sc_hd__xnor2_1
X_6160_ _2120_ VSS VSS VDD VDD _2133_ sky130_fd_sc_hd__inv_1
X_6161_ net12 _0954_ VSS VSS VDD VDD _1819_ sky130_fd_sc_hd__nand2_1
X_6162_ _2848_ _1819_ VSS VSS VDD VDD _2700_ sky130_fd_sc_hd__xnor2_1
X_6163_ net12 _0953_ VSS VSS VDD VDD _1820_ sky130_fd_sc_hd__nand2_1
X_6164_ _2818_ _1820_ VSS VSS VDD VDD _2707_ sky130_fd_sc_hd__xnor2_1
X_6165_ _2716_ net1 VSS VSS VDD VDD _1821_ sky130_fd_sc_hd__nor2_1
X_6166_ _2822_ _1821_ VSS VSS VDD VDD _2711_ sky130_fd_sc_hd__xor2_1
X_6167_ _2717_ _2852_ VSS VSS VDD VDD _1822_ sky130_fd_sc_hd__nand2_1
X_6168_ _2715_ _2852_ _1822_ VSS VSS VDD VDD _2137_ sky130_fd_sc_hd__o21ai_1
X_6169_ _2756_ _1817_ _0782_ net23 VSS VSS VDD VDD _1823_
+ sky130_fd_sc_hd__o211ai_1
X_6170_ net23 _0782_ _1823_ VSS VSS VDD VDD _2740_ sky130_fd_sc_hd__o21ai_0
X_6171_ _0571_ VSS VSS VDD VDD _2794_ sky130_fd_sc_hd__inv_1
X_6172_ _0592_ _0594_ VSS VSS VDD VDD _1824_ sky130_fd_sc_hd__nand2_1
X_6173_ _2640_ _1824_ VSS VSS VDD VDD _1825_ sky130_fd_sc_hd__nor2_1
X_6174_ _0595_ _1825_ VSS VSS VDD VDD _2834_ sky130_fd_sc_hd__nor2_1
X_6175_ _2134_ _2644_ VSS VSS VDD VDD _2838_ sky130_fd_sc_hd__xor2_1
X_6176_ _3057_ _1750_ VSS VSS VDD VDD _1826_ sky130_fd_sc_hd__nor2_1
X_6177_ _3034_ _1826_ VSS VSS VDD VDD _2900_ sky130_fd_sc_hd__xor2_1
X_6178_ _2996_ _1749_ _0972_ VSS VSS VDD VDD _1827_ sky130_fd_sc_hd__o21ai_0
X_6179_ _2992_ _1827_ VSS VSS VDD VDD _2907_ sky130_fd_sc_hd__xnor2_1
X_6180_ net26 _1101_ VSS VSS VDD VDD _1828_ sky130_fd_sc_hd__nand2_1
X_6181_ _2996_ _1828_ VSS VSS VDD VDD _2911_ sky130_fd_sc_hd__xnor2_1
X_6182_ _2920_ _3057_ VSS VSS VDD VDD _1829_ sky130_fd_sc_hd__nor2_1
X_6183_ _3000_ _1829_ VSS VSS VDD VDD _2915_ sky130_fd_sc_hd__xor2_1
X_6184_ _2921_ net26 VSS VSS VDD VDD _1830_ sky130_fd_sc_hd__nand2_1
X_6185_ _2919_ _3038_ _1830_ VSS VSS VDD VDD _2147_ sky130_fd_sc_hd__o21ai_1
X_6186_ _0843_ _0845_ VSS VSS VDD VDD _1831_ sky130_fd_sc_hd__nand2_1
X_6187_ _2832_ _1831_ VSS VSS VDD VDD _1832_ sky130_fd_sc_hd__nor2_1
X_6188_ _0846_ _1832_ VSS VSS VDD VDD _3012_ sky130_fd_sc_hd__nor2_1
X_6189_ _0828_ _0830_ VSS VSS VDD VDD _1833_ sky130_fd_sc_hd__nand2_1
X_6190_ _2836_ _1833_ VSS VSS VDD VDD _1834_ sky130_fd_sc_hd__nor2_1
X_6191_ _0831_ _1834_ VSS VSS VDD VDD _3016_ sky130_fd_sc_hd__nor2_1
X_6192_ _2840_ _2143_ VSS VSS VDD VDD _3020_ sky130_fd_sc_hd__xnor2_1
X_6193_ _3159_ _3209_ VSS VSS VDD VDD _1835_ sky130_fd_sc_hd__nor2_1
X_6194_ _1235_ _1835_ _1049_ VSS VSS VDD VDD _1836_ sky130_fd_sc_hd__a21oi_1
X_6195_ _3205_ _1836_ VSS VSS VDD VDD _3093_ sky130_fd_sc_hd__xor2_1
X_6196_ _3209_ _1746_ VSS VSS VDD VDD _1837_ sky130_fd_sc_hd__nor2b_1
X_6197_ _3235_ _1837_ VSS VSS VDD VDD _1838_ sky130_fd_sc_hd__nor2_1
X_6198_ _3159_ _1838_ VSS VSS VDD VDD _3097_ sky130_fd_sc_hd__xor2_1
X_6199_ _1049_ _1235_ VSS VSS VDD VDD _1839_ sky130_fd_sc_hd__nor2_1
X_6200_ _3209_ _1839_ VSS VSS VDD VDD _3101_ sky130_fd_sc_hd__xor2_1
X_6201_ _3110_ _3235_ VSS VSS VDD VDD _1840_ sky130_fd_sc_hd__nor2_1
X_6202_ _3163_ _1840_ VSS VSS VDD VDD _3105_ sky130_fd_sc_hd__xor2_1
X_6203_ _3111_ _3213_ VSS VSS VDD VDD _1841_ sky130_fd_sc_hd__nand2_1
X_6204_ _3108_ _3213_ _1841_ VSS VSS VDD VDD _2157_ sky130_fd_sc_hd__o21ai_1
X_6205_ _3010_ _0996_ VSS VSS VDD VDD _3176_ sky130_fd_sc_hd__xor2_1
X_6206_ _3014_ _1010_ VSS VSS VDD VDD _3180_ sky130_fd_sc_hd__xor2_1
X_6207_ _2152_ _3022_ VSS VSS VDD VDD _3188_ sky130_fd_sc_hd__xnor2_1
X_6208_ _3040_ _3043_ VSS VSS VDD VDD _1842_ sky130_fd_sc_hd__nor2b_1
X_6209_ _3040_ VSS VSS VDD VDD _1843_ sky130_fd_sc_hd__inv_1
X_6210_ _1843_ _3042_ _3045_ VSS VSS VDD VDD _1844_ sky130_fd_sc_hd__nor3_1
X_6211_ _3067_ _1762_ _3065_ VSS VSS VDD VDD _1845_ sky130_fd_sc_hd__o21ai_0
X_6212_ _1031_ _1845_ _3062_ VSS VSS VDD VDD _1846_ sky130_fd_sc_hd__a21boi_0
X_6213_ _3061_ _1846_ _3059_ VSS VSS VDD VDD _1847_ sky130_fd_sc_hd__o21ai_0
X_6214_ _1030_ _1847_ _3055_ VSS VSS VDD VDD _1848_ sky130_fd_sc_hd__a21boi_0
X_6215_ _3054_ _1848_ _3052_ VSS VSS VDD VDD _1849_ sky130_fd_sc_hd__o21ai_0
X_6216_ _1029_ _1849_ _3049_ VSS VSS VDD VDD _1850_ sky130_fd_sc_hd__a21boi_0
X_6217_ _3048_ _1850_ _3046_ VSS VSS VDD VDD _1851_ sky130_fd_sc_hd__o21ai_0
X_6218_ _1842_ _1844_ _1851_ VSS VSS VDD VDD _1852_ sky130_fd_sc_hd__mux2i_1
X_6219_ _1843_ _3043_ _3042_ VSS VSS VDD VDD _1853_ sky130_fd_sc_hd__nor3_1
X_6220_ _1843_ _3042_ _3045_ _1842_ _1853_ VSS VSS VDD VDD
+ _1854_ sky130_fd_sc_hd__a221oi_1
X_6221_ _1852_ _1854_ VSS VSS VDD VDD _3214_ sky130_fd_sc_hd__nand2_1
X_6222_ _1028_ _1045_ VSS VSS VDD VDD _1855_ sky130_fd_sc_hd__nand2_1
X_6223_ _3043_ _1855_ VSS VSS VDD VDD _1856_ sky130_fd_sc_hd__nor2_1
X_6224_ _1046_ _1856_ VSS VSS VDD VDD _3217_ sky130_fd_sc_hd__nor2_1
X_6225_ _3048_ _1850_ VSS VSS VDD VDD _1857_ sky130_fd_sc_hd__nor2_1
X_6226_ _3046_ _1857_ VSS VSS VDD VDD _3220_ sky130_fd_sc_hd__xnor2_1
X_6227_ _1029_ _1043_ VSS VSS VDD VDD _1858_ sky130_fd_sc_hd__nand2_1
X_6228_ _3049_ _1858_ VSS VSS VDD VDD _1859_ sky130_fd_sc_hd__nor2_1
X_6229_ _1044_ _1859_ VSS VSS VDD VDD _3223_ sky130_fd_sc_hd__nor2_1
X_6230_ _3054_ _1848_ VSS VSS VDD VDD _1860_ sky130_fd_sc_hd__nor2_1
X_6231_ _3052_ _1860_ VSS VSS VDD VDD _3226_ sky130_fd_sc_hd__xnor2_1
X_6232_ _1030_ _1041_ VSS VSS VDD VDD _1861_ sky130_fd_sc_hd__nand2_1
X_6233_ _3055_ _1861_ VSS VSS VDD VDD _1862_ sky130_fd_sc_hd__nor2_1
X_6234_ _1042_ _1862_ VSS VSS VDD VDD _3229_ sky130_fd_sc_hd__nor2_1
X_6235_ _3061_ _1846_ VSS VSS VDD VDD _1863_ sky130_fd_sc_hd__nor2_1
X_6236_ _3059_ _1863_ VSS VSS VDD VDD _3232_ sky130_fd_sc_hd__xnor2_1
X_6237_ _1031_ _1039_ VSS VSS VDD VDD _1864_ sky130_fd_sc_hd__nand2_1
X_6238_ _3062_ _1864_ VSS VSS VDD VDD _1865_ sky130_fd_sc_hd__nor2_1
X_6239_ _1040_ _1865_ VSS VSS VDD VDD _3236_ sky130_fd_sc_hd__nor2_1
X_6240_ _1032_ _1037_ VSS VSS VDD VDD _1866_ sky130_fd_sc_hd__nand2_1
X_6241_ _3068_ _1866_ VSS VSS VDD VDD _1867_ sky130_fd_sc_hd__nor2_1
X_6242_ _1038_ _1867_ VSS VSS VDD VDD _3242_ sky130_fd_sc_hd__nor2_1
X_6243_ _3073_ _1760_ VSS VSS VDD VDD _1868_ sky130_fd_sc_hd__nor2_1
X_6244_ _3071_ _1868_ VSS VSS VDD VDD _3245_ sky130_fd_sc_hd__xnor2_1
X_6245_ _1033_ _1035_ VSS VSS VDD VDD _1869_ sky130_fd_sc_hd__nand2_1
X_6246_ _3074_ _1869_ VSS VSS VDD VDD _1870_ sky130_fd_sc_hd__nor2_1
X_6247_ _1036_ _1870_ VSS VSS VDD VDD _3248_ sky130_fd_sc_hd__nor2_1
X_6248_ _3077_ _1758_ VSS VSS VDD VDD _3251_ sky130_fd_sc_hd__xor2_1
X_6249_ _1238_ _1746_ net11 VSS VSS VDD VDD _1871_ sky130_fd_sc_hd__a21oi_1
X_6250_ _1234_ _1871_ VSS VSS VDD VDD _3258_ sky130_fd_sc_hd__xnor2_1
X_6251_ _1186_ _1771_ VSS VSS VDD VDD _1872_ sky130_fd_sc_hd__nor2_1
X_6252_ _3361_ _1872_ VSS VSS VDD VDD _3266_ sky130_fd_sc_hd__xor2_1
X_6253_ _3095_ _1062_ VSS VSS VDD VDD _3270_ sky130_fd_sc_hd__xnor2_1
X_6254_ _3099_ _1191_ VSS VSS VDD VDD _3274_ sky130_fd_sc_hd__xnor2_1
X_6255_ _3103_ _1060_ VSS VSS VDD VDD _3278_ sky130_fd_sc_hd__xnor2_1
X_6256_ _3107_ _2158_ VSS VSS VDD VDD _3282_ sky130_fd_sc_hd__xor2_1
X_6257_ _1231_ _1232_ VSS VSS VDD VDD _1873_ sky130_fd_sc_hd__or2_1
X_6258_ _1234_ _1238_ _1746_ net25 VSS VSS VDD VDD _1874_
+ sky130_fd_sc_hd__a31oi_2
X_6259_ _1873_ _1874_ _1233_ VSS VSS VDD VDD _3295_ sky130_fd_sc_hd__a21o_1
X_6260_ _1873_ _1874_ _1233_ VSS VSS VDD VDD _3303_ sky130_fd_sc_hd__a21o_1
X_6261_ _1873_ _1239_ VSS VSS VDD VDD _3307_ sky130_fd_sc_hd__xnor2_1
X_6262_ _1873_ _1874_ _1233_ VSS VSS VDD VDD _3299_ sky130_fd_sc_hd__a21o_1
X_6263_ _1233_ _1240_ VSS VSS VDD VDD _3317_ sky130_fd_sc_hd__or2_0
X_6264_ _3182_ _1143_ VSS VSS VDD VDD _3343_ sky130_fd_sc_hd__xnor2_1
X_6265_ _3247_ VSS VSS VDD VDD _1875_ sky130_fd_sc_hd__inv_1
X_6266_ _3253_ VSS VSS VDD VDD _1876_ sky130_fd_sc_hd__inv_1
X_6267_ net28 _3080_ VSS VSS VDD VDD _1877_ sky130_fd_sc_hd__nand2_1
X_6268_ _3039_ _3080_ _1047_ _1877_ VSS VSS VDD VDD _1878_
+ sky130_fd_sc_hd__o31a_1
X_6269_ _1876_ _1878_ _3252_ VSS VSS VDD VDD _1879_ sky130_fd_sc_hd__o21bai_1
X_6270_ _3250_ _1879_ _3249_ VSS VSS VDD VDD _1880_ sky130_fd_sc_hd__a21oi_1
X_6271_ _1875_ _1880_ _3246_ VSS VSS VDD VDD _1881_ sky130_fd_sc_hd__o21bai_1
X_6272_ _3244_ _1881_ _3243_ VSS VSS VDD VDD _1882_ sky130_fd_sc_hd__a21o_1
X_6273_ _3241_ _1882_ _3240_ VSS VSS VDD VDD _1883_ sky130_fd_sc_hd__a21oi_1
X_6274_ _1169_ _1883_ _3237_ VSS VSS VDD VDD _1884_ sky130_fd_sc_hd__o21bai_1
X_6275_ _3234_ _1884_ _3233_ VSS VSS VDD VDD _1885_ sky130_fd_sc_hd__a21oi_1
X_6276_ _1168_ _1885_ _3230_ VSS VSS VDD VDD _1886_ sky130_fd_sc_hd__o21bai_1
X_6277_ _3225_ _3227_ _3224_ VSS VSS VDD VDD _1887_ sky130_fd_sc_hd__a21o_1
X_6278_ _3225_ _3228_ _1886_ _1887_ VSS VSS VDD VDD _1888_
+ sky130_fd_sc_hd__a31o_1
X_6279_ _3222_ _1888_ _3221_ VSS VSS VDD VDD _1889_ sky130_fd_sc_hd__a21o_1
X_6280_ _3219_ _1889_ _3218_ VSS VSS VDD VDD _1890_ sky130_fd_sc_hd__a21oi_1
X_6281_ _3216_ _1890_ VSS VSS VDD VDD _3381_ sky130_fd_sc_hd__xnor2_1
X_6282_ _3219_ _1183_ VSS VSS VDD VDD _3384_ sky130_fd_sc_hd__xnor2_1
X_6283_ _3222_ _1888_ VSS VSS VDD VDD _3387_ sky130_fd_sc_hd__xor2_1
X_6284_ _3225_ _1181_ VSS VSS VDD VDD _3390_ sky130_fd_sc_hd__xnor2_1
X_6285_ _3228_ _1886_ VSS VSS VDD VDD _3393_ sky130_fd_sc_hd__xor2_1
X_6286_ _3231_ _1179_ VSS VSS VDD VDD _3396_ sky130_fd_sc_hd__xnor2_1
X_6287_ _3234_ _1884_ VSS VSS VDD VDD _3399_ sky130_fd_sc_hd__xor2_1
X_6288_ _3238_ _1177_ VSS VSS VDD VDD _3402_ sky130_fd_sc_hd__xnor2_1
X_6289_ _3241_ _1882_ VSS VSS VDD VDD _3406_ sky130_fd_sc_hd__xor2_1
X_6290_ _3244_ _1175_ VSS VSS VDD VDD _3409_ sky130_fd_sc_hd__xnor2_1
X_6291_ _3247_ _1880_ VSS VSS VDD VDD _3412_ sky130_fd_sc_hd__xnor2_1
X_6292_ _3250_ _1173_ VSS VSS VDD VDD _3415_ sky130_fd_sc_hd__xnor2_1
X_6293_ _3253_ _1878_ VSS VSS VDD VDD _3418_ sky130_fd_sc_hd__xnor2_1
X_6294_ net28 _3256_ VSS VSS VDD VDD _3421_ sky130_fd_sc_hd__xor2_1
X_6295_ _1464_ _1465_ VSS VSS VDD VDD _3425_ sky130_fd_sc_hd__nand2_1
X_6296_ _1431_ _1433_ VSS VSS VDD VDD _3434_ sky130_fd_sc_hd__nand2_1
X_6297_ _1431_ _1433_ VSS VSS VDD VDD _3437_ sky130_fd_sc_hd__nand2_1
X_6298_ _3276_ _1201_ VSS VSS VDD VDD _3445_ sky130_fd_sc_hd__xnor2_1
X_6299_ _1319_ _1357_ VSS VSS VDD VDD _1891_ sky130_fd_sc_hd__nor2_1
X_6300_ _3641_ _1891_ VSS VSS VDD VDD _3449_ sky130_fd_sc_hd__xor2_1
X_6301_ _2168_ _3284_ VSS VSS VDD VDD _3453_ sky130_fd_sc_hd__xor2_1
X_6302_ _3620_ _3489_ VSS VSS VDD VDD _1892_ sky130_fd_sc_hd__nand2_1
X_6303_ _1356_ _1892_ VSS VSS VDD VDD _2188_ sky130_fd_sc_hd__xnor2_1
X_6304_ _1773_ net8 _1770_ VSS VSS VDD VDD _3466_ sky130_fd_sc_hd__mux2_1
X_6305_ _1431_ _1433_ VSS VSS VDD VDD _3470_ sky130_fd_sc_hd__nand2_1
X_6306_ _3443_ _3517_ _1431_ VSS VSS VDD VDD _3474_ sky130_fd_sc_hd__o21ai_2
X_6307_ _3268_ _1203_ VSS VSS VDD VDD _3478_ sky130_fd_sc_hd__xnor2_1
X_6308_ _3272_ _1335_ VSS VSS VDD VDD _3482_ sky130_fd_sc_hd__xnor2_1
X_6309_ _3394_ _1792_ _3389_ _3392_ VSS VSS VDD VDD _1893_
+ sky130_fd_sc_hd__o211ai_1
X_6310_ _3389_ _3391_ VSS VSS VDD VDD _1894_ sky130_fd_sc_hd__nand2_1
X_6311_ _1312_ _1893_ _1894_ VSS VSS VDD VDD _1895_ sky130_fd_sc_hd__nand3_1
X_6312_ _3386_ _1895_ _3385_ VSS VSS VDD VDD _1896_ sky130_fd_sc_hd__a21oi_1
X_6313_ _3383_ _1896_ VSS VSS VDD VDD _3490_ sky130_fd_sc_hd__xnor2_1
X_6314_ _3386_ _1313_ VSS VSS VDD VDD _3493_ sky130_fd_sc_hd__xor2_1
X_6315_ _3395_ _1791_ VSS VSS VDD VDD _3502_ sky130_fd_sc_hd__xnor2_1
X_6316_ _3398_ _1308_ VSS VSS VDD VDD _3505_ sky130_fd_sc_hd__xor2_1
X_6317_ _3401_ _1789_ VSS VSS VDD VDD _3508_ sky130_fd_sc_hd__xnor2_1
X_6318_ _3404_ _1305_ VSS VSS VDD VDD _1897_ sky130_fd_sc_hd__nor2_1
X_6319_ _1306_ _1897_ VSS VSS VDD VDD _3511_ sky130_fd_sc_hd__nor2_1
X_6320_ _3408_ _1787_ VSS VSS VDD VDD _3514_ sky130_fd_sc_hd__xnor2_1
X_6321_ _3414_ _1301_ _3413_ _3411_ VSS VSS VDD VDD _1898_
+ sky130_fd_sc_hd__a211oi_1
X_6322_ _1303_ _1898_ VSS VSS VDD VDD _3518_ sky130_fd_sc_hd__nor2_1
X_6323_ _2172_ _3353_ VSS VSS VDD VDD _3530_ sky130_fd_sc_hd__xor2_2
X_6324_ _1464_ _1465_ VSS VSS VDD VDD _3534_ sky130_fd_sc_hd__nand2_1
X_6325_ _1431_ _1433_ VSS VSS VDD VDD _3538_ sky130_fd_sc_hd__nand2_1
X_6326_ _2178_ net133 VSS VSS VDD VDD _3542_ sky130_fd_sc_hd__xnor2_1
X_6327_ _3349_ _1282_ VSS VSS VDD VDD _3546_ sky130_fd_sc_hd__xor2_2
X_6328_ _1773_ net8 _1770_ VSS VSS VDD VDD _3550_ sky130_fd_sc_hd__mux2_1
X_6329_ _1398_ _1503_ VSS VSS VDD VDD _1899_ sky130_fd_sc_hd__and2_0
X_6330_ _3736_ _1899_ VSS VSS VDD VDD _3558_ sky130_fd_sc_hd__xnor2_1
X_6331_ _3345_ _1268_ VSS VSS VDD VDD _3562_ sky130_fd_sc_hd__xnor2_2
X_6332_ _1464_ _1465_ VSS VSS VDD VDD _3566_ sky130_fd_sc_hd__nand2_1
X_6333_ _1431_ _1433_ VSS VSS VDD VDD _3570_ sky130_fd_sc_hd__nand2_1
X_6334_ _3736_ _1527_ _1555_ VSS VSS VDD VDD _1900_ sky130_fd_sc_hd__o21ai_0
X_6335_ _3740_ _1900_ VSS VSS VDD VDD _3574_ sky130_fd_sc_hd__xor2_1
X_6336_ _3489_ _1490_ VSS VSS VDD VDD _1901_ sky130_fd_sc_hd__nand2_1
X_6337_ _3569_ _1901_ VSS VSS VDD VDD _3578_ sky130_fd_sc_hd__xor2_1
X_6338_ _1773_ net8 _1770_ VSS VSS VDD VDD _3582_ sky130_fd_sc_hd__mux2_1
X_6339_ _1431_ _1433_ VSS VSS VDD VDD _3586_ sky130_fd_sc_hd__nand2_1
X_6340_ _3736_ _3740_ _1503_ _1555_ VSS VSS VDD VDD _1902_
+ sky130_fd_sc_hd__o31ai_1
X_6341_ _3743_ _1902_ VSS VSS VDD VDD _3590_ sky130_fd_sc_hd__xor2_1
X_6342_ _3585_ _1475_ VSS VSS VDD VDD _3594_ sky130_fd_sc_hd__xnor2_1
X_6343_ _3600_ _1397_ VSS VSS VDD VDD _1903_ sky130_fd_sc_hd__nor2_1
X_6344_ _1507_ _1903_ VSS VSS VDD VDD _3602_ sky130_fd_sc_hd__nor2_1
X_6345_ _3379_ _1286_ VSS VSS VDD VDD _3610_ sky130_fd_sc_hd__xnor2_1
X_6346_ _3612_ net222 VSS VSS VDD VDD _3617_ sky130_fd_sc_hd__xor2_2
X_6347_ _1505_ _3597_ _1507_ VSS VSS VDD VDD _3625_ sky130_fd_sc_hd__a21oi_1
X_6348_ _3674_ _1397_ VSS VSS VDD VDD _1904_ sky130_fd_sc_hd__nor2_2
X_6349_ _1904_ net190 VSS VSS VDD VDD _3690_ sky130_fd_sc_hd__xnor2_1
X_6350_ _1804_ _1555_ VSS VSS VDD VDD _1905_ sky130_fd_sc_hd__nand2_2
X_6351_ _3653_ _1905_ VSS VSS VDD VDD _3694_ sky130_fd_sc_hd__xnor2_1
X_6352_ _3447_ _1365_ VSS VSS VDD VDD _3698_ sky130_fd_sc_hd__xnor2_2
X_6353_ _3484_ _1347_ VSS VSS VDD VDD _3702_ sky130_fd_sc_hd__xnor2_2
X_6354_ _3653_ _3661_ _3669_ _1802_ VSS VSS VDD VDD _3706_
+ sky130_fd_sc_hd__or4_4
X_6355_ _3708_ _1397_ _1806_ VSS VSS VDD VDD _3710_ sky130_fd_sc_hd__o21bai_1
X_6356_ _3705_ _1807_ VSS VSS VDD VDD _3713_ sky130_fd_sc_hd__nand2_1
X_6357_ net116 _1349_ VSS VSS VDD VDD _3717_ sky130_fd_sc_hd__xnor2_1
X_6358_ _1398_ net197 _1568_ VSS VSS VDD VDD _1906_ sky130_fd_sc_hd__and3_1
X_6359_ _1906_ net201 _1806_ VSS VSS VDD VDD _3721_ sky130_fd_sc_hd__a21o_1
X_6360_ _1807_ _1808_ _1806_ VSS VSS VDD VDD _3725_ sky130_fd_sc_hd__o21bai_1
X_6361_ _1906_ net201 _1806_ VSS VSS VDD VDD _3729_ sky130_fd_sc_hd__a21o_1
X_6362_ _1807_ _1808_ _1806_ VSS VSS VDD VDD _3733_ sky130_fd_sc_hd__o21bai_1
X_6363_ _3707_ _1555_ _1806_ VSS VSS VDD VDD _3744_ sky130_fd_sc_hd__a21o_1
X_6364_ _3526_ VSS VSS VDD VDD net94 sky130_fd_sc_hd__inv_1
X_6365_ _3723_ VSS VSS VDD VDD _1907_ sky130_fd_sc_hd__inv_1
X_6366_ _3712_ VSS VSS VDD VDD _1908_ sky130_fd_sc_hd__inv_1
X_6367_ _3700_ VSS VSS VDD VDD _1909_ sky130_fd_sc_hd__inv_1
X_6368_ _3696_ VSS VSS VDD VDD _1910_ sky130_fd_sc_hd__inv_1
X_6369_ _3692_ _2193_ _3691_ VSS VSS VDD VDD _1911_ sky130_fd_sc_hd__a21oi_2
X_6370_ _1911_ _1910_ VSS VSS VDD VDD _1912_ sky130_fd_sc_hd__nor2_1
X_6371_ _1912_ _3695_ VSS VSS VDD VDD _1913_ sky130_fd_sc_hd__nor2_2
X_6372_ _1909_ _1913_ _3699_ VSS VSS VDD VDD _1914_ sky130_fd_sc_hd__o21bai_1
X_6373_ _1914_ _3704_ _3703_ VSS VSS VDD VDD _1915_ sky130_fd_sc_hd__a21oi_2
X_6374_ _1915_ _1908_ _3711_ VSS VSS VDD VDD _1916_ sky130_fd_sc_hd__o21bai_1
X_6375_ _1916_ _3719_ _3718_ VSS VSS VDD VDD _1917_ sky130_fd_sc_hd__a21oi_2
X_6376_ _1917_ _1907_ _3722_ VSS VSS VDD VDD _1918_ sky130_fd_sc_hd__o21bai_1
X_6377_ _3727_ _1918_ _3726_ VSS VSS VDD VDD _1919_ sky130_fd_sc_hd__a21oi_2
X_6378_ _3731_ _1919_ VSS VSS VDD VDD _1920_ sky130_fd_sc_hd__xnor2_2
X_6379_ _3686_ VSS VSS VDD VDD _1921_ sky130_fd_sc_hd__buf_2
X_6380_ _3719_ VSS VSS VDD VDD _1922_ sky130_fd_sc_hd__inv_1
X_6381_ _3704_ VSS VSS VDD VDD _1923_ sky130_fd_sc_hd__inv_1
X_6382_ _3677_ _2191_ _3676_ VSS VSS VDD VDD _1924_ sky130_fd_sc_hd__a21o_1
X_6383_ _1924_ _3692_ _3691_ VSS VSS VDD VDD _1925_ sky130_fd_sc_hd__a21oi_2
X_6384_ _1925_ _1910_ _3695_ VSS VSS VDD VDD _1926_ sky130_fd_sc_hd__o21bai_1
X_6385_ _1926_ _3700_ _3699_ VSS VSS VDD VDD _1927_ sky130_fd_sc_hd__a21oi_2
X_6386_ _1923_ _1927_ _3703_ VSS VSS VDD VDD _1928_ sky130_fd_sc_hd__o21bai_1
X_6387_ _3712_ _1928_ _3711_ VSS VSS VDD VDD _1929_ sky130_fd_sc_hd__a21oi_2
X_6388_ _1922_ _1929_ _3718_ VSS VSS VDD VDD _1930_ sky130_fd_sc_hd__o21bai_1
X_6389_ _3723_ _1930_ _3722_ VSS VSS VDD VDD _1931_ sky130_fd_sc_hd__a21oi_4
X_6390_ _3727_ _1931_ VSS VSS VDD VDD _1932_ sky130_fd_sc_hd__xnor2_2
X_6391_ net208 _3723_ VSS VSS VDD VDD _1933_ sky130_fd_sc_hd__xnor2_2
X_6392_ net221 _3719_ VSS VSS VDD VDD _1934_ sky130_fd_sc_hd__xnor2_2
X_6393_ _1915_ _3712_ VSS VSS VDD VDD _1935_ sky130_fd_sc_hd__xnor2_2
X_6394_ _1923_ net233 VSS VSS VDD VDD _1936_ sky130_fd_sc_hd__xnor2_4
X_6395_ _3700_ _1913_ VSS VSS VDD VDD _1937_ sky130_fd_sc_hd__xnor2_2
X_6396_ net228 net209 VSS VSS VDD VDD _1938_ sky130_fd_sc_hd__xnor2_4
X_6397_ _1937_ _1938_ VSS VSS VDD VDD _1939_ sky130_fd_sc_hd__nor2_2
X_6398_ _3692_ net129 VSS VSS VDD VDD _1940_ sky130_fd_sc_hd__xnor2_4
X_6399_ _3681_ _1936_ _1939_ _1940_ VSS VSS VDD VDD _1941_
+ sky130_fd_sc_hd__nand4_1
X_6400_ _1941_ net210 _1934_ VSS VSS VDD VDD _1942_ sky130_fd_sc_hd__or3_4
X_6401_ _1932_ _1942_ _1933_ VSS VSS VDD VDD _1943_ sky130_fd_sc_hd__or3_4
X_6402_ _1943_ _1921_ VSS VSS VDD VDD _1944_ sky130_fd_sc_hd__nand2_4
X_6403_ _1920_ _1944_ VSS VSS VDD VDD net79 sky130_fd_sc_hd__xnor2_2
X_6404_ _3727_ VSS VSS VDD VDD _1945_ sky130_fd_sc_hd__inv_1
X_6405_ _1945_ _1931_ _3726_ VSS VSS VDD VDD _1946_ sky130_fd_sc_hd__o21bai_1
X_6406_ _3731_ _1946_ _3730_ VSS VSS VDD VDD _1947_ sky130_fd_sc_hd__a21oi_2
X_6407_ _3735_ _1947_ VSS VSS VDD VDD _1948_ sky130_fd_sc_hd__xnor2_2
X_6408_ net78 _2194_ VSS VSS VDD VDD _1949_ sky130_fd_sc_hd__nor2_1
X_6409_ _1939_ _1940_ _1949_ VSS VSS VDD VDD _1950_ sky130_fd_sc_hd__nand3_2
X_6410_ _1950_ _1935_ _1936_ VSS VSS VDD VDD _1951_ sky130_fd_sc_hd__or3b_4
X_6411_ _1951_ _1934_ _1933_ VSS VSS VDD VDD _1952_ sky130_fd_sc_hd__or3_4
X_6412_ _1920_ _1952_ _1932_ VSS VSS VDD VDD _1953_ sky130_fd_sc_hd__or3_4
X_6413_ _1953_ _1921_ VSS VSS VDD VDD _1954_ sky130_fd_sc_hd__nand2_2
X_6414_ _1948_ _1954_ VSS VSS VDD VDD net80 sky130_fd_sc_hd__xnor2_1
X_6415_ _3731_ VSS VSS VDD VDD _1955_ sky130_fd_sc_hd__inv_1
X_6416_ _1919_ _1955_ _3730_ VSS VSS VDD VDD _1956_ sky130_fd_sc_hd__o21bai_1
X_6417_ _1956_ _3735_ _3734_ VSS VSS VDD VDD _1957_ sky130_fd_sc_hd__a21oi_2
X_6418_ _3738_ _1957_ VSS VSS VDD VDD _1958_ sky130_fd_sc_hd__xnor2_2
X_6419_ _1920_ _1943_ _1948_ VSS VSS VDD VDD _1959_ sky130_fd_sc_hd__or3_4
X_6420_ _1959_ _1921_ VSS VSS VDD VDD _1960_ sky130_fd_sc_hd__nand2_4
X_6421_ _1958_ _1960_ VSS VSS VDD VDD net81 sky130_fd_sc_hd__xnor2_2
X_6422_ _3735_ VSS VSS VDD VDD _1961_ sky130_fd_sc_hd__inv_1
X_6423_ _1961_ _1947_ _3734_ VSS VSS VDD VDD _1962_ sky130_fd_sc_hd__o21bai_1
X_6424_ _3738_ _1962_ _3737_ VSS VSS VDD VDD _1963_ sky130_fd_sc_hd__a21oi_1
X_6425_ _3742_ _1963_ VSS VSS VDD VDD _1964_ sky130_fd_sc_hd__xnor2_2
X_6426_ _1948_ _1958_ _1953_ _3686_ VSS VSS VDD VDD _1965_
+ sky130_fd_sc_hd__o31ai_4
X_6427_ _1964_ net119 VSS VSS VDD VDD net82 sky130_fd_sc_hd__xnor2_2
X_6428_ _3738_ VSS VSS VDD VDD _1966_ sky130_fd_sc_hd__inv_1
X_6429_ _1957_ _1966_ _3737_ VSS VSS VDD VDD _1967_ sky130_fd_sc_hd__o21bai_1
X_6430_ _1967_ _3742_ _3741_ VSS VSS VDD VDD _1968_ sky130_fd_sc_hd__a21oi_1
X_6431_ _1968_ _3746_ VSS VSS VDD VDD _1969_ sky130_fd_sc_hd__xnor2_1
X_6432_ _1958_ _1964_ _1959_ _3686_ VSS VSS VDD VDD _1970_
+ sky130_fd_sc_hd__o31ai_4
X_6433_ net196 _1970_ VSS VSS VDD VDD net83 sky130_fd_sc_hd__xnor2_1
X_6434_ _3588_ _1482_ _1484_ _3587_ VSS VSS VDD VDD _1971_
+ sky130_fd_sc_hd__a31oi_2
X_6435_ _1964_ _1969_ _3686_ VSS VSS VDD VDD _1972_ sky130_fd_sc_hd__o21ai_1
X_6436_ _1965_ _1972_ VSS VSS VDD VDD _1973_ sky130_fd_sc_hd__nand2_1
X_6437_ _3742_ VSS VSS VDD VDD _1974_ sky130_fd_sc_hd__inv_1
X_6438_ _1974_ _1963_ _3741_ VSS VSS VDD VDD _1975_ sky130_fd_sc_hd__o21bai_1
X_6439_ _3746_ _1975_ _3745_ VSS VSS VDD VDD _1976_ sky130_fd_sc_hd__a21oi_1
X_6440_ _1976_ _1973_ VSS VSS VDD VDD _1977_ sky130_fd_sc_hd__xor2_1
X_6441_ _1480_ _1971_ _1977_ VSS VSS VDD VDD _1978_ sky130_fd_sc_hd__xnor3_1
X_6442_ _3714_ _1397_ VSS VSS VDD VDD _1979_ sky130_fd_sc_hd__nor2_1
X_6443_ _1397_ net198 _1568_ _1979_ VSS VSS VDD VDD _1980_
+ sky130_fd_sc_hd__a31oi_2
X_6444_ _1978_ _1980_ VSS VSS VDD VDD net84 sky130_fd_sc_hd__xnor2_1
X_6445_ _1921_ _3682_ VSS VSS VDD VDD _1981_ sky130_fd_sc_hd__nand2_2
X_6446_ _3679_ _1921_ _1981_ VSS VSS VDD VDD net85 sky130_fd_sc_hd__o21ai_2
X_6447_ _3681_ _3686_ VSS VSS VDD VDD _1982_ sky130_fd_sc_hd__nor2b_2
X_6448_ _1982_ net236 VSS VSS VDD VDD net86 sky130_fd_sc_hd__xnor2_1
X_6449_ _1940_ _1949_ VSS VSS VDD VDD _1983_ sky130_fd_sc_hd__nand2_1
X_6450_ _1921_ _1983_ VSS VSS VDD VDD _1984_ sky130_fd_sc_hd__nand2_1
X_6451_ _1984_ _1938_ VSS VSS VDD VDD net87 sky130_fd_sc_hd__xnor2_1
X_6452_ _3681_ net235 VSS VSS VDD VDD _1985_ sky130_fd_sc_hd__nand2_1
X_6453_ _1985_ _1938_ _3686_ VSS VSS VDD VDD _1986_ sky130_fd_sc_hd__o21ai_2
X_6454_ _1986_ _1937_ VSS VSS VDD VDD net88 sky130_fd_sc_hd__xnor2_1
X_6455_ _1950_ _3686_ VSS VSS VDD VDD _1987_ sky130_fd_sc_hd__nand2_1
X_6456_ _1987_ net229 VSS VSS VDD VDD net89 sky130_fd_sc_hd__xor2_1
X_6457_ _1921_ _1941_ VSS VSS VDD VDD _1988_ sky130_fd_sc_hd__nand2_1
X_6458_ _1988_ net210 VSS VSS VDD VDD net90 sky130_fd_sc_hd__xnor2_2
X_6459_ _1951_ _1921_ VSS VSS VDD VDD _1989_ sky130_fd_sc_hd__nand2_2
X_6460_ _1934_ _1989_ VSS VSS VDD VDD net91 sky130_fd_sc_hd__xnor2_1
X_6461_ _1942_ _1921_ VSS VSS VDD VDD _1990_ sky130_fd_sc_hd__nand2_2
X_6462_ _1933_ _1990_ VSS VSS VDD VDD net92 sky130_fd_sc_hd__xnor2_1
X_6463_ _1952_ _1921_ VSS VSS VDD VDD _1991_ sky130_fd_sc_hd__nand2_2
X_6464_ _1932_ _1991_ VSS VSS VDD VDD net93 sky130_fd_sc_hd__xnor2_1
X_6465_ _2183_ _3544_ VSS VSS VDD VDD _1992_ sky130_fd_sc_hd__nor2b_1
X_6466_ _3543_ _1992_ _3560_ VSS VSS VDD VDD _1993_ sky130_fd_sc_hd__o21ai_1
X_6467_ _3559_ _1993_ VSS VSS VDD VDD _1994_ sky130_fd_sc_hd__nand2b_1
X_6468_ _3576_ _1994_ _3575_ VSS VSS VDD VDD _1995_ sky130_fd_sc_hd__a21o_1
X_6469_ _3592_ _1995_ _3591_ VSS VSS VDD VDD _1996_ sky130_fd_sc_hd__a21o_1
X_6470_ _3604_ _1996_ _3603_ VSS VSS VDD VDD _1997_ sky130_fd_sc_hd__a21o_1
X_6471_ _1997_ _3619_ _3618_ VSS VSS VDD VDD _1998_ sky130_fd_sc_hd__a21o_1
X_6472_ _3627_ _1998_ _3626_ VSS VSS VDD VDD _1999_ sky130_fd_sc_hd__a21o_1
X_6473_ _1999_ _3631_ _3630_ VSS VSS VDD VDD _2000_ sky130_fd_sc_hd__a21oi_2
X_6474_ _3639_ net120 VSS VSS VDD VDD _2001_ sky130_fd_sc_hd__xnor2_4
X_6475_ _3684_ _3685_ VSS VSS VDD VDD _2002_ sky130_fd_sc_hd__nor2_1
X_6476_ _2002_ VSS VSS VDD VDD _2003_ sky130_fd_sc_hd__clkbuf_2
X_6477_ _2181_ _3525_ VSS VSS VDD VDD _2004_ sky130_fd_sc_hd__nor2b_1
X_6478_ _3524_ _2004_ _3544_ VSS VSS VDD VDD _2005_ sky130_fd_sc_hd__o21ai_1
X_6479_ _3543_ _2005_ VSS VSS VDD VDD _2006_ sky130_fd_sc_hd__nand2b_1
X_6480_ _3560_ _2006_ _3559_ VSS VSS VDD VDD _2007_ sky130_fd_sc_hd__a21o_1
X_6481_ _3576_ _2007_ _3575_ VSS VSS VDD VDD _2008_ sky130_fd_sc_hd__a21oi_2
X_6482_ _2008_ _3592_ VSS VSS VDD VDD _2009_ sky130_fd_sc_hd__nor2b_1
X_6483_ _3591_ _2009_ _3604_ VSS VSS VDD VDD _2010_ sky130_fd_sc_hd__o21ai_1
X_6484_ _3603_ _2010_ VSS VSS VDD VDD _2011_ sky130_fd_sc_hd__nand2b_1
X_6485_ _3619_ _2011_ _3618_ VSS VSS VDD VDD _2012_ sky130_fd_sc_hd__a21o_1
X_6486_ _2012_ _3627_ _3626_ VSS VSS VDD VDD _2013_ sky130_fd_sc_hd__a21o_1
X_6487_ _3631_ _2013_ VSS VSS VDD VDD _2014_ sky130_fd_sc_hd__xor2_2
X_6488_ _3627_ _1998_ VSS VSS VDD VDD _2015_ sky130_fd_sc_hd__xor2_1
X_6489_ _3619_ _2011_ VSS VSS VDD VDD _2016_ sky130_fd_sc_hd__xor2_1
X_6490_ _3604_ _1996_ VSS VSS VDD VDD _2017_ sky130_fd_sc_hd__xor2_1
X_6491_ _3592_ _2008_ VSS VSS VDD VDD _2018_ sky130_fd_sc_hd__xnor2_2
X_6492_ _3576_ net142 VSS VSS VDD VDD _2019_ sky130_fd_sc_hd__xor2_4
X_6493_ net152 net173 VSS VSS VDD VDD _2020_ sky130_fd_sc_hd__xor2_4
X_6494_ net144 net240 VSS VSS VDD VDD _2021_ sky130_fd_sc_hd__xor2_4
X_6495_ _2021_ _3527_ VSS VSS VDD VDD _2022_ sky130_fd_sc_hd__nand2_1
X_6496_ _2022_ _2019_ _2020_ _2018_ VSS VSS VDD VDD _2023_
+ sky130_fd_sc_hd__or4_1
X_6497_ _2016_ _2017_ _2023_ VSS VSS VDD VDD _2024_ sky130_fd_sc_hd__or3_1
X_6498_ _2024_ _2015_ _2014_ VSS VSS VDD VDD _2025_ sky130_fd_sc_hd__or3_4
X_6499_ _2003_ _2025_ VSS VSS VDD VDD _2026_ sky130_fd_sc_hd__nand2_2
X_6500_ _2001_ _2026_ VSS VSS VDD VDD net95 sky130_fd_sc_hd__xnor2_1
X_6501_ _3639_ VSS VSS VDD VDD _2027_ sky130_fd_sc_hd__inv_1
X_6502_ _2013_ _3631_ _3630_ VSS VSS VDD VDD _2028_ sky130_fd_sc_hd__a21oi_2
X_6503_ _2028_ _2027_ _3638_ VSS VSS VDD VDD _2029_ sky130_fd_sc_hd__o21bai_4
X_6504_ _2029_ _3647_ VSS VSS VDD VDD _2030_ sky130_fd_sc_hd__xor2_4
X_6505_ _2019_ _2020_ VSS VSS VDD VDD _2031_ sky130_fd_sc_hd__nor2_1
X_6506_ _2031_ _3526_ _2184_ _2021_ VSS VSS VDD VDD _2032_
+ sky130_fd_sc_hd__nand4_1
X_6507_ _2017_ _2018_ _2032_ VSS VSS VDD VDD _2033_ sky130_fd_sc_hd__or3_1
X_6508_ _2015_ _2016_ _2033_ VSS VSS VDD VDD _2034_ sky130_fd_sc_hd__or3_4
X_6509_ _2001_ _2014_ _2034_ _2003_ VSS VSS VDD VDD _2035_
+ sky130_fd_sc_hd__o31ai_4
X_6510_ _2035_ _2030_ VSS VSS VDD VDD net96 sky130_fd_sc_hd__xnor2_2
X_6511_ _2027_ _2000_ _3638_ VSS VSS VDD VDD _2036_ sky130_fd_sc_hd__o21bai_1
X_6512_ _2036_ _3647_ _3646_ VSS VSS VDD VDD _2037_ sky130_fd_sc_hd__a21o_1
X_6513_ _3655_ _2037_ VSS VSS VDD VDD _2038_ sky130_fd_sc_hd__xor2_2
X_6514_ _2001_ _2025_ _2030_ _2003_ VSS VSS VDD VDD _2039_
+ sky130_fd_sc_hd__o31ai_2
X_6515_ _2038_ _2039_ VSS VSS VDD VDD net97 sky130_fd_sc_hd__xnor2_1
X_6516_ _3647_ _2029_ _3646_ VSS VSS VDD VDD _2040_ sky130_fd_sc_hd__a21o_1
X_6517_ _2040_ _3655_ _3654_ VSS VSS VDD VDD _2041_ sky130_fd_sc_hd__a21oi_2
X_6518_ _3663_ _2041_ VSS VSS VDD VDD _2042_ sky130_fd_sc_hd__xnor2_2
X_6519_ _2001_ _2014_ _2034_ _2038_ VSS VSS VDD VDD _2043_
+ sky130_fd_sc_hd__or4_4
X_6520_ _2043_ _2030_ _2002_ VSS VSS VDD VDD _2044_ sky130_fd_sc_hd__o21ai_4
X_6521_ _2042_ _2044_ VSS VSS VDD VDD net98 sky130_fd_sc_hd__xnor2_1
X_6522_ _3663_ VSS VSS VDD VDD _2045_ sky130_fd_sc_hd__inv_1
X_6523_ _3655_ _2037_ _3654_ VSS VSS VDD VDD _2046_ sky130_fd_sc_hd__a21oi_1
X_6524_ _2045_ _2046_ VSS VSS VDD VDD _2047_ sky130_fd_sc_hd__nor2_1
X_6525_ _3662_ _2047_ VSS VSS VDD VDD _2048_ sky130_fd_sc_hd__nor2_1
X_6526_ _3671_ _2048_ VSS VSS VDD VDD _2049_ sky130_fd_sc_hd__xnor2_1
X_6527_ _2001_ _2025_ _2030_ _2038_ VSS VSS VDD VDD _2050_
+ sky130_fd_sc_hd__or4_1
X_6528_ _2042_ _2050_ _2003_ VSS VSS VDD VDD _2051_ sky130_fd_sc_hd__o21ai_2
X_6529_ _2051_ _2049_ VSS VSS VDD VDD net99 sky130_fd_sc_hd__xnor2_1
X_6530_ _2045_ _2041_ _3662_ VSS VSS VDD VDD _2052_ sky130_fd_sc_hd__o21bai_1
X_6531_ _3671_ _2052_ _3670_ VSS VSS VDD VDD _2053_ sky130_fd_sc_hd__a21oi_1
X_6532_ _2042_ _2049_ _2002_ VSS VSS VDD VDD _2054_ sky130_fd_sc_hd__o21ai_1
X_6533_ _2044_ _2054_ VSS VSS VDD VDD _2055_ sky130_fd_sc_hd__nand2_2
X_6534_ _2055_ _2053_ VSS VSS VDD VDD _2056_ sky130_fd_sc_hd__xnor2_2
X_6535_ _3587_ _1398_ VSS VSS VDD VDD _2057_ sky130_fd_sc_hd__nor2_1
X_6536_ _1480_ _2057_ VSS VSS VDD VDD _2058_ sky130_fd_sc_hd__nand2_1
X_6537_ _3571_ _1447_ _2058_ VSS VSS VDD VDD _2059_ sky130_fd_sc_hd__nor3_1
X_6538_ _3588_ _1396_ VSS VSS VDD VDD _2060_ sky130_fd_sc_hd__nand2_1
X_6539_ _1480_ _1483_ _2060_ _1482_ VSS VSS VDD VDD _2061_
+ sky130_fd_sc_hd__nor4b_1
X_6540_ _3587_ _1396_ VSS VSS VDD VDD _2062_ sky130_fd_sc_hd__nand2_1
X_6541_ _3588_ _3587_ VSS VSS VDD VDD _2063_ sky130_fd_sc_hd__nor2_1
X_6542_ _1396_ _1480_ _2063_ VSS VSS VDD VDD _2064_ sky130_fd_sc_hd__nand3_1
X_6543_ _3614_ _1398_ VSS VSS VDD VDD _2065_ sky130_fd_sc_hd__nand2_1
X_6544_ _1480_ _2062_ _2064_ _2065_ VSS VSS VDD VDD _2066_
+ sky130_fd_sc_hd__o211ai_1
X_6545_ _2059_ _2061_ _2066_ VSS VSS VDD VDD _2067_ sky130_fd_sc_hd__nor3_1
X_6546_ _3705_ _2067_ _2056_ VSS VSS VDD VDD net100 sky130_fd_sc_hd__xnor3_1
X_6547_ _3685_ net68 VSS VSS VDD VDD _2068_ sky130_fd_sc_hd__nand2b_1
X_6548_ _3528_ _2068_ VSS VSS VDD VDD _2069_ sky130_fd_sc_hd__nor2_2
X_6549_ _2184_ _2068_ _2069_ VSS VSS VDD VDD net101 sky130_fd_sc_hd__a21oi_1
X_6550_ _3527_ _2068_ VSS VSS VDD VDD _2070_ sky130_fd_sc_hd__nor2_1
X_6551_ net242 _2070_ VSS VSS VDD VDD net102 sky130_fd_sc_hd__xnor2_1
X_6552_ net241 _3526_ _2184_ _2068_ VSS VSS VDD VDD _2071_
+ sky130_fd_sc_hd__a31oi_1
X_6553_ _2020_ _2071_ VSS VSS VDD VDD net103 sky130_fd_sc_hd__xor2_1
X_6554_ _2022_ _2020_ _2003_ VSS VSS VDD VDD _2072_ sky130_fd_sc_hd__o21ai_2
X_6555_ _2019_ _2072_ VSS VSS VDD VDD net104 sky130_fd_sc_hd__xnor2_1
X_6556_ _2003_ _2032_ VSS VSS VDD VDD _2073_ sky130_fd_sc_hd__nand2_1
X_6557_ net215 _2073_ VSS VSS VDD VDD net105 sky130_fd_sc_hd__xnor2_2
X_6558_ _2003_ _2023_ VSS VSS VDD VDD _2074_ sky130_fd_sc_hd__nand2_1
X_6559_ _2017_ _2074_ VSS VSS VDD VDD net106 sky130_fd_sc_hd__xnor2_1
X_6560_ _2003_ _2033_ VSS VSS VDD VDD _2075_ sky130_fd_sc_hd__nand2_2
X_6561_ _2016_ _2075_ VSS VSS VDD VDD net107 sky130_fd_sc_hd__xnor2_2
X_6562_ _2003_ _2024_ VSS VSS VDD VDD _2076_ sky130_fd_sc_hd__nand2_2
X_6563_ _2015_ _2076_ VSS VSS VDD VDD net108 sky130_fd_sc_hd__xnor2_2
X_6564_ _2003_ _2034_ VSS VSS VDD VDD _2077_ sky130_fd_sc_hd__nand2_2
X_6565_ _2014_ _2077_ VSS VSS VDD VDD net109 sky130_fd_sc_hd__xnor2_1
X_6566_ _2078_ net53 _2079_ VSS VSS VDD VDD _2080_ _2081_
+ sky130_fd_sc_hd__fa_4
X_6567_ _2078_ _2082_ _2083_ VSS VSS VDD VDD _2084_ _2085_
+ sky130_fd_sc_hd__fa_4
X_6568_ net37 _2082_ _2086_ VSS VSS VDD VDD _2087_ _2088_
+ sky130_fd_sc_hd__fa_2
X_6569_ _2090_ _2089_ _2091_ VSS VSS VDD VDD _2092_ _2093_
+ sky130_fd_sc_hd__fa_4
X_6570_ _2094_ _2095_ _2096_ VSS VSS VDD VDD _2097_ _2098_
+ sky130_fd_sc_hd__fa_2
X_6571_ _2099_ _2100_ _2101_ VSS VSS VDD VDD _2102_ _2103_
+ sky130_fd_sc_hd__fa_1
X_6572_ _2106_ _2107_ net5 VSS VSS VDD VDD _2108_ _2109_ sky130_fd_sc_hd__fa_1
X_6573_ _2112_ _2098_ _2113_ VSS VSS VDD VDD _2114_ _2115_
+ sky130_fd_sc_hd__fa_1
X_6574_ _2116_ _2117_ _2118_ VSS VSS VDD VDD _2119_ _2120_
+ sky130_fd_sc_hd__fa_1
X_6575_ _2122_ _2123_ _2124_ VSS VSS VDD VDD _2125_ _2126_
+ sky130_fd_sc_hd__fa_1
X_6576_ _2127_ _2115_ _2128_ VSS VSS VDD VDD _2129_ _2130_
+ sky130_fd_sc_hd__fa_1
X_6577_ _2131_ _2132_ _2133_ VSS VSS VDD VDD _2134_ _2135_
+ sky130_fd_sc_hd__fa_1
X_6578_ _2136_ _2130_ _2137_ VSS VSS VDD VDD _2138_ _2139_
+ sky130_fd_sc_hd__fa_1
X_6579_ _2140_ _2141_ _2142_ VSS VSS VDD VDD _2143_ _2144_
+ sky130_fd_sc_hd__fa_1
X_6580_ _2146_ _2139_ _2147_ VSS VSS VDD VDD _2148_ _2149_
+ sky130_fd_sc_hd__fa_4
X_6581_ _2144_ _2150_ _2151_ VSS VSS VDD VDD _2152_ _2153_
+ sky130_fd_sc_hd__fa_1
X_6582_ _2156_ _2149_ _2157_ VSS VSS VDD VDD _2158_ _2159_
+ sky130_fd_sc_hd__fa_1
X_6583_ _2160_ _2161_ _2162_ VSS VSS VDD VDD _2163_ _2164_
+ sky130_fd_sc_hd__fa_1
X_6584_ _2166_ _2167_ _2159_ VSS VSS VDD VDD _2168_ _2169_
+ sky130_fd_sc_hd__fa_2
X_6585_ _2164_ _2170_ _2171_ VSS VSS VDD VDD _2172_ _2173_
+ sky130_fd_sc_hd__fa_2
X_6586_ _2175_ _2176_ _2177_ VSS VSS VDD VDD _2178_ _2179_
+ sky130_fd_sc_hd__fa_2
X_6587_ _2179_ _2181_ _2182_ VSS VSS VDD VDD _2183_ _2184_
+ sky130_fd_sc_hd__fa_2
X_6588_ _2169_ _2187_ _2188_ VSS VSS VDD VDD _2189_ _2190_
+ sky130_fd_sc_hd__fa_2
X_6589_ _2192_ _2191_ _2190_ VSS VSS VDD VDD _2193_ _2194_
+ sky130_fd_sc_hd__fa_2
X_6590_ _2195_ net46 VSS VSS VDD VDD _2079_ _2196_ sky130_fd_sc_hd__ha_1
X_6591_ net30 _2197_ VSS VSS VDD VDD _2086_ _2198_ sky130_fd_sc_hd__ha_1
X_6592_ net30 net46 VSS VSS VDD VDD _2199_ _2200_ sky130_fd_sc_hd__ha_1
X_6593_ _2078_ net53 VSS VSS VDD VDD _2202_ _2201_ sky130_fd_sc_hd__ha_1
X_6594_ net37 _2082_ VSS VSS VDD VDD _2203_ _2204_ sky130_fd_sc_hd__ha_1
X_6595_ net37 net53 VSS VSS VDD VDD _2205_ _2206_ sky130_fd_sc_hd__ha_1
X_6596_ _2207_ _2196_ VSS VSS VDD VDD _2104_ _2208_ sky130_fd_sc_hd__ha_1
X_6597_ _2209_ net55 VSS VSS VDD VDD _2210_ _2211_ sky130_fd_sc_hd__ha_2
X_6598_ net39 _2212_ VSS VSS VDD VDD _2213_ _2214_ sky130_fd_sc_hd__ha_2
X_6599_ net39 net55 VSS VSS VDD VDD _2215_ _2216_ sky130_fd_sc_hd__ha_1
X_6600_ _2217_ net54 VSS VSS VDD VDD _2218_ _2219_ sky130_fd_sc_hd__ha_1
X_6601_ net38 _2220_ VSS VSS VDD VDD _2221_ _2222_ sky130_fd_sc_hd__ha_2
X_6602_ net38 net54 VSS VSS VDD VDD _2223_ _2224_ sky130_fd_sc_hd__ha_1
X_6603_ _2090_ net172 VSS VSS VDD VDD _2225_ _2226_ sky130_fd_sc_hd__ha_1
X_6604_ _2227_ _2228_ VSS VSS VDD VDD _2229_ _2230_ sky130_fd_sc_hd__ha_1
X_6605_ _2105_ _2231_ VSS VSS VDD VDD _2232_ _2233_ sky130_fd_sc_hd__ha_1
X_6606_ _2234_ _2207_ VSS VSS VDD VDD _2235_ _2236_ sky130_fd_sc_hd__ha_1
X_6607_ _2237_ _2208_ VSS VSS VDD VDD _2116_ _2238_ sky130_fd_sc_hd__ha_1
X_6608_ _2239_ net57 VSS VSS VDD VDD _2240_ _2241_ sky130_fd_sc_hd__ha_2
X_6609_ net41 _2242_ VSS VSS VDD VDD _2243_ _2244_ sky130_fd_sc_hd__ha_2
X_6610_ net41 net57 VSS VSS VDD VDD _2245_ _2246_ sky130_fd_sc_hd__ha_1
X_6611_ _2247_ net56 VSS VSS VDD VDD _2248_ _2249_ sky130_fd_sc_hd__ha_2
X_6612_ net40 _2250_ VSS VSS VDD VDD _2251_ _2252_ sky130_fd_sc_hd__ha_1
X_6613_ net40 net56 VSS VSS VDD VDD _2253_ _2254_ sky130_fd_sc_hd__ha_1
X_6614_ _2255_ net58 VSS VSS VDD VDD _2256_ _2257_ sky130_fd_sc_hd__ha_1
X_6615_ net42 _2258_ VSS VSS VDD VDD _2259_ _2260_ sky130_fd_sc_hd__ha_2
X_6616_ net42 net58 VSS VSS VDD VDD _2261_ _2262_ sky130_fd_sc_hd__ha_2
X_6617_ _2263_ _2264_ VSS VSS VDD VDD _2265_ _2266_ sky130_fd_sc_hd__ha_1
X_6618_ _2267_ _2268_ VSS VSS VDD VDD _2269_ _2270_ sky130_fd_sc_hd__ha_1
X_6619_ _2271_ _2272_ VSS VSS VDD VDD _2273_ _2274_ sky130_fd_sc_hd__ha_1
X_6620_ _2275_ _2276_ VSS VSS VDD VDD _2277_ _2278_ sky130_fd_sc_hd__ha_1
X_6621_ _2279_ _2096_ VSS VSS VDD VDD _2280_ _2281_ sky130_fd_sc_hd__ha_1
X_6622_ _2100_ _2101_ VSS VSS VDD VDD _2282_ _2283_ sky130_fd_sc_hd__ha_1
X_6623_ net5 _2284_ VSS VSS VDD VDD _2285_ _2286_ sky130_fd_sc_hd__ha_1
X_6624_ _2287_ _2111_ VSS VSS VDD VDD _2288_ _2289_ sky130_fd_sc_hd__ha_1
X_6625_ _2290_ net5 VSS VSS VDD VDD _2291_ _2292_ sky130_fd_sc_hd__ha_1
X_6626_ _2293_ _2092_ VSS VSS VDD VDD _2294_ _2295_ sky130_fd_sc_hd__ha_1
X_6627_ _2296_ _2111_ VSS VSS VDD VDD _2297_ _2298_ sky130_fd_sc_hd__ha_1
X_6628_ _2299_ _2092_ VSS VSS VDD VDD _2300_ _2301_ sky130_fd_sc_hd__ha_1
X_6629_ _2111_ _2302_ VSS VSS VDD VDD _2303_ _2304_ sky130_fd_sc_hd__ha_4
X_6630_ _2305_ _2111_ VSS VSS VDD VDD _2306_ _2307_ sky130_fd_sc_hd__ha_1
X_6631_ _2308_ _2111_ VSS VSS VDD VDD _2309_ _2310_ sky130_fd_sc_hd__ha_1
X_6632_ _2311_ _2092_ VSS VSS VDD VDD _2312_ _2313_ sky130_fd_sc_hd__ha_4
X_6633_ _2107_ _2092_ VSS VSS VDD VDD _2314_ _2315_ sky130_fd_sc_hd__ha_1
X_6634_ _2316_ _2317_ VSS VSS VDD VDD _2318_ _2319_ sky130_fd_sc_hd__ha_2
X_6635_ _2320_ _2321_ VSS VSS VDD VDD _2322_ _2323_ sky130_fd_sc_hd__ha_1
X_6636_ _2324_ _2237_ VSS VSS VDD VDD _2325_ _2326_ sky130_fd_sc_hd__ha_1
X_6637_ _2327_ _2328_ VSS VSS VDD VDD _2329_ _2330_ sky130_fd_sc_hd__ha_1
X_6638_ _2098_ _2113_ VSS VSS VDD VDD _2332_ _2333_ sky130_fd_sc_hd__ha_1
X_6639_ _2101_ _2334_ VSS VSS VDD VDD _2331_ _2335_ sky130_fd_sc_hd__ha_1
X_6640_ _2336_ _2238_ VSS VSS VDD VDD _2337_ _2338_ sky130_fd_sc_hd__ha_1
X_6641_ _2339_ net59 VSS VSS VDD VDD _2340_ _2341_ sky130_fd_sc_hd__ha_1
X_6642_ net43 _2342_ VSS VSS VDD VDD _2343_ _2344_ sky130_fd_sc_hd__ha_1
X_6643_ net43 net59 VSS VSS VDD VDD _2345_ _2346_ sky130_fd_sc_hd__ha_2
X_6644_ _2347_ net60 VSS VSS VDD VDD _2348_ _2349_ sky130_fd_sc_hd__ha_1
X_6645_ net44 _2350_ VSS VSS VDD VDD _2351_ _2352_ sky130_fd_sc_hd__ha_1
X_6646_ net44 net60 VSS VSS VDD VDD _2353_ _2354_ sky130_fd_sc_hd__ha_1
X_6647_ _2355_ _2356_ VSS VSS VDD VDD _2357_ _2358_ sky130_fd_sc_hd__ha_1
X_6648_ _2359_ _2360_ VSS VSS VDD VDD _2361_ _2362_ sky130_fd_sc_hd__ha_1
X_6649_ _2363_ net47 VSS VSS VDD VDD _2364_ _2365_ sky130_fd_sc_hd__ha_1
X_6650_ net31 _2366_ VSS VSS VDD VDD _2367_ _2368_ sky130_fd_sc_hd__ha_1
X_6651_ net31 net47 VSS VSS VDD VDD _2369_ _2370_ sky130_fd_sc_hd__ha_2
X_6652_ _2371_ net61 VSS VSS VDD VDD _2372_ _2373_ sky130_fd_sc_hd__ha_2
X_6653_ net45 _2374_ VSS VSS VDD VDD _2375_ _2376_ sky130_fd_sc_hd__ha_1
X_6654_ net45 net61 VSS VSS VDD VDD _2377_ _2378_ sky130_fd_sc_hd__ha_1
X_6655_ _2379_ _2380_ VSS VSS VDD VDD _2381_ _2382_ sky130_fd_sc_hd__ha_1
X_6656_ _2383_ _2384_ VSS VSS VDD VDD _2385_ _2386_ sky130_fd_sc_hd__ha_2
X_6657_ _2387_ _2388_ VSS VSS VDD VDD _2389_ _2390_ sky130_fd_sc_hd__ha_2
X_6658_ _2391_ _2392_ VSS VSS VDD VDD _2393_ _2394_ sky130_fd_sc_hd__ha_2
X_6659_ _2395_ _2396_ VSS VSS VDD VDD _2397_ _2398_ sky130_fd_sc_hd__ha_2
X_6660_ _2399_ _2400_ VSS VSS VDD VDD _2401_ _2402_ sky130_fd_sc_hd__ha_1
X_6661_ _2403_ _2404_ VSS VSS VDD VDD _2405_ _2406_ sky130_fd_sc_hd__ha_1
X_6662_ _2407_ _2408_ VSS VSS VDD VDD _2409_ _2410_ sky130_fd_sc_hd__ha_1
X_6663_ _2411_ _2412_ VSS VSS VDD VDD _2413_ _2414_ sky130_fd_sc_hd__ha_1
X_6664_ _2415_ _2416_ VSS VSS VDD VDD _2417_ _2418_ sky130_fd_sc_hd__ha_1
X_6665_ _2419_ _2420_ VSS VSS VDD VDD _2421_ _2422_ sky130_fd_sc_hd__ha_1
X_6666_ _2423_ _2424_ VSS VSS VDD VDD _2425_ _2426_ sky130_fd_sc_hd__ha_1
X_6667_ _2427_ _2428_ VSS VSS VDD VDD _2429_ _2430_ sky130_fd_sc_hd__ha_1
X_6668_ _2121_ _2103_ VSS VSS VDD VDD _2431_ _2432_ sky130_fd_sc_hd__ha_1
X_6669_ _2433_ _2124_ VSS VSS VDD VDD _2434_ _2435_ sky130_fd_sc_hd__ha_1
X_6670_ _2436_ _2124_ VSS VSS VDD VDD _2437_ _2438_ sky130_fd_sc_hd__ha_1
X_6671_ _2439_ _2124_ VSS VSS VDD VDD _2440_ _2441_ sky130_fd_sc_hd__ha_2
X_6672_ _2442_ net15 VSS VSS VDD VDD _2444_ _2445_ sky130_fd_sc_hd__ha_1
X_6673_ _2446_ _2124_ VSS VSS VDD VDD _2447_ _2448_ sky130_fd_sc_hd__ha_1
X_6674_ _2449_ _2124_ VSS VSS VDD VDD _2450_ _2451_ sky130_fd_sc_hd__ha_1
X_6675_ _2452_ net15 VSS VSS VDD VDD _2453_ _2454_ sky130_fd_sc_hd__ha_1
X_6676_ _2455_ net15 VSS VSS VDD VDD _2456_ _2457_ sky130_fd_sc_hd__ha_1
X_6677_ _2458_ _2443_ VSS VSS VDD VDD _2459_ _2460_ sky130_fd_sc_hd__ha_1
X_6678_ _2461_ _2443_ VSS VSS VDD VDD _2462_ _2463_ sky130_fd_sc_hd__ha_1
X_6679_ _2464_ _2443_ VSS VSS VDD VDD _2465_ _2466_ sky130_fd_sc_hd__ha_1
X_6680_ _2109_ _2443_ VSS VSS VDD VDD _2467_ _2468_ sky130_fd_sc_hd__ha_1
X_6681_ _2124_ _2110_ VSS VSS VDD VDD _2469_ _2470_ sky130_fd_sc_hd__ha_4
X_6682_ _2471_ _2122_ VSS VSS VDD VDD _2472_ _2473_ sky130_fd_sc_hd__ha_4
X_6683_ _2474_ _2443_ VSS VSS VDD VDD _2475_ _2476_ sky130_fd_sc_hd__ha_4
X_6684_ _2477_ _2478_ VSS VSS VDD VDD _2479_ _2480_ sky130_fd_sc_hd__ha_1
X_6685_ _2481_ _2482_ VSS VSS VDD VDD _2483_ _2484_ sky130_fd_sc_hd__ha_1
X_6686_ _2485_ _2336_ VSS VSS VDD VDD _2486_ _2487_ sky130_fd_sc_hd__ha_1
X_6687_ _2488_ _2489_ VSS VSS VDD VDD _2490_ _2491_ sky130_fd_sc_hd__ha_1
X_6688_ _2492_ _2493_ VSS VSS VDD VDD _2494_ _2495_ sky130_fd_sc_hd__ha_1
X_6689_ _2115_ _2128_ VSS VSS VDD VDD _2496_ _2497_ sky130_fd_sc_hd__ha_1
X_6690_ _2335_ _2424_ VSS VSS VDD VDD _2112_ _2498_ sky130_fd_sc_hd__ha_1
X_6691_ _2499_ _2338_ VSS VSS VDD VDD _2140_ _2500_ sky130_fd_sc_hd__ha_1
X_6692_ _2501_ _2502_ VSS VSS VDD VDD _2503_ _2504_ sky130_fd_sc_hd__ha_1
X_6693_ _2505_ _2506_ VSS VSS VDD VDD _2507_ _2508_ sky130_fd_sc_hd__ha_2
X_6694_ _2509_ net49 VSS VSS VDD VDD _2510_ _2511_ sky130_fd_sc_hd__ha_1
X_6695_ net33 _2512_ VSS VSS VDD VDD _2513_ _2514_ sky130_fd_sc_hd__ha_1
X_6696_ net33 net49 VSS VSS VDD VDD _2515_ _2516_ sky130_fd_sc_hd__ha_1
X_6697_ _2517_ net48 VSS VSS VDD VDD _2518_ _2519_ sky130_fd_sc_hd__ha_1
X_6698_ net32 _2520_ VSS VSS VDD VDD _2521_ _2522_ sky130_fd_sc_hd__ha_1
X_6699_ net32 net48 VSS VSS VDD VDD _2523_ _2524_ sky130_fd_sc_hd__ha_1
X_6700_ _2525_ _2526_ VSS VSS VDD VDD _2527_ _2528_ sky130_fd_sc_hd__ha_1
X_6701_ _2529_ _2530_ VSS VSS VDD VDD _2531_ _2532_ sky130_fd_sc_hd__ha_1
X_6702_ _2533_ _2534_ VSS VSS VDD VDD _2535_ _2536_ sky130_fd_sc_hd__ha_1
X_6703_ _2537_ _2538_ VSS VSS VDD VDD _2539_ _2540_ sky130_fd_sc_hd__ha_1
X_6704_ _2541_ net51 VSS VSS VDD VDD _2542_ _2543_ sky130_fd_sc_hd__ha_1
X_6705_ net35 _2544_ VSS VSS VDD VDD _2545_ _2546_ sky130_fd_sc_hd__ha_1
X_6706_ net35 net51 VSS VSS VDD VDD _2547_ _2548_ sky130_fd_sc_hd__ha_1
X_6707_ _2549_ net50 VSS VSS VDD VDD _2550_ _2551_ sky130_fd_sc_hd__ha_2
X_6708_ net34 _2552_ VSS VSS VDD VDD _2553_ _2554_ sky130_fd_sc_hd__ha_1
X_6709_ net34 net50 VSS VSS VDD VDD _2555_ _2556_ sky130_fd_sc_hd__ha_1
X_6710_ _2557_ _2558_ VSS VSS VDD VDD _2559_ _2560_ sky130_fd_sc_hd__ha_1
X_6711_ _2561_ _2562_ VSS VSS VDD VDD _2563_ _2564_ sky130_fd_sc_hd__ha_1
X_6712_ _2565_ _2566_ VSS VSS VDD VDD _2567_ _2568_ sky130_fd_sc_hd__ha_1
X_6713_ _2569_ _2570_ VSS VSS VDD VDD _2571_ _2572_ sky130_fd_sc_hd__ha_1
X_6714_ _2573_ _2574_ VSS VSS VDD VDD _2575_ _2576_ sky130_fd_sc_hd__ha_2
X_6715_ _2577_ _2578_ VSS VSS VDD VDD _2579_ _2580_ sky130_fd_sc_hd__ha_1
X_6716_ _2581_ _2582_ VSS VSS VDD VDD _2583_ _2584_ sky130_fd_sc_hd__ha_1
X_6717_ _2585_ _2586_ VSS VSS VDD VDD _2587_ _2588_ sky130_fd_sc_hd__ha_1
X_6718_ _2589_ _2590_ VSS VSS VDD VDD _2591_ _2592_ sky130_fd_sc_hd__ha_2
X_6719_ _2593_ _2594_ VSS VSS VDD VDD _2595_ _2596_ sky130_fd_sc_hd__ha_2
X_6720_ _2597_ _2598_ VSS VSS VDD VDD _2599_ _2600_ sky130_fd_sc_hd__ha_2
X_6721_ _2601_ _2602_ VSS VSS VDD VDD _2603_ _2604_ sky130_fd_sc_hd__ha_2
X_6722_ _2605_ _2606_ VSS VSS VDD VDD _2607_ _2608_ sky130_fd_sc_hd__ha_2
X_6723_ _2609_ _2610_ VSS VSS VDD VDD _2611_ _2612_ sky130_fd_sc_hd__ha_1
X_6724_ _2613_ _2614_ VSS VSS VDD VDD _2615_ _2616_ sky130_fd_sc_hd__ha_1
X_6725_ _2617_ _2618_ VSS VSS VDD VDD _2619_ _2620_ sky130_fd_sc_hd__ha_1
X_6726_ _2621_ _2622_ VSS VSS VDD VDD _2623_ _2624_ sky130_fd_sc_hd__ha_2
X_6727_ _2625_ _2626_ VSS VSS VDD VDD _2627_ _2628_ sky130_fd_sc_hd__ha_1
X_6728_ _2629_ _2630_ VSS VSS VDD VDD _2631_ _2632_ sky130_fd_sc_hd__ha_1
X_6729_ _2633_ _2634_ VSS VSS VDD VDD _2635_ _2636_ sky130_fd_sc_hd__ha_1
X_6730_ _2637_ _2638_ VSS VSS VDD VDD _2639_ _2640_ sky130_fd_sc_hd__ha_1
X_6731_ _2641_ _2642_ VSS VSS VDD VDD _2643_ _2644_ sky130_fd_sc_hd__ha_1
X_6732_ _2645_ _2646_ VSS VSS VDD VDD _2647_ _2648_ sky130_fd_sc_hd__ha_1
X_6733_ _2132_ _2133_ VSS VSS VDD VDD _2649_ _2650_ sky130_fd_sc_hd__ha_1
X_6734_ _2651_ net14 VSS VSS VDD VDD _2653_ _2654_ sky130_fd_sc_hd__ha_1
X_6735_ _2655_ net14 VSS VSS VDD VDD _2656_ _2657_ sky130_fd_sc_hd__ha_1
X_6736_ _2658_ net9 VSS VSS VDD VDD _2659_ _2660_ sky130_fd_sc_hd__ha_1
X_6737_ _2661_ net14 VSS VSS VDD VDD _2662_ _2663_ sky130_fd_sc_hd__ha_1
X_6738_ _2664_ _2665_ VSS VSS VDD VDD _2666_ _2667_ sky130_fd_sc_hd__ha_1
X_6739_ _2668_ net14 VSS VSS VDD VDD _2669_ _2670_ sky130_fd_sc_hd__ha_1
X_6740_ _2671_ _2665_ VSS VSS VDD VDD _2672_ _2673_ sky130_fd_sc_hd__ha_1
X_6741_ _2674_ net14 VSS VSS VDD VDD _2675_ _2676_ sky130_fd_sc_hd__ha_1
X_6742_ _2677_ _2652_ VSS VSS VDD VDD _2678_ _2679_ sky130_fd_sc_hd__ha_1
X_6743_ _2680_ _2652_ VSS VSS VDD VDD _2681_ _2682_ sky130_fd_sc_hd__ha_1
X_6744_ _2683_ _2665_ VSS VSS VDD VDD _2684_ _2685_ sky130_fd_sc_hd__ha_1
X_6745_ _2686_ _2652_ VSS VSS VDD VDD _2687_ _2688_ sky130_fd_sc_hd__ha_1
X_6746_ _2689_ _2652_ VSS VSS VDD VDD _2690_ _2691_ sky130_fd_sc_hd__ha_1
X_6747_ _2692_ _2652_ VSS VSS VDD VDD _2693_ _2694_ sky130_fd_sc_hd__ha_4
X_6748_ _2695_ _2696_ VSS VSS VDD VDD _2697_ _2698_ sky130_fd_sc_hd__ha_1
X_6749_ _2699_ _2700_ VSS VSS VDD VDD _2701_ _2702_ sky130_fd_sc_hd__ha_1
X_6750_ _2703_ _2499_ VSS VSS VDD VDD _2704_ _2705_ sky130_fd_sc_hd__ha_1
X_6751_ _2706_ _2707_ VSS VSS VDD VDD _2708_ _2709_ sky130_fd_sc_hd__ha_1
X_6752_ _2710_ _2711_ VSS VSS VDD VDD _2712_ _2713_ sky130_fd_sc_hd__ha_1
X_6753_ _2714_ _2715_ VSS VSS VDD VDD _2716_ _2717_ sky130_fd_sc_hd__ha_1
X_6754_ _2130_ _2137_ VSS VSS VDD VDD _2718_ _2719_ sky130_fd_sc_hd__ha_1
X_6755_ _2498_ _2638_ VSS VSS VDD VDD _2127_ _2720_ sky130_fd_sc_hd__ha_1
X_6756_ _2721_ _2500_ VSS VSS VDD VDD _2150_ _2722_ sky130_fd_sc_hd__ha_1
X_6757_ _2723_ _2724_ VSS VSS VDD VDD _2725_ _2726_ sky130_fd_sc_hd__ha_1
X_6758_ _2727_ _2728_ VSS VSS VDD VDD _2729_ _2730_ sky130_fd_sc_hd__ha_2
X_6759_ _2731_ _2732_ VSS VSS VDD VDD _2733_ _2734_ sky130_fd_sc_hd__ha_1
X_6760_ _2735_ _2736_ VSS VSS VDD VDD _2737_ _2738_ sky130_fd_sc_hd__ha_2
X_6761_ _2739_ _2740_ VSS VSS VDD VDD _2741_ _2742_ sky130_fd_sc_hd__ha_2
X_6762_ _2743_ _2744_ VSS VSS VDD VDD _2745_ _2746_ sky130_fd_sc_hd__ha_2
X_6763_ _2747_ _2748_ VSS VSS VDD VDD _2749_ _2750_ sky130_fd_sc_hd__ha_1
X_6764_ _2751_ _2752_ VSS VSS VDD VDD _2753_ _2754_ sky130_fd_sc_hd__ha_2
X_6765_ _2755_ _2756_ VSS VSS VDD VDD _2757_ _2758_ sky130_fd_sc_hd__ha_2
X_6766_ _2759_ _2760_ VSS VSS VDD VDD _2761_ _2762_ sky130_fd_sc_hd__ha_1
X_6767_ _2763_ _2764_ VSS VSS VDD VDD _2765_ _2766_ sky130_fd_sc_hd__ha_2
X_6768_ _2767_ _2768_ VSS VSS VDD VDD _2769_ _2770_ sky130_fd_sc_hd__ha_1
X_6769_ _2771_ _2772_ VSS VSS VDD VDD _2773_ _2774_ sky130_fd_sc_hd__ha_1
X_6770_ _2771_ _2772_ VSS VSS VDD VDD _2775_ _2776_ sky130_fd_sc_hd__ha_2
X_6771_ _2777_ _2778_ VSS VSS VDD VDD _2779_ _2780_ sky130_fd_sc_hd__ha_1
X_6772_ _2781_ _2782_ VSS VSS VDD VDD _2783_ _2784_ sky130_fd_sc_hd__ha_1
X_6773_ _2785_ _2786_ VSS VSS VDD VDD _2787_ _2788_ sky130_fd_sc_hd__ha_1
X_6774_ _2789_ _2790_ VSS VSS VDD VDD _2791_ _2792_ sky130_fd_sc_hd__ha_1
X_6775_ _2793_ _2794_ VSS VSS VDD VDD _2795_ _2796_ sky130_fd_sc_hd__ha_1
X_6776_ _2797_ _2798_ VSS VSS VDD VDD _2799_ _2800_ sky130_fd_sc_hd__ha_1
X_6777_ _2801_ _2802_ VSS VSS VDD VDD _2803_ _2804_ sky130_fd_sc_hd__ha_1
X_6778_ _2805_ _2806_ VSS VSS VDD VDD _2807_ _2808_ sky130_fd_sc_hd__ha_2
X_6779_ _2809_ _2810_ VSS VSS VDD VDD _2811_ _2812_ sky130_fd_sc_hd__ha_1
X_6780_ _2813_ _2814_ VSS VSS VDD VDD _2815_ _2816_ sky130_fd_sc_hd__ha_1
X_6781_ _2817_ _2818_ VSS VSS VDD VDD _2819_ _2820_ sky130_fd_sc_hd__ha_1
X_6782_ _2821_ _2822_ VSS VSS VDD VDD _2823_ _2824_ sky130_fd_sc_hd__ha_1
X_6783_ _2825_ _2826_ VSS VSS VDD VDD _2827_ _2828_ sky130_fd_sc_hd__ha_1
X_6784_ _2829_ _2830_ VSS VSS VDD VDD _2831_ _2832_ sky130_fd_sc_hd__ha_1
X_6785_ _2833_ _2834_ VSS VSS VDD VDD _2835_ _2836_ sky130_fd_sc_hd__ha_1
X_6786_ _2837_ _2838_ VSS VSS VDD VDD _2839_ _2840_ sky130_fd_sc_hd__ha_1
X_6787_ _2841_ _2842_ VSS VSS VDD VDD _2843_ _2844_ sky130_fd_sc_hd__ha_1
X_6788_ _2145_ _2135_ VSS VSS VDD VDD _2845_ _2846_ sky130_fd_sc_hd__ha_1
X_6789_ _2847_ _2848_ VSS VSS VDD VDD _2849_ _2850_ sky130_fd_sc_hd__ha_1
X_6790_ _2851_ net12 VSS VSS VDD VDD _2853_ _2854_ sky130_fd_sc_hd__ha_1
X_6791_ _2855_ net12 VSS VSS VDD VDD _2856_ _2857_ sky130_fd_sc_hd__ha_1
X_6792_ _2858_ _2852_ VSS VSS VDD VDD _2859_ _2860_ sky130_fd_sc_hd__ha_1
X_6793_ _2861_ _2852_ VSS VSS VDD VDD _2862_ _2863_ sky130_fd_sc_hd__ha_1
X_6794_ _2864_ _2852_ VSS VSS VDD VDD _2865_ _2866_ sky130_fd_sc_hd__ha_1
X_6795_ _2867_ _2868_ VSS VSS VDD VDD _2869_ _2870_ sky130_fd_sc_hd__ha_1
X_6796_ _2871_ _2852_ VSS VSS VDD VDD _2872_ _2873_ sky130_fd_sc_hd__ha_1
X_6797_ _2874_ _2868_ VSS VSS VDD VDD _2875_ _2876_ sky130_fd_sc_hd__ha_1
X_6798_ _2877_ _2852_ VSS VSS VDD VDD _2878_ _2879_ sky130_fd_sc_hd__ha_1
X_6799_ _2880_ _2852_ VSS VSS VDD VDD _2881_ _2882_ sky130_fd_sc_hd__ha_1
X_6800_ _2883_ _2852_ VSS VSS VDD VDD _2884_ _2885_ sky130_fd_sc_hd__ha_1
X_6801_ _2886_ _2868_ VSS VSS VDD VDD _2887_ _2888_ sky130_fd_sc_hd__ha_1
X_6802_ _2889_ _2852_ VSS VSS VDD VDD _2890_ _2891_ sky130_fd_sc_hd__ha_4
X_6803_ _2892_ _2868_ VSS VSS VDD VDD _2893_ _2894_ sky130_fd_sc_hd__ha_4
X_6804_ _2895_ _2896_ VSS VSS VDD VDD _2897_ _2898_ sky130_fd_sc_hd__ha_1
X_6805_ _2899_ _2900_ VSS VSS VDD VDD _2901_ _2902_ sky130_fd_sc_hd__ha_2
X_6806_ _2903_ _2721_ VSS VSS VDD VDD _2904_ _2905_ sky130_fd_sc_hd__ha_1
X_6807_ _2906_ _2907_ VSS VSS VDD VDD _2908_ _2909_ sky130_fd_sc_hd__ha_1
X_6808_ _2910_ _2911_ VSS VSS VDD VDD _2912_ _2913_ sky130_fd_sc_hd__ha_1
X_6809_ _2914_ _2915_ VSS VSS VDD VDD _2916_ _2917_ sky130_fd_sc_hd__ha_1
X_6810_ _2918_ _2919_ VSS VSS VDD VDD _2920_ _2921_ sky130_fd_sc_hd__ha_1
X_6811_ _2139_ _2147_ VSS VSS VDD VDD _2922_ _2923_ sky130_fd_sc_hd__ha_1
X_6812_ _2720_ _2830_ VSS VSS VDD VDD _2136_ _2924_ sky130_fd_sc_hd__ha_1
X_6813_ _2925_ _2722_ VSS VSS VDD VDD _2165_ _2926_ sky130_fd_sc_hd__ha_1
X_6814_ _2927_ _2928_ VSS VSS VDD VDD _2929_ _2930_ sky130_fd_sc_hd__ha_1
X_6815_ _2931_ _2932_ VSS VSS VDD VDD _2933_ _2934_ sky130_fd_sc_hd__ha_1
X_6816_ _2935_ _2936_ VSS VSS VDD VDD _2937_ _2938_ sky130_fd_sc_hd__ha_2
X_6817_ _2939_ _2940_ VSS VSS VDD VDD _2941_ _2942_ sky130_fd_sc_hd__ha_2
X_6818_ _2943_ _2944_ VSS VSS VDD VDD _2945_ _2946_ sky130_fd_sc_hd__ha_1
X_6819_ _2947_ _2948_ VSS VSS VDD VDD _2949_ _2950_ sky130_fd_sc_hd__ha_2
X_6820_ _2951_ _2952_ VSS VSS VDD VDD _2953_ _2954_ sky130_fd_sc_hd__ha_1
X_6821_ _2951_ _2952_ VSS VSS VDD VDD _2955_ _2956_ sky130_fd_sc_hd__ha_2
X_6822_ _2957_ _2958_ VSS VSS VDD VDD _2959_ _2960_ sky130_fd_sc_hd__ha_2
X_6823_ _2961_ _2962_ VSS VSS VDD VDD _2963_ _2964_ sky130_fd_sc_hd__ha_1
X_6824_ _2965_ _2966_ VSS VSS VDD VDD _2967_ _2968_ sky130_fd_sc_hd__ha_1
X_6825_ _2969_ _2970_ VSS VSS VDD VDD _2971_ _2972_ sky130_fd_sc_hd__ha_2
X_6826_ _2973_ _2974_ VSS VSS VDD VDD _2975_ _2976_ sky130_fd_sc_hd__ha_2
X_6827_ _2977_ _2978_ VSS VSS VDD VDD _2979_ _2980_ sky130_fd_sc_hd__ha_2
X_6828_ _2981_ _2982_ VSS VSS VDD VDD _2983_ _2984_ sky130_fd_sc_hd__ha_1
X_6829_ _2985_ _2986_ VSS VSS VDD VDD _2987_ _2988_ sky130_fd_sc_hd__ha_1
X_6830_ _2985_ _2986_ VSS VSS VDD VDD _2989_ _2990_ sky130_fd_sc_hd__ha_1
X_6831_ _2991_ _2992_ VSS VSS VDD VDD _2993_ _2994_ sky130_fd_sc_hd__ha_1
X_6832_ _2995_ _2996_ VSS VSS VDD VDD _2997_ _2998_ sky130_fd_sc_hd__ha_2
X_6833_ _2999_ _3000_ VSS VSS VDD VDD _3001_ _3002_ sky130_fd_sc_hd__ha_1
X_6834_ _3003_ _3004_ VSS VSS VDD VDD _3005_ _3006_ sky130_fd_sc_hd__ha_2
X_6835_ _3007_ _3008_ VSS VSS VDD VDD _3009_ _3010_ sky130_fd_sc_hd__ha_1
X_6836_ _3011_ _3012_ VSS VSS VDD VDD _3013_ _3014_ sky130_fd_sc_hd__ha_1
X_6837_ _3015_ _3016_ VSS VSS VDD VDD _3017_ _3018_ sky130_fd_sc_hd__ha_1
X_6838_ _3019_ _3020_ VSS VSS VDD VDD _3021_ _3022_ sky130_fd_sc_hd__ha_1
X_6839_ _3023_ _3024_ VSS VSS VDD VDD _3025_ _3026_ sky130_fd_sc_hd__ha_1
X_6840_ _2154_ _2155_ VSS VSS VDD VDD _3027_ _3028_ sky130_fd_sc_hd__ha_1
X_6841_ _3029_ _3030_ VSS VSS VDD VDD _3031_ _3032_ sky130_fd_sc_hd__ha_1
X_6842_ _3033_ _3034_ VSS VSS VDD VDD _3035_ _3036_ sky130_fd_sc_hd__ha_2
X_6843_ _3037_ net24 VSS VSS VDD VDD _3039_ _3040_ sky130_fd_sc_hd__ha_1
X_6844_ _3041_ net24 VSS VSS VDD VDD _3042_ _3043_ sky130_fd_sc_hd__ha_1
X_6845_ _3044_ net24 VSS VSS VDD VDD _3045_ _3046_ sky130_fd_sc_hd__ha_1
X_6846_ _3047_ net24 VSS VSS VDD VDD _3048_ _3049_ sky130_fd_sc_hd__ha_1
X_6847_ _3050_ net24 VSS VSS VDD VDD _3051_ _3052_ sky130_fd_sc_hd__ha_1
X_6848_ _3053_ net26 VSS VSS VDD VDD _3054_ _3055_ sky130_fd_sc_hd__ha_1
X_6849_ _3056_ _3057_ VSS VSS VDD VDD _3058_ _3059_ sky130_fd_sc_hd__ha_1
X_6850_ _3060_ net26 VSS VSS VDD VDD _3061_ _3062_ sky130_fd_sc_hd__ha_1
X_6851_ _3063_ _3057_ VSS VSS VDD VDD _3064_ _3065_ sky130_fd_sc_hd__ha_1
X_6852_ _3066_ _3038_ VSS VSS VDD VDD _3067_ _3068_ sky130_fd_sc_hd__ha_1
X_6853_ _3069_ _3038_ VSS VSS VDD VDD _3070_ _3071_ sky130_fd_sc_hd__ha_1
X_6854_ _3072_ _3038_ VSS VSS VDD VDD _3073_ _3074_ sky130_fd_sc_hd__ha_1
X_6855_ _3075_ _3057_ VSS VSS VDD VDD _3076_ _3077_ sky130_fd_sc_hd__ha_1
X_6856_ _3038_ _3078_ VSS VSS VDD VDD _3079_ _3080_ sky130_fd_sc_hd__ha_4
X_6857_ _3081_ _3082_ VSS VSS VDD VDD _3083_ _3084_ sky130_fd_sc_hd__ha_1
X_6858_ _3085_ _3086_ VSS VSS VDD VDD _3087_ _3088_ sky130_fd_sc_hd__ha_1
X_6859_ _3089_ _2925_ VSS VSS VDD VDD _3090_ _3091_ sky130_fd_sc_hd__ha_1
X_6860_ _3092_ _3093_ VSS VSS VDD VDD _3094_ _3095_ sky130_fd_sc_hd__ha_1
X_6861_ _3096_ _3097_ VSS VSS VDD VDD _3098_ _3099_ sky130_fd_sc_hd__ha_1
X_6862_ _3100_ _3101_ VSS VSS VDD VDD _3102_ _3103_ sky130_fd_sc_hd__ha_1
X_6863_ _3104_ _3105_ VSS VSS VDD VDD _3106_ _3107_ sky130_fd_sc_hd__ha_1
X_6864_ _3108_ _3109_ VSS VSS VDD VDD _3110_ _3111_ sky130_fd_sc_hd__ha_1
X_6865_ _2149_ _2157_ VSS VSS VDD VDD _3112_ _3113_ sky130_fd_sc_hd__ha_1
X_6866_ _2924_ _3008_ VSS VSS VDD VDD _2146_ _3114_ sky130_fd_sc_hd__ha_1
X_6867_ _3115_ _2926_ VSS VSS VDD VDD _2174_ _3116_ sky130_fd_sc_hd__ha_1
X_6868_ _3117_ _3118_ VSS VSS VDD VDD _3119_ _3120_ sky130_fd_sc_hd__ha_2
X_6869_ _3121_ _3122_ VSS VSS VDD VDD _3123_ _3124_ sky130_fd_sc_hd__ha_1
X_6870_ _3125_ _3126_ VSS VSS VDD VDD _3127_ _3128_ sky130_fd_sc_hd__ha_2
X_6871_ _3129_ _3130_ VSS VSS VDD VDD _3131_ _3132_ sky130_fd_sc_hd__ha_1
X_6872_ _3133_ _3134_ VSS VSS VDD VDD _3135_ _3136_ sky130_fd_sc_hd__ha_1
X_6873_ _3137_ _3138_ VSS VSS VDD VDD _3139_ _3140_ sky130_fd_sc_hd__ha_1
X_6874_ _3141_ _3142_ VSS VSS VDD VDD _3143_ _3144_ sky130_fd_sc_hd__ha_1
X_6875_ _3145_ _3146_ VSS VSS VDD VDD _3147_ _3148_ sky130_fd_sc_hd__ha_1
X_6876_ _3133_ _3134_ VSS VSS VDD VDD _3149_ _3150_ sky130_fd_sc_hd__ha_2
X_6877_ _3151_ _3152_ VSS VSS VDD VDD _3153_ _3154_ sky130_fd_sc_hd__ha_1
X_6878_ _3155_ _3156_ VSS VSS VDD VDD _3157_ _3158_ sky130_fd_sc_hd__ha_1
X_6879_ _3159_ _3160_ VSS VSS VDD VDD _3161_ _3162_ sky130_fd_sc_hd__ha_1
X_6880_ _3163_ _3164_ VSS VSS VDD VDD _3165_ _3166_ sky130_fd_sc_hd__ha_1
X_6881_ _3167_ _3168_ VSS VSS VDD VDD _3169_ _3170_ sky130_fd_sc_hd__ha_1
X_6882_ _3171_ _3172_ VSS VSS VDD VDD _3173_ _3174_ sky130_fd_sc_hd__ha_1
X_6883_ _3175_ _3176_ VSS VSS VDD VDD _3177_ _3178_ sky130_fd_sc_hd__ha_1
X_6884_ _3179_ _3180_ VSS VSS VDD VDD _3181_ _3182_ sky130_fd_sc_hd__ha_1
X_6885_ _3183_ _3184_ VSS VSS VDD VDD _3185_ _3186_ sky130_fd_sc_hd__ha_1
X_6886_ _3187_ _3188_ VSS VSS VDD VDD _3189_ _3190_ sky130_fd_sc_hd__ha_1
X_6887_ _3191_ _3192_ VSS VSS VDD VDD _3193_ _3194_ sky130_fd_sc_hd__ha_1
X_6888_ _2160_ _2161_ VSS VSS VDD VDD _3195_ _3196_ sky130_fd_sc_hd__ha_1
X_6889_ _3197_ _3198_ VSS VSS VDD VDD _3199_ _3200_ sky130_fd_sc_hd__ha_2
X_6890_ _3201_ _3202_ VSS VSS VDD VDD _3203_ _3204_ sky130_fd_sc_hd__ha_1
X_6891_ _3205_ _3206_ VSS VSS VDD VDD _3207_ _3208_ sky130_fd_sc_hd__ha_2
X_6892_ _3209_ _3210_ VSS VSS VDD VDD _3211_ _3212_ sky130_fd_sc_hd__ha_2
X_6893_ net10 _3214_ VSS VSS VDD VDD _3215_ _3216_ sky130_fd_sc_hd__ha_1
X_6894_ net10 _3217_ VSS VSS VDD VDD _3218_ _3219_ sky130_fd_sc_hd__ha_1
X_6895_ net10 _3220_ VSS VSS VDD VDD _3221_ _3222_ sky130_fd_sc_hd__ha_1
X_6896_ net10 _3223_ VSS VSS VDD VDD _3224_ _3225_ sky130_fd_sc_hd__ha_1
X_6897_ net10 _3226_ VSS VSS VDD VDD _3227_ _3228_ sky130_fd_sc_hd__ha_1
X_6898_ net10 _3229_ VSS VSS VDD VDD _3230_ _3231_ sky130_fd_sc_hd__ha_1
X_6899_ net19 _3232_ VSS VSS VDD VDD _3233_ _3234_ sky130_fd_sc_hd__ha_1
X_6900_ net11 _3236_ VSS VSS VDD VDD _3237_ _3238_ sky130_fd_sc_hd__ha_1
X_6901_ _3239_ net19 VSS VSS VDD VDD _3240_ _3241_ sky130_fd_sc_hd__ha_1
X_6902_ _3235_ _3242_ VSS VSS VDD VDD _3243_ _3244_ sky130_fd_sc_hd__ha_1
X_6903_ net19 _3245_ VSS VSS VDD VDD _3246_ _3247_ sky130_fd_sc_hd__ha_1
X_6904_ _3213_ _3248_ VSS VSS VDD VDD _3249_ _3250_ sky130_fd_sc_hd__ha_1
X_6905_ _3213_ _3251_ VSS VSS VDD VDD _3252_ _3253_ sky130_fd_sc_hd__ha_1
X_6906_ _3254_ _3235_ VSS VSS VDD VDD _3255_ _3256_ sky130_fd_sc_hd__ha_4
X_6907_ _3257_ _3258_ VSS VSS VDD VDD _3259_ _3260_ sky130_fd_sc_hd__ha_1
X_6908_ _3261_ _3262_ VSS VSS VDD VDD _3263_ _3264_ sky130_fd_sc_hd__ha_1
X_6909_ _3265_ _3266_ VSS VSS VDD VDD _3267_ _3268_ sky130_fd_sc_hd__ha_1
X_6910_ _3269_ _3270_ VSS VSS VDD VDD _3271_ _3272_ sky130_fd_sc_hd__ha_1
X_6911_ _3273_ _3274_ VSS VSS VDD VDD _3275_ _3276_ sky130_fd_sc_hd__ha_1
X_6912_ _3277_ _3278_ VSS VSS VDD VDD _3279_ _3280_ sky130_fd_sc_hd__ha_1
X_6913_ _3281_ _3282_ VSS VSS VDD VDD _3283_ _3284_ sky130_fd_sc_hd__ha_1
X_6914_ _3285_ _3286_ VSS VSS VDD VDD _3287_ _3288_ sky130_fd_sc_hd__ha_1
X_6915_ _2167_ _2159_ VSS VSS VDD VDD _3289_ _3290_ sky130_fd_sc_hd__ha_1
X_6916_ _3114_ _3172_ VSS VSS VDD VDD _2156_ _3291_ sky130_fd_sc_hd__ha_1
X_6917_ _3292_ _3116_ VSS VSS VDD VDD _2176_ _3293_ sky130_fd_sc_hd__ha_1
X_6918_ _3294_ _3295_ VSS VSS VDD VDD _3296_ _3297_ sky130_fd_sc_hd__ha_2
X_6919_ _3298_ _3299_ VSS VSS VDD VDD _3300_ _3301_ sky130_fd_sc_hd__ha_1
X_6920_ _3302_ _3303_ VSS VSS VDD VDD _3304_ _3305_ sky130_fd_sc_hd__ha_1
X_6921_ _3306_ _3307_ VSS VSS VDD VDD _3308_ _3309_ sky130_fd_sc_hd__ha_1
X_6922_ _3310_ _3311_ VSS VSS VDD VDD _3312_ _3313_ sky130_fd_sc_hd__ha_2
X_6923_ _3298_ _3299_ VSS VSS VDD VDD _3314_ _3315_ sky130_fd_sc_hd__ha_1
X_6924_ _3316_ _3317_ VSS VSS VDD VDD _3318_ _3319_ sky130_fd_sc_hd__ha_2
X_6925_ _3320_ _3321_ VSS VSS VDD VDD _3322_ _3323_ sky130_fd_sc_hd__ha_1
X_6926_ _3324_ _3325_ VSS VSS VDD VDD _3326_ _3327_ sky130_fd_sc_hd__ha_1
X_6927_ _3328_ _3329_ VSS VSS VDD VDD _3330_ _3331_ sky130_fd_sc_hd__ha_2
X_6928_ _3332_ _3333_ VSS VSS VDD VDD _3334_ _3335_ sky130_fd_sc_hd__ha_1
X_6929_ _3332_ _3333_ VSS VSS VDD VDD _3336_ _3337_ sky130_fd_sc_hd__ha_1
X_6930_ _3338_ _3339_ VSS VSS VDD VDD _3340_ _3341_ sky130_fd_sc_hd__ha_1
X_6931_ _3342_ _3343_ VSS VSS VDD VDD _3344_ _3345_ sky130_fd_sc_hd__ha_1
X_6932_ _3346_ _3347_ VSS VSS VDD VDD _3348_ _3349_ sky130_fd_sc_hd__ha_1
X_6933_ _3350_ _3351_ VSS VSS VDD VDD _3352_ _3353_ sky130_fd_sc_hd__ha_1
X_6934_ _3354_ _3355_ VSS VSS VDD VDD _3356_ _3357_ sky130_fd_sc_hd__ha_1
X_6935_ _2164_ _2171_ VSS VSS VDD VDD _3358_ _3359_ sky130_fd_sc_hd__ha_1
X_6936_ _3360_ _3361_ VSS VSS VDD VDD _3362_ _3363_ sky130_fd_sc_hd__ha_1
X_6937_ _3364_ _3365_ VSS VSS VDD VDD _3366_ _3367_ sky130_fd_sc_hd__ha_1
X_6938_ _3368_ _3369_ VSS VSS VDD VDD _3370_ _3371_ sky130_fd_sc_hd__ha_1
X_6939_ _3372_ _3373_ VSS VSS VDD VDD _3374_ _3375_ sky130_fd_sc_hd__ha_2
X_6940_ _3376_ _3377_ VSS VSS VDD VDD _3378_ _3379_ sky130_fd_sc_hd__ha_1
X_6941_ net7 _3381_ VSS VSS VDD VDD _3382_ _3383_ sky130_fd_sc_hd__ha_1
X_6942_ net7 _3384_ VSS VSS VDD VDD _3385_ _3386_ sky130_fd_sc_hd__ha_1
X_6943_ net7 _3387_ VSS VSS VDD VDD _3388_ _3389_ sky130_fd_sc_hd__ha_1
X_6944_ net7 _3390_ VSS VSS VDD VDD _3391_ _3392_ sky130_fd_sc_hd__ha_1
X_6945_ net7 _3393_ VSS VSS VDD VDD _3394_ _3395_ sky130_fd_sc_hd__ha_1
X_6946_ net7 _3396_ VSS VSS VDD VDD _3397_ _3398_ sky130_fd_sc_hd__ha_1
X_6947_ net7 _3399_ VSS VSS VDD VDD _3400_ _3401_ sky130_fd_sc_hd__ha_1
X_6948_ net20 _3402_ VSS VSS VDD VDD _3403_ _3404_ sky130_fd_sc_hd__ha_1
X_6949_ net8 _3406_ VSS VSS VDD VDD _3407_ _3408_ sky130_fd_sc_hd__ha_1
X_6950_ net20 _3409_ VSS VSS VDD VDD _3410_ _3411_ sky130_fd_sc_hd__ha_1
X_6951_ _3405_ _3412_ VSS VSS VDD VDD _3413_ _3414_ sky130_fd_sc_hd__ha_1
X_6952_ _3380_ _3415_ VSS VSS VDD VDD _3416_ _3417_ sky130_fd_sc_hd__ha_1
X_6953_ _3380_ _3418_ VSS VSS VDD VDD _3419_ _3420_ sky130_fd_sc_hd__ha_1
X_6954_ _3380_ _3421_ VSS VSS VDD VDD _3422_ _3423_ sky130_fd_sc_hd__ha_4
X_6955_ _3424_ _3425_ VSS VSS VDD VDD _3426_ _3427_ sky130_fd_sc_hd__ha_2
X_6956_ _3261_ _3262_ VSS VSS VDD VDD _3428_ _3429_ sky130_fd_sc_hd__ha_1
X_6957_ _3430_ _3115_ VSS VSS VDD VDD _3431_ _3432_ sky130_fd_sc_hd__ha_1
X_6958_ net178 _3434_ VSS VSS VDD VDD _3435_ _3436_ sky130_fd_sc_hd__ha_1
X_6959_ _3292_ _3437_ VSS VSS VDD VDD _3438_ _3439_ sky130_fd_sc_hd__ha_2
X_6960_ _3440_ _3441_ VSS VSS VDD VDD _3442_ _3443_ sky130_fd_sc_hd__ha_4
X_6961_ _3444_ _3445_ VSS VSS VDD VDD _3446_ _3447_ sky130_fd_sc_hd__ha_1
X_6962_ _3448_ _3449_ VSS VSS VDD VDD _3450_ _3451_ sky130_fd_sc_hd__ha_1
X_6963_ _3452_ _3453_ VSS VSS VDD VDD _3454_ _3455_ sky130_fd_sc_hd__ha_1
X_6964_ _2169_ _2188_ VSS VSS VDD VDD _3456_ _3457_ sky130_fd_sc_hd__ha_1
X_6965_ _3291_ _3376_ VSS VSS VDD VDD _2166_ _3458_ sky130_fd_sc_hd__ha_1
X_6966_ _3459_ _3460_ VSS VSS VDD VDD _3461_ _3462_ sky130_fd_sc_hd__ha_1
X_6967_ _2173_ _2180_ VSS VSS VDD VDD _3463_ _3464_ sky130_fd_sc_hd__ha_1
X_6968_ _3465_ _3466_ VSS VSS VDD VDD _3467_ _3468_ sky130_fd_sc_hd__ha_1
X_6969_ _3469_ _3470_ VSS VSS VDD VDD _3471_ _3472_ sky130_fd_sc_hd__ha_2
X_6970_ _3474_ _3473_ VSS VSS VDD VDD _3475_ _3476_ sky130_fd_sc_hd__ha_1
X_6971_ _3477_ _3478_ VSS VSS VDD VDD _3479_ _3480_ sky130_fd_sc_hd__ha_1
X_6972_ _3481_ _3482_ VSS VSS VDD VDD _3483_ _3484_ sky130_fd_sc_hd__ha_1
X_6973_ _3485_ _3486_ VSS VSS VDD VDD _3487_ _3488_ sky130_fd_sc_hd__ha_2
X_6974_ _3489_ _3490_ VSS VSS VDD VDD _3491_ _3492_ sky130_fd_sc_hd__ha_1
X_6975_ _3489_ _3493_ VSS VSS VDD VDD _3494_ _3495_ sky130_fd_sc_hd__ha_1
X_6976_ _3496_ _3489_ VSS VSS VDD VDD _3497_ _3498_ sky130_fd_sc_hd__ha_1
X_6977_ _3499_ _3489_ VSS VSS VDD VDD _3500_ _3501_ sky130_fd_sc_hd__ha_1
X_6978_ _3489_ _3502_ VSS VSS VDD VDD _3503_ _3504_ sky130_fd_sc_hd__ha_1
X_6979_ _3489_ _3505_ VSS VSS VDD VDD _3506_ _3507_ sky130_fd_sc_hd__ha_1
X_6980_ _3489_ _3508_ VSS VSS VDD VDD _3509_ _3510_ sky130_fd_sc_hd__ha_1
X_6981_ _3489_ _3511_ VSS VSS VDD VDD _3512_ _3513_ sky130_fd_sc_hd__ha_1
X_6982_ _3489_ _3514_ VSS VSS VDD VDD _3515_ _3516_ sky130_fd_sc_hd__ha_1
X_6983_ _3517_ _3518_ VSS VSS VDD VDD _3519_ _3520_ sky130_fd_sc_hd__ha_1
X_6984_ _3521_ _3489_ VSS VSS VDD VDD _3522_ _3523_ sky130_fd_sc_hd__ha_1
X_6985_ _2185_ _2186_ VSS VSS VDD VDD _3524_ _3525_ sky130_fd_sc_hd__ha_1
X_6986_ _3526_ _2184_ VSS VSS VDD VDD _3527_ _3528_ sky130_fd_sc_hd__ha_4
X_6987_ _3530_ _3529_ VSS VSS VDD VDD _3531_ _3532_ sky130_fd_sc_hd__ha_1
X_6988_ _3533_ _3534_ VSS VSS VDD VDD _3535_ _3536_ sky130_fd_sc_hd__ha_1
X_6989_ _3537_ _3538_ VSS VSS VDD VDD _3539_ _3540_ sky130_fd_sc_hd__ha_1
X_6990_ _3542_ _3541_ VSS VSS VDD VDD _3543_ _3544_ sky130_fd_sc_hd__ha_1
X_6991_ _3545_ _3546_ VSS VSS VDD VDD _3547_ _3548_ sky130_fd_sc_hd__ha_1
X_6992_ _3549_ _3550_ VSS VSS VDD VDD _3551_ _3552_ sky130_fd_sc_hd__ha_1
X_6993_ _3553_ _3554_ VSS VSS VDD VDD _3555_ _3556_ sky130_fd_sc_hd__ha_2
X_6994_ _3558_ _3557_ VSS VSS VDD VDD _3559_ _3560_ sky130_fd_sc_hd__ha_1
X_6995_ _3561_ _3562_ VSS VSS VDD VDD _3563_ _3564_ sky130_fd_sc_hd__ha_1
X_6996_ _3565_ _3566_ VSS VSS VDD VDD _3567_ _3568_ sky130_fd_sc_hd__ha_2
X_6997_ _3569_ _3570_ VSS VSS VDD VDD _3571_ _3572_ sky130_fd_sc_hd__ha_2
X_6998_ _3573_ _3574_ VSS VSS VDD VDD _3575_ _3576_ sky130_fd_sc_hd__ha_1
X_6999_ _3577_ _3578_ VSS VSS VDD VDD _3579_ _3580_ sky130_fd_sc_hd__ha_1
X_7000_ _3581_ _3582_ VSS VSS VDD VDD _3583_ _3584_ sky130_fd_sc_hd__ha_2
X_7001_ _3585_ _3586_ VSS VSS VDD VDD _3587_ _3588_ sky130_fd_sc_hd__ha_2
X_7002_ _3589_ _3590_ VSS VSS VDD VDD _3591_ _3592_ sky130_fd_sc_hd__ha_1
X_7003_ _3593_ _3594_ VSS VSS VDD VDD _3595_ _3596_ sky130_fd_sc_hd__ha_1
X_7004_ _3597_ _3598_ VSS VSS VDD VDD _3599_ _3600_ sky130_fd_sc_hd__ha_4
X_7005_ _3601_ _3602_ VSS VSS VDD VDD _3603_ _3604_ sky130_fd_sc_hd__ha_1
X_7006_ _3606_ _3605_ VSS VSS VDD VDD _3607_ _3608_ sky130_fd_sc_hd__ha_4
X_7007_ _3609_ _3610_ VSS VSS VDD VDD _3611_ _3612_ sky130_fd_sc_hd__ha_4
X_7008_ _3598_ _3613_ VSS VSS VDD VDD _3614_ _3615_ sky130_fd_sc_hd__ha_1
X_7009_ _3617_ _3616_ VSS VSS VDD VDD _3618_ _3619_ sky130_fd_sc_hd__ha_1
X_7010_ _3621_ _3620_ VSS VSS VDD VDD _3622_ _3623_ sky130_fd_sc_hd__ha_1
X_7011_ _3624_ _3625_ VSS VSS VDD VDD _3626_ _3627_ sky130_fd_sc_hd__ha_1
X_7012_ _3628_ net154 VSS VSS VDD VDD _3630_ _3631_ sky130_fd_sc_hd__ha_1
X_7013_ _3632_ _3633_ VSS VSS VDD VDD _3634_ _3635_ sky130_fd_sc_hd__ha_1
X_7014_ net134 _3637_ VSS VSS VDD VDD _3638_ _3639_ sky130_fd_sc_hd__ha_1
X_7015_ _3640_ _3641_ VSS VSS VDD VDD _3642_ _3643_ sky130_fd_sc_hd__ha_2
X_7016_ _3644_ _3645_ VSS VSS VDD VDD _3646_ _3647_ sky130_fd_sc_hd__ha_1
X_7017_ _3648_ _3649_ VSS VSS VDD VDD _3650_ _3651_ sky130_fd_sc_hd__ha_2
X_7018_ _3652_ _3653_ VSS VSS VDD VDD _3654_ _3655_ sky130_fd_sc_hd__ha_1
X_7019_ _3656_ _3657_ VSS VSS VDD VDD _3658_ _3659_ sky130_fd_sc_hd__ha_2
X_7020_ _3660_ net224 VSS VSS VDD VDD _3662_ _3663_ sky130_fd_sc_hd__ha_1
X_7021_ _3664_ _3665_ VSS VSS VDD VDD _3666_ _3667_ sky130_fd_sc_hd__ha_2
X_7022_ _3668_ _3669_ VSS VSS VDD VDD _3670_ _3671_ sky130_fd_sc_hd__ha_1
X_7023_ _3673_ _3672_ VSS VSS VDD VDD _3674_ _3675_ sky130_fd_sc_hd__ha_4
X_7024_ _2190_ _2192_ VSS VSS VDD VDD _3676_ _3677_ sky130_fd_sc_hd__ha_4
X_7025_ _3620_ _3458_ VSS VSS VDD VDD _2187_ _3678_ sky130_fd_sc_hd__ha_1
X_7026_ _3678_ _3629_ VSS VSS VDD VDD _2191_ net78 sky130_fd_sc_hd__ha_4
X_7027_ _3679_ _3680_ VSS VSS VDD VDD _3681_ _3682_ sky130_fd_sc_hd__ha_4
X_7028_ _3683_ _3684_ VSS VSS VDD VDD _3685_ _3686_ sky130_fd_sc_hd__ha_2
X_7029_ net67 net68 VSS VSS VDD VDD _3687_ _3688_ sky130_fd_sc_hd__ha_4
X_7030_ _3689_ _3690_ VSS VSS VDD VDD _3691_ _3692_ sky130_fd_sc_hd__ha_4
X_7031_ _3694_ _3693_ VSS VSS VDD VDD _3695_ _3696_ sky130_fd_sc_hd__ha_1
X_7032_ _3697_ _3698_ VSS VSS VDD VDD _3699_ _3700_ sky130_fd_sc_hd__ha_1
X_7033_ _3701_ _3702_ VSS VSS VDD VDD _3703_ _3704_ sky130_fd_sc_hd__ha_1
X_7034_ _3705_ _3706_ VSS VSS VDD VDD _3707_ _3708_ sky130_fd_sc_hd__ha_4
X_7035_ _3710_ _3709_ VSS VSS VDD VDD _3711_ _3712_ sky130_fd_sc_hd__ha_1
X_7036_ _3705_ _3713_ VSS VSS VDD VDD _3714_ _3715_ sky130_fd_sc_hd__ha_1
X_7037_ _3716_ _3717_ VSS VSS VDD VDD _3718_ _3719_ sky130_fd_sc_hd__ha_1
X_7038_ _3720_ _3721_ VSS VSS VDD VDD _3722_ _3723_ sky130_fd_sc_hd__ha_4
X_7039_ _3724_ _3725_ VSS VSS VDD VDD _3726_ _3727_ sky130_fd_sc_hd__ha_1
X_7040_ net118 _3729_ VSS VSS VDD VDD _3730_ _3731_ sky130_fd_sc_hd__ha_1
X_7041_ net138 _3733_ VSS VSS VDD VDD _3734_ _3735_ sky130_fd_sc_hd__ha_1
X_7042_ _3736_ _3721_ VSS VSS VDD VDD _3737_ _3738_ sky130_fd_sc_hd__ha_1
X_7043_ _3739_ _3740_ VSS VSS VDD VDD _3741_ _3742_ sky130_fd_sc_hd__ha_1
X_7044_ _3743_ _3744_ VSS VSS VDD VDD _3745_ _3746_ sky130_fd_sc_hd__ha_1
X_7045_ _3293_ _3724_ VSS VSS VDD VDD _2181_ _3526_ sky130_fd_sc_hd__ha_4
Xclone1 _0629_ VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkinv_2
Xclone3 _0158_ VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkinv_2
Xclone4 net5 VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_2
Xsplit5 _2092_ VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_2
Xclone6 _0343_ _0342_ _0347_ VSS VSS VDD VDD net6 sky130_fd_sc_hd__o21bai_4
Xclone7 _1185_ VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_4
Xclone8 _1186_ VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_2
Xclone9 net174 VSS VSS VDD VDD net9 sky130_fd_sc_hd__buf_6
Xclone10 _1048_ VSS VSS VDD VDD net10 sky130_fd_sc_hd__buf_6
Xclone11 _1049_ VSS VSS VDD VDD net11 sky130_fd_sc_hd__buf_6
Xclone12 _0629_ VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_4
Xclone13 _2660_ _0627_ _0626_ _0628_ _2653_ VSS VSS VDD VDD
+ net13 sky130_fd_sc_hd__a311o_4
Xclone14 net174 VSS VSS VDD VDD net14 sky130_fd_sc_hd__buf_4
Xclone15 _0159_ VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_2
Xclone16 _0045_ VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkinv_4
Xclone17 _0873_ VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_2
Xclone18 _0158_ VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_2
Xclone19 _1048_ VSS VSS VDD VDD net19 sky130_fd_sc_hd__buf_4
Xclone20 _1185_ VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_2
Xclone21 net211 VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_2
Xclone22 _3382_ _1315_ VSS VSS VDD VDD net22 sky130_fd_sc_hd__nand2b_2
Xclone23 _0295_ VSS VSS VDD VDD net23 sky130_fd_sc_hd__buf_4
Xclone24 _0972_ VSS VSS VDD VDD net24 sky130_fd_sc_hd__buf_6
Xclone25 _3213_ VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkinv_4
Xclone26 _0972_ VSS VSS VDD VDD net26 sky130_fd_sc_hd__buf_4
Xclone27 _1319_ VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_2
Xclone28 net62 VSS VSS VDD VDD net28 sky130_fd_sc_hd__buf_4
Xclone29 net205 net202 VSS VSS VDD VDD net29 sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 x_in[0] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_1
Xinput2 x_in[10] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_1
Xinput3 x_in[11] VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_1
Xinput4 x_in[12] VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_1
Xinput5 x_in[13] VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_1
Xinput6 x_in[14] VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_1
Xinput7 x_in[15] VSS VSS VDD VDD net36 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput8 x_in[1] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_2
Xinput9 x_in[2] VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_1
Xinput10 x_in[3] VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_1
Xinput11 x_in[4] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
Xinput12 x_in[5] VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_1
Xinput13 x_in[6] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_1
Xinput14 x_in[7] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
Xinput15 x_in[8] VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_1
Xinput16 x_in[9] VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_1
Xinput17 y_in[0] VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkbuf_1
Xinput18 y_in[10] VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkbuf_1
Xinput19 y_in[11] VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_1
Xinput20 y_in[12] VSS VSS VDD VDD net49 sky130_fd_sc_hd__clkbuf_1
Xinput21 y_in[13] VSS VSS VDD VDD net50 sky130_fd_sc_hd__clkbuf_1
Xinput22 y_in[14] VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkbuf_1
Xinput23 y_in[15] VSS VSS VDD VDD net52 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput24 y_in[1] VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkbuf_2
Xinput25 y_in[2] VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkbuf_1
Xinput26 y_in[3] VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_1
Xinput27 y_in[4] VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_1
Xinput28 y_in[5] VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkbuf_1
Xinput29 y_in[6] VSS VSS VDD VDD net58 sky130_fd_sc_hd__clkbuf_1
Xinput30 y_in[7] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_1
Xinput31 y_in[8] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_1
Xinput32 y_in[9] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_1
Xinput33 z_in[0] VSS VSS VDD VDD net62 sky130_fd_sc_hd__buf_12
Xinput34 z_in[10] VSS VSS VDD VDD net63 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput35 z_in[11] VSS VSS VDD VDD net64 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput36 z_in[12] VSS VSS VDD VDD net65 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput37 z_in[13] VSS VSS VDD VDD net66 sky130_fd_sc_hd__clkbuf_1
Xinput38 z_in[14] VSS VSS VDD VDD net67 sky130_fd_sc_hd__buf_8
Xinput39 z_in[15] VSS VSS VDD VDD net68 sky130_fd_sc_hd__buf_6
Xinput40 z_in[1] VSS VSS VDD VDD net69 sky130_fd_sc_hd__clkbuf_1
Xinput41 z_in[2] VSS VSS VDD VDD net70 sky130_fd_sc_hd__clkbuf_1
Xinput42 z_in[3] VSS VSS VDD VDD net71 sky130_fd_sc_hd__clkbuf_2
Xinput43 z_in[4] VSS VSS VDD VDD net72 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput44 z_in[5] VSS VSS VDD VDD net73 sky130_fd_sc_hd__clkbuf_1
Xinput45 z_in[6] VSS VSS VDD VDD net74 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput46 z_in[7] VSS VSS VDD VDD net75 sky130_fd_sc_hd__clkbuf_1
Xinput47 z_in[8] VSS VSS VDD VDD net76 sky130_fd_sc_hd__clkbuf_1
Xinput48 z_in[9] VSS VSS VDD VDD net77 sky130_fd_sc_hd__clkbuf_1
Xoutput49 net78 VSS VSS VDD VDD x_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput50 net79 VSS VSS VDD VDD x_out[10] sky130_fd_sc_hd__clkbuf_1
Xoutput51 net80 VSS VSS VDD VDD x_out[11] sky130_fd_sc_hd__clkbuf_1
Xoutput52 net81 VSS VSS VDD VDD x_out[12] sky130_fd_sc_hd__clkbuf_1
Xoutput53 net82 VSS VSS VDD VDD x_out[13] sky130_fd_sc_hd__clkbuf_1
Xoutput54 net83 VSS VSS VDD VDD x_out[14] sky130_fd_sc_hd__clkbuf_1
Xoutput55 net84 VSS VSS VDD VDD x_out[15] sky130_fd_sc_hd__clkbuf_1
Xoutput56 net85 VSS VSS VDD VDD x_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput57 net86 VSS VSS VDD VDD x_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput58 net87 VSS VSS VDD VDD x_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput59 net88 VSS VSS VDD VDD x_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput60 net89 VSS VSS VDD VDD x_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput61 net90 VSS VSS VDD VDD x_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput62 net91 VSS VSS VDD VDD x_out[7] sky130_fd_sc_hd__clkbuf_1
Xoutput63 net92 VSS VSS VDD VDD x_out[8] sky130_fd_sc_hd__clkbuf_1
Xoutput64 net93 VSS VSS VDD VDD x_out[9] sky130_fd_sc_hd__clkbuf_1
Xoutput65 net94 VSS VSS VDD VDD y_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput66 net95 VSS VSS VDD VDD y_out[10] sky130_fd_sc_hd__buf_2
Xoutput67 net96 VSS VSS VDD VDD y_out[11] sky130_fd_sc_hd__clkbuf_1
Xoutput68 net97 VSS VSS VDD VDD y_out[12] sky130_fd_sc_hd__clkbuf_1
Xoutput69 net98 VSS VSS VDD VDD y_out[13] sky130_fd_sc_hd__clkbuf_1
Xoutput70 net99 VSS VSS VDD VDD y_out[14] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net100 VSS VSS VDD VDD y_out[15] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net101 VSS VSS VDD VDD y_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net102 VSS VSS VDD VDD y_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net103 VSS VSS VDD VDD y_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net104 VSS VSS VDD VDD y_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net105 VSS VSS VDD VDD y_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net106 VSS VSS VDD VDD y_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net107 VSS VSS VDD VDD y_out[7] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net108 VSS VSS VDD VDD y_out[8] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net109 VSS VSS VDD VDD y_out[9] sky130_fd_sc_hd__clkbuf_1
Xrebuffer1 _1545_ VSS VSS VDD VDD net110 sky130_fd_sc_hd__buf_6
Xrebuffer2 net200 VSS VSS VDD VDD net111 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer3 net111 VSS VSS VDD VDD net112 sky130_fd_sc_hd__buf_6
Xrebuffer4 _3264_ VSS VSS VDD VDD net113 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer5 _1223_ VSS VSS VDD VDD net114 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer6 _3476_ VSS VSS VDD VDD net115 sky130_fd_sc_hd__buf_6
Xrebuffer7 net115 VSS VSS VDD VDD net116 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer8 _1351_ VSS VSS VDD VDD net117 sky130_fd_sc_hd__buf_4
Xrebuffer9 net158 VSS VSS VDD VDD net118 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer10 _1965_ VSS VSS VDD VDD net119 sky130_fd_sc_hd__buf_2
Xrebuffer11 _2000_ VSS VSS VDD VDD net120 sky130_fd_sc_hd__buf_4
Xrebuffer12 net205 VSS VSS VDD VDD net121 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer13 _1413_ VSS VSS VDD VDD net122 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer14 _1328_ VSS VSS VDD VDD net123 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer15 net123 VSS VSS VDD VDD net124 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer16 net123 VSS VSS VDD VDD net125 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer17 net125 VSS VSS VDD VDD net126 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer18 _1401_ VSS VSS VDD VDD net127 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer19 _1221_ VSS VSS VDD VDD net128 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer20 _2193_ VSS VSS VDD VDD net129 sky130_fd_sc_hd__buf_6
Xrebuffer21 _1289_ VSS VSS VDD VDD net130 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer22 _1510_ VSS VSS VDD VDD net131 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer78 _1564_ VSS VSS VDD VDD net197 sky130_fd_sc_hd__buf_6
Xrebuffer24 _3532_ VSS VSS VDD VDD net133 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer25 _3636_ VSS VSS VDD VDD net134 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer26 net148 VSS VSS VDD VDD net135 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer27 _1326_ VSS VSS VDD VDD net136 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer28 _3732_ VSS VSS VDD VDD net137 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer29 _3732_ VSS VSS VDD VDD net138 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer30 _1121_ VSS VSS VDD VDD net139 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer31 _1291_ VSS VSS VDD VDD net140 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer32 _1427_ VSS VSS VDD VDD net141 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer33 _1994_ VSS VSS VDD VDD net142 sky130_fd_sc_hd__buf_6
Xrebuffer34 net207 VSS VSS VDD VDD net143 sky130_fd_sc_hd__buf_4
Xrebuffer35 _3544_ VSS VSS VDD VDD net144 sky130_fd_sc_hd__clkbuf_2
Xrebuffer36 _1501_ VSS VSS VDD VDD net145 sky130_fd_sc_hd__buf_6
Xrebuffer37 _1532_ VSS VSS VDD VDD net146 sky130_fd_sc_hd__buf_4
Xrebuffer38 net211 VSS VSS VDD VDD net147 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer39 _1329_ VSS VSS VDD VDD net148 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer40 net212 VSS VSS VDD VDD net149 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer41 _1512_ VSS VSS VDD VDD net150 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer42 _1514_ VSS VSS VDD VDD net151 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer43 _2006_ VSS VSS VDD VDD net152 sky130_fd_sc_hd__buf_4
Xrebuffer44 _3629_ VSS VSS VDD VDD net153 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer45 net153 VSS VSS VDD VDD net154 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer46 _1495_ VSS VSS VDD VDD net155 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer47 _1340_ VSS VSS VDD VDD net156 sky130_fd_sc_hd__buf_2
Xrebuffer48 _3728_ VSS VSS VDD VDD net157 sky130_fd_sc_hd__clkbuf_2
Xrebuffer49 net157 VSS VSS VDD VDD net158 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer50 net214 VSS VSS VDD VDD net159 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer51 _1293_ VSS VSS VDD VDD net160 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer52 net162 VSS VSS VDD VDD net161 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer53 net163 VSS VSS VDD VDD net162 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer54 net164 VSS VSS VDD VDD net163 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer55 net165 VSS VSS VDD VDD net164 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer56 net166 VSS VSS VDD VDD net165 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer57 net167 VSS VSS VDD VDD net166 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer58 net168 VSS VSS VDD VDD net167 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer59 net169 VSS VSS VDD VDD net168 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer60 net170 VSS VSS VDD VDD net169 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer61 _1369_ VSS VSS VDD VDD net170 sky130_fd_sc_hd__buf_1
Xclone62 _0008_ VSS VSS VDD VDD net171 sky130_fd_sc_hd__clkbuf_16
Xclone63 _0010_ VSS VSS VDD VDD net172 sky130_fd_sc_hd__clkbuf_16
Xclone67 _0009_ VSS VSS VDD VDD net176 sky130_fd_sc_hd__clkbuf_16
Xrebuffer68 _1327_ VSS VSS VDD VDD net177 sky130_fd_sc_hd__buf_6
Xrebuffer69 _3433_ VSS VSS VDD VDD net178 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer70 net178 VSS VSS VDD VDD net179 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer79 _1472_ VSS VSS VDD VDD net188 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer80 _1469_ VSS VSS VDD VDD net189 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer81 _1535_ VSS VSS VDD VDD net190 sky130_fd_sc_hd__clkbuf_2
Xrebuffer82 _1535_ VSS VSS VDD VDD net191 sky130_fd_sc_hd__buf_6
Xrebuffer83 _3606_ VSS VSS VDD VDD net192 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer84 net192 VSS VSS VDD VDD net193 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer85 _1205_ VSS VSS VDD VDD net194 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer112 _1929_ VSS VSS VDD VDD net221 sky130_fd_sc_hd__buf_2
Xrebuffer113 _1499_ VSS VSS VDD VDD net222 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer114 _1529_ VSS VSS VDD VDD net223 sky130_fd_sc_hd__buf_6
Xrebuffer115 _3661_ VSS VSS VDD VDD net224 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer119 _1925_ VSS VSS VDD VDD net228 sky130_fd_sc_hd__buf_2
Xrebuffer120 _1936_ VSS VSS VDD VDD net229 sky130_fd_sc_hd__buf_2
Xrebuffer124 _1927_ VSS VSS VDD VDD net233 sky130_fd_sc_hd__buf_6
Xrebuffer126 _1940_ VSS VSS VDD VDD net235 sky130_fd_sc_hd__buf_2
Xrebuffer127 net235 VSS VSS VDD VDD net236 sky130_fd_sc_hd__clkbuf_2
Xrebuffer128 _1516_ VSS VSS VDD VDD net237 sky130_fd_sc_hd__buf_1
Xrebuffer129 _3672_ VSS VSS VDD VDD net238 sky130_fd_sc_hd__clkbuf_2
Xrebuffer130 _2194_ VSS VSS VDD VDD net239 sky130_fd_sc_hd__buf_6
Xrebuffer131 _2183_ VSS VSS VDD VDD net240 sky130_fd_sc_hd__clkbuf_2
Xrebuffer132 _2021_ VSS VSS VDD VDD net241 sky130_fd_sc_hd__clkbuf_2
Xrebuffer133 net241 VSS VSS VDD VDD net242 sky130_fd_sc_hd__buf_1
Xrebuffer62 _3560_ VSS VSS VDD VDD net173 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer63 _0348_ VSS VSS VDD VDD net174 sky130_fd_sc_hd__buf_4
Xrebuffer64 _1376_ VSS VSS VDD VDD net175 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer65 _1504_ VSS VSS VDD VDD net180 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer66 net180 VSS VSS VDD VDD net181 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer76 _1491_ VSS VSS VDD VDD net195 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer77 _1969_ VSS VSS VDD VDD net196 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer86 net197 VSS VSS VDD VDD net198 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer87 net205 VSS VSS VDD VDD net199 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer88 _1545_ VSS VSS VDD VDD net200 sky130_fd_sc_hd__buf_1
Xrebuffer89 _3706_ VSS VSS VDD VDD net201 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer90 _1469_ VSS VSS VDD VDD net202 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer91 net202 VSS VSS VDD VDD net203 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer92 net202 VSS VSS VDD VDD net204 sky130_fd_sc_hd__dlymetal6s4s_1
Xrebuffer93 _1470_ VSS VSS VDD VDD net205 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer94 _1528_ VSS VSS VDD VDD net206 sky130_fd_sc_hd__buf_1
Xrebuffer95 _1531_ VSS VSS VDD VDD net207 sky130_fd_sc_hd__buf_1
Xrebuffer96 _1917_ VSS VSS VDD VDD net208 sky130_fd_sc_hd__buf_2
Xrebuffer97 _3696_ VSS VSS VDD VDD net209 sky130_fd_sc_hd__clkbuf_2
Xrebuffer98 _1935_ VSS VSS VDD VDD net210 sky130_fd_sc_hd__buf_2
Xrebuffer99 _1318_ VSS VSS VDD VDD net211 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer100 net211 VSS VSS VDD VDD net212 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer101 _3623_ VSS VSS VDD VDD net213 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer102 _3728_ VSS VSS VDD VDD net214 sky130_fd_sc_hd__buf_2
Xrebuffer103 _2018_ VSS VSS VDD VDD net215 sky130_fd_sc_hd__clkbuf_2
Xrebuffer152 _1273_ VSS VSS VDD VDD net264 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer160 _1520_ VSS VSS VDD VDD net272 sky130_fd_sc_hd__buf_1
.ENDS cordic_core
