* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT mesh_router clk east_in_data[0] east_in_data[10] east_in_data[11]
+ east_in_data[12] east_in_data[13] east_in_data[14] east_in_data[15]
+ east_in_data[16] east_in_data[17] east_in_data[18] east_in_data[19]
+ east_in_data[1] east_in_data[20] east_in_data[21] east_in_data[22]
+ east_in_data[23] east_in_data[24] east_in_data[25] east_in_data[26]
+ east_in_data[27] east_in_data[28] east_in_data[29] east_in_data[2]
+ east_in_data[30] east_in_data[31] east_in_data[3] east_in_data[4]
+ east_in_data[5] east_in_data[6] east_in_data[7] east_in_data[8]
+ east_in_data[9] east_in_ready east_in_valid east_out_data[0]
+ east_out_data[10] east_out_data[11] east_out_data[12] east_out_data[13]
+ east_out_data[14] east_out_data[15] east_out_data[16] east_out_data[17]
+ east_out_data[18] east_out_data[19] east_out_data[1] east_out_data[20]
+ east_out_data[21] east_out_data[22] east_out_data[23] east_out_data[24]
+ east_out_data[25] east_out_data[26] east_out_data[27] east_out_data[28]
+ east_out_data[29] east_out_data[2] east_out_data[30] east_out_data[31]
+ east_out_data[3] east_out_data[4] east_out_data[5] east_out_data[6]
+ east_out_data[7] east_out_data[8] east_out_data[9] east_out_ready
+ east_out_valid local_in_data[0] local_in_data[10] local_in_data[11]
+ local_in_data[12] local_in_data[13] local_in_data[14] local_in_data[15]
+ local_in_data[16] local_in_data[17] local_in_data[18] local_in_data[19]
+ local_in_data[1] local_in_data[20] local_in_data[21] local_in_data[22]
+ local_in_data[23] local_in_data[24] local_in_data[25] local_in_data[26]
+ local_in_data[27] local_in_data[28] local_in_data[29] local_in_data[2]
+ local_in_data[30] local_in_data[31] local_in_data[3] local_in_data[4]
+ local_in_data[5] local_in_data[6] local_in_data[7] local_in_data[8]
+ local_in_data[9] local_in_ready local_in_valid local_out_data[0]
+ local_out_data[10] local_out_data[11] local_out_data[12] local_out_data[13]
+ local_out_data[14] local_out_data[15] local_out_data[16] local_out_data[17]
+ local_out_data[18] local_out_data[19] local_out_data[1] local_out_data[20]
+ local_out_data[21] local_out_data[22] local_out_data[23] local_out_data[24]
+ local_out_data[25] local_out_data[26] local_out_data[27] local_out_data[28]
+ local_out_data[29] local_out_data[2] local_out_data[30] local_out_data[31]
+ local_out_data[3] local_out_data[4] local_out_data[5] local_out_data[6]
+ local_out_data[7] local_out_data[8] local_out_data[9] local_out_ready
+ local_out_valid north_in_data[0] north_in_data[10] north_in_data[11]
+ north_in_data[12] north_in_data[13] north_in_data[14] north_in_data[15]
+ north_in_data[16] north_in_data[17] north_in_data[18] north_in_data[19]
+ north_in_data[1] north_in_data[20] north_in_data[21] north_in_data[22]
+ north_in_data[23] north_in_data[24] north_in_data[25] north_in_data[26]
+ north_in_data[27] north_in_data[28] north_in_data[29] north_in_data[2]
+ north_in_data[30] north_in_data[31] north_in_data[3] north_in_data[4]
+ north_in_data[5] north_in_data[6] north_in_data[7] north_in_data[8]
+ north_in_data[9] north_in_ready north_in_valid north_out_data[0]
+ north_out_data[10] north_out_data[11] north_out_data[12] north_out_data[13]
+ north_out_data[14] north_out_data[15] north_out_data[16] north_out_data[17]
+ north_out_data[18] north_out_data[19] north_out_data[1] north_out_data[20]
+ north_out_data[21] north_out_data[22] north_out_data[23] north_out_data[24]
+ north_out_data[25] north_out_data[26] north_out_data[27] north_out_data[28]
+ north_out_data[29] north_out_data[2] north_out_data[30] north_out_data[31]
+ north_out_data[3] north_out_data[4] north_out_data[5] north_out_data[6]
+ north_out_data[7] north_out_data[8] north_out_data[9] north_out_ready
+ north_out_valid rst_n south_in_data[0] south_in_data[10] south_in_data[11]
+ south_in_data[12] south_in_data[13] south_in_data[14] south_in_data[15]
+ south_in_data[16] south_in_data[17] south_in_data[18] south_in_data[19]
+ south_in_data[1] south_in_data[20] south_in_data[21] south_in_data[22]
+ south_in_data[23] south_in_data[24] south_in_data[25] south_in_data[26]
+ south_in_data[27] south_in_data[28] south_in_data[29] south_in_data[2]
+ south_in_data[30] south_in_data[31] south_in_data[3] south_in_data[4]
+ south_in_data[5] south_in_data[6] south_in_data[7] south_in_data[8]
+ south_in_data[9] south_in_ready south_in_valid south_out_data[0]
+ south_out_data[10] south_out_data[11] south_out_data[12] south_out_data[13]
+ south_out_data[14] south_out_data[15] south_out_data[16] south_out_data[17]
+ south_out_data[18] south_out_data[19] south_out_data[1] south_out_data[20]
+ south_out_data[21] south_out_data[22] south_out_data[23] south_out_data[24]
+ south_out_data[25] south_out_data[26] south_out_data[27] south_out_data[28]
+ south_out_data[29] south_out_data[2] south_out_data[30] south_out_data[31]
+ south_out_data[3] south_out_data[4] south_out_data[5] south_out_data[6]
+ south_out_data[7] south_out_data[8] south_out_data[9] south_out_ready
+ south_out_valid west_in_data[0] west_in_data[10] west_in_data[11]
+ west_in_data[12] west_in_data[13] west_in_data[14] west_in_data[15]
+ west_in_data[16] west_in_data[17] west_in_data[18] west_in_data[19]
+ west_in_data[1] west_in_data[20] west_in_data[21] west_in_data[22]
+ west_in_data[23] west_in_data[24] west_in_data[25] west_in_data[26]
+ west_in_data[27] west_in_data[28] west_in_data[29] west_in_data[2]
+ west_in_data[30] west_in_data[31] west_in_data[3] west_in_data[4]
+ west_in_data[5] west_in_data[6] west_in_data[7] west_in_data[8]
+ west_in_data[9] west_in_ready west_in_valid west_out_data[0]
+ west_out_data[10] west_out_data[11] west_out_data[12] west_out_data[13]
+ west_out_data[14] west_out_data[15] west_out_data[16] west_out_data[17]
+ west_out_data[18] west_out_data[19] west_out_data[1] west_out_data[20]
+ west_out_data[21] west_out_data[22] west_out_data[23] west_out_data[24]
+ west_out_data[25] west_out_data[26] west_out_data[27] west_out_data[28]
+ west_out_data[29] west_out_data[2] west_out_data[30] west_out_data[31]
+ west_out_data[3] west_out_data[4] west_out_data[5] west_out_data[6]
+ west_out_data[7] west_out_data[8] west_out_data[9] west_out_ready
+ west_out_valid
X_1163_ input_buffer_valid\[4\] VSS VSS VDD VDD net203 sky130_fd_sc_hd__inv_1
X_1164_ net203 net68 net104 VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__and3_4
X_1165_ input_buffer_valid\[3\] VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__buf_4
X_1166_ _0597_ VSS VSS VDD VDD net301 sky130_fd_sc_hd__clkinv_2
X_1167_ net104 net301 net171 VSS VSS VDD VDD _0006_ sky130_fd_sc_hd__and3_4
X_1168_ input_buffer_valid\[2\] VSS VSS VDD VDD _0598_ sky130_fd_sc_hd__buf_4
X_1169_ _0598_ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__buf_2
X_1170_ _0599_ VSS VSS VDD VDD net271 sky130_fd_sc_hd__inv_1
X_1171_ net104 net271 net137 VSS VSS VDD VDD _0007_ sky130_fd_sc_hd__and3_4
X_1172_ input_buffer_valid\[1\] VSS VSS VDD VDD _0600_ sky130_fd_sc_hd__buf_4
X_1173_ _0600_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__buf_2
X_1174_ _0601_ VSS VSS VDD VDD _0602_ sky130_fd_sc_hd__buf_2
X_1175_ _0602_ VSS VSS VDD VDD net173 sky130_fd_sc_hd__inv_1
X_1176_ net104 net173 net34 VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__and3_4
X_1177_ input_buffer_valid\[0\] VSS VSS VDD VDD _0603_ sky130_fd_sc_hd__buf_2
X_1178_ _0603_ VSS VSS VDD VDD net237 sky130_fd_sc_hd__clkinvlp_4
X_1179_ net104 net237 net102 VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__and3_4
X_1180_ dest_id\[4\]\[1\] VSS VSS VDD VDD _0604_ sky130_fd_sc_hd__clkbuf_4
X_1181_ dest_id\[4\]\[2\] VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__buf_4
X_1182_ dest_id\[4\]\[0\] VSS VSS VDD VDD _0606_ sky130_fd_sc_hd__clkbuf_4
X_1183_ _0604_ _0605_ _0606_ VSS VSS VDD VDD _0607_ sky130_fd_sc_hd__nor3b_2
X_1184_ dest_id\[4\]\[3\] VSS VSS VDD VDD _0608_ sky130_fd_sc_hd__clkbuf_4
X_1185_ _0606_ _0608_ _0605_ VSS VSS VDD VDD _0609_ sky130_fd_sc_hd__nor3b_2
X_1186_ dest_id\[4\]\[5\] dest_id\[4\]\[4\] dest_id\[4\]\[7\]
+ dest_id\[4\]\[6\] VSS VSS VDD VDD _0610_ sky130_fd_sc_hd__nor4_2
X_1187_ _0607_ _0609_ _0610_ VSS VSS VDD VDD _0611_ sky130_fd_sc_hd__o21ai_2
X_1188_ _0611_ VSS VSS VDD VDD _1159_ sky130_fd_sc_hd__inv_1
X_1189_ dest_id\[4\]\[5\] dest_id\[4\]\[4\] dest_id\[4\]\[7\]
+ dest_id\[4\]\[6\] VSS VSS VDD VDD _0612_ sky130_fd_sc_hd__or4_1
X_1190_ _0612_ VSS VSS VDD VDD _0613_ sky130_fd_sc_hd__clkbuf_4
X_1191_ dest_id\[4\]\[0\] _0608_ _0605_ VSS VSS VDD VDD _0614_
+ sky130_fd_sc_hd__or3b_1
X_1192_ _0614_ VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__buf_4
X_1193_ _0613_ _0615_ VSS VSS VDD VDD _1148_ sky130_fd_sc_hd__nor2_2
X_1194_ _1148_ VSS VSS VDD VDD _1151_ sky130_fd_sc_hd__inv_1
X_1195_ _0605_ _0608_ _0606_ VSS VSS VDD VDD _0616_ sky130_fd_sc_hd__nand3b_1
X_1196_ _0615_ _0616_ _0604_ _0613_ VSS VSS VDD VDD _1147_
+ sky130_fd_sc_hd__a211o_1
X_1197_ _1147_ VSS VSS VDD VDD _1154_ sky130_fd_sc_hd__inv_1
X_1198_ net172 _0609_ _1151_ net138 _1147_ VSS VSS VDD VDD
+ _0617_ sky130_fd_sc_hd__a221oi_1
X_1199_ _0604_ _0605_ dest_id\[4\]\[0\] VSS VSS VDD VDD _0618_
+ sky130_fd_sc_hd__or3b_1
X_1200_ _0618_ VSS VSS VDD VDD _0619_ sky130_fd_sc_hd__buf_2
X_1201_ _0606_ _0604_ _0605_ VSS VSS VDD VDD _0620_ sky130_fd_sc_hd__nand3b_1
X_1202_ _0619_ _0620_ _0608_ _0613_ VSS VSS VDD VDD _0621_
+ sky130_fd_sc_hd__a211oi_2
X_1203_ net103 _1151_ VSS VSS VDD VDD _0622_ sky130_fd_sc_hd__nand2_1
X_1204_ net35 _1148_ VSS VSS VDD VDD _0623_ sky130_fd_sc_hd__nand2_1
X_1205_ _0621_ _0622_ _0623_ VSS VSS VDD VDD _0624_ sky130_fd_sc_hd__and3_1
X_1206_ input_buffer_valid\[4\] VSS VSS VDD VDD _0625_ sky130_fd_sc_hd__buf_4
X_1207_ net69 _1159_ _0625_ VSS VSS VDD VDD _0626_ sky130_fd_sc_hd__o21ai_0
X_1208_ _0617_ _0624_ _0626_ net68 _0625_ VSS VSS VDD VDD
+ _0004_ sky130_fd_sc_hd__o32a_1
X_1209_ dest_id\[3\]\[1\] VSS VSS VDD VDD _0627_ sky130_fd_sc_hd__buf_4
X_1210_ dest_id\[3\]\[2\] VSS VSS VDD VDD _0628_ sky130_fd_sc_hd__buf_4
X_1211_ _0627_ _0628_ dest_id\[3\]\[0\] VSS VSS VDD VDD _0629_
+ sky130_fd_sc_hd__or3b_2
X_1212_ dest_id\[3\]\[0\] dest_id\[3\]\[3\] dest_id\[3\]\[2\]
+ VSS VSS VDD VDD _0630_ sky130_fd_sc_hd__or3b_2
X_1213_ dest_id\[3\]\[5\] dest_id\[3\]\[4\] dest_id\[3\]\[7\]
+ dest_id\[3\]\[6\] VSS VSS VDD VDD _0631_ sky130_fd_sc_hd__or4_2
X_1214_ _0629_ _0630_ _0631_ VSS VSS VDD VDD _1144_ sky130_fd_sc_hd__a21oi_4
X_1215_ _0631_ _0630_ VSS VSS VDD VDD _1133_ sky130_fd_sc_hd__nor2_1
X_1216_ _1133_ VSS VSS VDD VDD _1136_ sky130_fd_sc_hd__inv_1
X_1217_ _0627_ VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__inv_1
X_1218_ dest_id\[3\]\[5\] dest_id\[3\]\[4\] dest_id\[3\]\[7\]
+ dest_id\[3\]\[6\] VSS VSS VDD VDD _0633_ sky130_fd_sc_hd__nor4_4
X_1219_ dest_id\[3\]\[0\] VSS VSS VDD VDD _0634_ sky130_fd_sc_hd__buf_4
X_1220_ _0634_ dest_id\[3\]\[3\] VSS VSS VDD VDD _0635_ sky130_fd_sc_hd__nand2_1
X_1221_ _0628_ _0635_ _0630_ VSS VSS VDD VDD _0636_ sky130_fd_sc_hd__o21ai_0
X_1222_ _0632_ _0633_ _0636_ VSS VSS VDD VDD _1139_ sky130_fd_sc_hd__and3_1
X_1223_ _0597_ VSS VSS VDD VDD _0637_ sky130_fd_sc_hd__buf_2
X_1224_ _1145_ _1134_ _1140_ _1142_ VSS VSS VDD VDD _0638_
+ sky130_fd_sc_hd__nor4_1
X_1225_ net69 _1144_ VSS VSS VDD VDD _0639_ sky130_fd_sc_hd__nor2_1
X_1226_ _1144_ _0638_ _0639_ VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__a21oi_1
X_1227_ net138 _0630_ VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__nand2_1
X_1228_ _0634_ dest_id\[3\]\[3\] _0628_ VSS VSS VDD VDD _0642_
+ sky130_fd_sc_hd__nor3b_4
X_1229_ net172 _0642_ VSS VSS VDD VDD _0643_ sky130_fd_sc_hd__nand2_1
X_1230_ dest_id\[3\]\[3\] _0631_ VSS VSS VDD VDD _0644_ sky130_fd_sc_hd__nor2_1
X_1231_ _0634_ _0628_ VSS VSS VDD VDD _0645_ sky130_fd_sc_hd__nand2b_1
X_1232_ net35 _0632_ _0645_ _0629_ net103 VSS VSS VDD VDD
+ _0646_ sky130_fd_sc_hd__o32ai_1
X_1233_ _1139_ _0641_ _0643_ _0644_ _0646_ VSS VSS VDD VDD
+ _0647_ sky130_fd_sc_hd__a32oi_1
X_1234_ _0637_ net171 VSS VSS VDD VDD _0648_ sky130_fd_sc_hd__nor2_1
X_1235_ _0637_ _0640_ _0647_ _0648_ VSS VSS VDD VDD _0003_
+ sky130_fd_sc_hd__a31oi_1
X_1236_ dest_id\[2\]\[2\] VSS VSS VDD VDD _0649_ sky130_fd_sc_hd__buf_4
X_1237_ dest_id\[2\]\[0\] VSS VSS VDD VDD _0650_ sky130_fd_sc_hd__buf_4
X_1238_ dest_id\[2\]\[1\] _0649_ _0650_ VSS VSS VDD VDD _0651_
+ sky130_fd_sc_hd__nor3b_4
X_1239_ dest_id\[2\]\[3\] VSS VSS VDD VDD _0652_ sky130_fd_sc_hd__clkbuf_4
X_1240_ _0650_ _0652_ _0649_ VSS VSS VDD VDD _0653_ sky130_fd_sc_hd__nor3b_2
X_1241_ dest_id\[2\]\[5\] dest_id\[2\]\[4\] dest_id\[2\]\[7\]
+ dest_id\[2\]\[6\] VSS VSS VDD VDD _0654_ sky130_fd_sc_hd__nor4_4
X_1242_ _0651_ _0653_ _0654_ VSS VSS VDD VDD _0655_ sky130_fd_sc_hd__o21ai_4
X_1243_ _0655_ VSS VSS VDD VDD _1129_ sky130_fd_sc_hd__inv_1
X_1244_ dest_id\[2\]\[5\] dest_id\[2\]\[4\] dest_id\[2\]\[7\]
+ dest_id\[2\]\[6\] VSS VSS VDD VDD _0656_ sky130_fd_sc_hd__or4_4
X_1245_ dest_id\[2\]\[0\] _0652_ dest_id\[2\]\[2\] VSS VSS
+ VDD VDD _0657_ sky130_fd_sc_hd__or3b_1
X_1246_ _0657_ VSS VSS VDD VDD _0658_ sky130_fd_sc_hd__clkbuf_2
X_1247_ _0656_ _0658_ VSS VSS VDD VDD _1118_ sky130_fd_sc_hd__nor2_1
X_1248_ _1118_ VSS VSS VDD VDD _1121_ sky130_fd_sc_hd__inv_1
X_1249_ dest_id\[2\]\[1\] VSS VSS VDD VDD _0659_ sky130_fd_sc_hd__inv_1
X_1250_ _0650_ _0652_ VSS VSS VDD VDD _0660_ sky130_fd_sc_hd__nand2_1
X_1251_ _0649_ _0660_ _0658_ VSS VSS VDD VDD _0661_ sky130_fd_sc_hd__o21ai_0
X_1252_ _0659_ _0654_ _0661_ VSS VSS VDD VDD _1124_ sky130_fd_sc_hd__and3_1
X_1253_ _1130_ _1119_ _1125_ _1127_ VSS VSS VDD VDD _0662_
+ sky130_fd_sc_hd__nor4_1
X_1254_ net69 _0655_ VSS VSS VDD VDD _0663_ sky130_fd_sc_hd__nand2_1
X_1255_ _0655_ _0662_ _0663_ VSS VSS VDD VDD _0664_ sky130_fd_sc_hd__o21ai_0
X_1256_ net138 _0658_ VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__nand2_1
X_1257_ net172 _0653_ VSS VSS VDD VDD _0666_ sky130_fd_sc_hd__nand2_1
X_1258_ _0652_ _0656_ VSS VSS VDD VDD _0667_ sky130_fd_sc_hd__nor2_1
X_1259_ _0650_ _0649_ VSS VSS VDD VDD _0668_ sky130_fd_sc_hd__nand2b_1
X_1260_ dest_id\[2\]\[1\] _0649_ _0650_ VSS VSS VDD VDD _0669_
+ sky130_fd_sc_hd__or3b_2
X_1261_ net35 _0659_ _0668_ _0669_ net103 VSS VSS VDD VDD
+ _0670_ sky130_fd_sc_hd__o32ai_1
X_1262_ _1124_ _0665_ _0666_ _0667_ _0670_ VSS VSS VDD VDD
+ _0671_ sky130_fd_sc_hd__a32oi_1
X_1263_ _0599_ net137 VSS VSS VDD VDD _0672_ sky130_fd_sc_hd__nor2_1
X_1264_ _0599_ _0664_ _0671_ _0672_ VSS VSS VDD VDD _0002_
+ sky130_fd_sc_hd__a31oi_1
X_1265_ dest_id\[1\]\[1\] VSS VSS VDD VDD _0673_ sky130_fd_sc_hd__clkbuf_4
X_1266_ dest_id\[1\]\[2\] VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__clkbuf_4
X_1267_ _0673_ _0674_ dest_id\[1\]\[0\] VSS VSS VDD VDD _0675_
+ sky130_fd_sc_hd__nor3b_2
X_1268_ dest_id\[1\]\[0\] VSS VSS VDD VDD _0676_ sky130_fd_sc_hd__clkbuf_4
X_1269_ dest_id\[1\]\[3\] VSS VSS VDD VDD _0677_ sky130_fd_sc_hd__buf_4
X_1270_ _0676_ _0677_ dest_id\[1\]\[2\] VSS VSS VDD VDD _0678_
+ sky130_fd_sc_hd__nor3b_2
X_1271_ dest_id\[1\]\[5\] dest_id\[1\]\[4\] dest_id\[1\]\[7\]
+ dest_id\[1\]\[6\] VSS VSS VDD VDD _0679_ sky130_fd_sc_hd__nor4_2
X_1272_ _0675_ _0678_ _0679_ VSS VSS VDD VDD _0680_ sky130_fd_sc_hd__o21ai_2
X_1273_ _0680_ VSS VSS VDD VDD _0681_ sky130_fd_sc_hd__clkbuf_4
X_1274_ _0681_ VSS VSS VDD VDD _0682_ sky130_fd_sc_hd__clkbuf_4
X_1275_ _0682_ VSS VSS VDD VDD _1114_ sky130_fd_sc_hd__inv_1
X_1276_ _0679_ VSS VSS VDD VDD _0683_ sky130_fd_sc_hd__buf_4
X_1277_ _0683_ VSS VSS VDD VDD _0684_ sky130_fd_sc_hd__buf_2
X_1278_ _0678_ VSS VSS VDD VDD _0685_ sky130_fd_sc_hd__buf_4
X_1279_ _0685_ VSS VSS VDD VDD _0686_ sky130_fd_sc_hd__buf_2
X_1280_ _0684_ _0686_ VSS VSS VDD VDD _1106_ sky130_fd_sc_hd__nand2_2
X_1281_ _0676_ _0677_ _0674_ VSS VSS VDD VDD _0687_ sky130_fd_sc_hd__or3b_1
X_1282_ _0674_ _0677_ _0676_ VSS VSS VDD VDD _0688_ sky130_fd_sc_hd__nand3b_1
X_1283_ dest_id\[1\]\[5\] dest_id\[1\]\[4\] dest_id\[1\]\[7\]
+ dest_id\[1\]\[6\] VSS VSS VDD VDD _0689_ sky130_fd_sc_hd__or4_2
X_1284_ _0687_ _0688_ _0673_ _0689_ VSS VSS VDD VDD _1102_
+ sky130_fd_sc_hd__a211o_1
X_1285_ _1102_ VSS VSS VDD VDD _1109_ sky130_fd_sc_hd__clkinvlp_4
X_1286_ net35 net172 _1109_ VSS VSS VDD VDD _0690_ sky130_fd_sc_hd__mux2i_1
X_1287_ net103 net138 _1109_ VSS VSS VDD VDD _0691_ sky130_fd_sc_hd__mux2i_1
X_1288_ _0690_ _0691_ _1106_ VSS VSS VDD VDD _0692_ sky130_fd_sc_hd__mux2i_1
X_1289_ _1115_ _1104_ _1110_ _1112_ VSS VSS VDD VDD _0693_
+ sky130_fd_sc_hd__nor4_1
X_1290_ net173 _0682_ _0693_ VSS VSS VDD VDD _0694_ sky130_fd_sc_hd__nor3_1
X_1291_ _0602_ net69 _0682_ VSS VSS VDD VDD _0695_ sky130_fd_sc_hd__nand3_1
X_1292_ _0602_ net34 _0695_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__o21ai_0
X_1293_ _0692_ _0694_ _0696_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__a21oi_1
X_1294_ dest_id\[0\]\[2\] VSS VSS VDD VDD _0697_ sky130_fd_sc_hd__clkbuf_4
X_1295_ dest_id\[0\]\[0\] dest_id\[0\]\[3\] _0697_ VSS VSS
+ VDD VDD _0698_ sky130_fd_sc_hd__nor3b_4
X_1296_ dest_id\[0\]\[0\] VSS VSS VDD VDD _0699_ sky130_fd_sc_hd__inv_1
X_1297_ dest_id\[0\]\[3\] VSS VSS VDD VDD _0700_ sky130_fd_sc_hd__inv_1
X_1298_ _0699_ _0700_ _0697_ VSS VSS VDD VDD _0701_ sky130_fd_sc_hd__nor3_1
X_1299_ dest_id\[0\]\[5\] dest_id\[0\]\[4\] dest_id\[0\]\[7\]
+ dest_id\[0\]\[6\] VSS VSS VDD VDD _0702_ sky130_fd_sc_hd__nor4_4
X_1300_ dest_id\[0\]\[1\] _0702_ VSS VSS VDD VDD _0703_ sky130_fd_sc_hd__nor2b_2
X_1301_ _0698_ _0701_ _0703_ VSS VSS VDD VDD _1091_ sky130_fd_sc_hd__o21a_2
X_1302_ _0702_ _0698_ VSS VSS VDD VDD _1094_ sky130_fd_sc_hd__nand2_2
X_1303_ net35 net103 _1094_ VSS VSS VDD VDD _0704_ sky130_fd_sc_hd__mux2i_1
X_1304_ net172 net138 _1094_ VSS VSS VDD VDD _0705_ sky130_fd_sc_hd__mux2i_1
X_1305_ _0704_ _0705_ _1091_ VSS VSS VDD VDD _0706_ sky130_fd_sc_hd__mux2i_1
X_1306_ dest_id\[0\]\[1\] _0697_ dest_id\[0\]\[0\] VSS VSS
+ VDD VDD _0707_ sky130_fd_sc_hd__nor3b_4
X_1307_ _0698_ _0707_ _0702_ VSS VSS VDD VDD _0708_ sky130_fd_sc_hd__o21ai_4
X_1308_ _1100_ VSS VSS VDD VDD _0709_ sky130_fd_sc_hd__clkbuf_2
X_1309_ _0709_ VSS VSS VDD VDD _0710_ sky130_fd_sc_hd__buf_4
X_1310_ _1089_ _1092_ _1097_ _0710_ VSS VSS VDD VDD _0711_
+ sky130_fd_sc_hd__nor4_1
X_1311_ net237 _0708_ _0711_ VSS VSS VDD VDD _0712_ sky130_fd_sc_hd__nor3_1
X_1312_ _0603_ VSS VSS VDD VDD _0713_ sky130_fd_sc_hd__buf_4
X_1313_ _0713_ VSS VSS VDD VDD _0714_ sky130_fd_sc_hd__clkbuf_4
X_1314_ _0714_ net69 _0708_ VSS VSS VDD VDD _0715_ sky130_fd_sc_hd__nand3_1
X_1315_ _0714_ net102 _0715_ VSS VSS VDD VDD _0716_ sky130_fd_sc_hd__o21ai_0
X_1316_ _0706_ _0712_ _0716_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__a21oi_1
X_1317_ _1094_ VSS VSS VDD VDD _1087_ sky130_fd_sc_hd__inv_1
X_1318_ _1124_ VSS VSS VDD VDD _1117_ sky130_fd_sc_hd__inv_1
X_1319_ _1139_ VSS VSS VDD VDD _1132_ sky130_fd_sc_hd__inv_1
X_1320_ _1091_ VSS VSS VDD VDD _1088_ sky130_fd_sc_hd__inv_1
X_1321_ _0708_ VSS VSS VDD VDD _1099_ sky130_fd_sc_hd__clkinv_2
X_1322_ _1106_ VSS VSS VDD VDD _1103_ sky130_fd_sc_hd__inv_1
X_1323_ _0651_ _0653_ _0598_ _1119_ _0654_ VSS VSS VDD VDD
+ _0717_ sky130_fd_sc_hd__o2111ai_4
X_1324_ _0717_ VSS VSS VDD VDD _0718_ sky130_fd_sc_hd__clkbuf_4
X_1325_ _0718_ VSS VSS VDD VDD _0719_ sky130_fd_sc_hd__clkbuf_4
X_1326_ _0698_ _0707_ _1089_ _0702_ VSS VSS VDD VDD _0720_
+ sky130_fd_sc_hd__o211ai_4
X_1327_ _0720_ VSS VSS VDD VDD _0721_ sky130_fd_sc_hd__clkbuf_4
X_1328_ _0600_ _1104_ VSS VSS VDD VDD _0722_ sky130_fd_sc_hd__and2_0
X_1329_ _0722_ VSS VSS VDD VDD _0723_ sky130_fd_sc_hd__clkbuf_2
X_1330_ _0675_ _0678_ _0723_ _0679_ VSS VSS VDD VDD _0724_
+ sky130_fd_sc_hd__o211a_1
X_1331_ _0724_ VSS VSS VDD VDD _0725_ sky130_fd_sc_hd__buf_2
X_1332_ _0725_ VSS VSS VDD VDD _0726_ sky130_fd_sc_hd__clkbuf_4
X_1333_ _0603_ VSS VSS VDD VDD _0727_ sky130_fd_sc_hd__buf_4
X_1334_ _0727_ input_buffer\[0\]\[0\] VSS VSS VDD VDD _0728_
+ sky130_fd_sc_hd__nand2_1
X_1335_ _0718_ VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__buf_4
X_1336_ _0675_ VSS VSS VDD VDD _0730_ sky130_fd_sc_hd__buf_4
X_1337_ _0730_ VSS VSS VDD VDD _0731_ sky130_fd_sc_hd__buf_2
X_1338_ _0723_ VSS VSS VDD VDD _0732_ sky130_fd_sc_hd__clkbuf_4
X_1339_ _0731_ _0686_ _0732_ _0684_ input_buffer\[1\]\[0\]
+ VSS VSS VDD VDD _0733_ sky130_fd_sc_hd__o2111ai_1
X_1340_ _0721_ _0726_ _0728_ _0729_ _0733_ VSS VSS VDD VDD
+ _0734_ sky130_fd_sc_hd__o311ai_1
X_1341_ _0627_ _0628_ _0634_ VSS VSS VDD VDD _0735_ sky130_fd_sc_hd__nor3b_4
X_1342_ _0735_ _0642_ _0597_ _1134_ _0633_ VSS VSS VDD VDD
+ _0736_ sky130_fd_sc_hd__o2111ai_4
X_1343_ _0736_ VSS VSS VDD VDD _0737_ sky130_fd_sc_hd__clkbuf_4
X_1344_ input_buffer\[2\]\[0\] _0719_ _0734_ _0737_ VSS VSS
+ VDD VDD _0738_ sky130_fd_sc_hd__o211ai_1
X_1345_ _0607_ _0609_ _0625_ _1149_ _0610_ VSS VSS VDD VDD
+ _0739_ sky130_fd_sc_hd__o2111ai_4
X_1346_ _0739_ VSS VSS VDD VDD _0740_ sky130_fd_sc_hd__buf_4
X_1347_ _0740_ VSS VSS VDD VDD _0741_ sky130_fd_sc_hd__buf_4
X_1348_ _0597_ _1134_ _1144_ VSS VSS VDD VDD _0742_ sky130_fd_sc_hd__and3_1
X_1349_ _0742_ VSS VSS VDD VDD _0743_ sky130_fd_sc_hd__buf_4
X_1350_ _0743_ VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__buf_6
X_1351_ input_buffer\[3\]\[0\] _0744_ VSS VSS VDD VDD _0745_
+ sky130_fd_sc_hd__nand2_1
X_1352_ input_buffer\[4\]\[0\] _0741_ VSS VSS VDD VDD _0746_
+ sky130_fd_sc_hd__nor2_1
X_1353_ _0738_ _0741_ _0745_ _0746_ VSS VSS VDD VDD net174
+ sky130_fd_sc_hd__a31oi_2
X_1354_ _0740_ VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__clkbuf_4
X_1355_ _0727_ input_buffer\[0\]\[10\] VSS VSS VDD VDD _0748_
+ sky130_fd_sc_hd__nand2_1
X_1356_ _0731_ _0686_ _0732_ _0684_ input_buffer\[1\]\[10\]
+ VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__o2111ai_1
X_1357_ _0721_ _0726_ _0748_ _0749_ _0729_ VSS VSS VDD VDD
+ _0750_ sky130_fd_sc_hd__o311ai_1
X_1358_ input_buffer\[2\]\[10\] _0719_ _0737_ _0750_ VSS VSS
+ VDD VDD _0751_ sky130_fd_sc_hd__o211ai_1
X_1359_ input_buffer\[3\]\[10\] _0744_ VSS VSS VDD VDD _0752_
+ sky130_fd_sc_hd__nand2_1
X_1360_ input_buffer\[4\]\[10\] _0741_ VSS VSS VDD VDD _0753_
+ sky130_fd_sc_hd__nor2_1
X_1361_ _0747_ _0751_ _0752_ _0753_ VSS VSS VDD VDD net175
+ sky130_fd_sc_hd__a31oi_1
X_1362_ _0603_ VSS VSS VDD VDD _0754_ sky130_fd_sc_hd__buf_4
X_1363_ _0754_ input_buffer\[0\]\[11\] VSS VSS VDD VDD _0755_
+ sky130_fd_sc_hd__nand2_1
X_1364_ _0731_ _0686_ _0732_ _0684_ input_buffer\[1\]\[11\]
+ VSS VSS VDD VDD _0756_ sky130_fd_sc_hd__o2111ai_1
X_1365_ _0721_ _0726_ _0755_ _0756_ _0729_ VSS VSS VDD VDD
+ _0757_ sky130_fd_sc_hd__o311ai_2
X_1366_ input_buffer\[2\]\[11\] _0719_ _0737_ _0757_ VSS VSS
+ VDD VDD _0758_ sky130_fd_sc_hd__o211ai_1
X_1367_ input_buffer\[3\]\[11\] _0744_ VSS VSS VDD VDD _0759_
+ sky130_fd_sc_hd__nand2_1
X_1368_ input_buffer\[4\]\[11\] _0741_ VSS VSS VDD VDD _0760_
+ sky130_fd_sc_hd__nor2_1
X_1369_ _0747_ _0758_ _0759_ _0760_ VSS VSS VDD VDD net176
+ sky130_fd_sc_hd__a31oi_1
X_1370_ _0727_ input_buffer\[0\]\[12\] VSS VSS VDD VDD _0761_
+ sky130_fd_sc_hd__nand2_1
X_1371_ _0731_ _0686_ _0732_ _0684_ input_buffer\[1\]\[12\]
+ VSS VSS VDD VDD _0762_ sky130_fd_sc_hd__o2111ai_1
X_1372_ _0718_ VSS VSS VDD VDD _0763_ sky130_fd_sc_hd__clkbuf_4
X_1373_ _0721_ _0726_ _0761_ _0762_ _0763_ VSS VSS VDD VDD
+ _0764_ sky130_fd_sc_hd__o311ai_1
X_1374_ input_buffer\[2\]\[12\] _0719_ _0737_ _0764_ VSS VSS
+ VDD VDD _0765_ sky130_fd_sc_hd__o211ai_1
X_1375_ input_buffer\[3\]\[12\] _0744_ VSS VSS VDD VDD _0766_
+ sky130_fd_sc_hd__nand2_1
X_1376_ _0739_ VSS VSS VDD VDD _0767_ sky130_fd_sc_hd__buf_4
X_1377_ input_buffer\[4\]\[12\] _0767_ VSS VSS VDD VDD _0768_
+ sky130_fd_sc_hd__nor2_1
X_1378_ _0747_ _0765_ _0766_ _0768_ VSS VSS VDD VDD net177
+ sky130_fd_sc_hd__a31oi_1
X_1379_ _0727_ input_buffer\[0\]\[13\] VSS VSS VDD VDD _0769_
+ sky130_fd_sc_hd__nand2_1
X_1380_ _0731_ _0686_ _0732_ _0684_ input_buffer\[1\]\[13\]
+ VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__o2111ai_1
X_1381_ _0721_ _0726_ _0769_ _0770_ _0763_ VSS VSS VDD VDD
+ _0771_ sky130_fd_sc_hd__o311ai_1
X_1382_ input_buffer\[2\]\[13\] _0719_ _0737_ _0771_ VSS VSS
+ VDD VDD _0772_ sky130_fd_sc_hd__o211ai_1
X_1383_ input_buffer\[3\]\[13\] _0744_ VSS VSS VDD VDD _0773_
+ sky130_fd_sc_hd__nand2_1
X_1384_ input_buffer\[4\]\[13\] _0767_ VSS VSS VDD VDD _0774_
+ sky130_fd_sc_hd__nor2_1
X_1385_ _0747_ _0772_ _0773_ _0774_ VSS VSS VDD VDD net178
+ sky130_fd_sc_hd__a31oi_1
X_1386_ _0724_ VSS VSS VDD VDD _0775_ sky130_fd_sc_hd__clkbuf_4
X_1387_ _0754_ input_buffer\[0\]\[14\] VSS VSS VDD VDD _0776_
+ sky130_fd_sc_hd__nand2_1
X_1388_ _0731_ _0686_ _0732_ _0684_ input_buffer\[1\]\[14\]
+ VSS VSS VDD VDD _0777_ sky130_fd_sc_hd__o2111ai_1
X_1389_ _0721_ _0775_ _0776_ _0777_ _0763_ VSS VSS VDD VDD
+ _0778_ sky130_fd_sc_hd__o311ai_2
X_1390_ input_buffer\[2\]\[14\] _0719_ _0737_ _0778_ VSS VSS
+ VDD VDD _0779_ sky130_fd_sc_hd__o211ai_1
X_1391_ input_buffer\[3\]\[14\] _0744_ VSS VSS VDD VDD _0780_
+ sky130_fd_sc_hd__nand2_1
X_1392_ input_buffer\[4\]\[14\] _0767_ VSS VSS VDD VDD _0781_
+ sky130_fd_sc_hd__nor2_1
X_1393_ _0747_ _0779_ _0780_ _0781_ VSS VSS VDD VDD net179
+ sky130_fd_sc_hd__a31oi_1
X_1394_ _0754_ input_buffer\[0\]\[15\] VSS VSS VDD VDD _0782_
+ sky130_fd_sc_hd__nand2_1
X_1395_ _0731_ _0686_ _0732_ _0684_ input_buffer\[1\]\[15\]
+ VSS VSS VDD VDD _0783_ sky130_fd_sc_hd__o2111ai_1
X_1396_ _0721_ _0775_ _0782_ _0783_ _0763_ VSS VSS VDD VDD
+ _0784_ sky130_fd_sc_hd__o311ai_0
X_1397_ input_buffer\[2\]\[15\] _0719_ _0737_ _0784_ VSS VSS
+ VDD VDD _0785_ sky130_fd_sc_hd__o211ai_1
X_1398_ input_buffer\[3\]\[15\] _0744_ VSS VSS VDD VDD _0786_
+ sky130_fd_sc_hd__nand2_1
X_1399_ input_buffer\[4\]\[15\] _0767_ VSS VSS VDD VDD _0787_
+ sky130_fd_sc_hd__nor2_1
X_1400_ _0747_ _0785_ _0786_ _0787_ VSS VSS VDD VDD net180
+ sky130_fd_sc_hd__a31oi_1
X_1401_ _0754_ input_buffer\[0\]\[16\] VSS VSS VDD VDD _0788_
+ sky130_fd_sc_hd__nand2_1
X_1402_ _0731_ _0686_ _0732_ _0684_ input_buffer\[1\]\[16\]
+ VSS VSS VDD VDD _0789_ sky130_fd_sc_hd__o2111ai_1
X_1403_ _0721_ _0775_ _0788_ _0789_ _0763_ VSS VSS VDD VDD
+ _0790_ sky130_fd_sc_hd__o311ai_0
X_1404_ input_buffer\[2\]\[16\] _0719_ _0737_ _0790_ VSS VSS
+ VDD VDD _0791_ sky130_fd_sc_hd__o211ai_1
X_1405_ input_buffer\[3\]\[16\] _0744_ VSS VSS VDD VDD _0792_
+ sky130_fd_sc_hd__nand2_1
X_1406_ input_buffer\[4\]\[16\] _0767_ VSS VSS VDD VDD _0793_
+ sky130_fd_sc_hd__nor2_1
X_1407_ _0747_ _0791_ _0792_ _0793_ VSS VSS VDD VDD net181
+ sky130_fd_sc_hd__a31oi_1
X_1408_ _0727_ input_buffer\[0\]\[17\] VSS VSS VDD VDD _0794_
+ sky130_fd_sc_hd__nand2_1
X_1409_ _0731_ _0686_ _0732_ _0684_ input_buffer\[1\]\[17\]
+ VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__o2111ai_1
X_1410_ _0721_ _0775_ _0794_ _0795_ _0763_ VSS VSS VDD VDD
+ _0796_ sky130_fd_sc_hd__o311ai_0
X_1411_ input_buffer\[2\]\[17\] _0719_ _0737_ _0796_ VSS VSS
+ VDD VDD _0797_ sky130_fd_sc_hd__o211ai_1
X_1412_ input_buffer\[3\]\[17\] _0744_ VSS VSS VDD VDD _0798_
+ sky130_fd_sc_hd__nand2_1
X_1413_ input_buffer\[4\]\[17\] _0767_ VSS VSS VDD VDD _0799_
+ sky130_fd_sc_hd__nor2_1
X_1414_ _0747_ _0797_ _0798_ _0799_ VSS VSS VDD VDD net182
+ sky130_fd_sc_hd__a31oi_2
X_1415_ _0718_ VSS VSS VDD VDD _0800_ sky130_fd_sc_hd__clkbuf_4
X_1416_ _0736_ VSS VSS VDD VDD _0801_ sky130_fd_sc_hd__clkbuf_4
X_1417_ _0754_ input_buffer\[0\]\[18\] VSS VSS VDD VDD _0802_
+ sky130_fd_sc_hd__nand2_1
X_1418_ _0730_ VSS VSS VDD VDD _0803_ sky130_fd_sc_hd__buf_2
X_1419_ _0685_ VSS VSS VDD VDD _0804_ sky130_fd_sc_hd__buf_2
X_1420_ _0683_ VSS VSS VDD VDD _0805_ sky130_fd_sc_hd__buf_2
X_1421_ _0803_ _0804_ _0732_ _0805_ input_buffer\[1\]\[18\]
+ VSS VSS VDD VDD _0806_ sky130_fd_sc_hd__o2111ai_1
X_1422_ _0721_ _0775_ _0802_ _0806_ _0763_ VSS VSS VDD VDD
+ _0807_ sky130_fd_sc_hd__o311ai_0
X_1423_ input_buffer\[2\]\[18\] _0800_ _0801_ _0807_ VSS VSS
+ VDD VDD _0808_ sky130_fd_sc_hd__o211ai_1
X_1424_ input_buffer\[3\]\[18\] _0744_ VSS VSS VDD VDD _0809_
+ sky130_fd_sc_hd__nand2_1
X_1425_ input_buffer\[4\]\[18\] _0767_ VSS VSS VDD VDD _0810_
+ sky130_fd_sc_hd__nor2_1
X_1426_ _0747_ _0808_ _0809_ _0810_ VSS VSS VDD VDD net183
+ sky130_fd_sc_hd__a31oi_1
X_1427_ _0720_ VSS VSS VDD VDD _0811_ sky130_fd_sc_hd__buf_2
X_1428_ _0727_ input_buffer\[0\]\[19\] VSS VSS VDD VDD _0812_
+ sky130_fd_sc_hd__nand2_1
X_1429_ _0723_ VSS VSS VDD VDD _0813_ sky130_fd_sc_hd__clkbuf_4
X_1430_ _0803_ _0804_ _0813_ _0805_ input_buffer\[1\]\[19\]
+ VSS VSS VDD VDD _0814_ sky130_fd_sc_hd__o2111ai_1
X_1431_ _0811_ _0775_ _0812_ _0814_ _0763_ VSS VSS VDD VDD
+ _0815_ sky130_fd_sc_hd__o311ai_1
X_1432_ input_buffer\[2\]\[19\] _0800_ _0801_ _0815_ VSS VSS
+ VDD VDD _0816_ sky130_fd_sc_hd__o211ai_1
X_1433_ _0743_ VSS VSS VDD VDD _0817_ sky130_fd_sc_hd__buf_6
X_1434_ input_buffer\[3\]\[19\] _0817_ VSS VSS VDD VDD _0818_
+ sky130_fd_sc_hd__nand2_1
X_1435_ input_buffer\[4\]\[19\] _0767_ VSS VSS VDD VDD _0819_
+ sky130_fd_sc_hd__nor2_1
X_1436_ _0747_ _0816_ _0818_ _0819_ VSS VSS VDD VDD net184
+ sky130_fd_sc_hd__a31oi_1
X_1437_ _0740_ VSS VSS VDD VDD _0820_ sky130_fd_sc_hd__buf_4
X_1438_ _0754_ input_buffer\[0\]\[1\] VSS VSS VDD VDD _0821_
+ sky130_fd_sc_hd__nand2_1
X_1439_ _0803_ _0804_ _0813_ _0805_ input_buffer\[1\]\[1\]
+ VSS VSS VDD VDD _0822_ sky130_fd_sc_hd__o2111ai_1
X_1440_ _0811_ _0775_ _0821_ _0822_ _0763_ VSS VSS VDD VDD
+ _0823_ sky130_fd_sc_hd__o311ai_0
X_1441_ input_buffer\[2\]\[1\] _0800_ _0801_ _0823_ VSS VSS
+ VDD VDD _0824_ sky130_fd_sc_hd__o211ai_1
X_1442_ input_buffer\[3\]\[1\] _0817_ VSS VSS VDD VDD _0825_
+ sky130_fd_sc_hd__nand2_1
X_1443_ input_buffer\[4\]\[1\] _0767_ VSS VSS VDD VDD _0826_
+ sky130_fd_sc_hd__nor2_1
X_1444_ _0820_ _0824_ _0825_ _0826_ VSS VSS VDD VDD net185
+ sky130_fd_sc_hd__a31oi_1
X_1445_ _0754_ input_buffer\[0\]\[20\] VSS VSS VDD VDD _0827_
+ sky130_fd_sc_hd__nand2_1
X_1446_ _0803_ _0804_ _0813_ _0805_ input_buffer\[1\]\[20\]
+ VSS VSS VDD VDD _0828_ sky130_fd_sc_hd__o2111ai_1
X_1447_ _0811_ _0775_ _0827_ _0828_ _0763_ VSS VSS VDD VDD
+ _0829_ sky130_fd_sc_hd__o311ai_0
X_1448_ input_buffer\[2\]\[20\] _0800_ _0801_ _0829_ VSS VSS
+ VDD VDD _0830_ sky130_fd_sc_hd__o211ai_1
X_1449_ input_buffer\[3\]\[20\] _0817_ VSS VSS VDD VDD _0831_
+ sky130_fd_sc_hd__nand2_1
X_1450_ input_buffer\[4\]\[20\] _0767_ VSS VSS VDD VDD _0832_
+ sky130_fd_sc_hd__nor2_1
X_1451_ _0820_ _0830_ _0831_ _0832_ VSS VSS VDD VDD net186
+ sky130_fd_sc_hd__a31oi_1
X_1452_ _0713_ input_buffer\[0\]\[21\] VSS VSS VDD VDD _0833_
+ sky130_fd_sc_hd__nand2_1
X_1453_ _0803_ _0804_ _0813_ _0805_ input_buffer\[1\]\[21\]
+ VSS VSS VDD VDD _0834_ sky130_fd_sc_hd__o2111ai_1
X_1454_ _0717_ VSS VSS VDD VDD _0835_ sky130_fd_sc_hd__buf_2
X_1455_ _0811_ _0775_ _0833_ _0834_ _0835_ VSS VSS VDD VDD
+ _0836_ sky130_fd_sc_hd__o311ai_0
X_1456_ input_buffer\[2\]\[21\] _0800_ _0801_ _0836_ VSS VSS
+ VDD VDD _0837_ sky130_fd_sc_hd__o211ai_1
X_1457_ input_buffer\[3\]\[21\] _0817_ VSS VSS VDD VDD _0838_
+ sky130_fd_sc_hd__nand2_1
X_1458_ _0739_ VSS VSS VDD VDD _0839_ sky130_fd_sc_hd__buf_4
X_1459_ input_buffer\[4\]\[21\] _0839_ VSS VSS VDD VDD _0840_
+ sky130_fd_sc_hd__nor2_1
X_1460_ _0820_ _0837_ _0838_ _0840_ VSS VSS VDD VDD net187
+ sky130_fd_sc_hd__a31oi_1
X_1461_ _0754_ input_buffer\[0\]\[22\] VSS VSS VDD VDD _0841_
+ sky130_fd_sc_hd__nand2_1
X_1462_ _0803_ _0804_ _0813_ _0805_ input_buffer\[1\]\[22\]
+ VSS VSS VDD VDD _0842_ sky130_fd_sc_hd__o2111ai_1
X_1463_ _0811_ _0775_ _0841_ _0842_ _0835_ VSS VSS VDD VDD
+ _0843_ sky130_fd_sc_hd__o311ai_0
X_1464_ input_buffer\[2\]\[22\] _0800_ _0801_ _0843_ VSS VSS
+ VDD VDD _0844_ sky130_fd_sc_hd__o211ai_1
X_1465_ input_buffer\[3\]\[22\] _0817_ VSS VSS VDD VDD _0845_
+ sky130_fd_sc_hd__nand2_1
X_1466_ input_buffer\[4\]\[22\] _0839_ VSS VSS VDD VDD _0846_
+ sky130_fd_sc_hd__nor2_1
X_1467_ _0820_ _0844_ _0845_ _0846_ VSS VSS VDD VDD net188
+ sky130_fd_sc_hd__a31oi_1
X_1468_ _0713_ input_buffer\[0\]\[23\] VSS VSS VDD VDD _0847_
+ sky130_fd_sc_hd__nand2_1
X_1469_ _0803_ _0804_ _0813_ _0805_ input_buffer\[1\]\[23\]
+ VSS VSS VDD VDD _0848_ sky130_fd_sc_hd__o2111ai_1
X_1470_ _0811_ _0725_ _0847_ _0848_ _0835_ VSS VSS VDD VDD
+ _0849_ sky130_fd_sc_hd__o311ai_1
X_1471_ input_buffer\[2\]\[23\] _0800_ _0801_ _0849_ VSS VSS
+ VDD VDD _0850_ sky130_fd_sc_hd__o211ai_1
X_1472_ input_buffer\[3\]\[23\] _0817_ VSS VSS VDD VDD _0851_
+ sky130_fd_sc_hd__nand2_1
X_1473_ input_buffer\[4\]\[23\] _0839_ VSS VSS VDD VDD _0852_
+ sky130_fd_sc_hd__nor2_1
X_1474_ _0820_ _0850_ _0851_ _0852_ VSS VSS VDD VDD net189
+ sky130_fd_sc_hd__a31oi_2
X_1475_ _1089_ VSS VSS VDD VDD _0853_ sky130_fd_sc_hd__clkinvlp_4
X_1476_ _0603_ VSS VSS VDD VDD _0854_ sky130_fd_sc_hd__buf_4
X_1477_ _0854_ dest_id\[0\]\[0\] _0702_ _0707_ VSS VSS VDD
+ VDD _0855_ sky130_fd_sc_hd__nand4_4
X_1478_ _0853_ _0726_ _0855_ VSS VSS VDD VDD _0856_ sky130_fd_sc_hd__nor3_1
X_1479_ _0601_ VSS VSS VDD VDD _0857_ sky130_fd_sc_hd__clkbuf_4
X_1480_ _0857_ _0676_ _1104_ VSS VSS VDD VDD _0858_ sky130_fd_sc_hd__nand3_1
X_1481_ _0682_ _0858_ _0729_ VSS VSS VDD VDD _0859_ sky130_fd_sc_hd__o21ai_0
X_1482_ _0650_ _0718_ _0736_ VSS VSS VDD VDD _0860_ sky130_fd_sc_hd__o21a_1
X_1483_ _0856_ _0859_ _0860_ VSS VSS VDD VDD _0861_ sky130_fd_sc_hd__o21ai_0
X_1484_ _0634_ _0817_ VSS VSS VDD VDD _0862_ sky130_fd_sc_hd__nand2_1
X_1485_ _0606_ _0839_ VSS VSS VDD VDD _0863_ sky130_fd_sc_hd__nor2_1
X_1486_ _0820_ _0861_ _0862_ _0863_ VSS VSS VDD VDD net190
+ sky130_fd_sc_hd__a31oi_2
X_1487_ _0857_ _0673_ _1104_ VSS VSS VDD VDD _0864_ sky130_fd_sc_hd__nand3_1
X_1488_ _0681_ _0864_ _0718_ VSS VSS VDD VDD _0865_ sky130_fd_sc_hd__o21ai_0
X_1489_ _0854_ dest_id\[0\]\[1\] VSS VSS VDD VDD _0866_ sky130_fd_sc_hd__nand2_1
X_1490_ _0853_ _0708_ _0726_ _0866_ VSS VSS VDD VDD _0867_
+ sky130_fd_sc_hd__nor4_1
X_1491_ dest_id\[2\]\[1\] _0718_ _0736_ VSS VSS VDD VDD _0868_
+ sky130_fd_sc_hd__o21a_1
X_1492_ _0865_ _0867_ _0868_ VSS VSS VDD VDD _0869_ sky130_fd_sc_hd__o21ai_0
X_1493_ _0627_ _0817_ VSS VSS VDD VDD _0870_ sky130_fd_sc_hd__nand2_1
X_1494_ _0604_ _0839_ VSS VSS VDD VDD _0871_ sky130_fd_sc_hd__nor2_1
X_1495_ _0820_ _0869_ _0870_ _0871_ VSS VSS VDD VDD net191
+ sky130_fd_sc_hd__a31oi_2
X_1496_ _0857_ _0674_ _1104_ VSS VSS VDD VDD _0872_ sky130_fd_sc_hd__nand3_1
X_1497_ _0681_ _0872_ _0718_ VSS VSS VDD VDD _0873_ sky130_fd_sc_hd__o21ai_0
X_1498_ _0854_ _0697_ VSS VSS VDD VDD _0874_ sky130_fd_sc_hd__nand2_1
X_1499_ _0853_ _0708_ _0726_ _0874_ VSS VSS VDD VDD _0875_
+ sky130_fd_sc_hd__nor4_1
X_1500_ _0649_ _0718_ _0736_ VSS VSS VDD VDD _0876_ sky130_fd_sc_hd__o21a_1
X_1501_ _0873_ _0875_ _0876_ VSS VSS VDD VDD _0877_ sky130_fd_sc_hd__o21ai_0
X_1502_ _0628_ _0817_ VSS VSS VDD VDD _0878_ sky130_fd_sc_hd__nand2_1
X_1503_ _0605_ _0839_ VSS VSS VDD VDD _0879_ sky130_fd_sc_hd__nor2_1
X_1504_ _0820_ _0877_ _0878_ _0879_ VSS VSS VDD VDD net192
+ sky130_fd_sc_hd__a31oi_2
X_1505_ _0737_ _0740_ VSS VSS VDD VDD _0880_ sky130_fd_sc_hd__nand2_1
X_1506_ _0677_ _0726_ VSS VSS VDD VDD _0881_ sky130_fd_sc_hd__nand2_1
X_1507_ net237 _0699_ _0700_ _0697_ VSS VSS VDD VDD _0882_
+ sky130_fd_sc_hd__nor4_2
X_1508_ _0726_ _0882_ _1089_ _0703_ VSS VSS VDD VDD _0883_
+ sky130_fd_sc_hd__nand4b_1
X_1509_ _0652_ _0729_ VSS VSS VDD VDD _0884_ sky130_fd_sc_hd__nor2_1
X_1510_ _0719_ _0881_ _0883_ _0884_ VSS VSS VDD VDD _0885_
+ sky130_fd_sc_hd__a31oi_1
X_1511_ dest_id\[3\]\[3\] VSS VSS VDD VDD _0886_ sky130_fd_sc_hd__inv_1
X_1512_ _0608_ _0740_ VSS VSS VDD VDD _0887_ sky130_fd_sc_hd__nor2_1
X_1513_ _0886_ _0743_ _0740_ _0887_ VSS VSS VDD VDD _0888_
+ sky130_fd_sc_hd__a31oi_1
X_1514_ _0880_ _0885_ _0888_ VSS VSS VDD VDD net193 sky130_fd_sc_hd__o21a_1
X_1515_ _0727_ input_buffer\[0\]\[2\] VSS VSS VDD VDD _0889_
+ sky130_fd_sc_hd__nand2_1
X_1516_ _0803_ _0804_ _0813_ _0805_ input_buffer\[1\]\[2\]
+ VSS VSS VDD VDD _0890_ sky130_fd_sc_hd__o2111ai_1
X_1517_ _0811_ _0725_ _0889_ _0890_ _0835_ VSS VSS VDD VDD
+ _0891_ sky130_fd_sc_hd__o311ai_0
X_1518_ input_buffer\[2\]\[2\] _0800_ _0801_ _0891_ VSS VSS
+ VDD VDD _0892_ sky130_fd_sc_hd__o211ai_1
X_1519_ input_buffer\[3\]\[2\] _0817_ VSS VSS VDD VDD _0893_
+ sky130_fd_sc_hd__nand2_1
X_1520_ input_buffer\[4\]\[2\] _0839_ VSS VSS VDD VDD _0894_
+ sky130_fd_sc_hd__nor2_1
X_1521_ _0820_ _0892_ _0893_ _0894_ VSS VSS VDD VDD net194
+ sky130_fd_sc_hd__a31oi_1
X_1522_ _0713_ input_buffer\[0\]\[3\] VSS VSS VDD VDD _0895_
+ sky130_fd_sc_hd__nand2_1
X_1523_ _0803_ _0804_ _0813_ _0805_ input_buffer\[1\]\[3\]
+ VSS VSS VDD VDD _0896_ sky130_fd_sc_hd__o2111ai_1
X_1524_ _0811_ _0725_ _0895_ _0896_ _0835_ VSS VSS VDD VDD
+ _0897_ sky130_fd_sc_hd__o311ai_0
X_1525_ input_buffer\[2\]\[3\] _0800_ _0801_ _0897_ VSS VSS
+ VDD VDD _0898_ sky130_fd_sc_hd__o211ai_1
X_1526_ input_buffer\[3\]\[3\] _0743_ VSS VSS VDD VDD _0899_
+ sky130_fd_sc_hd__nand2_1
X_1527_ input_buffer\[4\]\[3\] _0839_ VSS VSS VDD VDD _0900_
+ sky130_fd_sc_hd__nor2_1
X_1528_ _0820_ _0898_ _0899_ _0900_ VSS VSS VDD VDD net195
+ sky130_fd_sc_hd__a31oi_1
X_1529_ _0727_ input_buffer\[0\]\[4\] VSS VSS VDD VDD _0901_
+ sky130_fd_sc_hd__nand2_1
X_1530_ _0803_ _0804_ _0813_ _0805_ input_buffer\[1\]\[4\]
+ VSS VSS VDD VDD _0902_ sky130_fd_sc_hd__o2111ai_1
X_1531_ _0811_ _0725_ _0901_ _0902_ _0835_ VSS VSS VDD VDD
+ _0903_ sky130_fd_sc_hd__o311ai_0
X_1532_ input_buffer\[2\]\[4\] _0800_ _0801_ _0903_ VSS VSS
+ VDD VDD _0904_ sky130_fd_sc_hd__o211ai_1
X_1533_ input_buffer\[3\]\[4\] _0743_ VSS VSS VDD VDD _0905_
+ sky130_fd_sc_hd__nand2_1
X_1534_ input_buffer\[4\]\[4\] _0839_ VSS VSS VDD VDD _0906_
+ sky130_fd_sc_hd__nor2_1
X_1535_ _0741_ _0904_ _0905_ _0906_ VSS VSS VDD VDD net196
+ sky130_fd_sc_hd__a31oi_1
X_1536_ _0727_ input_buffer\[0\]\[5\] VSS VSS VDD VDD _0907_
+ sky130_fd_sc_hd__nand2_1
X_1537_ _0730_ _0685_ _0813_ _0683_ input_buffer\[1\]\[5\]
+ VSS VSS VDD VDD _0908_ sky130_fd_sc_hd__o2111ai_1
X_1538_ _0811_ _0725_ _0907_ _0908_ _0835_ VSS VSS VDD VDD
+ _0909_ sky130_fd_sc_hd__o311ai_0
X_1539_ input_buffer\[2\]\[5\] _0729_ _0736_ _0909_ VSS VSS
+ VDD VDD _0910_ sky130_fd_sc_hd__o211ai_1
X_1540_ input_buffer\[3\]\[5\] _0743_ VSS VSS VDD VDD _0911_
+ sky130_fd_sc_hd__nand2_1
X_1541_ input_buffer\[4\]\[5\] _0839_ VSS VSS VDD VDD _0912_
+ sky130_fd_sc_hd__nor2_1
X_1542_ _0741_ _0910_ _0911_ _0912_ VSS VSS VDD VDD net197
+ sky130_fd_sc_hd__a31oi_1
X_1543_ _0713_ input_buffer\[0\]\[6\] VSS VSS VDD VDD _0913_
+ sky130_fd_sc_hd__nand2_1
X_1544_ _0730_ _0685_ _0723_ _0683_ input_buffer\[1\]\[6\]
+ VSS VSS VDD VDD _0914_ sky130_fd_sc_hd__o2111ai_1
X_1545_ _0720_ _0725_ _0913_ _0914_ _0835_ VSS VSS VDD VDD
+ _0915_ sky130_fd_sc_hd__o311ai_1
X_1546_ input_buffer\[2\]\[6\] _0729_ _0736_ _0915_ VSS VSS
+ VDD VDD _0916_ sky130_fd_sc_hd__o211ai_1
X_1547_ input_buffer\[3\]\[6\] _0743_ VSS VSS VDD VDD _0917_
+ sky130_fd_sc_hd__nand2_1
X_1548_ input_buffer\[4\]\[6\] _0740_ VSS VSS VDD VDD _0918_
+ sky130_fd_sc_hd__nor2_1
X_1549_ _0741_ _0916_ _0917_ _0918_ VSS VSS VDD VDD net198
+ sky130_fd_sc_hd__a31oi_1
X_1550_ _0713_ input_buffer\[0\]\[7\] VSS VSS VDD VDD _0919_
+ sky130_fd_sc_hd__nand2_1
X_1551_ _0730_ _0685_ _0723_ _0683_ input_buffer\[1\]\[7\]
+ VSS VSS VDD VDD _0920_ sky130_fd_sc_hd__o2111ai_1
X_1552_ _0720_ _0725_ _0919_ _0920_ _0835_ VSS VSS VDD VDD
+ _0921_ sky130_fd_sc_hd__o311ai_0
X_1553_ input_buffer\[2\]\[7\] _0729_ _0736_ _0921_ VSS VSS
+ VDD VDD _0922_ sky130_fd_sc_hd__o211ai_1
X_1554_ input_buffer\[3\]\[7\] _0743_ VSS VSS VDD VDD _0923_
+ sky130_fd_sc_hd__nand2_1
X_1555_ input_buffer\[4\]\[7\] _0740_ VSS VSS VDD VDD _0924_
+ sky130_fd_sc_hd__nor2_1
X_1556_ _0741_ _0922_ _0923_ _0924_ VSS VSS VDD VDD net199
+ sky130_fd_sc_hd__a31oi_2
X_1557_ _0713_ input_buffer\[0\]\[8\] VSS VSS VDD VDD _0925_
+ sky130_fd_sc_hd__nand2_1
X_1558_ _0730_ _0685_ _0723_ _0683_ input_buffer\[1\]\[8\]
+ VSS VSS VDD VDD _0926_ sky130_fd_sc_hd__o2111ai_1
X_1559_ _0720_ _0725_ _0925_ _0926_ _0835_ VSS VSS VDD VDD
+ _0927_ sky130_fd_sc_hd__o311ai_0
X_1560_ input_buffer\[2\]\[8\] _0729_ _0736_ _0927_ VSS VSS
+ VDD VDD _0928_ sky130_fd_sc_hd__o211ai_1
X_1561_ input_buffer\[3\]\[8\] _0743_ VSS VSS VDD VDD _0929_
+ sky130_fd_sc_hd__nand2_1
X_1562_ input_buffer\[4\]\[8\] _0740_ VSS VSS VDD VDD _0930_
+ sky130_fd_sc_hd__nor2_1
X_1563_ _0741_ _0928_ _0929_ _0930_ VSS VSS VDD VDD net200
+ sky130_fd_sc_hd__a31oi_2
X_1564_ _0727_ input_buffer\[0\]\[9\] VSS VSS VDD VDD _0931_
+ sky130_fd_sc_hd__nand2_1
X_1565_ _0730_ _0685_ _0723_ _0683_ input_buffer\[1\]\[9\]
+ VSS VSS VDD VDD _0932_ sky130_fd_sc_hd__o2111ai_1
X_1566_ _0720_ _0725_ _0931_ _0932_ _0718_ VSS VSS VDD VDD
+ _0933_ sky130_fd_sc_hd__o311ai_1
X_1567_ input_buffer\[2\]\[9\] _0729_ _0736_ _0933_ VSS VSS
+ VDD VDD _0934_ sky130_fd_sc_hd__o211ai_1
X_1568_ input_buffer\[3\]\[9\] _0743_ VSS VSS VDD VDD _0935_
+ sky130_fd_sc_hd__nand2_1
X_1569_ input_buffer\[4\]\[9\] _0740_ VSS VSS VDD VDD _0936_
+ sky130_fd_sc_hd__nor2_1
X_1570_ _0741_ _0934_ _0935_ _0936_ VSS VSS VDD VDD net201
+ sky130_fd_sc_hd__a31oi_2
X_1571_ _0714_ _1101_ VSS VSS VDD VDD _0937_ sky130_fd_sc_hd__nand2_1
X_1572_ _0599_ _1131_ _1119_ VSS VSS VDD VDD _0938_ sky130_fd_sc_hd__nand3_1
X_1573_ _0637_ _1146_ _1134_ VSS VSS VDD VDD _0939_ sky130_fd_sc_hd__nand3_1
X_1574_ _0938_ _0939_ VSS VSS VDD VDD _0940_ sky130_fd_sc_hd__nand2_1
X_1575_ _0602_ _1116_ _1104_ _0940_ VSS VSS VDD VDD _0941_
+ sky130_fd_sc_hd__a31oi_1
X_1576_ _0625_ _1161_ _1149_ VSS VSS VDD VDD _0942_ sky130_fd_sc_hd__nand3_1
X_1577_ _0853_ _0937_ _0941_ _0942_ VSS VSS VDD VDD net202
+ sky130_fd_sc_hd__o211ai_2
X_1578_ _0600_ _0680_ VSS VSS VDD VDD _0943_ sky130_fd_sc_hd__and2_0
X_1579_ _0943_ VSS VSS VDD VDD _0944_ sky130_fd_sc_hd__buf_4
X_1580_ _0600_ _0680_ _1099_ VSS VSS VDD VDD _0945_ sky130_fd_sc_hd__a21oi_4
X_1581_ _0728_ VSS VSS VDD VDD _0946_ sky130_fd_sc_hd__inv_1
X_1582_ _0598_ _0655_ VSS VSS VDD VDD _0947_ sky130_fd_sc_hd__and2_0
X_1583_ _0947_ VSS VSS VDD VDD _0948_ sky130_fd_sc_hd__buf_2
X_1584_ _0948_ VSS VSS VDD VDD _0949_ sky130_fd_sc_hd__buf_6
X_1585_ input_buffer\[1\]\[0\] _0944_ _0945_ _0946_ _0949_
+ VSS VSS VDD VDD _0950_ sky130_fd_sc_hd__a221oi_1
X_1586_ net203 _1159_ _1144_ net301 VSS VSS VDD VDD _0951_
+ sky130_fd_sc_hd__o22ai_1
X_1587_ _0951_ VSS VSS VDD VDD _0952_ sky130_fd_sc_hd__buf_4
X_1588_ _0598_ _0655_ VSS VSS VDD VDD _0953_ sky130_fd_sc_hd__nand2_8
X_1589_ _0953_ VSS VSS VDD VDD _0954_ sky130_fd_sc_hd__clkbuf_4
X_1590_ input_buffer\[2\]\[0\] _0954_ VSS VSS VDD VDD _0955_
+ sky130_fd_sc_hd__nor2_1
X_1591_ net203 _1159_ VSS VSS VDD VDD _0956_ sky130_fd_sc_hd__nor2_1
X_1592_ _0956_ VSS VSS VDD VDD _0957_ sky130_fd_sc_hd__buf_4
X_1593_ _0957_ VSS VSS VDD VDD _0958_ sky130_fd_sc_hd__clkbuf_4
X_1594_ _0625_ _0611_ _1144_ net301 VSS VSS VDD VDD _0959_
+ sky130_fd_sc_hd__a211oi_4
X_1595_ _0959_ VSS VSS VDD VDD _0960_ sky130_fd_sc_hd__clkbuf_4
X_1596_ input_buffer\[4\]\[0\] _0958_ _0960_ input_buffer\[3\]\[0\]
+ VSS VSS VDD VDD _0961_ sky130_fd_sc_hd__a22oi_1
X_1597_ _0950_ _0952_ _0955_ _0961_ VSS VSS VDD VDD net204
+ sky130_fd_sc_hd__o31ai_1
X_1598_ _0944_ VSS VSS VDD VDD _0962_ sky130_fd_sc_hd__buf_4
X_1599_ _0945_ VSS VSS VDD VDD _0963_ sky130_fd_sc_hd__buf_4
X_1600_ _0748_ VSS VSS VDD VDD _0964_ sky130_fd_sc_hd__inv_1
X_1601_ _0948_ VSS VSS VDD VDD _0965_ sky130_fd_sc_hd__buf_4
X_1602_ input_buffer\[1\]\[10\] _0962_ _0963_ _0964_ _0965_
+ VSS VSS VDD VDD _0966_ sky130_fd_sc_hd__a221oi_1
X_1603_ input_buffer\[2\]\[10\] _0954_ VSS VSS VDD VDD _0967_
+ sky130_fd_sc_hd__nor2_1
X_1604_ input_buffer\[4\]\[10\] _0958_ _0960_ input_buffer\[3\]\[10\]
+ VSS VSS VDD VDD _0968_ sky130_fd_sc_hd__a22oi_1
X_1605_ _0952_ _0966_ _0967_ _0968_ VSS VSS VDD VDD net205
+ sky130_fd_sc_hd__o31ai_1
X_1606_ _0713_ input_buffer\[0\]\[11\] VSS VSS VDD VDD _0969_
+ sky130_fd_sc_hd__and2_0
X_1607_ input_buffer\[1\]\[11\] _0962_ _0963_ _0969_ _0965_
+ VSS VSS VDD VDD _0970_ sky130_fd_sc_hd__a221oi_1
X_1608_ input_buffer\[2\]\[11\] _0954_ VSS VSS VDD VDD _0971_
+ sky130_fd_sc_hd__nor2_1
X_1609_ input_buffer\[4\]\[11\] _0958_ _0960_ input_buffer\[3\]\[11\]
+ VSS VSS VDD VDD _0972_ sky130_fd_sc_hd__a22oi_1
X_1610_ _0952_ _0970_ _0971_ _0972_ VSS VSS VDD VDD net206
+ sky130_fd_sc_hd__o31ai_1
X_1611_ _0761_ VSS VSS VDD VDD _0973_ sky130_fd_sc_hd__inv_1
X_1612_ input_buffer\[1\]\[12\] _0962_ _0963_ _0973_ _0965_
+ VSS VSS VDD VDD _0974_ sky130_fd_sc_hd__a221oi_1
X_1613_ input_buffer\[2\]\[12\] _0954_ VSS VSS VDD VDD _0975_
+ sky130_fd_sc_hd__nor2_1
X_1614_ input_buffer\[4\]\[12\] _0958_ _0960_ input_buffer\[3\]\[12\]
+ VSS VSS VDD VDD _0976_ sky130_fd_sc_hd__a22oi_1
X_1615_ _0952_ _0974_ _0975_ _0976_ VSS VSS VDD VDD net207
+ sky130_fd_sc_hd__o31ai_1
X_1616_ _0769_ VSS VSS VDD VDD _0977_ sky130_fd_sc_hd__inv_1
X_1617_ input_buffer\[1\]\[13\] _0962_ _0963_ _0977_ _0965_
+ VSS VSS VDD VDD _0978_ sky130_fd_sc_hd__a221oi_1
X_1618_ input_buffer\[2\]\[13\] _0954_ VSS VSS VDD VDD _0979_
+ sky130_fd_sc_hd__nor2_1
X_1619_ input_buffer\[4\]\[13\] _0958_ _0960_ input_buffer\[3\]\[13\]
+ VSS VSS VDD VDD _0980_ sky130_fd_sc_hd__a22oi_1
X_1620_ _0952_ _0978_ _0979_ _0980_ VSS VSS VDD VDD net208
+ sky130_fd_sc_hd__o31ai_1
X_1621_ _0713_ input_buffer\[0\]\[14\] VSS VSS VDD VDD _0981_
+ sky130_fd_sc_hd__and2_0
X_1622_ input_buffer\[1\]\[14\] _0962_ _0963_ _0981_ _0965_
+ VSS VSS VDD VDD _0982_ sky130_fd_sc_hd__a221oi_1
X_1623_ input_buffer\[2\]\[14\] _0954_ VSS VSS VDD VDD _0983_
+ sky130_fd_sc_hd__nor2_1
X_1624_ input_buffer\[4\]\[14\] _0958_ _0960_ input_buffer\[3\]\[14\]
+ VSS VSS VDD VDD _0984_ sky130_fd_sc_hd__a22oi_1
X_1625_ _0952_ _0982_ _0983_ _0984_ VSS VSS VDD VDD net209
+ sky130_fd_sc_hd__o31ai_1
X_1626_ _0603_ VSS VSS VDD VDD _0985_ sky130_fd_sc_hd__clkbuf_4
X_1627_ _0985_ input_buffer\[0\]\[15\] VSS VSS VDD VDD _0986_
+ sky130_fd_sc_hd__and2_0
X_1628_ input_buffer\[1\]\[15\] _0962_ _0963_ _0986_ _0965_
+ VSS VSS VDD VDD _0987_ sky130_fd_sc_hd__a221oi_1
X_1629_ input_buffer\[2\]\[15\] _0954_ VSS VSS VDD VDD _0988_
+ sky130_fd_sc_hd__nor2_1
X_1630_ input_buffer\[4\]\[15\] _0958_ _0960_ input_buffer\[3\]\[15\]
+ VSS VSS VDD VDD _0989_ sky130_fd_sc_hd__a22oi_1
X_1631_ _0952_ _0987_ _0988_ _0989_ VSS VSS VDD VDD net210
+ sky130_fd_sc_hd__o31ai_1
X_1632_ _0985_ input_buffer\[0\]\[16\] VSS VSS VDD VDD _0990_
+ sky130_fd_sc_hd__and2_0
X_1633_ input_buffer\[1\]\[16\] _0962_ _0963_ _0990_ _0965_
+ VSS VSS VDD VDD _0991_ sky130_fd_sc_hd__a221oi_1
X_1634_ input_buffer\[2\]\[16\] _0954_ VSS VSS VDD VDD _0992_
+ sky130_fd_sc_hd__nor2_1
X_1635_ input_buffer\[4\]\[16\] _0958_ _0960_ input_buffer\[3\]\[16\]
+ VSS VSS VDD VDD _0993_ sky130_fd_sc_hd__a22oi_1
X_1636_ _0952_ _0991_ _0992_ _0993_ VSS VSS VDD VDD net211
+ sky130_fd_sc_hd__o31ai_1
X_1637_ _0944_ VSS VSS VDD VDD _0994_ sky130_fd_sc_hd__buf_4
X_1638_ _0794_ VSS VSS VDD VDD _0995_ sky130_fd_sc_hd__inv_1
X_1639_ input_buffer\[1\]\[17\] _0994_ _0963_ _0995_ _0965_
+ VSS VSS VDD VDD _0996_ sky130_fd_sc_hd__a221oi_1
X_1640_ input_buffer\[2\]\[17\] _0954_ VSS VSS VDD VDD _0997_
+ sky130_fd_sc_hd__nor2_1
X_1641_ input_buffer\[4\]\[17\] _0958_ _0960_ input_buffer\[3\]\[17\]
+ VSS VSS VDD VDD _0998_ sky130_fd_sc_hd__a22oi_1
X_1642_ _0952_ _0996_ _0997_ _0998_ VSS VSS VDD VDD net212
+ sky130_fd_sc_hd__o31ai_2
X_1643_ _0951_ VSS VSS VDD VDD _0999_ sky130_fd_sc_hd__buf_4
X_1644_ _0999_ VSS VSS VDD VDD _1000_ sky130_fd_sc_hd__buf_6
X_1645_ _0985_ input_buffer\[0\]\[18\] VSS VSS VDD VDD _1001_
+ sky130_fd_sc_hd__and2_0
X_1646_ _0948_ VSS VSS VDD VDD _1002_ sky130_fd_sc_hd__buf_4
X_1647_ input_buffer\[1\]\[18\] _0994_ _0963_ _1001_ _1002_
+ VSS VSS VDD VDD _1003_ sky130_fd_sc_hd__a221oi_1
X_1648_ input_buffer\[2\]\[18\] _0954_ VSS VSS VDD VDD _1004_
+ sky130_fd_sc_hd__nor2_1
X_1649_ input_buffer\[4\]\[18\] _0958_ _0960_ input_buffer\[3\]\[18\]
+ VSS VSS VDD VDD _1005_ sky130_fd_sc_hd__a22oi_1
X_1650_ _1000_ _1003_ _1004_ _1005_ VSS VSS VDD VDD net213
+ sky130_fd_sc_hd__o31ai_1
X_1651_ _0945_ VSS VSS VDD VDD _1006_ sky130_fd_sc_hd__clkbuf_4
X_1652_ _0812_ VSS VSS VDD VDD _1007_ sky130_fd_sc_hd__inv_1
X_1653_ input_buffer\[1\]\[19\] _0994_ _1006_ _1007_ _1002_
+ VSS VSS VDD VDD _1008_ sky130_fd_sc_hd__a221oi_1
X_1654_ _0953_ VSS VSS VDD VDD _1009_ sky130_fd_sc_hd__clkbuf_4
X_1655_ input_buffer\[2\]\[19\] _1009_ VSS VSS VDD VDD _1010_
+ sky130_fd_sc_hd__nor2_1
X_1656_ _0956_ VSS VSS VDD VDD _1011_ sky130_fd_sc_hd__buf_4
X_1657_ _0959_ VSS VSS VDD VDD _1012_ sky130_fd_sc_hd__buf_4
X_1658_ input_buffer\[4\]\[19\] _1011_ _1012_ input_buffer\[3\]\[19\]
+ VSS VSS VDD VDD _1013_ sky130_fd_sc_hd__a22oi_1
X_1659_ _1000_ _1008_ _1010_ _1013_ VSS VSS VDD VDD net214
+ sky130_fd_sc_hd__o31ai_1
X_1660_ _0985_ input_buffer\[0\]\[1\] VSS VSS VDD VDD _1014_
+ sky130_fd_sc_hd__and2_0
X_1661_ input_buffer\[1\]\[1\] _0994_ _1006_ _1014_ _1002_
+ VSS VSS VDD VDD _1015_ sky130_fd_sc_hd__a221oi_1
X_1662_ input_buffer\[2\]\[1\] _1009_ VSS VSS VDD VDD _1016_
+ sky130_fd_sc_hd__nor2_1
X_1663_ input_buffer\[4\]\[1\] _1011_ _1012_ input_buffer\[3\]\[1\]
+ VSS VSS VDD VDD _1017_ sky130_fd_sc_hd__a22oi_1
X_1664_ _1000_ _1015_ _1016_ _1017_ VSS VSS VDD VDD net215
+ sky130_fd_sc_hd__o31ai_1
X_1665_ _0985_ input_buffer\[0\]\[20\] VSS VSS VDD VDD _1018_
+ sky130_fd_sc_hd__and2_0
X_1666_ input_buffer\[1\]\[20\] _0994_ _1006_ _1018_ _1002_
+ VSS VSS VDD VDD _1019_ sky130_fd_sc_hd__a221oi_1
X_1667_ input_buffer\[2\]\[20\] _1009_ VSS VSS VDD VDD _1020_
+ sky130_fd_sc_hd__nor2_1
X_1668_ input_buffer\[4\]\[20\] _1011_ _1012_ input_buffer\[3\]\[20\]
+ VSS VSS VDD VDD _1021_ sky130_fd_sc_hd__a22oi_1
X_1669_ _1000_ _1019_ _1020_ _1021_ VSS VSS VDD VDD net216
+ sky130_fd_sc_hd__o31ai_1
X_1670_ _0833_ VSS VSS VDD VDD _1022_ sky130_fd_sc_hd__inv_1
X_1671_ input_buffer\[1\]\[21\] _0994_ _1006_ _1022_ _1002_
+ VSS VSS VDD VDD _1023_ sky130_fd_sc_hd__a221oi_1
X_1672_ input_buffer\[2\]\[21\] _1009_ VSS VSS VDD VDD _1024_
+ sky130_fd_sc_hd__nor2_1
X_1673_ input_buffer\[4\]\[21\] _1011_ _1012_ input_buffer\[3\]\[21\]
+ VSS VSS VDD VDD _1025_ sky130_fd_sc_hd__a22oi_1
X_1674_ _1000_ _1023_ _1024_ _1025_ VSS VSS VDD VDD net217
+ sky130_fd_sc_hd__o31ai_1
X_1675_ _0985_ input_buffer\[0\]\[22\] VSS VSS VDD VDD _1026_
+ sky130_fd_sc_hd__and2_0
X_1676_ input_buffer\[1\]\[22\] _0994_ _1006_ _1026_ _1002_
+ VSS VSS VDD VDD _1027_ sky130_fd_sc_hd__a221oi_1
X_1677_ input_buffer\[2\]\[22\] _1009_ VSS VSS VDD VDD _1028_
+ sky130_fd_sc_hd__nor2_1
X_1678_ input_buffer\[4\]\[22\] _1011_ _1012_ input_buffer\[3\]\[22\]
+ VSS VSS VDD VDD _1029_ sky130_fd_sc_hd__a22oi_1
X_1679_ _1000_ _1027_ _1028_ _1029_ VSS VSS VDD VDD net218
+ sky130_fd_sc_hd__o31ai_1
X_1680_ _0847_ VSS VSS VDD VDD _1030_ sky130_fd_sc_hd__inv_1
X_1681_ input_buffer\[1\]\[23\] _0994_ _1006_ _1030_ _1002_
+ VSS VSS VDD VDD _1031_ sky130_fd_sc_hd__a221oi_1
X_1682_ input_buffer\[2\]\[23\] _1009_ VSS VSS VDD VDD _1032_
+ sky130_fd_sc_hd__nor2_1
X_1683_ input_buffer\[4\]\[23\] _1011_ _1012_ input_buffer\[3\]\[23\]
+ VSS VSS VDD VDD _1033_ sky130_fd_sc_hd__a22oi_1
X_1684_ _1000_ _1031_ _1032_ _1033_ VSS VSS VDD VDD net219
+ sky130_fd_sc_hd__o31ai_2
X_1685_ _0602_ _0676_ _0682_ _0957_ _0965_ VSS VSS VDD VDD
+ _1034_ sky130_fd_sc_hd__a311oi_1
X_1686_ net301 _1144_ VSS VSS VDD VDD _1035_ sky130_fd_sc_hd__nor2_1
X_1687_ _0714_ dest_id\[0\]\[0\] _0963_ _1035_ _0634_ VSS
+ VSS VDD VDD _1036_ sky130_fd_sc_hd__a32oi_1
X_1688_ _0650_ _0953_ _0999_ VSS VSS VDD VDD _1037_ sky130_fd_sc_hd__nor3_1
X_1689_ _1144_ _0597_ VSS VSS VDD VDD _1038_ sky130_fd_sc_hd__nand2b_4
X_1690_ _0608_ _0613_ VSS VSS VDD VDD _1039_ sky130_fd_sc_hd__nor2_1
X_1691_ _0605_ _1039_ net203 _0606_ VSS VSS VDD VDD _1040_
+ sky130_fd_sc_hd__a211o_1
X_1692_ _0634_ _0957_ _1038_ _1040_ VSS VSS VDD VDD _1041_
+ sky130_fd_sc_hd__o31ai_1
X_1693_ _1034_ _1036_ _1037_ _1041_ VSS VSS VDD VDD net220
+ sky130_fd_sc_hd__a211oi_1
X_1694_ _0857_ _0681_ _1099_ _0866_ VSS VSS VDD VDD _1042_
+ sky130_fd_sc_hd__a211oi_1
X_1695_ _0673_ _0962_ _0949_ _1042_ VSS VSS VDD VDD _1043_
+ sky130_fd_sc_hd__a211oi_1
X_1696_ dest_id\[2\]\[1\] _1009_ VSS VSS VDD VDD _1044_ sky130_fd_sc_hd__nor2_1
X_1697_ _0604_ _1011_ _1012_ _0627_ VSS VSS VDD VDD _1045_
+ sky130_fd_sc_hd__a22oi_1
X_1698_ _1000_ _1043_ _1044_ _1045_ VSS VSS VDD VDD net221
+ sky130_fd_sc_hd__o31ai_2
X_1699_ _0857_ _0681_ _1099_ _0874_ VSS VSS VDD VDD _1046_
+ sky130_fd_sc_hd__a211oi_1
X_1700_ _0674_ _0962_ _0949_ _1046_ VSS VSS VDD VDD _1047_
+ sky130_fd_sc_hd__a211oi_1
X_1701_ _0649_ _1009_ VSS VSS VDD VDD _1048_ sky130_fd_sc_hd__nor2_1
X_1702_ _0605_ _1011_ _1012_ _0628_ VSS VSS VDD VDD _1049_
+ sky130_fd_sc_hd__a22oi_2
X_1703_ _1000_ _1047_ _1048_ _1049_ VSS VSS VDD VDD net222
+ sky130_fd_sc_hd__o31ai_4
X_1704_ _0985_ dest_id\[0\]\[3\] VSS VSS VDD VDD _1050_ sky130_fd_sc_hd__and2_0
X_1705_ _0677_ _0994_ _1006_ _1050_ _1002_ VSS VSS VDD VDD
+ _1051_ sky130_fd_sc_hd__a221oi_1
X_1706_ _0652_ _1009_ VSS VSS VDD VDD _1052_ sky130_fd_sc_hd__nor2_1
X_1707_ _0608_ _1011_ _1012_ dest_id\[3\]\[3\] VSS VSS VDD
+ VDD _1053_ sky130_fd_sc_hd__a22oi_1
X_1708_ _1000_ _1051_ _1052_ _1053_ VSS VSS VDD VDD net223
+ sky130_fd_sc_hd__o31ai_2
X_1709_ _0625_ _0611_ VSS VSS VDD VDD _1054_ sky130_fd_sc_hd__nand2_2
X_1710_ _0854_ dest_id\[0\]\[4\] VSS VSS VDD VDD _1055_ sky130_fd_sc_hd__nand2_1
X_1711_ _0857_ _0681_ _1055_ VSS VSS VDD VDD _1056_ sky130_fd_sc_hd__a21oi_1
X_1712_ _0601_ dest_id\[1\]\[4\] VSS VSS VDD VDD _1057_ sky130_fd_sc_hd__and2_0
X_1713_ dest_id\[2\]\[4\] _0655_ _0599_ VSS VSS VDD VDD _1058_
+ sky130_fd_sc_hd__nand3b_1
X_1714_ _0949_ _1056_ _1057_ _1058_ _1038_ VSS VSS VDD VDD
+ _1059_ sky130_fd_sc_hd__o311ai_4
X_1715_ _0637_ dest_id\[3\]\[4\] VSS VSS VDD VDD _1060_ sky130_fd_sc_hd__nand2_1
X_1716_ dest_id\[4\]\[4\] _1054_ VSS VSS VDD VDD _1061_ sky130_fd_sc_hd__nor2_1
X_1717_ _1054_ _1059_ _1060_ _1061_ VSS VSS VDD VDD net224
+ sky130_fd_sc_hd__a31oi_1
X_1718_ _0854_ dest_id\[0\]\[5\] VSS VSS VDD VDD _1062_ sky130_fd_sc_hd__nand2_1
X_1719_ _0601_ _0681_ _1062_ VSS VSS VDD VDD _1063_ sky130_fd_sc_hd__a21oi_1
X_1720_ _0601_ dest_id\[1\]\[5\] VSS VSS VDD VDD _1064_ sky130_fd_sc_hd__and2_0
X_1721_ dest_id\[2\]\[5\] _0655_ _0599_ VSS VSS VDD VDD _1065_
+ sky130_fd_sc_hd__nand3b_1
X_1722_ _0948_ _1063_ _1064_ _1065_ _1038_ VSS VSS VDD VDD
+ _1066_ sky130_fd_sc_hd__o311ai_4
X_1723_ _0637_ dest_id\[3\]\[5\] VSS VSS VDD VDD _1067_ sky130_fd_sc_hd__nand2_1
X_1724_ dest_id\[4\]\[5\] _1054_ VSS VSS VDD VDD _1068_ sky130_fd_sc_hd__nor2_1
X_1725_ _1054_ _1066_ _1067_ _1068_ VSS VSS VDD VDD net225
+ sky130_fd_sc_hd__a31oi_1
X_1726_ _0985_ input_buffer\[0\]\[2\] VSS VSS VDD VDD _1069_
+ sky130_fd_sc_hd__and2_0
X_1727_ input_buffer\[1\]\[2\] _0994_ _1006_ _1069_ _1002_
+ VSS VSS VDD VDD _1070_ sky130_fd_sc_hd__a221oi_1
X_1728_ input_buffer\[2\]\[2\] _1009_ VSS VSS VDD VDD _1071_
+ sky130_fd_sc_hd__nor2_1
X_1729_ input_buffer\[4\]\[2\] _1011_ _1012_ input_buffer\[3\]\[2\]
+ VSS VSS VDD VDD _1072_ sky130_fd_sc_hd__a22oi_1
X_1730_ _0999_ _1070_ _1071_ _1072_ VSS VSS VDD VDD net226
+ sky130_fd_sc_hd__o31ai_1
X_1731_ _0754_ dest_id\[0\]\[6\] VSS VSS VDD VDD _1073_ sky130_fd_sc_hd__nand2_1
X_1732_ _0601_ _0681_ _1073_ VSS VSS VDD VDD _1074_ sky130_fd_sc_hd__a21oi_1
X_1733_ _0601_ dest_id\[1\]\[6\] VSS VSS VDD VDD _1075_ sky130_fd_sc_hd__and2_0
X_1734_ dest_id\[2\]\[6\] _0655_ _0599_ VSS VSS VDD VDD _1076_
+ sky130_fd_sc_hd__nand3b_1
X_1735_ _0948_ _1074_ _1075_ _1076_ _1038_ VSS VSS VDD VDD
+ _1077_ sky130_fd_sc_hd__o311ai_2
X_1736_ _0637_ dest_id\[3\]\[6\] VSS VSS VDD VDD _1078_ sky130_fd_sc_hd__nand2_1
X_1737_ dest_id\[4\]\[6\] _1054_ VSS VSS VDD VDD _1079_ sky130_fd_sc_hd__nor2_1
X_1738_ _1054_ _1077_ _1078_ _1079_ VSS VSS VDD VDD net227
+ sky130_fd_sc_hd__a31oi_1
X_1739_ _0754_ dest_id\[0\]\[7\] VSS VSS VDD VDD _1080_ sky130_fd_sc_hd__nand2_1
X_1740_ _0601_ _0681_ _1080_ VSS VSS VDD VDD _1081_ sky130_fd_sc_hd__a21oi_1
X_1741_ _0601_ dest_id\[1\]\[7\] VSS VSS VDD VDD _1082_ sky130_fd_sc_hd__and2_0
X_1742_ dest_id\[2\]\[7\] _0655_ _0599_ VSS VSS VDD VDD _1083_
+ sky130_fd_sc_hd__nand3b_1
X_1743_ _0948_ _1081_ _1082_ _1083_ _1038_ VSS VSS VDD VDD
+ _1084_ sky130_fd_sc_hd__o311ai_2
X_1744_ _0637_ dest_id\[3\]\[7\] VSS VSS VDD VDD _1085_ sky130_fd_sc_hd__nand2_1
X_1745_ dest_id\[4\]\[7\] _1054_ VSS VSS VDD VDD _1086_ sky130_fd_sc_hd__nor2_1
X_1746_ _1054_ _1084_ _1085_ _1086_ VSS VSS VDD VDD net228
+ sky130_fd_sc_hd__a31oi_1
X_1747_ _0895_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__inv_1
X_1748_ input_buffer\[1\]\[3\] _0944_ _1006_ _0010_ _1002_
+ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__a221oi_1
X_1749_ input_buffer\[2\]\[3\] _0953_ VSS VSS VDD VDD _0012_
+ sky130_fd_sc_hd__nor2_1
X_1750_ input_buffer\[4\]\[3\] _0957_ _0959_ input_buffer\[3\]\[3\]
+ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__a22oi_1
X_1751_ _0999_ _0011_ _0012_ _0013_ VSS VSS VDD VDD net229
+ sky130_fd_sc_hd__o31ai_1
X_1752_ _0985_ input_buffer\[0\]\[4\] VSS VSS VDD VDD _0014_
+ sky130_fd_sc_hd__and2_0
X_1753_ input_buffer\[1\]\[4\] _0944_ _1006_ _0014_ _0949_
+ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__a221oi_1
X_1754_ input_buffer\[2\]\[4\] _0953_ VSS VSS VDD VDD _0016_
+ sky130_fd_sc_hd__nor2_1
X_1755_ input_buffer\[4\]\[4\] _0957_ _0959_ input_buffer\[3\]\[4\]
+ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__a22oi_1
X_1756_ _0999_ _0015_ _0016_ _0017_ VSS VSS VDD VDD net230
+ sky130_fd_sc_hd__o31ai_1
X_1757_ _0985_ input_buffer\[0\]\[5\] VSS VSS VDD VDD _0018_
+ sky130_fd_sc_hd__and2_0
X_1758_ input_buffer\[1\]\[5\] _0944_ _0945_ _0018_ _0949_
+ VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__a221oi_1
X_1759_ input_buffer\[2\]\[5\] _0953_ VSS VSS VDD VDD _0020_
+ sky130_fd_sc_hd__nor2_1
X_1760_ input_buffer\[4\]\[5\] _0957_ _0959_ input_buffer\[3\]\[5\]
+ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__a22oi_1
X_1761_ _0999_ _0019_ _0020_ _0021_ VSS VSS VDD VDD net231
+ sky130_fd_sc_hd__o31ai_1
X_1762_ _0913_ VSS VSS VDD VDD _0022_ sky130_fd_sc_hd__inv_1
X_1763_ input_buffer\[1\]\[6\] _0944_ _0945_ _0022_ _0949_
+ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__a221oi_1
X_1764_ input_buffer\[2\]\[6\] _0953_ VSS VSS VDD VDD _0024_
+ sky130_fd_sc_hd__nor2_1
X_1765_ input_buffer\[4\]\[6\] _0957_ _0959_ input_buffer\[3\]\[6\]
+ VSS VSS VDD VDD _0025_ sky130_fd_sc_hd__a22oi_1
X_1766_ _0999_ _0023_ _0024_ _0025_ VSS VSS VDD VDD net232
+ sky130_fd_sc_hd__o31ai_1
X_1767_ _0919_ VSS VSS VDD VDD _0026_ sky130_fd_sc_hd__inv_1
X_1768_ input_buffer\[1\]\[7\] _0944_ _0945_ _0026_ _0949_
+ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__a221oi_1
X_1769_ input_buffer\[2\]\[7\] _0953_ VSS VSS VDD VDD _0028_
+ sky130_fd_sc_hd__nor2_1
X_1770_ input_buffer\[4\]\[7\] _0957_ _0959_ input_buffer\[3\]\[7\]
+ VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__a22oi_1
X_1771_ _0999_ _0027_ _0028_ _0029_ VSS VSS VDD VDD net233
+ sky130_fd_sc_hd__o31ai_1
X_1772_ _0925_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__inv_1
X_1773_ input_buffer\[1\]\[8\] _0944_ _0945_ _0030_ _0949_
+ VSS VSS VDD VDD _0031_ sky130_fd_sc_hd__a221oi_1
X_1774_ input_buffer\[2\]\[8\] _0953_ VSS VSS VDD VDD _0032_
+ sky130_fd_sc_hd__nor2_1
X_1775_ input_buffer\[4\]\[8\] _0957_ _0959_ input_buffer\[3\]\[8\]
+ VSS VSS VDD VDD _0033_ sky130_fd_sc_hd__a22oi_1
X_1776_ _0999_ _0031_ _0032_ _0033_ VSS VSS VDD VDD net234
+ sky130_fd_sc_hd__o31ai_1
X_1777_ _0603_ input_buffer\[0\]\[9\] VSS VSS VDD VDD _0034_
+ sky130_fd_sc_hd__and2_0
X_1778_ input_buffer\[1\]\[9\] _0944_ _0945_ _0034_ _0949_
+ VSS VSS VDD VDD _0035_ sky130_fd_sc_hd__a221oi_1
X_1779_ input_buffer\[2\]\[9\] _0953_ VSS VSS VDD VDD _0036_
+ sky130_fd_sc_hd__nor2_1
X_1780_ input_buffer\[4\]\[9\] _0957_ _0959_ input_buffer\[3\]\[9\]
+ VSS VSS VDD VDD _0037_ sky130_fd_sc_hd__a22oi_1
X_1781_ _0999_ _0035_ _0036_ _0037_ VSS VSS VDD VDD net235
+ sky130_fd_sc_hd__o31ai_1
X_1782_ _0962_ _0965_ _0952_ VSS VSS VDD VDD _0038_ sky130_fd_sc_hd__nor3_1
X_1783_ net237 _1099_ _0038_ VSS VSS VDD VDD net236 sky130_fd_sc_hd__o21ai_1
X_1784_ _0625_ _1160_ VSS VSS VDD VDD _0039_ sky130_fd_sc_hd__nand2_8
X_1785_ _0039_ VSS VSS VDD VDD _0040_ sky130_fd_sc_hd__clkbuf_4
X_1786_ _0597_ _1145_ VSS VSS VDD VDD _0041_ sky130_fd_sc_hd__and2_0
X_1787_ _0041_ VSS VSS VDD VDD _0042_ sky130_fd_sc_hd__buf_4
X_1788_ _0042_ VSS VSS VDD VDD _0043_ sky130_fd_sc_hd__clkbuf_4
X_1789_ _0598_ _1130_ VSS VSS VDD VDD _0044_ sky130_fd_sc_hd__nand2_8
X_1790_ _0044_ VSS VSS VDD VDD _0045_ sky130_fd_sc_hd__clkbuf_4
X_1791_ _0600_ _1115_ VSS VSS VDD VDD _0046_ sky130_fd_sc_hd__and2_0
X_1792_ _0046_ VSS VSS VDD VDD _0047_ sky130_fd_sc_hd__clkbuf_2
X_1793_ _0047_ VSS VSS VDD VDD _0048_ sky130_fd_sc_hd__clkbuf_4
X_1794_ input_buffer\[1\]\[0\] _0048_ VSS VSS VDD VDD _0049_
+ sky130_fd_sc_hd__nand2_1
X_1795_ _0713_ VSS VSS VDD VDD _0050_ sky130_fd_sc_hd__clkbuf_4
X_1796_ _0709_ VSS VSS VDD VDD _0051_ sky130_fd_sc_hd__buf_4
X_1797_ _0600_ _1115_ VSS VSS VDD VDD _0052_ sky130_fd_sc_hd__nand2_2
X_1798_ _0052_ VSS VSS VDD VDD _0053_ sky130_fd_sc_hd__buf_4
X_1799_ _0050_ input_buffer\[0\]\[0\] _0051_ _0053_ VSS VSS
+ VDD VDD _0054_ sky130_fd_sc_hd__nand4_1
X_1800_ _0044_ VSS VSS VDD VDD _0055_ sky130_fd_sc_hd__buf_4
X_1801_ input_buffer\[2\]\[0\] _0055_ VSS VSS VDD VDD _0056_
+ sky130_fd_sc_hd__nor2_1
X_1802_ _0042_ VSS VSS VDD VDD _0057_ sky130_fd_sc_hd__buf_4
X_1803_ _0045_ _0049_ _0054_ _0056_ _0057_ VSS VSS VDD VDD
+ _0058_ sky130_fd_sc_hd__a311oi_1
X_1804_ input_buffer\[3\]\[0\] _0043_ _0058_ VSS VSS VDD VDD
+ _0059_ sky130_fd_sc_hd__a21oi_1
X_1805_ _0039_ VSS VSS VDD VDD _0060_ sky130_fd_sc_hd__buf_4
X_1806_ input_buffer\[4\]\[0\] _0060_ VSS VSS VDD VDD _0061_
+ sky130_fd_sc_hd__nor2_1
X_1807_ _0040_ _0059_ _0061_ VSS VSS VDD VDD net238 sky130_fd_sc_hd__a21oi_1
X_1808_ input_buffer\[1\]\[10\] _0048_ VSS VSS VDD VDD _0062_
+ sky130_fd_sc_hd__nand2_1
X_1809_ _0050_ input_buffer\[0\]\[10\] _0051_ _0053_ VSS VSS
+ VDD VDD _0063_ sky130_fd_sc_hd__nand4_1
X_1810_ input_buffer\[2\]\[10\] _0055_ VSS VSS VDD VDD _0064_
+ sky130_fd_sc_hd__nor2_1
X_1811_ _0045_ _0062_ _0063_ _0064_ _0057_ VSS VSS VDD VDD
+ _0065_ sky130_fd_sc_hd__a311oi_1
X_1812_ input_buffer\[3\]\[10\] _0043_ _0065_ VSS VSS VDD
+ VDD _0066_ sky130_fd_sc_hd__a21oi_1
X_1813_ input_buffer\[4\]\[10\] _0060_ VSS VSS VDD VDD _0067_
+ sky130_fd_sc_hd__nor2_1
X_1814_ _0040_ _0066_ _0067_ VSS VSS VDD VDD net239 sky130_fd_sc_hd__a21oi_1
X_1815_ input_buffer\[1\]\[11\] _0048_ VSS VSS VDD VDD _0068_
+ sky130_fd_sc_hd__nand2_1
X_1816_ _0052_ VSS VSS VDD VDD _0069_ sky130_fd_sc_hd__clkbuf_4
X_1817_ _0710_ _0969_ _0069_ VSS VSS VDD VDD _0070_ sky130_fd_sc_hd__nand3_1
X_1818_ input_buffer\[2\]\[11\] _0055_ VSS VSS VDD VDD _0071_
+ sky130_fd_sc_hd__nor2_1
X_1819_ _0045_ _0068_ _0070_ _0071_ _0057_ VSS VSS VDD VDD
+ _0072_ sky130_fd_sc_hd__a311oi_1
X_1820_ input_buffer\[3\]\[11\] _0043_ _0072_ VSS VSS VDD
+ VDD _0073_ sky130_fd_sc_hd__a21oi_1
X_1821_ input_buffer\[4\]\[11\] _0060_ VSS VSS VDD VDD _0074_
+ sky130_fd_sc_hd__nor2_1
X_1822_ _0040_ _0073_ _0074_ VSS VSS VDD VDD net240 sky130_fd_sc_hd__a21oi_1
X_1823_ input_buffer\[1\]\[12\] _0048_ VSS VSS VDD VDD _0075_
+ sky130_fd_sc_hd__nand2_1
X_1824_ _0709_ VSS VSS VDD VDD _0076_ sky130_fd_sc_hd__clkbuf_4
X_1825_ _0050_ input_buffer\[0\]\[12\] _0076_ _0053_ VSS VSS
+ VDD VDD _0077_ sky130_fd_sc_hd__nand4_1
X_1826_ input_buffer\[2\]\[12\] _0055_ VSS VSS VDD VDD _0078_
+ sky130_fd_sc_hd__nor2_1
X_1827_ _0045_ _0075_ _0077_ _0078_ _0057_ VSS VSS VDD VDD
+ _0079_ sky130_fd_sc_hd__a311oi_1
X_1828_ input_buffer\[3\]\[12\] _0043_ _0079_ VSS VSS VDD
+ VDD _0080_ sky130_fd_sc_hd__a21oi_1
X_1829_ input_buffer\[4\]\[12\] _0060_ VSS VSS VDD VDD _0081_
+ sky130_fd_sc_hd__nor2_1
X_1830_ _0040_ _0080_ _0081_ VSS VSS VDD VDD net241 sky130_fd_sc_hd__a21oi_1
X_1831_ input_buffer\[1\]\[13\] _0048_ VSS VSS VDD VDD _0082_
+ sky130_fd_sc_hd__nand2_1
X_1832_ _0052_ VSS VSS VDD VDD _0083_ sky130_fd_sc_hd__buf_4
X_1833_ _0050_ input_buffer\[0\]\[13\] _0076_ _0083_ VSS VSS
+ VDD VDD _0084_ sky130_fd_sc_hd__nand4_1
X_1834_ input_buffer\[2\]\[13\] _0055_ VSS VSS VDD VDD _0085_
+ sky130_fd_sc_hd__nor2_1
X_1835_ _0045_ _0082_ _0084_ _0085_ _0057_ VSS VSS VDD VDD
+ _0086_ sky130_fd_sc_hd__a311oi_1
X_1836_ input_buffer\[3\]\[13\] _0043_ _0086_ VSS VSS VDD
+ VDD _0087_ sky130_fd_sc_hd__a21oi_1
X_1837_ input_buffer\[4\]\[13\] _0060_ VSS VSS VDD VDD _0088_
+ sky130_fd_sc_hd__nor2_1
X_1838_ _0040_ _0087_ _0088_ VSS VSS VDD VDD net242 sky130_fd_sc_hd__a21oi_1
X_1839_ input_buffer\[1\]\[14\] _0048_ VSS VSS VDD VDD _0089_
+ sky130_fd_sc_hd__nand2_1
X_1840_ _0710_ _0981_ _0069_ VSS VSS VDD VDD _0090_ sky130_fd_sc_hd__nand3_1
X_1841_ input_buffer\[2\]\[14\] _0055_ VSS VSS VDD VDD _0091_
+ sky130_fd_sc_hd__nor2_1
X_1842_ _0045_ _0089_ _0090_ _0091_ _0057_ VSS VSS VDD VDD
+ _0092_ sky130_fd_sc_hd__a311oi_1
X_1843_ input_buffer\[3\]\[14\] _0043_ _0092_ VSS VSS VDD
+ VDD _0093_ sky130_fd_sc_hd__a21oi_1
X_1844_ input_buffer\[4\]\[14\] _0060_ VSS VSS VDD VDD _0094_
+ sky130_fd_sc_hd__nor2_1
X_1845_ _0040_ _0093_ _0094_ VSS VSS VDD VDD net243 sky130_fd_sc_hd__a21oi_1
X_1846_ input_buffer\[1\]\[15\] _0048_ VSS VSS VDD VDD _0095_
+ sky130_fd_sc_hd__nand2_1
X_1847_ _0710_ _0986_ _0069_ VSS VSS VDD VDD _0096_ sky130_fd_sc_hd__nand3_1
X_1848_ input_buffer\[2\]\[15\] _0055_ VSS VSS VDD VDD _0097_
+ sky130_fd_sc_hd__nor2_1
X_1849_ _0045_ _0095_ _0096_ _0097_ _0057_ VSS VSS VDD VDD
+ _0098_ sky130_fd_sc_hd__a311oi_1
X_1850_ input_buffer\[3\]\[15\] _0043_ _0098_ VSS VSS VDD
+ VDD _0099_ sky130_fd_sc_hd__a21oi_1
X_1851_ input_buffer\[4\]\[15\] _0060_ VSS VSS VDD VDD _0100_
+ sky130_fd_sc_hd__nor2_1
X_1852_ _0040_ _0099_ _0100_ VSS VSS VDD VDD net244 sky130_fd_sc_hd__a21oi_1
X_1853_ input_buffer\[1\]\[16\] _0048_ VSS VSS VDD VDD _0101_
+ sky130_fd_sc_hd__nand2_1
X_1854_ _0710_ _0990_ _0069_ VSS VSS VDD VDD _0102_ sky130_fd_sc_hd__nand3_1
X_1855_ input_buffer\[2\]\[16\] _0055_ VSS VSS VDD VDD _0103_
+ sky130_fd_sc_hd__nor2_1
X_1856_ _0045_ _0101_ _0102_ _0103_ _0057_ VSS VSS VDD VDD
+ _0104_ sky130_fd_sc_hd__a311oi_1
X_1857_ input_buffer\[3\]\[16\] _0043_ _0104_ VSS VSS VDD
+ VDD _0105_ sky130_fd_sc_hd__a21oi_1
X_1858_ input_buffer\[4\]\[16\] _0060_ VSS VSS VDD VDD _0106_
+ sky130_fd_sc_hd__nor2_1
X_1859_ _0040_ _0105_ _0106_ VSS VSS VDD VDD net245 sky130_fd_sc_hd__a21oi_1
X_1860_ input_buffer\[1\]\[17\] _0048_ VSS VSS VDD VDD _0107_
+ sky130_fd_sc_hd__nand2_1
X_1861_ _0050_ input_buffer\[0\]\[17\] _0076_ _0083_ VSS VSS
+ VDD VDD _0108_ sky130_fd_sc_hd__nand4_1
X_1862_ _0044_ VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__clkbuf_4
X_1863_ input_buffer\[2\]\[17\] _0109_ VSS VSS VDD VDD _0110_
+ sky130_fd_sc_hd__nor2_1
X_1864_ _0042_ VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__clkbuf_4
X_1865_ _0045_ _0107_ _0108_ _0110_ _0111_ VSS VSS VDD VDD
+ _0112_ sky130_fd_sc_hd__a311oi_1
X_1866_ input_buffer\[3\]\[17\] _0043_ _0112_ VSS VSS VDD
+ VDD _0113_ sky130_fd_sc_hd__a21oi_1
X_1867_ _0039_ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__clkbuf_4
X_1868_ input_buffer\[4\]\[17\] _0114_ VSS VSS VDD VDD _0115_
+ sky130_fd_sc_hd__nor2_1
X_1869_ _0040_ _0113_ _0115_ VSS VSS VDD VDD net246 sky130_fd_sc_hd__a21oi_1
X_1870_ input_buffer\[1\]\[18\] _0048_ VSS VSS VDD VDD _0116_
+ sky130_fd_sc_hd__nand2_1
X_1871_ _0710_ _1001_ _0069_ VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__nand3_1
X_1872_ input_buffer\[2\]\[18\] _0109_ VSS VSS VDD VDD _0118_
+ sky130_fd_sc_hd__nor2_1
X_1873_ _0045_ _0116_ _0117_ _0118_ _0111_ VSS VSS VDD VDD
+ _0119_ sky130_fd_sc_hd__a311oi_1
X_1874_ input_buffer\[3\]\[18\] _0043_ _0119_ VSS VSS VDD
+ VDD _0120_ sky130_fd_sc_hd__a21oi_1
X_1875_ input_buffer\[4\]\[18\] _0114_ VSS VSS VDD VDD _0121_
+ sky130_fd_sc_hd__nor2_1
X_1876_ _0040_ _0120_ _0121_ VSS VSS VDD VDD net247 sky130_fd_sc_hd__a21oi_1
X_1877_ _0039_ VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__clkbuf_4
X_1878_ _0042_ VSS VSS VDD VDD _0123_ sky130_fd_sc_hd__clkbuf_4
X_1879_ _0044_ VSS VSS VDD VDD _0124_ sky130_fd_sc_hd__clkbuf_4
X_1880_ _0047_ VSS VSS VDD VDD _0125_ sky130_fd_sc_hd__clkbuf_4
X_1881_ input_buffer\[1\]\[19\] _0125_ VSS VSS VDD VDD _0126_
+ sky130_fd_sc_hd__nand2_1
X_1882_ _0050_ input_buffer\[0\]\[19\] _0076_ _0083_ VSS VSS
+ VDD VDD _0127_ sky130_fd_sc_hd__nand4_1
X_1883_ input_buffer\[2\]\[19\] _0109_ VSS VSS VDD VDD _0128_
+ sky130_fd_sc_hd__nor2_1
X_1884_ _0124_ _0126_ _0127_ _0128_ _0111_ VSS VSS VDD VDD
+ _0129_ sky130_fd_sc_hd__a311oi_1
X_1885_ input_buffer\[3\]\[19\] _0123_ _0129_ VSS VSS VDD
+ VDD _0130_ sky130_fd_sc_hd__a21oi_1
X_1886_ input_buffer\[4\]\[19\] _0114_ VSS VSS VDD VDD _0131_
+ sky130_fd_sc_hd__nor2_1
X_1887_ _0122_ _0130_ _0131_ VSS VSS VDD VDD net248 sky130_fd_sc_hd__a21oi_1
X_1888_ input_buffer\[1\]\[1\] _0125_ VSS VSS VDD VDD _0132_
+ sky130_fd_sc_hd__nand2_1
X_1889_ _0710_ _1014_ _0069_ VSS VSS VDD VDD _0133_ sky130_fd_sc_hd__nand3_1
X_1890_ input_buffer\[2\]\[1\] _0109_ VSS VSS VDD VDD _0134_
+ sky130_fd_sc_hd__nor2_1
X_1891_ _0124_ _0132_ _0133_ _0134_ _0111_ VSS VSS VDD VDD
+ _0135_ sky130_fd_sc_hd__a311oi_1
X_1892_ input_buffer\[3\]\[1\] _0123_ _0135_ VSS VSS VDD VDD
+ _0136_ sky130_fd_sc_hd__a21oi_1
X_1893_ input_buffer\[4\]\[1\] _0114_ VSS VSS VDD VDD _0137_
+ sky130_fd_sc_hd__nor2_1
X_1894_ _0122_ _0136_ _0137_ VSS VSS VDD VDD net249 sky130_fd_sc_hd__a21oi_1
X_1895_ input_buffer\[1\]\[20\] _0125_ VSS VSS VDD VDD _0138_
+ sky130_fd_sc_hd__nand2_1
X_1896_ _0710_ _1018_ _0069_ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__nand3_1
X_1897_ input_buffer\[2\]\[20\] _0109_ VSS VSS VDD VDD _0140_
+ sky130_fd_sc_hd__nor2_1
X_1898_ _0124_ _0138_ _0139_ _0140_ _0111_ VSS VSS VDD VDD
+ _0141_ sky130_fd_sc_hd__a311oi_1
X_1899_ input_buffer\[3\]\[20\] _0123_ _0141_ VSS VSS VDD
+ VDD _0142_ sky130_fd_sc_hd__a21oi_1
X_1900_ input_buffer\[4\]\[20\] _0114_ VSS VSS VDD VDD _0143_
+ sky130_fd_sc_hd__nor2_1
X_1901_ _0122_ _0142_ _0143_ VSS VSS VDD VDD net250 sky130_fd_sc_hd__a21oi_1
X_1902_ input_buffer\[1\]\[21\] _0125_ VSS VSS VDD VDD _0144_
+ sky130_fd_sc_hd__nand2_1
X_1903_ _0050_ input_buffer\[0\]\[21\] _0076_ _0083_ VSS VSS
+ VDD VDD _0145_ sky130_fd_sc_hd__nand4_1
X_1904_ input_buffer\[2\]\[21\] _0109_ VSS VSS VDD VDD _0146_
+ sky130_fd_sc_hd__nor2_1
X_1905_ _0124_ _0144_ _0145_ _0146_ _0111_ VSS VSS VDD VDD
+ _0147_ sky130_fd_sc_hd__a311oi_1
X_1906_ input_buffer\[3\]\[21\] _0123_ _0147_ VSS VSS VDD
+ VDD _0148_ sky130_fd_sc_hd__a21oi_1
X_1907_ input_buffer\[4\]\[21\] _0114_ VSS VSS VDD VDD _0149_
+ sky130_fd_sc_hd__nor2_1
X_1908_ _0122_ _0148_ _0149_ VSS VSS VDD VDD net251 sky130_fd_sc_hd__a21oi_1
X_1909_ input_buffer\[1\]\[22\] _0125_ VSS VSS VDD VDD _0150_
+ sky130_fd_sc_hd__nand2_1
X_1910_ _0710_ _1026_ _0069_ VSS VSS VDD VDD _0151_ sky130_fd_sc_hd__nand3_1
X_1911_ input_buffer\[2\]\[22\] _0109_ VSS VSS VDD VDD _0152_
+ sky130_fd_sc_hd__nor2_1
X_1912_ _0124_ _0150_ _0151_ _0152_ _0111_ VSS VSS VDD VDD
+ _0153_ sky130_fd_sc_hd__a311oi_1
X_1913_ input_buffer\[3\]\[22\] _0123_ _0153_ VSS VSS VDD
+ VDD _0154_ sky130_fd_sc_hd__a21oi_1
X_1914_ input_buffer\[4\]\[22\] _0114_ VSS VSS VDD VDD _0155_
+ sky130_fd_sc_hd__nor2_1
X_1915_ _0122_ _0154_ _0155_ VSS VSS VDD VDD net252 sky130_fd_sc_hd__a21oi_1
X_1916_ input_buffer\[1\]\[23\] _0125_ VSS VSS VDD VDD _0156_
+ sky130_fd_sc_hd__nand2_1
X_1917_ _0050_ input_buffer\[0\]\[23\] _0076_ _0083_ VSS VSS
+ VDD VDD _0157_ sky130_fd_sc_hd__nand4_1
X_1918_ input_buffer\[2\]\[23\] _0109_ VSS VSS VDD VDD _0158_
+ sky130_fd_sc_hd__nor2_1
X_1919_ _0124_ _0156_ _0157_ _0158_ _0111_ VSS VSS VDD VDD
+ _0159_ sky130_fd_sc_hd__a311oi_1
X_1920_ input_buffer\[3\]\[23\] _0123_ _0159_ VSS VSS VDD
+ VDD _0160_ sky130_fd_sc_hd__a21oi_1
X_1921_ input_buffer\[4\]\[23\] _0114_ VSS VSS VDD VDD _0161_
+ sky130_fd_sc_hd__nor2_1
X_1922_ _0122_ _0160_ _0161_ VSS VSS VDD VDD net253 sky130_fd_sc_hd__a21oi_1
X_1923_ _0676_ _0125_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__nand2_1
X_1924_ _0050_ dest_id\[0\]\[0\] _0076_ _0083_ VSS VSS VDD
+ VDD _0163_ sky130_fd_sc_hd__nand4_1
X_1925_ _0650_ _0109_ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__nor2_1
X_1926_ _0124_ _0162_ _0163_ _0164_ _0111_ VSS VSS VDD VDD
+ _0165_ sky130_fd_sc_hd__a311oi_1
X_1927_ _0634_ _0123_ _0165_ VSS VSS VDD VDD _0166_ sky130_fd_sc_hd__a21oi_1
X_1928_ _0606_ _0114_ VSS VSS VDD VDD _0167_ sky130_fd_sc_hd__nor2_1
X_1929_ _0122_ _0166_ _0167_ VSS VSS VDD VDD net254 sky130_fd_sc_hd__a21oi_2
X_1930_ _0673_ _0125_ VSS VSS VDD VDD _0168_ sky130_fd_sc_hd__nand2_1
X_1931_ _0050_ dest_id\[0\]\[1\] _0076_ _0083_ VSS VSS VDD
+ VDD _0169_ sky130_fd_sc_hd__nand4_1
X_1932_ dest_id\[2\]\[1\] _0109_ VSS VSS VDD VDD _0170_ sky130_fd_sc_hd__nor2_1
X_1933_ _0124_ _0168_ _0169_ _0170_ _0111_ VSS VSS VDD VDD
+ _0171_ sky130_fd_sc_hd__a311oi_1
X_1934_ _0627_ _0123_ _0171_ VSS VSS VDD VDD _0172_ sky130_fd_sc_hd__a21oi_1
X_1935_ _0604_ _0114_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__nor2_1
X_1936_ _0122_ _0172_ _0173_ VSS VSS VDD VDD net255 sky130_fd_sc_hd__a21oi_1
X_1937_ _0674_ _0125_ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__nand2_1
X_1938_ _0854_ _0697_ _0076_ _0083_ VSS VSS VDD VDD _0175_
+ sky130_fd_sc_hd__nand4_1
X_1939_ _0044_ VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__clkbuf_4
X_1940_ _0649_ _0176_ VSS VSS VDD VDD _0177_ sky130_fd_sc_hd__nor2_1
X_1941_ _0042_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__buf_4
X_1942_ _0124_ _0174_ _0175_ _0177_ _0178_ VSS VSS VDD VDD
+ _0179_ sky130_fd_sc_hd__a311oi_1
X_1943_ _0628_ _0123_ _0179_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__a21oi_1
X_1944_ _0039_ VSS VSS VDD VDD _0181_ sky130_fd_sc_hd__buf_4
X_1945_ _0605_ _0181_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__nor2_1
X_1946_ _0122_ _0180_ _0182_ VSS VSS VDD VDD net256 sky130_fd_sc_hd__a21oi_2
X_1947_ _0677_ _0125_ VSS VSS VDD VDD _0183_ sky130_fd_sc_hd__nand2_1
X_1948_ _0710_ _1050_ _0069_ VSS VSS VDD VDD _0184_ sky130_fd_sc_hd__nand3_1
X_1949_ _0652_ _0176_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__nor2_1
X_1950_ _0124_ _0183_ _0184_ _0185_ _0178_ VSS VSS VDD VDD
+ _0186_ sky130_fd_sc_hd__a311oi_1
X_1951_ dest_id\[3\]\[3\] _0123_ _0186_ VSS VSS VDD VDD _0187_
+ sky130_fd_sc_hd__a21oi_1
X_1952_ _0608_ _0181_ VSS VSS VDD VDD _0188_ sky130_fd_sc_hd__nor2_1
X_1953_ _0122_ _0187_ _0188_ VSS VSS VDD VDD net257 sky130_fd_sc_hd__a21oi_1
X_1954_ _0039_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__buf_4
X_1955_ _0042_ VSS VSS VDD VDD _0190_ sky130_fd_sc_hd__buf_4
X_1956_ _0044_ VSS VSS VDD VDD _0191_ sky130_fd_sc_hd__buf_4
X_1957_ _0714_ dest_id\[0\]\[4\] _0051_ _0053_ VSS VSS VDD
+ VDD _0192_ sky130_fd_sc_hd__nand4_1
X_1958_ _0047_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__clkbuf_4
X_1959_ dest_id\[1\]\[4\] _0193_ VSS VSS VDD VDD _0194_ sky130_fd_sc_hd__nand2_1
X_1960_ dest_id\[2\]\[4\] _0176_ VSS VSS VDD VDD _0195_ sky130_fd_sc_hd__nor2_1
X_1961_ _0191_ _0192_ _0194_ _0195_ _0178_ VSS VSS VDD VDD
+ _0196_ sky130_fd_sc_hd__a311oi_2
X_1962_ dest_id\[3\]\[4\] _0190_ _0196_ VSS VSS VDD VDD _0197_
+ sky130_fd_sc_hd__a21oi_1
X_1963_ dest_id\[4\]\[4\] _0181_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__nor2_1
X_1964_ _0189_ _0197_ _0198_ VSS VSS VDD VDD net258 sky130_fd_sc_hd__a21oi_1
X_1965_ _0714_ dest_id\[0\]\[5\] _0051_ _0053_ VSS VSS VDD
+ VDD _0199_ sky130_fd_sc_hd__nand4_1
X_1966_ dest_id\[1\]\[5\] _0193_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__nand2_1
X_1967_ dest_id\[2\]\[5\] _0176_ VSS VSS VDD VDD _0201_ sky130_fd_sc_hd__nor2_1
X_1968_ _0191_ _0199_ _0200_ _0201_ _0178_ VSS VSS VDD VDD
+ _0202_ sky130_fd_sc_hd__a311oi_2
X_1969_ dest_id\[3\]\[5\] _0190_ _0202_ VSS VSS VDD VDD _0203_
+ sky130_fd_sc_hd__a21oi_1
X_1970_ dest_id\[4\]\[5\] _0181_ VSS VSS VDD VDD _0204_ sky130_fd_sc_hd__nor2_1
X_1971_ _0189_ _0203_ _0204_ VSS VSS VDD VDD net259 sky130_fd_sc_hd__a21oi_1
X_1972_ input_buffer\[1\]\[2\] _0193_ VSS VSS VDD VDD _0205_
+ sky130_fd_sc_hd__nand2_1
X_1973_ _0051_ _1069_ _0069_ VSS VSS VDD VDD _0206_ sky130_fd_sc_hd__nand3_1
X_1974_ input_buffer\[2\]\[2\] _0176_ VSS VSS VDD VDD _0207_
+ sky130_fd_sc_hd__nor2_1
X_1975_ _0191_ _0205_ _0206_ _0207_ _0178_ VSS VSS VDD VDD
+ _0208_ sky130_fd_sc_hd__a311oi_1
X_1976_ input_buffer\[3\]\[2\] _0190_ _0208_ VSS VSS VDD VDD
+ _0209_ sky130_fd_sc_hd__a21oi_1
X_1977_ input_buffer\[4\]\[2\] _0181_ VSS VSS VDD VDD _0210_
+ sky130_fd_sc_hd__nor2_1
X_1978_ _0189_ _0209_ _0210_ VSS VSS VDD VDD net260 sky130_fd_sc_hd__a21oi_1
X_1979_ _0714_ dest_id\[0\]\[6\] _0051_ _0053_ VSS VSS VDD
+ VDD _0211_ sky130_fd_sc_hd__nand4_1
X_1980_ dest_id\[1\]\[6\] _0047_ VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__nand2_1
X_1981_ dest_id\[2\]\[6\] _0176_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__nor2_1
X_1982_ _0191_ _0211_ _0212_ _0213_ _0178_ VSS VSS VDD VDD
+ _0214_ sky130_fd_sc_hd__a311oi_2
X_1983_ dest_id\[3\]\[6\] _0190_ _0214_ VSS VSS VDD VDD _0215_
+ sky130_fd_sc_hd__a21oi_1
X_1984_ dest_id\[4\]\[6\] _0181_ VSS VSS VDD VDD _0216_ sky130_fd_sc_hd__nor2_1
X_1985_ _0189_ _0215_ _0216_ VSS VSS VDD VDD net261 sky130_fd_sc_hd__a21oi_1
X_1986_ _0714_ dest_id\[0\]\[7\] _0051_ _0053_ VSS VSS VDD
+ VDD _0217_ sky130_fd_sc_hd__nand4_1
X_1987_ dest_id\[1\]\[7\] _0047_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__nand2_1
X_1988_ dest_id\[2\]\[7\] _0176_ VSS VSS VDD VDD _0219_ sky130_fd_sc_hd__nor2_1
X_1989_ _0191_ _0217_ _0218_ _0219_ _0178_ VSS VSS VDD VDD
+ _0220_ sky130_fd_sc_hd__a311oi_2
X_1990_ dest_id\[3\]\[7\] _0190_ _0220_ VSS VSS VDD VDD _0221_
+ sky130_fd_sc_hd__a21oi_1
X_1991_ dest_id\[4\]\[7\] _0181_ VSS VSS VDD VDD _0222_ sky130_fd_sc_hd__nor2_1
X_1992_ _0189_ _0221_ _0222_ VSS VSS VDD VDD net262 sky130_fd_sc_hd__a21oi_1
X_1993_ input_buffer\[1\]\[3\] _0193_ VSS VSS VDD VDD _0223_
+ sky130_fd_sc_hd__nand2_1
X_1994_ _0854_ input_buffer\[0\]\[3\] _0076_ _0083_ VSS VSS
+ VDD VDD _0224_ sky130_fd_sc_hd__nand4_1
X_1995_ input_buffer\[2\]\[3\] _0176_ VSS VSS VDD VDD _0225_
+ sky130_fd_sc_hd__nor2_1
X_1996_ _0191_ _0223_ _0224_ _0225_ _0178_ VSS VSS VDD VDD
+ _0226_ sky130_fd_sc_hd__a311oi_1
X_1997_ input_buffer\[3\]\[3\] _0190_ _0226_ VSS VSS VDD VDD
+ _0227_ sky130_fd_sc_hd__a21oi_1
X_1998_ input_buffer\[4\]\[3\] _0181_ VSS VSS VDD VDD _0228_
+ sky130_fd_sc_hd__nor2_1
X_1999_ _0189_ _0227_ _0228_ VSS VSS VDD VDD net263 sky130_fd_sc_hd__a21oi_1
X_2000_ input_buffer\[1\]\[4\] _0193_ VSS VSS VDD VDD _0229_
+ sky130_fd_sc_hd__nand2_1
X_2001_ _0051_ _0014_ _0053_ VSS VSS VDD VDD _0230_ sky130_fd_sc_hd__nand3_1
X_2002_ input_buffer\[2\]\[4\] _0176_ VSS VSS VDD VDD _0231_
+ sky130_fd_sc_hd__nor2_1
X_2003_ _0191_ _0229_ _0230_ _0231_ _0178_ VSS VSS VDD VDD
+ _0232_ sky130_fd_sc_hd__a311oi_1
X_2004_ input_buffer\[3\]\[4\] _0190_ _0232_ VSS VSS VDD VDD
+ _0233_ sky130_fd_sc_hd__a21oi_1
X_2005_ input_buffer\[4\]\[4\] _0181_ VSS VSS VDD VDD _0234_
+ sky130_fd_sc_hd__nor2_1
X_2006_ _0189_ _0233_ _0234_ VSS VSS VDD VDD net264 sky130_fd_sc_hd__a21oi_1
X_2007_ input_buffer\[1\]\[5\] _0193_ VSS VSS VDD VDD _0235_
+ sky130_fd_sc_hd__nand2_1
X_2008_ _0051_ _0018_ _0053_ VSS VSS VDD VDD _0236_ sky130_fd_sc_hd__nand3_1
X_2009_ input_buffer\[2\]\[5\] _0176_ VSS VSS VDD VDD _0237_
+ sky130_fd_sc_hd__nor2_1
X_2010_ _0191_ _0235_ _0236_ _0237_ _0178_ VSS VSS VDD VDD
+ _0238_ sky130_fd_sc_hd__a311oi_1
X_2011_ input_buffer\[3\]\[5\] _0190_ _0238_ VSS VSS VDD VDD
+ _0239_ sky130_fd_sc_hd__a21oi_1
X_2012_ input_buffer\[4\]\[5\] _0181_ VSS VSS VDD VDD _0240_
+ sky130_fd_sc_hd__nor2_1
X_2013_ _0189_ _0239_ _0240_ VSS VSS VDD VDD net265 sky130_fd_sc_hd__a21oi_1
X_2014_ input_buffer\[1\]\[6\] _0193_ VSS VSS VDD VDD _0241_
+ sky130_fd_sc_hd__nand2_1
X_2015_ _0854_ input_buffer\[0\]\[6\] _0709_ _0083_ VSS VSS
+ VDD VDD _0242_ sky130_fd_sc_hd__nand4_1
X_2016_ input_buffer\[2\]\[6\] _0044_ VSS VSS VDD VDD _0243_
+ sky130_fd_sc_hd__nor2_1
X_2017_ _0191_ _0241_ _0242_ _0243_ _0042_ VSS VSS VDD VDD
+ _0244_ sky130_fd_sc_hd__a311oi_1
X_2018_ input_buffer\[3\]\[6\] _0190_ _0244_ VSS VSS VDD VDD
+ _0245_ sky130_fd_sc_hd__a21oi_1
X_2019_ input_buffer\[4\]\[6\] _0039_ VSS VSS VDD VDD _0246_
+ sky130_fd_sc_hd__nor2_1
X_2020_ _0189_ _0245_ _0246_ VSS VSS VDD VDD net266 sky130_fd_sc_hd__a21oi_1
X_2021_ input_buffer\[1\]\[7\] _0193_ VSS VSS VDD VDD _0247_
+ sky130_fd_sc_hd__nand2_1
X_2022_ _0854_ input_buffer\[0\]\[7\] _0709_ _0052_ VSS VSS
+ VDD VDD _0248_ sky130_fd_sc_hd__nand4_1
X_2023_ input_buffer\[2\]\[7\] _0044_ VSS VSS VDD VDD _0249_
+ sky130_fd_sc_hd__nor2_1
X_2024_ _0191_ _0247_ _0248_ _0249_ _0042_ VSS VSS VDD VDD
+ _0250_ sky130_fd_sc_hd__a311oi_1
X_2025_ input_buffer\[3\]\[7\] _0190_ _0250_ VSS VSS VDD VDD
+ _0251_ sky130_fd_sc_hd__a21oi_1
X_2026_ input_buffer\[4\]\[7\] _0039_ VSS VSS VDD VDD _0252_
+ sky130_fd_sc_hd__nor2_1
X_2027_ _0189_ _0251_ _0252_ VSS VSS VDD VDD net267 sky130_fd_sc_hd__a21oi_1
X_2028_ input_buffer\[1\]\[8\] _0193_ VSS VSS VDD VDD _0253_
+ sky130_fd_sc_hd__nand2_1
X_2029_ _0854_ input_buffer\[0\]\[8\] _0709_ _0052_ VSS VSS
+ VDD VDD _0254_ sky130_fd_sc_hd__nand4_1
X_2030_ input_buffer\[2\]\[8\] _0044_ VSS VSS VDD VDD _0255_
+ sky130_fd_sc_hd__nor2_1
X_2031_ _0055_ _0253_ _0254_ _0255_ _0042_ VSS VSS VDD VDD
+ _0256_ sky130_fd_sc_hd__a311oi_1
X_2032_ input_buffer\[3\]\[8\] _0057_ _0256_ VSS VSS VDD VDD
+ _0257_ sky130_fd_sc_hd__a21oi_1
X_2033_ input_buffer\[4\]\[8\] _0039_ VSS VSS VDD VDD _0258_
+ sky130_fd_sc_hd__nor2_1
X_2034_ _0060_ _0257_ _0258_ VSS VSS VDD VDD net268 sky130_fd_sc_hd__a21oi_1
X_2035_ input_buffer\[1\]\[9\] _0193_ VSS VSS VDD VDD _0259_
+ sky130_fd_sc_hd__nand2_1
X_2036_ _0051_ _0034_ _0053_ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__nand3_1
X_2037_ input_buffer\[2\]\[9\] _0044_ VSS VSS VDD VDD _0261_
+ sky130_fd_sc_hd__nor2_1
X_2038_ _0055_ _0259_ _0260_ _0261_ _0042_ VSS VSS VDD VDD
+ _0262_ sky130_fd_sc_hd__a311oi_1
X_2039_ input_buffer\[3\]\[9\] _0057_ _0262_ VSS VSS VDD VDD
+ _0263_ sky130_fd_sc_hd__a21oi_1
X_2040_ input_buffer\[4\]\[9\] _0039_ VSS VSS VDD VDD _0264_
+ sky130_fd_sc_hd__nor2_1
X_2041_ _0060_ _0263_ _0264_ VSS VSS VDD VDD net269 sky130_fd_sc_hd__a21oi_1
X_2042_ _0625_ _1150_ VSS VSS VDD VDD _0265_ sky130_fd_sc_hd__nand2_1
X_2043_ _1161_ _0265_ VSS VSS VDD VDD _0266_ sky130_fd_sc_hd__nor2_1
X_2044_ _1151_ _0621_ _0266_ VSS VSS VDD VDD _0267_ sky130_fd_sc_hd__nand3_1
X_2045_ _0677_ _0689_ VSS VSS VDD VDD _0268_ sky130_fd_sc_hd__nor2_1
X_2046_ _1116_ _1105_ _0857_ _0676_ VSS VSS VDD VDD _0269_
+ sky130_fd_sc_hd__nand4b_1
X_2047_ _0673_ _0674_ _0269_ VSS VSS VDD VDD _0270_ sky130_fd_sc_hd__nor3_1
X_2048_ net301 _0629_ _1146_ _1135_ VSS VSS VDD VDD _0271_
+ sky130_fd_sc_hd__nor4b_1
X_2049_ _0268_ _0270_ _0271_ _0644_ VSS VSS VDD VDD _0272_
+ sky130_fd_sc_hd__a22oi_1
X_2050_ _1131_ _1120_ VSS VSS VDD VDD _0273_ sky130_fd_sc_hd__nor2b_1
X_2051_ _0599_ _0651_ _0667_ _0273_ VSS VSS VDD VDD _0274_
+ sky130_fd_sc_hd__nand4_1
X_2052_ dest_id\[0\]\[3\] _0697_ _1101_ _1090_ VSS VSS VDD
+ VDD _0275_ sky130_fd_sc_hd__nor4b_1
X_2053_ _0714_ dest_id\[0\]\[0\] _0703_ _0275_ VSS VSS VDD
+ VDD _0276_ sky130_fd_sc_hd__nand4_1
X_2054_ _0267_ _0272_ _0274_ _0276_ VSS VSS VDD VDD net270
+ sky130_fd_sc_hd__nand4_1
X_2055_ _0730_ _0685_ _0600_ _1112_ _0683_ VSS VSS VDD VDD
+ _0277_ sky130_fd_sc_hd__o2111a_1
X_2056_ _0277_ VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__clkbuf_4
X_2057_ _0598_ _1127_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__nand2_1
X_2058_ _0655_ _0279_ VSS VSS VDD VDD _0280_ sky130_fd_sc_hd__nor2_4
X_2059_ _0280_ VSS VSS VDD VDD _0281_ sky130_fd_sc_hd__clkbuf_4
X_2060_ _0698_ _0707_ _1097_ _0702_ VSS VSS VDD VDD _0282_
+ sky130_fd_sc_hd__o211ai_4
X_2061_ _0282_ VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__clkbuf_4
X_2062_ _0277_ VSS VSS VDD VDD _0284_ sky130_fd_sc_hd__buf_4
X_2063_ _0728_ _0283_ _0284_ VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__nor3_1
X_2064_ input_buffer\[1\]\[0\] _0278_ _0281_ _0285_ VSS VSS
+ VDD VDD _0286_ sky130_fd_sc_hd__a211oi_1
X_2065_ _0669_ _0658_ _0279_ _0656_ VSS VSS VDD VDD _0287_
+ sky130_fd_sc_hd__a211o_2
X_2066_ _0287_ VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__clkbuf_4
X_2067_ _0735_ _0642_ _0597_ _1142_ _0633_ VSS VSS VDD VDD
+ _0289_ sky130_fd_sc_hd__o2111ai_4
X_2068_ input_buffer_valid\[4\] _1157_ VSS VSS VDD VDD _0290_
+ sky130_fd_sc_hd__nand2_1
X_2069_ _0619_ _0615_ _0290_ _0613_ VSS VSS VDD VDD _0291_
+ sky130_fd_sc_hd__a211o_1
X_2070_ _0289_ _0291_ VSS VSS VDD VDD _0292_ sky130_fd_sc_hd__and2_2
X_2071_ _0292_ VSS VSS VDD VDD _0293_ sky130_fd_sc_hd__clkbuf_4
X_2072_ input_buffer\[2\]\[0\] _0288_ _0293_ VSS VSS VDD VDD
+ _0294_ sky130_fd_sc_hd__o21ai_0
X_2073_ _0619_ _0615_ _0290_ _0613_ VSS VSS VDD VDD _0295_
+ sky130_fd_sc_hd__a211oi_4
X_2074_ _0295_ VSS VSS VDD VDD _0296_ sky130_fd_sc_hd__buf_4
X_2075_ _0289_ _0295_ VSS VSS VDD VDD _0297_ sky130_fd_sc_hd__nor2_8
X_2076_ _0297_ VSS VSS VDD VDD _0298_ sky130_fd_sc_hd__buf_6
X_2077_ input_buffer\[4\]\[0\] _0296_ _0298_ input_buffer\[3\]\[0\]
+ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__a22oi_1
X_2078_ _0286_ _0294_ _0299_ VSS VSS VDD VDD net272 sky130_fd_sc_hd__o21ai_0
X_2079_ _0748_ _0283_ _0284_ VSS VSS VDD VDD _0300_ sky130_fd_sc_hd__nor3_1
X_2080_ input_buffer\[1\]\[10\] _0278_ _0281_ _0300_ VSS VSS
+ VDD VDD _0301_ sky130_fd_sc_hd__a211oi_1
X_2081_ input_buffer\[2\]\[10\] _0288_ _0293_ VSS VSS VDD
+ VDD _0302_ sky130_fd_sc_hd__o21ai_0
X_2082_ input_buffer\[4\]\[10\] _0296_ _0298_ input_buffer\[3\]\[10\]
+ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__a22oi_1
X_2083_ _0301_ _0302_ _0303_ VSS VSS VDD VDD net273 sky130_fd_sc_hd__o21ai_0
X_2084_ _0755_ _0283_ _0284_ VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__nor3_1
X_2085_ input_buffer\[1\]\[11\] _0278_ _0281_ _0304_ VSS VSS
+ VDD VDD _0305_ sky130_fd_sc_hd__a211oi_1
X_2086_ input_buffer\[2\]\[11\] _0288_ _0293_ VSS VSS VDD
+ VDD _0306_ sky130_fd_sc_hd__o21ai_0
X_2087_ input_buffer\[4\]\[11\] _0296_ _0298_ input_buffer\[3\]\[11\]
+ VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__a22oi_1
X_2088_ _0305_ _0306_ _0307_ VSS VSS VDD VDD net274 sky130_fd_sc_hd__o21ai_0
X_2089_ _0761_ _0283_ _0284_ VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__nor3_1
X_2090_ input_buffer\[1\]\[12\] _0278_ _0281_ _0308_ VSS VSS
+ VDD VDD _0309_ sky130_fd_sc_hd__a211oi_1
X_2091_ input_buffer\[2\]\[12\] _0288_ _0293_ VSS VSS VDD
+ VDD _0310_ sky130_fd_sc_hd__o21ai_0
X_2092_ input_buffer\[4\]\[12\] _0296_ _0298_ input_buffer\[3\]\[12\]
+ VSS VSS VDD VDD _0311_ sky130_fd_sc_hd__a22oi_1
X_2093_ _0309_ _0310_ _0311_ VSS VSS VDD VDD net275 sky130_fd_sc_hd__o21ai_0
X_2094_ _0769_ _0283_ _0284_ VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__nor3_1
X_2095_ input_buffer\[1\]\[13\] _0278_ _0281_ _0312_ VSS VSS
+ VDD VDD _0313_ sky130_fd_sc_hd__a211oi_1
X_2096_ input_buffer\[2\]\[13\] _0288_ _0293_ VSS VSS VDD
+ VDD _0314_ sky130_fd_sc_hd__o21ai_0
X_2097_ input_buffer\[4\]\[13\] _0296_ _0298_ input_buffer\[3\]\[13\]
+ VSS VSS VDD VDD _0315_ sky130_fd_sc_hd__a22oi_1
X_2098_ _0313_ _0314_ _0315_ VSS VSS VDD VDD net276 sky130_fd_sc_hd__o21ai_0
X_2099_ _0277_ VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__clkbuf_4
X_2100_ _0776_ _0283_ _0316_ VSS VSS VDD VDD _0317_ sky130_fd_sc_hd__nor3_1
X_2101_ input_buffer\[1\]\[14\] _0278_ _0281_ _0317_ VSS VSS
+ VDD VDD _0318_ sky130_fd_sc_hd__a211oi_1
X_2102_ input_buffer\[2\]\[14\] _0288_ _0293_ VSS VSS VDD
+ VDD _0319_ sky130_fd_sc_hd__o21ai_0
X_2103_ input_buffer\[4\]\[14\] _0296_ _0298_ input_buffer\[3\]\[14\]
+ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__a22oi_1
X_2104_ _0318_ _0319_ _0320_ VSS VSS VDD VDD net277 sky130_fd_sc_hd__o21ai_0
X_2105_ _0782_ _0283_ _0316_ VSS VSS VDD VDD _0321_ sky130_fd_sc_hd__nor3_1
X_2106_ input_buffer\[1\]\[15\] _0278_ _0281_ _0321_ VSS VSS
+ VDD VDD _0322_ sky130_fd_sc_hd__a211oi_1
X_2107_ _0287_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__clkbuf_4
X_2108_ input_buffer\[2\]\[15\] _0323_ _0293_ VSS VSS VDD
+ VDD _0324_ sky130_fd_sc_hd__o21ai_0
X_2109_ _0297_ VSS VSS VDD VDD _0325_ sky130_fd_sc_hd__buf_6
X_2110_ input_buffer\[4\]\[15\] _0296_ _0325_ input_buffer\[3\]\[15\]
+ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__a22oi_1
X_2111_ _0322_ _0324_ _0326_ VSS VSS VDD VDD net278 sky130_fd_sc_hd__o21ai_1
X_2112_ _0788_ _0283_ _0316_ VSS VSS VDD VDD _0327_ sky130_fd_sc_hd__nor3_1
X_2113_ input_buffer\[1\]\[16\] _0278_ _0281_ _0327_ VSS VSS
+ VDD VDD _0328_ sky130_fd_sc_hd__a211oi_1
X_2114_ input_buffer\[2\]\[16\] _0323_ _0293_ VSS VSS VDD
+ VDD _0329_ sky130_fd_sc_hd__o21ai_0
X_2115_ _0295_ VSS VSS VDD VDD _0330_ sky130_fd_sc_hd__clkbuf_4
X_2116_ input_buffer\[4\]\[16\] _0330_ _0325_ input_buffer\[3\]\[16\]
+ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__a22oi_1
X_2117_ _0328_ _0329_ _0331_ VSS VSS VDD VDD net279 sky130_fd_sc_hd__o21ai_1
X_2118_ _0289_ _0291_ VSS VSS VDD VDD _0332_ sky130_fd_sc_hd__nand2_2
X_2119_ _0277_ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__clkbuf_4
X_2120_ _0794_ _0282_ _0333_ VSS VSS VDD VDD _0334_ sky130_fd_sc_hd__nor3_1
X_2121_ input_buffer\[1\]\[17\] _0284_ _0280_ _0334_ VSS VSS
+ VDD VDD _0335_ sky130_fd_sc_hd__a211oi_1
X_2122_ input_buffer\[2\]\[17\] _0288_ VSS VSS VDD VDD _0336_
+ sky130_fd_sc_hd__nor2_1
X_2123_ input_buffer\[4\]\[17\] _0296_ _0298_ input_buffer\[3\]\[17\]
+ VSS VSS VDD VDD _0337_ sky130_fd_sc_hd__a22oi_1
X_2124_ _0332_ _0335_ _0336_ _0337_ VSS VSS VDD VDD net280
+ sky130_fd_sc_hd__o31ai_2
X_2125_ _0802_ _0283_ _0316_ VSS VSS VDD VDD _0338_ sky130_fd_sc_hd__nor3_1
X_2126_ input_buffer\[1\]\[18\] _0278_ _0281_ _0338_ VSS VSS
+ VDD VDD _0339_ sky130_fd_sc_hd__a211oi_1
X_2127_ input_buffer\[2\]\[18\] _0323_ _0293_ VSS VSS VDD
+ VDD _0340_ sky130_fd_sc_hd__o21ai_0
X_2128_ input_buffer\[4\]\[18\] _0330_ _0325_ input_buffer\[3\]\[18\]
+ VSS VSS VDD VDD _0341_ sky130_fd_sc_hd__a22oi_1
X_2129_ _0339_ _0340_ _0341_ VSS VSS VDD VDD net281 sky130_fd_sc_hd__o21ai_1
X_2130_ _0812_ _0283_ _0316_ VSS VSS VDD VDD _0342_ sky130_fd_sc_hd__nor3_1
X_2131_ input_buffer\[1\]\[19\] _0278_ _0281_ _0342_ VSS VSS
+ VDD VDD _0343_ sky130_fd_sc_hd__a211oi_1
X_2132_ _0292_ VSS VSS VDD VDD _0344_ sky130_fd_sc_hd__clkbuf_4
X_2133_ input_buffer\[2\]\[19\] _0323_ _0344_ VSS VSS VDD
+ VDD _0345_ sky130_fd_sc_hd__o21ai_0
X_2134_ input_buffer\[4\]\[19\] _0330_ _0325_ input_buffer\[3\]\[19\]
+ VSS VSS VDD VDD _0346_ sky130_fd_sc_hd__a22oi_1
X_2135_ _0343_ _0345_ _0346_ VSS VSS VDD VDD net282 sky130_fd_sc_hd__o21ai_1
X_2136_ _0277_ VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__clkbuf_4
X_2137_ _0280_ VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__clkbuf_4
X_2138_ _0282_ VSS VSS VDD VDD _0349_ sky130_fd_sc_hd__clkbuf_4
X_2139_ _0821_ _0349_ _0316_ VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__nor3_1
X_2140_ input_buffer\[1\]\[1\] _0347_ _0348_ _0350_ VSS VSS
+ VDD VDD _0351_ sky130_fd_sc_hd__a211oi_1
X_2141_ input_buffer\[2\]\[1\] _0323_ _0344_ VSS VSS VDD VDD
+ _0352_ sky130_fd_sc_hd__o21ai_0
X_2142_ input_buffer\[4\]\[1\] _0330_ _0325_ input_buffer\[3\]\[1\]
+ VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__a22oi_1
X_2143_ _0351_ _0352_ _0353_ VSS VSS VDD VDD net283 sky130_fd_sc_hd__o21ai_1
X_2144_ _0827_ _0349_ _0316_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__nor3_1
X_2145_ input_buffer\[1\]\[20\] _0347_ _0348_ _0354_ VSS VSS
+ VDD VDD _0355_ sky130_fd_sc_hd__a211oi_1
X_2146_ input_buffer\[2\]\[20\] _0323_ _0344_ VSS VSS VDD
+ VDD _0356_ sky130_fd_sc_hd__o21ai_0
X_2147_ input_buffer\[4\]\[20\] _0330_ _0325_ input_buffer\[3\]\[20\]
+ VSS VSS VDD VDD _0357_ sky130_fd_sc_hd__a22oi_1
X_2148_ _0355_ _0356_ _0357_ VSS VSS VDD VDD net284 sky130_fd_sc_hd__o21ai_0
X_2149_ _0833_ _0349_ _0316_ VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__nor3_1
X_2150_ input_buffer\[1\]\[21\] _0347_ _0348_ _0358_ VSS VSS
+ VDD VDD _0359_ sky130_fd_sc_hd__a211oi_1
X_2151_ input_buffer\[2\]\[21\] _0323_ _0344_ VSS VSS VDD
+ VDD _0360_ sky130_fd_sc_hd__o21ai_0
X_2152_ input_buffer\[4\]\[21\] _0330_ _0325_ input_buffer\[3\]\[21\]
+ VSS VSS VDD VDD _0361_ sky130_fd_sc_hd__a22oi_1
X_2153_ _0359_ _0360_ _0361_ VSS VSS VDD VDD net285 sky130_fd_sc_hd__o21ai_0
X_2154_ _0841_ _0349_ _0316_ VSS VSS VDD VDD _0362_ sky130_fd_sc_hd__nor3_1
X_2155_ input_buffer\[1\]\[22\] _0347_ _0348_ _0362_ VSS VSS
+ VDD VDD _0363_ sky130_fd_sc_hd__a211oi_1
X_2156_ input_buffer\[2\]\[22\] _0323_ _0344_ VSS VSS VDD
+ VDD _0364_ sky130_fd_sc_hd__o21ai_0
X_2157_ input_buffer\[4\]\[22\] _0330_ _0325_ input_buffer\[3\]\[22\]
+ VSS VSS VDD VDD _0365_ sky130_fd_sc_hd__a22oi_1
X_2158_ _0363_ _0364_ _0365_ VSS VSS VDD VDD net286 sky130_fd_sc_hd__o21ai_0
X_2159_ _0847_ _0282_ _0333_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__nor3_1
X_2160_ input_buffer\[1\]\[23\] _0284_ _0280_ _0366_ VSS VSS
+ VDD VDD _0367_ sky130_fd_sc_hd__a211oi_1
X_2161_ input_buffer\[2\]\[23\] _0288_ VSS VSS VDD VDD _0368_
+ sky130_fd_sc_hd__nor2_1
X_2162_ input_buffer\[4\]\[23\] _0296_ _0298_ input_buffer\[3\]\[23\]
+ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__a22oi_1
X_2163_ _0332_ _0367_ _0368_ _0369_ VSS VSS VDD VDD net287
+ sky130_fd_sc_hd__o31ai_2
X_2164_ _0284_ _0855_ _1097_ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__nor3b_1
X_2165_ _0602_ _0676_ _1112_ VSS VSS VDD VDD _0371_ sky130_fd_sc_hd__nand3_1
X_2166_ _0287_ VSS VSS VDD VDD _0372_ sky130_fd_sc_hd__clkbuf_4
X_2167_ _0682_ _0371_ _0372_ VSS VSS VDD VDD _0373_ sky130_fd_sc_hd__o21ai_0
X_2168_ _0650_ _0288_ _0370_ _0373_ _0293_ VSS VSS VDD VDD
+ _0374_ sky130_fd_sc_hd__o221ai_2
X_2169_ _0606_ _0296_ _0298_ _0634_ VSS VSS VDD VDD _0375_
+ sky130_fd_sc_hd__a22oi_1
X_2170_ _0374_ _0375_ VSS VSS VDD VDD net288 sky130_fd_sc_hd__nand2_1
X_2171_ _0708_ _0866_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__nor2_1
X_2172_ _0730_ _0685_ _0601_ _1112_ _0683_ VSS VSS VDD VDD
+ _0377_ sky130_fd_sc_hd__o2111ai_4
X_2173_ _0602_ _0673_ _1112_ VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__nand3_1
X_2174_ _0682_ _0378_ _0372_ VSS VSS VDD VDD _0379_ sky130_fd_sc_hd__o21ai_0
X_2175_ _1097_ _0376_ _0377_ _0379_ VSS VSS VDD VDD _0380_
+ sky130_fd_sc_hd__a31oi_1
X_2176_ dest_id\[2\]\[1\] _0323_ _0344_ VSS VSS VDD VDD _0381_
+ sky130_fd_sc_hd__o21ai_0
X_2177_ _0604_ _0330_ _0325_ _0627_ VSS VSS VDD VDD _0382_
+ sky130_fd_sc_hd__a22oi_1
X_2178_ _0380_ _0381_ _0382_ VSS VSS VDD VDD net289 sky130_fd_sc_hd__o21ai_2
X_2179_ _0708_ _0874_ VSS VSS VDD VDD _0383_ sky130_fd_sc_hd__nor2_1
X_2180_ _0857_ _0674_ _1112_ VSS VSS VDD VDD _0384_ sky130_fd_sc_hd__nand3_1
X_2181_ _0681_ _0384_ _0287_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__o21ai_0
X_2182_ _1097_ _0383_ _0377_ _0385_ VSS VSS VDD VDD _0386_
+ sky130_fd_sc_hd__a31oi_1
X_2183_ _0649_ _0288_ VSS VSS VDD VDD _0387_ sky130_fd_sc_hd__nor2_1
X_2184_ _0606_ _0291_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__nor2_1
X_2185_ _0628_ _0298_ _0388_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__a21oi_1
X_2186_ _0332_ _0386_ _0387_ _0389_ VSS VSS VDD VDD net290
+ sky130_fd_sc_hd__o31ai_2
X_2187_ _0677_ _0333_ VSS VSS VDD VDD _0390_ sky130_fd_sc_hd__nand2_1
X_2188_ _1097_ _0703_ _0882_ _0377_ VSS VSS VDD VDD _0391_
+ sky130_fd_sc_hd__nand4_1
X_2189_ _0652_ _0287_ VSS VSS VDD VDD _0392_ sky130_fd_sc_hd__nor2_1
X_2190_ _0372_ _0390_ _0391_ _0392_ VSS VSS VDD VDD _0393_
+ sky130_fd_sc_hd__a31oi_1
X_2191_ _0886_ _0297_ VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__nand2_1
X_2192_ _0608_ _0291_ _0332_ _0393_ _0394_ VSS VSS VDD VDD
+ net291 sky130_fd_sc_hd__o221a_1
X_2193_ _0889_ _0349_ _0316_ VSS VSS VDD VDD _0395_ sky130_fd_sc_hd__nor3_1
X_2194_ input_buffer\[1\]\[2\] _0347_ _0348_ _0395_ VSS VSS
+ VDD VDD _0396_ sky130_fd_sc_hd__a211oi_1
X_2195_ input_buffer\[2\]\[2\] _0323_ _0344_ VSS VSS VDD VDD
+ _0397_ sky130_fd_sc_hd__o21ai_0
X_2196_ input_buffer\[4\]\[2\] _0330_ _0325_ input_buffer\[3\]\[2\]
+ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__a22oi_1
X_2197_ _0396_ _0397_ _0398_ VSS VSS VDD VDD net292 sky130_fd_sc_hd__o21ai_0
X_2198_ _0895_ _0349_ _0333_ VSS VSS VDD VDD _0399_ sky130_fd_sc_hd__nor3_1
X_2199_ input_buffer\[1\]\[3\] _0347_ _0348_ _0399_ VSS VSS
+ VDD VDD _0400_ sky130_fd_sc_hd__a211oi_1
X_2200_ input_buffer\[2\]\[3\] _0372_ _0344_ VSS VSS VDD VDD
+ _0401_ sky130_fd_sc_hd__o21ai_0
X_2201_ input_buffer\[4\]\[3\] _0330_ _0297_ input_buffer\[3\]\[3\]
+ VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__a22oi_1
X_2202_ _0400_ _0401_ _0402_ VSS VSS VDD VDD net293 sky130_fd_sc_hd__o21ai_0
X_2203_ _0901_ _0349_ _0333_ VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__nor3_1
X_2204_ input_buffer\[1\]\[4\] _0347_ _0348_ _0403_ VSS VSS
+ VDD VDD _0404_ sky130_fd_sc_hd__a211oi_1
X_2205_ input_buffer\[2\]\[4\] _0372_ _0344_ VSS VSS VDD VDD
+ _0405_ sky130_fd_sc_hd__o21ai_0
X_2206_ input_buffer\[4\]\[4\] _0295_ _0297_ input_buffer\[3\]\[4\]
+ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__a22oi_1
X_2207_ _0404_ _0405_ _0406_ VSS VSS VDD VDD net294 sky130_fd_sc_hd__o21ai_0
X_2208_ _0907_ _0349_ _0333_ VSS VSS VDD VDD _0407_ sky130_fd_sc_hd__nor3_1
X_2209_ input_buffer\[1\]\[5\] _0347_ _0348_ _0407_ VSS VSS
+ VDD VDD _0408_ sky130_fd_sc_hd__a211oi_1
X_2210_ input_buffer\[2\]\[5\] _0372_ _0344_ VSS VSS VDD VDD
+ _0409_ sky130_fd_sc_hd__o21ai_0
X_2211_ input_buffer\[4\]\[5\] _0295_ _0297_ input_buffer\[3\]\[5\]
+ VSS VSS VDD VDD _0410_ sky130_fd_sc_hd__a22oi_1
X_2212_ _0408_ _0409_ _0410_ VSS VSS VDD VDD net295 sky130_fd_sc_hd__o21ai_0
X_2213_ _0913_ _0349_ _0333_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__nor3_1
X_2214_ input_buffer\[1\]\[6\] _0347_ _0348_ _0411_ VSS VSS
+ VDD VDD _0412_ sky130_fd_sc_hd__a211oi_1
X_2215_ input_buffer\[2\]\[6\] _0372_ _0292_ VSS VSS VDD VDD
+ _0413_ sky130_fd_sc_hd__o21ai_0
X_2216_ input_buffer\[4\]\[6\] _0295_ _0297_ input_buffer\[3\]\[6\]
+ VSS VSS VDD VDD _0414_ sky130_fd_sc_hd__a22oi_1
X_2217_ _0412_ _0413_ _0414_ VSS VSS VDD VDD net296 sky130_fd_sc_hd__o21ai_0
X_2218_ _0919_ _0349_ _0333_ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__nor3_1
X_2219_ input_buffer\[1\]\[7\] _0347_ _0348_ _0415_ VSS VSS
+ VDD VDD _0416_ sky130_fd_sc_hd__a211oi_1
X_2220_ input_buffer\[2\]\[7\] _0372_ _0292_ VSS VSS VDD VDD
+ _0417_ sky130_fd_sc_hd__o21ai_0
X_2221_ input_buffer\[4\]\[7\] _0295_ _0297_ input_buffer\[3\]\[7\]
+ VSS VSS VDD VDD _0418_ sky130_fd_sc_hd__a22oi_1
X_2222_ _0416_ _0417_ _0418_ VSS VSS VDD VDD net297 sky130_fd_sc_hd__o21ai_1
X_2223_ _0925_ _0282_ _0333_ VSS VSS VDD VDD _0419_ sky130_fd_sc_hd__nor3_1
X_2224_ input_buffer\[1\]\[8\] _0284_ _0280_ _0419_ VSS VSS
+ VDD VDD _0420_ sky130_fd_sc_hd__a211oi_1
X_2225_ input_buffer\[2\]\[8\] _0372_ _0292_ VSS VSS VDD VDD
+ _0421_ sky130_fd_sc_hd__o21ai_0
X_2226_ input_buffer\[4\]\[8\] _0295_ _0297_ input_buffer\[3\]\[8\]
+ VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__a22oi_1
X_2227_ _0420_ _0421_ _0422_ VSS VSS VDD VDD net298 sky130_fd_sc_hd__o21ai_1
X_2228_ _0931_ _0282_ _0333_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__nor3_1
X_2229_ input_buffer\[1\]\[9\] _0284_ _0280_ _0423_ VSS VSS
+ VDD VDD _0424_ sky130_fd_sc_hd__a211oi_1
X_2230_ input_buffer\[2\]\[9\] _0372_ _0292_ VSS VSS VDD VDD
+ _0425_ sky130_fd_sc_hd__o21ai_0
X_2231_ input_buffer\[4\]\[9\] _0295_ _0297_ input_buffer\[3\]\[9\]
+ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__a22oi_1
X_2232_ _0424_ _0425_ _0426_ VSS VSS VDD VDD net299 sky130_fd_sc_hd__o21ai_1
X_2233_ _0625_ _1161_ VSS VSS VDD VDD _0427_ sky130_fd_sc_hd__nand2_1
X_2234_ _0629_ _0645_ VSS VSS VDD VDD _0428_ sky130_fd_sc_hd__nand2_1
X_2235_ _0637_ _1146_ VSS VSS VDD VDD _0429_ sky130_fd_sc_hd__nand2_1
X_2236_ _0644_ _0428_ _0429_ _1135_ VSS VSS VDD VDD _0430_
+ sky130_fd_sc_hd__a211oi_1
X_2237_ _0699_ _0697_ _0707_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__a21o_1
X_2238_ _0700_ _0702_ _0431_ _0937_ _1090_ VSS VSS VDD VDD
+ _0432_ sky130_fd_sc_hd__a311oi_2
X_2239_ _0669_ _0668_ VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__nand2_1
X_2240_ _0598_ _1131_ VSS VSS VDD VDD _0434_ sky130_fd_sc_hd__nand2_1
X_2241_ _0667_ _0433_ _0434_ _1120_ VSS VSS VDD VDD _0435_
+ sky130_fd_sc_hd__a211oi_1
X_2242_ _0676_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__inv_1
X_2243_ _0436_ _0674_ _0731_ VSS VSS VDD VDD _0437_ sky130_fd_sc_hd__a21o_1
X_2244_ _0602_ _1116_ VSS VSS VDD VDD _0438_ sky130_fd_sc_hd__nand2_1
X_2245_ _0268_ _0437_ _0438_ _1105_ VSS VSS VDD VDD _0439_
+ sky130_fd_sc_hd__a211oi_1
X_2246_ _0430_ _0432_ _0435_ _0439_ VSS VSS VDD VDD _0440_
+ sky130_fd_sc_hd__nor4_1
X_2247_ _1150_ _1148_ _0621_ _0427_ _0440_ VSS VSS VDD VDD
+ net300 sky130_fd_sc_hd__o41ai_1
X_2248_ _0598_ _1125_ VSS VSS VDD VDD _0441_ sky130_fd_sc_hd__nand2_1
X_2249_ _0669_ _0658_ _0441_ _0656_ VSS VSS VDD VDD _0442_
+ sky130_fd_sc_hd__a211o_2
X_2250_ _0442_ VSS VSS VDD VDD _0443_ sky130_fd_sc_hd__clkbuf_4
X_2251_ _0675_ _0678_ _0600_ _1110_ _0679_ VSS VSS VDD VDD
+ _0444_ sky130_fd_sc_hd__o2111a_2
X_2252_ _0444_ VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__clkbuf_4
X_2253_ _0669_ _0658_ _0441_ _0656_ VSS VSS VDD VDD _0446_
+ sky130_fd_sc_hd__a211oi_4
X_2254_ input_buffer\[1\]\[0\] _0445_ _0446_ VSS VSS VDD VDD
+ _0447_ sky130_fd_sc_hd__a21o_1
X_2255_ _0698_ _0707_ _1092_ _0702_ VSS VSS VDD VDD _0448_
+ sky130_fd_sc_hd__o211ai_4
X_2256_ _0448_ VSS VSS VDD VDD _0449_ sky130_fd_sc_hd__clkbuf_4
X_2257_ _0444_ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__buf_4
X_2258_ _0728_ _0449_ _0450_ VSS VSS VDD VDD _0451_ sky130_fd_sc_hd__nor3_1
X_2259_ _0637_ _1140_ _1144_ VSS VSS VDD VDD _0452_ sky130_fd_sc_hd__nand3_2
X_2260_ input_buffer\[2\]\[0\] _0443_ _0447_ _0451_ _0452_
+ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__o221ai_1
X_2261_ _0597_ _1140_ _1144_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__and3_1
X_2262_ input_buffer_valid\[4\] _1155_ VSS VSS VDD VDD _0455_
+ sky130_fd_sc_hd__nand2_1
X_2263_ _0619_ _0615_ _0455_ _0613_ VSS VSS VDD VDD _0456_
+ sky130_fd_sc_hd__a211oi_4
X_2264_ _0456_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__clkbuf_4
X_2265_ input_buffer\[3\]\[0\] _0454_ _0457_ VSS VSS VDD VDD
+ _0458_ sky130_fd_sc_hd__a21oi_1
X_2266_ _0619_ _0615_ _0455_ _0613_ VSS VSS VDD VDD _0459_
+ sky130_fd_sc_hd__a211o_1
X_2267_ input_buffer\[4\]\[0\] _0459_ VSS VSS VDD VDD _0460_
+ sky130_fd_sc_hd__nor2_1
X_2268_ _0453_ _0458_ _0460_ VSS VSS VDD VDD net302 sky130_fd_sc_hd__a21oi_1
X_2269_ _0444_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__clkbuf_4
X_2270_ _0446_ VSS VSS VDD VDD _0462_ sky130_fd_sc_hd__clkbuf_4
X_2271_ _0748_ _0449_ _0450_ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__nor3_1
X_2272_ input_buffer\[1\]\[10\] _0461_ _0462_ _0463_ VSS VSS
+ VDD VDD _0464_ sky130_fd_sc_hd__a211oi_1
X_2273_ _0442_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__clkbuf_4
X_2274_ _0735_ _0642_ _0597_ _1140_ _0633_ VSS VSS VDD VDD
+ _0466_ sky130_fd_sc_hd__o2111ai_4
X_2275_ _0459_ _0466_ VSS VSS VDD VDD _0467_ sky130_fd_sc_hd__and2_2
X_2276_ _0467_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__clkbuf_4
X_2277_ input_buffer\[2\]\[10\] _0465_ _0468_ VSS VSS VDD
+ VDD _0469_ sky130_fd_sc_hd__o21ai_0
X_2278_ _0456_ _0466_ VSS VSS VDD VDD _0470_ sky130_fd_sc_hd__nor2_8
X_2279_ _0470_ VSS VSS VDD VDD _0471_ sky130_fd_sc_hd__buf_6
X_2280_ input_buffer\[4\]\[10\] _0457_ _0471_ input_buffer\[3\]\[10\]
+ VSS VSS VDD VDD _0472_ sky130_fd_sc_hd__a22oi_1
X_2281_ _0464_ _0469_ _0472_ VSS VSS VDD VDD net303 sky130_fd_sc_hd__o21ai_1
X_2282_ _0755_ _0449_ _0450_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__nor3_1
X_2283_ input_buffer\[1\]\[11\] _0461_ _0462_ _0473_ VSS VSS
+ VDD VDD _0474_ sky130_fd_sc_hd__a211oi_1
X_2284_ input_buffer\[2\]\[11\] _0465_ _0468_ VSS VSS VDD
+ VDD _0475_ sky130_fd_sc_hd__o21ai_0
X_2285_ input_buffer\[4\]\[11\] _0457_ _0471_ input_buffer\[3\]\[11\]
+ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__a22oi_1
X_2286_ _0474_ _0475_ _0476_ VSS VSS VDD VDD net304 sky130_fd_sc_hd__o21ai_1
X_2287_ _0761_ _0449_ _0450_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__nor3_1
X_2288_ input_buffer\[1\]\[12\] _0461_ _0462_ _0477_ VSS VSS
+ VDD VDD _0478_ sky130_fd_sc_hd__a211oi_1
X_2289_ input_buffer\[2\]\[12\] _0465_ _0468_ VSS VSS VDD
+ VDD _0479_ sky130_fd_sc_hd__o21ai_0
X_2290_ input_buffer\[4\]\[12\] _0457_ _0471_ input_buffer\[3\]\[12\]
+ VSS VSS VDD VDD _0480_ sky130_fd_sc_hd__a22oi_1
X_2291_ _0478_ _0479_ _0480_ VSS VSS VDD VDD net305 sky130_fd_sc_hd__o21ai_1
X_2292_ _0769_ _0449_ _0450_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__nor3_1
X_2293_ input_buffer\[1\]\[13\] _0445_ _0446_ VSS VSS VDD
+ VDD _0482_ sky130_fd_sc_hd__a21o_1
X_2294_ input_buffer\[2\]\[13\] _0443_ _0481_ _0482_ _0452_
+ VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__o221ai_1
X_2295_ input_buffer\[3\]\[13\] _0454_ _0457_ VSS VSS VDD
+ VDD _0484_ sky130_fd_sc_hd__a21oi_1
X_2296_ input_buffer\[4\]\[13\] _0459_ VSS VSS VDD VDD _0485_
+ sky130_fd_sc_hd__nor2_1
X_2297_ _0483_ _0484_ _0485_ VSS VSS VDD VDD net306 sky130_fd_sc_hd__a21oi_1
X_2298_ _0776_ _0449_ _0450_ VSS VSS VDD VDD _0486_ sky130_fd_sc_hd__nor3_1
X_2299_ input_buffer\[1\]\[14\] _0461_ _0462_ _0486_ VSS VSS
+ VDD VDD _0487_ sky130_fd_sc_hd__a211oi_1
X_2300_ input_buffer\[2\]\[14\] _0465_ _0468_ VSS VSS VDD
+ VDD _0488_ sky130_fd_sc_hd__o21ai_0
X_2301_ input_buffer\[4\]\[14\] _0457_ _0471_ input_buffer\[3\]\[14\]
+ VSS VSS VDD VDD _0489_ sky130_fd_sc_hd__a22oi_1
X_2302_ _0487_ _0488_ _0489_ VSS VSS VDD VDD net307 sky130_fd_sc_hd__o21ai_1
X_2303_ _0782_ _0449_ _0450_ VSS VSS VDD VDD _0490_ sky130_fd_sc_hd__nor3_1
X_2304_ input_buffer\[1\]\[15\] _0461_ _0462_ _0490_ VSS VSS
+ VDD VDD _0491_ sky130_fd_sc_hd__a211oi_1
X_2305_ input_buffer\[2\]\[15\] _0465_ _0468_ VSS VSS VDD
+ VDD _0492_ sky130_fd_sc_hd__o21ai_0
X_2306_ input_buffer\[4\]\[15\] _0457_ _0471_ input_buffer\[3\]\[15\]
+ VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__a22oi_1
X_2307_ _0491_ _0492_ _0493_ VSS VSS VDD VDD net308 sky130_fd_sc_hd__o21ai_1
X_2308_ _0788_ _0449_ _0450_ VSS VSS VDD VDD _0494_ sky130_fd_sc_hd__nor3_1
X_2309_ input_buffer\[1\]\[16\] _0461_ _0462_ _0494_ VSS VSS
+ VDD VDD _0495_ sky130_fd_sc_hd__a211oi_1
X_2310_ input_buffer\[2\]\[16\] _0465_ _0468_ VSS VSS VDD
+ VDD _0496_ sky130_fd_sc_hd__o21ai_0
X_2311_ input_buffer\[4\]\[16\] _0457_ _0471_ input_buffer\[3\]\[16\]
+ VSS VSS VDD VDD _0497_ sky130_fd_sc_hd__a22oi_1
X_2312_ _0495_ _0496_ _0497_ VSS VSS VDD VDD net309 sky130_fd_sc_hd__o21ai_1
X_2313_ _0444_ VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__clkbuf_4
X_2314_ _0794_ _0449_ _0498_ VSS VSS VDD VDD _0499_ sky130_fd_sc_hd__nor3_1
X_2315_ input_buffer\[1\]\[17\] _0461_ _0462_ _0499_ VSS VSS
+ VDD VDD _0500_ sky130_fd_sc_hd__a211oi_1
X_2316_ input_buffer\[2\]\[17\] _0465_ _0468_ VSS VSS VDD
+ VDD _0501_ sky130_fd_sc_hd__o21ai_0
X_2317_ input_buffer\[4\]\[17\] _0457_ _0471_ input_buffer\[3\]\[17\]
+ VSS VSS VDD VDD _0502_ sky130_fd_sc_hd__a22oi_1
X_2318_ _0500_ _0501_ _0502_ VSS VSS VDD VDD net310 sky130_fd_sc_hd__o21ai_1
X_2319_ _0802_ _0449_ _0498_ VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__nor3_1
X_2320_ input_buffer\[1\]\[18\] _0461_ _0462_ _0503_ VSS VSS
+ VDD VDD _0504_ sky130_fd_sc_hd__a211oi_1
X_2321_ input_buffer\[2\]\[18\] _0465_ _0468_ VSS VSS VDD
+ VDD _0505_ sky130_fd_sc_hd__o21ai_0
X_2322_ _0456_ VSS VSS VDD VDD _0506_ sky130_fd_sc_hd__buf_4
X_2323_ input_buffer\[4\]\[18\] _0506_ _0471_ input_buffer\[3\]\[18\]
+ VSS VSS VDD VDD _0507_ sky130_fd_sc_hd__a22oi_1
X_2324_ _0504_ _0505_ _0507_ VSS VSS VDD VDD net311 sky130_fd_sc_hd__o21ai_1
X_2325_ _0448_ VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__clkbuf_4
X_2326_ _0812_ _0508_ _0498_ VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__nor3_1
X_2327_ input_buffer\[1\]\[19\] _0461_ _0462_ _0509_ VSS VSS
+ VDD VDD _0510_ sky130_fd_sc_hd__a211oi_1
X_2328_ input_buffer\[2\]\[19\] _0465_ _0468_ VSS VSS VDD
+ VDD _0511_ sky130_fd_sc_hd__o21ai_0
X_2329_ input_buffer\[4\]\[19\] _0506_ _0471_ input_buffer\[3\]\[19\]
+ VSS VSS VDD VDD _0512_ sky130_fd_sc_hd__a22oi_1
X_2330_ _0510_ _0511_ _0512_ VSS VSS VDD VDD net312 sky130_fd_sc_hd__o21ai_1
X_2331_ _0821_ _0508_ _0498_ VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__nor3_1
X_2332_ input_buffer\[1\]\[1\] _0461_ _0462_ _0513_ VSS VSS
+ VDD VDD _0514_ sky130_fd_sc_hd__a211oi_1
X_2333_ _0467_ VSS VSS VDD VDD _0515_ sky130_fd_sc_hd__clkbuf_4
X_2334_ input_buffer\[2\]\[1\] _0465_ _0515_ VSS VSS VDD VDD
+ _0516_ sky130_fd_sc_hd__o21ai_0
X_2335_ input_buffer\[4\]\[1\] _0506_ _0471_ input_buffer\[3\]\[1\]
+ VSS VSS VDD VDD _0517_ sky130_fd_sc_hd__a22oi_1
X_2336_ _0514_ _0516_ _0517_ VSS VSS VDD VDD net313 sky130_fd_sc_hd__o21ai_1
X_2337_ _0444_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__clkbuf_4
X_2338_ _0446_ VSS VSS VDD VDD _0519_ sky130_fd_sc_hd__clkbuf_4
X_2339_ _0827_ _0508_ _0498_ VSS VSS VDD VDD _0520_ sky130_fd_sc_hd__nor3_1
X_2340_ input_buffer\[1\]\[20\] _0518_ _0519_ _0520_ VSS VSS
+ VDD VDD _0521_ sky130_fd_sc_hd__a211oi_1
X_2341_ _0442_ VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__clkbuf_4
X_2342_ input_buffer\[2\]\[20\] _0522_ _0515_ VSS VSS VDD
+ VDD _0523_ sky130_fd_sc_hd__o21ai_0
X_2343_ _0470_ VSS VSS VDD VDD _0524_ sky130_fd_sc_hd__buf_6
X_2344_ input_buffer\[4\]\[20\] _0506_ _0524_ input_buffer\[3\]\[20\]
+ VSS VSS VDD VDD _0525_ sky130_fd_sc_hd__a22oi_1
X_2345_ _0521_ _0523_ _0525_ VSS VSS VDD VDD net314 sky130_fd_sc_hd__o21ai_0
X_2346_ _0833_ _0508_ _0498_ VSS VSS VDD VDD _0526_ sky130_fd_sc_hd__nor3_1
X_2347_ input_buffer\[1\]\[21\] _0518_ _0519_ _0526_ VSS VSS
+ VDD VDD _0527_ sky130_fd_sc_hd__a211oi_1
X_2348_ input_buffer\[2\]\[21\] _0522_ _0515_ VSS VSS VDD
+ VDD _0528_ sky130_fd_sc_hd__o21ai_0
X_2349_ input_buffer\[4\]\[21\] _0506_ _0524_ input_buffer\[3\]\[21\]
+ VSS VSS VDD VDD _0529_ sky130_fd_sc_hd__a22oi_1
X_2350_ _0527_ _0528_ _0529_ VSS VSS VDD VDD net315 sky130_fd_sc_hd__o21ai_0
X_2351_ _0841_ _0508_ _0498_ VSS VSS VDD VDD _0530_ sky130_fd_sc_hd__nor3_1
X_2352_ input_buffer\[1\]\[22\] _0518_ _0519_ _0530_ VSS VSS
+ VDD VDD _0531_ sky130_fd_sc_hd__a211oi_1
X_2353_ input_buffer\[2\]\[22\] _0522_ _0515_ VSS VSS VDD
+ VDD _0532_ sky130_fd_sc_hd__o21ai_0
X_2354_ input_buffer\[4\]\[22\] _0506_ _0524_ input_buffer\[3\]\[22\]
+ VSS VSS VDD VDD _0533_ sky130_fd_sc_hd__a22oi_1
X_2355_ _0531_ _0532_ _0533_ VSS VSS VDD VDD net316 sky130_fd_sc_hd__o21ai_0
X_2356_ _0847_ _0508_ _0498_ VSS VSS VDD VDD _0534_ sky130_fd_sc_hd__nor3_1
X_2357_ input_buffer\[1\]\[23\] _0518_ _0519_ _0534_ VSS VSS
+ VDD VDD _0535_ sky130_fd_sc_hd__a211oi_1
X_2358_ input_buffer\[2\]\[23\] _0522_ _0515_ VSS VSS VDD
+ VDD _0536_ sky130_fd_sc_hd__o21ai_0
X_2359_ input_buffer\[4\]\[23\] _0506_ _0524_ input_buffer\[3\]\[23\]
+ VSS VSS VDD VDD _0537_ sky130_fd_sc_hd__a22oi_1
X_2360_ _0535_ _0536_ _0537_ VSS VSS VDD VDD net317 sky130_fd_sc_hd__o21ai_1
X_2361_ _0445_ _0855_ _1092_ VSS VSS VDD VDD _0538_ sky130_fd_sc_hd__nor3b_1
X_2362_ _0602_ _0676_ _1110_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__nand3_1
X_2363_ _0682_ _0539_ _0443_ VSS VSS VDD VDD _0540_ sky130_fd_sc_hd__o21ai_0
X_2364_ _0650_ _0443_ _0538_ _0540_ _0452_ VSS VSS VDD VDD
+ _0541_ sky130_fd_sc_hd__o221ai_1
X_2365_ _0634_ _0454_ _0457_ VSS VSS VDD VDD _0542_ sky130_fd_sc_hd__a21oi_1
X_2366_ _0606_ _0459_ VSS VSS VDD VDD _0543_ sky130_fd_sc_hd__nor2_1
X_2367_ _0541_ _0542_ _0543_ VSS VSS VDD VDD net318 sky130_fd_sc_hd__a21oi_1
X_2368_ _0730_ _0685_ _0600_ _1110_ _0683_ VSS VSS VDD VDD
+ _0544_ sky130_fd_sc_hd__o2111ai_4
X_2369_ _0857_ _0673_ _1110_ VSS VSS VDD VDD _0545_ sky130_fd_sc_hd__nand3_1
X_2370_ _0682_ _0545_ _0443_ VSS VSS VDD VDD _0546_ sky130_fd_sc_hd__o21ai_1
X_2371_ _1092_ _0376_ _0544_ _0546_ VSS VSS VDD VDD _0547_
+ sky130_fd_sc_hd__a31oi_2
X_2372_ dest_id\[2\]\[1\] _0522_ _0515_ VSS VSS VDD VDD _0548_
+ sky130_fd_sc_hd__o21ai_0
X_2373_ _0604_ _0506_ _0524_ _0627_ VSS VSS VDD VDD _0549_
+ sky130_fd_sc_hd__a22oi_1
X_2374_ _0547_ _0548_ _0549_ VSS VSS VDD VDD net319 sky130_fd_sc_hd__o21ai_2
X_2375_ _0857_ _0674_ _1110_ VSS VSS VDD VDD _0550_ sky130_fd_sc_hd__nand3_1
X_2376_ _0682_ _0550_ _0443_ VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__o21ai_0
X_2377_ _1092_ _0383_ _0544_ _0551_ VSS VSS VDD VDD _0552_
+ sky130_fd_sc_hd__a31oi_1
X_2378_ _0649_ _0522_ _0515_ VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__o21ai_1
X_2379_ _0628_ _0470_ _0543_ VSS VSS VDD VDD _0554_ sky130_fd_sc_hd__a21oi_1
X_2380_ _0552_ _0553_ _0554_ VSS VSS VDD VDD net320 sky130_fd_sc_hd__o21ai_1
X_2381_ _0677_ _0445_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__nand2_1
X_2382_ _1092_ _0703_ _0882_ _0544_ VSS VSS VDD VDD _0556_
+ sky130_fd_sc_hd__nand4_1
X_2383_ _0652_ _0442_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__nor2_1
X_2384_ _0442_ _0555_ _0556_ _0557_ VSS VSS VDD VDD _0558_
+ sky130_fd_sc_hd__a31o_1
X_2385_ _0608_ _0459_ VSS VSS VDD VDD _0559_ sky130_fd_sc_hd__nor2_1
X_2386_ _0886_ _0470_ _0558_ _0468_ _0559_ VSS VSS VDD VDD
+ net321 sky130_fd_sc_hd__a221oi_2
X_2387_ _0889_ _0508_ _0498_ VSS VSS VDD VDD _0560_ sky130_fd_sc_hd__nor3_1
X_2388_ input_buffer\[1\]\[2\] _0518_ _0519_ _0560_ VSS VSS
+ VDD VDD _0561_ sky130_fd_sc_hd__a211oi_1
X_2389_ input_buffer\[2\]\[2\] _0522_ _0515_ VSS VSS VDD VDD
+ _0562_ sky130_fd_sc_hd__o21ai_0
X_2390_ input_buffer\[4\]\[2\] _0506_ _0524_ input_buffer\[3\]\[2\]
+ VSS VSS VDD VDD _0563_ sky130_fd_sc_hd__a22oi_1
X_2391_ _0561_ _0562_ _0563_ VSS VSS VDD VDD net322 sky130_fd_sc_hd__o21ai_0
X_2392_ _0895_ _0508_ _0498_ VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__nor3_1
X_2393_ input_buffer\[1\]\[3\] _0518_ _0519_ _0564_ VSS VSS
+ VDD VDD _0565_ sky130_fd_sc_hd__a211oi_1
X_2394_ input_buffer\[2\]\[3\] _0522_ _0515_ VSS VSS VDD VDD
+ _0566_ sky130_fd_sc_hd__o21ai_0
X_2395_ input_buffer\[4\]\[3\] _0506_ _0524_ input_buffer\[3\]\[3\]
+ VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__a22oi_1
X_2396_ _0565_ _0566_ _0567_ VSS VSS VDD VDD net323 sky130_fd_sc_hd__o21ai_0
X_2397_ _0901_ _0508_ _0445_ VSS VSS VDD VDD _0568_ sky130_fd_sc_hd__nor3_1
X_2398_ input_buffer\[1\]\[4\] _0518_ _0519_ _0568_ VSS VSS
+ VDD VDD _0569_ sky130_fd_sc_hd__a211oi_1
X_2399_ input_buffer\[2\]\[4\] _0522_ _0515_ VSS VSS VDD VDD
+ _0570_ sky130_fd_sc_hd__o21ai_0
X_2400_ input_buffer\[4\]\[4\] _0456_ _0524_ input_buffer\[3\]\[4\]
+ VSS VSS VDD VDD _0571_ sky130_fd_sc_hd__a22oi_1
X_2401_ _0569_ _0570_ _0571_ VSS VSS VDD VDD net324 sky130_fd_sc_hd__o21ai_0
X_2402_ _0907_ _0508_ _0445_ VSS VSS VDD VDD _0572_ sky130_fd_sc_hd__nor3_1
X_2403_ input_buffer\[1\]\[5\] _0518_ _0519_ _0572_ VSS VSS
+ VDD VDD _0573_ sky130_fd_sc_hd__a211oi_1
X_2404_ input_buffer\[2\]\[5\] _0522_ _0467_ VSS VSS VDD VDD
+ _0574_ sky130_fd_sc_hd__o21ai_0
X_2405_ input_buffer\[4\]\[5\] _0456_ _0524_ input_buffer\[3\]\[5\]
+ VSS VSS VDD VDD _0575_ sky130_fd_sc_hd__a22oi_1
X_2406_ _0573_ _0574_ _0575_ VSS VSS VDD VDD net325 sky130_fd_sc_hd__o21ai_0
X_2407_ _0913_ _0448_ _0445_ VSS VSS VDD VDD _0576_ sky130_fd_sc_hd__nor3_1
X_2408_ input_buffer\[1\]\[6\] _0518_ _0519_ _0576_ VSS VSS
+ VDD VDD _0577_ sky130_fd_sc_hd__a211oi_1
X_2409_ input_buffer\[2\]\[6\] _0443_ _0467_ VSS VSS VDD VDD
+ _0578_ sky130_fd_sc_hd__o21ai_0
X_2410_ input_buffer\[4\]\[6\] _0456_ _0524_ input_buffer\[3\]\[6\]
+ VSS VSS VDD VDD _0579_ sky130_fd_sc_hd__a22oi_1
X_2411_ _0577_ _0578_ _0579_ VSS VSS VDD VDD net326 sky130_fd_sc_hd__o21ai_0
X_2412_ _0919_ _0448_ _0445_ VSS VSS VDD VDD _0580_ sky130_fd_sc_hd__nor3_1
X_2413_ input_buffer\[1\]\[7\] _0518_ _0519_ _0580_ VSS VSS
+ VDD VDD _0581_ sky130_fd_sc_hd__a211oi_1
X_2414_ input_buffer\[2\]\[7\] _0443_ _0467_ VSS VSS VDD VDD
+ _0582_ sky130_fd_sc_hd__o21ai_0
X_2415_ input_buffer\[4\]\[7\] _0456_ _0470_ input_buffer\[3\]\[7\]
+ VSS VSS VDD VDD _0583_ sky130_fd_sc_hd__a22oi_1
X_2416_ _0581_ _0582_ _0583_ VSS VSS VDD VDD net327 sky130_fd_sc_hd__o21ai_1
X_2417_ _0925_ _0448_ _0445_ VSS VSS VDD VDD _0584_ sky130_fd_sc_hd__nor3_1
X_2418_ input_buffer\[1\]\[8\] _0450_ _0446_ _0584_ VSS VSS
+ VDD VDD _0585_ sky130_fd_sc_hd__a211oi_1
X_2419_ input_buffer\[2\]\[8\] _0443_ _0467_ VSS VSS VDD VDD
+ _0586_ sky130_fd_sc_hd__o21ai_0
X_2420_ input_buffer\[4\]\[8\] _0456_ _0470_ input_buffer\[3\]\[8\]
+ VSS VSS VDD VDD _0587_ sky130_fd_sc_hd__a22oi_1
X_2421_ _0585_ _0586_ _0587_ VSS VSS VDD VDD net328 sky130_fd_sc_hd__o21ai_1
X_2422_ _0931_ _0448_ _0445_ VSS VSS VDD VDD _0588_ sky130_fd_sc_hd__nor3_1
X_2423_ input_buffer\[1\]\[9\] _0450_ _0446_ _0588_ VSS VSS
+ VDD VDD _0589_ sky130_fd_sc_hd__a211oi_1
X_2424_ input_buffer\[2\]\[9\] _0443_ _0467_ VSS VSS VDD VDD
+ _0590_ sky130_fd_sc_hd__o21ai_0
X_2425_ input_buffer\[4\]\[9\] _0456_ _0470_ input_buffer\[3\]\[9\]
+ VSS VSS VDD VDD _0591_ sky130_fd_sc_hd__a22oi_1
X_2426_ _0589_ _0590_ _0591_ VSS VSS VDD VDD net329 sky130_fd_sc_hd__o21ai_1
X_2427_ _0625_ _1161_ _1155_ VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__nand3_1
X_2428_ _0599_ _1131_ _1125_ VSS VSS VDD VDD _0593_ sky130_fd_sc_hd__nand3_1
X_2429_ _0714_ _1101_ _1092_ VSS VSS VDD VDD _0594_ sky130_fd_sc_hd__nand3_1
X_2430_ _0602_ _1116_ _1110_ VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__and3_1
X_2431_ _0637_ _1146_ _1140_ _0595_ VSS VSS VDD VDD _0596_
+ sky130_fd_sc_hd__a31oi_1
X_2432_ _0592_ _0593_ _0594_ _0596_ VSS VSS VDD VDD net330
+ sky130_fd_sc_hd__nand4_1
X_2433_ _1087_ _1088_ VSS VSS VDD VDD _1089_ _1090_ sky130_fd_sc_hd__ha_2
X_2434_ _1087_ _1091_ VSS VSS VDD VDD _1092_ _1093_ sky130_fd_sc_hd__ha_4
X_2435_ _1094_ _1088_ VSS VSS VDD VDD _1095_ _1096_ sky130_fd_sc_hd__ha_1
X_2436_ _1094_ _1091_ VSS VSS VDD VDD _1097_ _1098_ sky130_fd_sc_hd__ha_2
X_2437_ _1095_ _1099_ VSS VSS VDD VDD _1100_ _1101_ sky130_fd_sc_hd__ha_1
X_2438_ _1102_ _1103_ VSS VSS VDD VDD _1104_ _1105_ sky130_fd_sc_hd__ha_2
X_2439_ _1102_ _1106_ VSS VSS VDD VDD _1107_ _1108_ sky130_fd_sc_hd__ha_1
X_2440_ _1109_ _1103_ VSS VSS VDD VDD _1110_ _1111_ sky130_fd_sc_hd__ha_4
X_2441_ _1109_ _1106_ VSS VSS VDD VDD _1112_ _1113_ sky130_fd_sc_hd__ha_2
X_2442_ _1107_ _1114_ VSS VSS VDD VDD _1115_ _1116_ sky130_fd_sc_hd__ha_1
X_2443_ _1117_ _1118_ VSS VSS VDD VDD _1119_ _1120_ sky130_fd_sc_hd__ha_1
X_2444_ _1117_ _1121_ VSS VSS VDD VDD _1122_ _1123_ sky130_fd_sc_hd__ha_1
X_2445_ _1124_ _1118_ VSS VSS VDD VDD _1125_ _1126_ sky130_fd_sc_hd__ha_1
X_2446_ _1124_ _1121_ VSS VSS VDD VDD _1127_ _1128_ sky130_fd_sc_hd__ha_1
X_2447_ _1122_ _1129_ VSS VSS VDD VDD _1130_ _1131_ sky130_fd_sc_hd__ha_2
X_2448_ _1132_ _1133_ VSS VSS VDD VDD _1134_ _1135_ sky130_fd_sc_hd__ha_1
X_2449_ _1132_ _1136_ VSS VSS VDD VDD _1137_ _1138_ sky130_fd_sc_hd__ha_1
X_2450_ _1139_ _1133_ VSS VSS VDD VDD _1140_ _1141_ sky130_fd_sc_hd__ha_2
X_2451_ _1139_ _1136_ VSS VSS VDD VDD _1142_ _1143_ sky130_fd_sc_hd__ha_1
X_2452_ _1137_ _1144_ VSS VSS VDD VDD _1145_ _1146_ sky130_fd_sc_hd__ha_1
X_2453_ _1147_ _1148_ VSS VSS VDD VDD _1149_ _1150_ sky130_fd_sc_hd__ha_1
X_2454_ _1147_ _1151_ VSS VSS VDD VDD _1152_ _1153_ sky130_fd_sc_hd__ha_1
X_2455_ _1154_ _1148_ VSS VSS VDD VDD _1155_ _1156_ sky130_fd_sc_hd__ha_1
X_2456_ _1154_ _1151_ VSS VSS VDD VDD _1157_ _1158_ sky130_fd_sc_hd__ha_1
X_2457_ _1152_ _1159_ VSS VSS VDD VDD _1160_ _1161_ sky130_fd_sc_hd__ha_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_2459_ net331 VSS VSS VDD VDD east_out_data[28] sky130_fd_sc_hd__buf_4
X_2460_ net332 VSS VSS VDD VDD east_out_data[29] sky130_fd_sc_hd__buf_4
X_2461_ net333 VSS VSS VDD VDD east_out_data[30] sky130_fd_sc_hd__buf_4
X_2462_ net334 VSS VSS VDD VDD east_out_data[31] sky130_fd_sc_hd__buf_4
X_2463_ net335 VSS VSS VDD VDD south_out_data[28] sky130_fd_sc_hd__buf_4
X_2464_ net336 VSS VSS VDD VDD south_out_data[29] sky130_fd_sc_hd__buf_4
X_2465_ net337 VSS VSS VDD VDD south_out_data[30] sky130_fd_sc_hd__buf_4
X_2466_ net338 VSS VSS VDD VDD south_out_data[31] sky130_fd_sc_hd__buf_4
X_2467_ net339 VSS VSS VDD VDD west_out_data[28] sky130_fd_sc_hd__buf_4
X_2468_ net340 VSS VSS VDD VDD west_out_data[29] sky130_fd_sc_hd__buf_4
X_2469_ net341 VSS VSS VDD VDD west_out_data[30] sky130_fd_sc_hd__buf_4
X_2470_ net342 VSS VSS VDD VDD west_out_data[31] sky130_fd_sc_hd__buf_4
Xinput_buffer\[0\]\[0\]$_DFFE_PP_ clknet_4_13_0_clk net70
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[10\]$_DFFE_PP_ clknet_4_12_0_clk net71
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[11\]$_DFFE_PP_ clknet_4_13_0_clk net72
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[12\]$_DFFE_PP_ clknet_4_13_0_clk net73
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[13\]$_DFFE_PP_ clknet_4_13_0_clk net74
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[14\]$_DFFE_PP_ clknet_4_12_0_clk net75
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[15\]$_DFFE_PP_ clknet_4_13_0_clk net76
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[16\]$_DFFE_PP_ clknet_4_7_0_clk net77
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[17\]$_DFFE_PP_ clknet_4_7_0_clk net78
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[18\]$_DFFE_PP_ clknet_4_7_0_clk net79
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[19\]$_DFFE_PP_ clknet_4_6_0_clk net80
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[1\]$_DFFE_PP_ clknet_4_5_0_clk net81 _0009_
+ VSS VSS VDD VDD input_buffer\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[20\]$_DFFE_PP_ clknet_4_5_0_clk net82
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[21\]$_DFFE_PP_ clknet_4_4_0_clk net83
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[22\]$_DFFE_PP_ clknet_4_5_0_clk net84
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[23\]$_DFFE_PP_ clknet_4_5_0_clk net85
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[24\]$_DFFE_PP_ clknet_4_2_0_clk net86
+ _0009_ VSS VSS VDD VDD dest_id\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[25\]$_DFFE_PP_ clknet_4_2_0_clk net87
+ _0009_ VSS VSS VDD VDD dest_id\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[26\]$_DFFE_PP_ clknet_4_2_0_clk net88
+ _0009_ VSS VSS VDD VDD dest_id\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[27\]$_DFFE_PP_ clknet_4_0_0_clk net89
+ _0009_ VSS VSS VDD VDD dest_id\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[28\]$_DFFE_PP_ clknet_4_3_0_clk net90
+ _0009_ VSS VSS VDD VDD dest_id\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[29\]$_DFFE_PP_ clknet_4_3_0_clk net91
+ _0009_ VSS VSS VDD VDD dest_id\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[2\]$_DFFE_PP_ clknet_4_4_0_clk net92 _0009_
+ VSS VSS VDD VDD input_buffer\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[30\]$_DFFE_PP_ clknet_4_3_0_clk net93
+ _0009_ VSS VSS VDD VDD dest_id\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[31\]$_DFFE_PP_ clknet_4_2_0_clk net94
+ _0009_ VSS VSS VDD VDD dest_id\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[3\]$_DFFE_PP_ clknet_4_1_0_clk net95 _0009_
+ VSS VSS VDD VDD input_buffer\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[4\]$_DFFE_PP_ clknet_4_1_0_clk net96 _0009_
+ VSS VSS VDD VDD input_buffer\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[5\]$_DFFE_PP_ clknet_4_1_0_clk net97 _0009_
+ VSS VSS VDD VDD input_buffer\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[6\]$_DFFE_PP_ clknet_4_0_0_clk net98 _0009_
+ VSS VSS VDD VDD input_buffer\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[7\]$_DFFE_PP_ clknet_4_0_0_clk net99 _0009_
+ VSS VSS VDD VDD input_buffer\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[8\]$_DFFE_PP_ clknet_4_0_0_clk net100
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[0\]\[9\]$_DFFE_PP_ clknet_4_2_0_clk net101
+ _0009_ VSS VSS VDD VDD input_buffer\[0\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[0\]$_DFFE_PP_ clknet_4_12_0_clk net2 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[10\]$_DFFE_PP_ clknet_4_15_0_clk net3
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[11\]$_DFFE_PP_ clknet_4_12_0_clk net4
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[12\]$_DFFE_PP_ clknet_4_15_0_clk net5
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[13\]$_DFFE_PP_ clknet_4_15_0_clk net6
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[14\]$_DFFE_PP_ clknet_4_12_0_clk net7
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[15\]$_DFFE_PP_ clknet_4_13_0_clk net8
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[16\]$_DFFE_PP_ clknet_4_7_0_clk net9 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[17\]$_DFFE_PP_ clknet_4_7_0_clk net10
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[18\]$_DFFE_PP_ clknet_4_6_0_clk net11
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[19\]$_DFFE_PP_ clknet_4_6_0_clk net12
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[1\]$_DFFE_PP_ clknet_4_5_0_clk net13 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[20\]$_DFFE_PP_ clknet_4_5_0_clk net14
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[21\]$_DFFE_PP_ clknet_4_5_0_clk net15
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[22\]$_DFFE_PP_ clknet_4_5_0_clk net16
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[23\]$_DFFE_PP_ clknet_4_4_0_clk net17
+ _0008_ VSS VSS VDD VDD input_buffer\[1\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[24\]$_DFFE_PP_ clknet_4_3_0_clk net18
+ _0008_ VSS VSS VDD VDD dest_id\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[25\]$_DFFE_PP_ clknet_4_2_0_clk net19
+ _0008_ VSS VSS VDD VDD dest_id\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[26\]$_DFFE_PP_ clknet_4_3_0_clk net20
+ _0008_ VSS VSS VDD VDD dest_id\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[27\]$_DFFE_PP_ clknet_4_0_0_clk net21
+ _0008_ VSS VSS VDD VDD dest_id\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[28\]$_DFFE_PP_ clknet_4_3_0_clk net22
+ _0008_ VSS VSS VDD VDD dest_id\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[29\]$_DFFE_PP_ clknet_4_3_0_clk net23
+ _0008_ VSS VSS VDD VDD dest_id\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[2\]$_DFFE_PP_ clknet_4_4_0_clk net24 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[30\]$_DFFE_PP_ clknet_4_3_0_clk net25
+ _0008_ VSS VSS VDD VDD dest_id\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[31\]$_DFFE_PP_ clknet_4_3_0_clk net26
+ _0008_ VSS VSS VDD VDD dest_id\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[3\]$_DFFE_PP_ clknet_4_4_0_clk net27 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[4\]$_DFFE_PP_ clknet_4_1_0_clk net28 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[5\]$_DFFE_PP_ clknet_4_1_0_clk net29 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[6\]$_DFFE_PP_ clknet_4_1_0_clk net30 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[7\]$_DFFE_PP_ clknet_4_1_0_clk net31 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[8\]$_DFFE_PP_ clknet_4_0_0_clk net32 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[1\]\[9\]$_DFFE_PP_ clknet_4_0_0_clk net33 _0008_
+ VSS VSS VDD VDD input_buffer\[1\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[0\]$_DFFE_PP_ clknet_4_14_0_clk net105
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[10\]$_DFFE_PP_ clknet_4_14_0_clk net106
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[11\]$_DFFE_PP_ clknet_4_15_0_clk net107
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[12\]$_DFFE_PP_ clknet_4_15_0_clk net108
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[13\]$_DFFE_PP_ clknet_4_14_0_clk net109
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[14\]$_DFFE_PP_ clknet_4_15_0_clk net110
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[15\]$_DFFE_PP_ clknet_4_13_0_clk net111
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[16\]$_DFFE_PP_ clknet_4_7_0_clk net112
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[17\]$_DFFE_PP_ clknet_4_6_0_clk net113
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[18\]$_DFFE_PP_ clknet_4_7_0_clk net114
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[19\]$_DFFE_PP_ clknet_4_6_0_clk net115
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[1\]$_DFFE_PP_ clknet_4_5_0_clk net116
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[20\]$_DFFE_PP_ clknet_4_5_0_clk net117
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[21\]$_DFFE_PP_ clknet_4_4_0_clk net118
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[22\]$_DFFE_PP_ clknet_4_5_0_clk net119
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[23\]$_DFFE_PP_ clknet_4_4_0_clk net120
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[24\]$_DFFE_PP_ clknet_4_8_0_clk net121
+ _0007_ VSS VSS VDD VDD dest_id\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[25\]$_DFFE_PP_ clknet_4_2_0_clk net122
+ _0007_ VSS VSS VDD VDD dest_id\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[26\]$_DFFE_PP_ clknet_4_8_0_clk net123
+ _0007_ VSS VSS VDD VDD dest_id\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[27\]$_DFFE_PP_ clknet_4_10_0_clk net124
+ _0007_ VSS VSS VDD VDD dest_id\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[28\]$_DFFE_PP_ clknet_4_2_0_clk net125
+ _0007_ VSS VSS VDD VDD dest_id\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[29\]$_DFFE_PP_ clknet_4_8_0_clk net126
+ _0007_ VSS VSS VDD VDD dest_id\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[2\]$_DFFE_PP_ clknet_4_4_0_clk net127
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[30\]$_DFFE_PP_ clknet_4_8_0_clk net128
+ _0007_ VSS VSS VDD VDD dest_id\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[31\]$_DFFE_PP_ clknet_4_8_0_clk net129
+ _0007_ VSS VSS VDD VDD dest_id\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[3\]$_DFFE_PP_ clknet_4_1_0_clk net130
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[4\]$_DFFE_PP_ clknet_4_1_0_clk net131
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[5\]$_DFFE_PP_ clknet_4_1_0_clk net132
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[6\]$_DFFE_PP_ clknet_4_1_0_clk net133
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[7\]$_DFFE_PP_ clknet_4_0_0_clk net134
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[8\]$_DFFE_PP_ clknet_4_0_0_clk net135
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[2\]\[9\]$_DFFE_PP_ clknet_4_0_0_clk net136
+ _0007_ VSS VSS VDD VDD input_buffer\[2\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[0\]$_DFFE_PP_ clknet_4_14_0_clk net139
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[10\]$_DFFE_PP_ clknet_4_12_0_clk net140
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[11\]$_DFFE_PP_ clknet_4_15_0_clk net141
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[12\]$_DFFE_PP_ clknet_4_15_0_clk net142
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[13\]$_DFFE_PP_ clknet_4_14_0_clk net143
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[14\]$_DFFE_PP_ clknet_4_15_0_clk net144
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[15\]$_DFFE_PP_ clknet_4_13_0_clk net145
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[16\]$_DFFE_PP_ clknet_4_6_0_clk net146
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[17\]$_DFFE_PP_ clknet_4_14_0_clk net147
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[18\]$_DFFE_PP_ clknet_4_7_0_clk net148
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[19\]$_DFFE_PP_ clknet_4_7_0_clk net149
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[1\]$_DFFE_PP_ clknet_4_5_0_clk net150
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[20\]$_DFFE_PP_ clknet_4_5_0_clk net151
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[21\]$_DFFE_PP_ clknet_4_5_0_clk net152
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[22\]$_DFFE_PP_ clknet_4_5_0_clk net153
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[23\]$_DFFE_PP_ clknet_4_6_0_clk net154
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[24\]$_DFFE_PP_ clknet_4_11_0_clk net155
+ _0006_ VSS VSS VDD VDD dest_id\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[25\]$_DFFE_PP_ clknet_4_11_0_clk net156
+ _0006_ VSS VSS VDD VDD dest_id\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[26\]$_DFFE_PP_ clknet_4_10_0_clk net157
+ _0006_ VSS VSS VDD VDD dest_id\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[27\]$_DFFE_PP_ clknet_4_10_0_clk net158
+ _0006_ VSS VSS VDD VDD dest_id\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[28\]$_DFFE_PP_ clknet_4_10_0_clk net159
+ _0006_ VSS VSS VDD VDD dest_id\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[29\]$_DFFE_PP_ clknet_4_11_0_clk net160
+ _0006_ VSS VSS VDD VDD dest_id\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[2\]$_DFFE_PP_ clknet_4_4_0_clk net161
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[30\]$_DFFE_PP_ clknet_4_10_0_clk net162
+ _0006_ VSS VSS VDD VDD dest_id\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[31\]$_DFFE_PP_ clknet_4_9_0_clk net163
+ _0006_ VSS VSS VDD VDD dest_id\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[3\]$_DFFE_PP_ clknet_4_1_0_clk net164
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[4\]$_DFFE_PP_ clknet_4_1_0_clk net165
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[5\]$_DFFE_PP_ clknet_4_1_0_clk net166
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[6\]$_DFFE_PP_ clknet_4_0_0_clk net167
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[7\]$_DFFE_PP_ clknet_4_1_0_clk net168
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[8\]$_DFFE_PP_ clknet_4_1_0_clk net169
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[3\]\[9\]$_DFFE_PP_ clknet_4_2_0_clk net170
+ _0006_ VSS VSS VDD VDD input_buffer\[3\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[0\]$_DFFE_PP_ clknet_4_14_0_clk net36
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[10\]$_DFFE_PP_ clknet_4_12_0_clk net37
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[11\]$_DFFE_PP_ clknet_4_15_0_clk net38
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[12\]$_DFFE_PP_ clknet_4_15_0_clk net39
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[13\]$_DFFE_PP_ clknet_4_14_0_clk net40
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[14\]$_DFFE_PP_ clknet_4_15_0_clk net41
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[15\]$_DFFE_PP_ clknet_4_15_0_clk net42
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[16\]$_DFFE_PP_ clknet_4_13_0_clk net43
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[17\]$_DFFE_PP_ clknet_4_14_0_clk net44
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[18\]$_DFFE_PP_ clknet_4_7_0_clk net45
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[19\]$_DFFE_PP_ clknet_4_7_0_clk net46
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[1\]$_DFFE_PP_ clknet_4_5_0_clk net47 _0005_
+ VSS VSS VDD VDD input_buffer\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[20\]$_DFFE_PP_ clknet_4_5_0_clk net48
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[21\]$_DFFE_PP_ clknet_4_4_0_clk net49
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[22\]$_DFFE_PP_ clknet_4_5_0_clk net50
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[23\]$_DFFE_PP_ clknet_4_6_0_clk net51
+ _0005_ VSS VSS VDD VDD input_buffer\[4\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[24\]$_DFFE_PP_ clknet_4_11_0_clk net52
+ _0005_ VSS VSS VDD VDD dest_id\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[25\]$_DFFE_PP_ clknet_4_11_0_clk net53
+ _0005_ VSS VSS VDD VDD dest_id\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[26\]$_DFFE_PP_ clknet_4_11_0_clk net54
+ _0005_ VSS VSS VDD VDD dest_id\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[27\]$_DFFE_PP_ clknet_4_11_0_clk net55
+ _0005_ VSS VSS VDD VDD dest_id\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[28\]$_DFFE_PP_ clknet_4_10_0_clk net56
+ _0005_ VSS VSS VDD VDD dest_id\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[29\]$_DFFE_PP_ clknet_4_10_0_clk net57
+ _0005_ VSS VSS VDD VDD dest_id\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[2\]$_DFFE_PP_ clknet_4_4_0_clk net58 _0005_
+ VSS VSS VDD VDD input_buffer\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[30\]$_DFFE_PP_ clknet_4_11_0_clk net59
+ _0005_ VSS VSS VDD VDD dest_id\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[31\]$_DFFE_PP_ clknet_4_11_0_clk net60
+ _0005_ VSS VSS VDD VDD dest_id\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[3\]$_DFFE_PP_ clknet_4_4_0_clk net61 _0005_
+ VSS VSS VDD VDD input_buffer\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[4\]$_DFFE_PP_ clknet_4_1_0_clk net62 _0005_
+ VSS VSS VDD VDD input_buffer\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[5\]$_DFFE_PP_ clknet_4_1_0_clk net63 _0005_
+ VSS VSS VDD VDD input_buffer\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[6\]$_DFFE_PP_ clknet_4_0_0_clk net64 _0005_
+ VSS VSS VDD VDD input_buffer\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[7\]$_DFFE_PP_ clknet_4_0_0_clk net65 _0005_
+ VSS VSS VDD VDD input_buffer\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[8\]$_DFFE_PP_ clknet_4_3_0_clk net66 _0005_
+ VSS VSS VDD VDD input_buffer\[4\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer\[4\]\[9\]$_DFFE_PP_ clknet_4_3_0_clk net67 _0005_
+ VSS VSS VDD VDD input_buffer\[4\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xinput_buffer_valid\[0\]$_DFF_PN0_ clknet_4_9_0_clk _0000_
+ net1 VSS VSS VDD VDD input_buffer_valid\[0\] sky130_fd_sc_hd__dfrtp_1
Xinput_buffer_valid\[1\]$_DFF_PN0_ clknet_4_9_0_clk _0001_
+ net1 VSS VSS VDD VDD input_buffer_valid\[1\] sky130_fd_sc_hd__dfrtp_1
Xinput_buffer_valid\[2\]$_DFF_PN0_ clknet_4_9_0_clk _0002_
+ net1 VSS VSS VDD VDD input_buffer_valid\[2\] sky130_fd_sc_hd__dfrtp_1
Xinput_buffer_valid\[3\]$_DFF_PN0_ clknet_4_9_0_clk _0003_
+ net1 VSS VSS VDD VDD input_buffer_valid\[3\] sky130_fd_sc_hd__dfrtp_1
Xinput_buffer_valid\[4\]$_DFF_PN0_ clknet_4_9_0_clk _0004_
+ net1 VSS VSS VDD VDD input_buffer_valid\[4\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net104 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 net498 VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 net447 VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 net436 VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 net480 VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 net457 VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 net390 VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 net460 VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 net452 VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 net499 VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 net411 VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 net376 VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 net364 VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput13 net348 VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput14 net362 VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput15 net379 VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput16 net425 VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput17 net495 VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xinput18 net409 VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xinput19 net492 VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
Xinput20 net497 VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
Xinput21 net488 VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
Xinput22 net465 VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_1
Xinput23 net408 VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
Xinput24 net469 VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
Xinput25 net477 VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_1
Xinput26 net496 VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
Xinput27 net357 VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_1
Xinput28 net372 VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_1
Xinput29 net352 VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_1
Xinput30 net360 VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_1
Xinput31 net481 VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_1
Xinput32 net471 VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_1
Xinput33 east_in_valid VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_1
Xinput34 east_out_ready VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_2
Xinput35 net484 VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkbuf_1
Xinput36 net433 VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_1
Xinput37 net479 VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_1
Xinput38 net444 VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_1
Xinput39 net458 VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
Xinput40 net467 VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_1
Xinput41 net403 VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_1
Xinput42 net478 VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
Xinput43 net427 VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_1
Xinput44 net483 VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_1
Xinput45 net374 VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkbuf_1
Xinput46 net472 VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkbuf_1
Xinput47 net356 VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_1
Xinput48 net387 VSS VSS VDD VDD net49 sky130_fd_sc_hd__clkbuf_1
Xinput49 net449 VSS VSS VDD VDD net50 sky130_fd_sc_hd__clkbuf_1
Xinput50 net487 VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkbuf_1
Xinput51 net416 VSS VSS VDD VDD net52 sky130_fd_sc_hd__clkbuf_1
Xinput52 net437 VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkbuf_1
Xinput53 net490 VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkbuf_1
Xinput54 net442 VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_1
Xinput55 net422 VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_1
Xinput56 net429 VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkbuf_1
Xinput57 net424 VSS VSS VDD VDD net58 sky130_fd_sc_hd__clkbuf_1
Xinput58 net365 VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_1
Xinput59 net464 VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_1
Xinput60 local_in_data[3] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_1
Xinput61 net371 VSS VSS VDD VDD net62 sky130_fd_sc_hd__clkbuf_1
Xinput62 net383 VSS VSS VDD VDD net63 sky130_fd_sc_hd__clkbuf_1
Xinput63 net388 VSS VSS VDD VDD net64 sky130_fd_sc_hd__clkbuf_1
Xinput64 net386 VSS VSS VDD VDD net65 sky130_fd_sc_hd__clkbuf_1
Xinput65 local_in_data[8] VSS VSS VDD VDD net66 sky130_fd_sc_hd__clkbuf_2
Xinput66 local_in_data[9] VSS VSS VDD VDD net67 sky130_fd_sc_hd__clkbuf_2
Xinput67 local_in_valid VSS VSS VDD VDD net68 sky130_fd_sc_hd__clkbuf_1
Xinput68 local_out_ready VSS VSS VDD VDD net69 sky130_fd_sc_hd__buf_2
Xinput69 net414 VSS VSS VDD VDD net70 sky130_fd_sc_hd__clkbuf_1
Xinput70 net399 VSS VSS VDD VDD net71 sky130_fd_sc_hd__clkbuf_1
Xinput71 net441 VSS VSS VDD VDD net72 sky130_fd_sc_hd__clkbuf_1
Xinput72 net406 VSS VSS VDD VDD net73 sky130_fd_sc_hd__clkbuf_1
Xinput73 net400 VSS VSS VDD VDD net74 sky130_fd_sc_hd__clkbuf_1
Xinput74 net396 VSS VSS VDD VDD net75 sky130_fd_sc_hd__clkbuf_1
Xinput75 net382 VSS VSS VDD VDD net76 sky130_fd_sc_hd__clkbuf_1
Xinput76 net404 VSS VSS VDD VDD net77 sky130_fd_sc_hd__clkbuf_1
Xinput77 net373 VSS VSS VDD VDD net78 sky130_fd_sc_hd__clkbuf_1
Xinput78 net369 VSS VSS VDD VDD net79 sky130_fd_sc_hd__clkbuf_1
Xinput79 net451 VSS VSS VDD VDD net80 sky130_fd_sc_hd__clkbuf_1
Xinput80 net461 VSS VSS VDD VDD net81 sky130_fd_sc_hd__clkbuf_1
Xinput81 net401 VSS VSS VDD VDD net82 sky130_fd_sc_hd__clkbuf_1
Xinput82 net491 VSS VSS VDD VDD net83 sky130_fd_sc_hd__clkbuf_1
Xinput83 net349 VSS VSS VDD VDD net84 sky130_fd_sc_hd__clkbuf_1
Xinput84 net350 VSS VSS VDD VDD net85 sky130_fd_sc_hd__clkbuf_1
Xinput85 net381 VSS VSS VDD VDD net86 sky130_fd_sc_hd__clkbuf_1
Xinput86 net454 VSS VSS VDD VDD net87 sky130_fd_sc_hd__clkbuf_1
Xinput87 net380 VSS VSS VDD VDD net88 sky130_fd_sc_hd__clkbuf_1
Xinput88 net430 VSS VSS VDD VDD net89 sky130_fd_sc_hd__clkbuf_1
Xinput89 net459 VSS VSS VDD VDD net90 sky130_fd_sc_hd__clkbuf_1
Xinput90 net440 VSS VSS VDD VDD net91 sky130_fd_sc_hd__clkbuf_1
Xinput91 net468 VSS VSS VDD VDD net92 sky130_fd_sc_hd__clkbuf_1
Xinput92 net466 VSS VSS VDD VDD net93 sky130_fd_sc_hd__clkbuf_1
Xinput93 net412 VSS VSS VDD VDD net94 sky130_fd_sc_hd__clkbuf_1
Xinput94 net358 VSS VSS VDD VDD net95 sky130_fd_sc_hd__clkbuf_1
Xinput95 net361 VSS VSS VDD VDD net96 sky130_fd_sc_hd__clkbuf_1
Xinput96 net410 VSS VSS VDD VDD net97 sky130_fd_sc_hd__clkbuf_1
Xinput97 net394 VSS VSS VDD VDD net98 sky130_fd_sc_hd__clkbuf_1
Xinput98 net476 VSS VSS VDD VDD net99 sky130_fd_sc_hd__clkbuf_1
Xinput99 net415 VSS VSS VDD VDD net100 sky130_fd_sc_hd__clkbuf_1
Xinput100 net393 VSS VSS VDD VDD net101 sky130_fd_sc_hd__clkbuf_1
Xinput101 north_in_valid VSS VSS VDD VDD net102 sky130_fd_sc_hd__clkbuf_1
Xinput102 north_out_ready VSS VSS VDD VDD net103 sky130_fd_sc_hd__clkbuf_2
Xinput103 net343 VSS VSS VDD VDD net104 sky130_fd_sc_hd__buf_2
Xinput104 south_in_data[0] VSS VSS VDD VDD net105 sky130_fd_sc_hd__clkbuf_1
Xinput105 net475 VSS VSS VDD VDD net106 sky130_fd_sc_hd__clkbuf_1
Xinput106 net405 VSS VSS VDD VDD net107 sky130_fd_sc_hd__clkbuf_1
Xinput107 net485 VSS VSS VDD VDD net108 sky130_fd_sc_hd__clkbuf_1
Xinput108 net482 VSS VSS VDD VDD net109 sky130_fd_sc_hd__clkbuf_1
Xinput109 net426 VSS VSS VDD VDD net110 sky130_fd_sc_hd__clkbuf_1
Xinput110 net368 VSS VSS VDD VDD net111 sky130_fd_sc_hd__clkbuf_1
Xinput111 net397 VSS VSS VDD VDD net112 sky130_fd_sc_hd__clkbuf_1
Xinput112 net474 VSS VSS VDD VDD net113 sky130_fd_sc_hd__clkbuf_1
Xinput113 net423 VSS VSS VDD VDD net114 sky130_fd_sc_hd__clkbuf_1
Xinput114 net377 VSS VSS VDD VDD net115 sky130_fd_sc_hd__clkbuf_1
Xinput115 net363 VSS VSS VDD VDD net116 sky130_fd_sc_hd__clkbuf_1
Xinput116 net351 VSS VSS VDD VDD net117 sky130_fd_sc_hd__clkbuf_1
Xinput117 net417 VSS VSS VDD VDD net118 sky130_fd_sc_hd__clkbuf_1
Xinput118 net398 VSS VSS VDD VDD net119 sky130_fd_sc_hd__clkbuf_1
Xinput119 net392 VSS VSS VDD VDD net120 sky130_fd_sc_hd__clkbuf_1
Xinput120 net413 VSS VSS VDD VDD net121 sky130_fd_sc_hd__clkbuf_1
Xinput121 net494 VSS VSS VDD VDD net122 sky130_fd_sc_hd__clkbuf_1
Xinput122 net431 VSS VSS VDD VDD net123 sky130_fd_sc_hd__clkbuf_1
Xinput123 net375 VSS VSS VDD VDD net124 sky130_fd_sc_hd__clkbuf_1
Xinput124 net378 VSS VSS VDD VDD net125 sky130_fd_sc_hd__clkbuf_1
Xinput125 net402 VSS VSS VDD VDD net126 sky130_fd_sc_hd__clkbuf_1
Xinput126 net391 VSS VSS VDD VDD net127 sky130_fd_sc_hd__clkbuf_1
Xinput127 net446 VSS VSS VDD VDD net128 sky130_fd_sc_hd__clkbuf_1
Xinput128 net455 VSS VSS VDD VDD net129 sky130_fd_sc_hd__clkbuf_1
Xinput129 net359 VSS VSS VDD VDD net130 sky130_fd_sc_hd__clkbuf_1
Xinput130 net346 VSS VSS VDD VDD net131 sky130_fd_sc_hd__clkbuf_1
Xinput131 net347 VSS VSS VDD VDD net132 sky130_fd_sc_hd__clkbuf_1
Xinput132 net367 VSS VSS VDD VDD net133 sky130_fd_sc_hd__clkbuf_1
Xinput133 net443 VSS VSS VDD VDD net134 sky130_fd_sc_hd__clkbuf_1
Xinput134 net407 VSS VSS VDD VDD net135 sky130_fd_sc_hd__clkbuf_1
Xinput135 net420 VSS VSS VDD VDD net136 sky130_fd_sc_hd__clkbuf_1
Xinput136 south_in_valid VSS VSS VDD VDD net137 sky130_fd_sc_hd__clkbuf_1
Xinput137 south_out_ready VSS VSS VDD VDD net138 sky130_fd_sc_hd__clkbuf_2
Xinput138 net470 VSS VSS VDD VDD net139 sky130_fd_sc_hd__clkbuf_1
Xinput139 net428 VSS VSS VDD VDD net140 sky130_fd_sc_hd__clkbuf_1
Xinput140 net370 VSS VSS VDD VDD net141 sky130_fd_sc_hd__clkbuf_1
Xinput141 net453 VSS VSS VDD VDD net142 sky130_fd_sc_hd__clkbuf_1
Xinput142 net456 VSS VSS VDD VDD net143 sky130_fd_sc_hd__clkbuf_1
Xinput143 net463 VSS VSS VDD VDD net144 sky130_fd_sc_hd__clkbuf_1
Xinput144 net438 VSS VSS VDD VDD net145 sky130_fd_sc_hd__clkbuf_1
Xinput145 net473 VSS VSS VDD VDD net146 sky130_fd_sc_hd__clkbuf_1
Xinput146 net462 VSS VSS VDD VDD net147 sky130_fd_sc_hd__clkbuf_1
Xinput147 net486 VSS VSS VDD VDD net148 sky130_fd_sc_hd__clkbuf_1
Xinput148 net366 VSS VSS VDD VDD net149 sky130_fd_sc_hd__clkbuf_1
Xinput149 net448 VSS VSS VDD VDD net150 sky130_fd_sc_hd__clkbuf_1
Xinput150 net353 VSS VSS VDD VDD net151 sky130_fd_sc_hd__clkbuf_1
Xinput151 net344 VSS VSS VDD VDD net152 sky130_fd_sc_hd__clkbuf_1
Xinput152 net345 VSS VSS VDD VDD net153 sky130_fd_sc_hd__clkbuf_1
Xinput153 net432 VSS VSS VDD VDD net154 sky130_fd_sc_hd__clkbuf_1
Xinput154 net489 VSS VSS VDD VDD net155 sky130_fd_sc_hd__clkbuf_1
Xinput155 net419 VSS VSS VDD VDD net156 sky130_fd_sc_hd__clkbuf_1
Xinput156 net439 VSS VSS VDD VDD net157 sky130_fd_sc_hd__clkbuf_1
Xinput157 net435 VSS VSS VDD VDD net158 sky130_fd_sc_hd__clkbuf_1
Xinput158 net395 VSS VSS VDD VDD net159 sky130_fd_sc_hd__clkbuf_1
Xinput159 net450 VSS VSS VDD VDD net160 sky130_fd_sc_hd__clkbuf_1
Xinput160 net389 VSS VSS VDD VDD net161 sky130_fd_sc_hd__clkbuf_1
Xinput161 net418 VSS VSS VDD VDD net162 sky130_fd_sc_hd__clkbuf_1
Xinput162 net421 VSS VSS VDD VDD net163 sky130_fd_sc_hd__clkbuf_1
Xinput163 net385 VSS VSS VDD VDD net164 sky130_fd_sc_hd__clkbuf_1
Xinput164 net384 VSS VSS VDD VDD net165 sky130_fd_sc_hd__clkbuf_1
Xinput165 net354 VSS VSS VDD VDD net166 sky130_fd_sc_hd__clkbuf_1
Xinput166 net434 VSS VSS VDD VDD net167 sky130_fd_sc_hd__clkbuf_1
Xinput167 net355 VSS VSS VDD VDD net168 sky130_fd_sc_hd__clkbuf_1
Xinput168 net445 VSS VSS VDD VDD net169 sky130_fd_sc_hd__clkbuf_1
Xinput169 net493 VSS VSS VDD VDD net170 sky130_fd_sc_hd__clkbuf_1
Xinput170 west_in_valid VSS VSS VDD VDD net171 sky130_fd_sc_hd__clkbuf_1
Xinput171 west_out_ready VSS VSS VDD VDD net172 sky130_fd_sc_hd__clkbuf_2
Xoutput172 net173 VSS VSS VDD VDD east_in_ready sky130_fd_sc_hd__clkbuf_1
Xoutput173 net174 VSS VSS VDD VDD east_out_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput174 net175 VSS VSS VDD VDD east_out_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput175 net176 VSS VSS VDD VDD east_out_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput176 net177 VSS VSS VDD VDD east_out_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput177 net178 VSS VSS VDD VDD east_out_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput178 net179 VSS VSS VDD VDD east_out_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput179 net180 VSS VSS VDD VDD east_out_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput180 net181 VSS VSS VDD VDD east_out_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput181 net182 VSS VSS VDD VDD east_out_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput182 net183 VSS VSS VDD VDD east_out_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput183 net184 VSS VSS VDD VDD east_out_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput184 net185 VSS VSS VDD VDD east_out_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput185 net186 VSS VSS VDD VDD east_out_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput186 net187 VSS VSS VDD VDD east_out_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput187 net188 VSS VSS VDD VDD east_out_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput188 net189 VSS VSS VDD VDD east_out_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput189 net190 VSS VSS VDD VDD east_out_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput190 net191 VSS VSS VDD VDD east_out_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput191 net192 VSS VSS VDD VDD east_out_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput192 net193 VSS VSS VDD VDD east_out_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput193 net194 VSS VSS VDD VDD east_out_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput194 net195 VSS VSS VDD VDD east_out_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput195 net196 VSS VSS VDD VDD east_out_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput196 net197 VSS VSS VDD VDD east_out_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput197 net198 VSS VSS VDD VDD east_out_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput198 net199 VSS VSS VDD VDD east_out_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput199 net200 VSS VSS VDD VDD east_out_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput200 net201 VSS VSS VDD VDD east_out_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput201 net202 VSS VSS VDD VDD east_out_valid sky130_fd_sc_hd__clkbuf_1
Xoutput202 net203 VSS VSS VDD VDD local_in_ready sky130_fd_sc_hd__clkbuf_1
Xoutput203 net204 VSS VSS VDD VDD local_out_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput204 net205 VSS VSS VDD VDD local_out_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput205 net206 VSS VSS VDD VDD local_out_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput206 net207 VSS VSS VDD VDD local_out_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput207 net208 VSS VSS VDD VDD local_out_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput208 net209 VSS VSS VDD VDD local_out_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput209 net210 VSS VSS VDD VDD local_out_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput210 net211 VSS VSS VDD VDD local_out_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput211 net212 VSS VSS VDD VDD local_out_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput212 net213 VSS VSS VDD VDD local_out_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput213 net214 VSS VSS VDD VDD local_out_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput214 net215 VSS VSS VDD VDD local_out_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput215 net216 VSS VSS VDD VDD local_out_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput216 net217 VSS VSS VDD VDD local_out_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput217 net218 VSS VSS VDD VDD local_out_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput218 net219 VSS VSS VDD VDD local_out_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput219 net220 VSS VSS VDD VDD local_out_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput220 net221 VSS VSS VDD VDD local_out_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput221 net222 VSS VSS VDD VDD local_out_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput222 net223 VSS VSS VDD VDD local_out_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput223 net224 VSS VSS VDD VDD local_out_data[28] sky130_fd_sc_hd__clkbuf_1
Xoutput224 net225 VSS VSS VDD VDD local_out_data[29] sky130_fd_sc_hd__clkbuf_1
Xoutput225 net226 VSS VSS VDD VDD local_out_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput226 net227 VSS VSS VDD VDD local_out_data[30] sky130_fd_sc_hd__clkbuf_1
Xoutput227 net228 VSS VSS VDD VDD local_out_data[31] sky130_fd_sc_hd__clkbuf_1
Xoutput228 net229 VSS VSS VDD VDD local_out_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput229 net230 VSS VSS VDD VDD local_out_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput230 net231 VSS VSS VDD VDD local_out_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput231 net232 VSS VSS VDD VDD local_out_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput232 net233 VSS VSS VDD VDD local_out_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput233 net234 VSS VSS VDD VDD local_out_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput234 net235 VSS VSS VDD VDD local_out_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput235 net236 VSS VSS VDD VDD local_out_valid sky130_fd_sc_hd__clkbuf_1
Xoutput236 net237 VSS VSS VDD VDD north_in_ready sky130_fd_sc_hd__clkbuf_1
Xoutput237 net238 VSS VSS VDD VDD north_out_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput238 net239 VSS VSS VDD VDD north_out_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput239 net240 VSS VSS VDD VDD north_out_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput240 net241 VSS VSS VDD VDD north_out_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput241 net242 VSS VSS VDD VDD north_out_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput242 net243 VSS VSS VDD VDD north_out_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput243 net244 VSS VSS VDD VDD north_out_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput244 net245 VSS VSS VDD VDD north_out_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput245 net246 VSS VSS VDD VDD north_out_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput246 net247 VSS VSS VDD VDD north_out_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput247 net248 VSS VSS VDD VDD north_out_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput248 net249 VSS VSS VDD VDD north_out_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput249 net250 VSS VSS VDD VDD north_out_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput250 net251 VSS VSS VDD VDD north_out_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput251 net252 VSS VSS VDD VDD north_out_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput252 net253 VSS VSS VDD VDD north_out_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput253 net254 VSS VSS VDD VDD north_out_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput254 net255 VSS VSS VDD VDD north_out_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput255 net256 VSS VSS VDD VDD north_out_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput256 net257 VSS VSS VDD VDD north_out_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput257 net258 VSS VSS VDD VDD north_out_data[28] sky130_fd_sc_hd__clkbuf_1
Xoutput258 net259 VSS VSS VDD VDD north_out_data[29] sky130_fd_sc_hd__clkbuf_1
Xoutput259 net260 VSS VSS VDD VDD north_out_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput260 net261 VSS VSS VDD VDD north_out_data[30] sky130_fd_sc_hd__clkbuf_1
Xoutput261 net262 VSS VSS VDD VDD north_out_data[31] sky130_fd_sc_hd__clkbuf_1
Xoutput262 net263 VSS VSS VDD VDD north_out_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput263 net264 VSS VSS VDD VDD north_out_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput264 net265 VSS VSS VDD VDD north_out_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput265 net266 VSS VSS VDD VDD north_out_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput266 net267 VSS VSS VDD VDD north_out_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput267 net268 VSS VSS VDD VDD north_out_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput268 net269 VSS VSS VDD VDD north_out_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput269 net270 VSS VSS VDD VDD north_out_valid sky130_fd_sc_hd__clkbuf_1
Xoutput270 net271 VSS VSS VDD VDD south_in_ready sky130_fd_sc_hd__clkbuf_1
Xoutput271 net272 VSS VSS VDD VDD south_out_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput272 net273 VSS VSS VDD VDD south_out_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput273 net274 VSS VSS VDD VDD south_out_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput274 net275 VSS VSS VDD VDD south_out_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput275 net276 VSS VSS VDD VDD south_out_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput276 net277 VSS VSS VDD VDD south_out_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput277 net278 VSS VSS VDD VDD south_out_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput278 net279 VSS VSS VDD VDD south_out_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput279 net280 VSS VSS VDD VDD south_out_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput280 net281 VSS VSS VDD VDD south_out_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput281 net282 VSS VSS VDD VDD south_out_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput282 net283 VSS VSS VDD VDD south_out_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput283 net284 VSS VSS VDD VDD south_out_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput284 net285 VSS VSS VDD VDD south_out_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput285 net286 VSS VSS VDD VDD south_out_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput286 net287 VSS VSS VDD VDD south_out_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput287 net288 VSS VSS VDD VDD south_out_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput288 net289 VSS VSS VDD VDD south_out_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput289 net290 VSS VSS VDD VDD south_out_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput290 net291 VSS VSS VDD VDD south_out_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput291 net292 VSS VSS VDD VDD south_out_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput292 net293 VSS VSS VDD VDD south_out_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput293 net294 VSS VSS VDD VDD south_out_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput294 net295 VSS VSS VDD VDD south_out_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput295 net296 VSS VSS VDD VDD south_out_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput296 net297 VSS VSS VDD VDD south_out_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput297 net298 VSS VSS VDD VDD south_out_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput298 net299 VSS VSS VDD VDD south_out_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput299 net300 VSS VSS VDD VDD south_out_valid sky130_fd_sc_hd__clkbuf_1
Xoutput300 net301 VSS VSS VDD VDD west_in_ready sky130_fd_sc_hd__clkbuf_1
Xoutput301 net302 VSS VSS VDD VDD west_out_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput302 net303 VSS VSS VDD VDD west_out_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput303 net304 VSS VSS VDD VDD west_out_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput304 net305 VSS VSS VDD VDD west_out_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput305 net306 VSS VSS VDD VDD west_out_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput306 net307 VSS VSS VDD VDD west_out_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput307 net308 VSS VSS VDD VDD west_out_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput308 net309 VSS VSS VDD VDD west_out_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput309 net310 VSS VSS VDD VDD west_out_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput310 net311 VSS VSS VDD VDD west_out_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput311 net312 VSS VSS VDD VDD west_out_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput312 net313 VSS VSS VDD VDD west_out_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput313 net314 VSS VSS VDD VDD west_out_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput314 net315 VSS VSS VDD VDD west_out_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput315 net316 VSS VSS VDD VDD west_out_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput316 net317 VSS VSS VDD VDD west_out_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput317 net318 VSS VSS VDD VDD west_out_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput318 net319 VSS VSS VDD VDD west_out_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput319 net320 VSS VSS VDD VDD west_out_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput320 net321 VSS VSS VDD VDD west_out_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput321 net322 VSS VSS VDD VDD west_out_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput322 net323 VSS VSS VDD VDD west_out_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput323 net324 VSS VSS VDD VDD west_out_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput324 net325 VSS VSS VDD VDD west_out_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput325 net326 VSS VSS VDD VDD west_out_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput326 net327 VSS VSS VDD VDD west_out_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput327 net328 VSS VSS VDD VDD west_out_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput328 net329 VSS VSS VDD VDD west_out_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput329 net330 VSS VSS VDD VDD west_out_valid sky130_fd_sc_hd__clkbuf_1
X_2459__330 VSS VSS VDD VDD _unconnected_0 net331 sky130_fd_sc_hd__conb_1
X_2460__331 VSS VSS VDD VDD _unconnected_1 net332 sky130_fd_sc_hd__conb_1
X_2461__332 VSS VSS VDD VDD _unconnected_2 net333 sky130_fd_sc_hd__conb_1
X_2462__333 VSS VSS VDD VDD _unconnected_3 net334 sky130_fd_sc_hd__conb_1
X_2463__334 VSS VSS VDD VDD _unconnected_4 net335 sky130_fd_sc_hd__conb_1
X_2464__335 VSS VSS VDD VDD _unconnected_5 net336 sky130_fd_sc_hd__conb_1
X_2465__336 VSS VSS VDD VDD _unconnected_6 net337 sky130_fd_sc_hd__conb_1
X_2466__337 VSS VSS VDD VDD _unconnected_7 net338 sky130_fd_sc_hd__conb_1
X_2467__338 VSS VSS VDD VDD _unconnected_8 net339 sky130_fd_sc_hd__conb_1
X_2468__339 VSS VSS VDD VDD _unconnected_9 net340 sky130_fd_sc_hd__conb_1
X_2469__340 VSS VSS VDD VDD _unconnected_10 net341 sky130_fd_sc_hd__conb_1
X_2470__341 VSS VSS VDD VDD _unconnected_11 net342 sky130_fd_sc_hd__conb_1
Xclkbuf_4_0_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_0_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_1_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_1_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_2_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_2_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_3_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_3_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_4_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_4_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_5_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_5_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_6_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_6_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_7_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_7_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_8_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_8_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_9_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_9_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_10_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_10_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_11_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_11_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_12_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_12_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_13_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_13_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_14_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_14_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_15_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_15_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_4_0_0_clk VSS VSS VDD VDD _unconnected_12
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload1 clknet_4_2_0_clk VSS VSS VDD VDD _unconnected_13
+ sky130_fd_sc_hd__inv_8
Xclkload2 clknet_4_3_0_clk VSS VSS VDD VDD _unconnected_14
+ sky130_fd_sc_hd__inv_6
Xclkload3 clknet_4_4_0_clk VSS VSS VDD VDD _unconnected_15
+ sky130_fd_sc_hd__clkinv_4
Xclkload4 clknet_4_6_0_clk VSS VSS VDD VDD _unconnected_16
+ sky130_fd_sc_hd__inv_8
Xclkload5 clknet_4_7_0_clk VSS VSS VDD VDD _unconnected_17
+ sky130_fd_sc_hd__inv_6
Xclkload6 clknet_4_8_0_clk VSS VSS VDD VDD _unconnected_18
+ sky130_fd_sc_hd__clkinv_8
Xclkload7 clknet_4_9_0_clk VSS VSS VDD VDD _unconnected_19
+ sky130_fd_sc_hd__clkinv_8
Xclkload8 clknet_4_10_0_clk VSS VSS VDD VDD _unconnected_20
+ sky130_fd_sc_hd__clkinv_8
Xclkload9 clknet_4_11_0_clk VSS VSS VDD VDD _unconnected_21
+ sky130_fd_sc_hd__inv_8
Xclkload10 clknet_4_12_0_clk VSS VSS VDD VDD _unconnected_22
+ sky130_fd_sc_hd__clkinv_8
Xclkload11 clknet_4_13_0_clk VSS VSS VDD VDD _unconnected_23
+ sky130_fd_sc_hd__inv_8
Xclkload12 clknet_4_14_0_clk VSS VSS VDD VDD _unconnected_24
+ sky130_fd_sc_hd__inv_8
Xclkload13 clknet_4_15_0_clk VSS VSS VDD VDD _unconnected_25
+ sky130_fd_sc_hd__clkinvlp_4
Xhold2 rst_n VSS VSS VDD VDD net343 sky130_fd_sc_hd__dlygate4sd3_1
Xhold3 west_in_data[21] VSS VSS VDD VDD net344 sky130_fd_sc_hd__dlygate4sd3_1
Xhold4 west_in_data[22] VSS VSS VDD VDD net345 sky130_fd_sc_hd__dlygate4sd3_1
Xhold5 south_in_data[4] VSS VSS VDD VDD net346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold6 south_in_data[5] VSS VSS VDD VDD net347 sky130_fd_sc_hd__dlygate4sd3_1
Xhold7 east_in_data[20] VSS VSS VDD VDD net348 sky130_fd_sc_hd__dlygate4sd3_1
Xhold8 north_in_data[22] VSS VSS VDD VDD net349 sky130_fd_sc_hd__dlygate4sd3_1
Xhold9 north_in_data[23] VSS VSS VDD VDD net350 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 south_in_data[20] VSS VSS VDD VDD net351 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 east_in_data[6] VSS VSS VDD VDD net352 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 west_in_data[20] VSS VSS VDD VDD net353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 west_in_data[5] VSS VSS VDD VDD net354 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 west_in_data[7] VSS VSS VDD VDD net355 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 local_in_data[20] VSS VSS VDD VDD net356 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 east_in_data[4] VSS VSS VDD VDD net357 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 north_in_data[3] VSS VSS VDD VDD net358 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 south_in_data[3] VSS VSS VDD VDD net359 sky130_fd_sc_hd__dlygate4sd3_1
Xhold19 east_in_data[7] VSS VSS VDD VDD net360 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 north_in_data[4] VSS VSS VDD VDD net361 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 east_in_data[21] VSS VSS VDD VDD net362 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 south_in_data[1] VSS VSS VDD VDD net363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 east_in_data[1] VSS VSS VDD VDD net364 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 local_in_data[30] VSS VSS VDD VDD net365 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 west_in_data[19] VSS VSS VDD VDD net366 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 south_in_data[6] VSS VSS VDD VDD net367 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 south_in_data[15] VSS VSS VDD VDD net368 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 north_in_data[18] VSS VSS VDD VDD net369 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 west_in_data[11] VSS VSS VDD VDD net370 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 local_in_data[4] VSS VSS VDD VDD net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 east_in_data[5] VSS VSS VDD VDD net372 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 north_in_data[17] VSS VSS VDD VDD net373 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 local_in_data[19] VSS VSS VDD VDD net374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 south_in_data[27] VSS VSS VDD VDD net375 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 east_in_data[19] VSS VSS VDD VDD net376 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 south_in_data[19] VSS VSS VDD VDD net377 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 south_in_data[28] VSS VSS VDD VDD net378 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 east_in_data[22] VSS VSS VDD VDD net379 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 north_in_data[26] VSS VSS VDD VDD net380 sky130_fd_sc_hd__dlygate4sd3_1
Xhold40 north_in_data[24] VSS VSS VDD VDD net381 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 north_in_data[15] VSS VSS VDD VDD net382 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 local_in_data[5] VSS VSS VDD VDD net383 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 west_in_data[4] VSS VSS VDD VDD net384 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 west_in_data[3] VSS VSS VDD VDD net385 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 local_in_data[7] VSS VSS VDD VDD net386 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 local_in_data[21] VSS VSS VDD VDD net387 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 local_in_data[6] VSS VSS VDD VDD net388 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 west_in_data[2] VSS VSS VDD VDD net389 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 east_in_data[14] VSS VSS VDD VDD net390 sky130_fd_sc_hd__dlygate4sd3_1
Xhold50 south_in_data[2] VSS VSS VDD VDD net391 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 south_in_data[23] VSS VSS VDD VDD net392 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 north_in_data[9] VSS VSS VDD VDD net393 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 north_in_data[6] VSS VSS VDD VDD net394 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 west_in_data[28] VSS VSS VDD VDD net395 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 north_in_data[14] VSS VSS VDD VDD net396 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 south_in_data[16] VSS VSS VDD VDD net397 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 south_in_data[22] VSS VSS VDD VDD net398 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 north_in_data[10] VSS VSS VDD VDD net399 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 north_in_data[13] VSS VSS VDD VDD net400 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 north_in_data[20] VSS VSS VDD VDD net401 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 south_in_data[29] VSS VSS VDD VDD net402 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 local_in_data[15] VSS VSS VDD VDD net403 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 north_in_data[16] VSS VSS VDD VDD net404 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 south_in_data[11] VSS VSS VDD VDD net405 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 north_in_data[12] VSS VSS VDD VDD net406 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 south_in_data[8] VSS VSS VDD VDD net407 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 east_in_data[2] VSS VSS VDD VDD net408 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 east_in_data[25] VSS VSS VDD VDD net409 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 north_in_data[5] VSS VSS VDD VDD net410 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 east_in_data[18] VSS VSS VDD VDD net411 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 north_in_data[31] VSS VSS VDD VDD net412 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 south_in_data[24] VSS VSS VDD VDD net413 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 north_in_data[0] VSS VSS VDD VDD net414 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 north_in_data[8] VSS VSS VDD VDD net415 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 local_in_data[24] VSS VSS VDD VDD net416 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 south_in_data[21] VSS VSS VDD VDD net417 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 west_in_data[30] VSS VSS VDD VDD net418 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 west_in_data[25] VSS VSS VDD VDD net419 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 south_in_data[9] VSS VSS VDD VDD net420 sky130_fd_sc_hd__dlygate4sd3_1
Xhold80 west_in_data[31] VSS VSS VDD VDD net421 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 local_in_data[28] VSS VSS VDD VDD net422 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 south_in_data[18] VSS VSS VDD VDD net423 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 local_in_data[2] VSS VSS VDD VDD net424 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 east_in_data[23] VSS VSS VDD VDD net425 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 south_in_data[14] VSS VSS VDD VDD net426 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 local_in_data[17] VSS VSS VDD VDD net427 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 west_in_data[10] VSS VSS VDD VDD net428 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 local_in_data[29] VSS VSS VDD VDD net429 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 north_in_data[27] VSS VSS VDD VDD net430 sky130_fd_sc_hd__dlygate4sd3_1
Xhold90 south_in_data[26] VSS VSS VDD VDD net431 sky130_fd_sc_hd__dlygate4sd3_1
Xhold91 west_in_data[23] VSS VSS VDD VDD net432 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 local_in_data[10] VSS VSS VDD VDD net433 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 west_in_data[6] VSS VSS VDD VDD net434 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 west_in_data[27] VSS VSS VDD VDD net435 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 east_in_data[11] VSS VSS VDD VDD net436 sky130_fd_sc_hd__dlygate4sd3_1
Xhold96 local_in_data[25] VSS VSS VDD VDD net437 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 west_in_data[15] VSS VSS VDD VDD net438 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 west_in_data[26] VSS VSS VDD VDD net439 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 north_in_data[29] VSS VSS VDD VDD net440 sky130_fd_sc_hd__dlygate4sd3_1
Xhold100 north_in_data[11] VSS VSS VDD VDD net441 sky130_fd_sc_hd__dlygate4sd3_1
Xhold101 local_in_data[27] VSS VSS VDD VDD net442 sky130_fd_sc_hd__dlygate4sd3_1
Xhold102 south_in_data[7] VSS VSS VDD VDD net443 sky130_fd_sc_hd__dlygate4sd3_1
Xhold103 local_in_data[12] VSS VSS VDD VDD net444 sky130_fd_sc_hd__dlygate4sd3_1
Xhold104 west_in_data[8] VSS VSS VDD VDD net445 sky130_fd_sc_hd__dlygate4sd3_1
Xhold105 south_in_data[30] VSS VSS VDD VDD net446 sky130_fd_sc_hd__dlygate4sd3_1
Xhold106 east_in_data[10] VSS VSS VDD VDD net447 sky130_fd_sc_hd__dlygate4sd3_1
Xhold107 west_in_data[1] VSS VSS VDD VDD net448 sky130_fd_sc_hd__dlygate4sd3_1
Xhold108 local_in_data[22] VSS VSS VDD VDD net449 sky130_fd_sc_hd__dlygate4sd3_1
Xhold109 west_in_data[29] VSS VSS VDD VDD net450 sky130_fd_sc_hd__dlygate4sd3_1
Xhold110 north_in_data[19] VSS VSS VDD VDD net451 sky130_fd_sc_hd__dlygate4sd3_1
Xhold111 east_in_data[16] VSS VSS VDD VDD net452 sky130_fd_sc_hd__dlygate4sd3_1
Xhold112 west_in_data[12] VSS VSS VDD VDD net453 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 north_in_data[25] VSS VSS VDD VDD net454 sky130_fd_sc_hd__dlygate4sd3_1
Xhold114 south_in_data[31] VSS VSS VDD VDD net455 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 west_in_data[13] VSS VSS VDD VDD net456 sky130_fd_sc_hd__dlygate4sd3_1
Xhold116 east_in_data[13] VSS VSS VDD VDD net457 sky130_fd_sc_hd__dlygate4sd3_1
Xhold117 local_in_data[13] VSS VSS VDD VDD net458 sky130_fd_sc_hd__dlygate4sd3_1
Xhold118 north_in_data[28] VSS VSS VDD VDD net459 sky130_fd_sc_hd__dlygate4sd3_1
Xhold119 east_in_data[15] VSS VSS VDD VDD net460 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 north_in_data[1] VSS VSS VDD VDD net461 sky130_fd_sc_hd__dlygate4sd3_1
Xhold121 west_in_data[17] VSS VSS VDD VDD net462 sky130_fd_sc_hd__dlygate4sd3_1
Xhold122 west_in_data[14] VSS VSS VDD VDD net463 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 local_in_data[31] VSS VSS VDD VDD net464 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 east_in_data[29] VSS VSS VDD VDD net465 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 north_in_data[30] VSS VSS VDD VDD net466 sky130_fd_sc_hd__dlygate4sd3_1
Xhold126 local_in_data[14] VSS VSS VDD VDD net467 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 north_in_data[2] VSS VSS VDD VDD net468 sky130_fd_sc_hd__dlygate4sd3_1
Xhold128 east_in_data[30] VSS VSS VDD VDD net469 sky130_fd_sc_hd__dlygate4sd3_1
Xhold129 west_in_data[0] VSS VSS VDD VDD net470 sky130_fd_sc_hd__dlygate4sd3_1
Xhold130 east_in_data[9] VSS VSS VDD VDD net471 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 local_in_data[1] VSS VSS VDD VDD net472 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 west_in_data[16] VSS VSS VDD VDD net473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 south_in_data[17] VSS VSS VDD VDD net474 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 south_in_data[10] VSS VSS VDD VDD net475 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 north_in_data[7] VSS VSS VDD VDD net476 sky130_fd_sc_hd__dlygate4sd3_1
Xhold136 east_in_data[31] VSS VSS VDD VDD net477 sky130_fd_sc_hd__dlygate4sd3_1
Xhold137 local_in_data[16] VSS VSS VDD VDD net478 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 local_in_data[11] VSS VSS VDD VDD net479 sky130_fd_sc_hd__dlygate4sd3_1
Xhold139 east_in_data[12] VSS VSS VDD VDD net480 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 east_in_data[8] VSS VSS VDD VDD net481 sky130_fd_sc_hd__dlygate4sd3_1
Xhold141 south_in_data[13] VSS VSS VDD VDD net482 sky130_fd_sc_hd__dlygate4sd3_1
Xhold142 local_in_data[18] VSS VSS VDD VDD net483 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 local_in_data[0] VSS VSS VDD VDD net484 sky130_fd_sc_hd__dlygate4sd3_1
Xhold144 south_in_data[12] VSS VSS VDD VDD net485 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 west_in_data[18] VSS VSS VDD VDD net486 sky130_fd_sc_hd__dlygate4sd3_1
Xhold146 local_in_data[23] VSS VSS VDD VDD net487 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 east_in_data[28] VSS VSS VDD VDD net488 sky130_fd_sc_hd__dlygate4sd3_1
Xhold148 west_in_data[24] VSS VSS VDD VDD net489 sky130_fd_sc_hd__dlygate4sd3_1
Xhold149 local_in_data[26] VSS VSS VDD VDD net490 sky130_fd_sc_hd__dlygate4sd3_1
Xhold150 north_in_data[21] VSS VSS VDD VDD net491 sky130_fd_sc_hd__dlygate4sd3_1
Xhold151 east_in_data[26] VSS VSS VDD VDD net492 sky130_fd_sc_hd__dlygate4sd3_1
Xhold152 west_in_data[9] VSS VSS VDD VDD net493 sky130_fd_sc_hd__dlygate4sd3_1
Xhold153 south_in_data[25] VSS VSS VDD VDD net494 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 east_in_data[24] VSS VSS VDD VDD net495 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 east_in_data[3] VSS VSS VDD VDD net496 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 east_in_data[27] VSS VSS VDD VDD net497 sky130_fd_sc_hd__dlygate4sd3_1
Xhold157 east_in_data[0] VSS VSS VDD VDD net498 sky130_fd_sc_hd__dlygate4sd3_1
Xhold158 east_in_data[17] VSS VSS VDD VDD net499 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_1 _0344_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS mesh_router
