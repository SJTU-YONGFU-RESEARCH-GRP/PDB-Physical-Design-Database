* cell parameterized_fft
* pin data_out_imag[60]
* pin data_out_imag[49]
* pin data_out_imag[61]
* pin data_out_imag[59]
* pin data_out_imag[4]
* pin data_out_imag[58]
* pin data_out_imag[5]
* pin data_out_imag[42]
* pin data_out_imag[113]
* pin data_out_imag[43]
* pin data_out_imag[34]
* pin data_out_imag[126]
* pin data_out_imag[33]
* pin data_out_imag[123]
* pin data_out_imag[125]
* pin data_out_imag[26]
* pin data_out_imag[30]
* pin data_out_imag[97]
* pin data_out_imag[94]
* pin data_out_imag[90]
* pin data_out_imag[91]
* pin data_out_imag[14]
* pin data_out_imag[98]
* pin data_out_imag[12]
* pin data_out_imag[8]
* pin data_out_imag[96]
* pin data_out_imag[15]
* pin data_out_imag[127]
* pin data_out_real[32]
* pin data_out_imag[51]
* pin data_out_imag[52]
* pin data_out_imag[50]
* pin data_out_real[54]
* pin data_out_real[50]
* pin data_out_real[127]
* pin data_out_imag[124]
* pin data_out_imag[31]
* pin data_out_imag[13]
* pin data_out_real[23]
* pin data_out_real[48]
* pin data_out_real[38]
* pin data_out_imag[16]
* pin data_out_real[12]
* pin data_out_imag[32]
* pin data_out_real[43]
* pin data_out_real[33]
* pin data_out_real[53]
* pin data_out_real[34]
* pin data_out_real[13]
* pin data_out_real[3]
* pin data_out_real[4]
* pin data_out_real[51]
* pin data_out_real[41]
* pin data_out_real[2]
* pin data_out_real[16]
* pin data_out_real[29]
* pin data_out_imag[2]
* pin data_out_real[28]
* pin data_out_imag[92]
* pin data_out_real[15]
* pin data_out_imag[93]
* pin data_out_real[31]
* pin data_out_imag[95]
* pin data_out_real[30]
* pin data_out_real[36]
* pin data_out_imag[27]
* pin data_out_real[35]
* pin data_out_real[39]
* pin data_out_imag[28]
* pin data_out_real[46]
* pin data_out_imag[29]
* pin data_out_real[19]
* pin data_out_real[27]
* pin data_out_real[47]
* pin data_out_real[42]
* pin data_out_real[45]
* pin data_out_imag[45]
* pin data_out_real[40]
* pin data_out_real[17]
* pin data_out_real[25]
* pin data_out_real[21]
* pin data_out_real[44]
* pin data_out_real[49]
* pin data_out_real[22]
* pin data_out_imag[44]
* pin data_out_imag[47]
* pin data_out_real[14]
* pin data_out_real[18]
* pin data_out_real[57]
* pin data_out_real[37]
* pin data_out_real[62]
* pin data_out_imag[46]
* pin data_out_imag[1]
* pin data_out_real[20]
* pin data_out_imag[3]
* pin data_out_real[1]
* pin data_out_real[55]
* pin data_out_real[61]
* pin data_out_imag[20]
* pin data_out_real[56]
* pin data_out_real[26]
* pin data_out_real[59]
* pin data_out_imag[17]
* pin data_out_real[63]
* pin data_out_imag[48]
* pin data_out_imag[111]
* pin data_out_imag[112]
* pin data_out_real[52]
* pin data_out_imag[53]
* pin data_out_real[58]
* pin data_out_real[24]
* pin data_out_real[5]
* pin data_out_imag[10]
* pin rst_n
* pin data_out_real[60]
* pin data_out_imag[57]
* pin data_out_imag[109]
* pin data_out_imag[107]
* pin data_out_imag[106]
* pin data_out_imag[105]
* pin clk
* pin data_out_imag[110]
* pin data_out_imag[108]
* pin data_out_imag[18]
* pin data_in_real[8]
* pin data_out_real[11]
* pin data_out_real[89]
* pin data_out_real[8]
* pin data_out_real[86]
* pin data_in_real[5]
* pin data_out_real[85]
* pin data_in_real[7]
* pin data_in_real[4]
* pin data_in_real[3]
* pin data_in_real[2]
* pin data_out_real[87]
* pin data_out_real[88]
* pin data_out_real[83]
* pin data_out_real[123]
* pin data_out_real[120]
* pin data_out_real[84]
* pin data_out_real[90]
* pin data_out_real[119]
* pin data_out_real[107]
* pin data_out_real[116]
* pin data_out_real[117]
* pin data_out_real[108]
* pin data_out_real[82]
* pin data_out_real[100]
* pin data_out_real[114]
* pin data_out_real[93]
* pin data_out_real[91]
* pin data_out_real[101]
* pin data_out_real[115]
* pin data_out_real[109]
* pin data_in_real[6]
* pin data_in_imag[14]
* pin data_out_imag[63]
* pin data_out_real[9]
* pin data_out_real[98]
* pin data_out_real[92]
* pin data_out_real[97]
* pin data_out_imag[64]
* pin data_out_imag[76]
* pin data_ready
* pin data_in_imag[7]
* pin data_out_imag[77]
* pin data_in_imag[4]
* pin data_out_imag[100]
* pin data_out_imag[39]
* pin data_in_real[1]
* pin data_in_real[9]
* pin data_out_real[113]
* pin data_out_real[99]
* pin data_in_real[13]
* pin data_out_real[125]
* pin data_out_real[78]
* pin data_out_real[111]
* pin data_out_real[81]
* pin data_out_real[64]
* pin data_out_real[96]
* pin data_out_imag[88]
* pin data_out_imag[70]
* pin data_out_imag[23]
* pin data_out_imag[85]
* pin data_out_imag[120]
* pin data_out_real[95]
* pin data_out_real[80]
* pin data_out_real[118]
* pin data_out_real[110]
* pin data_out_real[75]
* pin data_out_real[6]
* pin data_out_imag[79]
* pin data_in_imag[13]
* pin data_valid_out
* pin data_out_imag[101]
* pin data_out_imag[83]
* pin data_out_imag[62]
* pin data_out_imag[55]
* pin data_out_imag[19]
* pin data_in_imag[12]
* pin data_out_imag[7]
* pin data_out_real[94]
* pin data_out_real[74]
* pin data_out_real[71]
* pin data_out_real[102]
* pin data_in_imag[11]
* pin data_in_imag[9]
* pin data_out_imag[122]
* pin data_out_imag[22]
* pin data_out_imag[69]
* pin data_out_real[121]
* pin data_out_imag[11]
* pin data_out_imag[82]
* pin data_out_imag[25]
* pin data_out_imag[87]
* pin data_out_imag[73]
* pin data_in_imag[15]
* pin data_out_imag[80]
* pin data_out_imag[89]
* pin data_out_imag[9]
* pin data_in_imag[5]
* pin data_out_imag[104]
* pin data_out_imag[41]
* pin data_out_imag[71]
* pin data_in_imag[3]
* pin data_in_real[15]
* pin data_out_real[126]
* pin data_out_real[105]
* pin data_in_real[11]
* pin data_out_real[124]
* pin data_out_real[72]
* pin data_out_real[66]
* pin data_out_real[67]
* pin data_out_real[104]
* pin data_out_real[70]
* pin data_out_real[106]
* pin data_out_real[73]
* pin data_out_real[10]
* pin data_out_real[65]
* pin data_out_imag[0]
* pin data_out_imag[67]
* pin data_out_imag[66]
* pin data_in_imag[2]
* pin data_in_imag[10]
* pin data_out_imag[103]
* pin data_valid_in
* pin data_out_imag[35]
* pin data_out_imag[38]
* pin data_out_imag[75]
* pin data_out_imag[119]
* pin data_out_imag[65]
* pin data_out_imag[86]
* pin data_out_imag[99]
* pin data_in_imag[8]
* pin data_out_real[0]
* pin data_in_imag[0]
* pin data_out_real[122]
* pin data_in_real[14]
* pin data_out_real[77]
* pin data_out_real[7]
* pin data_in_real[12]
* pin data_out_real[103]
* pin data_out_real[69]
* pin data_in_imag[6]
* pin data_out_imag[54]
* pin data_out_real[68]
* pin data_out_imag[102]
* pin start
* pin data_out_real[76]
* pin data_out_imag[36]
* pin data_out_imag[117]
* pin data_out_imag[114]
* pin data_out_imag[37]
* pin data_out_imag[115]
* pin data_out_imag[116]
* pin data_out_imag[21]
* pin data_out_imag[6]
* pin data_out_imag[40]
* pin data_out_imag[74]
* pin data_out_imag[68]
* pin data_out_imag[84]
* pin data_out_imag[78]
* pin data_out_imag[81]
* pin data_out_imag[24]
* pin data_in_imag[1]
* pin data_out_imag[121]
* pin data_in_real[10]
* pin data_out_imag[72]
* pin data_out_real[112]
* pin data_in_real[0]
* pin data_out_imag[56]
* pin busy
* pin data_out_imag[118]
* pin data_out_real[79]
.SUBCKT parameterized_fft 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 1933 2104 2106 2196 2285 2381 2382 2472 2556
+ 2669 2672 2750 2751 2832 2892 2893 2894 2963 2964 2967 3031 3032 3087 3147
+ 3148 3198 3199 3257 3258 3314 3316 3364 3365 3366 3428 3430 3496 3497 3535
+ 3596 3597 3598 3649 3710 3785 3786 3867 3868 3941 3942 3943 4041 4042 4127
+ 4128 4207 4277 4278 4282 4287 4389 4392 4463 4542 4543 4544 4691 4692 4698
+ 4767 4768 4771 4850 4918 4919 4998 5034 5066 5067 5147 5148 5213 5283 5386
+ 5469 5622 6088 6150 6356 6485 6634 6708 7630 7728 7729 7730 7798 7799 7873
+ 7874 7936 8055 8056 8135 8266 8400 8539 8605 8664 8665 8732 8786 8826 8827
+ 8874 8875 8927 8928 8979 9021 9022 9083 9084 9151 9187 9191 9194 9196 9197
+ 9217 9219 9221 9223 9224 9225 9226 9229 9230 9240 9247 9248 9255 9266 9268
+ 9276 9282 9283 9284 9285 9290 9291 9295 9302 9304 9305 9306 9308 9309 9310
+ 9317 9321 9324 9325 9328 9330 9334 9348 9350 9356 9357 9358 9359 9376 9378
+ 9380 9381 9382 9383 9384 9385 9386 9388 9391 9392 9394 9395 9396 9397 9398
+ 9399 9400 9401 9404 9405 9406 9407 9408 9409 9410 9411 9412 9413 9414 9416
+ 9417 9418 9419 9420 9422 9424 9425 9428 9429 9430 9431 9432 9433 9434 9436
+ 9437 9438 9439 9440 9442 9443 9444 9445 9446 9447 9448 9449 9450 9452 9453
+ 9454 9455 9456 9457 9458 9459 9460 9461 9462 9463 9464 9465 9466 9467 9468
+ 9469 9470 9471 9472 9473 9474 9475 9476 9477 9478 9479 9480 9481 9482
* net 1 data_out_imag[60]
* net 2 data_out_imag[49]
* net 3 data_out_imag[61]
* net 4 data_out_imag[59]
* net 5 data_out_imag[4]
* net 6 data_out_imag[58]
* net 7 data_out_imag[5]
* net 8 data_out_imag[42]
* net 9 data_out_imag[113]
* net 10 data_out_imag[43]
* net 11 data_out_imag[34]
* net 12 data_out_imag[126]
* net 13 data_out_imag[33]
* net 14 data_out_imag[123]
* net 15 data_out_imag[125]
* net 16 data_out_imag[26]
* net 17 data_out_imag[30]
* net 18 data_out_imag[97]
* net 19 data_out_imag[94]
* net 20 data_out_imag[90]
* net 21 data_out_imag[91]
* net 22 data_out_imag[14]
* net 23 data_out_imag[98]
* net 24 data_out_imag[12]
* net 25 data_out_imag[8]
* net 26 data_out_imag[96]
* net 27 data_out_imag[15]
* net 28 data_out_imag[127]
* net 29 data_out_real[32]
* net 30 data_out_imag[51]
* net 31 data_out_imag[52]
* net 32 data_out_imag[50]
* net 1933 data_out_real[54]
* net 2104 data_out_real[50]
* net 2106 data_out_real[127]
* net 2196 data_out_imag[124]
* net 2285 data_out_imag[31]
* net 2381 data_out_imag[13]
* net 2382 data_out_real[23]
* net 2472 data_out_real[48]
* net 2556 data_out_real[38]
* net 2669 data_out_imag[16]
* net 2672 data_out_real[12]
* net 2750 data_out_imag[32]
* net 2751 data_out_real[43]
* net 2832 data_out_real[33]
* net 2892 data_out_real[53]
* net 2893 data_out_real[34]
* net 2894 data_out_real[13]
* net 2963 data_out_real[3]
* net 2964 data_out_real[4]
* net 2967 data_out_real[51]
* net 3031 data_out_real[41]
* net 3032 data_out_real[2]
* net 3087 data_out_real[16]
* net 3147 data_out_real[29]
* net 3148 data_out_imag[2]
* net 3198 data_out_real[28]
* net 3199 data_out_imag[92]
* net 3257 data_out_real[15]
* net 3258 data_out_imag[93]
* net 3314 data_out_real[31]
* net 3316 data_out_imag[95]
* net 3364 data_out_real[30]
* net 3365 data_out_real[36]
* net 3366 data_out_imag[27]
* net 3428 data_out_real[35]
* net 3430 data_out_real[39]
* net 3496 data_out_imag[28]
* net 3497 data_out_real[46]
* net 3535 data_out_imag[29]
* net 3596 data_out_real[19]
* net 3597 data_out_real[27]
* net 3598 data_out_real[47]
* net 3649 data_out_real[42]
* net 3710 data_out_real[45]
* net 3785 data_out_imag[45]
* net 3786 data_out_real[40]
* net 3867 data_out_real[17]
* net 3868 data_out_real[25]
* net 3941 data_out_real[21]
* net 3942 data_out_real[44]
* net 3943 data_out_real[49]
* net 4041 data_out_real[22]
* net 4042 data_out_imag[44]
* net 4127 data_out_imag[47]
* net 4128 data_out_real[14]
* net 4207 data_out_real[18]
* net 4277 data_out_real[57]
* net 4278 data_out_real[37]
* net 4282 data_out_real[62]
* net 4287 data_out_imag[46]
* net 4389 data_out_imag[1]
* net 4392 data_out_real[20]
* net 4463 data_out_imag[3]
* net 4542 data_out_real[1]
* net 4543 data_out_real[55]
* net 4544 data_out_real[61]
* net 4691 data_out_imag[20]
* net 4692 data_out_real[56]
* net 4698 data_out_real[26]
* net 4767 data_out_real[59]
* net 4768 data_out_imag[17]
* net 4771 data_out_real[63]
* net 4850 data_out_imag[48]
* net 4918 data_out_imag[111]
* net 4919 data_out_imag[112]
* net 4998 data_out_real[52]
* net 5034 data_out_imag[53]
* net 5066 data_out_real[58]
* net 5067 data_out_real[24]
* net 5147 data_out_real[5]
* net 5148 data_out_imag[10]
* net 5213 rst_n
* net 5283 data_out_real[60]
* net 5386 data_out_imag[57]
* net 5469 data_out_imag[109]
* net 5622 data_out_imag[107]
* net 6088 data_out_imag[106]
* net 6150 data_out_imag[105]
* net 6356 clk
* net 6485 data_out_imag[110]
* net 6634 data_out_imag[108]
* net 6708 data_out_imag[18]
* net 7630 data_in_real[8]
* net 7728 data_out_real[11]
* net 7729 data_out_real[89]
* net 7730 data_out_real[8]
* net 7798 data_out_real[86]
* net 7799 data_in_real[5]
* net 7873 data_out_real[85]
* net 7874 data_in_real[7]
* net 7936 data_in_real[4]
* net 8055 data_in_real[3]
* net 8056 data_in_real[2]
* net 8135 data_out_real[87]
* net 8266 data_out_real[88]
* net 8400 data_out_real[83]
* net 8539 data_out_real[123]
* net 8605 data_out_real[120]
* net 8664 data_out_real[84]
* net 8665 data_out_real[90]
* net 8732 data_out_real[119]
* net 8786 data_out_real[107]
* net 8826 data_out_real[116]
* net 8827 data_out_real[117]
* net 8874 data_out_real[108]
* net 8875 data_out_real[82]
* net 8927 data_out_real[100]
* net 8928 data_out_real[114]
* net 8979 data_out_real[93]
* net 9021 data_out_real[91]
* net 9022 data_out_real[101]
* net 9083 data_out_real[115]
* net 9084 data_out_real[109]
* net 9151 data_in_real[6]
* net 9187 data_in_imag[14]
* net 9191 data_out_imag[63]
* net 9194 data_out_real[9]
* net 9196 data_out_real[98]
* net 9197 data_out_real[92]
* net 9217 data_out_real[97]
* net 9219 data_out_imag[64]
* net 9221 data_out_imag[76]
* net 9223 data_ready
* net 9224 data_in_imag[7]
* net 9225 data_out_imag[77]
* net 9226 data_in_imag[4]
* net 9229 data_out_imag[100]
* net 9230 data_out_imag[39]
* net 9240 data_in_real[1]
* net 9247 data_in_real[9]
* net 9248 data_out_real[113]
* net 9255 data_out_real[99]
* net 9266 data_in_real[13]
* net 9268 data_out_real[125]
* net 9276 data_out_real[78]
* net 9282 data_out_real[111]
* net 9283 data_out_real[81]
* net 9284 data_out_real[64]
* net 9285 data_out_real[96]
* net 9290 data_out_imag[88]
* net 9291 data_out_imag[70]
* net 9295 data_out_imag[23]
* net 9302 data_out_imag[85]
* net 9304 data_out_imag[120]
* net 9305 data_out_real[95]
* net 9306 data_out_real[80]
* net 9308 data_out_real[118]
* net 9309 data_out_real[110]
* net 9310 data_out_real[75]
* net 9317 data_out_real[6]
* net 9321 data_out_imag[79]
* net 9324 data_in_imag[13]
* net 9325 data_valid_out
* net 9328 data_out_imag[101]
* net 9330 data_out_imag[83]
* net 9334 data_out_imag[62]
* net 9348 data_out_imag[55]
* net 9350 data_out_imag[19]
* net 9356 data_in_imag[12]
* net 9357 data_out_imag[7]
* net 9358 data_out_real[94]
* net 9359 data_out_real[74]
* net 9376 data_out_real[71]
* net 9378 data_out_real[102]
* net 9380 data_in_imag[11]
* net 9381 data_in_imag[9]
* net 9382 data_out_imag[122]
* net 9383 data_out_imag[22]
* net 9384 data_out_imag[69]
* net 9385 data_out_real[121]
* net 9386 data_out_imag[11]
* net 9388 data_out_imag[82]
* net 9391 data_out_imag[25]
* net 9392 data_out_imag[87]
* net 9394 data_out_imag[73]
* net 9395 data_in_imag[15]
* net 9396 data_out_imag[80]
* net 9397 data_out_imag[89]
* net 9398 data_out_imag[9]
* net 9399 data_in_imag[5]
* net 9400 data_out_imag[104]
* net 9401 data_out_imag[41]
* net 9404 data_out_imag[71]
* net 9405 data_in_imag[3]
* net 9406 data_in_real[15]
* net 9407 data_out_real[126]
* net 9408 data_out_real[105]
* net 9409 data_in_real[11]
* net 9410 data_out_real[124]
* net 9411 data_out_real[72]
* net 9412 data_out_real[66]
* net 9413 data_out_real[67]
* net 9414 data_out_real[104]
* net 9416 data_out_real[70]
* net 9417 data_out_real[106]
* net 9418 data_out_real[73]
* net 9419 data_out_real[10]
* net 9420 data_out_real[65]
* net 9422 data_out_imag[0]
* net 9424 data_out_imag[67]
* net 9425 data_out_imag[66]
* net 9428 data_in_imag[2]
* net 9429 data_in_imag[10]
* net 9430 data_out_imag[103]
* net 9431 data_valid_in
* net 9432 data_out_imag[35]
* net 9433 data_out_imag[38]
* net 9434 data_out_imag[75]
* net 9436 data_out_imag[119]
* net 9437 data_out_imag[65]
* net 9438 data_out_imag[86]
* net 9439 data_out_imag[99]
* net 9440 data_in_imag[8]
* net 9442 data_out_real[0]
* net 9443 data_in_imag[0]
* net 9444 data_out_real[122]
* net 9445 data_in_real[14]
* net 9446 data_out_real[77]
* net 9447 data_out_real[7]
* net 9448 data_in_real[12]
* net 9449 data_out_real[103]
* net 9450 data_out_real[69]
* net 9452 data_in_imag[6]
* net 9453 data_out_imag[54]
* net 9454 data_out_real[68]
* net 9455 data_out_imag[102]
* net 9456 start
* net 9457 data_out_real[76]
* net 9458 data_out_imag[36]
* net 9459 data_out_imag[117]
* net 9460 data_out_imag[114]
* net 9461 data_out_imag[37]
* net 9462 data_out_imag[115]
* net 9463 data_out_imag[116]
* net 9464 data_out_imag[21]
* net 9465 data_out_imag[6]
* net 9466 data_out_imag[40]
* net 9467 data_out_imag[74]
* net 9468 data_out_imag[68]
* net 9469 data_out_imag[84]
* net 9470 data_out_imag[78]
* net 9471 data_out_imag[81]
* net 9472 data_out_imag[24]
* net 9473 data_in_imag[1]
* net 9474 data_out_imag[121]
* net 9475 data_in_real[10]
* net 9476 data_out_imag[72]
* net 9477 data_out_real[112]
* net 9478 data_in_real[0]
* net 9479 data_out_imag[56]
* net 9480 busy
* net 9481 data_out_imag[118]
* net 9482 data_out_real[79]
* cell instance $3 r0 *1 130.18,2.72
X$3 105 59 1 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6 r0 *1 132.02,2.72
X$6 105 61 2 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $9 r0 *1 133.4,2.72
X$9 105 362 3 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $11 m0 *1 139.84,8.16
X$11 105 131 4 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $15 r0 *1 140.3,2.72
X$15 105 45 5 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17 r0 *1 141.68,2.72
X$17 105 363 6 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $21 r0 *1 143.06,2.72
X$21 105 735 7 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $24 r0 *1 144.44,2.72
X$24 105 364 8 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $27 r0 *1 145.82,2.72
X$27 105 69 9 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $31 r0 *1 151.8,2.72
X$31 105 919 10 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $36 r0 *1 155.02,2.72
X$36 105 78 11 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $40 r0 *1 153.64,2.72
X$40 105 76 12 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $43 m0 *1 155.94,8.16
X$43 105 1998 13 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $45 r0 *1 156.4,2.72
X$45 105 46 14 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $49 r0 *1 160.54,2.72
X$49 105 365 15 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $51 r0 *1 162.84,2.72
X$51 105 83 16 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $55 r0 *1 169.28,2.72
X$55 105 47 17 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $58 r0 *1 167.9,2.72
X$58 105 90 18 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $61 r0 *1 170.66,2.72
X$61 105 2000 19 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $64 r0 *1 173.88,2.72
X$64 105 93 20 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $67 r0 *1 183.54,2.72
X$67 105 3076 21 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $70 r0 *1 185.38,2.72
X$70 105 91 22 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $73 r0 *1 192.74,2.72
X$73 105 86 23 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $76 r0 *1 201.94,2.72
X$76 105 370 24 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $79 r0 *1 209.3,2.72
X$79 105 77 25 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $81 r0 *1 218.96,2.72
X$81 105 371 26 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $85 r0 *1 220.8,2.72
X$85 105 102 27 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $88 r0 *1 230.46,2.72
X$88 105 71 28 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $91 r0 *1 240.58,2.72
X$91 105 35 29 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $94 r0 *1 126.04,2.72
X$94 105 58 30 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $97 r0 *1 122.82,2.72
X$97 105 56 31 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $100 r0 *1 124.2,2.72
X$100 105 44 32 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $103 r0 *1 165.6,2.72
X$103 105 33 105 40 87 40 sky130_fd_sc_hd__inv_1
* cell instance $105 r0 *1 155.94,8.16
X$105 40 178 33 387 285 218 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $108 r0 *1 178.48,2.72
X$108 105 34 118 92 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $110 r0 *1 190.9,2.72
X$110 105 89 136 88 105 40 34 40 sky130_fd_sc_hd__o21ai_1
* cell instance $114 r0 *1 264.5,95.2
X$114 40 3043 3207 35 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $117 m0 *1 262.66,95.2
X$117 40 2904 35 2950 3043 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $120 r0 *1 271.4,2.72
X$120 40 42 49 319 36 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $122 r0 *1 283.36,2.72
X$122 105 37 50 36 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $125 r0 *1 291.64,2.72
X$125 105 38 41 57 105 40 37 40 sky130_fd_sc_hd__o21ai_1
* cell instance $127 r0 *1 296.24,2.72
X$127 105 39 108 38 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $130 r0 *1 310.04,2.72
X$130 105 54 51 55 105 39 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $323 m0 *1 79.58,133.28
X$323 40 3761 3763 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $326 m0 *1 59.8,89.76
X$326 40 2805 2806 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $328 r0 *1 53.82,100.64
X$328 40 2874 3210 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $330 m0 *1 41.86,89.76
X$330 40 2570 2716 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $332 m0 *1 79.58,95.2
X$332 40 2938 2937 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $335 r0 *1 84.64,106.08
X$335 40 3275 3236 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $337 r0 *1 70.84,89.76
X$337 40 2577 2721 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $339 m0 *1 71.76,100.64
X$339 40 2936 3071 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $342 r0 *1 84.18,149.6
X$342 40 4480 4443 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $344 r0 *1 82.34,165.92
X$344 40 4785 4945 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $347 m0 *1 61.18,312.8
X$347 40 8686 8719 5939 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $350 r0 *1 63.48,285.6
X$350 40 7943 8005 5939 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $353 m0 *1 17.94,345.44
X$353 40 8513 9338 5939 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $356 m0 *1 22.54,345.44
X$356 40 9200 9314 5939 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $359 m0 *1 39.1,345.44
X$359 40 9117 9316 5939 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $361 m0 *1 84.64,198.56
X$361 40 5405 5638 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $364 m0 *1 86.02,220.32
X$364 40 6259 6018 5332 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $366 m0 *1 86.02,204
X$366 40 5555 5556 5332 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $368 m0 *1 86.02,214.88
X$368 40 5909 6016 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $371 r0 *1 73.14,236.64
X$371 40 6681 6781 5939 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $373 m0 *1 79.58,236.64
X$373 40 6647 6747 5332 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $375 m0 *1 78.66,225.76
X$375 40 6425 6540 2804 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $377 r0 *1 58.42,263.84
X$377 40 7447 7608 5939 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $380 m0 *1 62.56,301.92
X$380 40 8411 8337 5939 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $382 m0 *1 79.58,247.52
X$382 40 6977 7009 5332 105 40 105 40 sky130_fd_sc_hd__ha_1
* cell instance $384 m0 *1 73.14,280.16
X$384 40 7645 7705 40 5332 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $386 m0 *1 71.3,285.6
X$386 40 7921 7922 40 5332 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $450 r0 *1 134.78,2.72
X$450 40 111 94 63 105 64 105 40 sky130_fd_sc_hd__ha_1
* cell instance $453 r0 *1 147.2,2.72
X$453 40 97 70 72 105 68 105 40 sky130_fd_sc_hd__ha_1
* cell instance $478 r0 *1 196.42,2.72
X$478 40 85 82 84 105 81 105 40 sky130_fd_sc_hd__ha_1
* cell instance $480 r0 *1 203.32,2.72
X$480 40 43 162 79 105 80 105 40 sky130_fd_sc_hd__ha_1
* cell instance $486 r0 *1 211.14,2.72
X$486 40 161 75 620 74 209 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $492 r0 *1 224.94,2.72
X$492 105 73 105 40 74 40 sky130_fd_sc_hd__inv_1
* cell instance $503 r0 *1 246.1,2.72
X$503 105 67 48 152 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $514 r0 *1 264.5,2.72
X$514 40 112 65 199 105 66 105 40 sky130_fd_sc_hd__ha_1
* cell instance $520 r0 *1 285.66,2.72
X$520 40 41 50 62 105 60 105 40 sky130_fd_sc_hd__ha_1
* cell instance $537 r0 *1 321.08,2.72
X$537 40 143 144 53 105 52 105 40 sky130_fd_sc_hd__ha_1
* cell instance $623 m0 *1 131.56,8.16
X$623 105 94 155 128 105 40 109 40 sky130_fd_sc_hd__o21ai_1
* cell instance $625 m0 *1 135.24,8.16
X$625 105 111 157 129 40 105 128 40 sky130_fd_sc_hd__a21boi_0
* cell instance $626 m0 *1 138,8.16
X$626 105 130 105 40 95 40 sky130_fd_sc_hd__inv_1
* cell instance $628 m0 *1 141.22,8.16
X$628 40 64 132 160 70 96 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $629 m0 *1 148.58,8.16
X$629 40 96 133 220 97 221 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $632 m0 *1 158.7,8.16
X$632 40 134 98 132 105 120 105 40 sky130_fd_sc_hd__ha_1
* cell instance $633 m0 *1 163.3,8.16
X$633 105 134 98 92 105 129 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $636 m0 *1 167.44,8.16
X$636 40 163 166 165 87 217 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $637 m0 *1 174.8,8.16
X$637 40 136 118 99 105 119 105 40 sky130_fd_sc_hd__ha_1
* cell instance $638 m0 *1 179.4,8.16
X$638 40 119 164 166 117 214 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $640 m0 *1 187.22,8.16
X$640 40 135 89 164 105 213 105 40 sky130_fd_sc_hd__ha_1
* cell instance $641 m0 *1 191.82,8.16
X$641 105 100 135 88 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $646 m0 *1 196.42,8.16
X$646 40 134 137 43 135 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $647 m0 *1 198.72,8.16
X$647 105 82 162 85 40 105 100 40 sky130_fd_sc_hd__a21oi_1
* cell instance $650 m0 *1 204.7,8.16
X$650 40 81 79 275 101 161 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $651 m0 *1 212.06,8.16
X$651 40 138 80 75 105 208 105 40 sky130_fd_sc_hd__ha_1
* cell instance $653 m0 *1 217.12,8.16
X$653 40 240 116 138 105 115 105 40 sky130_fd_sc_hd__ha_1
* cell instance $656 m0 *1 222.64,8.16
X$656 40 159 115 158 105 272 105 40 sky130_fd_sc_hd__ha_1
* cell instance $657 m0 *1 227.24,8.16
X$657 40 9535 104 103 105 156 105 40 sky130_fd_sc_hd__ha_1
* cell instance $658 m0 *1 231.84,8.16
X$658 40 9538 101 104 105 154 105 40 sky130_fd_sc_hd__ha_1
* cell instance $661 m0 *1 237.82,8.16
X$661 40 153 417 139 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $662 m0 *1 243.8,8.16
X$662 40 855 153 152 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $664 m0 *1 250.24,8.16
X$664 40 67 113 1255 114 267 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $665 m0 *1 257.6,8.16
X$665 40 139 113 150 65 140 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $666 m0 *1 265.88,8.16
X$666 40 140 112 141 265 198 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $671 m0 *1 277.84,8.16
X$671 40 149 62 141 110 194 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $673 m0 *1 288.88,8.16
X$673 40 60 147 193 377 259 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $674 m0 *1 296.24,8.16
X$674 40 108 57 147 105 192 105 40 sky130_fd_sc_hd__ha_1
* cell instance $678 m0 *1 305.44,8.16
X$678 40 55 51 148 105 107 105 40 sky130_fd_sc_hd__ha_1
* cell instance $681 m0 *1 312.34,8.16
X$681 40 107 53 189 106 253 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $684 m0 *1 325.22,8.16
X$684 105 142 144 54 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $685 m0 *1 327.52,8.16
X$685 105 186 143 188 105 40 142 40 sky130_fd_sc_hd__o21ai_1
* cell instance $709 r0 *1 31.74,8.16
X$709 105 167 948 121 40 105 169 40 sky130_fd_sc_hd__a21o_1
* cell instance $710 r0 *1 34.5,8.16
X$710 105 168 121 167 170 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $711 r0 *1 36.34,8.16
X$711 105 191 168 169 122 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $712 r0 *1 38.18,8.16
X$712 105 191 168 122 40 174 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $720 r0 *1 48.3,8.16
X$720 105 170 105 40 125 40 sky130_fd_sc_hd__inv_1
* cell instance $723 r0 *1 52.44,8.16
X$723 40 258 224 123 171 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $724 r0 *1 54.74,8.16
X$724 105 124 40 123 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $725 r0 *1 57.5,8.16
X$725 105 171 105 40 200 40 sky130_fd_sc_hd__buf_4
* cell instance $726 r0 *1 60.26,8.16
X$726 40 172 126 171 124 125 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $727 r0 *1 64.86,8.16
X$727 40 171 127 124 126 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $736 r0 *1 74.06,8.16
X$736 105 205 105 40 173 40 sky130_fd_sc_hd__inv_1
* cell instance $737 r0 *1 75.44,8.16
X$737 105 127 173 174 172 40 277 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $759 r0 *1 126.96,8.16
X$759 40 282 63 508 236 175 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $760 r0 *1 134.32,8.16
X$760 40 175 160 95 286 176 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $761 r0 *1 141.68,8.16
X$761 105 177 105 40 176 40 sky130_fd_sc_hd__inv_1
* cell instance $763 r0 *1 143.52,8.16
X$763 40 177 219 303 287 341 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $765 r0 *1 150.88,8.16
X$765 105 219 105 40 220 40 sky130_fd_sc_hd__inv_1
* cell instance $769 r0 *1 154.56,8.16
X$769 105 178 105 40 221 40 sky130_fd_sc_hd__inv_1
* cell instance $770 r0 *1 163.3,8.16
X$770 40 120 99 133 385 163 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $773 r0 *1 172.04,8.16
X$773 105 179 105 40 217 40 sky130_fd_sc_hd__inv_1
* cell instance $774 r0 *1 173.42,8.16
X$774 40 179 216 284 281 384 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $778 r0 *1 181.7,8.16
X$778 105 216 105 40 280 40 sky130_fd_sc_hd__inv_1
* cell instance $779 r0 *1 183.08,8.16
X$779 40 214 212 215 280 180 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $781 r0 *1 191.36,8.16
X$781 40 213 84 212 274 278 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $782 r0 *1 198.72,8.16
X$782 40 85 181 157 136 137 116 105 105 40 sky130_fd_sc_hd__o2111ai_4
* cell instance $786 r0 *1 209.76,8.16
X$786 40 209 207 688 238 788 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $787 r0 *1 217.12,8.16
X$787 40 208 158 466 273 207 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $790 r0 *1 225.86,8.16
X$790 105 103 105 40 206 40 sky130_fd_sc_hd__inv_1
* cell instance $791 r0 *1 227.24,8.16
X$791 40 73 204 182 271 206 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $793 r0 *1 234.6,8.16
X$793 105 204 105 40 238 40 sky130_fd_sc_hd__inv_1
* cell instance $797 r0 *1 241.04,8.16
X$797 40 48 114 269 184 183 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $800 r0 *1 249.78,8.16
X$800 40 183 321 380 268 203 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $801 r0 *1 257.14,8.16
X$801 105 202 105 40 184 40 sky130_fd_sc_hd__inv_1
* cell instance $809 r0 *1 266.8,8.16
X$809 105 201 105 40 199 40 sky130_fd_sc_hd__inv_1
* cell instance $812 r0 *1 270.94,8.16
X$812 40 198 195 197 264 196 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $815 r0 *1 279.68,8.16
X$815 40 194 193 195 263 262 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $824 r0 *1 300.38,8.16
X$824 40 192 148 257 256 185 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $825 r0 *1 307.74,8.16
X$825 40 185 189 375 244 190 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $830 r0 *1 319.7,8.16
X$830 40 52 187 250 251 245 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $831 r0 *1 327.06,8.16
X$831 40 249 188 187 105 248 105 40 sky130_fd_sc_hd__ha_1
* cell instance $871 m0 *1 11.96,13.6
X$871 105 389 423 289 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $875 m0 *1 20.24,13.6
X$875 40 145 310 288 350 312 105 105 40 sky130_fd_sc_hd__nand4b_2
* cell instance $876 m0 *1 25.76,13.6
X$876 105 294 289 288 312 105 146 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $878 m0 *1 29.44,13.6
X$878 40 315 121 168 191 290 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $879 m0 *1 34.04,13.6
X$879 105 191 168 121 105 40 531 40 sky130_fd_sc_hd__o21ai_1
* cell instance $883 m0 *1 39.1,13.6
X$883 105 168 105 40 225 40 sky130_fd_sc_hd__inv_1
* cell instance $884 m0 *1 40.48,13.6
X$884 105 291 222 293 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $885 m0 *1 42.78,13.6
X$885 105 292 222 291 254 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $886 m0 *1 44.62,13.6
X$886 40 151 452 294 223 224 105 105 40 sky130_fd_sc_hd__o22a_2
* cell instance $887 m0 *1 48.3,13.6
X$887 105 146 145 324 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $888 m0 *1 49.68,13.6
X$888 105 354 294 258 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $890 m0 *1 53.36,13.6
X$890 105 226 227 225 105 205 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $893 m0 *1 57.04,13.6
X$893 105 295 205 328 171 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $895 m0 *1 59.8,13.6
X$895 105 226 227 229 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $896 m0 *1 61.18,13.6
X$896 105 295 205 228 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $897 m0 *1 62.56,13.6
X$897 40 297 126 200 123 229 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $898 m0 *1 67.16,13.6
X$898 105 228 296 559 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $899 m0 *1 68.54,13.6
X$899 105 126 200 229 123 40 105 298 40 sky130_fd_sc_hd__and4_1
* cell instance $900 m0 *1 71.76,13.6
X$900 40 40 230 105 297 298 105 sky130_fd_sc_hd__nor2_2
* cell instance $901 m0 *1 74.06,13.6
X$901 40 231 211 174 172 173 127 105 105 40 sky130_fd_sc_hd__a2111oi_4
* cell instance $904 m0 *1 85.1,13.6
X$904 105 232 151 210 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $906 m0 *1 87.86,13.6
X$906 105 151 232 342 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $908 m0 *1 89.7,13.6
X$908 105 151 406 299 300 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $909 m0 *1 91.54,13.6
X$909 105 299 232 234 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $911 m0 *1 93.84,13.6
X$911 105 233 277 346 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $913 m0 *1 97.98,13.6
X$913 105 300 301 230 105 233 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $916 m0 *1 102.12,13.6
X$916 40 348 210 234 488 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $918 m0 *1 106.72,13.6
X$918 105 211 230 302 279 347 105 360 40 40 sky130_fd_sc_hd__o2111ai_1
* cell instance $926 m0 *1 124.66,13.6
X$926 40 155 235 345 105 282 105 40 sky130_fd_sc_hd__ha_1
* cell instance $927 m0 *1 129.26,13.6
X$927 105 109 235 283 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $930 m0 *1 133.86,13.6
X$930 40 286 236 344 105 492 105 40 sky130_fd_sc_hd__ha_1
* cell instance $935 m0 *1 144.44,13.6
X$935 105 343 105 40 287 40 sky130_fd_sc_hd__inv_1
* cell instance $937 m0 *1 147.66,13.6
X$937 105 339 105 40 341 40 sky130_fd_sc_hd__inv_1
* cell instance $939 m0 *1 152.72,13.6
X$939 40 72 338 237 388 340 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $941 m0 *1 160.54,13.6
X$941 105 338 105 40 285 40 sky130_fd_sc_hd__inv_1
* cell instance $943 m0 *1 165.6,13.6
X$943 105 337 105 40 218 40 sky130_fd_sc_hd__inv_1
* cell instance $946 m0 *1 169.28,13.6
X$946 105 336 105 40 237 40 sky130_fd_sc_hd__inv_1
* cell instance $949 m0 *1 174.8,13.6
X$949 105 334 105 40 284 40 sky130_fd_sc_hd__inv_1
* cell instance $950 m0 *1 176.18,13.6
X$950 105 335 105 40 281 40 sky130_fd_sc_hd__inv_1
* cell instance $953 m0 *1 183.08,13.6
X$953 40 215 117 383 105 333 105 40 sky130_fd_sc_hd__ha_1
* cell instance $960 m0 *1 195.96,13.6
X$960 40 278 275 332 276 625 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $961 m0 *1 203.32,13.6
X$961 40 276 274 330 105 331 105 40 sky130_fd_sc_hd__ha_1
* cell instance $965 m0 *1 216.2,13.6
X$965 105 239 329 181 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $967 m0 *1 218.04,13.6
X$967 105 304 240 159 305 105 239 40 40 sky130_fd_sc_hd__nand4b_1
* cell instance $970 m0 *1 222.64,13.6
X$970 40 305 272 327 105 382 105 40 sky130_fd_sc_hd__ha_1
* cell instance $971 m0 *1 227.24,13.6
X$971 105 241 105 40 271 40 sky130_fd_sc_hd__inv_1
* cell instance $972 m0 *1 228.62,13.6
X$972 40 156 154 306 105 241 105 40 sky130_fd_sc_hd__ha_1
* cell instance $973 m0 *1 233.22,13.6
X$973 105 306 105 40 182 40 sky130_fd_sc_hd__inv_1
* cell instance $976 m0 *1 239.2,13.6
X$976 40 372 269 325 270 326 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $979 m0 *1 247.94,13.6
X$979 105 323 105 40 322 40 sky130_fd_sc_hd__inv_1
* cell instance $984 m0 *1 254.38,13.6
X$984 105 307 105 40 268 40 sky130_fd_sc_hd__inv_1
* cell instance $986 m0 *1 256.68,13.6
X$986 40 267 265 321 266 379 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $987 m0 *1 264.04,13.6
X$987 105 320 105 40 266 40 sky130_fd_sc_hd__inv_1
* cell instance $990 m0 *1 270.94,13.6
X$990 105 318 105 40 264 40 sky130_fd_sc_hd__inv_1
* cell instance $991 m0 *1 272.32,13.6
X$991 40 319 49 150 105 149 105 40 sky130_fd_sc_hd__ha_1
* cell instance $995 m0 *1 278.3,13.6
X$995 40 263 110 592 105 317 105 40 sky130_fd_sc_hd__ha_1
* cell instance $997 m0 *1 283.82,13.6
X$997 40 262 242 378 261 444 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $998 m0 *1 291.18,13.6
X$998 105 316 105 40 261 40 sky130_fd_sc_hd__inv_1
* cell instance $999 m0 *1 292.56,13.6
X$999 40 259 257 242 260 376 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1001 m0 *1 300.38,13.6
X$1001 40 244 256 314 105 243 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1005 m0 *1 308.2,13.6
X$1005 40 190 313 762 255 374 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1008 m0 *1 319.7,13.6
X$1008 40 253 250 313 252 431 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1011 m0 *1 329.36,13.6
X$1011 105 308 249 186 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $1015 m0 *1 333.5,13.6
X$1015 40 246 247 373 105 311 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1016 m0 *1 338.1,13.6
X$1016 105 246 247 309 105 308 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $1025 r0 *1 11.96,13.6
X$1025 105 389 423 105 350 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $1030 r0 *1 15.64,13.6
X$1030 40 294 496 310 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $1031 r0 *1 21.62,13.6
X$1031 105 433 350 393 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $1032 r0 *1 24.84,13.6
X$1032 105 436 191 105 227 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $1033 r0 *1 28.06,13.6
X$1033 40 349 291 353 351 352 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $1034 r0 *1 32.66,13.6
X$1034 105 349 291 351 352 40 381 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $1035 r0 *1 35.88,13.6
X$1035 105 352 447 291 393 105 40 223 40 sky130_fd_sc_hd__o31ai_1
* cell instance $1037 r0 *1 39.56,13.6
X$1037 105 394 293 353 40 355 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $1042 r0 *1 43.24,13.6
X$1042 40 146 222 356 145 105 105 40 sky130_fd_sc_hd__nand3b_4
* cell instance $1043 r0 *1 50.6,13.6
X$1043 40 403 224 258 123 105 105 40 sky130_fd_sc_hd__o21bai_2
* cell instance $1045 r0 *1 55.2,13.6
X$1045 105 295 205 328 459 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $1047 r0 *1 57.5,13.6
X$1047 40 386 461 463 205 295 355 105 105 40 sky130_fd_sc_hd__o41ai_1
* cell instance $1048 r0 *1 60.72,13.6
X$1048 105 123 356 386 357 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $1050 r0 *1 63.02,13.6
X$1050 105 200 356 123 355 40 105 397 40 sky130_fd_sc_hd__a31oi_1
* cell instance $1052 r0 *1 65.78,13.6
X$1052 40 232 355 356 123 397 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $1057 r0 *1 70.84,13.6
X$1057 40 399 357 298 297 503 358 105 105 40 sky130_fd_sc_hd__a2111oi_1
* cell instance $1059 r0 *1 74.98,13.6
X$1059 105 358 357 400 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1061 r0 *1 76.82,13.6
X$1061 105 400 471 406 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1063 r0 *1 78.66,13.6
X$1063 105 211 399 151 401 40 105 40 sky130_fd_sc_hd__and3b_1
* cell instance $1065 r0 *1 82.34,13.6
X$1065 105 231 127 476 478 105 40 40 sky130_fd_sc_hd__or3b_1
* cell instance $1067 r0 *1 86.48,13.6
X$1067 105 299 210 342 105 504 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $1069 r0 *1 88.78,13.6
X$1069 105 405 105 40 299 40 sky130_fd_sc_hd__inv_1
* cell instance $1070 r0 *1 90.16,13.6
X$1070 105 300 230 105 548 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $1071 r0 *1 93.38,13.6
X$1071 40 40 302 105 406 482 105 sky130_fd_sc_hd__nor2_2
* cell instance $1072 r0 *1 95.68,13.6
X$1072 105 230 482 489 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $1077 r0 *1 98.44,13.6
X$1077 105 360 359 361 405 40 105 408 40 sky130_fd_sc_hd__a31oi_1
* cell instance $1078 r0 *1 100.74,13.6
X$1078 105 361 359 486 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1079 r0 *1 102.12,13.6
X$1079 40 359 230 361 302 105 506 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $1093 r0 *1 137.54,13.6
X$1093 40 344 343 487 490 493 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1094 r0 *1 144.9,13.6
X$1094 40 340 490 491 105 627 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1100 r0 *1 153.64,13.6
X$1100 40 366 388 484 105 485 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1102 r0 *1 158.7,13.6
X$1102 105 483 105 40 387 40 sky130_fd_sc_hd__inv_1
* cell instance $1105 r0 *1 164.68,13.6
X$1105 40 165 385 409 105 481 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1106 r0 *1 169.28,13.6
X$1106 40 409 335 640 479 366 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1108 r0 *1 177.1,13.6
X$1108 105 477 105 40 384 40 sky130_fd_sc_hd__inv_1
* cell instance $1117 r0 *1 185.84,13.6
X$1117 105 368 105 40 383 40 sky130_fd_sc_hd__inv_1
* cell instance $1118 r0 *1 187.22,13.6
X$1118 40 368 535 694 472 474 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1121 r0 *1 198.72,13.6
X$1121 105 369 105 40 469 40 sky130_fd_sc_hd__inv_1
* cell instance $1123 r0 *1 201.02,13.6
X$1123 40 470 331 469 105 468 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1134 r0 *1 215.74,13.6
X$1134 40 273 327 785 467 465 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1135 r0 *1 223.1,13.6
X$1135 105 464 105 40 382 40 sky130_fd_sc_hd__inv_1
* cell instance $1137 r0 *1 226.32,13.6
X$1137 40 9549 306 416 105 513 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1147 r0 *1 237.82,13.6
X$1147 40 527 457 856 418 460 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1149 r0 *1 245.64,13.6
X$1149 40 326 380 457 322 456 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1153 r0 *1 256.22,13.6
X$1153 40 203 451 454 453 449 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1159 r0 *1 264.5,13.6
X$1159 40 379 197 451 450 420 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1160 r0 *1 271.86,13.6
X$1160 40 420 445 448 446 421 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1161 r0 *1 279.22,13.6
X$1161 40 196 378 445 443 587 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1168 r0 *1 291.64,13.6
X$1168 40 260 377 440 105 441 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1170 r0 *1 298.08,13.6
X$1170 40 376 375 439 437 765 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1173 r0 *1 310.96,13.6
X$1173 105 434 105 40 374 40 sky130_fd_sc_hd__inv_1
* cell instance $1178 r0 *1 314.18,13.6
X$1178 40 252 106 429 105 432 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1180 r0 *1 319.24,13.6
X$1180 40 428 251 427 105 430 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1181 r0 *1 323.84,13.6
X$1181 40 245 424 428 576 425 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1182 r0 *1 331.2,13.6
X$1182 40 248 373 757 424 574 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1195 m0 *1 9.66,19.04
X$1195 40 423 494 390 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $1196 m0 *1 15.64,19.04
X$1196 105 391 495 310 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1197 m0 *1 17.02,19.04
X$1197 105 391 390 495 352 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $1198 m0 *1 19.32,19.04
X$1198 105 310 496 433 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1199 m0 *1 20.7,19.04
X$1199 40 436 498 525 121 497 288 105 105 40 sky130_fd_sc_hd__a41oi_1
* cell instance $1200 m0 *1 23.92,19.04
X$1200 40 497 498 525 288 105 392 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $1203 m0 *1 29.44,19.04
X$1203 40 40 312 291 288 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $1204 m0 *1 31.74,19.04
X$1204 40 315 296 392 500 531 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $1206 m0 *1 41.4,19.04
X$1206 105 222 291 354 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1207 m0 *1 42.78,19.04
X$1207 105 394 222 291 395 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $1209 m0 *1 45.08,19.04
X$1209 40 452 200 293 254 223 123 105 105 40 sky130_fd_sc_hd__a41oi_1
* cell instance $1210 m0 *1 48.3,19.04
X$1210 105 395 296 356 353 105 328 40 40 sky130_fd_sc_hd__nand4b_1
* cell instance $1211 m0 *1 51.52,19.04
X$1211 105 222 324 396 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1213 m0 *1 53.36,19.04
X$1213 105 381 395 398 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1214 m0 *1 54.74,19.04
X$1214 105 381 395 557 105 461 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $1216 m0 *1 57.04,19.04
X$1216 105 558 200 501 597 536 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $1217 m0 *1 59.8,19.04
X$1217 40 396 126 355 295 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $1218 m0 *1 63.48,19.04
X$1218 105 296 105 40 463 40 sky130_fd_sc_hd__inv_1
* cell instance $1220 m0 *1 65.32,19.04
X$1220 40 296 228 231 123 356 398 105 105 40 sky130_fd_sc_hd__a41oi_4
* cell instance $1222 m0 *1 76.36,19.04
X$1222 105 471 105 40 503 40 sky130_fd_sc_hd__inv_1
* cell instance $1223 m0 *1 77.74,19.04
X$1223 105 151 211 399 475 40 105 40 sky130_fd_sc_hd__nand3b_1
* cell instance $1225 m0 *1 80.96,19.04
X$1225 105 503 404 402 105 476 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $1229 m0 *1 86.02,19.04
X$1229 40 544 547 504 478 403 105 105 40 sky130_fd_sc_hd__or4_4
* cell instance $1230 m0 *1 90.16,19.04
X$1230 105 405 151 105 482 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $1231 m0 *1 93.38,19.04
X$1231 105 302 548 549 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1232 m0 *1 94.76,19.04
X$1232 105 408 210 402 407 105 550 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $1233 m0 *1 97.98,19.04
X$1233 105 210 408 407 402 605 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $1234 m0 *1 100.74,19.04
X$1234 105 551 486 489 40 105 608 40 sky130_fd_sc_hd__a21boi_0
* cell instance $1237 m0 *1 104.88,19.04
X$1237 40 301 505 506 507 302 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $1238 m0 *1 108.56,19.04
X$1238 105 347 279 211 40 505 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $1245 m0 *1 127.42,19.04
X$1245 40 493 545 546 105 619 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1246 m0 *1 132.02,19.04
X$1246 40 546 492 542 105 543 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1253 m0 *1 145.82,19.04
X$1253 40 491 68 628 105 699 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1256 m0 *1 151.8,19.04
X$1256 105 509 105 40 487 40 sky130_fd_sc_hd__inv_1
* cell instance $1257 m0 *1 153.18,19.04
X$1257 40 485 540 637 105 413 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1259 m0 *1 158.24,19.04
X$1259 40 484 481 539 105 639 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1261 m0 *1 163.76,19.04
X$1261 105 538 105 40 537 40 sky130_fd_sc_hd__inv_1
* cell instance $1266 m0 *1 170.2,19.04
X$1266 40 511 479 414 105 480 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1268 m0 *1 175.26,19.04
X$1268 40 480 333 410 105 510 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1269 m0 *1 179.86,19.04
X$1269 40 636 369 659 473 633 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1270 m0 *1 187.22,19.04
X$1270 105 511 105 40 474 40 sky130_fd_sc_hd__inv_1
* cell instance $1273 m0 *1 191.36,19.04
X$1273 105 512 105 40 473 40 sky130_fd_sc_hd__inv_1
* cell instance $1274 m0 *1 192.74,19.04
X$1274 105 535 105 40 534 40 sky130_fd_sc_hd__inv_1
* cell instance $1279 m0 *1 197.34,19.04
X$1279 105 412 105 40 472 40 sky130_fd_sc_hd__inv_1
* cell instance $1281 m0 *1 199.18,19.04
X$1281 40 533 412 413 105 470 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1284 m0 *1 206.54,19.04
X$1284 40 512 415 367 413 414 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1286 m0 *1 214.36,19.04
X$1286 105 532 40 105 416 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $1287 m0 *1 217.58,19.04
X$1287 40 467 466 530 105 415 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1289 m0 *1 222.64,19.04
X$1289 40 513 530 414 105 413 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1291 m0 *1 227.7,19.04
X$1291 105 513 105 40 529 40 sky130_fd_sc_hd__inv_1
* cell instance $1293 m0 *1 230.92,19.04
X$1293 40 528 270 614 462 527 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1294 m0 *1 238.28,19.04
X$1294 40 460 419 607 458 612 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1295 m0 *1 245.64,19.04
X$1295 105 526 105 40 325 40 sky130_fd_sc_hd__inv_1
* cell instance $1299 m0 *1 250.24,19.04
X$1299 40 456 454 419 455 600 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1302 m0 *1 263.12,19.04
X$1302 105 524 105 40 450 40 sky130_fd_sc_hd__inv_1
* cell instance $1303 m0 *1 264.5,19.04
X$1303 40 449 448 515 595 850 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1309 m0 *1 279.22,19.04
X$1309 105 523 105 40 446 40 sky130_fd_sc_hd__inv_1
* cell instance $1310 m0 *1 280.6,19.04
X$1310 105 522 105 40 443 40 sky130_fd_sc_hd__inv_1
* cell instance $1314 m0 *1 287.96,19.04
X$1314 40 444 439 586 442 422 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1315 m0 *1 295.32,19.04
X$1315 40 440 437 581 438 583 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1319 m0 *1 305.44,19.04
X$1319 40 314 255 677 435 521 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1321 m0 *1 313.72,19.04
X$1321 40 429 519 577 675 520 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1322 m0 *1 321.08,19.04
X$1322 40 431 425 519 426 758 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1337 r0 *1 11.96,19.04
X$1337 105 573 552 673 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1338 r0 *1 13.34,19.04
X$1338 105 494 391 389 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1343 r0 *1 16.56,19.04
X$1343 105 578 573 552 40 105 553 40 sky130_fd_sc_hd__a21oi_1
* cell instance $1346 r0 *1 19.78,19.04
X$1346 105 553 121 554 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1348 r0 *1 21.62,19.04
X$1348 105 499 554 580 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1350 r0 *1 23.46,19.04
X$1350 40 525 555 288 497 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $1352 r0 *1 26.22,19.04
X$1352 40 471 555 499 556 580 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $1354 r0 *1 31.28,19.04
X$1354 105 392 105 40 167 40 sky130_fd_sc_hd__inv_1
* cell instance $1356 r0 *1 33.12,19.04
X$1356 40 556 716 647 584 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $1357 r0 *1 39.1,19.04
X$1357 40 588 645 589 584 354 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $1366 r0 *1 53.82,19.04
X$1366 105 593 123 459 40 105 696 40 sky130_fd_sc_hd__a21oi_1
* cell instance $1368 r0 *1 56.58,19.04
X$1368 105 588 536 105 541 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $1369 r0 *1 59.8,19.04
X$1369 105 558 200 597 40 654 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $1371 r0 *1 63.94,19.04
X$1371 105 558 396 355 502 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $1372 r0 *1 65.78,19.04
X$1372 105 558 396 398 557 358 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $1373 r0 *1 68.54,19.04
X$1373 105 559 502 557 402 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $1376 r0 *1 70.84,19.04
X$1376 105 557 502 407 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $1380 r0 *1 76.36,19.04
X$1380 40 405 598 599 728 475 403 105 105 40 sky130_fd_sc_hd__o2111a_1
* cell instance $1382 r0 *1 82.34,19.04
X$1382 105 403 541 599 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $1385 r0 *1 86.02,19.04
X$1385 40 544 601 602 541 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $1387 r0 *1 90.16,19.04
X$1387 40 561 562 549 560 547 105 105 40 sky130_fd_sc_hd__nor4_4
* cell instance $1390 r0 *1 98.44,19.04
X$1390 105 361 604 561 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $1392 r0 *1 101.66,19.04
X$1392 40 608 1040 562 609 105 794 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $1394 r0 *1 106.72,19.04
X$1394 105 611 605 550 40 105 657 40 sky130_fd_sc_hd__a21oi_1
* cell instance $1395 r0 *1 108.56,19.04
X$1395 105 505 506 507 105 488 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $1396 r0 *1 110.4,19.04
X$1396 105 616 551 347 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1403 r0 *1 124.2,19.04
X$1403 105 563 105 40 617 40 sky130_fd_sc_hd__inv_1
* cell instance $1405 r0 *1 126.04,19.04
X$1405 40 705 805 621 545 888 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1406 r0 *1 133.4,19.04
X$1406 40 619 623 629 105 703 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1407 r0 *1 138,19.04
X$1407 105 624 105 40 543 40 sky130_fd_sc_hd__inv_1
* cell instance $1409 r0 *1 143.06,19.04
X$1409 40 627 629 540 105 701 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1410 r0 *1 147.66,19.04
X$1410 105 630 105 40 628 40 sky130_fd_sc_hd__inv_1
* cell instance $1415 r0 *1 153.64,19.04
X$1415 105 634 105 40 564 40 sky130_fd_sc_hd__inv_1
* cell instance $1416 r0 *1 155.02,19.04
X$1416 105 367 40 105 637 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $1417 r0 *1 158.24,19.04
X$1417 40 639 410 642 641 537 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1418 r0 *1 165.6,19.04
X$1418 40 641 565 367 411 414 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1420 r0 *1 174.8,19.04
X$1420 105 638 105 40 640 40 sky130_fd_sc_hd__inv_1
* cell instance $1422 r0 *1 176.64,19.04
X$1422 105 565 105 40 633 40 sky130_fd_sc_hd__inv_1
* cell instance $1424 r0 *1 178.02,19.04
X$1424 105 636 105 40 510 40 sky130_fd_sc_hd__inv_1
* cell instance $1429 r0 *1 181.7,19.04
X$1429 40 477 631 635 632 695 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1430 r0 *1 189.06,19.04
X$1430 40 180 332 631 534 626 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1434 r0 *1 199.64,19.04
X$1434 40 625 620 691 566 690 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1440 r0 *1 209.3,19.04
X$1440 40 566 330 622 105 533 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1442 r0 *1 214.36,19.04
X$1442 40 468 241 411 415 530 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1443 r0 *1 221.72,19.04
X$1443 105 618 105 40 465 40 sky130_fd_sc_hd__inv_1
* cell instance $1444 r0 *1 223.1,19.04
X$1444 40 464 304 685 529 862 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1449 r0 *1 233.68,19.04
X$1449 105 615 105 40 614 40 sky130_fd_sc_hd__inv_1
* cell instance $1454 r0 *1 239.2,19.04
X$1454 105 613 105 40 612 40 sky130_fd_sc_hd__inv_1
* cell instance $1455 r0 *1 240.58,19.04
X$1455 105 567 105 40 418 40 sky130_fd_sc_hd__inv_1
* cell instance $1456 r0 *1 241.96,19.04
X$1456 105 610 105 40 607 40 sky130_fd_sc_hd__inv_1
* cell instance $1459 r0 *1 246.1,19.04
X$1459 105 606 105 40 514 40 sky130_fd_sc_hd__inv_1
* cell instance $1460 r0 *1 247.48,19.04
X$1460 105 603 105 40 458 40 sky130_fd_sc_hd__inv_1
* cell instance $1461 r0 *1 248.86,19.04
X$1461 40 603 744 828 105 684 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1462 r0 *1 253.46,19.04
X$1462 40 600 515 514 568 952 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1464 r0 *1 260.82,19.04
X$1464 105 596 105 40 455 40 sky130_fd_sc_hd__inv_1
* cell instance $1468 r0 *1 264.04,19.04
X$1468 40 453 594 516 773 683 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1469 r0 *1 271.4,19.04
X$1469 105 594 105 40 595 40 sky130_fd_sc_hd__inv_1
* cell instance $1472 r0 *1 275.54,19.04
X$1472 40 771 523 569 105 770 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1474 r0 *1 280.6,19.04
X$1474 105 570 105 40 592 40 sky130_fd_sc_hd__inv_1
* cell instance $1475 r0 *1 281.98,19.04
X$1475 105 591 105 40 516 40 sky130_fd_sc_hd__inv_1
* cell instance $1476 r0 *1 283.36,19.04
X$1476 40 587 586 681 590 848 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1482 r0 *1 293.02,19.04
X$1482 40 521 438 679 105 680 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1484 r0 *1 298.54,19.04
X$1484 105 585 105 40 583 40 sky130_fd_sc_hd__inv_1
* cell instance $1485 r0 *1 299.92,19.04
X$1485 105 582 105 40 581 40 sky130_fd_sc_hd__inv_1
* cell instance $1488 r0 *1 303.6,19.04
X$1488 40 520 435 579 105 1943 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1489 r0 *1 308.2,19.04
X$1489 40 579 432 676 105 458 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1490 r0 *1 312.8,19.04
X$1490 40 517 430 516 105 568 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1492 r0 *1 317.4,19.04
X$1492 105 571 105 40 577 40 sky130_fd_sc_hd__inv_1
* cell instance $1498 r0 *1 326.14,19.04
X$1498 40 576 572 1082 575 934 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1500 r0 *1 334.42,19.04
X$1500 40 574 671 756 572 518 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1536 m0 *1 7.82,24.48
X$1536 40 191 753 644 573 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $1537 m0 *1 10.12,24.48
X$1537 105 670 755 673 40 643 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $1539 m0 *1 15.18,24.48
X$1539 40 573 711 578 552 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $1541 m0 *1 17.94,24.48
X$1541 105 711 105 40 121 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $1542 m0 *1 19.78,24.48
X$1542 105 710 644 497 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1543 m0 *1 21.16,24.48
X$1543 105 644 499 678 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1544 m0 *1 22.54,24.48
X$1544 105 712 589 645 40 105 498 40 sky130_fd_sc_hd__a21oi_1
* cell instance $1545 m0 *1 24.38,24.48
X$1545 105 712 589 645 105 40 647 40 sky130_fd_sc_hd__a21o_2
* cell instance $1546 m0 *1 27.6,24.48
X$1546 105 646 643 767 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1548 m0 *1 29.44,24.48
X$1548 40 499 556 557 646 643 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $1549 m0 *1 37.26,24.48
X$1549 40 556 447 647 584 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $1550 m0 *1 40.94,24.48
X$1550 105 584 648 222 105 40 653 40 sky130_fd_sc_hd__o21ai_1
* cell instance $1552 m0 *1 43.24,24.48
X$1552 105 772 649 719 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1554 m0 *1 45.54,24.48
X$1554 105 714 721 717 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1556 m0 *1 47.38,24.48
X$1556 105 650 651 447 722 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $1557 m0 *1 49.22,24.48
X$1557 105 722 650 651 40 105 652 40 sky130_fd_sc_hd__a21oi_1
* cell instance $1558 m0 *1 51.06,24.48
X$1558 105 723 697 124 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $1559 m0 *1 53.36,24.48
X$1559 105 696 653 105 655 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $1563 m0 *1 59.34,24.48
X$1563 105 697 40 105 597 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $1565 m0 *1 63.02,24.48
X$1565 105 651 714 776 777 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $1566 m0 *1 64.86,24.48
X$1566 40 778 654 656 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $1569 m0 *1 77.28,24.48
X$1569 105 726 656 727 655 40 728 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $1573 m0 *1 84.64,24.48
X$1573 105 599 401 786 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $1574 m0 *1 86.94,24.48
X$1574 105 601 475 602 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1577 m0 *1 90.62,24.48
X$1577 105 786 40 730 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $1578 m0 *1 93.38,24.48
X$1578 105 403 475 601 105 787 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $1581 m0 *1 96.6,24.48
X$1581 40 346 792 657 793 105 2360 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $1584 m0 *1 105.8,24.48
X$1584 105 506 1038 732 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1586 m0 *1 107.64,24.48
X$1586 105 707 505 506 798 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $1589 m0 *1 112.24,24.48
X$1589 105 979 616 105 611 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $1591 m0 *1 117.3,24.48
X$1591 40 891 345 1153 706 658 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1592 m0 *1 124.66,24.48
X$1592 40 658 508 617 803 704 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1593 m0 *1 132.02,24.48
X$1593 40 804 130 1353 806 702 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1598 m0 *1 143.06,24.48
X$1598 40 701 700 414 105 411 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1601 m0 *1 149.04,24.48
X$1601 40 699 539 736 564 808 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1602 m0 *1 156.4,24.48
X$1602 40 634 538 883 737 659 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1608 m0 *1 167.9,24.48
X$1608 40 337 334 801 698 799 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1612 m0 *1 178.48,24.48
X$1612 105 797 105 40 698 40 sky130_fd_sc_hd__inv_1
* cell instance $1615 m0 *1 182.62,24.48
X$1615 40 739 695 642 105 660 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1617 m0 *1 188.14,24.48
X$1617 105 791 105 40 632 40 sky130_fd_sc_hd__inv_1
* cell instance $1620 m0 *1 190.9,24.48
X$1620 105 790 105 40 694 40 sky130_fd_sc_hd__inv_1
* cell instance $1625 m0 *1 195.5,24.48
X$1625 40 626 691 739 692 789 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1627 m0 *1 203.78,24.48
X$1627 40 690 688 740 689 687 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1629 m0 *1 212.06,24.48
X$1629 40 662 867 532 105 661 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1630 m0 *1 216.66,24.48
X$1630 40 532 367 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $1631 m0 *1 220.8,24.48
X$1631 105 662 105 40 784 40 sky130_fd_sc_hd__inv_1
* cell instance $1633 m0 *1 222.64,24.48
X$1633 40 618 685 784 686 861 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1638 m0 *1 238.74,24.48
X$1638 40 613 606 923 1855 828 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1642 m0 *1 250.7,24.48
X$1642 40 779 567 744 663 853 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1644 m0 *1 258.52,24.48
X$1644 40 775 663 664 105 665 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1646 m0 *1 263.58,24.48
X$1646 105 774 105 40 683 40 sky130_fd_sc_hd__inv_1
* cell instance $1648 m0 *1 265.42,24.48
X$1648 105 666 105 40 568 40 sky130_fd_sc_hd__inv_1
* cell instance $1649 m0 *1 266.8,24.48
X$1649 40 666 667 684 105 829 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1652 m0 *1 276,24.48
X$1652 105 771 105 40 682 40 sky130_fd_sc_hd__inv_1
* cell instance $1654 m0 *1 277.84,24.48
X$1654 40 421 681 849 682 943 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1655 m0 *1 285.2,24.48
X$1655 105 768 105 40 442 40 sky130_fd_sc_hd__inv_1
* cell instance $1658 m0 *1 289.34,24.48
X$1658 105 744 105 40 668 40 sky130_fd_sc_hd__inv_1
* cell instance $1659 m0 *1 290.72,24.48
X$1659 40 679 243 668 105 766 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1668 m0 *1 308.66,24.48
X$1668 105 764 105 40 677 40 sky130_fd_sc_hd__inv_1
* cell instance $1669 m0 *1 310.04,24.48
X$1669 105 667 105 40 676 40 sky130_fd_sc_hd__inv_1
* cell instance $1673 m0 *1 314.64,24.48
X$1673 40 669 675 517 105 749 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1676 m0 *1 320.62,24.48
X$1676 105 761 105 40 426 40 sky130_fd_sc_hd__inv_1
* cell instance $1677 m0 *1 322,24.48
X$1677 40 427 575 1085 674 669 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1682 m0 *1 333.04,24.48
X$1682 40 311 754 1234 671 672 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1683 m0 *1 340.4,24.48
X$1683 105 751 750 752 40 105 309 40 sky130_fd_sc_hd__a21o_1
* cell instance $1690 r0 *1 7.36,24.48
X$1690 40 191 810 578 708 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $1691 r0 *1 9.66,24.48
X$1691 40 709 708 753 552 810 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $1698 r0 *1 16.1,24.48
X$1698 105 710 578 760 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1700 r0 *1 17.94,24.48
X$1700 40 713 760 710 811 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $1701 r0 *1 22.08,24.48
X$1701 40 499 650 763 647 713 105 105 40 sky130_fd_sc_hd__nor4_2
* cell instance $1702 r0 *1 26.68,24.48
X$1702 105 715 288 312 646 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $1703 r0 *1 28.52,24.48
X$1703 105 720 651 714 525 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $1705 r0 *1 30.82,24.48
X$1705 105 716 678 767 40 295 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $1706 r0 *1 34.04,24.48
X$1706 40 647 693 709 949 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $1709 r0 *1 39.1,24.48
X$1709 40 723 716 717 648 718 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $1714 r0 *1 43.24,24.48
X$1714 40 725 719 720 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $1717 r0 *1 50.6,24.48
X$1717 105 714 226 721 105 40 724 40 sky130_fd_sc_hd__o21ai_1
* cell instance $1718 r0 *1 52.44,24.48
X$1718 40 723 697 105 558 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $1719 r0 *1 59.8,24.48
X$1719 40 778 725 501 653 724 105 105 40 sky130_fd_sc_hd__and4b_1
* cell instance $1720 r0 *1 63.48,24.48
X$1720 40 729 858 725 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $1726 r0 *1 70.84,24.48
X$1726 105 652 105 40 727 40 sky130_fd_sc_hd__inv_1
* cell instance $1728 r0 *1 72.68,24.48
X$1728 40 726 818 655 656 727 105 105 40 sky130_fd_sc_hd__or4_4
* cell instance $1729 r0 *1 76.82,24.48
X$1729 105 401 599 728 957 40 105 868 40 sky130_fd_sc_hd__and4_1
* cell instance $1730 r0 *1 80.04,24.48
X$1730 105 656 727 817 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $1731 r0 *1 82.34,24.48
X$1731 105 781 817 726 655 105 40 731 40 sky130_fd_sc_hd__o31ai_1
* cell instance $1733 r0 *1 85.56,24.48
X$1733 105 602 729 731 599 40 105 881 40 sky130_fd_sc_hd__and4_1
* cell instance $1735 r0 *1 90.62,24.48
X$1735 105 729 731 787 599 40 105 733 40 sky130_fd_sc_hd__and4_1
* cell instance $1736 r0 *1 93.84,24.48
X$1736 105 781 818 730 731 105 40 821 40 sky130_fd_sc_hd__o31ai_1
* cell instance $1745 r0 *1 99.82,24.48
X$1745 105 616 551 800 912 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $1747 r0 *1 102.12,24.48
X$1747 40 795 793 348 794 798 732 105 105 40 sky130_fd_sc_hd__a2111oi_4
* cell instance $1748 r0 *1 112.24,24.48
X$1748 105 733 800 551 616 40 105 978 40 sky130_fd_sc_hd__and4_1
* cell instance $1751 r0 *1 116.84,24.48
X$1751 40 734 889 890 105 891 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1752 r0 *1 121.44,24.48
X$1752 105 283 889 734 105 802 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $1758 r0 *1 126.04,24.48
X$1758 40 803 706 705 105 886 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1759 r0 *1 130.64,24.48
X$1759 105 804 105 40 704 40 sky130_fd_sc_hd__inv_1
* cell instance $1761 r0 *1 133.86,24.48
X$1761 105 805 105 40 806 40 sky130_fd_sc_hd__inv_1
* cell instance $1765 r0 *1 138.46,24.48
X$1765 40 624 630 1222 885 987 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1766 r0 *1 145.82,24.48
X$1766 40 885 807 659 824 737 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1771 r0 *1 153.64,24.48
X$1771 105 807 105 40 808 40 sky130_fd_sc_hd__inv_1
* cell instance $1773 r0 *1 156.86,24.48
X$1773 105 367 105 40 883 40 sky130_fd_sc_hd__inv_1
* cell instance $1774 r0 *1 158.24,24.48
X$1774 105 367 40 105 882 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $1775 r0 *1 161.46,24.48
X$1775 40 801 877 878 105 880 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1777 r0 *1 169.74,24.48
X$1777 40 635 799 736 105 876 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1779 r0 *1 175.26,24.48
X$1779 40 876 873 874 105 875 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1787 r0 *1 182.62,24.48
X$1787 40 638 791 738 871 1123 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1788 r0 *1 189.98,24.48
X$1788 105 796 105 40 738 40 sky130_fd_sc_hd__inv_1
* cell instance $1792 r0 *1 194.58,24.48
X$1792 40 740 789 971 105 869 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1802 r0 *1 212.98,24.48
X$1802 40 788 785 968 866 867 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1805 r0 *1 222.64,24.48
X$1805 105 783 105 40 686 40 sky130_fd_sc_hd__inv_1
* cell instance $1814 r0 *1 236.44,24.48
X$1814 105 782 105 40 857 40 sky130_fd_sc_hd__inv_1
* cell instance $1816 r0 *1 241.5,24.48
X$1816 105 780 105 40 766 40 sky130_fd_sc_hd__inv_1
* cell instance $1819 r0 *1 245.64,24.48
X$1819 40 615 854 779 105 741 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1820 r0 *1 250.24,24.48
X$1820 40 323 852 742 105 743 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1822 r0 *1 255.76,24.48
X$1822 40 742 596 667 851 775 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1828 r0 *1 264.04,24.48
X$1828 40 774 851 745 105 741 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1829 r0 *1 268.64,24.48
X$1829 105 746 105 40 773 40 sky130_fd_sc_hd__inv_1
* cell instance $1831 r0 *1 273.7,24.48
X$1831 40 770 746 665 105 743 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1832 r0 *1 278.3,24.48
X$1832 105 769 105 40 747 40 sky130_fd_sc_hd__inv_1
* cell instance $1833 r0 *1 279.68,24.48
X$1833 40 769 591 664 105 829 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1834 r0 *1 284.28,24.48
X$1834 40 9565 569 664 105 745 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1844 r0 *1 294.86,24.48
X$1844 105 748 105 40 590 40 sky130_fd_sc_hd__inv_1
* cell instance $1845 r0 *1 296.24,24.48
X$1845 40 939 748 741 105 846 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1848 r0 *1 303.14,24.48
X$1848 40 765 762 845 843 842 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1851 r0 *1 312.8,24.48
X$1851 105 569 105 40 831 40 sky130_fd_sc_hd__inv_1
* cell instance $1855 r0 *1 314.18,24.48
X$1855 40 840 839 831 105 747 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1860 r0 *1 322.46,24.48
X$1860 105 759 105 40 758 40 sky130_fd_sc_hd__inv_1
* cell instance $1865 r0 *1 330.74,24.48
X$1865 40 756 757 836 105 839 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1867 r0 *1 337.18,24.48
X$1867 40 751 752 835 105 754 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1871 r0 *1 341.78,24.48
X$1871 40 9564 832 929 105 834 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1877 m0 *1 4.14,29.92
X$1877 105 991 892 644 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $1880 m0 *1 9.66,29.92
X$1880 105 168 290 708 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $1881 m0 *1 11.96,29.92
X$1881 105 394 809 755 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $1883 m0 *1 14.26,29.92
X$1883 40 895 712 292 670 809 351 105 105 40 sky130_fd_sc_hd__o2111ai_2
* cell instance $1884 m0 *1 19.78,29.92
X$1884 105 811 812 813 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $1886 m0 *1 23.92,29.92
X$1886 40 814 812 897 896 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $1890 m0 *1 29.44,29.92
X$1890 105 650 813 763 105 40 648 40 sky130_fd_sc_hd__o21ai_1
* cell instance $1891 m0 *1 31.28,29.92
X$1891 40 556 709 1047 105 105 40 sky130_fd_sc_hd__nand2b_2
* cell instance $1892 m0 *1 34.5,29.92
X$1892 105 645 589 816 815 40 718 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $1893 m0 *1 37.26,29.92
X$1893 105 650 814 40 105 584 40 sky130_fd_sc_hd__or2_4
* cell instance $1894 m0 *1 40.48,29.92
X$1894 105 949 814 650 709 40 500 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $1895 m0 *1 42.78,29.92
X$1895 105 719 720 105 816 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $1896 m0 *1 46,29.92
X$1896 105 651 650 721 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $1897 m0 *1 49.22,29.92
X$1897 105 693 40 222 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $1899 m0 *1 52.9,29.92
X$1899 105 697 725 724 778 105 593 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $1904 m0 *1 57.5,29.92
X$1904 105 777 816 898 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $1905 m0 *1 60.72,29.92
X$1905 105 654 105 40 859 40 sky130_fd_sc_hd__inv_1
* cell instance $1906 m0 *1 62.1,29.92
X$1906 40 858 859 778 724 777 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $1907 m0 *1 66.7,29.92
X$1907 105 898 714 726 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $1908 m0 *1 69,29.92
X$1908 105 778 654 865 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $1910 m0 *1 71.76,29.92
X$1910 105 956 899 906 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $1912 m0 *1 73.6,29.92
X$1912 105 865 727 819 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $1913 m0 *1 76.82,29.92
X$1913 105 957 40 105 598 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $1914 m0 *1 80.04,29.92
X$1914 40 868 1004 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $1916 m0 *1 84.64,29.92
X$1916 40 800 907 906 707 781 656 105 105 40 sky130_fd_sc_hd__a2111oi_2
* cell instance $1917 m0 *1 90.16,29.92
X$1917 105 908 1059 819 40 105 964 40 sky130_fd_sc_hd__a21o_1
* cell instance $1919 m0 *1 93.84,29.92
X$1919 105 965 729 105 820 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $1923 m0 *1 100.28,29.92
X$1923 105 912 821 361 820 40 974 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $1925 m0 *1 103.04,29.92
X$1925 40 609 821 914 912 913 820 105 105 40 sky130_fd_sc_hd__o41ai_1
* cell instance $1927 m0 *1 107.18,29.92
X$1927 105 733 976 800 975 105 279 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $1928 m0 *1 109.48,29.92
X$1928 40 1037 507 915 978 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $1932 m0 *1 119.6,29.92
X$1932 40 1281 984 1128 982 887 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1933 m0 *1 126.96,29.92
X$1933 105 984 105 40 888 40 sky130_fd_sc_hd__inv_1
* cell instance $1934 m0 *1 128.34,29.92
X$1934 105 623 105 40 887 40 sky130_fd_sc_hd__inv_1
* cell instance $1936 m0 *1 133.4,29.92
X$1936 105 822 105 40 621 40 sky130_fd_sc_hd__inv_1
* cell instance $1937 m0 *1 134.78,29.92
X$1937 40 703 986 700 105 823 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1942 m0 *1 147.66,29.92
X$1942 105 990 40 105 659 40 sky130_fd_sc_hd__inv_4
* cell instance $1945 m0 *1 154.1,29.92
X$1945 40 339 483 988 879 877 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1947 m0 *1 163.3,29.92
X$1947 105 985 105 40 879 40 sky130_fd_sc_hd__inv_1
* cell instance $1953 m0 *1 172.96,29.92
X$1953 40 336 797 825 872 980 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1954 m0 *1 180.32,29.92
X$1954 105 873 105 40 825 40 sky130_fd_sc_hd__inv_1
* cell instance $1958 m0 *1 186.76,29.92
X$1958 40 660 796 972 105 973 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1967 m0 *1 207,29.92
X$1967 40 689 622 970 105 864 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1970 m0 *1 215.74,29.92
X$1970 105 967 966 413 40 105 329 40 sky130_fd_sc_hd__a21oi_1
* cell instance $1971 m0 *1 217.58,29.92
X$1971 40 866 103 1108 105 863 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1974 m0 *1 224.48,29.92
X$1974 105 961 105 40 862 40 sky130_fd_sc_hd__inv_1
* cell instance $1975 m0 *1 225.86,29.92
X$1975 105 960 105 40 861 40 sky130_fd_sc_hd__inv_1
* cell instance $1976 m0 *1 227.24,29.92
X$1976 40 1652 462 959 860 826 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1977 m0 *1 234.6,29.92
X$1977 40 826 856 1102 766 857 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1978 m0 *1 241.96,29.92
X$1978 40 780 955 923 105 828 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1980 m0 *1 248.4,29.92
X$1980 105 827 105 40 828 40 sky130_fd_sc_hd__inv_1
* cell instance $1985 m0 *1 256.22,29.92
X$1985 40 853 951 829 105 745 105 40 sky130_fd_sc_hd__ha_1
* cell instance $1990 m0 *1 269.56,29.92
X$1990 40 850 849 950 747 947 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1997 m0 *1 287.96,29.92
X$1997 40 848 830 942 847 1095 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $1998 m0 *1 295.32,29.92
X$1998 105 939 105 40 847 40 sky130_fd_sc_hd__inv_1
* cell instance $2000 m0 *1 297.62,29.92
X$2000 40 422 845 830 844 940 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2002 m0 *1 305.44,29.92
X$2002 105 938 105 40 844 40 sky130_fd_sc_hd__inv_1
* cell instance $2005 m0 *1 309.12,29.92
X$2005 105 928 105 40 842 40 sky130_fd_sc_hd__inv_1
* cell instance $2006 m0 *1 310.5,29.92
X$2006 40 434 761 937 841 1088 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2010 m0 *1 321.08,29.92
X$2010 40 838 674 840 105 2295 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2013 m0 *1 331.2,29.92
X$2013 105 933 105 40 837 40 sky130_fd_sc_hd__inv_1
* cell instance $2015 m0 *1 333.04,29.92
X$2015 40 932 836 837 105 838 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2018 m0 *1 340.4,29.92
X$2018 40 835 930 832 833 1073 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2022 r0 *1 5.06,29.92
X$2022 105 991 892 105 578 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $2023 r0 *1 8.28,29.92
X$2023 40 394 894 893 349 895 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $2025 r0 *1 13.34,29.92
X$2025 105 995 993 894 552 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $2030 r0 *1 15.64,29.92
X$2030 40 995 993 894 895 351 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $2031 r0 *1 20.24,29.92
X$2031 105 772 649 720 811 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $2032 r0 *1 22.08,29.92
X$2032 105 993 894 996 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2033 r0 *1 23.46,29.92
X$2033 105 897 896 763 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2034 r0 *1 24.84,29.92
X$2034 40 649 996 772 714 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $2036 r0 *1 31.28,29.92
X$2036 105 946 997 1047 290 105 40 948 40 sky130_fd_sc_hd__o31ai_1
* cell instance $2037 r0 *1 34.04,29.92
X$2037 40 1028 1046 949 651 998 105 105 40 sky130_fd_sc_hd__and4b_1
* cell instance $2038 r0 *1 37.72,29.92
X$2038 40 40 1029 105 650 814 105 sky130_fd_sc_hd__nor2_2
* cell instance $2039 r0 *1 40.02,29.92
X$2039 105 946 997 1030 1048 999 105 40 40 sky130_fd_sc_hd__or4_1
* cell instance $2044 r0 *1 43.24,29.92
X$2044 105 1145 447 1032 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2045 r0 *1 44.62,29.92
X$2045 40 999 650 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $2047 r0 *1 49.22,29.92
X$2047 40 1182 815 778 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $2048 r0 *1 59.34,29.92
X$2048 105 288 226 776 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2051 r0 *1 64.86,29.92
X$2051 105 651 865 776 40 105 1001 40 sky130_fd_sc_hd__a21oi_1
* cell instance $2053 r0 *1 67.16,29.92
X$2053 105 1001 714 105 909 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $2059 r0 *1 71.3,29.92
X$2059 105 903 900 604 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2060 r0 *1 72.68,29.92
X$2060 105 781 656 1004 907 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $2061 r0 *1 74.52,29.92
X$2061 105 901 1271 902 40 105 900 40 sky130_fd_sc_hd__a21oi_1
* cell instance $2062 r0 *1 76.36,29.92
X$2062 105 903 1002 1039 105 40 969 40 sky130_fd_sc_hd__o21ai_1
* cell instance $2063 r0 *1 78.2,29.92
X$2063 105 1217 958 904 40 105 1003 40 sky130_fd_sc_hd__a21oi_1
* cell instance $2064 r0 *1 80.04,29.92
X$2064 105 905 1057 870 1041 40 903 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $2065 r0 *1 82.34,29.92
X$2065 105 1004 40 105 905 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2066 r0 *1 85.56,29.92
X$2066 105 781 907 656 105 884 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $2067 r0 *1 88.78,29.92
X$2067 105 1196 910 909 40 105 908 40 sky130_fd_sc_hd__a21o_1
* cell instance $2068 r0 *1 91.54,29.92
X$2068 105 781 817 1004 909 965 105 40 40 sky130_fd_sc_hd__or4_1
* cell instance $2070 r0 *1 94.76,29.92
X$2070 105 964 969 1005 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2074 r0 *1 96.14,29.92
X$2074 105 781 817 910 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2077 r0 *1 98.44,29.92
X$2077 105 361 1005 884 911 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $2078 r0 *1 100.28,29.92
X$2078 105 604 361 914 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $2080 r0 *1 103.04,29.92
X$2080 105 820 911 707 913 105 1040 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $2082 r0 *1 106.26,29.92
X$2082 105 914 916 974 40 105 1038 40 sky130_fd_sc_hd__a21oi_1
* cell instance $2084 r0 *1 108.56,29.92
X$2084 105 915 1037 916 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2085 r0 *1 110.86,29.92
X$2085 105 505 506 916 1006 979 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $2093 r0 *1 123.28,29.92
X$2093 105 983 105 40 982 40 sky130_fd_sc_hd__inv_1
* cell instance $2096 r0 *1 126.04,29.92
X$2096 40 983 886 1519 105 1036 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2099 r0 *1 132.94,29.92
X$2099 105 917 105 40 1035 40 sky130_fd_sc_hd__inv_1
* cell instance $2100 r0 *1 134.32,29.92
X$2100 40 917 987 659 1007 824 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2102 r0 *1 142.14,29.92
X$2102 40 702 303 1277 918 1194 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2103 r0 *1 149.5,29.92
X$2103 105 990 40 105 971 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2110 r0 *1 155.48,29.92
X$2110 105 989 105 40 988 40 sky130_fd_sc_hd__inv_1
* cell instance $2114 r0 *1 162.84,29.92
X$2114 40 509 985 920 1034 1131 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2115 r0 *1 170.2,29.92
X$2115 40 878 1009 1033 105 1127 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2116 r0 *1 174.8,29.92
X$2116 105 1009 105 40 920 40 sky130_fd_sc_hd__inv_1
* cell instance $2118 r0 *1 177.1,29.92
X$2118 105 981 105 40 980 40 sky130_fd_sc_hd__inv_1
* cell instance $2122 r0 *1 178.48,29.92
X$2122 105 977 105 40 874 40 sky130_fd_sc_hd__inv_1
* cell instance $2127 r0 *1 185.84,29.92
X$2127 40 869 973 1010 105 1189 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2128 r0 *1 190.44,29.92
X$2128 40 972 875 1031 105 661 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2130 r0 *1 195.5,29.92
X$2130 40 692 790 1119 105 1011 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2132 r0 *1 203.78,29.92
X$2132 40 970 1011 1027 105 1114 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2138 r0 *1 209.3,29.92
X$2138 40 968 687 411 105 1026 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2140 r0 *1 214.36,29.92
X$2140 40 966 967 963 105 1025 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2142 r0 *1 219.42,29.92
X$2142 40 963 961 962 105 1024 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2144 r0 *1 224.48,29.92
X$2144 40 1024 960 1010 105 414 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2147 r0 *1 230.46,29.92
X$2147 105 921 105 40 860 40 sky130_fd_sc_hd__inv_1
* cell instance $2154 r0 *1 236.44,29.92
X$2154 40 782 610 924 1023 923 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2157 r0 *1 245.18,29.92
X$2157 105 955 105 40 1012 40 sky130_fd_sc_hd__inv_1
* cell instance $2160 r0 *1 247.94,29.92
X$2160 105 951 105 40 954 40 sky130_fd_sc_hd__inv_1
* cell instance $2161 r0 *1 249.32,29.92
X$2161 105 953 105 40 1022 40 sky130_fd_sc_hd__inv_1
* cell instance $2164 r0 *1 253.46,29.92
X$2164 105 925 105 40 684 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $2165 r0 *1 256.22,29.92
X$2165 40 952 950 827 1021 925 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2174 r0 *1 270.94,29.92
X$2174 105 926 105 40 947 40 sky130_fd_sc_hd__inv_1
* cell instance $2175 r0 *1 272.32,29.92
X$2175 40 926 945 684 1780 829 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2177 r0 *1 280.6,29.92
X$2177 105 945 105 40 927 40 sky130_fd_sc_hd__inv_1
* cell instance $2178 r0 *1 281.98,29.92
X$2178 105 944 105 40 1020 40 sky130_fd_sc_hd__inv_1
* cell instance $2180 r0 *1 283.82,29.92
X$2180 40 943 942 927 1017 1020 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2185 r0 *1 291.64,29.92
X$2185 105 941 105 40 1018 40 sky130_fd_sc_hd__inv_1
* cell instance $2186 r0 *1 293.02,29.92
X$2186 40 941 846 745 105 665 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2190 r0 *1 300.84,29.92
X$2190 40 940 1090 1093 1091 1399 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2192 r0 *1 308.66,29.92
X$2192 40 937 928 1089 105 1172 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2200 r0 *1 319.7,29.92
X$2200 40 759 935 936 1016 1237 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2202 r0 *1 327.98,29.92
X$2202 105 935 105 40 934 40 sky130_fd_sc_hd__inv_1
* cell instance $2203 r0 *1 329.36,29.92
X$2203 40 518 1077 932 1015 1080 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2204 r0 *1 336.72,29.92
X$2204 40 9550 929 931 105 1014 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2208 r0 *1 341.32,29.92
X$2208 40 1014 834 745 105 1013 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2214 m0 *1 3.22,35.36
X$2214 105 1042 1043 992 105 893 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $2215 m0 *1 5.06,35.36
X$2215 105 993 994 992 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $2216 m0 *1 7.36,35.36
X$2216 105 1074 1076 1079 105 1043 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $2217 m0 *1 10.12,35.36
X$2217 40 809 1042 992 1044 1043 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $2218 m0 *1 14.72,35.36
X$2218 105 994 105 40 995 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $2219 m0 *1 17.48,35.36
X$2219 40 995 496 772 649 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $2220 m0 *1 21.16,35.36
X$2220 105 993 720 1045 896 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $2222 m0 *1 23.46,35.36
X$2222 105 1139 896 897 812 40 105 312 40 sky130_fd_sc_hd__and4_1
* cell instance $2228 m0 *1 30.82,35.36
X$2228 105 651 1028 1046 998 105 1047 40 40 sky130_fd_sc_hd__nand4b_1
* cell instance $2230 m0 *1 34.5,35.36
X$2230 40 1030 288 946 997 1048 105 105 40 sky130_fd_sc_hd__nor4_4
* cell instance $2232 m0 *1 43.24,35.36
X$2232 105 1253 1029 222 40 105 1049 40 sky130_fd_sc_hd__a21oi_1
* cell instance $2234 m0 *1 46,35.36
X$2234 40 1049 697 1100 1050 1048 105 105 40 sky130_fd_sc_hd__and4bb_4
* cell instance $2235 m0 *1 51.98,35.36
X$2235 40 222 226 1029 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $2238 m0 *1 57.04,35.36
X$2238 105 1052 1051 1185 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2241 m0 *1 62.56,35.36
X$2241 105 1211 956 1053 1000 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $2242 m0 *1 64.4,35.36
X$2242 105 1050 956 1054 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2243 m0 *1 66.7,35.36
X$2243 105 1055 1053 105 1056 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $2244 m0 *1 69.92,35.36
X$2244 40 899 1105 1103 1054 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $2245 m0 *1 72.22,35.36
X$2245 105 1000 956 1056 40 105 560 40 sky130_fd_sc_hd__a21oi_1
* cell instance $2247 m0 *1 74.98,35.36
X$2247 40 616 1112 1050 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $2248 m0 *1 80.96,35.36
X$2248 105 1041 1115 1118 40 105 1039 40 sky130_fd_sc_hd__a21boi_0
* cell instance $2251 m0 *1 84.64,35.36
X$2251 40 40 1295 1057 1149 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $2252 m0 *1 86.94,35.36
X$2252 40 551 819 1058 908 1059 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $2253 m0 *1 91.54,35.36
X$2253 105 1200 909 910 1059 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $2255 m0 *1 93.84,35.36
X$2255 40 884 881 359 969 964 105 105 40 sky130_fd_sc_hd__and4bb_1
* cell instance $2257 m0 *1 99.36,35.36
X$2257 105 1005 729 361 884 105 1202 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $2260 m0 *1 107.18,35.36
X$2260 105 707 913 1205 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2261 m0 *1 108.56,35.36
X$2261 105 915 1037 913 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2269 m0 *1 122.82,35.36
X$2269 105 1129 105 40 1128 40 sky130_fd_sc_hd__inv_1
* cell instance $2270 m0 *1 124.2,35.36
X$2270 40 1129 1437 986 105 1132 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2271 m0 *1 128.8,35.36
X$2271 40 1036 542 1061 1035 1060 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2272 m0 *1 136.16,35.36
X$2272 105 1134 105 40 1060 40 sky130_fd_sc_hd__inv_1
* cell instance $2275 m0 *1 139.84,35.36
X$2275 40 823 1198 882 105 990 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2277 m0 *1 144.9,35.36
X$2277 105 882 40 105 1137 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2279 m0 *1 151.8,35.36
X$2279 40 822 918 1062 1008 1193 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2280 m0 *1 159.16,35.36
X$2280 105 1136 105 40 1062 40 sky130_fd_sc_hd__inv_1
* cell instance $2281 m0 *1 160.54,35.36
X$2281 105 1063 105 40 1135 40 sky130_fd_sc_hd__inv_1
* cell instance $2282 m0 *1 161.92,35.36
X$2282 40 880 1063 1010 105 1133 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2286 m0 *1 168.36,35.36
X$2286 105 1130 105 40 1131 40 sky130_fd_sc_hd__inv_1
* cell instance $2287 m0 *1 169.74,35.36
X$2287 105 1064 105 40 1034 40 sky130_fd_sc_hd__inv_1
* cell instance $2289 m0 *1 172.04,35.36
X$2289 105 1126 105 40 1127 40 sky130_fd_sc_hd__inv_1
* cell instance $2292 m0 *1 177.56,35.36
X$2292 40 981 1064 1125 105 1124 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2295 m0 *1 186.76,35.36
X$2295 105 1065 105 40 1123 40 sky130_fd_sc_hd__inv_1
* cell instance $2297 m0 *1 188.6,35.36
X$2297 105 1066 105 40 872 40 sky130_fd_sc_hd__inv_1
* cell instance $2298 m0 *1 189.98,35.36
X$2298 40 1065 1066 1121 105 1122 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2300 m0 *1 195.04,35.36
X$2300 105 1120 105 40 1031 40 sky130_fd_sc_hd__inv_1
* cell instance $2301 m0 *1 196.42,35.36
X$2301 105 1067 105 40 871 40 sky130_fd_sc_hd__inv_1
* cell instance $2302 m0 *1 197.8,35.36
X$2302 40 1119 1067 1116 105 1117 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2306 m0 *1 205.62,35.36
X$2306 105 1113 105 40 1114 40 sky130_fd_sc_hd__inv_1
* cell instance $2310 m0 *1 216.2,35.36
X$2310 105 1111 105 40 1110 40 sky130_fd_sc_hd__inv_1
* cell instance $2311 m0 *1 217.58,35.36
X$2311 40 1108 864 1110 105 1109 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2316 m0 *1 229.08,35.36
X$2316 40 1183 1102 1107 1106 1104 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2317 m0 *1 236.44,35.36
X$2317 105 1101 105 40 922 40 sky130_fd_sc_hd__inv_1
* cell instance $2318 m0 *1 237.82,35.36
X$2318 40 1101 1068 924 105 923 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2319 m0 *1 242.42,35.36
X$2319 40 1180 921 1012 954 1022 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2321 m0 *1 250.24,35.36
X$2321 40 953 1176 684 105 664 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2324 m0 *1 262.2,35.36
X$2324 105 1068 105 40 1070 40 sky130_fd_sc_hd__inv_1
* cell instance $2325 m0 *1 263.58,35.36
X$2325 105 1069 105 40 1099 40 sky130_fd_sc_hd__inv_1
* cell instance $2329 m0 *1 268.18,35.36
X$2329 40 1098 317 1070 105 1099 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2330 m0 *1 272.78,35.36
X$2330 40 1097 441 1012 105 922 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2333 m0 *1 281.52,35.36
X$2333 40 944 1096 664 1019 829 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2335 m0 *1 290.72,35.36
X$2335 105 1096 105 40 1094 40 sky130_fd_sc_hd__inv_1
* cell instance $2336 m0 *1 292.1,35.36
X$2336 40 1095 1093 1094 1018 1173 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2339 m0 *1 303.6,35.36
X$2339 105 1092 105 40 1091 40 sky130_fd_sc_hd__inv_1
* cell instance $2341 m0 *1 305.44,35.36
X$2341 40 1092 938 743 105 1071 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2342 m0 *1 310.04,35.36
X$2342 105 1090 105 40 1089 40 sky130_fd_sc_hd__inv_1
* cell instance $2345 m0 *1 315.56,35.36
X$2345 40 936 1088 1087 105 1168 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2347 m0 *1 323.84,35.36
X$2347 105 1086 105 40 1085 40 sky130_fd_sc_hd__inv_1
* cell instance $2349 m0 *1 325.68,35.36
X$2349 105 1084 105 40 1082 40 sky130_fd_sc_hd__inv_1
* cell instance $2350 m0 *1 327.06,35.36
X$2350 105 1083 40 105 1080 40 sky130_fd_sc_hd__inv_2
* cell instance $2353 m0 *1 331.2,35.36
X$2353 105 1081 105 40 1015 40 sky130_fd_sc_hd__inv_1
* cell instance $2356 m0 *1 333.5,35.36
X$2356 40 672 1073 1077 1075 1078 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2357 m0 *1 340.86,35.36
X$2357 40 1165 1072 745 931 1013 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2359 r0 *1 1.38,35.36
X$2359 40 1359 2021 168 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $2361 r0 *1 12.42,35.36
X$2361 105 1140 40 772 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $2364 r0 *1 15.64,35.36
X$2364 105 1045 1044 1138 105 40 651 40 sky130_fd_sc_hd__a21o_2
* cell instance $2366 r0 *1 19.78,35.36
X$2366 105 772 1523 1139 40 589 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $2367 r0 *1 23,35.36
X$2367 105 1140 1139 649 1174 40 105 645 40 sky130_fd_sc_hd__or4b_2
* cell instance $2368 r0 *1 26.68,35.36
X$2368 105 1246 1141 1142 40 105 40 sky130_fd_sc_hd__and2b_1
* cell instance $2369 r0 *1 29.44,35.36
X$2369 105 772 1143 1142 40 105 1046 40 sky130_fd_sc_hd__a21o_1
* cell instance $2370 r0 *1 32.2,35.36
X$2370 105 1140 1142 1143 105 1048 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $2371 r0 *1 35.42,35.36
X$2371 40 997 1451 1287 1144 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $2373 r0 *1 40.02,35.36
X$2373 105 1177 1179 1178 946 40 1253 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $2376 r0 *1 43.24,35.36
X$2376 105 1030 1048 1144 105 1179 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $2377 r0 *1 45.08,35.36
X$2377 105 1046 1050 1211 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2378 r0 *1 47.38,35.36
X$2378 105 1288 1046 1145 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2379 r0 *1 48.76,35.36
X$2379 40 1145 1182 1051 1146 1029 222 105 105 40 sky130_fd_sc_hd__a2111oi_4
* cell instance $2381 r0 *1 59.34,35.36
X$2381 105 558 200 1413 40 956 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $2382 r0 *1 62.56,35.36
X$2382 105 1053 1147 1051 1054 40 1002 105 40 sky130_fd_sc_hd__nor4b_1
* cell instance $2384 r0 *1 66.7,35.36
X$2384 105 1187 1105 1267 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $2386 r0 *1 69,35.36
X$2386 105 956 105 40 1191 40 sky130_fd_sc_hd__inv_1
* cell instance $2388 r0 *1 70.84,35.36
X$2388 105 1041 1050 1103 902 105 1055 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $2390 r0 *1 73.6,35.36
X$2390 40 1112 1118 1041 1148 1191 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $2391 r0 *1 78.2,35.36
X$2391 105 904 105 40 1274 40 sky130_fd_sc_hd__inv_1
* cell instance $2392 r0 *1 79.58,35.36
X$2392 105 1148 40 105 1271 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2393 r0 *1 82.8,35.36
X$2393 105 1149 958 599 401 105 1273 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $2394 r0 *1 86.02,35.36
X$2394 105 1195 40 105 1216 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2395 r0 *1 89.24,35.36
X$2395 105 1199 40 105 1196 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2396 r0 *1 92.46,35.36
X$2396 40 1199 1200 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $2401 r0 *1 99.82,35.36
X$2401 105 707 901 1006 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2403 r0 *1 101.66,35.36
X$2403 105 1150 1203 1202 884 105 1204 40 40 sky130_fd_sc_hd__nand4b_1
* cell instance $2405 r0 *1 105.8,35.36
X$2405 40 795 1151 1205 1204 1152 1206 105 105 40 sky130_fd_sc_hd__o32a_1
* cell instance $2406 r0 *1 109.48,35.36
X$2406 105 505 506 40 105 1152 40 sky130_fd_sc_hd__or2_4
* cell instance $2409 r0 *1 117.3,35.36
X$2409 40 1357 1280 1355 1281 1201 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2417 r0 *1 132.94,35.36
X$2417 40 1132 1278 1198 105 1279 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2422 r0 *1 144.44,35.36
X$2422 105 1197 105 40 1277 40 sky130_fd_sc_hd__inv_1
* cell instance $2423 r0 *1 145.82,35.36
X$2423 40 1194 989 1276 1275 1135 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2428 r0 *1 155.94,35.36
X$2428 105 1192 105 40 1193 40 sky130_fd_sc_hd__inv_1
* cell instance $2431 r0 *1 164.68,35.36
X$2431 105 1154 105 40 1008 40 sky130_fd_sc_hd__inv_1
* cell instance $2434 r0 *1 168.82,35.36
X$2434 40 1130 1154 1155 105 1269 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2435 r0 *1 173.42,35.36
X$2435 40 1126 977 1343 1268 1156 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2441 r0 *1 187.68,35.36
X$2441 105 1188 105 40 1189 40 sky130_fd_sc_hd__inv_1
* cell instance $2443 r0 *1 189.52,35.36
X$2443 105 1190 105 40 1266 40 sky130_fd_sc_hd__inv_1
* cell instance $2446 r0 *1 193.66,35.36
X$2446 40 1122 1116 1341 1262 1264 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2449 r0 *1 202.4,35.36
X$2449 40 661 1158 1157 105 1010 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2451 r0 *1 207,35.36
X$2451 105 1158 105 40 1156 40 sky130_fd_sc_hd__inv_1
* cell instance $2454 r0 *1 209.3,35.36
X$2454 40 1113 1111 1156 1260 1337 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2455 r0 *1 216.66,35.36
X$2455 105 1186 105 40 1260 40 sky130_fd_sc_hd__inv_1
* cell instance $2456 r0 *1 218.04,35.36
X$2456 40 783 863 1184 105 1259 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2459 r0 *1 227.24,35.36
X$2459 40 1258 959 1159 922 1183 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2461 r0 *1 234.6,35.36
X$2461 105 1107 105 40 1161 40 sky130_fd_sc_hd__inv_1
* cell instance $2465 r0 *1 237.82,35.36
X$2465 105 1181 105 40 1159 40 sky130_fd_sc_hd__inv_1
* cell instance $2466 r0 *1 239.2,35.36
X$2466 105 1104 105 40 924 40 sky130_fd_sc_hd__inv_1
* cell instance $2469 r0 *1 245.18,35.36
X$2469 40 1069 1162 1161 105 924 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2470 r0 *1 249.78,35.36
X$2470 105 1176 1068 1254 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2473 r0 *1 255.3,35.36
X$2473 105 1162 105 40 1175 40 sky130_fd_sc_hd__inv_1
* cell instance $2474 r0 *1 256.68,35.36
X$2474 40 1250 66 1229 105 1175 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2482 r0 *1 270.02,35.36
X$2482 40 201 318 1412 1248 1249 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2483 r0 *1 277.38,35.36
X$2483 105 1098 105 40 1247 40 sky130_fd_sc_hd__inv_1
* cell instance $2484 r0 *1 278.76,35.36
X$2484 105 1097 105 40 1243 40 sky130_fd_sc_hd__inv_1
* cell instance $2491 r0 *1 292.56,35.36
X$2491 105 1163 105 40 1173 40 sky130_fd_sc_hd__inv_1
* cell instance $2492 r0 *1 293.94,35.36
X$2492 40 1163 1242 1793 664 745 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2497 r0 *1 310.04,35.36
X$2497 105 1171 105 40 1172 40 sky130_fd_sc_hd__inv_1
* cell instance $2499 r0 *1 311.88,35.36
X$2499 40 1016 571 1169 105 1241 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2501 r0 *1 316.48,35.36
X$2501 105 1170 105 40 1168 40 sky130_fd_sc_hd__inv_1
* cell instance $2505 r0 *1 321.08,35.36
X$2505 40 1083 1167 1084 1166 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $2506 r0 *1 330.28,35.36
X$2506 40 1236 741 1071 665 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $2542 m0 *1 2.3,40.8
X$2542 105 1317 1282 670 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2543 m0 *1 5.52,40.8
X$2543 105 1282 1079 1076 991 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $2544 m0 *1 7.36,40.8
X$2544 40 1042 1140 394 995 1043 105 105 40 sky130_fd_sc_hd__nor4_4
* cell instance $2546 m0 *1 15.64,40.8
X$2546 40 1325 1284 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $2547 m0 *1 19.78,40.8
X$2547 40 1044 1284 1207 1208 1141 1285 105 105 40 sky130_fd_sc_hd__o311a_1
* cell instance $2548 m0 *1 23.46,40.8
X$2548 105 1207 1079 1208 105 40 1052 40 sky130_fd_sc_hd__or3_2
* cell instance $2549 m0 *1 26.22,40.8
X$2549 40 1333 1143 1052 1246 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $2552 m0 *1 29.44,40.8
X$2552 40 1051 1286 1332 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $2554 m0 *1 36.34,40.8
X$2554 105 1141 1052 1287 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $2555 m0 *1 38.64,40.8
X$2555 40 1030 1209 1140 1335 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $2556 m0 *1 44.62,40.8
X$2556 105 1030 1289 1210 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2558 m0 *1 47.38,40.8
X$2558 40 1050 693 1029 1338 1210 105 105 40 sky130_fd_sc_hd__a211o_2
* cell instance $2559 m0 *1 51.06,40.8
X$2559 40 1100 1141 1290 1032 1211 1212 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $2560 m0 *1 54.74,40.8
X$2560 105 1213 1340 1257 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2564 m0 *1 57.5,40.8
X$2564 105 1212 1185 1290 1214 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $2566 m0 *1 59.8,40.8
X$2566 105 1185 1291 1105 1342 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $2568 m0 *1 62.1,40.8
X$2568 40 1058 1267 1342 1214 1216 1187 105 105 40 sky130_fd_sc_hd__o2111a_1
* cell instance $2569 m0 *1 66.24,40.8
X$2569 105 956 1041 901 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2570 m0 *1 67.62,40.8
X$2570 105 956 1144 1050 899 105 1294 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $2571 m0 *1 69.92,40.8
X$2571 105 1215 40 105 1103 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2572 m0 *1 73.14,40.8
X$2572 40 1294 1147 957 1115 105 105 40 sky130_fd_sc_hd__nor3b_4
* cell instance $2573 m0 *1 80.04,40.8
X$2573 105 1115 40 105 1215 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2576 m0 *1 84.64,40.8
X$2576 40 707 1003 1422 1273 1274 1195 105 105 40 sky130_fd_sc_hd__o2111a_1
* cell instance $2578 m0 *1 89.24,40.8
X$2578 40 1004 1199 105 105 40 sky130_fd_sc_hd__inv_8
* cell instance $2579 m0 *1 93.38,40.8
X$2579 40 1351 1349 1296 730 1297 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $2581 m0 *1 103.04,40.8
X$2581 40 1299 1354 505 506 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $2589 m0 *1 117.3,40.8
X$2589 105 1357 105 40 1356 40 sky130_fd_sc_hd__inv_1
* cell instance $2592 m0 *1 120.98,40.8
X$2592 40 1432 563 1218 1280 1219 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2594 m0 *1 128.8,40.8
X$2594 40 1219 1353 1521 1220 1221 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2596 m0 *1 136.62,40.8
X$2596 105 1352 105 40 1221 40 sky130_fd_sc_hd__inv_1
* cell instance $2601 m0 *1 140.76,40.8
X$2601 105 824 40 105 642 40 sky130_fd_sc_hd__inv_2
* cell instance $2603 m0 *1 142.6,40.8
X$2603 105 1133 40 105 1222 40 sky130_fd_sc_hd__inv_2
* cell instance $2607 m0 *1 147.2,40.8
X$2607 105 1350 105 40 1276 40 sky130_fd_sc_hd__inv_1
* cell instance $2611 m0 *1 155.02,40.8
X$2611 105 1348 105 40 1275 40 sky130_fd_sc_hd__inv_1
* cell instance $2612 m0 *1 156.4,40.8
X$2612 40 1348 1136 1347 105 1272 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2617 m0 *1 167.44,40.8
X$2617 40 1272 1033 1346 1270 1345 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2618 m0 *1 174.8,40.8
X$2618 40 1269 1125 1344 1224 1223 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2621 m0 *1 186.76,40.8
X$2621 40 1124 1121 1266 1263 1265 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2625 m0 *1 195.96,40.8
X$2625 105 1225 105 40 1341 40 sky130_fd_sc_hd__inv_1
* cell instance $2626 m0 *1 197.34,40.8
X$2626 40 1264 1263 1306 105 1261 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2627 m0 *1 201.94,40.8
X$2627 40 1117 1027 1227 1226 1339 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2629 m0 *1 209.76,40.8
X$2629 40 1227 1026 1426 1010 1157 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2630 m0 *1 217.12,40.8
X$2630 40 1184 1109 1308 105 1336 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2637 m0 *1 232.76,40.8
X$2637 40 1334 1181 1611 1161 1256 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2638 m0 *1 240.12,40.8
X$2638 105 1228 1180 1310 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2640 m0 *1 243.8,40.8
X$2640 40 1160 1331 1256 105 1161 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2641 m0 *1 248.4,40.8
X$2641 105 1160 105 40 1229 40 sky130_fd_sc_hd__inv_1
* cell instance $2643 m0 *1 250.24,40.8
X$2643 105 1254 1310 1330 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2645 m0 *1 253.92,40.8
X$2645 40 1255 1311 1230 105 1252 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2646 m0 *1 258.52,40.8
X$2646 40 1230 320 1414 1251 1495 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2647 m0 *1 265.88,40.8
X$2647 40 1251 1329 1633 1250 1492 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2648 m0 *1 273.24,40.8
X$2648 105 1329 105 40 1249 40 sky130_fd_sc_hd__inv_1
* cell instance $2652 m0 *1 277.84,40.8
X$2652 40 1248 1245 1328 1247 1327 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2653 m0 *1 285.2,40.8
X$2653 40 570 316 1403 1244 1245 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2654 m0 *1 292.56,40.8
X$2654 40 1244 585 1488 1243 1326 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2656 m0 *1 301.76,40.8
X$2656 105 1231 105 40 1017 40 sky130_fd_sc_hd__inv_1
* cell instance $2657 m0 *1 303.14,40.8
X$2657 105 1242 105 40 1324 40 sky130_fd_sc_hd__inv_1
* cell instance $2660 m0 *1 305.44,40.8
X$2660 40 1231 1313 1315 105 1472 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2661 m0 *1 310.04,40.8
X$2661 40 1171 1170 1233 1240 1396 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2664 m0 *1 318.78,40.8
X$2664 40 1232 1087 1394 105 1239 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2665 m0 *1 323.38,40.8
X$2665 40 1167 1237 1232 105 1238 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2666 m0 *1 327.98,40.8
X$2666 40 1320 1235 1321 105 1322 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2669 m0 *1 333.5,40.8
X$2669 105 1235 1313 1234 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2670 m0 *1 335.8,40.8
X$2670 105 1071 105 40 1013 40 sky130_fd_sc_hd__inv_1
* cell instance $2672 m0 *1 338.1,40.8
X$2672 40 833 1318 1319 1389 1165 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2675 m0 *1 347.76,40.8
X$2675 105 1164 2285 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $2679 r0 *1 4.6,40.8
X$2679 105 1283 1076 1317 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2681 r0 *1 6.44,40.8
X$2681 40 1391 191 1359 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $2683 r0 *1 11.5,40.8
X$2683 40 715 1284 1076 292 1360 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $2686 r0 *1 15.64,40.8
X$2686 40 1076 1360 1283 351 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $2687 r0 *1 21.62,40.8
X$2687 105 1361 1044 897 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2689 r0 *1 23.46,40.8
X$2689 40 1283 1146 1207 1208 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $2690 r0 *1 27.14,40.8
X$2690 40 1332 1286 1144 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $2692 r0 *1 37.72,40.8
X$2692 105 1146 1144 1177 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2693 r0 *1 39.1,40.8
X$2693 105 772 1052 1333 1212 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $2694 r0 *1 40.94,40.8
X$2694 105 1287 1288 1046 40 105 1178 40 sky130_fd_sc_hd__a21oi_1
* cell instance $2697 r0 *1 43.24,40.8
X$2697 40 1289 1288 1363 1046 1100 226 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $2698 r0 *1 46.92,40.8
X$2698 105 1145 447 1363 40 1053 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $2699 r0 *1 50.14,40.8
X$2699 40 1100 1029 1407 1494 1257 693 105 105 40 sky130_fd_sc_hd__a32o_2
* cell instance $2700 r0 *1 54.28,40.8
X$2700 105 1100 40 105 1413 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2701 r0 *1 57.5,40.8
X$2701 105 1213 1411 1364 105 40 1292 40 sky130_fd_sc_hd__o21ai_1
* cell instance $2702 r0 *1 59.34,40.8
X$2702 105 1291 1146 1147 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2703 r0 *1 62.56,40.8
X$2703 105 1052 1144 1291 1187 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $2705 r0 *1 65.32,40.8
X$2705 105 1053 226 1292 40 105 899 40 sky130_fd_sc_hd__a21oi_1
* cell instance $2706 r0 *1 67.16,40.8
X$2706 105 1459 1293 1416 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2709 r0 *1 70.84,40.8
X$2709 105 1118 105 40 902 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $2710 r0 *1 72.68,40.8
X$2710 105 1293 40 105 1418 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2713 r0 *1 78.2,40.8
X$2713 40 870 1115 1057 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $2714 r0 *1 82.34,40.8
X$2714 105 1115 40 105 1148 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2715 r0 *1 85.56,40.8
X$2715 105 1149 1366 1217 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2716 r0 *1 86.94,40.8
X$2716 105 1149 1366 904 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2717 r0 *1 89.24,40.8
X$2717 105 1199 40 105 1349 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2718 r0 *1 92.46,40.8
X$2718 105 1461 40 105 1594 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2719 r0 *1 95.68,40.8
X$2719 105 1295 870 958 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $2722 r0 *1 98.44,40.8
X$2722 40 915 1509 1298 904 1217 361 105 105 40 sky130_fd_sc_hd__o221a_4
* cell instance $2727 r0 *1 117.3,40.8
X$2727 105 1432 105 40 1431 40 sky130_fd_sc_hd__inv_1
* cell instance $2730 r0 *1 122.82,40.8
X$2730 105 1300 105 40 1355 40 sky130_fd_sc_hd__inv_1
* cell instance $2737 r0 *1 127.42,40.8
X$2737 105 1437 105 40 1434 40 sky130_fd_sc_hd__inv_1
* cell instance $2738 r0 *1 128.8,40.8
X$2738 105 1301 105 40 1436 40 sky130_fd_sc_hd__inv_1
* cell instance $2740 r0 *1 130.64,40.8
X$2740 40 1301 1134 824 1007 1222 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2741 r0 *1 138,40.8
X$2741 40 1352 1197 1438 1441 1440 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2742 r0 *1 145.36,40.8
X$2742 40 1350 1440 1061 105 1439 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2743 r0 *1 149.96,40.8
X$2743 105 1442 105 40 1220 40 sky130_fd_sc_hd__inv_1
* cell instance $2752 r0 *1 160.08,40.8
X$2752 105 1303 105 40 1302 40 sky130_fd_sc_hd__inv_1
* cell instance $2754 r0 *1 161.92,40.8
X$2754 40 1303 1445 1514 1375 1371 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2755 r0 *1 169.28,40.8
X$2755 105 1445 105 40 1346 40 sky130_fd_sc_hd__inv_1
* cell instance $2756 r0 *1 170.66,40.8
X$2756 105 1446 105 40 1345 40 sky130_fd_sc_hd__inv_1
* cell instance $2757 r0 *1 172.04,40.8
X$2757 105 1372 105 40 1344 40 sky130_fd_sc_hd__inv_1
* cell instance $2758 r0 *1 173.42,40.8
X$2758 40 1372 1268 1540 1375 1304 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2761 r0 *1 181.24,40.8
X$2761 40 1225 1188 1371 1375 1305 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2762 r0 *1 188.6,40.8
X$2762 40 1190 1120 1371 1375 1304 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2763 r0 *1 195.96,40.8
X$2763 40 1265 1224 1433 105 1506 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2767 r0 *1 203.78,40.8
X$2767 40 1339 1262 1430 105 1429 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2772 r0 *1 211.14,40.8
X$2772 105 1427 105 40 1337 40 sky130_fd_sc_hd__inv_1
* cell instance $2774 r0 *1 212.98,40.8
X$2774 40 1336 1186 2328 105 1424 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2775 r0 *1 217.58,40.8
X$2775 40 962 1259 1653 105 1425 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2778 r0 *1 224.94,40.8
X$2778 40 1921 824 1309 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $2779 r0 *1 229.08,40.8
X$2779 105 1309 1547 1107 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2783 r0 *1 231.84,40.8
X$2783 105 1160 1334 1423 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2786 r0 *1 236.44,40.8
X$2786 40 40 1307 925 1309 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $2790 r0 *1 243.8,40.8
X$2790 105 1311 1421 1419 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2791 r0 *1 247.02,40.8
X$2791 40 1696 526 852 1732 1417 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2796 r0 *1 262.2,40.8
X$2796 105 1312 105 40 1414 40 sky130_fd_sc_hd__inv_1
* cell instance $2804 r0 *1 280.14,40.8
X$2804 105 1408 105 40 1328 40 sky130_fd_sc_hd__inv_1
* cell instance $2806 r0 *1 281.98,40.8
X$2806 105 1406 105 40 1327 40 sky130_fd_sc_hd__inv_1
* cell instance $2808 r0 *1 285.2,40.8
X$2808 105 1315 40 105 664 40 sky130_fd_sc_hd__inv_4
* cell instance $2814 r0 *1 296.24,40.8
X$2814 105 1402 105 40 1326 40 sky130_fd_sc_hd__inv_1
* cell instance $2817 r0 *1 299,40.8
X$2817 105 1309 1401 1075 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2820 r0 *1 303.14,40.8
X$2820 105 1381 105 40 843 40 sky130_fd_sc_hd__inv_1
* cell instance $2821 r0 *1 304.52,40.8
X$2821 40 1399 1240 1382 1324 1398 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2825 r0 *1 314.64,40.8
X$2825 105 1397 105 40 1383 40 sky130_fd_sc_hd__inv_1
* cell instance $2829 r0 *1 319.24,40.8
X$2829 40 1166 1323 1086 1383 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $2830 r0 *1 328.44,40.8
X$2830 105 1315 105 40 1322 40 sky130_fd_sc_hd__inv_1
* cell instance $2831 r0 *1 329.82,40.8
X$2831 105 1314 105 40 1321 40 sky130_fd_sc_hd__inv_1
* cell instance $2834 r0 *1 332.58,40.8
X$2834 40 1078 1389 1481 1320 1393 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2835 r0 *1 339.94,40.8
X$2835 105 1316 105 40 931 40 sky130_fd_sc_hd__inv_1
* cell instance $2837 r0 *1 341.32,40.8
X$2837 105 1390 105 40 1319 40 sky130_fd_sc_hd__inv_1
* cell instance $2840 r0 *1 346.84,40.8
X$2840 105 1386 105 40 1388 40 sky130_fd_sc_hd__inv_1
* cell instance $2870 m0 *1 2.76,46.24
X$2870 105 1358 1447 1449 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2871 m0 *1 4.14,46.24
X$2871 40 1391 1447 1283 1076 1074 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $2873 m0 *1 8.28,46.24
X$2873 105 1448 715 1449 992 105 1138 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $2875 m0 *1 11.5,46.24
X$2875 40 1448 715 1449 994 105 1361 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $2876 m0 *1 19.32,46.24
X$2876 40 1079 1207 1208 1141 1285 105 894 105 40 sky130_fd_sc_hd__o311ai_4
* cell instance $2878 m0 *1 29.44,46.24
X$2878 40 1487 1795 1451 815 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $2879 m0 *1 35.42,46.24
X$2879 40 1333 1455 1335 1362 1452 105 105 40 sky130_fd_sc_hd__and4b_2
* cell instance $2880 m0 *1 39.56,46.24
X$2880 105 1362 772 1453 1400 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $2881 m0 *1 41.4,46.24
X$2881 105 772 1335 1209 40 105 1288 40 sky130_fd_sc_hd__a21o_1
* cell instance $2883 m0 *1 44.62,46.24
X$2883 105 1400 1454 1456 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2884 m0 *1 46,46.24
X$2884 105 1455 1400 1454 1364 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $2886 m0 *1 48.3,46.24
X$2886 105 447 1364 1566 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $2887 m0 *1 49.68,46.24
X$2887 105 1288 1213 1364 1338 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $2890 m0 *1 52.9,46.24
X$2890 40 1340 1458 1496 1456 105 105 40 sky130_fd_sc_hd__maj3_1
* cell instance $2892 m0 *1 57.04,46.24
X$2892 105 1213 1458 1411 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2893 m0 *1 58.42,46.24
X$2893 105 1212 1290 1291 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2897 m0 *1 65.78,46.24
X$2897 105 226 1292 1041 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2898 m0 *1 67.16,46.24
X$2898 105 1294 1147 1215 1365 105 40 40 sky130_fd_sc_hd__or3b_1
* cell instance $2900 m0 *1 71.3,46.24
X$2900 40 558 200 1418 1459 105 1366 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $2901 m0 *1 79.12,46.24
X$2901 105 1418 40 105 1460 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2902 m0 *1 82.34,46.24
X$2902 105 781 818 1505 105 1422 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $2904 m0 *1 84.64,46.24
X$2904 40 1365 1297 818 2135 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $2905 m0 *1 88.32,46.24
X$2905 40 40 601 105 781 818 105 sky130_fd_sc_hd__nor2_2
* cell instance $2906 m0 *1 90.62,46.24
X$2906 105 1199 40 105 1195 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2907 m0 *1 93.84,46.24
X$2907 40 1508 1462 1118 1351 1297 730 105 105 40 sky130_fd_sc_hd__a221oi_2
* cell instance $2908 m0 *1 99.36,46.24
X$2908 105 1510 781 818 1572 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $2911 m0 *1 102.58,46.24
X$2911 105 1367 1298 1573 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $2913 m0 *1 104.88,46.24
X$2913 105 1368 1367 1462 915 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $2915 m0 *1 107.18,46.24
X$2915 105 1296 1368 1367 1206 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $2922 m0 *1 115.46,46.24
X$2922 40 1516 1153 1515 1740 1431 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2923 m0 *1 122.82,46.24
X$2923 105 1464 105 40 1435 40 sky130_fd_sc_hd__inv_1
* cell instance $2924 m0 *1 124.2,46.24
X$2924 40 1518 1201 1659 1435 1434 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2928 m0 *1 134.78,46.24
X$2928 40 1438 1585 1520 105 1465 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2932 m0 *1 143.98,46.24
X$2932 40 1300 1442 1369 1517 1669 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2933 m0 *1 151.34,46.24
X$2933 40 1441 1369 1467 105 1444 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2934 m0 *1 155.94,46.24
X$2934 40 1444 1347 1370 1443 1302 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2939 m0 *1 169.74,46.24
X$2939 105 1513 105 40 1370 40 sky130_fd_sc_hd__inv_1
* cell instance $2940 m0 *1 171.12,46.24
X$2940 40 1446 1343 1305 1373 1371 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2941 m0 *1 178.48,46.24
X$2941 105 1468 40 105 1374 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2942 m0 *1 181.7,46.24
X$2942 105 1468 40 105 1371 40 sky130_fd_sc_hd__inv_2
* cell instance $2950 m0 *1 197.34,46.24
X$2950 105 1376 1307 1433 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2952 m0 *1 200.56,46.24
X$2952 105 1378 1307 1261 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2953 m0 *1 202.86,46.24
X$2953 105 1376 1377 1430 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2956 m0 *1 207.46,46.24
X$2956 105 1378 1377 1428 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2957 m0 *1 209.76,46.24
X$2957 40 1427 1226 1507 105 1428 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2958 m0 *1 214.36,46.24
X$2958 105 1468 105 1426 40 40 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2959 m0 *1 218.04,46.24
X$2959 105 1378 1379 1424 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $2965 m0 *1 227.7,46.24
X$2965 105 1258 1409 1504 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2966 m0 *1 230.92,46.24
X$2966 105 1423 1419 1503 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $2967 m0 *1 234.14,46.24
X$2967 105 1377 40 105 1380 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $2970 m0 *1 238.74,46.24
X$2970 40 417 1499 1501 1420 1500 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2972 m0 *1 246.56,46.24
X$2972 105 1499 105 40 1417 40 sky130_fd_sc_hd__inv_1
* cell instance $2976 m0 *1 250.7,46.24
X$2976 105 1331 105 40 1415 40 sky130_fd_sc_hd__inv_1
* cell instance $2977 m0 *1 252.08,46.24
X$2977 40 1498 1252 1497 105 1415 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2981 m0 *1 263.12,46.24
X$2981 40 524 1312 1493 105 1726 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2984 m0 *1 272.32,46.24
X$2984 40 522 1412 1723 105 1410 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2987 m0 *1 277.84,46.24
X$2987 40 1410 1490 2213 1405 2011 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $2988 m0 *1 285.2,46.24
X$2988 40 768 1403 1490 105 1404 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2991 m0 *1 292.1,46.24
X$2991 40 680 1402 1489 105 1491 105 40 sky130_fd_sc_hd__ha_1
* cell instance $2992 m0 *1 296.7,46.24
X$2992 40 40 1379 1472 1309 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $2993 m0 *1 299,46.24
X$2993 40 1401 1314 1379 1380 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $2996 m0 *1 305.44,46.24
X$2996 105 1472 40 745 105 40 sky130_fd_sc_hd__clkinv_4
* cell instance $2999 m0 *1 311.42,46.24
X$2999 40 1396 1484 1485 1395 1486 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3002 m0 *1 320.16,46.24
X$3002 105 1484 105 40 1394 40 sky130_fd_sc_hd__inv_1
* cell instance $3005 m0 *1 323.84,46.24
X$3005 40 1473 1081 1482 105 1483 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3007 m0 *1 329.36,46.24
X$3007 105 1236 105 40 1382 40 sky130_fd_sc_hd__inv_1
* cell instance $3009 m0 *1 331.2,46.24
X$3009 105 1473 105 40 1481 40 sky130_fd_sc_hd__inv_1
* cell instance $3011 m0 *1 333.04,46.24
X$3011 105 1480 105 40 1392 40 sky130_fd_sc_hd__inv_1
* cell instance $3013 m0 *1 334.88,46.24
X$3013 105 1384 105 40 1393 40 sky130_fd_sc_hd__inv_1
* cell instance $3015 m0 *1 337.18,46.24
X$3015 105 1479 105 40 1478 40 sky130_fd_sc_hd__inv_1
* cell instance $3017 m0 *1 339.02,46.24
X$3017 40 1390 1385 1474 1387 1477 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3018 m0 *1 346.38,46.24
X$3018 105 1072 105 40 1387 40 sky130_fd_sc_hd__inv_1
* cell instance $3019 m0 *1 347.76,46.24
X$3019 105 1385 105 40 1476 40 sky130_fd_sc_hd__inv_1
* cell instance $3021 r0 *1 3.22,46.24
X$3021 105 1522 1282 1447 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $3022 r0 *1 5.52,46.24
X$3022 40 1448 1282 1555 1522 573 394 105 105 40 sky130_fd_sc_hd__a311oi_4
* cell instance $3027 r0 *1 17.02,46.24
X$3027 40 1450 1333 1561 993 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $3028 r0 *1 23,46.24
X$3028 40 946 1452 1333 1140 105 105 40 sky130_fd_sc_hd__a21boi_4
* cell instance $3029 r0 *1 29.9,46.24
X$3029 105 1332 1286 946 105 1487 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $3031 r0 *1 33.12,46.24
X$3031 105 1333 1452 1453 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $3032 r0 *1 35.42,46.24
X$3032 105 2031 1524 1289 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3033 r0 *1 38.64,46.24
X$3033 105 1714 772 1453 40 105 1524 40 sky130_fd_sc_hd__a21oi_1
* cell instance $3035 r0 *1 40.94,46.24
X$3035 105 1361 649 1526 105 1454 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $3038 r0 *1 43.24,46.24
X$3038 40 1525 1209 1526 1496 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $3039 r0 *1 46.92,46.24
X$3039 105 1496 1566 1456 105 1149 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $3040 r0 *1 50.14,46.24
X$3040 105 1456 1455 1494 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3042 r0 *1 53.82,46.24
X$3042 105 1293 1457 1340 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $3043 r0 *1 56.12,46.24
X$3043 105 1527 1528 1643 40 105 1496 40 sky130_fd_sc_hd__a21o_1
* cell instance $3044 r0 *1 58.88,46.24
X$3044 105 1528 1643 1527 105 1455 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $3045 r0 *1 62.1,46.24
X$3045 40 1457 1459 1529 716 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $3050 r0 *1 72.22,46.24
X$3050 40 870 1645 558 200 1570 1416 105 105 40 sky130_fd_sc_hd__o32a_1
* cell instance $3051 r0 *1 75.9,46.24
X$3051 40 1459 1366 1460 1367 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $3052 r0 *1 81.88,46.24
X$3052 105 1365 105 40 781 40 sky130_fd_sc_hd__buf_4
* cell instance $3053 r0 *1 84.64,46.24
X$3053 40 902 1533 1295 1571 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $3054 r0 *1 86.94,46.24
X$3054 105 1149 958 1505 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3057 r0 *1 89.7,46.24
X$3057 105 1461 1118 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $3058 r0 *1 91.54,46.24
X$3058 105 1004 40 105 1461 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3059 r0 *1 94.76,46.24
X$3059 105 1296 1591 1509 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3064 r0 *1 99.82,46.24
X$3064 105 730 1572 1530 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $3066 r0 *1 103.04,46.24
X$3066 105 1573 1531 1462 1530 40 1512 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $3067 r0 *1 105.34,46.24
X$3067 105 1462 1531 1530 1463 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $3069 r0 *1 108.1,46.24
X$3069 105 1534 1739 1533 1532 40 1575 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $3070 r0 *1 110.86,46.24
X$3070 105 1575 1037 1657 40 105 1151 40 sky130_fd_sc_hd__a21oi_1
* cell instance $3071 r0 *1 112.7,46.24
X$3071 105 1463 1367 1534 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $3074 r0 *1 116.38,46.24
X$3074 40 1515 1577 1356 105 1578 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3075 r0 *1 120.98,46.24
X$3075 40 1464 1578 1580 105 1579 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3078 r0 *1 126.04,46.24
X$3078 40 1579 1519 1520 1436 1535 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3081 r0 *1 135.7,46.24
X$3081 105 1466 105 40 1521 40 sky130_fd_sc_hd__inv_1
* cell instance $3082 r0 *1 137.08,46.24
X$3082 40 1584 1466 2058 1587 1585 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3085 r0 *1 148.58,46.24
X$3085 40 1465 1588 1537 105 1536 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3089 r0 *1 154.56,46.24
X$3089 40 1517 1192 413 1511 1538 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3092 r0 *1 164.68,46.24
X$3092 105 1539 105 40 1514 40 sky130_fd_sc_hd__inv_1
* cell instance $3093 r0 *1 166.06,46.24
X$3093 40 1670 1513 1586 1375 1304 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3098 r0 *1 179.4,46.24
X$3098 105 1469 105 40 1270 40 sky130_fd_sc_hd__inv_1
* cell instance $3103 r0 *1 186.3,46.24
X$3103 105 1540 105 40 1583 40 sky130_fd_sc_hd__inv_1
* cell instance $3105 r0 *1 188.6,46.24
X$3105 40 1582 1469 1540 1581 1304 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3115 r0 *1 211.14,46.24
X$3115 105 1576 1379 1507 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $3116 r0 *1 213.44,46.24
X$3116 105 1574 413 1025 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $3117 r0 *1 215.74,46.24
X$3117 40 1425 1308 1470 105 1544 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3118 r0 *1 220.34,46.24
X$3118 40 40 1545 1104 1546 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $3119 r0 *1 222.64,46.24
X$3119 40 1471 1309 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $3120 r0 *1 226.78,46.24
X$3120 105 1504 1650 1548 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3122 r0 *1 230.46,46.24
X$3122 105 1503 1548 1502 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3124 r0 *1 233.68,46.24
X$3124 40 40 1377 1315 1471 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $3128 r0 *1 237.82,46.24
X$3128 105 1569 105 40 1501 40 sky130_fd_sc_hd__inv_1
* cell instance $3129 r0 *1 239.2,46.24
X$3129 40 1569 1421 1568 105 1647 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3131 r0 *1 244.26,46.24
X$3131 105 1567 105 40 1500 40 sky130_fd_sc_hd__inv_1
* cell instance $3137 r0 *1 256.22,46.24
X$3137 40 1637 1495 1498 1777 1565 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3143 r0 *1 272.32,46.24
X$3143 40 1492 1408 1632 1549 1564 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3145 r0 *1 281.52,46.24
X$3145 105 1563 105 40 1405 40 sky130_fd_sc_hd__inv_1
* cell instance $3148 r0 *1 285.66,46.24
X$3148 40 1552 1406 1873 105 1562 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3154 r0 *1 294.4,46.24
X$3154 105 1552 105 40 1488 40 sky130_fd_sc_hd__inv_1
* cell instance $3155 r0 *1 295.78,46.24
X$3155 40 1381 582 1560 105 1627 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3159 r0 *1 303.6,46.24
X$3159 105 1551 40 105 665 40 sky130_fd_sc_hd__inv_2
* cell instance $3160 r0 *1 304.98,46.24
X$3160 40 1398 1485 1472 1559 1551 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3164 r0 *1 315.1,46.24
X$3164 105 1558 105 40 1239 40 sky130_fd_sc_hd__inv_1
* cell instance $3170 r0 *1 320.62,46.24
X$3170 40 1482 1238 1623 105 1624 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3173 r0 *1 327.98,46.24
X$3173 40 1474 1384 1621 105 1557 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3174 r0 *1 332.58,46.24
X$3174 40 1620 1480 1233 105 1382 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3175 r0 *1 337.18,46.24
X$3175 105 1556 105 40 1477 40 sky130_fd_sc_hd__inv_1
* cell instance $3177 r0 *1 339.02,46.24
X$3177 40 1554 2018 1476 1388 1553 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3180 r0 *1 346.84,46.24
X$3180 105 1475 105 40 1553 40 sky130_fd_sc_hd__inv_1
* cell instance $3210 m0 *1 2.76,51.68
X$3210 40 40 1079 105 1618 1589 105 sky130_fd_sc_hd__nor2_2
* cell instance $3211 m0 *1 5.06,51.68
X$3211 40 40 1555 105 1619 1752 105 sky130_fd_sc_hd__nor2_2
* cell instance $3214 m0 *1 8.74,51.68
X$3214 105 1282 2244 1358 105 40 1042 40 sky130_fd_sc_hd__or3_2
* cell instance $3215 m0 *1 11.5,51.68
X$3215 40 1325 1076 1360 292 105 394 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $3218 m0 *1 20.7,51.68
X$3218 105 1333 1452 1174 1523 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $3220 m0 *1 23,51.68
X$3220 40 1629 1286 1325 1942 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $3223 m0 *1 29.9,51.68
X$3223 40 1452 1333 105 649 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $3224 m0 *1 37.26,51.68
X$3224 40 1028 1526 1525 649 1361 1362 105 105 40 sky130_fd_sc_hd__o32ai_2
* cell instance $3225 m0 *1 43.24,51.68
X$3225 40 649 1361 1639 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $3226 m0 *1 50.6,51.68
X$3226 105 1639 1714 1641 40 1213 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $3231 m0 *1 57.5,51.68
X$3231 40 1527 1643 1591 105 1529 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3233 m0 *1 63.02,51.68
X$3233 105 1528 1527 105 1457 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $3237 m0 *1 69.46,51.68
X$3237 40 200 558 1592 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $3238 m0 *1 76.82,51.68
X$3238 40 1727 1680 1591 105 1645 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3240 m0 *1 82.34,51.68
X$3240 105 1592 1648 1729 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3243 m0 *1 84.64,51.68
X$3243 105 1295 1571 1532 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3244 m0 *1 86.02,51.68
X$3244 105 1571 1295 105 1649 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $3246 m0 *1 89.7,51.68
X$3246 40 1649 1593 601 1368 1510 730 105 105 40 sky130_fd_sc_hd__a32oi_4
* cell instance $3247 m0 *1 99.82,51.68
X$3247 105 1594 1593 1531 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3250 m0 *1 103.5,51.68
X$3250 105 1298 1531 1891 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3252 m0 *1 105.8,51.68
X$3252 105 1595 1367 1368 1596 40 975 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $3253 m0 *1 108.1,51.68
X$3253 40 1656 1532 1533 1367 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $3255 m0 *1 112.24,51.68
X$3255 105 1463 1656 1657 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3256 m0 *1 113.62,51.68
X$3256 40 1597 1516 890 1577 1766 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $3257 m0 *1 121.9,51.68
X$3257 40 1893 1742 1598 1518 1666 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3259 m0 *1 129.72,51.68
X$3259 105 1660 105 40 1659 40 sky130_fd_sc_hd__inv_1
* cell instance $3260 m0 *1 131.1,51.68
X$3260 105 1661 105 40 1535 40 sky130_fd_sc_hd__inv_1
* cell instance $3262 m0 *1 134.32,51.68
X$3262 105 1584 105 40 1664 40 sky130_fd_sc_hd__inv_1
* cell instance $3266 m0 *1 140.76,51.68
X$3266 105 1599 105 40 1744 40 sky130_fd_sc_hd__inv_1
* cell instance $3267 m0 *1 142.14,51.68
X$3267 40 1599 1669 414 1600 1668 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3268 m0 *1 149.5,51.68
X$3268 40 1746 1587 1588 1671 1601 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3270 m0 *1 157.78,51.68
X$3270 40 1671 1467 1824 1667 1602 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3271 m0 *1 165.14,51.68
X$3271 105 1670 105 40 1602 40 sky130_fd_sc_hd__inv_1
* cell instance $3278 m0 *1 174.34,51.68
X$3278 105 1157 1305 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $3279 m0 *1 176.18,51.68
X$3279 40 1600 1538 1603 1541 1690 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3280 m0 *1 183.54,51.68
X$3280 40 1603 1443 1583 1542 1749 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3282 m0 *1 191.36,51.68
X$3282 105 1582 105 40 1665 40 sky130_fd_sc_hd__inv_1
* cell instance $3285 m0 *1 195.04,51.68
X$3285 40 1511 1155 1665 1663 1662 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3286 m0 *1 202.4,51.68
X$3286 40 1662 1541 1605 105 1604 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3287 m0 *1 207,51.68
X$3287 105 1543 1658 1606 1605 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $3288 m0 *1 208.84,51.68
X$3288 105 1745 1853 1607 1544 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $3289 m0 *1 210.68,51.68
X$3289 105 737 40 411 105 40 sky130_fd_sc_hd__clkinv_4
* cell instance $3291 m0 *1 214.36,51.68
X$3291 40 40 1608 1373 1655 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $3292 m0 *1 216.66,51.68
X$3292 40 1574 1653 1743 105 1654 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3296 m0 *1 223.56,51.68
X$3296 105 1576 40 1376 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $3297 m0 *1 226.32,51.68
X$3297 105 1651 1652 1650 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3298 m0 *1 229.54,51.68
X$3298 105 1551 829 105 1609 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $3299 m0 *1 232.76,51.68
X$3299 40 1610 737 1309 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $3301 m0 *1 237.82,51.68
X$3301 105 1611 105 40 1737 40 sky130_fd_sc_hd__inv_1
* cell instance $3302 m0 *1 239.2,51.68
X$3302 105 1646 105 40 1647 40 sky130_fd_sc_hd__inv_1
* cell instance $3304 m0 *1 241.5,51.68
X$3304 105 1644 105 40 1420 40 sky130_fd_sc_hd__inv_1
* cell instance $3306 m0 *1 243.34,51.68
X$3306 40 1640 1567 1734 105 1642 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3311 m0 *1 253,51.68
X$3311 40 1638 202 1612 1636 1637 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3312 m0 *1 260.36,51.68
X$3312 105 1635 105 40 1612 40 sky130_fd_sc_hd__inv_1
* cell instance $3315 m0 *1 264.5,51.68
X$3315 40 1565 1633 1796 1631 1634 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3319 m0 *1 277.84,51.68
X$3319 40 1632 1563 1717 1409 1876 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3320 m0 *1 285.2,51.68
X$3320 40 1562 1549 1613 105 1630 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3322 m0 *1 290.72,51.68
X$3322 40 1710 1491 1614 105 1613 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3325 m0 *1 297.62,51.68
X$3325 40 1627 1626 1628 2281 1708 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3327 m0 *1 305.44,51.68
X$3327 40 841 1626 764 2115 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $3328 m0 *1 314.64,51.68
X$3328 40 1558 1616 1615 1704 1706 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3329 m0 *1 322,51.68
X$3329 105 1625 105 40 1624 40 sky130_fd_sc_hd__inv_1
* cell instance $3330 m0 *1 323.38,51.68
X$3330 105 1616 105 40 1623 40 sky130_fd_sc_hd__inv_1
* cell instance $3332 m0 *1 325.68,51.68
X$3332 105 1622 105 40 1621 40 sky130_fd_sc_hd__inv_1
* cell instance $3333 m0 *1 327.06,51.68
X$3333 40 9546 1703 2028 105 1620 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3336 m0 *1 333.04,51.68
X$3336 40 1479 1386 665 1392 1786 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3337 m0 *1 340.4,51.68
X$3337 40 1699 1617 1478 1318 1554 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3341 r0 *1 3.22,51.68
X$3341 40 1618 1589 1325 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $3342 r0 *1 10.58,51.68
X$3342 105 1325 105 40 1283 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $3347 r0 *1 15.64,51.68
X$3347 40 1590 1589 292 390 495 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $3349 r0 *1 23.46,51.68
X$3349 105 1673 1672 1711 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3350 r0 *1 24.84,51.68
X$3350 40 1452 1141 1208 1207 1325 105 105 40 sky130_fd_sc_hd__o31a_4
* cell instance $3351 r0 *1 31.28,51.68
X$3351 105 1283 1672 1674 105 1675 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $3352 r0 *1 33.12,51.68
X$3352 105 1713 1590 1754 1674 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $3354 r0 *1 35.42,51.68
X$3354 105 1715 1675 1641 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3355 r0 *1 36.8,51.68
X$3355 105 1675 1715 1714 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $3357 r0 *1 39.56,51.68
X$3357 105 1756 1757 105 1526 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $3362 r0 *1 47.84,51.68
X$3362 105 1639 2033 1676 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3363 r0 *1 49.22,51.68
X$3363 105 1293 1641 1718 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3364 r0 *1 50.6,51.68
X$3364 105 1721 1718 1676 105 1407 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $3365 r0 *1 53.82,51.68
X$3365 105 1676 1800 1722 105 1529 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $3368 r0 *1 63.94,51.68
X$3368 105 1677 226 1679 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3369 r0 *1 65.32,51.68
X$3369 105 1678 1807 1528 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $3370 r0 *1 67.62,51.68
X$3370 105 1679 226 1808 40 105 1645 40 sky130_fd_sc_hd__a21oi_1
* cell instance $3376 r0 *1 73.6,51.68
X$3376 40 1293 1680 1727 1681 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $3377 r0 *1 79.58,51.68
X$3377 105 1681 1727 1648 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3378 r0 *1 82.8,51.68
X$3378 105 1729 1645 1731 40 105 1571 40 sky130_fd_sc_hd__a21oi_1
* cell instance $3379 r0 *1 84.64,51.68
X$3379 40 1295 1885 1761 1958 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $3380 r0 *1 90.62,51.68
X$3380 105 1733 105 40 1510 40 sky130_fd_sc_hd__inv_1
* cell instance $3383 r0 *1 94.3,51.68
X$3383 105 730 601 1510 1682 40 105 1811 40 sky130_fd_sc_hd__a31oi_1
* cell instance $3385 r0 *1 96.6,51.68
X$3385 105 730 1572 1738 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3388 r0 *1 98.9,51.68
X$3388 105 1594 40 105 1683 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3389 r0 *1 102.12,51.68
X$3389 105 1683 1738 1593 105 40 1765 40 sky130_fd_sc_hd__o21ai_1
* cell instance $3391 r0 *1 105.8,51.68
X$3391 105 1367 1298 1684 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3392 r0 *1 107.18,51.68
X$3392 105 976 1512 1685 1686 1684 1739 105 40 40 sky130_fd_sc_hd__o221ai_1
* cell instance $3394 r0 *1 110.86,51.68
X$3394 105 1686 976 1685 105 40 1037 40 sky130_fd_sc_hd__o21ai_1
* cell instance $3398 r0 *1 120.52,51.68
X$3398 105 1741 105 40 1740 40 sky130_fd_sc_hd__inv_1
* cell instance $3403 r0 *1 127.88,51.68
X$3403 40 1816 1218 1688 1687 1664 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3404 r0 *1 135.24,51.68
X$3404 40 1598 1687 1689 1744 1819 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3406 r0 *1 143.52,51.68
X$3406 105 1746 105 40 1689 40 sky130_fd_sc_hd__inv_1
* cell instance $3409 r0 *1 147.66,51.68
X$3409 40 1439 1536 1747 105 1157 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3414 r0 *1 155.48,51.68
X$3414 40 1899 1537 1539 1010 1374 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3415 r0 *1 162.84,51.68
X$3415 40 1901 1823 1769 1304 1540 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3416 r0 *1 170.2,51.68
X$3416 40 2065 1767 1305 1375 1586 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3418 r0 *1 177.56,51.68
X$3418 105 1373 105 40 1747 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $3421 r0 *1 181.24,51.68
X$3421 40 1820 1667 1749 1750 1542 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3422 r0 *1 188.6,51.68
X$3422 40 1690 1748 1691 105 1818 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3425 r0 *1 197.8,51.68
X$3425 105 1376 1545 1691 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $3426 r0 *1 200.1,51.68
X$3426 40 1223 1663 1852 105 1898 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3428 r0 *1 204.7,51.68
X$3428 105 1378 1545 1604 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $3429 r0 *1 207,51.68
X$3429 105 1692 1693 1429 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3431 r0 *1 208.84,51.68
X$3431 40 1693 829 1773 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $3432 r0 *1 212.98,51.68
X$3432 40 40 1694 1586 1655 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $3433 r0 *1 215.28,51.68
X$3433 105 1692 1695 1654 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3434 r0 *1 216.66,51.68
X$3434 105 1576 1608 1743 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $3436 r0 *1 219.88,51.68
X$3436 40 1694 1551 1546 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $3437 r0 *1 224.02,51.68
X$3437 105 1695 40 105 1809 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3438 r0 *1 227.24,51.68
X$3438 40 1471 1698 1695 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $3440 r0 *1 232.3,51.68
X$3440 105 1609 1023 2272 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3444 r0 *1 238.28,51.68
X$3444 40 1646 1736 1737 1735 1801 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3445 r0 *1 245.64,51.68
X$3445 105 1736 105 40 1734 40 sky130_fd_sc_hd__inv_1
* cell instance $3449 r0 *1 250.24,51.68
X$3449 40 1732 1728 1640 1730 1799 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3450 r0 *1 257.6,51.68
X$3450 40 307 1635 1728 105 1798 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3457 r0 *1 266.34,51.68
X$3457 40 1726 1723 2278 1724 2490 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3458 r0 *1 273.7,51.68
X$3458 105 1725 105 40 1724 40 sky130_fd_sc_hd__inv_1
* cell instance $3460 r0 *1 276,51.68
X$3460 40 1564 1631 1720 105 1719 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3462 r0 *1 281.06,51.68
X$3462 105 1716 105 40 1717 40 sky130_fd_sc_hd__inv_1
* cell instance $3463 r0 *1 282.44,51.68
X$3463 40 1719 1707 1409 1861 1614 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $3469 r0 *1 294.4,51.68
X$3469 40 1489 1709 1697 1710 1712 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3470 r0 *1 301.76,51.68
X$3470 105 1709 105 40 1708 40 sky130_fd_sc_hd__inv_1
* cell instance $3474 r0 *1 306.36,51.68
X$3474 105 1698 40 105 741 40 sky130_fd_sc_hd__inv_4
* cell instance $3476 r0 *1 309.12,51.68
X$3476 40 1486 1706 1551 1707 1698 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3479 r0 *1 317.4,51.68
X$3479 105 1705 105 40 1704 40 sky130_fd_sc_hd__inv_1
* cell instance $3484 r0 *1 325.68,51.68
X$3484 105 1702 105 40 1395 40 sky130_fd_sc_hd__inv_1
* cell instance $3486 r0 *1 327.98,51.68
X$3486 40 1702 743 1782 741 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $3487 r0 *1 337.18,51.68
X$3487 40 1700 1617 1784 1701 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $3490 r0 *1 346.84,51.68
X$3490 105 1550 2381 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $3519 m0 *1 1.84,57.12
X$3519 105 1358 1751 40 105 1589 40 sky130_fd_sc_hd__or2_4
* cell instance $3521 m0 *1 5.98,57.12
X$3521 105 1619 1752 1358 105 40 40 sky130_fd_sc_hd__or2_2
* cell instance $3522 m0 *1 8.28,57.12
X$3522 40 1076 1074 1325 1448 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $3525 m0 *1 15.64,57.12
X$3525 105 1713 1618 391 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3526 m0 *1 17.02,57.12
X$3526 40 1753 1141 1829 1618 1589 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $3528 m0 *1 25.3,57.12
X$3528 105 1450 1561 1285 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3530 m0 *1 27.14,57.12
X$3530 105 946 1794 1286 105 40 1795 40 sky130_fd_sc_hd__o21ai_1
* cell instance $3532 m0 *1 29.44,57.12
X$3532 105 1629 1874 1826 40 105 1207 40 sky130_fd_sc_hd__and3_2
* cell instance $3534 m0 *1 32.66,57.12
X$3534 105 1754 1673 1880 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3536 m0 *1 36.34,57.12
X$3536 105 1757 1756 1755 40 105 1715 40 sky130_fd_sc_hd__a21o_1
* cell instance $3537 m0 *1 39.1,57.12
X$3537 40 1673 1755 1757 1756 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $3540 m0 *1 47.38,57.12
X$3540 105 1881 1758 40 105 1756 40 sky130_fd_sc_hd__or2_4
* cell instance $3541 m0 *1 50.6,57.12
X$3541 105 1758 1759 1800 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3542 m0 *1 51.98,57.12
X$3542 105 1830 1802 1831 1759 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $3543 m0 *1 53.82,57.12
X$3543 105 1758 1759 1714 105 1721 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $3546 m0 *1 57.04,57.12
X$3546 105 1639 105 40 1722 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $3549 m0 *1 61.64,57.12
X$3549 40 1836 1807 1760 105 1677 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3550 m0 *1 66.24,57.12
X$3550 105 1678 1883 1808 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3554 m0 *1 76.82,57.12
X$3554 40 1733 1884 1957 1592 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $3555 m0 *1 80.96,57.12
X$3555 105 1648 105 40 1570 40 sky130_fd_sc_hd__inv_1
* cell instance $3559 m0 *1 88.32,57.12
X$3559 40 1761 1810 1593 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $3561 m0 *1 95.22,57.12
X$3561 105 902 1593 1888 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3562 m0 *1 96.6,57.12
X$3562 105 1811 1888 1682 1738 40 1762 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $3565 m0 *1 101.2,57.12
X$3565 105 1763 1765 1764 1813 1296 105 1150 40 40 sky130_fd_sc_hd__a311oi_1
* cell instance $3566 m0 *1 104.42,57.12
X$3566 105 1891 1762 1763 1813 40 1764 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $3569 m0 *1 108.56,57.12
X$3569 105 1296 1813 976 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3575 m0 *1 122.36,57.12
X$3575 40 1844 1741 1742 1821 1816 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3576 m0 *1 129.72,57.12
X$3576 40 1660 1894 1278 105 1817 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3582 m0 *1 141.68,57.12
X$3582 105 1822 105 40 1819 40 sky130_fd_sc_hd__inv_1
* cell instance $3588 m0 *1 159.62,57.12
X$3588 105 1767 105 40 1900 40 sky130_fd_sc_hd__inv_1
* cell instance $3591 m0 *1 162.38,57.12
X$3591 105 1823 105 40 1824 40 sky130_fd_sc_hd__inv_1
* cell instance $3597 m0 *1 167.9,57.12
X$3597 40 1902 1903 1539 1010 1768 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3598 m0 *1 175.26,57.12
X$3598 105 1586 105 40 1768 40 sky130_fd_sc_hd__inv_1
* cell instance $3599 m0 *1 176.64,57.12
X$3599 105 1769 105 40 1904 40 sky130_fd_sc_hd__inv_1
* cell instance $3602 m0 *1 179.4,57.12
X$3602 40 1971 1668 1820 1748 2002 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3604 m0 *1 187.68,57.12
X$3604 105 1581 40 105 1749 40 sky130_fd_sc_hd__inv_4
* cell instance $3606 m0 *1 190.9,57.12
X$3606 105 1692 1770 1818 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3610 m0 *1 195.04,57.12
X$3610 105 1543 1771 1306 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3611 m0 *1 196.42,57.12
X$3611 105 1745 1658 1606 1898 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $3612 m0 *1 198.26,57.12
X$3612 105 1812 1772 1847 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $3614 m0 *1 201.48,57.12
X$3614 105 1851 40 1695 105 40 sky130_fd_sc_hd__buf_2
* cell instance $3615 m0 *1 203.32,57.12
X$3615 105 1815 40 105 1897 40 sky130_fd_sc_hd__inv_2
* cell instance $3616 m0 *1 204.7,57.12
X$3616 105 1814 40 1655 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $3619 m0 *1 208.84,57.12
X$3619 40 1773 923 1658 1774 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $3620 m0 *1 214.82,57.12
X$3620 105 1745 105 40 1692 40 sky130_fd_sc_hd__buf_4
* cell instance $3623 m0 *1 218.96,57.12
X$3623 105 1812 1608 40 1010 105 40 sky130_fd_sc_hd__and2_4
* cell instance $3625 m0 *1 222.64,57.12
X$3625 105 1543 1809 1470 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3626 m0 *1 224.02,57.12
X$3626 40 1608 1615 1546 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $3627 m0 *1 228.16,57.12
X$3627 40 1651 1804 1106 1806 1805 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3628 m0 *1 235.52,57.12
X$3628 40 1889 1644 1804 1803 1887 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3629 m0 *1 242.88,57.12
X$3629 105 1543 1775 1801 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3632 m0 *1 247.02,57.12
X$3632 105 1378 1775 1955 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $3635 m0 *1 250.24,57.12
X$3635 40 1776 1799 1882 105 2586 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3637 m0 *1 258.52,57.12
X$3637 40 1798 1493 1776 1797 1859 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3639 m0 *1 267.72,57.12
X$3639 40 1796 1725 1879 1779 1778 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3641 m0 *1 275.54,57.12
X$3641 105 1781 105 40 1778 40 sky130_fd_sc_hd__inv_1
* cell instance $3644 m0 *1 277.84,57.12
X$3644 40 1781 1716 1780 1793 1019 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3649 m0 *1 296.7,57.12
X$3649 105 1792 1559 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $3658 m0 *1 312.34,57.12
X$3658 105 1791 105 40 1241 40 sky130_fd_sc_hd__inv_1
* cell instance $3659 m0 *1 313.72,57.12
X$3659 40 1790 1705 741 105 1789 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3661 m0 *1 318.78,57.12
X$3661 105 1790 105 40 1788 40 sky130_fd_sc_hd__inv_1
* cell instance $3662 m0 *1 320.16,57.12
X$3662 40 1625 1622 1615 1787 1788 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3667 m0 *1 333.04,57.12
X$3667 105 1782 105 40 1233 40 sky130_fd_sc_hd__inv_1
* cell instance $3669 m0 *1 334.88,57.12
X$3669 105 1703 105 40 1786 40 sky130_fd_sc_hd__inv_1
* cell instance $3671 m0 *1 337.18,57.12
X$3671 40 1785 1699 1865 930 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $3672 m0 *1 346.38,57.12
X$3672 105 1700 1783 1784 40 105 2022 40 sky130_fd_sc_hd__a21o_1
* cell instance $3673 r0 *1 1.38,57.12
X$3673 40 1751 1713 1358 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $3674 r0 *1 5.52,57.12
X$3674 40 1752 1751 1618 1869 1619 105 290 105 40 sky130_fd_sc_hd__o311ai_4
* cell instance $3678 r0 *1 15.64,57.12
X$3678 40 993 1825 1590 1713 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $3679 r0 *1 21.62,57.12
X$3679 40 1826 1874 1208 2438 1629 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $3680 r0 *1 28.98,57.12
X$3680 40 1827 1246 1944 1877 1828 1829 105 105 40 sky130_fd_sc_hd__o221ai_2
* cell instance $3682 r0 *1 34.96,57.12
X$3682 40 40 1673 1829 2764 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $3684 r0 *1 38.18,57.12
X$3684 40 1757 1755 1591 105 1362 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3690 r0 *1 45.54,57.12
X$3690 40 1830 1881 1760 105 1947 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3692 r0 *1 50.6,57.12
X$3692 105 1830 1831 1802 105 1758 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $3694 r0 *1 53.82,57.12
X$3694 105 1832 1911 1834 105 1831 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $3695 r0 *1 56.58,57.12
X$3695 105 1831 1639 1950 1833 105 40 1677 40 sky130_fd_sc_hd__o31ai_1
* cell instance $3697 r0 *1 60.26,57.12
X$3697 105 1836 1837 1835 1883 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $3698 r0 *1 62.56,57.12
X$3698 105 1837 1835 1836 40 1678 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $3700 r0 *1 66.7,57.12
X$3700 105 1835 716 1953 1954 105 40 1884 40 sky130_fd_sc_hd__o31ai_1
* cell instance $3705 r0 *1 70.84,57.12
X$3705 40 716 2444 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $3706 r0 *1 74.98,57.12
X$3706 40 1914 1838 1760 105 1884 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3707 r0 *1 79.58,57.12
X$3707 105 1839 1838 1681 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $3709 r0 *1 82.8,57.12
X$3709 40 1761 1885 1591 105 1733 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3710 r0 *1 87.4,57.12
X$3710 105 1840 1761 1841 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3711 r0 *1 90.62,57.12
X$3711 105 1840 40 105 1810 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3713 r0 *1 94.76,57.12
X$3713 40 1961 1572 902 1917 730 1841 105 105 40 sky130_fd_sc_hd__a221oi_1
* cell instance $3719 r0 *1 100.74,57.12
X$3719 105 1765 1842 1890 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3720 r0 *1 102.12,57.12
X$3720 105 1890 1960 1296 105 1203 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $3722 r0 *1 104.88,57.12
X$3722 105 1298 40 105 1682 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3726 r0 *1 115.92,57.12
X$3726 40 1843 1597 2049 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $3727 r0 *1 121.9,57.12
X$3727 105 1893 105 40 1963 40 sky130_fd_sc_hd__inv_1
* cell instance $3730 r0 *1 123.28,57.12
X$3730 105 1844 105 40 1962 40 sky130_fd_sc_hd__inv_1
* cell instance $3737 r0 *1 132.94,57.12
X$3737 105 1894 105 40 1967 40 sky130_fd_sc_hd__inv_1
* cell instance $3740 r0 *1 135.7,57.12
X$3740 105 1896 105 40 1688 40 sky130_fd_sc_hd__inv_1
* cell instance $3741 r0 *1 137.08,57.12
X$3741 40 1279 1968 411 105 642 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3742 r0 *1 141.68,57.12
X$3742 40 2055 1822 1137 1971 1845 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3748 r0 *1 153.64,57.12
X$3748 40 2149 1970 1900 105 1899 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3751 r0 *1 161,57.12
X$3751 105 1901 105 40 1972 40 sky130_fd_sc_hd__inv_1
* cell instance $3752 r0 *1 162.38,57.12
X$3752 40 2062 2066 1371 1304 1769 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3756 r0 *1 172.96,57.12
X$3756 40 2067 1975 1157 1904 1768 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3762 r0 *1 181.7,57.12
X$3762 40 1843 1846 1848 1847 1749 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $3763 r0 *1 189.98,57.12
X$3763 105 1849 105 40 1542 40 sky130_fd_sc_hd__inv_1
* cell instance $3764 r0 *1 191.36,57.12
X$3764 105 1847 40 105 1304 40 sky130_fd_sc_hd__inv_2
* cell instance $3765 r0 *1 192.74,57.12
X$3765 40 40 1379 1769 1814 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $3767 r0 *1 195.5,57.12
X$3767 105 1850 40 105 1920 40 sky130_fd_sc_hd__inv_2
* cell instance $3769 r0 *1 197.34,57.12
X$3769 105 1772 40 105 1377 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3770 r0 *1 200.56,57.12
X$3770 40 1851 2006 1157 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $3775 r0 *1 208.84,57.12
X$3775 105 1693 40 105 1771 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3776 r0 *1 212.06,57.12
X$3776 105 1695 40 105 1965 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3777 r0 *1 215.28,57.12
X$3777 105 1892 1966 1895 1852 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $3778 r0 *1 217.12,57.12
X$3778 105 1378 105 40 1745 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $3779 r0 *1 219.88,57.12
X$3779 105 1853 1607 1694 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3780 r0 *1 221.26,57.12
X$3780 40 1773 1546 105 105 40 sky130_fd_sc_hd__clkinv_8
* cell instance $3783 r0 *1 228.62,57.12
X$3783 105 528 1889 2054 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3786 r0 *1 231.84,57.12
X$3786 105 1854 105 40 1106 40 sky130_fd_sc_hd__inv_1
* cell instance $3790 r0 *1 236.44,57.12
X$3790 105 1886 105 40 1887 40 sky130_fd_sc_hd__inv_1
* cell instance $3791 r0 *1 237.82,57.12
X$3791 105 827 1104 1924 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3792 r0 *1 241.04,57.12
X$3792 105 1806 105 40 1855 40 sky130_fd_sc_hd__inv_1
* cell instance $3795 r0 *1 244.72,57.12
X$3795 40 1642 1882 1854 1955 2128 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3798 r0 *1 254.38,57.12
X$3798 105 1856 105 40 1857 40 sky130_fd_sc_hd__inv_1
* cell instance $3800 r0 *1 256.22,57.12
X$3800 40 1856 2041 1806 1858 1021 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3805 r0 *1 264.96,57.12
X$3805 40 1949 1879 1021 1927 1858 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3809 r0 *1 277.38,57.12
X$3809 105 1878 105 40 1780 40 sky130_fd_sc_hd__inv_1
* cell instance $3811 r0 *1 280.6,57.12
X$3811 105 1860 105 40 1876 40 sky130_fd_sc_hd__inv_1
* cell instance $3812 r0 *1 281.98,57.12
X$3812 40 1860 1875 1019 1792 1793 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3816 r0 *1 289.8,57.12
X$3816 105 1875 105 40 1872 40 sky130_fd_sc_hd__inv_1
* cell instance $3818 r0 *1 291.64,57.12
X$3818 40 1873 2034 1872 1945 1946 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3819 r0 *1 299,57.12
X$3819 40 1712 1941 1559 1862 1707 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3820 r0 *1 306.36,57.12
X$3820 40 1940 1939 1707 1613 1862 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3829 r0 *1 320.62,57.12
X$3829 105 1871 40 105 1323 40 sky130_fd_sc_hd__inv_2
* cell instance $3832 r0 *1 323.38,57.12
X$3832 105 1870 105 40 1787 40 sky130_fd_sc_hd__inv_1
* cell instance $3835 r0 *1 327.52,57.12
X$3835 40 9520 1866 1782 1236 1937 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3836 r0 *1 334.88,57.12
X$3836 105 1868 105 40 1867 40 sky130_fd_sc_hd__inv_1
* cell instance $3837 r0 *1 336.26,57.12
X$3837 40 1932 1475 1867 105 1866 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3841 r0 *1 341.78,57.12
X$3841 40 2017 1783 1864 105 1934 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3844 r0 *1 347.76,57.12
X$3844 105 1863 1933 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $3859 m0 *1 2.3,62.56
X$3859 40 2476 1555 1359 1618 1751 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $3860 m0 *1 9.66,62.56
X$3860 105 1869 105 40 2020 40 sky130_fd_sc_hd__inv_1
* cell instance $3862 m0 *1 11.96,62.56
X$3862 40 1618 1905 2156 994 1978 1589 105 105 40 sky130_fd_sc_hd__o32ai_4
* cell instance $3863 m0 *1 22.08,62.56
X$3863 40 40 1590 1828 1713 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $3864 m0 *1 24.38,62.56
X$3864 105 1874 1826 1942 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3865 m0 *1 25.76,62.56
X$3865 105 1942 1713 1590 40 105 1877 40 sky130_fd_sc_hd__a21oi_1
* cell instance $3866 m0 *1 27.6,62.56
X$3866 105 1907 1981 1827 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3868 m0 *1 29.44,62.56
X$3868 105 1906 1907 1981 1753 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $3869 m0 *1 31.28,62.56
X$3869 105 1906 1983 1908 40 105 1944 40 sky130_fd_sc_hd__a21oi_1
* cell instance $3870 m0 *1 33.12,62.56
X$3870 105 1711 105 40 1907 40 sky130_fd_sc_hd__inv_1
* cell instance $3871 m0 *1 34.5,62.56
X$3871 105 1908 1880 1985 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3872 m0 *1 35.88,62.56
X$3872 40 1525 1907 1984 1909 1828 1985 105 105 40 sky130_fd_sc_hd__o32a_1
* cell instance $3873 m0 *1 39.56,62.56
X$3873 105 1673 1672 1909 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3877 m0 *1 46.92,62.56
X$3877 105 2033 105 40 1947 40 sky130_fd_sc_hd__inv_1
* cell instance $3880 m0 *1 50.6,62.56
X$3880 40 1832 1802 1986 105 1910 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3881 m0 *1 55.2,62.56
X$3881 105 1910 1722 1833 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3883 m0 *1 57.04,62.56
X$3883 105 1832 1834 1911 1950 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $3884 m0 *1 58.88,62.56
X$3884 40 1639 2036 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $3885 m0 *1 63.02,62.56
X$3885 40 1952 1837 1986 105 1913 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3886 m0 *1 67.62,62.56
X$3886 105 1952 1912 2037 1953 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $3887 m0 *1 69.46,62.56
X$3887 105 1989 1913 1954 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $3888 m0 *1 70.84,62.56
X$3888 105 716 105 40 1989 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $3890 m0 *1 73.6,62.56
X$3890 105 1956 1914 1957 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3891 m0 *1 76.82,62.56
X$3891 105 1916 1915 1956 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $3892 m0 *1 78.2,62.56
X$3892 105 1915 1914 1916 105 40 1839 40 sky130_fd_sc_hd__o21ai_1
* cell instance $3898 m0 *1 87.4,62.56
X$3898 105 1840 1958 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $3903 m0 *1 100.74,62.56
X$3903 105 1765 1508 2040 40 105 1960 40 sky130_fd_sc_hd__a21boi_0
* cell instance $3905 m0 *1 103.96,62.56
X$3905 105 1813 1298 1992 2139 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $3908 m0 *1 108.1,62.56
X$3908 105 2042 1961 1994 105 1685 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $3913 m0 *1 115,62.56
X$3913 40 2044 1766 2047 1962 2784 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3914 m0 *1 122.36,62.56
X$3914 40 2047 1997 1963 105 1964 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3915 m0 *1 126.96,62.56
X$3915 40 1996 1661 1222 1007 2052 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3920 m0 *1 139.84,62.56
X$3920 105 2055 105 40 2056 40 sky130_fd_sc_hd__inv_1
* cell instance $3922 m0 *1 143.06,62.56
X$3922 105 1007 736 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $3923 m0 *1 144.9,62.56
X$3923 40 2057 1896 2061 1918 2059 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3924 m0 *1 152.26,62.56
X$3924 40 2060 1918 1970 1969 1974 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3926 m0 *1 161.46,62.56
X$3926 105 2062 105 40 2063 40 sky130_fd_sc_hd__inv_1
* cell instance $3931 m0 *1 168.36,62.56
X$3931 105 2066 105 40 2064 40 sky130_fd_sc_hd__inv_1
* cell instance $3932 m0 *1 169.74,62.56
X$3932 105 2065 105 40 1976 40 sky130_fd_sc_hd__inv_1
* cell instance $3935 m0 *1 173.88,62.56
X$3935 105 1977 2067 2068 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3938 m0 *1 181.7,62.56
X$3938 105 1848 40 105 2069 40 sky130_fd_sc_hd__inv_2
* cell instance $3939 m0 *1 183.08,62.56
X$3939 40 1977 9521 1973 105 1542 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3941 m0 *1 188.14,62.56
X$3941 105 1814 1919 40 105 1539 40 sky130_fd_sc_hd__nor2b_2
* cell instance $3942 m0 *1 191.36,62.56
X$3942 105 1850 40 105 1770 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3944 m0 *1 195.04,62.56
X$3944 105 1814 1897 40 1846 105 40 sky130_fd_sc_hd__and2_4
* cell instance $3945 m0 *1 198.26,62.56
X$3945 40 1547 1920 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $3947 m0 *1 203.78,62.56
X$3947 40 1897 2004 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $3948 m0 *1 207.92,62.56
X$3948 105 1815 40 105 1693 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $3949 m0 *1 211.14,62.56
X$3949 40 1853 1468 1607 2006 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $3950 m0 *1 217.12,62.56
X$3950 105 1606 105 40 1774 40 sky130_fd_sc_hd__buf_4
* cell instance $3951 m0 *1 219.88,62.56
X$3951 40 40 2007 827 1471 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $3953 m0 *1 222.64,62.56
X$3953 105 1892 105 40 1543 40 sky130_fd_sc_hd__buf_4
* cell instance $3955 m0 *1 225.86,62.56
X$3955 105 1814 1921 40 1923 105 40 sky130_fd_sc_hd__and2_4
* cell instance $3956 m0 *1 229.08,62.56
X$3956 105 2131 1638 1922 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3957 m0 *1 232.3,62.56
X$3957 105 1922 2054 2053 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $3960 m0 *1 237.82,62.56
X$3960 40 1886 2048 1023 1959 1855 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3964 m0 *1 250.24,62.56
X$3964 40 2045 1730 2048 1951 1857 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3966 m0 *1 261.28,62.56
X$3966 105 1925 105 40 1797 40 sky130_fd_sc_hd__inv_1
* cell instance $3969 m0 *1 264.96,62.56
X$3969 40 2043 1925 2041 1948 1949 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3972 m0 *1 273.7,62.56
X$3972 105 1926 105 40 1948 40 sky130_fd_sc_hd__inv_1
* cell instance $3974 m0 *1 275.54,62.56
X$3974 105 1878 105 40 1858 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $3977 m0 *1 278.3,62.56
X$3977 105 1927 1019 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $3978 m0 *1 280.14,62.56
X$3978 40 2407 1926 1923 1861 2118 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3979 m0 *1 287.5,62.56
X$3979 40 1630 1945 2038 1862 1928 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3980 m0 *1 294.86,62.56
X$3980 40 1946 1697 1559 1707 2035 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3981 m0 *1 302.22,62.56
X$3981 105 2206 40 105 2015 40 sky130_fd_sc_hd__inv_2
* cell instance $3985 m0 *1 305.44,62.56
X$3985 40 1943 2030 1928 1940 1941 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3986 m0 *1 312.8,62.56
X$3986 40 1791 1871 2015 1938 2302 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $3987 m0 *1 320.16,62.56
X$3987 40 1930 1870 743 105 1929 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3990 m0 *1 327.06,62.56
X$3990 105 1615 40 105 743 40 sky130_fd_sc_hd__inv_2
* cell instance $3991 m0 *1 328.44,62.56
X$3991 105 1930 105 40 1931 40 sky130_fd_sc_hd__inv_1
* cell instance $3992 m0 *1 329.82,62.56
X$3992 105 2028 105 40 1937 40 sky130_fd_sc_hd__inv_1
* cell instance $3997 m0 *1 333.96,62.56
X$3997 40 1868 1556 1931 105 1936 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3998 m0 *1 338.56,62.56
X$3998 40 2023 1934 2024 105 1935 105 40 sky130_fd_sc_hd__ha_1
* cell instance $3999 m0 *1 343.16,62.56
X$3999 40 2103 1865 1785 2022 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $4002 r0 *1 3.68,62.56
X$4002 105 1619 1752 2020 105 2021 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $4003 r0 *1 6.9,62.56
X$4003 40 2025 1360 423 1713 1618 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $4008 r0 *1 16.56,62.56
X$4008 105 1980 1979 2026 40 710 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $4009 r0 *1 19.78,62.56
X$4009 105 1980 1978 2197 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4011 r0 *1 22.08,62.56
X$4011 40 1794 1452 2303 1045 2119 1982 105 105 40 sky130_fd_sc_hd__a32oi_4
* cell instance $4012 r0 *1 32.2,62.56
X$4012 105 1908 1983 1984 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4013 r0 *1 35.42,62.56
X$4013 105 1983 2120 1908 105 40 2031 40 sky130_fd_sc_hd__o21ai_1
* cell instance $4014 r0 *1 37.26,62.56
X$4014 105 1828 105 40 2072 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $4022 r0 *1 54.74,62.56
X$4022 40 2078 1834 1988 105 2077 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4023 r0 *1 59.34,62.56
X$4023 105 1911 1722 2130 1987 105 40 1913 40 sky130_fd_sc_hd__o31ai_1
* cell instance $4026 r0 *1 66.24,62.56
X$4026 105 1952 2037 1912 105 1835 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4034 r0 *1 74.06,62.56
X$4034 40 2083 1916 1986 105 2082 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4035 r0 *1 78.66,62.56
X$4035 40 1915 1592 2134 2135 1990 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $4037 r0 *1 86.94,62.56
X$4037 40 2039 1991 1760 105 2135 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4038 r0 *1 91.54,62.56
X$4038 40 40 1840 105 2136 1991 105 sky130_fd_sc_hd__nor2_2
* cell instance $4044 r0 *1 100.28,62.56
X$4044 105 1763 1813 2138 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4045 r0 *1 103.5,62.56
X$4045 105 1813 1992 2139 105 2040 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $4046 r0 *1 105.34,62.56
X$4046 105 1813 1992 2140 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4047 r0 *1 106.72,62.56
X$4047 105 1686 2042 1993 40 105 1763 40 sky130_fd_sc_hd__a21oi_1
* cell instance $4048 r0 *1 108.56,62.56
X$4048 105 2042 1993 1686 40 105 1992 40 sky130_fd_sc_hd__a21o_1
* cell instance $4049 r0 *1 111.32,62.56
X$4049 105 1917 1994 1993 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $4051 r0 *1 114.08,62.56
X$4051 105 2044 2046 1995 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4052 r0 *1 117.3,62.56
X$4052 40 2050 2049 1995 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $4054 r0 *1 123.28,62.56
X$4054 105 1996 105 40 2051 40 sky130_fd_sc_hd__inv_1
* cell instance $4059 r0 *1 128.8,62.56
X$4059 40 2142 1666 2227 2143 1967 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4060 r0 *1 136.16,62.56
X$4060 40 2144 2146 2084 2056 2736 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4061 r0 *1 143.52,62.56
X$4061 105 2057 105 40 2147 40 sky130_fd_sc_hd__inv_1
* cell instance $4062 r0 *1 144.9,62.56
X$4062 40 2058 2059 2149 105 2148 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4063 r0 *1 149.5,62.56
X$4063 105 2060 105 40 2084 40 sky130_fd_sc_hd__inv_1
* cell instance $4069 r0 *1 157.32,62.56
X$4069 40 1969 1601 1999 2088 1972 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4070 r0 *1 164.68,62.56
X$4070 40 2151 2152 2064 105 1976 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4071 r0 *1 169.28,62.56
X$4071 105 1902 105 40 2154 40 sky130_fd_sc_hd__inv_1
* cell instance $4073 r0 *1 171.12,62.56
X$4073 40 2153 2087 2001 1375 1540 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4076 r0 *1 179.4,62.56
X$4076 105 1975 105 40 2150 40 sky130_fd_sc_hd__inv_1
* cell instance $4079 r0 *1 182.16,62.56
X$4079 105 2003 105 40 1999 40 sky130_fd_sc_hd__inv_1
* cell instance $4083 r0 *1 186.76,62.56
X$4083 105 1846 105 40 2070 40 sky130_fd_sc_hd__inv_1
* cell instance $4084 r0 *1 188.14,62.56
X$4084 40 2240 2003 2001 1581 1540 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4085 r0 *1 195.5,62.56
X$4085 40 1919 2089 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $4087 r0 *1 201.02,62.56
X$4087 40 2004 1812 105 1540 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $4090 r0 *1 208.84,62.56
X$4090 40 40 1920 2005 1812 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4091 r0 *1 211.14,62.56
X$4091 105 2091 1468 105 2233 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $4093 r0 *1 215.28,62.56
X$4093 105 532 40 105 2091 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $4095 r0 *1 219.42,62.56
X$4095 105 2008 2050 2093 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4096 r0 *1 222.64,62.56
X$4096 105 2742 2093 2092 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4097 r0 *1 225.86,62.56
X$4097 105 1546 40 1471 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $4098 r0 *1 228.62,62.56
X$4098 40 2131 1803 2132 1923 1858 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4104 r0 *1 241.5,62.56
X$4104 105 2127 372 105 2129 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $4108 r0 *1 251.16,62.56
X$4108 105 1951 854 2126 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4109 r0 *1 254.38,62.56
X$4109 105 2124 1330 2125 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4113 r0 *1 258.98,62.56
X$4113 105 2045 105 40 2123 40 sky130_fd_sc_hd__inv_1
* cell instance $4119 r0 *1 265.88,62.56
X$4119 105 1959 105 40 1021 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $4121 r0 *1 270.48,62.56
X$4121 40 2122 1951 2121 2280 1019 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4122 r0 *1 277.84,62.56
X$4122 40 2010 2012 2101 2014 1793 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4123 r0 *1 285.2,62.56
X$4123 105 2013 40 2118 105 40 sky130_fd_sc_hd__buf_2
* cell instance $4125 r0 *1 287.04,62.56
X$4125 105 2014 105 40 2038 40 sky130_fd_sc_hd__inv_1
* cell instance $4132 r0 *1 294.86,62.56
X$4132 105 2013 40 105 2035 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $4133 r0 *1 298.08,62.56
X$4133 105 2013 40 105 1793 40 sky130_fd_sc_hd__inv_2
* cell instance $4134 r0 *1 299.46,62.56
X$4134 105 2034 105 40 2117 40 sky130_fd_sc_hd__inv_1
* cell instance $4137 r0 *1 303.6,62.56
X$4137 40 2115 1169 2032 2116 2205 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4138 r0 *1 310.96,62.56
X$4138 105 2030 105 40 2116 40 sky130_fd_sc_hd__inv_1
* cell instance $4141 r0 *1 313.26,62.56
X$4141 40 1938 749 1939 105 2113 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4146 r0 *1 321.54,62.56
X$4146 40 1483 933 2112 105 2296 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4147 r0 *1 326.14,62.56
X$4147 40 2029 2110 743 105 2111 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4148 r0 *1 330.74,62.56
X$4148 40 2016 2109 2027 105 2110 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4149 r0 *1 335.34,62.56
X$4149 40 40 2017 2108 1785 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4150 r0 *1 337.64,62.56
X$4150 40 1701 1864 2018 2105 2107 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4152 r0 *1 345,62.56
X$4152 105 2102 2106 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $4155 r0 *1 347.76,62.56
X$4155 105 2019 2104 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $4183 m0 *1 1.84,68
X$4183 40 2071 2156 2160 105 1618 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $4185 m0 *1 8.74,68
X$4185 105 1713 2071 2158 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4186 m0 *1 10.12,68
X$4186 40 495 2071 2160 2156 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $4188 m0 *1 17.02,68
X$4188 105 1979 2197 1284 40 105 1174 40 sky130_fd_sc_hd__a21o_1
* cell instance $4189 m0 *1 19.78,68
X$4189 105 1978 1980 2072 105 40 720 40 sky130_fd_sc_hd__a21o_2
* cell instance $4191 m0 *1 24.84,68
X$4191 105 2073 1828 1982 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4192 m0 *1 26.22,68
X$4192 105 2202 1450 2119 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $4195 m0 *1 29.44,68
X$4195 40 1908 2162 2074 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $4197 m0 *1 35.88,68
X$4197 105 1983 2072 1908 2120 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $4199 m0 *1 38.18,68
X$4199 40 1362 2208 2209 1828 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $4200 m0 *1 42.32,68
X$4200 40 1828 2075 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $4201 m0 *1 46.46,68
X$4201 40 2033 2210 2211 2072 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $4202 m0 *1 50.14,68
X$4202 105 2072 2076 2214 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4204 m0 *1 51.98,68
X$4204 105 2214 2072 2215 40 105 1910 40 sky130_fd_sc_hd__a21oi_1
* cell instance $4209 m0 *1 57.5,68
X$4209 105 1722 2077 1987 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4210 m0 *1 58.88,68
X$4210 105 2078 2079 2080 105 1911 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4211 m0 *1 61.64,68
X$4211 105 2078 2080 2079 2130 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4213 m0 *1 65.32,68
X$4213 40 2170 1912 1988 105 2081 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4216 m0 *1 71.3,68
X$4216 105 1989 2081 2172 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4217 m0 *1 72.68,68
X$4217 105 2037 1989 2217 2172 105 40 2082 40 sky130_fd_sc_hd__o31ai_1
* cell instance $4220 m0 *1 77.74,68
X$4220 105 1592 2082 1990 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4221 m0 *1 79.12,68
X$4221 105 2083 2133 2173 105 1915 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4222 m0 *1 81.88,68
X$4222 105 2083 2133 2173 2134 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4228 m0 *1 89.7,68
X$4228 105 2174 2039 2136 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $4229 m0 *1 92,68
X$4229 40 2039 2221 1351 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $4233 m0 *1 103.04,68
X$4233 105 2138 1508 2140 1298 1842 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $4235 m0 *1 105.8,68
X$4235 40 1298 1686 2042 2419 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $4240 m0 *1 120.52,68
X$4240 40 2324 1580 2009 2051 2225 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4243 m0 *1 132.48,68
X$4243 105 2226 105 40 2227 40 sky130_fd_sc_hd__inv_1
* cell instance $4245 m0 *1 134.78,68
X$4245 40 1817 2330 1968 105 2145 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4248 m0 *1 140.3,68
X$4248 40 2734 2146 1821 2147 2228 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $4249 m0 *1 148.58,68
X$4249 40 2148 2230 1747 105 2009 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4251 m0 *1 155.02,68
X$4251 105 2085 105 40 2061 40 sky130_fd_sc_hd__inv_1
* cell instance $4253 m0 *1 156.86,68
X$4253 105 2151 105 40 2232 40 sky130_fd_sc_hd__inv_1
* cell instance $4260 m0 *1 167.9,68
X$4260 40 2234 2086 2154 2069 2153 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4261 m0 *1 175.26,68
X$4261 105 2087 105 40 2181 40 sky130_fd_sc_hd__inv_1
* cell instance $4264 m0 *1 184,68
X$4264 40 2237 2241 2070 1849 1581 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4266 m0 *1 192.28,68
X$4266 105 1814 1307 1973 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $4268 m0 *1 195.04,68
X$4268 40 1307 1581 2090 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $4269 m0 *1 199.18,68
X$4269 40 2089 1851 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $4270 m0 *1 203.32,68
X$4270 40 1379 1375 2090 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $4271 m0 *1 207.46,68
X$4271 105 1655 2007 2238 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4272 m0 *1 208.84,68
X$4272 105 1379 2236 105 2141 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $4273 m0 *1 212.06,68
X$4273 105 1966 40 105 2137 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $4274 m0 *1 215.28,68
X$4274 105 2508 2233 2231 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4275 m0 *1 218.5,68
X$4275 105 1540 2092 2229 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4278 m0 *1 222.64,68
X$4278 105 1745 2137 1895 1506 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4279 m0 *1 224.48,68
X$4279 40 1812 2090 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $4280 m0 *1 229.54,68
X$4280 105 1814 2183 2132 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $4281 m0 *1 231.84,68
X$4281 105 2094 1502 2422 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4282 m0 *1 235.06,68
X$4282 105 2053 2095 2094 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4283 m0 *1 238.28,68
X$4283 40 40 2096 1611 1812 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4284 m0 *1 240.58,68
X$4284 105 1812 1775 2224 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $4286 m0 *1 243.8,68
X$4286 105 2097 2129 2095 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4288 m0 *1 247.48,68
X$4288 105 1376 2096 2128 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4291 m0 *1 250.24,68
X$4291 105 2319 2010 2098 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4292 m0 *1 253.46,68
X$4292 105 2126 2098 2124 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4295 m0 *1 258.98,68
X$4295 40 2220 2218 2123 2310 2099 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4298 m0 *1 269.1,68
X$4298 105 2122 105 40 2216 40 sky130_fd_sc_hd__inv_1
* cell instance $4299 m0 *1 270.48,68
X$4299 40 2100 1007 1309 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $4300 m0 *1 274.62,68
X$4300 105 1655 2100 2121 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4305 m0 *1 278.76,68
X$4305 105 2012 105 40 2212 40 sky130_fd_sc_hd__inv_1
* cell instance $4307 m0 *1 280.6,68
X$4307 105 1655 1610 2101 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4308 m0 *1 281.98,68
X$4308 105 2101 105 40 1861 40 sky130_fd_sc_hd__inv_1
* cell instance $4311 m0 *1 286.12,68
X$4311 40 1610 1792 2090 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $4312 m0 *1 290.26,68
X$4312 40 1404 1560 2187 2117 2487 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4315 m0 *1 299,68
X$4315 105 2207 40 105 1707 40 sky130_fd_sc_hd__inv_2
* cell instance $4321 m0 *1 310.04,68
X$4321 40 2114 2113 1862 105 1613 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4322 m0 *1 314.64,68
X$4322 40 1397 2198 2200 2199 2300 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4323 m0 *1 322,68
X$4323 105 2198 105 40 2112 40 sky130_fd_sc_hd__inv_1
* cell instance $4327 m0 *1 329.82,68
X$4327 105 2027 1615 2109 40 105 1935 40 sky130_fd_sc_hd__a21o_1
* cell instance $4329 m0 *1 333.04,68
X$4329 105 2195 2196 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $4330 m0 *1 334.42,68
X$4330 40 2190 2288 2291 105 1702 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4331 m0 *1 339.02,68
X$4331 40 2289 2108 2193 750 2103 2194 105 105 40 sky130_fd_sc_hd__o41ai_4
* cell instance $4332 r0 *1 1.38,68
X$4332 105 2155 2243 1979 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4333 r0 *1 2.76,68
X$4333 105 2156 1979 2159 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $4334 r0 *1 5.06,68
X$4334 105 2286 2287 2157 105 1139 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4335 r0 *1 7.82,68
X$4335 105 2155 2158 2159 40 105 2287 40 sky130_fd_sc_hd__a21oi_1
* cell instance $4337 r0 *1 10.12,68
X$4337 105 2157 2159 2158 105 40 2026 40 sky130_fd_sc_hd__o21ai_1
* cell instance $4339 r0 *1 13.8,68
X$4339 105 2292 2387 2294 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4342 r0 *1 15.64,68
X$4342 40 2071 1590 2160 2156 105 105 40 sky130_fd_sc_hd__and3_4
* cell instance $4343 r0 *1 19.78,68
X$4343 105 2026 1979 1980 105 812 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4344 r0 *1 22.54,68
X$4344 105 2201 2299 2297 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4346 r0 *1 24.84,68
X$4346 105 1874 2161 2394 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4347 r0 *1 26.22,68
X$4347 40 1981 2162 1983 2074 105 105 40 sky130_fd_sc_hd__xnor3_1
* cell instance $4350 r0 *1 39.1,68
X$4350 105 2401 2163 2208 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4351 r0 *1 40.48,68
X$4351 105 2246 2247 2164 2163 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4356 r0 *1 43.7,68
X$4356 105 2164 2165 2211 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4358 r0 *1 45.54,68
X$4358 105 2167 2309 2166 2165 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4360 r0 *1 48.3,68
X$4360 105 2403 2166 2215 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $4362 r0 *1 51.06,68
X$4362 40 2248 2309 1988 105 2076 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4364 r0 *1 59.34,68
X$4364 105 2079 1722 2406 2168 105 40 2081 40 sky130_fd_sc_hd__o31ai_1
* cell instance $4365 r0 *1 62.1,68
X$4365 105 2036 2169 2168 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4368 r0 *1 66.24,68
X$4368 105 1952 2311 1836 2170 105 2313 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $4372 r0 *1 70.84,68
X$4372 105 2170 2219 2171 105 2037 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4373 r0 *1 73.6,68
X$4373 105 2170 2171 2219 2217 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4375 r0 *1 79.12,68
X$4375 40 2254 2133 1988 105 2253 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4376 r0 *1 83.72,68
X$4376 105 2173 1731 2320 2317 105 40 2175 40 sky130_fd_sc_hd__o31ai_1
* cell instance $4378 r0 *1 87.4,68
X$4378 40 40 2174 105 2257 2258 105 sky130_fd_sc_hd__nor2_2
* cell instance $4379 r0 *1 89.7,68
X$4379 105 2174 40 105 2221 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $4380 r0 *1 92.92,68
X$4380 40 2259 2257 1986 105 2175 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4384 r0 *1 98.44,68
X$4384 105 2259 2260 2222 2322 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4385 r0 *1 100.28,68
X$4385 105 2175 2176 2261 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4387 r0 *1 105.34,68
X$4387 40 2042 1686 2177 1760 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $4391 r0 *1 118.68,68
X$4391 40 2178 1964 2179 105 2324 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4394 r0 *1 124.2,68
X$4394 105 2180 105 40 2225 40 sky130_fd_sc_hd__inv_1
* cell instance $4397 r0 *1 126.96,68
X$4397 105 2178 105 40 2143 40 sky130_fd_sc_hd__inv_1
* cell instance $4398 r0 *1 128.34,68
X$4398 40 2426 2180 1222 2263 2052 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4399 r0 *1 135.7,68
X$4399 105 2263 40 105 1520 40 sky130_fd_sc_hd__inv_2
* cell instance $4403 r0 *1 142.14,68
X$4403 105 2052 40 105 1061 40 sky130_fd_sc_hd__inv_2
* cell instance $4408 r0 *1 151.8,68
X$4408 105 2230 105 40 2264 40 sky130_fd_sc_hd__inv_1
* cell instance $4410 r0 *1 153.64,68
X$4410 40 2265 2085 2333 2232 2264 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4411 r0 *1 161,68
X$4411 40 2865 2228 2522 2334 2265 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4413 r0 *1 169.28,68
X$4413 105 2235 105 40 2334 40 sky130_fd_sc_hd__inv_1
* cell instance $4416 r0 *1 174.8,68
X$4416 105 2434 2068 2335 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4422 r0 *1 182.16,68
X$4422 105 2237 105 40 2336 40 sky130_fd_sc_hd__inv_1
* cell instance $4425 r0 *1 186.3,68
X$4425 105 2239 105 40 1750 40 sky130_fd_sc_hd__inv_1
* cell instance $4426 r0 *1 187.68,68
X$4426 105 2240 105 40 2338 40 sky130_fd_sc_hd__inv_1
* cell instance $4429 r0 *1 190.44,68
X$4429 105 2241 105 40 2268 40 sky130_fd_sc_hd__inv_1
* cell instance $4432 r0 *1 194.58,68
X$4432 105 1655 1772 2001 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4433 r0 *1 195.96,68
X$4433 105 1973 105 40 2242 40 sky130_fd_sc_hd__inv_1
* cell instance $4434 r0 *1 197.34,68
X$4434 40 2618 2269 2242 2239 1849 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4436 r0 *1 204.7,68
X$4436 105 1772 40 105 2236 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $4439 r0 *1 208.84,68
X$4439 105 2141 1965 2182 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4440 r0 *1 212.06,68
X$4440 105 1814 2182 2332 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4441 r0 *1 213.44,68
X$4441 105 2332 2231 2331 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4442 r0 *1 216.66,68
X$4442 105 1892 1853 1607 2328 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4445 r0 *1 219.88,68
X$4445 105 2327 2229 2430 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4446 r0 *1 223.1,68
X$4446 105 2096 1775 2326 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4448 r0 *1 227.24,68
X$4448 105 1471 2183 105 1133 40 40 sky130_fd_sc_hd__and2_2
* cell instance $4451 r0 *1 231.84,68
X$4451 40 40 2424 2263 1309 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4456 r0 *1 237.82,68
X$4456 40 1228 1568 2224 2321 2323 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4459 r0 *1 247.48,68
X$4459 105 2090 2223 1854 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4462 r0 *1 251.62,68
X$4462 40 2127 1636 2316 2218 2315 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4464 r0 *1 258.98,68
X$4464 105 2220 2184 2097 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4470 r0 *1 266.34,68
X$4470 40 2184 2310 2216 2212 2279 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4471 r0 *1 273.7,68
X$4471 105 2185 105 40 2279 40 sky130_fd_sc_hd__inv_1
* cell instance $4473 r0 *1 276.92,68
X$4473 40 2185 2308 2014 2186 1792 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4476 r0 *1 286.12,68
X$4476 105 2186 105 40 1614 40 sky130_fd_sc_hd__inv_1
* cell instance $4482 r0 *1 300.84,68
X$4482 40 2206 2204 2205 2306 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $4483 r0 *1 310.04,68
X$4483 40 2188 2189 2282 105 2304 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4485 r0 *1 314.64,68
X$4485 105 2203 105 40 2300 40 sky130_fd_sc_hd__inv_1
* cell instance $4486 r0 *1 316.02,68
X$4486 105 2189 105 40 2302 40 sky130_fd_sc_hd__inv_1
* cell instance $4487 r0 *1 317.4,68
X$4487 105 2188 105 40 2200 40 sky130_fd_sc_hd__inv_1
* cell instance $4489 r0 *1 319.24,68
X$4489 40 2199 2295 2114 105 2298 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4493 r0 *1 330.28,68
X$4493 40 2027 2283 1937 105 2293 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4495 r0 *1 335.8,68
X$4495 40 2192 2024 1932 2288 2290 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4497 r0 *1 343.16,68
X$4497 105 2023 2029 1700 2194 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $4498 r0 *1 345,68
X$4498 105 2191 2472 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $4500 r0 *1 346.84,68
X$4500 105 2192 105 40 2107 40 sky130_fd_sc_hd__inv_1
* cell instance $4529 m0 *1 2.3,73.44
X$4529 105 2155 2159 2340 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4530 m0 *1 3.68,73.44
X$4530 105 2157 2340 2286 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4531 m0 *1 5.06,73.44
X$4531 40 2161 2160 2557 1450 2343 105 105 40 sky130_fd_sc_hd__and4b_1
* cell instance $4532 m0 *1 8.74,73.44
X$4532 105 2155 2157 2243 1905 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $4534 m0 *1 11.96,73.44
X$4534 105 2292 2387 2388 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $4535 m0 *1 14.26,73.44
X$4535 40 2301 2344 2156 2202 2345 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $4536 m0 *1 21.62,73.44
X$4536 105 2292 2387 2245 2389 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $4538 m0 *1 23.92,73.44
X$4538 40 2303 1561 2245 1450 2394 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $4544 m0 *1 35.42,73.44
X$4544 105 2347 40 105 2568 40 sky130_fd_sc_hd__inv_2
* cell instance $4546 m0 *1 37.72,73.44
X$4546 105 2246 2164 2247 105 2401 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4547 m0 *1 40.48,73.44
X$4547 40 2167 2247 1986 105 2210 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4548 m0 *1 45.08,73.44
X$4548 105 2167 2166 2309 105 2164 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4549 m0 *1 47.84,73.44
X$4549 105 2248 2249 2492 105 2166 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4551 m0 *1 51.06,73.44
X$4551 105 2491 2249 2250 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $4553 m0 *1 53.82,73.44
X$4553 105 2405 2075 2250 40 105 2077 40 sky130_fd_sc_hd__a21oi_1
* cell instance $4557 m0 *1 57.5,73.44
X$4557 40 2350 2080 2251 105 2169 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4560 m0 *1 69.46,73.44
X$4560 105 1989 2352 2252 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4561 m0 *1 70.84,73.44
X$4561 105 2219 1989 2354 2252 105 40 2253 40 sky130_fd_sc_hd__o31ai_1
* cell instance $4562 m0 *1 73.6,73.44
X$4562 105 2353 2314 2410 105 2219 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4565 m0 *1 79.12,73.44
X$4565 105 2254 2256 2255 105 2173 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4567 m0 *1 82.34,73.44
X$4567 105 2254 2255 2256 2320 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4569 m0 *1 84.64,73.44
X$4569 105 1731 2253 2317 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4572 m0 *1 90.16,73.44
X$4572 40 1200 2639 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $4573 m0 *1 95.68,73.44
X$4573 105 2259 2260 2222 105 2258 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4574 m0 *1 98.44,73.44
X$4574 105 2322 2258 2417 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $4575 m0 *1 100.74,73.44
X$4575 105 2418 2176 2502 40 105 2262 40 sky130_fd_sc_hd__a21oi_1
* cell instance $4576 m0 *1 102.58,73.44
X$4576 105 2261 2176 2417 40 105 2177 40 sky130_fd_sc_hd__a21oi_1
* cell instance $4579 m0 *1 105.8,73.44
X$4579 40 2361 1994 1986 105 2262 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4580 m0 *1 110.4,73.44
X$4580 105 2361 2420 1917 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4582 m0 *1 112.24,73.44
X$4582 105 2421 2361 1994 40 105 2419 40 sky130_fd_sc_hd__a21o_1
* cell instance $4586 m0 *1 121.44,73.44
X$4586 105 802 2425 105 2325 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $4590 m0 *1 130.64,73.44
X$4590 105 2426 105 40 2428 40 sky130_fd_sc_hd__inv_1
* cell instance $4592 m0 *1 133.86,73.44
X$4592 40 2226 2429 2330 105 2329 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4600 m0 *1 156.4,73.44
X$4600 105 2431 105 40 2333 40 sky130_fd_sc_hd__inv_1
* cell instance $4603 m0 *1 159.16,73.44
X$4603 40 2600 2521 2433 2063 2181 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4606 m0 *1 167.44,73.44
X$4606 40 2363 2235 2152 2267 2266 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4607 m0 *1 174.8,73.44
X$4607 105 2086 40 105 2435 40 sky130_fd_sc_hd__inv_2
* cell instance $4608 m0 *1 176.18,73.44
X$4608 40 2608 2267 2365 2336 2516 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4610 m0 *1 184.46,73.44
X$4610 40 2266 1974 2268 2337 2338 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4614 m0 *1 195.04,73.44
X$4614 105 2269 105 40 2365 40 sky130_fd_sc_hd__inv_1
* cell instance $4615 m0 *1 196.42,73.44
X$4615 40 2364 2619 2238 2270 2239 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4616 m0 *1 203.78,73.44
X$4616 105 1658 2366 2367 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4617 m0 *1 205.16,73.44
X$4617 40 1895 2007 1966 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $4618 m0 *1 209.3,73.44
X$4618 40 2425 2458 2271 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $4619 m0 *1 215.28,73.44
X$4619 105 2331 2430 2271 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4622 m0 *1 222.64,73.44
X$4622 105 1471 2326 2327 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4623 m0 *1 224.02,73.44
X$4623 40 40 2096 2362 1309 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4624 m0 *1 226.32,73.44
X$4624 40 2369 2052 1309 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $4627 m0 *1 231.84,73.44
X$4627 105 2272 2423 2273 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4629 m0 *1 235.98,73.44
X$4629 105 2273 1611 2846 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4630 m0 *1 239.2,73.44
X$4630 105 1376 2274 2323 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4632 m0 *1 241.04,73.44
X$4632 105 2275 2368 2321 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4634 m0 *1 242.88,73.44
X$4634 105 2275 2274 1735 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $4638 m0 *1 250.24,73.44
X$4638 40 2319 2316 2494 2318 2416 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4640 m0 *1 258.06,73.44
X$4640 40 2315 1777 2043 2312 2414 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4643 m0 *1 266.8,73.44
X$4643 105 2276 105 40 2312 40 sky130_fd_sc_hd__inv_1
* cell instance $4644 m0 *1 268.18,73.44
X$4644 105 2277 105 40 2413 40 sky130_fd_sc_hd__inv_1
* cell instance $4646 m0 *1 270.02,73.44
X$4646 40 2411 1779 2280 1792 2014 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4649 m0 *1 278.3,73.44
X$4649 40 2099 2276 2407 2404 2308 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4650 m0 *1 285.66,73.44
X$4650 40 1720 2277 1928 105 1862 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4652 m0 *1 291.18,73.44
X$4652 105 2402 105 40 1928 40 sky130_fd_sc_hd__inv_1
* cell instance $4653 m0 *1 292.56,73.44
X$4653 105 1376 2374 2307 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4654 m0 *1 293.94,73.44
X$4654 40 2306 2282 1792 2398 2307 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4656 m0 *1 302.22,73.44
X$4656 105 1929 40 105 1613 40 sky130_fd_sc_hd__inv_2
* cell instance $4657 m0 *1 303.6,73.44
X$4657 105 1376 1610 2305 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4659 m0 *1 305.44,73.44
X$4659 40 2396 2304 2207 105 2305 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4661 m0 *1 310.96,73.44
X$4661 105 1789 1862 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $4663 m0 *1 314.64,73.44
X$4663 40 2392 2298 1613 105 2377 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4664 m0 *1 319.24,73.44
X$4664 105 2393 105 40 2296 40 sky130_fd_sc_hd__inv_1
* cell instance $4668 m0 *1 323.84,73.44
X$4668 40 1557 1314 2390 105 2483 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4669 m0 *1 328.44,73.44
X$4669 105 3144 2382 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $4670 m0 *1 329.82,73.44
X$4670 105 2283 105 40 2290 40 sky130_fd_sc_hd__inv_1
* cell instance $4671 m0 *1 331.2,73.44
X$4671 105 2190 105 40 2293 40 sky130_fd_sc_hd__inv_1
* cell instance $4673 m0 *1 333.04,73.44
X$4673 105 2386 105 40 1936 40 sky130_fd_sc_hd__inv_1
* cell instance $4674 m0 *1 334.42,73.44
X$4674 105 2379 105 40 2291 40 sky130_fd_sc_hd__inv_1
* cell instance $4676 m0 *1 336.26,73.44
X$4676 105 1615 2016 2289 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4678 m0 *1 339.94,73.44
X$4678 40 2747 1863 2284 2385 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $4680 r0 *1 1.84,73.44
X$4680 105 2339 2383 2965 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4681 r0 *1 3.22,73.44
X$4681 105 1522 2384 2341 40 105 2473 40 sky130_fd_sc_hd__a21oi_1
* cell instance $4682 r0 *1 5.06,73.44
X$4682 105 2477 2342 2475 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4683 r0 *1 6.44,73.44
X$4683 105 3001 423 2437 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4684 r0 *1 7.82,73.44
X$4684 105 2244 2479 2623 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4685 r0 *1 9.2,73.44
X$4685 40 2155 2160 2157 2243 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $4689 r0 *1 16.1,73.44
X$4689 40 2073 2388 2389 105 1825 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $4690 r0 *1 21.16,73.44
X$4690 40 1980 2345 2202 2344 2301 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $4691 r0 *1 25.76,73.44
X$4691 105 2292 2346 1561 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $4692 r0 *1 28.06,73.44
X$4692 40 2397 2345 2439 2526 1450 105 105 40 sky130_fd_sc_hd__or4_4
* cell instance $4693 r0 *1 32.2,73.44
X$4693 105 1983 40 105 2397 40 sky130_fd_sc_hd__inv_2
* cell instance $4694 r0 *1 33.58,73.44
X$4694 105 2347 2488 105 1672 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $4697 r0 *1 38.18,73.44
X$4697 40 2246 2348 1760 105 2209 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4700 r0 *1 43.24,73.44
X$4700 40 40 2347 105 2401 2348 105 sky130_fd_sc_hd__nor2_2
* cell instance $4702 r0 *1 47.38,73.44
X$4702 105 2248 2492 2249 2403 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4703 r0 *1 49.22,73.44
X$4703 40 2441 2492 2251 105 2349 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4704 r0 *1 53.82,73.44
X$4704 105 2075 2349 2405 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4706 r0 *1 58.88,73.44
X$4706 105 2350 2408 2443 105 2079 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4707 r0 *1 61.64,73.44
X$4707 105 2350 2443 2408 2406 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4710 r0 *1 64.86,73.44
X$4710 40 2409 998 2351 2313 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $4714 r0 *1 70.84,73.44
X$4714 40 2353 2171 2251 105 2352 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4715 r0 *1 75.44,73.44
X$4715 105 2353 2410 2314 2354 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4717 r0 *1 77.74,73.44
X$4717 40 2447 2255 2251 105 2355 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4718 r0 *1 82.34,73.44
X$4718 105 1592 105 40 1731 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $4719 r0 *1 84.18,73.44
X$4719 105 1731 2355 2356 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4720 r0 *1 85.56,73.44
X$4720 105 2256 1731 2499 2356 105 40 2358 40 sky130_fd_sc_hd__o31ai_1
* cell instance $4721 r0 *1 88.32,73.44
X$4721 105 1200 40 2357 105 40 sky130_fd_sc_hd__buf_2
* cell instance $4722 r0 *1 90.16,73.44
X$4722 105 2501 2449 2359 2415 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4723 r0 *1 92,73.44
X$4723 40 2501 2260 1988 105 2358 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4725 r0 *1 96.6,73.44
X$4725 105 2176 2358 2418 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4728 r0 *1 98.9,73.44
X$4728 40 2357 2176 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $4730 r0 *1 108.56,73.44
X$4730 105 2419 40 105 2451 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $4731 r0 *1 111.78,73.44
X$4731 105 2420 2361 2510 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4735 r0 *1 118.22,73.44
X$4735 40 2046 2593 2362 1520 2009 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4739 r0 *1 126.5,73.44
X$4739 40 2594 2512 2009 1520 1061 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4742 r0 *1 138,73.44
X$4742 40 2145 2514 2515 105 736 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4743 r0 *1 142.6,73.44
X$4743 40 2453 2598 642 105 1133 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4744 r0 *1 147.2,73.44
X$4744 105 2362 105 40 2454 40 sky130_fd_sc_hd__inv_1
* cell instance $4745 r0 *1 148.58,73.44
X$4745 40 2431 2456 2432 105 2454 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4750 r0 *1 157.78,73.44
X$4750 40 2432 2433 1747 105 1539 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4751 r0 *1 162.38,73.44
X$4751 40 2602 2603 2520 2521 2456 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4752 r0 *1 169.74,73.44
X$4752 105 2234 2364 2519 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4754 r0 *1 173.42,73.44
X$4754 105 2516 1997 2434 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4761 r0 *1 186.76,73.44
X$4761 40 2611 2088 1849 2270 2239 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4762 r0 *1 194.12,73.44
X$4762 40 2513 2337 2239 2005 2270 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4763 r0 *1 201.48,73.44
X$4763 40 40 1545 2270 2090 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4764 r0 *1 203.78,73.44
X$4764 40 40 2367 2239 2090 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4766 r0 *1 206.08,73.44
X$4766 40 40 2007 1849 2090 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4768 r0 *1 208.84,73.44
X$4768 105 2366 40 105 1606 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $4769 r0 *1 212.06,73.44
X$4769 40 1546 2739 2507 105 105 40 sky130_fd_sc_hd__dfxtp_4
* cell instance $4770 r0 *1 220.8,73.44
X$4770 105 1546 2274 2457 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $4771 r0 *1 223.1,73.44
X$4771 105 1471 2368 2503 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4773 r0 *1 225.4,73.44
X$4773 40 1745 2193 2427 2459 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $4774 r0 *1 231.38,73.44
X$4774 105 1814 2369 2500 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4776 r0 *1 232.76,73.44
X$4776 105 2500 2422 2498 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4780 r0 *1 240.58,73.44
X$4780 40 2497 855 2008 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $4781 r0 *1 246.56,73.44
X$4781 40 2371 2318 2461 105 1256 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4783 r0 *1 252.08,73.44
X$4783 40 1497 2372 2370 105 1613 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4784 r0 *1 256.68,73.44
X$4784 105 2371 105 40 2370 40 sky130_fd_sc_hd__inv_1
* cell instance $4785 r0 *1 258.06,73.44
X$4785 105 2372 105 40 2416 40 sky130_fd_sc_hd__inv_1
* cell instance $4789 r0 *1 262.2,73.44
X$4789 105 2373 105 40 2414 40 sky130_fd_sc_hd__inv_1
* cell instance $4792 r0 *1 265.88,73.44
X$4792 40 2373 2412 2413 2464 2411 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4793 r0 *1 273.24,73.44
X$4793 105 2412 105 40 1634 40 sky130_fd_sc_hd__inv_1
* cell instance $4797 r0 *1 277.84,73.44
X$4797 105 1655 2374 2280 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4799 r0 *1 281.06,73.44
X$4799 105 1655 2375 2186 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4800 r0 *1 282.44,73.44
X$4800 105 2376 105 40 2404 40 sky130_fd_sc_hd__inv_1
* cell instance $4801 r0 *1 283.82,73.44
X$4801 40 2376 2400 2186 2402 2207 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4804 r0 *1 291.64,73.44
X$4804 105 2400 105 40 2464 40 sky130_fd_sc_hd__inv_1
* cell instance $4806 r0 *1 296.7,73.44
X$4806 105 2275 1921 2398 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4809 r0 *1 299.46,73.44
X$4809 105 2090 2399 2207 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4811 r0 *1 304.52,73.44
X$4811 40 2378 2203 2396 105 2485 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4813 r0 *1 310.04,73.44
X$4813 105 2378 105 40 2395 40 sky130_fd_sc_hd__inv_1
* cell instance $4814 r0 *1 311.42,73.44
X$4814 40 2393 2391 2395 2392 2484 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4817 r0 *1 319.24,73.44
X$4817 105 2391 105 40 2390 40 sky130_fd_sc_hd__inv_1
* cell instance $4821 r0 *1 328.44,73.44
X$4821 40 2111 2379 2482 105 2193 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4822 r0 *1 333.04,73.44
X$4822 40 2386 1316 2480 105 2481 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4823 r0 *1 337.64,73.44
X$4823 40 9551 2380 2379 105 1702 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4825 r0 *1 342.24,73.44
X$4825 40 2478 2474 2019 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $4827 r0 *1 346.84,73.44
X$4827 105 1702 2380 2105 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $4854 m0 *1 1.38,78.88
X$4854 105 2243 2155 1450 2157 40 2523 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $4855 m0 *1 3.68,78.88
X$4855 40 2436 2523 2343 2161 105 2476 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $4856 m0 *1 8.28,78.88
X$4856 40 2557 1874 2071 2437 105 1076 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $4857 m0 *1 16.1,78.88
X$4857 105 2297 2524 105 2387 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $4858 m0 *1 19.32,78.88
X$4858 105 2294 2560 2073 105 1978 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $4860 m0 *1 23,78.88
X$4860 105 2760 2345 2301 105 2073 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $4861 m0 *1 26.22,78.88
X$4861 105 2525 2387 2346 2292 105 40 2343 40 sky130_fd_sc_hd__o31ai_1
* cell instance $4863 m0 *1 29.44,78.88
X$4863 105 2292 2346 1794 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4864 m0 *1 30.82,78.88
X$4864 40 40 1874 105 2397 2439 105 sky130_fd_sc_hd__nor2_2
* cell instance $4865 m0 *1 33.12,78.88
X$4865 40 1983 2527 2488 2568 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $4867 m0 *1 39.56,78.88
X$4867 105 2246 2570 2488 2248 105 2489 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $4869 m0 *1 42.32,78.88
X$4869 105 2528 2439 2409 2489 40 2436 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $4871 m0 *1 45.08,78.88
X$4871 105 2441 2440 2167 2573 105 2528 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $4873 m0 *1 48.3,78.88
X$4873 105 2441 2529 2442 105 2249 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4874 m0 *1 51.06,78.88
X$4874 105 2441 2442 2529 2491 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4879 m0 *1 59.34,78.88
X$4879 105 2036 2531 2533 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4880 m0 *1 60.72,78.88
X$4880 105 2408 2036 2686 2533 105 40 2352 40 sky130_fd_sc_hd__o31ai_1
* cell instance $4883 m0 *1 68.08,78.88
X$4883 105 1527 2353 2577 2576 105 2351 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $4885 m0 *1 71.3,78.88
X$4885 105 2576 2496 2688 105 2314 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4886 m0 *1 74.06,78.88
X$4886 105 2444 2535 2445 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4887 m0 *1 75.44,78.88
X$4887 105 2314 2444 2579 2445 105 40 2355 40 sky130_fd_sc_hd__o31ai_1
* cell instance $4890 m0 *1 82.34,78.88
X$4890 105 2447 2448 2446 2499 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $4892 m0 *1 84.64,78.88
X$4892 105 2447 2446 2448 105 2256 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4893 m0 *1 87.4,78.88
X$4893 40 1592 2637 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $4896 m0 *1 92.92,78.88
X$4896 105 2501 2359 2449 105 2222 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $4899 m0 *1 97.06,78.88
X$4899 105 2415 2222 2502 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $4900 m0 *1 99.36,78.88
X$4900 105 2361 2647 2583 2536 105 1595 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $4901 m0 *1 101.66,78.88
X$4901 105 2587 2450 2505 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $4902 m0 *1 103.96,78.88
X$4902 105 2451 2042 2589 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4903 m0 *1 107.18,78.88
X$4903 40 2536 2452 1988 105 2646 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4905 m0 *1 112.24,78.88
X$4905 105 2511 2536 3060 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4906 m0 *1 115.46,78.88
X$4906 105 2539 2536 2452 40 105 2421 40 sky130_fd_sc_hd__a21o_1
* cell instance $4909 m0 *1 120.98,78.88
X$4909 105 2593 105 40 2592 40 sky130_fd_sc_hd__inv_1
* cell instance $4913 m0 *1 128.34,78.88
X$4913 40 2699 2179 2454 2428 2512 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $4914 m0 *1 135.7,78.88
X$4914 105 2429 105 40 2597 40 sky130_fd_sc_hd__inv_1
* cell instance $4918 m0 *1 139.84,78.88
X$4918 40 2329 2596 2453 105 2514 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4919 m0 *1 144.44,78.88
X$4919 40 2709 2455 1061 105 736 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4920 m0 *1 149.04,78.88
X$4920 105 2453 2455 2599 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4924 m0 *1 163.3,78.88
X$4924 105 2602 105 40 2601 40 sky130_fd_sc_hd__inv_1
* cell instance $4925 m0 *1 164.68,78.88
X$4925 105 2603 105 40 2522 40 sky130_fd_sc_hd__inv_1
* cell instance $4929 m0 *1 169.28,78.88
X$4929 40 2520 2607 1903 105 2604 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4931 m0 *1 175.72,78.88
X$4931 105 2608 105 40 2518 40 sky130_fd_sc_hd__inv_1
* cell instance $4932 m0 *1 177.1,78.88
X$4932 40 2609 2542 1747 105 2457 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4934 m0 *1 185.38,78.88
X$4934 105 2611 105 40 2517 40 sky130_fd_sc_hd__inv_1
* cell instance $4938 m0 *1 193.2,78.88
X$4938 105 2270 105 40 2614 40 sky130_fd_sc_hd__inv_1
* cell instance $4942 m0 *1 197.34,78.88
X$4942 105 2618 105 40 2617 40 sky130_fd_sc_hd__inv_1
* cell instance $4943 m0 *1 198.72,78.88
X$4943 105 2005 40 105 2543 40 sky130_fd_sc_hd__inv_2
* cell instance $4946 m0 *1 201.48,78.88
X$4946 105 2619 105 40 2620 40 sky130_fd_sc_hd__inv_1
* cell instance $4949 m0 *1 205.62,78.88
X$4949 105 1814 2367 2509 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4950 m0 *1 207,78.88
X$4950 105 2509 2545 2615 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4951 m0 *1 210.22,78.88
X$4951 105 2853 2612 2458 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4952 m0 *1 213.44,78.88
X$4952 105 2506 2457 2508 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4953 m0 *1 216.66,78.88
X$4953 105 2504 2503 2605 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4954 m0 *1 219.88,78.88
X$4954 105 1608 2546 2504 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $4956 m0 *1 222.64,78.88
X$4956 40 2546 2547 2008 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $4957 m0 *1 228.62,78.88
X$4957 105 2460 2689 2423 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4958 m0 *1 231.84,78.88
X$4958 105 2595 2461 105 2460 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $4959 m0 *1 235.06,78.88
X$4959 40 40 2424 1023 2462 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4961 m0 *1 239.2,78.88
X$4961 40 2183 1959 2462 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $4963 m0 *1 245.18,78.88
X$4963 105 2590 105 40 2463 40 sky130_fd_sc_hd__inv_1
* cell instance $4969 m0 *1 251.16,78.88
X$4969 105 2584 2125 2495 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4970 m0 *1 254.38,78.88
X$4970 105 2582 105 40 2494 40 sky130_fd_sc_hd__inv_1
* cell instance $4972 m0 *1 256.68,78.88
X$4972 40 2582 2493 2463 105 1720 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4973 m0 *1 261.28,78.88
X$4973 105 2493 2277 2581 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $4974 m0 *1 264.5,78.88
X$4974 40 2213 2490 2772 105 2580 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4975 m0 *1 269.1,78.88
X$4975 105 1376 2369 2683 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4982 m0 *1 279.68,78.88
X$4982 105 2427 2459 2552 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $4986 m0 *1 284.28,78.88
X$4986 40 40 2399 2014 1655 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4987 m0 *1 286.58,78.88
X$4987 105 1655 2552 2402 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $4988 m0 *1 287.96,78.88
X$4988 40 1628 2487 2572 105 2486 105 40 sky130_fd_sc_hd__ha_1
* cell instance $4993 m0 *1 299.46,78.88
X$4993 40 40 2552 1929 2090 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4994 m0 *1 301.76,78.88
X$4994 40 40 2375 1789 2090 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $4998 m0 *1 306.36,78.88
X$4998 105 1376 2399 2675 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5001 m0 *1 309.12,78.88
X$5001 40 2466 2465 2566 105 2761 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5002 m0 *1 313.72,78.88
X$5002 105 2465 105 40 2484 40 sky130_fd_sc_hd__inv_1
* cell instance $5005 m0 *1 317.4,78.88
X$5005 105 2466 105 40 2565 40 sky130_fd_sc_hd__inv_1
* cell instance $5008 m0 *1 320.16,78.88
X$5008 40 2468 2467 2565 105 2674 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5010 m0 *1 325.22,78.88
X$5010 105 2467 105 40 2483 40 sky130_fd_sc_hd__inv_1
* cell instance $5011 m0 *1 326.6,78.88
X$5011 105 2468 105 40 2480 40 sky130_fd_sc_hd__inv_1
* cell instance $5013 m0 *1 329.82,78.88
X$5013 105 2562 105 40 2482 40 sky130_fd_sc_hd__inv_1
* cell instance $5014 m0 *1 331.2,78.88
X$5014 105 2555 2556 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5017 m0 *1 333.5,78.88
X$5017 105 2559 105 40 2481 40 sky130_fd_sc_hd__inv_1
* cell instance $5019 m0 *1 335.34,78.88
X$5019 105 2469 2669 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5020 m0 *1 336.72,78.88
X$5020 40 2747 2019 2284 2478 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5021 m0 *1 345.92,78.88
X$5021 105 2554 2750 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5022 m0 *1 347.3,78.88
X$5022 105 2471 2751 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5024 r0 *1 1.38,78.88
X$5024 40 2622 2558 2071 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $5025 r0 *1 11.5,78.88
X$5025 105 2622 2558 40 105 494 40 sky130_fd_sc_hd__nor2b_2
* cell instance $5029 r0 *1 15.64,78.88
X$5029 105 2625 2525 2560 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5031 r0 *1 19.78,78.88
X$5031 40 2299 2627 1629 2161 2301 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $5032 r0 *1 24.38,78.88
X$5032 105 2628 2563 2626 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5033 r0 *1 25.76,78.88
X$5033 105 2299 2627 2301 40 1826 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $5034 r0 *1 28.98,78.88
X$5034 40 40 1451 105 2526 2202 105 sky130_fd_sc_hd__nor2_2
* cell instance $5035 r0 *1 31.28,78.88
X$5035 105 2439 2299 2631 40 105 1906 40 sky130_fd_sc_hd__a21oi_1
* cell instance $5036 r0 *1 33.12,78.88
X$5036 40 40 1629 105 2628 2299 105 sky130_fd_sc_hd__nor2_2
* cell instance $5037 r0 *1 35.42,78.88
X$5037 105 2339 2567 2341 2631 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $5038 r0 *1 37.26,78.88
X$5038 40 2488 2527 1591 105 1754 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5044 r0 *1 47.84,78.88
X$5044 40 2573 2442 2532 105 2633 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5045 r0 *1 52.44,78.88
X$5045 105 2529 2684 2075 105 2530 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $5046 r0 *1 54.28,78.88
X$5046 105 2530 2633 2075 105 2169 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5048 r0 *1 57.96,78.88
X$5048 40 2634 2531 2443 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $5049 r0 *1 67.16,78.88
X$5049 105 2575 2534 2687 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5053 r0 *1 70.84,78.88
X$5053 105 2576 2688 2496 2579 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5055 r0 *1 73.6,78.88
X$5055 40 2576 2535 2410 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $5056 r0 *1 82.8,78.88
X$5056 40 2691 2636 2448 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $5057 r0 *1 92,78.88
X$5057 40 2638 2449 2251 105 2725 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5064 r0 *1 99.82,78.88
X$5064 40 2585 2538 2537 2176 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $5065 r0 *1 110.86,78.88
X$5065 105 2591 2536 2452 40 105 2420 40 sky130_fd_sc_hd__a21o_1
* cell instance $5067 r0 *1 114.08,78.88
X$5067 105 2539 40 105 2511 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5069 r0 *1 118.22,78.88
X$5069 40 2651 2540 2592 2541 2650 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5072 r0 *1 126.04,78.88
X$5072 105 2594 105 40 2650 40 sky130_fd_sc_hd__inv_1
* cell instance $5073 r0 *1 127.42,78.88
X$5073 105 2540 105 40 2698 40 sky130_fd_sc_hd__inv_1
* cell instance $5075 r0 *1 130.64,78.88
X$5075 40 2701 2705 2144 2142 2788 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5077 r0 *1 138.92,78.88
X$5077 105 2596 105 40 2707 40 sky130_fd_sc_hd__inv_1
* cell instance $5078 r0 *1 140.3,78.88
X$5078 105 990 40 105 2515 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5079 r0 *1 143.52,78.88
X$5079 40 2710 2866 2598 105 2709 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5086 r0 *1 154.1,78.88
X$5086 40 2708 2653 413 105 411 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5088 r0 *1 159.62,78.88
X$5088 105 2600 105 40 2706 40 sky130_fd_sc_hd__inv_1
* cell instance $5090 r0 *1 161.92,78.88
X$5090 40 2704 2703 2700 2601 2798 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5093 r0 *1 170.66,78.88
X$5093 105 2541 105 40 2604 40 sky130_fd_sc_hd__inv_1
* cell instance $5094 r0 *1 172.04,78.88
X$5094 105 2657 2542 2862 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5096 r0 *1 175.72,78.88
X$5096 40 2801 2657 2150 105 2609 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5102 r0 *1 183.54,78.88
X$5102 40 2002 2697 2696 105 2695 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5103 r0 *1 188.14,78.88
X$5103 105 1543 1850 2696 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5105 r0 *1 189.98,78.88
X$5105 40 2694 2693 2516 2614 2543 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $5108 r0 *1 202.4,78.88
X$5108 40 1773 1256 2544 2616 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5111 r0 *1 208.84,78.88
X$5111 105 2615 2605 2612 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5112 r0 *1 212.06,78.88
X$5112 105 2613 40 1814 105 40 sky130_fd_sc_hd__buf_2
* cell instance $5113 r0 *1 213.9,78.88
X$5113 105 1773 2610 2548 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5114 r0 *1 215.28,78.88
X$5114 105 2606 105 40 2507 40 sky130_fd_sc_hd__inv_1
* cell instance $5117 r0 *1 219.42,78.88
X$5117 40 2541 1775 1471 105 105 40 sky130_fd_sc_hd__nand2b_2
* cell instance $5118 r0 *1 222.64,78.88
X$5118 105 2427 2459 2547 105 2506 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $5120 r0 *1 224.94,78.88
X$5120 105 1608 2547 2690 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $5121 r0 *1 227.24,78.88
X$5121 40 1773 413 2427 2459 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5123 r0 *1 233.22,78.88
X$5123 105 1576 2368 2595 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5124 r0 *1 234.6,78.88
X$5124 105 1023 105 40 1805 40 sky130_fd_sc_hd__inv_1
* cell instance $5127 r0 *1 237.36,78.88
X$5127 105 2495 1959 2685 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5129 r0 *1 241.5,78.88
X$5129 40 2590 2549 2461 105 2548 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5130 r0 *1 246.1,78.88
X$5130 105 1696 2549 2550 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5132 r0 *1 251.16,78.88
X$5132 105 2588 105 40 2586 40 sky130_fd_sc_hd__inv_1
* cell instance $5133 r0 *1 252.54,78.88
X$5133 105 2581 2550 2584 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5136 r0 *1 258.52,78.88
X$5136 40 2278 1859 2777 105 2840 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5142 r0 *1 266.8,78.88
X$5142 40 2580 2578 1959 2681 2683 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5144 r0 *1 274.62,78.88
X$5144 40 2187 2011 2578 105 2680 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5146 r0 *1 279.68,78.88
X$5146 105 1543 2427 2459 2663 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5148 r0 *1 285.2,78.88
X$5148 105 2551 105 40 2486 40 sky130_fd_sc_hd__inv_1
* cell instance $5150 r0 *1 286.58,78.88
X$5150 105 2574 105 40 2572 40 sky130_fd_sc_hd__inv_1
* cell instance $5152 r0 *1 288.88,78.88
X$5152 105 2275 2183 2678 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $5154 r0 *1 291.64,78.88
X$5154 105 1692 2899 2553 2377 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5157 r0 *1 294.86,78.88
X$5157 105 2571 105 40 2677 40 sky130_fd_sc_hd__inv_1
* cell instance $5159 r0 *1 296.7,78.88
X$5159 40 2032 2281 2569 105 2677 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5161 r0 *1 302.22,78.88
X$5161 105 2275 1610 2676 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5162 r0 *1 303.6,78.88
X$5162 40 2485 2566 1789 2676 2675 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5170 r0 *1 323.84,78.88
X$5170 105 2564 105 40 2561 40 sky130_fd_sc_hd__inv_1
* cell instance $5173 r0 *1 327.52,78.88
X$5173 40 2028 2559 2561 105 2562 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5175 r0 *1 333.04,78.88
X$5175 40 2385 2673 1863 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5176 r0 *1 337.18,78.88
X$5176 40 2747 2555 2284 2833 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5180 r0 *1 347.76,78.88
X$5180 105 2670 2892 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5208 m0 *1 1.84,84.32
X$5208 105 2524 2621 2624 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5209 m0 *1 3.22,84.32
X$5209 105 2341 2384 2339 2752 40 105 2625 40 sky130_fd_sc_hd__a31oi_1
* cell instance $5210 m0 *1 5.52,84.32
X$5210 40 2341 2384 2623 1752 3089 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $5211 m0 *1 13.34,84.32
X$5211 40 2384 2341 105 2383 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $5213 m0 *1 21.16,84.32
X$5213 105 2624 2626 2627 2712 40 105 2344 40 sky130_fd_sc_hd__or4_2
* cell instance $5214 m0 *1 24.38,84.32
X$5214 105 2628 2299 2631 40 105 2438 40 sky130_fd_sc_hd__and3_2
* cell instance $5215 m0 *1 27.14,84.32
X$5215 105 2201 2524 2299 2752 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $5217 m0 *1 29.44,84.32
X$5217 105 2713 2629 2714 105 40 2346 40 sky130_fd_sc_hd__o21ai_1
* cell instance $5218 m0 *1 31.28,84.32
X$5218 105 2630 2628 2299 40 105 2713 40 sky130_fd_sc_hd__a21oi_1
* cell instance $5219 m0 *1 33.12,84.32
X$5219 40 2438 2714 1332 2630 105 105 40 sky130_fd_sc_hd__o21bai_4
* cell instance $5220 m0 *1 40.02,84.32
X$5220 105 2627 2768 2715 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5221 m0 *1 41.4,84.32
X$5221 105 2440 2570 2716 2769 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5222 m0 *1 43.24,84.32
X$5222 105 2440 2716 2570 105 2632 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5223 m0 *1 46,84.32
X$5223 40 1284 2719 2570 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $5224 m0 *1 50.14,84.32
X$5224 105 2573 2632 2717 105 2529 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5225 m0 *1 52.9,84.32
X$5225 105 2573 2717 2632 2684 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5230 m0 *1 58.42,84.32
X$5230 105 2634 2575 2635 105 2408 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5231 m0 *1 61.18,84.32
X$5231 105 2634 2635 2575 2686 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5232 m0 *1 63.02,84.32
X$5232 40 2036 2687 2719 2535 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $5234 m0 *1 69.46,84.32
X$5234 105 2311 2721 2577 105 2496 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5235 m0 *1 72.22,84.32
X$5235 105 2805 2720 2806 2534 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5239 m0 *1 80.04,84.32
X$5239 105 2691 2774 2773 105 2446 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5240 m0 *1 82.8,84.32
X$5240 105 2637 2636 2724 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5243 m0 *1 85.1,84.32
X$5243 105 2446 2637 2851 2724 105 40 2725 40 sky130_fd_sc_hd__o31ai_1
* cell instance $5247 m0 *1 91.08,84.32
X$5247 105 2638 2641 2640 105 2359 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5248 m0 *1 93.84,84.32
X$5248 105 2638 2640 2641 2642 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5250 m0 *1 96.6,84.32
X$5250 105 2781 2725 2639 105 2646 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5252 m0 *1 100.28,84.32
X$5252 105 2912 40 105 2727 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5254 m0 *1 104.42,84.32
X$5254 105 2644 40 105 2726 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5255 m0 *1 107.64,84.32
X$5255 105 2643 2645 2647 105 2783 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5259 m0 *1 112.24,84.32
X$5259 105 2648 2728 2539 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $5260 m0 *1 114.54,84.32
X$5260 105 2505 2649 2728 40 105 2591 40 sky130_fd_sc_hd__a21o_1
* cell instance $5261 m0 *1 117.3,84.32
X$5261 105 2042 2730 2727 2649 105 1596 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $5262 m0 *1 119.6,84.32
X$5262 105 2644 2649 2450 105 40 2648 40 sky130_fd_sc_hd__o21ai_1
* cell instance $5265 m0 *1 125.58,84.32
X$5265 40 2786 2733 2698 105 2699 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5266 m0 *1 130.18,84.32
X$5266 105 2786 105 40 2787 40 sky130_fd_sc_hd__inv_1
* cell instance $5268 m0 *1 132.02,84.32
X$5268 105 2701 2733 105 2790 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $5273 m0 *1 140.3,84.32
X$5273 105 2651 2791 2711 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5275 m0 *1 144.44,84.32
X$5275 105 2710 105 40 2792 40 sky130_fd_sc_hd__inv_1
* cell instance $5276 m0 *1 145.82,84.32
X$5276 105 2652 105 40 2736 40 sky130_fd_sc_hd__inv_1
* cell instance $5278 m0 *1 149.04,84.32
X$5278 105 2653 105 40 2793 40 sky130_fd_sc_hd__inv_1
* cell instance $5280 m0 *1 150.88,84.32
X$5280 40 2794 2652 2655 2708 2654 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5281 m0 *1 158.24,84.32
X$5281 40 2795 2798 2706 2702 2518 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5282 m0 *1 165.6,84.32
X$5282 105 2797 105 40 2702 40 sky130_fd_sc_hd__inv_1
* cell instance $5287 m0 *1 170.66,84.32
X$5287 105 2656 40 105 2700 40 sky130_fd_sc_hd__inv_2
* cell instance $5288 m0 *1 172.04,84.32
X$5288 40 2799 2656 2801 2607 2435 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5291 m0 *1 181.7,84.32
X$5291 40 2654 2697 1845 2517 2859 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $5292 m0 *1 189.98,84.32
X$5292 105 1692 2800 2616 2695 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5296 m0 *1 195.04,84.32
X$5296 40 2857 2797 2620 2796 2617 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5297 m0 *1 202.4,84.32
X$5297 40 2613 2739 2785 105 105 40 sky130_fd_sc_hd__dfxtp_1
* cell instance $5299 m0 *1 210.22,84.32
X$5299 105 2658 2610 105 2692 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $5300 m0 *1 213.44,84.32
X$5300 105 1892 2658 2545 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5301 m0 *1 214.82,84.32
X$5301 40 2546 2739 2789 105 105 40 sky130_fd_sc_hd__dfxtp_1
* cell instance $5303 m0 *1 222.64,84.32
X$5303 105 2427 2459 2546 105 2659 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $5306 m0 *1 225.86,84.32
X$5306 105 2690 2659 2689 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5309 m0 *1 230.46,84.32
X$5309 105 1471 2375 40 414 105 40 sky130_fd_sc_hd__and2_4
* cell instance $5310 m0 *1 233.68,84.32
X$5310 105 1812 2369 105 1806 40 40 sky130_fd_sc_hd__and2_2
* cell instance $5311 m0 *1 236.44,84.32
X$5311 105 2498 2685 2782 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5312 m0 *1 239.66,84.32
X$5312 105 2462 2006 105 40 40 sky130_fd_sc_hd__inv_6
* cell instance $5315 m0 *1 244.26,84.32
X$5315 105 1378 40 2275 105 40 sky130_fd_sc_hd__buf_2
* cell instance $5316 m0 *1 246.1,84.32
X$5316 105 2275 2096 2660 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $5321 m0 *1 250.7,84.32
X$5321 40 2588 2778 1805 2660 2779 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5323 m0 *1 258.98,84.32
X$5323 40 2776 2775 1806 2841 2682 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5324 m0 *1 266.34,84.32
X$5324 105 1576 40 105 1892 40 sky130_fd_sc_hd__inv_2
* cell instance $5325 m0 *1 267.72,84.32
X$5325 105 2275 2424 2681 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5328 m0 *1 271.4,84.32
X$5328 105 1576 2183 2661 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $5331 m0 *1 276,84.32
X$5331 105 2662 105 40 2680 40 sky130_fd_sc_hd__inv_1
* cell instance $5333 m0 *1 277.84,84.32
X$5333 40 2662 2574 2771 2679 2661 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5334 m0 *1 285.2,84.32
X$5334 105 2743 40 2770 105 40 sky130_fd_sc_hd__buf_2
* cell instance $5336 m0 *1 287.96,84.32
X$5336 40 2551 2665 1927 2678 2766 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5337 m0 *1 295.32,84.32
X$5337 105 1892 2889 2664 2837 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5338 m0 *1 297.16,84.32
X$5338 105 2665 105 40 2569 40 sky130_fd_sc_hd__inv_1
* cell instance $5342 m0 *1 303.6,84.32
X$5342 105 2275 2399 2667 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5344 m0 *1 305.44,84.32
X$5344 105 2275 2375 2762 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $5345 m0 *1 307.74,84.32
X$5345 105 1376 2375 2666 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5346 m0 *1 309.12,84.32
X$5346 40 2761 2758 1929 2667 2666 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5347 m0 *1 316.48,84.32
X$5347 40 2564 2668 2758 105 2759 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5348 m0 *1 321.08,84.32
X$5348 105 2668 105 40 2674 40 sky130_fd_sc_hd__inv_1
* cell instance $5350 m0 *1 323.38,84.32
X$5350 40 2747 2191 2284 2757 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5352 m0 *1 333.04,84.32
X$5352 40 2756 2746 2471 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5353 m0 *1 337.18,84.32
X$5353 105 2755 2672 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5355 m0 *1 339.48,84.32
X$5355 40 2747 2670 2284 2671 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5357 r0 *1 1.38,84.32
X$5357 40 2383 2753 2339 1282 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $5358 r0 *1 7.36,84.32
X$5358 40 2754 2341 2339 2155 2802 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $5363 r0 *1 15.64,84.32
X$5363 40 2341 2384 2339 105 2292 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $5364 r0 *1 22.08,84.32
X$5364 105 2299 2627 2626 2760 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $5365 r0 *1 24.38,84.32
X$5365 40 2526 2563 2712 2628 2629 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $5366 r0 *1 28.98,84.32
X$5366 40 2341 2384 2339 2162 2839 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $5367 r0 *1 36.8,84.32
X$5367 105 2074 2765 2767 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5369 r0 *1 38.64,84.32
X$5369 40 2764 2715 2767 2292 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5376 r0 *1 44.62,84.32
X$5376 40 2718 2769 2632 1284 105 105 40 sky130_fd_sc_hd__or3_4
* cell instance $5377 r0 *1 48.76,84.32
X$5377 40 2718 2531 2874 2933 2075 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $5378 r0 *1 56.58,84.32
X$5378 40 2720 2803 2635 2719 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $5379 r0 *1 65.78,84.32
X$5379 105 2720 2806 2805 105 2575 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5380 r0 *1 68.54,84.32
X$5380 105 2577 2311 2721 2722 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5386 r0 *1 71.76,84.32
X$5386 40 2906 2636 2496 2444 2722 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $5387 r0 *1 79.58,84.32
X$5387 40 2844 2723 2773 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $5388 r0 *1 88.78,84.32
X$5388 105 2637 2723 2850 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5389 r0 *1 90.16,84.32
X$5389 40 2808 2640 2807 105 2532 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5391 r0 *1 95.22,84.32
X$5391 105 2912 2729 2783 105 2644 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5396 r0 *1 98.44,84.32
X$5396 105 2359 2642 2639 105 2781 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $5398 r0 *1 100.74,84.32
X$5398 105 2643 40 105 2730 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5399 r0 *1 103.96,84.32
X$5399 105 2811 40 105 2854 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5401 r0 *1 107.64,84.32
X$5401 40 2649 2728 2251 105 2809 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5403 r0 *1 112.7,84.32
X$5403 105 2505 2649 2858 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5404 r0 *1 115.92,84.32
X$5404 105 2731 2729 2917 2812 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5405 r0 *1 117.76,84.32
X$5405 105 2732 40 105 2784 40 sky130_fd_sc_hd__inv_2
* cell instance $5414 r0 *1 126.96,84.32
X$5414 40 2861 2788 2815 2787 2597 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5415 r0 *1 134.32,84.32
X$5415 40 2863 2732 2705 2735 2734 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5416 r0 *1 141.68,84.32
X$5416 40 2791 2815 2793 2707 2792 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5424 r0 *1 154.56,84.32
X$5424 40 2868 2735 2737 2703 2865 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5425 r0 *1 161.92,84.32
X$5425 105 2363 105 40 2864 40 sky130_fd_sc_hd__inv_1
* cell instance $5426 r0 *1 163.3,84.32
X$5426 105 2821 2704 105 2738 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $5427 r0 *1 166.52,84.32
X$5427 105 2519 2738 2921 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5430 r0 *1 174.34,84.32
X$5430 105 2857 2799 2860 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5442 r0 *1 190.9,84.32
X$5442 40 2800 2740 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $5443 r0 *1 195.5,84.32
X$5443 40 2821 2796 2856 2693 2543 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5445 r0 *1 203.32,84.32
X$5445 40 2544 2740 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $5451 r0 *1 208.84,84.32
X$5451 40 2006 2693 2616 2740 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5453 r0 *1 215.74,84.32
X$5453 40 2547 2739 2741 105 105 40 sky130_fd_sc_hd__dfxtp_1
* cell instance $5454 r0 *1 223.1,84.32
X$5454 105 2606 2785 2741 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5455 r0 *1 224.48,84.32
X$5455 105 1471 2692 2849 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5465 r0 *1 237.36,84.32
X$5465 105 2849 2782 2845 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5466 r0 *1 240.58,84.32
X$5466 105 2846 2911 2847 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5467 r0 *1 243.8,84.32
X$5467 105 2274 1775 105 2843 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $5468 r0 *1 247.02,84.32
X$5468 40 2827 2907 2780 1773 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5469 r0 *1 253,84.32
X$5469 105 2842 42 3022 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5470 r0 *1 256.22,84.32
X$5470 105 1892 2780 2828 2779 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5471 r0 *1 258.06,84.32
X$5471 105 2778 105 40 2777 40 sky130_fd_sc_hd__inv_1
* cell instance $5476 r0 *1 259.9,84.32
X$5476 105 2776 105 40 2840 40 sky130_fd_sc_hd__inv_1
* cell instance $5482 r0 *1 266.34,84.32
X$5482 105 2775 105 40 2772 40 sky130_fd_sc_hd__inv_1
* cell instance $5486 r0 *1 275.54,84.32
X$5486 105 2275 2369 2679 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $5487 r0 *1 277.84,84.32
X$5487 105 1878 40 105 2771 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5489 r0 *1 281.52,84.32
X$5489 40 2006 2013 2770 2553 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5493 r0 *1 287.5,84.32
X$5493 40 40 2374 105 2743 2553 105 sky130_fd_sc_hd__nor2_2
* cell instance $5494 r0 *1 289.8,84.32
X$5494 105 1543 2888 2766 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5496 r0 *1 291.64,84.32
X$5496 105 2013 40 2838 105 40 sky130_fd_sc_hd__buf_2
* cell instance $5497 r0 *1 293.48,84.32
X$5497 40 2571 2763 2971 2838 2837 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5499 r0 *1 302.68,84.32
X$5499 105 2763 40 105 2204 40 sky130_fd_sc_hd__inv_2
* cell instance $5501 r0 *1 304.52,84.32
X$5501 40 2562 2744 2762 105 2663 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5503 r0 *1 310.04,84.32
X$5503 105 2744 105 40 2759 40 sky130_fd_sc_hd__inv_1
* cell instance $5516 r0 *1 326.6,84.32
X$5516 40 2757 2835 2191 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5518 r0 *1 331.2,84.32
X$5518 40 2747 2471 2284 2756 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5522 r0 *1 340.4,84.32
X$5522 40 2833 2831 2555 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5523 r0 *1 344.54,84.32
X$5523 105 2745 2893 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5526 r0 *1 346.84,84.32
X$5526 105 2749 2963 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5528 m0 *1 1.38,89.76
X$5528 40 2339 2383 2869 2753 105 1751 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $5529 m0 *1 9.2,89.76
X$5529 40 2341 2384 2623 2895 105 1869 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $5530 m0 *1 13.8,89.76
X$5530 40 2754 2299 2243 2201 2524 2621 105 105 40 sky130_fd_sc_hd__a41oi_4
* cell instance $5531 m0 *1 23.92,89.76
X$5531 105 2870 105 40 2341 40 sky130_fd_sc_hd__buf_4
* cell instance $5532 m0 *1 26.68,89.76
X$5532 40 2712 2714 2628 2630 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $5534 m0 *1 29.44,89.76
X$5534 40 2245 2341 2567 2339 2898 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $5535 m0 *1 32.66,89.76
X$5535 105 2712 40 2299 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $5536 m0 *1 35.42,89.76
X$5536 40 2627 2839 2074 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $5538 m0 *1 46.46,89.76
X$5538 40 2440 2717 2903 105 2803 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5545 m0 *1 64.4,89.76
X$5545 40 40 2875 105 2805 2036 105 sky130_fd_sc_hd__nor2_2
* cell instance $5547 m0 *1 67.16,89.76
X$5547 40 2311 2875 2688 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $5548 m0 *1 76.36,89.76
X$5548 40 2444 2723 2577 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $5550 m0 *1 81.42,89.76
X$5550 105 2774 2637 2848 2850 105 40 2807 40 sky130_fd_sc_hd__o31ai_1
* cell instance $5552 m0 *1 84.64,89.76
X$5552 105 2691 2773 2774 2851 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5554 m0 *1 86.94,89.76
X$5554 105 2908 2807 2639 105 2809 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5555 m0 *1 89.7,89.76
X$5555 105 2808 2852 2939 105 2641 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5556 m0 *1 92.46,89.76
X$5556 105 2910 2876 2639 105 2810 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5557 m0 *1 95.22,89.76
X$5557 40 9530 2645 1299 105 2804 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5558 m0 *1 99.82,89.76
X$5558 105 3109 40 105 3167 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5560 m0 *1 103.96,89.76
X$5560 105 2783 40 105 2915 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5561 m0 *1 107.18,89.76
X$5561 105 2727 40 105 2731 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5562 m0 *1 110.4,89.76
X$5562 105 2726 2812 2916 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5564 m0 *1 112.24,89.76
X$5564 105 2177 2813 2982 105 2877 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $5566 m0 *1 114.54,89.76
X$5566 40 2585 2918 2537 2814 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $5567 m0 *1 125.58,89.76
X$5567 40 2918 2785 2814 2585 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $5568 m0 *1 133.86,89.76
X$5568 105 2863 2861 2987 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5573 m0 *1 141.68,89.76
X$5573 40 2819 2816 414 105 990 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5574 m0 *1 146.28,89.76
X$5574 105 2866 2816 2817 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5575 m0 *1 149.5,89.76
X$5575 105 2817 2711 2867 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5577 m0 *1 153.18,89.76
X$5577 105 2868 2795 2818 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5578 m0 *1 156.4,89.76
X$5578 105 2818 2599 2820 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5579 m0 *1 159.62,89.76
X$5579 105 2794 105 40 2920 40 sky130_fd_sc_hd__inv_1
* cell instance $5582 m0 *1 163.76,89.76
X$5582 105 2820 2921 2923 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5586 m0 *1 170.2,89.76
X$5586 105 2862 2924 2998 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5588 m0 *1 175.26,89.76
X$5588 105 2860 2927 2926 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5591 m0 *1 185.84,89.76
X$5591 40 2859 2925 2822 105 2823 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5592 m0 *1 190.44,89.76
X$5592 105 1543 2740 2616 2822 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5594 m0 *1 192.74,89.76
X$5594 105 2513 105 40 2922 40 sky130_fd_sc_hd__inv_1
* cell instance $5599 m0 *1 197.8,89.76
X$5599 105 1692 2825 2824 2823 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5600 m0 *1 199.64,89.76
X$5600 105 2006 2825 2824 2856 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5602 m0 *1 202.4,89.76
X$5602 105 2825 2824 2919 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5603 m0 *1 203.78,89.76
X$5603 105 2855 2826 2853 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5604 m0 *1 207,89.76
X$5604 40 2880 2739 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $5605 m0 *1 216.2,89.76
X$5605 105 2606 2785 2881 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $5606 m0 *1 218.5,89.76
X$5606 105 2741 105 40 2882 40 sky130_fd_sc_hd__inv_1
* cell instance $5607 m0 *1 219.88,89.76
X$5607 105 2789 2882 2914 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $5609 m0 *1 222.64,89.76
X$5609 40 1773 2461 2825 2824 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $5610 m0 *1 226.32,89.76
X$5610 105 2606 2785 2789 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5611 m0 *1 227.7,89.76
X$5611 40 2462 2950 2914 105 105 40 sky130_fd_sc_hd__dfxtp_2
* cell instance $5613 m0 *1 235.98,89.76
X$5613 105 2462 105 40 1812 40 sky130_fd_sc_hd__buf_4
* cell instance $5615 m0 *1 239.2,89.76
X$5615 105 1924 2884 2980 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5616 m0 *1 242.42,89.76
X$5616 105 2847 2845 2842 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5618 m0 *1 246.56,89.76
X$5618 105 2843 2223 2883 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5621 m0 *1 252.08,89.76
X$5621 40 2907 2009 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $5622 m0 *1 256.22,89.76
X$5622 105 2827 40 105 2828 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5623 m0 *1 259.44,89.76
X$5623 105 1692 2780 2828 2841 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5625 m0 *1 264.96,89.76
X$5625 40 40 2424 105 2829 2953 105 sky130_fd_sc_hd__nor2_2
* cell instance $5626 m0 *1 267.26,89.76
X$5626 105 1892 2829 2905 2682 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5629 m0 *1 273.24,89.76
X$5629 40 2955 1878 2006 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $5632 m0 *1 278.3,89.76
X$5632 40 2886 2902 2553 1773 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5633 m0 *1 284.28,89.76
X$5633 40 2902 990 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $5634 m0 *1 288.42,89.76
X$5634 40 2006 1927 2664 2889 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5635 m0 *1 294.4,89.76
X$5635 40 2743 2886 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $5636 m0 *1 298.54,89.76
X$5636 40 2889 1921 2664 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $5643 m0 *1 310.5,89.76
X$5643 40 2747 2102 2897 2969 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5644 m0 *1 319.7,89.76
X$5644 40 2747 2755 2284 2896 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5647 m0 *1 333.04,89.76
X$5647 40 2284 9489 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $5648 m0 *1 338.1,89.76
X$5648 105 2830 2894 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5650 m0 *1 339.94,89.76
X$5650 40 2747 2966 2834 2891 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5653 r0 *1 1.84,89.76
X$5653 105 1522 2473 2965 105 892 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $5654 r0 *1 5.06,89.76
X$5654 40 2342 2339 2244 3033 2383 2477 105 105 40 sky130_fd_sc_hd__o32ai_4
* cell instance $5657 r0 *1 15.64,89.76
X$5657 40 2928 2339 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $5658 r0 *1 20.7,89.76
X$5658 40 2870 2567 2928 2202 2898 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $5659 r0 *1 28.52,89.76
X$5659 40 2898 2930 2629 2712 2628 105 105 40 sky130_fd_sc_hd__nand4b_2
* cell instance $5661 r0 *1 34.5,89.76
X$5661 40 1754 2768 2765 2292 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5662 r0 *1 38.64,89.76
X$5662 105 2900 2932 2931 2872 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5664 r0 *1 40.94,89.76
X$5664 105 2901 2970 2871 3038 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5667 r0 *1 43.24,89.76
X$5667 105 2873 2872 2768 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5670 r0 *1 46.92,89.76
X$5670 105 2933 3068 3041 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5671 r0 *1 48.3,89.76
X$5671 105 2874 2935 2903 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5674 r0 *1 55.2,89.76
X$5674 40 2633 3046 2975 2292 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5681 r0 *1 76.82,89.76
X$5681 105 2444 2875 2906 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5685 r0 *1 81.88,89.76
X$5685 105 2844 2937 2938 105 2774 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5687 r0 *1 85.56,89.76
X$5687 40 2938 2637 2876 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $5688 r0 *1 92.92,89.76
X$5688 105 2852 2940 2639 40 2910 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $5690 r0 *1 96.14,89.76
X$5690 105 2641 2977 1200 105 2908 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $5692 r0 *1 98.44,89.76
X$5692 105 2941 2942 2943 105 2913 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $5693 r0 *1 100.28,89.76
X$5693 40 2912 2810 2450 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $5694 r0 *1 109.48,89.76
X$5694 105 2810 40 105 2811 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5695 r0 *1 112.7,89.76
X$5695 105 2915 40 105 2917 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5696 r0 *1 115.92,89.76
X$5696 105 2729 2731 2941 105 40 2587 40 sky130_fd_sc_hd__o21ai_1
* cell instance $5697 r0 *1 117.76,89.76
X$5697 105 2878 2858 2985 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5706 r0 *1 135.24,89.76
X$5706 105 2987 2790 2879 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5715 r0 *1 159.16,89.76
X$5715 40 2990 2737 2864 2993 2920 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5716 r0 *1 166.52,89.76
X$5716 105 2867 2923 2995 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5717 r0 *1 169.74,89.76
X$5717 105 2998 2879 3057 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5718 r0 *1 172.96,89.76
X$5718 105 2335 2926 2999 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5719 r0 *1 176.18,89.76
X$5719 105 2997 2994 105 2927 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $5726 r0 *1 183.54,89.76
X$5726 40 2996 2655 2922 2925 2992 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5727 r0 *1 190.9,89.76
X$5727 40 2992 2947 2948 105 2989 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5728 r0 *1 195.5,89.76
X$5728 105 1692 2610 2989 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5730 r0 *1 198.72,89.76
X$5730 105 1543 2825 2824 2948 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5732 r0 *1 201.02,89.76
X$5732 105 1812 2949 2855 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5733 r0 *1 202.4,89.76
X$5733 105 2610 2919 2949 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5735 r0 *1 205.62,89.76
X$5735 105 2739 105 40 9518 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $5737 r0 *1 208.84,89.76
X$5737 40 1576 2986 2881 105 105 40 sky130_fd_sc_hd__dfxtp_2
* cell instance $5739 r0 *1 217.12,89.76
X$5739 40 1378 2739 2882 105 105 40 sky130_fd_sc_hd__dfxtp_4
* cell instance $5740 r0 *1 225.86,89.76
X$5740 40 2904 71 2950 2983 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5746 r0 *1 238.74,89.76
X$5746 105 1812 2883 2885 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5747 r0 *1 240.12,89.76
X$5747 105 2980 2885 2911 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5748 r0 *1 243.34,89.76
X$5748 105 2497 2951 2884 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5751 r0 *1 247.94,89.76
X$5751 105 2780 2979 2223 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5752 r0 *1 249.32,89.76
X$5752 40 2904 2195 2950 2909 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $5757 r0 *1 264.04,89.76
X$5757 105 2953 40 105 2905 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5758 r0 *1 267.26,89.76
X$5758 40 2904 2469 2950 2954 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5762 r0 *1 279.68,89.76
X$5762 40 2887 2974 1773 2956 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5763 r0 *1 285.66,89.76
X$5763 40 2974 532 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $5765 r0 *1 289.8,89.76
X$5765 105 1692 2888 2971 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5768 r0 *1 293.48,89.76
X$5768 105 2743 40 105 2899 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5769 r0 *1 296.7,89.76
X$5769 40 40 2399 105 2887 2956 105 sky130_fd_sc_hd__nor2_2
* cell instance $5771 r0 *1 299.46,89.76
X$5771 40 2747 2890 2897 3096 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5776 r0 *1 313.72,89.76
X$5776 40 2969 2968 2102 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5779 r0 *1 319.24,89.76
X$5779 105 2890 2832 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5780 r0 *1 320.62,89.76
X$5780 40 2896 2836 2755 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5782 r0 *1 325.68,89.76
X$5782 40 2747 2960 2284 2959 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5783 r0 *1 334.88,89.76
X$5783 40 3034 2284 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $5785 r0 *1 344.08,89.76
X$5785 105 3030 3031 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5789 r0 *1 347.76,89.76
X$5789 105 2966 2967 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5817 m0 *1 1.38,95.2
X$5817 40 2479 3033 1074 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $5818 m0 *1 11.5,95.2
X$5818 40 2244 2933 2383 3003 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5819 m0 *1 17.48,95.2
X$5819 40 2929 2928 2870 2384 105 2301 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $5822 m0 *1 29.44,95.2
X$5822 40 2630 2930 3005 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $5823 m0 *1 35.42,95.2
X$5823 105 2900 2931 2932 105 2873 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5824 m0 *1 38.18,95.2
X$5824 40 2931 2933 3038 2209 3039 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $5825 m0 *1 42.78,95.2
X$5825 105 3006 2933 3039 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5826 m0 *1 44.16,95.2
X$5826 40 2871 2933 3007 2210 3041 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $5827 m0 *1 48.76,95.2
X$5827 105 2972 3069 3008 3007 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5828 m0 *1 50.6,95.2
X$5828 105 3100 3009 2934 105 3008 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5829 m0 *1 53.36,95.2
X$5829 105 2935 3101 3042 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5832 m0 *1 57.04,95.2
X$5832 105 3047 2976 3010 105 3009 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5838 m0 *1 73.6,95.2
X$5838 40 3013 3131 2936 3071 105 105 40 sky130_fd_sc_hd__o21a_4
* cell instance $5843 m0 *1 84.64,95.2
X$5843 105 2844 2938 2937 2848 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5845 m0 *1 86.94,95.2
X$5845 105 2808 2939 2852 2977 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5846 m0 *1 88.78,95.2
X$5846 40 3014 2803 2939 2876 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $5848 m0 *1 98.44,95.2
X$5848 40 1200 3110 3016 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $5850 m0 *1 103.5,95.2
X$5850 40 3052 2854 2916 2813 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $5851 m0 *1 107.18,95.2
X$5851 105 2981 3017 40 105 2941 40 sky130_fd_sc_hd__nor2b_2
* cell instance $5852 m0 *1 110.4,95.2
X$5852 105 2878 2589 2982 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5855 m0 *1 112.7,95.2
X$5855 40 40 2510 3059 2878 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $5856 m0 *1 115,95.2
X$5856 40 40 3060 3062 2878 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $5857 m0 *1 117.3,95.2
X$5857 105 2813 2985 2809 105 40 2984 40 sky130_fd_sc_hd__o21ai_1
* cell instance $5858 m0 *1 119.14,95.2
X$5858 40 2585 3063 2537 2944 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $5860 m0 *1 130.64,95.2
X$5860 40 3063 2606 2944 2585 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $5863 m0 *1 139.84,95.2
X$5863 40 2904 735 2988 3019 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5866 m0 *1 150.42,95.2
X$5866 40 2904 1998 2988 3058 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5869 m0 *1 162.38,95.2
X$5869 105 3055 105 40 2993 40 sky130_fd_sc_hd__inv_1
* cell instance $5870 m0 *1 163.76,95.2
X$5870 105 2990 3020 2924 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5874 m0 *1 170.2,95.2
X$5874 105 2995 2945 2826 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5875 m0 *1 173.42,95.2
X$5875 105 2999 3057 2945 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $5876 m0 *1 176.64,95.2
X$5876 40 2997 3055 2946 2819 2996 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5877 m0 *1 184,95.2
X$5877 40 2994 2946 2947 2694 3054 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $5878 m0 *1 191.36,95.2
X$5878 105 1692 2658 3053 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5879 m0 *1 192.74,95.2
X$5879 105 1543 2610 2991 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5884 m0 *1 199.64,95.2
X$5884 40 2904 370 2739 3051 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5887 m0 *1 212.98,95.2
X$5887 40 2904 102 2986 3116 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5891 m0 *1 230,95.2
X$5891 40 2983 3050 71 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5894 m0 *1 241.5,95.2
X$5894 40 2827 2979 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $5899 m0 *1 250.24,95.2
X$5899 40 3034 2950 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $5903 m0 *1 272.32,95.2
X$5903 40 2954 3082 2469 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5906 m0 *1 277.84,95.2
X$5906 40 2888 2955 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $5910 m0 *1 285.66,95.2
X$5910 40 2747 1164 2897 3040 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5911 m0 *1 294.86,95.2
X$5911 40 2747 2554 2897 2973 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5914 m0 *1 305.44,95.2
X$5914 40 2747 2830 2897 3037 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5917 m0 *1 317.4,95.2
X$5917 40 2747 2745 2284 3092 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5919 m0 *1 327.52,95.2
X$5919 40 2959 3025 2960 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5922 m0 *1 333.04,95.2
X$5922 40 3035 2958 3030 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5923 m0 *1 337.18,95.2
X$5923 105 2960 2964 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5924 m0 *1 338.56,95.2
X$5924 40 2747 2749 2834 2961 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $5925 m0 *1 347.76,95.2
X$5925 105 2962 3087 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $5927 r0 *1 2.3,95.2
X$5927 40 3088 2869 1522 2437 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $5928 r0 *1 4.6,95.2
X$5928 40 2558 2870 3000 3001 3002 105 105 40 sky130_fd_sc_hd__nor4_4
* cell instance $5930 r0 *1 12.88,95.2
X$5930 105 2201 3004 2567 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $5933 r0 *1 15.64,95.2
X$5933 40 2870 2928 2622 2157 2802 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $5934 r0 *1 23,95.2
X$5934 40 2244 2935 2383 3003 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $5935 r0 *1 28.98,95.2
X$5935 40 2712 2384 2201 3004 105 105 40 sky130_fd_sc_hd__and3_4
* cell instance $5937 r0 *1 33.58,95.2
X$5937 105 2930 3005 105 2563 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $5940 r0 *1 38.18,95.2
X$5940 40 2901 2932 1986 105 3006 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5944 r0 *1 43.7,95.2
X$5944 40 2972 2970 1988 105 3068 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5945 r0 *1 48.3,95.2
X$5945 40 3008 2935 3099 2076 3042 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $5946 r0 *1 52.9,95.2
X$5946 40 3009 2935 3070 2349 3045 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $5947 r0 *1 57.5,95.2
X$5947 105 2935 3011 3045 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $5948 r0 *1 58.88,95.2
X$5948 105 3010 3103 3046 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $5949 r0 *1 60.26,95.2
X$5949 40 3047 2934 3011 105 2532 105 40 sky130_fd_sc_hd__ha_1
* cell instance $5957 r0 *1 70.84,95.2
X$5957 40 2936 3012 2975 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $5958 r0 *1 78.2,95.2
X$5958 40 3213 3011 3013 3012 3072 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $5960 r0 *1 89.7,95.2
X$5960 105 3014 3015 3074 2940 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $5961 r0 *1 91.54,95.2
X$5961 105 3014 3074 3015 105 2852 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $5963 r0 *1 94.76,95.2
X$5963 105 3107 40 105 3108 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5966 r0 *1 98.44,95.2
X$5966 40 3109 3110 3015 1200 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $5967 r0 *1 104.42,95.2
X$5967 105 2813 3059 2262 105 40 3056 40 sky130_fd_sc_hd__o21ai_1
* cell instance $5968 r0 *1 106.26,95.2
X$5968 105 2981 40 105 3018 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $5971 r0 *1 110.86,95.2
X$5971 105 2878 2646 3062 40 3113 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $5972 r0 *1 114.08,95.2
X$5972 40 1152 2878 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $5973 r0 *1 118.22,95.2
X$5973 105 3018 3017 2942 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $5974 r0 *1 120.52,95.2
X$5974 105 1986 105 40 3115 40 sky130_fd_sc_hd__inv_1
* cell instance $5980 r0 *1 130.64,95.2
X$5980 40 3119 3064 362 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5981 r0 *1 134.78,95.2
X$5981 40 2904 363 2988 3120 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $5982 r0 *1 144.44,95.2
X$5982 40 3019 3077 735 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5983 r0 *1 148.58,95.2
X$5983 40 3122 3061 76 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5988 r0 *1 154.56,95.2
X$5988 40 3058 3021 1998 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $5990 r0 *1 162.38,95.2
X$5990 40 2904 90 3133 3123 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $5999 r0 *1 186.76,95.2
X$5999 40 3054 3020 2991 105 3053 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6004 r0 *1 201.02,95.2
X$6004 40 3051 3114 370 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6010 r0 *1 208.84,95.2
X$6010 40 3117 3118 77 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6013 r0 *1 217.58,95.2
X$6013 40 40 2824 105 3114 2978 105 sky130_fd_sc_hd__nor2_2
* cell instance $6026 r0 *1 240.12,95.2
X$6026 40 2427 3112 3106 3111 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $6027 r0 *1 246.1,95.2
X$6027 40 2909 3048 2195 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6028 r0 *1 250.24,95.2
X$6028 40 2585 3044 2950 3022 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $6035 r0 *1 269.1,95.2
X$6035 40 2904 2835 3023 3104 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6039 r0 *1 282.9,95.2
X$6039 40 40 2553 105 3025 3024 105 sky130_fd_sc_hd__nor2_2
* cell instance $6040 r0 *1 285.2,95.2
X$6040 105 3095 2978 2956 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6042 r0 *1 286.58,95.2
X$6042 40 3040 3102 1164 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6047 r0 *1 293.02,95.2
X$6047 40 2973 3026 2554 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6050 r0 *1 299.92,95.2
X$6050 40 3034 2897 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $6051 r0 *1 309.12,95.2
X$6051 40 3037 3036 2830 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6053 r0 *1 313.26,95.2
X$6053 40 3094 3027 2962 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6057 r0 *1 319.24,95.2
X$6057 40 3092 3091 2745 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6062 r0 *1 330.28,95.2
X$6062 40 2747 3030 2834 3035 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6065 r0 *1 340.4,95.2
X$6065 40 2671 3028 2670 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6069 r0 *1 347.76,95.2
X$6069 105 3029 3032 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6096 m0 *1 1.38,100.64
X$6096 105 2475 2479 3088 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $6097 m0 *1 4.6,100.64
X$6097 40 2558 3001 2802 2753 3002 3000 105 105 40 sky130_fd_sc_hd__o41ai_4
* cell instance $6098 m0 *1 14.72,100.64
X$6098 105 3126 3065 3090 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6099 m0 *1 16.1,100.64
X$6099 40 3003 2928 2244 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $6101 m0 *1 21.16,100.64
X$6101 40 2712 3004 2201 105 2802 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $6102 m0 *1 27.6,100.64
X$6102 105 3152 2930 3093 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6104 m0 *1 29.44,100.64
X$6104 40 2201 3128 3093 2628 3066 3129 105 105 40 sky130_fd_sc_hd__o2111a_2
* cell instance $6105 m0 *1 34.04,100.64
X$6105 40 2900 3067 1760 105 2765 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6106 m0 *1 38.64,100.64
X$6106 105 2901 2970 2871 105 2931 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $6108 m0 *1 41.86,100.64
X$6108 40 3067 3097 2873 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $6110 m0 *1 46.46,100.64
X$6110 105 2972 3008 3069 105 2871 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $6111 m0 *1 49.22,100.64
X$6111 105 3100 2934 3009 3099 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6112 m0 *1 51.06,100.64
X$6112 40 3100 3069 2251 105 3101 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6115 m0 *1 57.04,100.64
X$6115 105 3047 2976 3010 3070 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6117 m0 *1 59.8,100.64
X$6117 105 2874 3156 3210 3103 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6119 m0 *1 62.56,100.64
X$6119 40 3156 2803 2976 2975 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $6121 m0 *1 76.36,100.64
X$6121 40 3189 3012 3160 3101 3161 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $6122 m0 *1 80.96,100.64
X$6122 105 2936 3131 3071 3072 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6123 m0 *1 82.8,100.64
X$6123 105 3012 3073 3161 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $6128 m0 *1 87.86,100.64
X$6128 105 2643 105 40 3075 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $6129 m0 *1 89.7,100.64
X$6129 40 3015 3074 3016 105 2804 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6131 m0 *1 95.22,100.64
X$6131 105 2943 2913 3167 105 40 3166 40 sky130_fd_sc_hd__o21ai_1
* cell instance $6132 m0 *1 97.06,100.64
X$6132 40 2643 3109 2729 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $6135 m0 *1 107.64,100.64
X$6135 105 3075 40 105 3164 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $6138 m0 *1 112.24,100.64
X$6138 105 1152 40 2943 105 40 sky130_fd_sc_hd__buf_2
* cell instance $6139 m0 *1 114.08,100.64
X$6139 40 1152 2813 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $6141 m0 *1 118.68,100.64
X$6141 40 2585 3171 2537 2325 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $6142 m0 *1 129.72,100.64
X$6142 40 2904 362 2988 3119 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6146 m0 *1 140.3,100.64
X$6146 40 3120 3691 363 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6147 m0 *1 144.44,100.64
X$6147 40 2904 76 2988 3122 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6149 m0 *1 154.1,100.64
X$6149 40 2904 365 2988 3172 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6154 m0 *1 167.44,100.64
X$6154 40 3123 3173 90 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6158 m0 *1 174.8,100.64
X$6158 40 2904 3076 3133 3176 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6160 m0 *1 184.92,100.64
X$6160 40 2904 86 2739 3134 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6162 m0 *1 195.04,100.64
X$6162 40 3135 3175 3077 1815 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $6165 m0 *1 202.4,100.64
X$6165 105 3136 3135 1895 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6166 m0 *1 203.78,100.64
X$6166 40 2904 77 2986 3117 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6168 m0 *1 213.9,100.64
X$6168 40 40 1607 105 3098 3135 105 sky130_fd_sc_hd__nor2_2
* cell instance $6170 m0 *1 217.12,100.64
X$6170 40 3116 3170 102 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6173 m0 *1 222.64,100.64
X$6173 40 2742 3170 1378 3080 3079 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $6180 m0 *1 238.74,100.64
X$6180 40 3081 3106 2835 3207 3049 3138 3137 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $6184 m0 *1 250.24,100.64
X$6184 105 3165 3079 1378 105 3139 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $6185 m0 *1 252.08,100.64
X$6185 105 2950 9497 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $6186 m0 *1 253.92,100.64
X$6186 105 3163 3139 2951 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6188 m0 *1 255.76,100.64
X$6188 40 40 2780 105 3140 3079 105 sky130_fd_sc_hd__nor2_2
* cell instance $6189 m0 *1 258.06,100.64
X$6189 40 2904 3082 2950 3105 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6197 m0 *1 279.68,100.64
X$6197 40 2904 3086 3023 3158 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6200 m0 *1 291.64,100.64
X$6200 40 2747 3141 2897 3155 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6201 m0 *1 300.84,100.64
X$6201 40 3096 3084 2890 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6203 m0 *1 305.44,100.64
X$6203 105 2897 9568 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6205 m0 *1 310.5,100.64
X$6205 40 2747 2962 2897 3094 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6213 m0 *1 334.42,100.64
X$6213 105 3151 3198 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6214 m0 *1 335.8,100.64
X$6214 105 3141 3148 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6215 m0 *1 337.18,100.64
X$6215 105 3086 3199 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6217 m0 *1 339.48,100.64
X$6217 40 2747 3256 2834 3145 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6219 r0 *1 1.38,100.64
X$6219 105 3149 3124 3498 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $6220 r0 *1 3.68,100.64
X$6220 105 3125 105 40 3200 40 sky130_fd_sc_hd__inv_1
* cell instance $6221 r0 *1 5.06,100.64
X$6221 40 3124 3125 2558 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $6226 r0 *1 15.64,100.64
X$6226 40 2621 3127 3090 3262 3177 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $6228 r0 *1 23.92,100.64
X$6228 105 3128 3066 3129 105 2629 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $6230 r0 *1 27.14,100.64
X$6230 40 3128 3152 1450 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $6231 r0 *1 37.26,100.64
X$6231 105 3090 3127 2621 3180 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $6232 r0 *1 39.1,100.64
X$6232 105 3090 3180 2621 105 40 2525 40 sky130_fd_sc_hd__o21ai_1
* cell instance $6233 r0 *1 40.94,100.64
X$6233 105 3130 3153 3204 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6239 r0 *1 43.24,100.64
X$6239 105 3130 3204 3154 105 2929 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $6241 r0 *1 46.92,100.64
X$6241 40 2839 3097 3183 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $6244 r0 *1 59.34,100.64
X$6244 105 3156 3210 2874 105 3010 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $6247 r0 *1 63.48,100.64
X$6247 40 3130 3012 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $6255 r0 *1 72.68,100.64
X$6255 105 3132 2936 3188 3131 105 3448 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $6258 r0 *1 76.36,100.64
X$6258 40 3131 3162 3191 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $6259 r0 *1 85.56,100.64
X$6259 40 3132 3073 3190 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $6260 r0 *1 94.76,100.64
X$6260 105 3164 40 105 3107 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $6265 r0 *1 98.44,100.64
X$6265 105 3108 40 105 2981 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $6267 r0 *1 102.58,100.64
X$6267 40 3169 3113 3217 3115 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $6268 r0 *1 111.78,100.64
X$6268 40 2585 3216 2988 2813 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $6280 r0 *1 139.84,100.64
X$6280 105 2988 9576 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6281 r0 *1 141.22,100.64
X$6281 40 2880 2988 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $6293 r0 *1 159.16,100.64
X$6293 40 3172 3174 365 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6297 r0 *1 166.52,100.64
X$6297 40 2904 93 3133 3215 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6299 r0 *1 176.64,100.64
X$6299 40 3176 3214 3076 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6304 r0 *1 181.24,100.64
X$6304 40 2904 91 3133 3282 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6305 r0 *1 190.9,100.64
X$6305 40 3134 3212 86 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6309 r0 *1 202.86,100.64
X$6309 40 3135 3079 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $6314 r0 *1 208.84,100.64
X$6314 40 40 1658 105 3118 3079 105 sky130_fd_sc_hd__nor2_2
* cell instance $6315 r0 *1 211.14,100.64
X$6315 40 2904 371 2986 3211 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6316 r0 *1 220.8,100.64
X$6316 40 3194 3135 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $6324 r0 *1 236.44,100.64
X$6324 40 3168 3137 3111 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $6330 r0 *1 252.08,100.64
X$6330 40 2904 3140 2950 3208 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6337 r0 *1 264.96,100.64
X$6337 105 3159 3135 2829 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6343 r0 *1 278.76,100.64
X$6343 40 3158 3157 3086 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6352 r0 *1 292.1,100.64
X$6352 40 3155 3098 3141 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6354 r0 *1 297.16,100.64
X$6354 40 3142 3202 3146 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6355 r0 *1 301.3,100.64
X$6355 40 2747 3146 2897 3142 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6364 r0 *1 319.7,100.64
X$6364 40 2747 3144 2284 3201 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6365 r0 *1 328.9,100.64
X$6365 40 2747 3029 2834 3197 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6371 r0 *1 340.86,100.64
X$6371 40 2891 3150 2966 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6372 r0 *1 345,100.64
X$6372 105 3146 3147 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6375 r0 *1 347.76,100.64
X$6375 105 3143 3257 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6376 m0 *1 1.38,106.08
X$6376 40 2342 3149 423 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $6377 m0 *1 11.5,106.08
X$6377 105 2524 3260 3004 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $6378 m0 *1 13.8,106.08
X$6378 40 40 2621 105 3178 3177 105 sky130_fd_sc_hd__nor2_2
* cell instance $6380 m0 *1 17.02,106.08
X$6380 105 3261 3178 3177 3260 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6381 m0 *1 18.86,106.08
X$6381 40 3261 3262 2754 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $6383 m0 *1 29.44,106.08
X$6383 40 3223 3130 3126 3179 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $6384 m0 *1 35.42,106.08
X$6384 40 3225 3126 3220 3179 3203 3375 105 105 40 sky130_fd_sc_hd__o32a_1
* cell instance $6385 m0 *1 39.1,106.08
X$6385 40 3182 3130 3181 3225 2712 105 105 40 sky130_fd_sc_hd__a31o_4
* cell instance $6386 m0 *1 45.54,106.08
X$6386 105 3205 3181 3264 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $6387 m0 *1 48.76,106.08
X$6387 105 3183 3154 3097 3184 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $6389 m0 *1 51.98,106.08
X$6389 105 3226 3184 3182 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $6390 m0 *1 54.28,106.08
X$6390 105 3183 3294 3266 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6393 m0 *1 57.04,106.08
X$6393 105 3130 3229 3209 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $6396 m0 *1 60.72,106.08
X$6396 105 3130 105 40 3187 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $6397 m0 *1 62.56,106.08
X$6397 105 3231 3186 3185 3267 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6398 m0 *1 64.4,106.08
X$6398 105 3231 3185 3186 40 105 3230 40 sky130_fd_sc_hd__o21a_2
* cell instance $6399 m0 *1 67.62,106.08
X$6399 40 3185 3187 3268 3006 3272 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $6400 m0 *1 72.22,106.08
X$6400 105 3188 3189 3190 105 3232 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $6401 m0 *1 74.98,106.08
X$6401 105 3188 3190 3189 3269 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6403 m0 *1 77.74,106.08
X$6403 105 3132 3191 3013 105 3189 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $6404 m0 *1 80.5,106.08
X$6404 105 3132 3191 3013 3160 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6405 m0 *1 82.34,106.08
X$6405 105 3012 3162 3213 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $6410 m0 *1 86.02,106.08
X$6410 105 3183 40 1813 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $6413 m0 *1 90.62,106.08
X$6413 40 3276 9522 2803 105 3192 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6414 m0 *1 95.22,106.08
X$6414 40 3384 3239 3192 792 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $6415 m0 *1 101.2,106.08
X$6415 40 3192 1354 2943 2647 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $6416 m0 *1 107.18,106.08
X$6416 40 3279 3218 3283 105 2984 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6419 m0 *1 112.7,106.08
X$6419 105 2537 9495 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $6420 m0 *1 114.54,106.08
X$6420 105 3169 3217 3218 105 3392 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $6422 m0 *1 118.22,106.08
X$6422 40 2904 58 2537 3242 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6423 m0 *1 127.88,106.08
X$6423 40 2904 61 2988 3285 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6429 m0 *1 146.28,106.08
X$6429 40 2904 46 2988 3193 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6430 m0 *1 155.94,106.08
X$6430 40 3193 3402 46 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6438 m0 *1 169.74,106.08
X$6438 40 3215 3284 93 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6442 m0 *1 184.92,106.08
X$6442 40 40 2616 105 3281 3024 105 sky130_fd_sc_hd__nor2_2
* cell instance $6450 m0 *1 201.94,106.08
X$6450 40 3247 3278 1550 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6451 m0 *1 206.08,106.08
X$6451 40 2904 1550 2986 3247 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6454 m0 *1 218.04,106.08
X$6454 40 3211 3274 371 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6457 m0 *1 223.1,106.08
X$6457 105 3194 105 40 2978 40 sky130_fd_sc_hd__buf_4
* cell instance $6458 m0 *1 225.86,106.08
X$6458 40 3194 2459 3394 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $6467 m0 *1 250.24,106.08
X$6467 40 2904 3165 2950 3273 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6470 m0 *1 266.34,106.08
X$6470 40 2904 3249 3023 3206 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6476 m0 *1 285.66,106.08
X$6476 40 2904 3265 2897 3250 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6478 m0 *1 295.78,106.08
X$6478 40 2904 3143 2897 3251 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6481 m0 *1 305.9,106.08
X$6481 40 3252 3310 3151 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6482 m0 *1 310.04,106.08
X$6482 40 2747 3151 2897 3252 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6484 m0 *1 321.08,106.08
X$6484 40 3201 3263 3144 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6487 m0 *1 327.98,106.08
X$6487 40 3197 3095 3029 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6490 m0 *1 333.04,106.08
X$6490 105 3248 3258 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6491 m0 *1 334.42,106.08
X$6491 40 2961 3196 2749 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6494 m0 *1 339.94,106.08
X$6494 40 2747 3259 2834 3255 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6498 r0 *1 1.38,106.08
X$6498 40 3339 3220 3219 3222 105 3342 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $6499 r0 *1 9.2,106.08
X$6499 40 3125 3221 3220 3222 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $6501 r0 *1 13.8,106.08
X$6501 105 3290 3224 3065 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $6504 r0 *1 15.64,106.08
X$6504 40 3222 3221 3220 3124 105 2342 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $6505 r0 *1 23.46,106.08
X$6505 105 3223 105 40 3220 40 sky130_fd_sc_hd__buf_4
* cell instance $6506 r0 *1 26.22,106.08
X$6506 40 3220 3179 3224 3221 105 3128 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $6507 r0 *1 34.04,106.08
X$6507 40 2074 3374 3154 3179 3220 3126 105 105 40 sky130_fd_sc_hd__o41a_2
* cell instance $6509 r0 *1 39.56,106.08
X$6509 105 3153 3183 3324 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $6512 r0 *1 43.24,106.08
X$6512 40 3209 2439 3130 3291 3264 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $6513 r0 *1 51.06,106.08
X$6513 105 3293 3227 3154 105 3226 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $6514 r0 *1 52.9,106.08
X$6514 105 3181 3226 3184 40 105 3229 40 sky130_fd_sc_hd__a21oi_1
* cell instance $6516 r0 *1 55.2,106.08
X$6516 105 3228 40 105 3330 40 sky130_fd_sc_hd__inv_2
* cell instance $6517 r0 *1 56.58,106.08
X$6517 105 1591 3097 3227 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6518 r0 *1 57.96,106.08
X$6518 40 3295 3228 3153 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $6519 r0 *1 63.94,106.08
X$6519 40 3230 3228 3444 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $6521 r0 *1 68.54,106.08
X$6521 105 3297 3298 3232 3268 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6524 r0 *1 70.84,106.08
X$6524 40 3232 3187 3269 3068 3271 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $6525 r0 *1 75.44,106.08
X$6525 105 3187 3233 3271 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $6528 r0 *1 78.2,106.08
X$6528 105 3235 3234 3335 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $6529 r0 *1 79.58,106.08
X$6529 40 3235 3162 3275 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $6531 r0 *1 89.24,106.08
X$6531 105 3275 3301 3236 3300 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6533 r0 *1 92,106.08
X$6533 40 404 3277 3238 3237 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $6538 r0 *1 99.82,106.08
X$6538 40 3303 3338 3803 105 3052 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6539 r0 *1 104.42,106.08
X$6539 40 3279 3169 3240 3241 105 3238 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $6540 r0 *1 109.02,106.08
X$6540 40 3240 3337 3056 105 3389 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6542 r0 *1 114.08,106.08
X$6542 105 3305 3241 3337 105 40 3354 40 sky130_fd_sc_hd__o21ai_1
* cell instance $6543 r0 *1 115.92,106.08
X$6543 40 2904 44 2537 3336 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6546 r0 *1 126.04,106.08
X$6546 40 3242 3334 58 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6547 r0 *1 130.18,106.08
X$6547 40 3285 3286 61 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6548 r0 *1 134.32,106.08
X$6548 40 2904 45 2988 3244 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6549 r0 *1 143.98,106.08
X$6549 40 3244 3245 45 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6553 r0 *1 150.42,106.08
X$6553 105 3307 105 40 2952 40 sky130_fd_sc_hd__buf_4
* cell instance $6556 r0 *1 155.48,106.08
X$6556 40 2904 47 2988 3333 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6557 r0 *1 165.14,106.08
X$6557 40 2904 2000 3133 3331 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6565 r0 *1 182.62,106.08
X$6565 40 3282 3246 91 2952 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6566 r0 *1 186.76,106.08
X$6566 105 3246 3079 3280 40 2658 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $6570 r0 *1 195.96,106.08
X$6570 40 2904 3248 2986 3326 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6590 r0 *1 253,106.08
X$6590 40 2904 3207 3023 3270 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6596 r0 *1 270.02,106.08
X$6596 40 2904 3084 3023 3660 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6600 r0 *1 286.12,106.08
X$6600 40 3250 3249 3265 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6603 r0 *1 291.64,106.08
X$6603 40 2904 3321 3363 3541 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6604 r0 *1 300.84,106.08
X$6604 40 3251 3165 3143 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6606 r0 *1 306.82,106.08
X$6606 40 2747 3253 2897 3320 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6611 r0 *1 319.24,106.08
X$6611 40 2747 3254 2834 3319 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6612 r0 *1 328.44,106.08
X$6612 40 2747 3313 2834 3317 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6613 r0 *1 337.64,106.08
X$6613 105 3253 3314 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6617 r0 *1 340.86,106.08
X$6617 40 3145 3315 3256 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6622 r0 *1 347.3,106.08
X$6622 105 3254 3365 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6650 m0 *1 1.38,111.52
X$6650 40 3219 3287 3002 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $6651 m0 *1 7.36,111.52
X$6651 40 2025 3367 3001 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $6652 m0 *1 13.34,111.52
X$6652 105 3289 3341 3340 3370 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $6653 m0 *1 15.18,111.52
X$6653 40 3288 3342 2244 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $6654 m0 *1 25.3,111.52
X$6654 105 3290 3224 105 3343 40 40 sky130_fd_sc_hd__and2_2
* cell instance $6657 m0 *1 29.44,111.52
X$6657 40 3220 3179 3221 3323 105 3005 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $6659 m0 *1 38.18,111.52
X$6659 40 3375 3181 3205 3291 105 105 40 sky130_fd_sc_hd__nor3b_2
* cell instance $6660 m0 *1 42.78,111.52
X$6660 105 3325 3347 3292 40 3181 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $6661 m0 *1 46,111.52
X$6661 105 3324 3097 3153 1508 3291 40 105 40 sky130_fd_sc_hd__o22a_1
* cell instance $6662 m0 *1 49.22,111.52
X$6662 105 3294 3183 3205 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $6663 m0 *1 52.44,111.52
X$6663 40 3378 3347 3294 3183 105 105 40 sky130_fd_sc_hd__or3_4
* cell instance $6665 m0 *1 57.04,111.52
X$6665 40 3295 3379 1760 105 3154 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6667 m0 *1 62.1,111.52
X$6667 40 3296 2765 3230 3130 3267 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $6668 m0 *1 69.92,111.52
X$6668 105 3295 3231 3297 3449 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $6669 m0 *1 71.76,111.52
X$6669 40 3188 3298 2251 105 3233 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6670 m0 *1 76.36,111.52
X$6670 40 3335 3073 3299 3235 3300 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $6672 m0 *1 84.64,111.52
X$6672 105 3301 3236 3275 105 3299 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $6675 m0 *1 90.16,111.52
X$6675 105 3276 3302 3382 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $6676 m0 *1 91.54,111.52
X$6676 105 3303 3302 3352 3384 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $6677 m0 *1 93.38,111.52
X$6677 40 3277 3238 3303 3276 3302 3351 105 105 40 sky130_fd_sc_hd__a41oi_2
* cell instance $6680 m0 *1 100.74,111.52
X$6680 105 3383 3303 3338 3237 40 3239 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $6681 m0 *1 103.5,111.52
X$6681 40 3241 3388 3304 105 2877 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6683 m0 *1 108.56,111.52
X$6683 105 3240 3392 40 105 3305 40 sky130_fd_sc_hd__nor2b_2
* cell instance $6686 m0 *1 112.7,111.52
X$6686 40 2880 2537 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $6688 m0 *1 123.74,111.52
X$6688 40 3336 3396 44 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6695 m0 *1 143.52,111.52
X$6695 40 3398 3514 364 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6697 m0 *1 149.5,111.52
X$6697 40 3399 3355 919 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6698 m0 *1 153.64,111.52
X$6698 40 3307 3306 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $6700 m0 *1 158.24,111.52
X$6700 40 3403 3404 83 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6701 m0 *1 162.38,111.52
X$6701 40 3333 3332 47 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6705 m0 *1 167.9,111.52
X$6705 40 3331 3329 2000 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6707 m0 *1 175.72,111.52
X$6707 40 2904 3246 3133 3328 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6709 m0 *1 185.84,111.52
X$6709 40 3327 3308 3369 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6715 m0 *1 196.42,111.52
X$6715 40 3326 3400 3248 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6717 m0 *1 204.24,111.52
X$6717 105 2986 105 40 40 sky130_fd_sc_hd__clkinv_1
* cell instance $6718 m0 *1 205.62,111.52
X$6718 40 2880 2986 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $6727 m0 *1 236.44,111.52
X$6727 40 3111 3112 3081 3443 3385 3386 105 105 40 sky130_fd_sc_hd__a221oi_2
* cell instance $6729 m0 *1 245.64,111.52
X$6729 40 3385 3702 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $6735 m0 *1 259.9,111.52
X$6735 40 2904 3309 3023 3507 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6738 m0 *1 271.86,111.52
X$6738 105 3311 105 40 3078 40 sky130_fd_sc_hd__buf_4
* cell instance $6744 m0 *1 279.22,111.52
X$6744 40 2904 3312 3023 3380 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6746 m0 *1 288.88,111.52
X$6746 40 2904 3310 3363 3322 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6751 m0 *1 307.28,111.52
X$6751 40 3320 3309 3253 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6753 m0 *1 312.34,111.52
X$6753 105 3311 40 3195 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $6757 m0 *1 321.54,111.52
X$6757 40 3319 3373 3254 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6760 m0 *1 328.44,111.52
X$6760 40 3317 3318 3313 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6762 m0 *1 333.04,111.52
X$6762 40 3034 2834 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $6763 m0 *1 342.24,111.52
X$6763 105 3312 3316 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6764 m0 *1 343.62,111.52
X$6764 105 3313 3364 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6767 r0 *1 1.38,111.52
X$6767 40 3342 3288 1522 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $6768 r0 *1 11.5,111.52
X$6768 40 40 3340 1619 3407 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $6774 r0 *1 15.64,111.52
X$6774 40 3260 3221 3127 3343 105 3431 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $6775 r0 *1 23.46,111.52
X$6775 105 3126 3065 3371 3341 105 40 3467 40 sky130_fd_sc_hd__o31ai_1
* cell instance $6777 r0 *1 26.68,111.52
X$6777 105 3290 3224 3344 40 105 3222 40 sky130_fd_sc_hd__and3_2
* cell instance $6778 r0 *1 29.44,111.52
X$6778 105 3468 3345 2895 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $6780 r0 *1 31.28,111.52
X$6780 40 3344 3224 3290 105 3179 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $6781 r0 *1 37.72,111.52
X$6781 105 3126 3220 3179 3153 105 40 3374 40 sky130_fd_sc_hd__o31ai_1
* cell instance $6782 r0 *1 40.48,111.52
X$6782 40 3411 3066 3346 3376 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $6786 r0 *1 43.24,111.52
X$6786 105 3347 3183 3471 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $6788 r0 *1 47.38,111.52
X$6788 40 3346 3348 3293 3292 3347 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $6789 r0 *1 51.98,111.52
X$6789 105 1591 3377 3413 3412 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $6791 r0 *1 54.28,111.52
X$6791 40 3347 3294 3445 3183 105 105 40 sky130_fd_sc_hd__nand3b_4
* cell instance $6792 r0 *1 61.64,111.52
X$6792 40 3294 3379 3295 3330 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $6793 r0 *1 67.62,111.52
X$6793 105 3297 3232 3298 105 3185 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $6797 r0 *1 70.84,111.52
X$6797 40 3297 3186 1988 105 3450 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6798 r0 *1 75.44,111.52
X$6798 105 3450 3187 3272 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $6799 r0 *1 76.82,111.52
X$6799 105 3187 3418 3296 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $6801 r0 *1 78.66,111.52
X$6801 40 3301 3349 3234 105 2803 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6802 r0 *1 83.26,111.52
X$6802 105 3381 3349 3299 3451 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $6804 r0 *1 86.02,111.52
X$6804 105 3381 3299 3349 105 3419 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $6806 r0 *1 90.62,111.52
X$6806 105 3387 3885 3382 105 40 3383 40 sky130_fd_sc_hd__o21bai_1
* cell instance $6807 r0 *1 93.38,111.52
X$6807 105 3302 3549 3350 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $6810 r0 *1 96.6,111.52
X$6810 105 2803 105 40 3352 40 sky130_fd_sc_hd__inv_1
* cell instance $6812 r0 *1 98.44,111.52
X$6812 40 3302 3387 3353 105 3166 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6813 r0 *1 103.04,111.52
X$6813 105 2532 105 40 3353 40 sky130_fd_sc_hd__inv_1
* cell instance $6814 r0 *1 104.42,111.52
X$6814 105 1988 3283 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $6816 r0 *1 108.1,111.52
X$6816 105 3354 3388 3237 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $6817 r0 *1 110.4,111.52
X$6817 105 1760 105 40 3389 40 sky130_fd_sc_hd__inv_1
* cell instance $6818 r0 *1 111.78,111.52
X$6818 105 3353 3391 3393 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $6828 r0 *1 127.88,111.52
X$6828 40 3462 3397 59 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6833 r0 *1 140.76,111.52
X$6833 105 3307 105 40 3243 40 sky130_fd_sc_hd__buf_4
* cell instance $6834 r0 *1 143.52,111.52
X$6834 40 2904 919 3401 3399 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6840 r0 *1 155.02,111.52
X$6840 40 2904 83 3401 3403 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6843 r0 *1 168.82,111.52
X$6843 105 3133 9573 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6844 r0 *1 170.2,111.52
X$6844 40 2904 3421 3133 3406 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6849 r0 *1 184.92,111.52
X$6849 40 2904 3369 3405 3327 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6863 r0 *1 224.94,111.52
X$6863 40 3357 3356 3395 3358 3359 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $6867 r0 *1 233.22,111.52
X$6867 105 3390 40 3137 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $6869 r0 *1 236.44,111.52
X$6869 40 40 3385 105 3081 3360 105 sky130_fd_sc_hd__nor2_2
* cell instance $6870 r0 *1 238.74,111.52
X$6870 105 3361 105 40 3386 40 sky130_fd_sc_hd__inv_1
* cell instance $6886 r0 *1 270.94,111.52
X$6886 40 3034 3023 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $6887 r0 *1 280.14,111.52
X$6887 40 3380 3362 3312 3078 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6896 r0 *1 295.32,111.52
X$6896 40 2904 3263 3363 3727 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6899 r0 *1 308.2,111.52
X$6899 40 2904 3196 3363 4137 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $6905 r0 *1 324.76,111.52
X$6905 40 2747 3432 2834 3372 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6906 r0 *1 333.96,111.52
X$6906 105 3369 3366 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6908 r0 *1 337.18,111.52
X$6908 40 2747 3427 2834 3368 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $6913 r0 *1 347.76,111.52
X$6913 105 3256 3497 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $6927 m0 *1 1.38,116.96
X$6927 40 3431 3429 2157 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $6928 m0 *1 11.5,116.96
X$6928 105 3220 3222 3339 3287 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $6929 m0 *1 13.34,116.96
X$6929 105 3371 3433 3126 3065 40 3345 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $6930 m0 *1 15.64,116.96
X$6930 40 3407 3408 3343 3221 3501 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $6931 m0 *1 18.86,116.96
X$6931 40 3409 3410 3343 2524 3221 3127 105 105 40 sky130_fd_sc_hd__a32oi_4
* cell instance $6934 m0 *1 30.36,116.96
X$6934 40 3220 3179 3502 3519 105 2628 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $6935 m0 *1 38.18,116.96
X$6935 40 3346 3126 3411 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $6936 m0 *1 42.32,116.96
X$6936 40 3205 3203 3181 3291 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $6938 m0 *1 45.08,116.96
X$6938 105 3293 3292 3347 3348 105 40 3436 40 sky130_fd_sc_hd__o211a_2
* cell instance $6939 m0 *1 48.76,116.96
X$6939 40 3544 3442 3414 3415 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $6942 m0 *1 57.04,116.96
X$6942 40 3445 3378 3505 3416 3417 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $6943 m0 *1 64.86,116.96
X$6943 40 3231 3444 1986 105 3418 105 40 sky130_fd_sc_hd__ha_1
* cell instance $6944 m0 *1 69.46,116.96
X$6944 40 2409 3413 3448 3449 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $6946 m0 *1 73.6,116.96
X$6946 105 3348 105 40 3325 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $6947 m0 *1 75.44,116.96
X$6947 40 3348 3235 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $6949 m0 *1 81.42,116.96
X$6949 105 3419 3451 3452 105 3508 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $6953 m0 *1 86.48,116.96
X$6953 40 3381 3454 3477 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $6956 m0 *1 97.06,116.96
X$6956 40 3456 3457 3551 2360 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $6957 m0 *1 100.74,116.96
X$6957 40 3459 3166 3350 2360 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $6958 m0 *1 104.42,116.96
X$6958 40 3293 3304 105 105 40 sky130_fd_sc_hd__clkinv_8
* cell instance $6964 m0 *1 114.54,116.96
X$6964 40 2904 56 2537 3461 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6965 m0 *1 124.2,116.96
X$6965 40 2904 59 3420 3462 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6968 m0 *1 135.24,116.96
X$6968 40 3463 3464 131 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6970 m0 *1 139.84,116.96
X$6970 40 2904 364 3401 3398 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6971 m0 *1 149.5,116.96
X$6971 40 2880 3401 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $6977 m0 *1 169.28,116.96
X$6977 40 2880 3133 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $6978 m0 *1 178.48,116.96
X$6978 40 3406 3460 3421 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $6985 m0 *1 195.96,116.96
X$6985 40 2904 3278 2986 3458 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $6990 m0 *1 214.36,116.96
X$6990 40 3455 3422 3395 3453 3664 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $6993 m0 *1 223.1,116.96
X$6993 40 3423 3446 3249 3026 3356 3274 3486 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $6994 m0 *1 232.76,116.96
X$6994 105 3447 40 105 3423 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $6997 m0 *1 237.36,116.96
X$6997 40 3443 3027 3441 3485 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $7005 m0 *1 257.6,116.96
X$7005 105 3440 3439 3438 3437 3424 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $7009 m0 *1 270.94,116.96
X$7009 105 3023 9571 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7016 m0 *1 282.44,116.96
X$7016 40 2904 3434 3363 3435 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7019 m0 *1 293.94,116.96
X$7019 40 3034 3363 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $7022 m0 *1 305.44,116.96
X$7022 40 2904 3095 3363 3425 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7023 m0 *1 316.02,116.96
X$7023 40 2747 3373 3426 3602 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $7024 m0 *1 325.68,116.96
X$7024 40 3372 3594 3432 3085 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7029 m0 *1 333.96,116.96
X$7029 105 3432 3428 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7030 m0 *1 335.34,116.96
X$7030 40 2747 3494 3426 3714 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7032 m0 *1 346.38,116.96
X$7032 105 3427 3598 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7033 m0 *1 347.76,116.96
X$7033 105 3493 3430 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7034 r0 *1 1.38,116.96
X$7034 40 40 3341 2479 3289 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $7035 r0 *1 3.68,116.96
X$7035 105 3200 3498 2622 105 40 3367 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7036 r0 *1 5.52,116.96
X$7036 40 3499 3000 3465 3431 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $7037 r0 *1 13.8,116.96
X$7037 105 3466 3433 3340 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7040 r0 *1 15.64,116.96
X$7040 105 3500 3468 3467 105 3089 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $7042 r0 *1 19.32,116.96
X$7042 40 3408 3517 3127 3469 105 105 40 sky130_fd_sc_hd__nand3b_4
* cell instance $7043 r0 *1 26.68,116.96
X$7043 40 3436 3473 3221 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $7045 r0 *1 34.5,116.96
X$7045 105 3436 3473 3323 3502 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $7046 r0 *1 36.8,116.96
X$7046 105 3470 3346 3411 3224 105 3410 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $7047 r0 *1 39.1,116.96
X$7047 40 3520 3325 3471 3472 3413 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $7050 r0 *1 43.24,116.96
X$7050 40 3348 3471 3413 3472 105 3469 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $7051 r0 *1 51.06,116.96
X$7051 40 3266 3505 3377 3348 3411 3442 105 105 40 sky130_fd_sc_hd__a311oi_4
* cell instance $7052 r0 *1 60.72,116.96
X$7052 40 3473 3442 3505 3266 3377 3348 105 105 40 sky130_fd_sc_hd__a311o_4
* cell instance $7057 r0 *1 70.84,116.96
X$7057 105 3506 3474 3547 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7060 r0 *1 77.74,116.96
X$7060 105 3475 3235 3510 3509 105 40 3450 40 sky130_fd_sc_hd__o31ai_1
* cell instance $7062 r0 *1 81.42,116.96
X$7062 105 3508 3454 3452 105 3233 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $7063 r0 *1 84.18,116.96
X$7063 105 3476 3419 3477 105 3475 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $7064 r0 *1 86.94,116.96
X$7064 105 3476 3477 3419 3510 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $7068 r0 *1 96.14,116.96
X$7068 105 3192 105 40 3457 40 sky130_fd_sc_hd__inv_1
* cell instance $7072 r0 *1 99.36,116.96
X$7072 40 2585 3555 2537 3459 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $7075 r0 *1 111.78,116.96
X$7075 40 3391 3560 3352 3621 3845 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $7078 r0 *1 121.44,116.96
X$7078 40 3461 3513 56 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7084 r0 *1 132.48,116.96
X$7084 40 2904 131 3420 3463 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $7087 r0 *1 143.52,116.96
X$7087 40 2904 78 3401 3478 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $7091 r0 *1 154.1,116.96
X$7091 40 3307 3083 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $7092 r0 *1 159.16,116.96
X$7092 40 3478 3586 78 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7096 r0 *1 169.28,116.96
X$7096 40 2904 3460 3133 3515 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7100 r0 *1 181.24,116.96
X$7100 40 2904 3245 3405 3479 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7105 r0 *1 198.72,116.96
X$7105 40 2904 3481 2986 3480 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $7108 r0 *1 208.84,116.96
X$7108 40 3480 3482 3481 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7109 r0 *1 212.98,116.96
X$7109 105 3564 40 3360 105 40 sky130_fd_sc_hd__clkinv_4
* cell instance $7111 r0 *1 219.88,116.96
X$7111 40 1608 3563 3512 3483 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $7112 r0 *1 225.86,116.96
X$7112 105 3447 105 40 3081 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $7113 r0 *1 227.7,116.96
X$7113 105 3556 3626 3081 3484 105 3512 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $7115 r0 *1 231.38,116.96
X$7115 40 3486 3485 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $7118 r0 *1 236.44,116.96
X$7118 105 3111 3446 3483 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7120 r0 *1 238.28,116.96
X$7120 40 2904 3102 3622 3511 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7124 r0 *1 254.84,116.96
X$7124 40 3487 3488 3439 2835 3489 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $7127 r0 *1 259.9,116.96
X$7127 105 3309 3528 3859 40 105 3507 40 sky130_fd_sc_hd__a21o_1
* cell instance $7132 r0 *1 269.56,116.96
X$7132 40 2904 3491 3023 3490 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7133 r0 *1 280.14,116.96
X$7133 40 2904 3492 3023 3545 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7138 r0 *1 293.48,116.96
X$7138 40 3542 3504 3495 3083 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7141 r0 *1 299,116.96
X$7141 40 2904 3091 3363 3503 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7143 r0 *1 310.04,116.96
X$7143 105 3311 105 40 3085 40 sky130_fd_sc_hd__buf_4
* cell instance $7153 r0 *1 328.9,116.96
X$7153 40 2747 3493 2834 3539 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7155 r0 *1 338.56,116.96
X$7155 40 3368 3491 3427 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7158 r0 *1 343.62,116.96
X$7158 105 3495 3496 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7159 r0 *1 345,116.96
X$7159 105 3650 3597 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7161 r0 *1 346.84,116.96
X$7161 105 3494 3649 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7189 m0 *1 1.38,122.4
X$7189 105 3787 3001 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $7190 m0 *1 3.22,122.4
X$7190 105 3429 3599 3499 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $7191 m0 *1 5.52,122.4
X$7191 40 40 3632 2477 3516 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $7192 m0 *1 7.82,122.4
X$7192 40 3003 3407 3370 3345 3468 105 105 40 sky130_fd_sc_hd__or4b_4
* cell instance $7193 m0 *1 12.88,122.4
X$7193 105 3520 3408 3517 105 40 3371 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7195 m0 *1 15.18,122.4
X$7195 105 3415 3537 3433 105 3601 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $7196 m0 *1 17.02,122.4
X$7196 105 3452 3412 3500 3501 3517 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $7198 m0 *1 20.24,122.4
X$7198 40 3223 3517 3124 3518 3469 105 105 40 sky130_fd_sc_hd__nand4b_2
* cell instance $7199 m0 *1 25.76,122.4
X$7199 105 3516 3540 3568 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $7202 m0 *1 29.44,122.4
X$7202 40 3436 3339 3473 3717 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $7203 m0 *1 33.12,122.4
X$7203 105 3436 3323 3473 105 40 3519 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7204 m0 *1 34.96,122.4
X$7204 105 3452 3574 105 3152 40 40 sky130_fd_sc_hd__and2_2
* cell instance $7206 m0 *1 38.18,122.4
X$7206 105 3521 3470 3290 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $7208 m0 *1 41.4,122.4
X$7208 40 3224 3348 3719 3603 3376 105 105 40 sky130_fd_sc_hd__o31a_2
* cell instance $7209 m0 *1 45.08,122.4
X$7209 40 3472 1591 3416 3417 3377 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $7212 m0 *1 51.06,122.4
X$7212 40 3544 3377 3294 1591 105 105 40 sky130_fd_sc_hd__or3_4
* cell instance $7216 m0 *1 57.04,122.4
X$7216 40 3414 3415 3348 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $7219 m0 *1 65.78,122.4
X$7219 105 3377 105 40 3607 40 sky130_fd_sc_hd__inv_1
* cell instance $7220 m0 *1 67.16,122.4
X$7220 40 3547 3608 3347 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $7221 m0 *1 77.28,122.4
X$7221 105 3548 3523 3522 3609 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $7222 m0 *1 79.12,122.4
X$7222 105 3548 3522 3523 105 3474 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $7224 m0 *1 82.34,122.4
X$7224 105 3524 3235 3509 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7227 m0 *1 84.64,122.4
X$7227 40 3476 3580 2251 105 3524 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7230 m0 *1 91.54,122.4
X$7230 40 3549 3551 2803 3550 3192 105 105 40 sky130_fd_sc_hd__fa_1
* cell instance $7234 m0 *1 102.12,122.4
X$7234 40 2647 3017 3554 105 3553 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7237 m0 *1 109.02,122.4
X$7237 105 2538 1813 3615 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7241 m0 *1 112.24,122.4
X$7241 40 2585 3525 2537 3557 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $7242 m0 *1 123.28,122.4
X$7242 105 3560 105 40 3562 40 sky130_fd_sc_hd__inv_1
* cell instance $7245 m0 *1 126.04,122.4
X$7245 40 2585 3565 3420 3562 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $7250 m0 *1 140.76,122.4
X$7250 40 2904 69 3401 3625 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $7251 m0 *1 150.42,122.4
X$7251 105 3401 9499 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $7254 m0 *1 156.4,122.4
X$7254 40 2904 3021 3401 3894 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7256 m0 *1 167.44,122.4
X$7256 40 2904 3514 3133 3896 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7259 m0 *1 180.78,122.4
X$7259 40 2904 3077 3405 3631 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7266 m0 *1 197.34,122.4
X$7266 40 2904 3526 3405 3667 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7270 m0 *1 214.36,122.4
X$7270 105 3390 40 3564 105 40 sky130_fd_sc_hd__buf_2
* cell instance $7271 m0 *1 216.2,122.4
X$7271 40 3525 3558 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $7273 m0 *1 220.8,122.4
X$7273 105 3561 3194 3563 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7275 m0 *1 222.64,122.4
X$7275 40 3453 3559 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $7276 m0 *1 228.16,122.4
X$7276 40 3194 3390 3558 3589 105 105 40 sky130_fd_sc_hd__or3_4
* cell instance $7277 m0 *1 232.3,122.4
X$7277 40 3484 3082 3552 3527 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $7278 m0 *1 235.98,122.4
X$7278 105 3390 40 105 3527 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $7279 m0 *1 239.2,122.4
X$7279 105 3390 40 105 3485 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $7280 m0 *1 242.42,122.4
X$7280 105 3102 3528 3701 40 105 3511 40 sky130_fd_sc_hd__a21o_1
* cell instance $7286 m0 *1 254.84,122.4
X$7286 105 3529 3531 3487 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7291 m0 *1 263.12,122.4
X$7291 40 3424 2835 3104 3614 3530 3531 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $7292 m0 *1 266.8,122.4
X$7292 40 2904 3026 3023 3546 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7296 m0 *1 283.36,122.4
X$7296 40 3435 3492 3434 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7297 m0 *1 287.5,122.4
X$7297 40 3541 3543 3321 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7298 m0 *1 291.64,122.4
X$7298 105 3363 9567 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7299 m0 *1 293.02,122.4
X$7299 40 2904 3495 3363 3542 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7306 m0 *1 316.48,122.4
X$7306 105 3532 3533 4037 105 40 3534 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7307 m0 *1 318.32,122.4
X$7307 105 3594 3605 3533 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7309 m0 *1 320.16,122.4
X$7309 40 2747 3594 3426 3534 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $7313 m0 *1 333.04,122.4
X$7313 40 3539 3538 3493 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7314 m0 *1 337.18,122.4
X$7314 105 3481 3535 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7317 m0 *1 339.94,122.4
X$7317 40 2747 3709 3426 3536 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7318 r0 *1 1.38,122.4
X$7318 105 3149 3566 105 3599 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $7319 r0 *1 4.6,122.4
X$7319 40 3567 3600 3408 3566 2477 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $7320 r0 *1 11.96,122.4
X$7320 105 2477 3600 3567 40 105 3518 40 sky130_fd_sc_hd__a21oi_1
* cell instance $7321 r0 *1 13.8,122.4
X$7321 105 3500 105 40 3433 40 sky130_fd_sc_hd__inv_1
* cell instance $7324 r0 *1 15.64,122.4
X$7324 105 3415 3537 3466 105 3501 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $7325 r0 *1 17.48,122.4
X$7325 40 3468 3408 3343 3221 3601 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $7326 r0 *1 22.08,122.4
X$7326 105 3415 3576 3537 3341 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $7327 r0 *1 24.38,122.4
X$7327 105 3636 3568 3537 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7329 r0 *1 26.22,122.4
X$7329 40 3568 3569 3570 3571 105 3633 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $7330 r0 *1 30.82,122.4
X$7330 105 3571 3570 3569 40 105 3416 40 sky130_fd_sc_hd__and3_2
* cell instance $7331 r0 *1 33.58,122.4
X$7331 105 3573 3572 3574 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7332 r0 *1 36.8,122.4
X$7332 40 3452 3657 3572 3573 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $7333 r0 *1 39.1,122.4
X$7333 105 3415 3414 3574 105 3470 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $7334 r0 *1 40.94,122.4
X$7334 105 3452 3685 3575 3129 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $7338 r0 *1 43.7,122.4
X$7338 105 3575 105 40 3603 40 sky130_fd_sc_hd__inv_1
* cell instance $7339 r0 *1 45.08,122.4
X$7339 105 3576 3636 3540 40 105 3417 40 sky130_fd_sc_hd__and3_2
* cell instance $7340 r0 *1 47.84,122.4
X$7340 40 3414 3576 3636 3540 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $7341 r0 *1 51.52,122.4
X$7341 105 3416 3417 3377 3292 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $7342 r0 *1 53.36,122.4
X$7342 105 3577 1591 3658 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7343 r0 *1 56.58,122.4
X$7343 40 40 3417 3452 3416 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $7344 r0 *1 58.88,122.4
X$7344 40 3323 3606 3578 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $7346 r0 *1 65.78,122.4
X$7346 40 3608 3640 1760 105 3607 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7349 r0 *1 70.84,122.4
X$7349 40 3154 3610 3611 3452 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $7350 r0 *1 74.98,122.4
X$7350 105 3474 3609 3611 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7351 r0 *1 76.36,122.4
X$7351 40 3522 3325 3579 3418 3725 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $7353 r0 *1 81.42,122.4
X$7353 105 3581 3580 3475 105 3522 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $7354 r0 *1 84.18,122.4
X$7354 105 3581 3580 3475 3579 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $7358 r0 *1 92,122.4
X$7358 40 3351 3583 2583 105 3582 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7360 r0 *1 96.6,122.4
X$7360 105 3583 105 40 3550 40 sky130_fd_sc_hd__inv_1
* cell instance $7362 r0 *1 98.44,122.4
X$7362 40 2585 3618 3420 3456 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $7364 r0 *1 109.94,122.4
X$7364 40 3557 3621 3666 105 3617 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7365 r0 *1 114.54,122.4
X$7365 105 3620 3619 3584 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7367 r0 *1 118.68,122.4
X$7367 105 3393 3584 3585 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7371 r0 *1 126.04,122.4
X$7371 40 2585 3624 3420 3585 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $7375 r0 *1 146.28,122.4
X$7375 40 3625 3678 69 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7377 r0 *1 150.42,122.4
X$7377 105 3529 105 40 3489 40 sky130_fd_sc_hd__buf_4
* cell instance $7380 r0 *1 154.1,122.4
X$7380 40 2904 3586 3401 3677 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7382 r0 *1 165.14,122.4
X$7382 40 2904 3355 3133 3676 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7384 r0 *1 176.64,122.4
X$7384 105 3629 3630 3587 105 40 3328 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7386 r0 *1 178.48,122.4
X$7386 105 3587 3673 3675 105 40 3479 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7389 r0 *1 181.24,122.4
X$7389 105 3587 3739 4520 105 40 3631 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7392 r0 *1 185.84,122.4
X$7392 40 2904 3669 3405 3671 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $7393 r0 *1 195.5,122.4
X$7393 40 2880 3405 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $7396 r0 *1 206.54,122.4
X$7396 105 3525 105 40 3628 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $7399 r0 *1 209.3,122.4
X$7399 40 3390 3665 3628 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $7401 r0 *1 215.28,122.4
X$7401 40 3565 3627 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $7402 r0 *1 219.42,122.4
X$7402 105 3565 105 40 3589 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $7405 r0 *1 224.02,122.4
X$7405 40 3588 3137 3081 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $7407 r0 *1 229.54,122.4
X$7407 105 3588 3111 40 3623 105 40 sky130_fd_sc_hd__and2_4
* cell instance $7409 r0 *1 232.76,122.4
X$7409 105 3589 40 105 3626 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $7411 r0 *1 236.44,122.4
X$7411 105 3589 40 3111 105 40 sky130_fd_sc_hd__buf_2
* cell instance $7413 r0 *1 238.74,122.4
X$7413 40 2904 3027 3622 3661 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7419 r0 *1 258.98,122.4
X$7419 105 3531 3616 3614 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7426 r0 *1 269.56,122.4
X$7426 105 3491 3532 3613 40 105 3490 40 sky130_fd_sc_hd__a21o_1
* cell instance $7427 r0 *1 272.32,122.4
X$7427 105 3492 3532 3590 40 105 3545 40 sky130_fd_sc_hd__a21o_1
* cell instance $7432 r0 *1 286.12,122.4
X$7432 105 3591 3605 3612 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7433 r0 *1 287.5,122.4
X$7433 105 3592 3612 5080 105 40 3593 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7436 r0 *1 291.64,122.4
X$7436 40 2904 3591 3363 3593 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7439 r0 *1 304.52,122.4
X$7439 40 2904 3025 3706 3655 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7441 r0 *1 315.1,122.4
X$7441 105 4126 3604 3532 105 40 3602 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7442 r0 *1 316.94,122.4
X$7442 105 3373 3605 3604 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7445 r0 *1 319.24,122.4
X$7445 40 2747 3538 3426 3652 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7446 r0 *1 329.82,122.4
X$7446 40 2747 3650 2834 3651 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7448 r0 *1 339.94,122.4
X$7448 105 3595 3596 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7450 r0 *1 341.32,122.4
X$7450 40 3255 3591 3259 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7454 r0 *1 347.3,122.4
X$7454 105 3526 3785 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7483 m0 *1 3.22,127.84
X$7483 105 3429 3149 3465 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7484 m0 *1 4.6,127.84
X$7484 105 3680 3679 3632 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $7485 m0 *1 6.9,127.84
X$7485 105 3632 105 40 3711 40 sky130_fd_sc_hd__inv_1
* cell instance $7486 m0 *1 8.28,127.84
X$7486 105 3711 3634 3633 105 40 3289 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7487 m0 *1 10.12,127.84
X$7487 105 3633 3634 3567 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7488 m0 *1 13.34,127.84
X$7488 105 3576 3634 3600 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $7489 m0 *1 15.64,127.84
X$7489 105 3571 3682 3681 105 3177 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $7490 m0 *1 18.86,127.84
X$7490 105 3516 3124 3717 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7492 m0 *1 21.16,127.84
X$7492 40 3344 3713 3261 3178 3635 105 105 40 sky130_fd_sc_hd__nor4_2
* cell instance $7493 m0 *1 25.76,127.84
X$7493 105 3540 3569 3570 3906 40 105 3716 40 sky130_fd_sc_hd__and4_1
* cell instance $7495 m0 *1 29.44,127.84
X$7495 40 3540 3569 3570 105 3682 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $7496 m0 *1 35.88,127.84
X$7496 40 3657 3718 3409 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $7498 m0 *1 42.78,127.84
X$7498 40 3637 3721 2930 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $7500 m0 *1 54.74,127.84
X$7500 105 3415 3658 3414 105 40 3606 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7504 m0 *1 58.42,127.84
X$7504 105 3659 3637 3578 105 40 3687 40 sky130_fd_sc_hd__o21bai_1
* cell instance $7505 m0 *1 61.18,127.84
X$7505 105 1591 3638 3637 3578 105 3724 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $7507 m0 *1 64.86,127.84
X$7507 40 3577 3640 3639 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $7508 m0 *1 69.92,127.84
X$7508 105 3639 3640 3638 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $7510 m0 *1 73.14,127.84
X$7510 40 3548 3506 1986 105 3610 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7513 m0 *1 79.12,127.84
X$7513 40 3581 3523 1988 105 3663 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7521 m0 *1 95.22,127.84
X$7521 40 3728 2583 3351 2360 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $7522 m0 *1 98.9,127.84
X$7522 105 3553 40 105 3582 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $7525 m0 *1 104.42,127.84
X$7525 105 3553 40 105 3666 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $7526 m0 *1 107.64,127.84
X$7526 105 3615 3887 3690 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7529 m0 *1 112.24,127.84
X$7529 40 3641 3732 3731 105 3668 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7530 m0 *1 116.84,127.84
X$7530 105 3642 3690 3619 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7532 m0 *1 118.68,127.84
X$7532 105 3643 3807 3620 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7533 m0 *1 121.9,127.84
X$7533 105 3672 3555 3643 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7535 m0 *1 128.8,127.84
X$7535 40 2904 3464 3420 3674 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7537 m0 *1 139.84,127.84
X$7537 40 3624 3390 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $7540 m0 *1 149.5,127.84
X$7540 40 2904 3332 3401 3737 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7549 m0 *1 173.88,127.84
X$7549 105 3245 3696 3673 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7550 m0 *1 175.26,127.84
X$7550 40 2904 3281 3405 3694 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7552 m0 *1 186.76,127.84
X$7552 105 3405 9570 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7556 m0 *1 191.36,127.84
X$7556 105 3587 3670 3740 105 40 3458 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7557 m0 *1 193.2,127.84
X$7557 105 3278 3696 3670 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7560 m0 *1 195.5,127.84
X$7560 40 3667 3669 3526 3243 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7562 m0 *1 200.1,127.84
X$7562 40 2904 3114 3405 3819 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7566 m0 *1 217.12,127.84
X$7566 105 3525 3447 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $7567 m0 *1 218.5,127.84
X$7567 105 3561 3774 3664 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7572 m0 *1 223.1,127.84
X$7572 105 3358 3665 3556 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7573 m0 *1 224.48,127.84
X$7573 40 3588 3645 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $7574 m0 *1 228.62,127.84
X$7574 40 3390 3697 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $7575 m0 *1 232.76,127.84
X$7575 40 2904 3394 3622 3662 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7577 m0 *1 245.18,127.84
X$7577 40 3777 3356 3738 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7584 m0 *1 264.96,127.84
X$7584 40 3735 3249 3206 3734 3530 3531 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $7587 m0 *1 270.02,127.84
X$7587 105 5015 3646 3592 105 40 3660 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7588 m0 *1 271.86,127.84
X$7588 105 3084 3605 3646 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7592 m0 *1 277.84,127.84
X$7592 40 2904 3647 3023 3730 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7593 m0 *1 288.42,127.84
X$7593 40 2904 3648 3363 3882 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7594 m0 *1 299,127.84
X$7594 105 3726 3656 3592 105 40 3503 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7595 m0 *1 300.84,127.84
X$7595 105 3091 3605 3656 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7599 m0 *1 305.44,127.84
X$7599 40 3723 3866 2664 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $7602 m0 *1 315.56,127.84
X$7602 105 3532 3653 3654 105 40 3652 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7603 m0 *1 317.4,127.84
X$7603 105 3538 3605 3653 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7604 m0 *1 318.78,127.84
X$7604 40 2747 3595 3426 3720 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7605 m0 *1 327.98,127.84
X$7605 40 3651 3648 3650 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7608 m0 *1 333.04,127.84
X$7608 40 2747 3708 3426 3715 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7611 m0 *1 346.38,127.84
X$7611 105 3259 3710 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7612 m0 *1 347.76,127.84
X$7612 105 3708 3868 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7615 r0 *1 4.14,127.84
X$7615 40 3219 3744 3680 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $7616 r0 *1 10.12,127.84
X$7616 40 3636 3680 3634 3679 105 105 40 sky130_fd_sc_hd__nor3b_2
* cell instance $7622 r0 *1 15.64,127.84
X$7622 40 3681 3682 3571 3748 105 3566 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $7623 r0 *1 23.46,127.84
X$7623 105 3682 3749 3681 40 105 3635 40 sky130_fd_sc_hd__a21oi_1
* cell instance $7625 r0 *1 25.76,127.84
X$7625 40 3570 3569 3571 105 3415 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $7626 r0 *1 32.2,127.84
X$7626 105 3569 3684 3573 105 3178 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $7627 r0 *1 35.42,127.84
X$7627 105 3569 3573 3684 40 105 3748 40 sky130_fd_sc_hd__a21o_1
* cell instance $7628 r0 *1 38.18,127.84
X$7628 105 3683 3521 3718 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7629 r0 *1 39.56,127.84
X$7629 105 3792 40 3569 105 40 sky130_fd_sc_hd__buf_2
* cell instance $7630 r0 *1 41.4,127.84
X$7630 105 3685 105 40 3719 40 sky130_fd_sc_hd__inv_1
* cell instance $7636 r0 *1 43.7,127.84
X$7636 105 3752 3540 3637 3685 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $7637 r0 *1 46,127.84
X$7637 105 3540 3576 3636 3753 105 3793 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $7639 r0 *1 48.76,127.84
X$7639 105 3415 3754 3793 105 40 3376 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7640 r0 *1 50.6,127.84
X$7640 40 3686 3722 3637 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $7641 r0 *1 60.72,127.84
X$7641 105 3799 3800 3724 3687 3754 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $7643 r0 *1 63.94,127.84
X$7643 105 3638 3753 3183 40 105 3800 40 sky130_fd_sc_hd__a21o_1
* cell instance $7644 r0 *1 66.7,127.84
X$7644 105 3686 3688 3912 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7651 r0 *1 70.84,127.84
X$7651 105 3506 3474 3608 40 3639 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $7654 r0 *1 79.58,127.84
X$7654 105 3325 3663 3725 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7658 r0 *1 84.64,127.84
X$7658 40 3841 3760 3689 3454 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $7666 r0 *1 98.44,127.84
X$7666 40 2585 3804 3420 2360 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $7667 r0 *1 109.48,127.84
X$7667 40 1813 3805 3216 3642 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $7668 r0 *1 111.78,127.84
X$7668 40 3731 3672 3618 105 3805 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7669 r0 *1 116.38,127.84
X$7669 40 2880 3420 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $7675 r0 *1 126.5,127.84
X$7675 40 3307 3644 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $7676 r0 *1 130.64,127.84
X$7676 40 2904 3691 3420 3969 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7677 r0 *1 141.22,127.84
X$7677 40 2904 3768 3766 3810 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7686 r0 *1 155.94,127.84
X$7686 105 3692 3817 3816 105 40 3677 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7687 r0 *1 157.78,127.84
X$7687 105 3586 3693 3817 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7689 r0 *1 162.84,127.84
X$7689 40 2904 3824 3133 3821 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7690 r0 *1 173.42,127.84
X$7690 40 3623 3695 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $7694 r0 *1 177.56,127.84
X$7694 105 3246 3696 3630 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7695 r0 *1 178.94,127.84
X$7695 105 3281 3696 3772 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7700 r0 *1 182.62,127.84
X$7700 105 3077 3696 3739 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7701 r0 *1 184,127.84
X$7701 40 2904 3741 3405 3900 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7702 r0 *1 194.58,127.84
X$7702 105 3587 3773 3822 105 40 3742 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7703 r0 *1 196.42,127.84
X$7703 40 2904 3098 3405 3742 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7710 r0 *1 208.84,127.84
X$7710 40 2904 3543 2986 3815 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7711 r0 *1 219.42,127.84
X$7711 40 2904 3561 3622 3811 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7713 r0 *1 230.46,127.84
X$7713 40 3808 3394 3662 3809 3530 3698 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $7721 r0 *1 238.74,127.84
X$7721 105 3528 3616 3699 3700 3661 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $7724 r0 *1 244.26,127.84
X$7724 40 3622 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $7726 r0 *1 256.22,127.84
X$7726 105 3487 3778 3249 3489 105 3703 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $7730 r0 *1 258.98,127.84
X$7730 40 3437 3735 3736 3703 3695 105 105 40 sky130_fd_sc_hd__o22ai_2
* cell instance $7733 r0 *1 264.96,127.84
X$7733 105 3781 3531 3734 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7734 r0 *1 266.34,127.84
X$7734 40 2904 3159 3622 3733 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7735 r0 *1 276.92,127.84
X$7735 105 3695 105 40 3440 40 sky130_fd_sc_hd__buf_4
* cell instance $7736 r0 *1 279.68,127.84
X$7736 105 3592 3796 4682 105 40 3730 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7738 r0 *1 282.44,127.84
X$7738 105 3647 3693 3796 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7740 r0 *1 284.74,127.84
X$7740 105 2746 3693 3794 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7744 r0 *1 286.12,127.84
X$7744 105 3704 3794 3592 105 40 3729 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7752 r0 *1 294.86,127.84
X$7752 105 3528 3705 4304 105 40 3727 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7753 r0 *1 296.7,127.84
X$7753 105 3263 3780 3705 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7755 r0 *1 299.92,127.84
X$7755 40 2904 3783 3706 3791 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7756 r0 *1 309.12,127.84
X$7756 40 2904 3707 3706 3789 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $7762 r0 *1 320.16,127.84
X$7762 40 3720 3707 3595 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7765 r0 *1 326.6,127.84
X$7765 105 3426 9574 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7766 r0 *1 327.98,127.84
X$7766 40 3034 3426 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $7767 r0 *1 337.18,127.84
X$7767 40 3714 3647 3494 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7771 r0 *1 341.32,127.84
X$7771 40 3536 3712 3709 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7774 r0 *1 346.84,127.84
X$7774 105 3709 3786 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7777 m0 *1 1.84,133.28
X$7777 105 3744 3743 3787 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7778 m0 *1 3.22,133.28
X$7778 40 40 3744 105 3681 3633 105 sky130_fd_sc_hd__nor2_2
* cell instance $7780 m0 *1 5.98,133.28
X$7780 105 3680 3634 3679 3745 105 40 40 sky130_fd_sc_hd__or3b_1
* cell instance $7781 m0 *1 9.2,133.28
X$7781 40 40 3681 105 3827 3745 105 sky130_fd_sc_hd__nor2_2
* cell instance $7783 m0 *1 11.96,133.28
X$7783 105 3827 3571 3745 105 40 3747 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7785 m0 *1 14.26,133.28
X$7785 105 3829 3746 3466 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7786 m0 *1 15.64,133.28
X$7786 40 3124 3747 3682 3749 3716 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $7788 m0 *1 22.54,133.28
X$7788 40 3832 4048 3750 105 3429 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $7790 m0 *1 29.44,133.28
X$7790 105 3751 3835 3750 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7794 m0 *1 34.04,133.28
X$7794 40 3684 3683 3833 3834 3835 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $7795 m0 *1 38.64,133.28
X$7795 105 3521 3572 3792 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $7797 m0 *1 42.78,133.28
X$7797 105 3752 3637 3950 105 3575 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $7799 m0 *1 45.08,133.28
X$7799 105 3752 3325 3721 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7802 m0 *1 47.84,133.28
X$7802 105 3686 1508 3755 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7803 m0 *1 51.06,133.28
X$7803 105 3722 3755 3757 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7804 m0 *1 52.44,133.28
X$7804 105 3756 3909 3877 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7805 m0 *1 53.82,133.28
X$7805 105 3878 3758 3798 3797 40 105 40 sky130_fd_sc_hd__nor3b_1
* cell instance $7808 m0 *1 57.96,133.28
X$7808 105 3880 3757 3638 3578 40 3799 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $7809 m0 *1 60.26,133.28
X$7809 40 40 3837 105 3577 3759 105 sky130_fd_sc_hd__nor2_2
* cell instance $7810 m0 *1 62.56,133.28
X$7810 40 40 3759 3659 3638 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $7811 m0 *1 64.86,133.28
X$7811 40 3688 3578 3840 3758 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $7812 m0 *1 73.14,133.28
X$7812 105 3759 105 40 3183 40 sky130_fd_sc_hd__buf_4
* cell instance $7816 m0 *1 84.64,133.28
X$7816 40 3762 3883 2803 105 3760 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7817 m0 *1 89.24,133.28
X$7817 105 3761 3762 3763 3884 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $7818 m0 *1 91.08,133.28
X$7818 105 3762 3763 3761 105 3843 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $7820 m0 *1 94.3,133.28
X$7820 40 2585 3886 3420 3728 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $7822 m0 *1 105.8,133.28
X$7822 105 3216 3764 3964 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7823 m0 *1 107.18,133.28
X$7823 40 3642 3804 3668 3765 3764 105 105 40 sky130_fd_sc_hd__and4b_1
* cell instance $7826 m0 *1 112.24,133.28
X$7826 40 1813 3888 3804 3642 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $7827 m0 *1 114.54,133.28
X$7827 40 3845 3806 3641 105 3890 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7828 m0 *1 119.14,133.28
X$7828 105 3806 3732 105 3807 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $7832 m0 *1 128.8,133.28
X$7832 40 2904 3064 3420 3891 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7837 m0 *1 143.06,133.28
X$7837 105 3775 3812 3846 105 40 3810 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7839 m0 *1 145.36,133.28
X$7839 105 3768 3767 3812 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7841 m0 *1 150.42,133.28
X$7841 105 3775 3814 3813 105 40 3737 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7843 m0 *1 152.72,133.28
X$7843 105 3332 3769 3814 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7845 m0 *1 155.02,133.28
X$7845 40 2904 3404 3401 3892 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $7846 m0 *1 164.68,133.28
X$7846 105 3692 3983 3927 105 40 3676 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7849 m0 *1 167.44,133.28
X$7849 40 3821 3741 3824 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7850 m0 *1 171.58,133.28
X$7850 105 3898 3825 3692 105 40 3515 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7851 m0 *1 173.42,133.28
X$7851 105 3460 3771 3825 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7853 m0 *1 175.26,133.28
X$7853 40 2904 3849 3405 3899 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7855 m0 *1 187.68,133.28
X$7855 105 3692 3823 3902 105 40 3671 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7856 m0 *1 189.52,133.28
X$7856 105 3669 3771 3823 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7861 m0 *1 196.42,133.28
X$7861 105 3098 3696 3773 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7864 m0 *1 199.18,133.28
X$7864 105 3587 3820 4071 105 40 3819 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7865 m0 *1 201.02,133.28
X$7865 105 3114 3696 3820 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7867 m0 *1 203.32,133.28
X$7867 105 3698 40 3696 105 40 sky130_fd_sc_hd__buf_2
* cell instance $7870 m0 *1 206.54,133.28
X$7870 105 3692 3818 3978 105 40 3815 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7871 m0 *1 208.38,133.28
X$7871 105 3543 3771 3818 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7874 m0 *1 211.14,133.28
X$7874 40 2904 3504 2986 3903 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7877 m0 *1 222.64,133.28
X$7877 40 3854 3561 3811 3776 3530 3698 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $7878 m0 *1 226.32,133.28
X$7878 105 3698 3781 3776 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7881 m0 *1 230,133.28
X$7881 105 3698 3616 3809 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7882 m0 *1 231.38,133.28
X$7882 40 5570 3082 3422 5342 3026 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $7883 m0 *1 239.2,133.28
X$7883 105 3027 3775 3699 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7884 m0 *1 240.58,133.28
X$7884 40 3034 3622 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $7886 m0 *1 250.24,133.28
X$7886 105 3895 3778 3082 3779 105 3802 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $7888 m0 *1 253.92,133.28
X$7888 40 3270 3532 3935 3893 3616 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $7889 m0 *1 258.52,133.28
X$7889 40 3105 3781 3855 3857 3769 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $7890 m0 *1 263.12,133.28
X$7890 105 3082 3780 3857 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7892 m0 *1 264.96,133.28
X$7892 105 3781 3771 3801 3889 3546 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $7895 m0 *1 270.02,133.28
X$7895 105 3026 3605 3801 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7902 m0 *1 283.36,133.28
X$7902 105 3648 3767 3795 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7904 m0 *1 285.2,133.28
X$7904 105 3864 3795 3782 105 40 3882 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7905 m0 *1 287.04,133.28
X$7905 40 2904 2746 3363 3729 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7908 m0 *1 299.92,133.28
X$7908 40 3791 3863 3783 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $7911 m0 *1 305.44,133.28
X$7911 40 3034 3706 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $7912 m0 *1 314.64,133.28
X$7912 105 3864 3788 3790 105 40 3789 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7913 m0 *1 316.48,133.28
X$7913 105 3707 3780 3788 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7914 m0 *1 317.86,133.28
X$7914 105 3712 3605 3944 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7918 m0 *1 322.46,133.28
X$7918 40 2747 2904 105 105 40 sky130_fd_sc_hd__buf_16
* cell instance $7921 m0 *1 334.88,133.28
X$7921 105 3783 3867 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7922 m0 *1 336.26,133.28
X$7922 40 2747 3784 3426 3874 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $7923 m0 *1 345.46,133.28
X$7923 105 3784 3942 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7925 m0 *1 347.76,133.28
X$7925 105 3870 4041 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $7926 r0 *1 1.38,133.28
X$7926 105 3869 3826 3828 40 105 3743 40 sky130_fd_sc_hd__a21oi_1
* cell instance $7927 r0 *1 3.22,133.28
X$7927 40 3828 3826 3149 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $7928 r0 *1 13.34,133.28
X$7928 105 3516 3872 3829 3827 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $7931 r0 *1 15.64,133.28
X$7931 40 3872 3576 3516 3829 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $7932 r0 *1 17.94,133.28
X$7932 40 40 3828 105 3682 3747 105 sky130_fd_sc_hd__nor2_2
* cell instance $7933 r0 *1 20.24,133.28
X$7933 40 3831 3516 4078 3905 3830 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $7935 r0 *1 28.52,133.28
X$7935 40 3832 3261 3713 3907 3682 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $7936 r0 *1 33.12,133.28
X$7936 40 3683 3752 3833 3834 3570 3835 105 105 40 sky130_fd_sc_hd__a311oi_4
* cell instance $7940 r0 *1 43.7,133.28
X$7940 40 3798 3752 3836 3831 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $7942 r0 *1 52.44,133.28
X$7942 105 3876 3998 3911 40 105 3910 40 sky130_fd_sc_hd__a21oi_1
* cell instance $7943 r0 *1 54.28,133.28
X$7943 40 3573 3877 3836 3758 3797 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $7945 r0 *1 57.96,133.28
X$7945 40 3953 3910 3798 4142 105 105 40 sky130_fd_sc_hd__nor3b_4
* cell instance $7946 r0 *1 64.86,133.28
X$7946 105 3837 3840 3839 40 3836 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $7947 r0 *1 68.08,133.28
X$7947 105 1508 3659 3840 3839 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $7951 r0 *1 70.84,133.28
X$7951 105 3838 3761 3913 105 3234 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $7952 r0 *1 74.06,133.28
X$7952 105 3831 105 40 3758 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $7956 r0 *1 79.12,133.28
X$7956 40 3831 3841 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $7958 r0 *1 84.18,133.28
X$7958 105 3961 3841 3842 105 3524 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $7960 r0 *1 87.86,133.28
X$7960 105 3962 3883 3843 3960 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $7961 r0 *1 89.7,133.28
X$7961 105 3843 3884 3689 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7968 r0 *1 98.44,133.28
X$7968 40 9561 3885 3916 105 2804 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7971 r0 *1 105.34,133.28
X$7971 105 3964 3965 3844 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $7972 r0 *1 108.56,133.28
X$7972 105 3765 3844 3887 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $7974 r0 *1 110.86,133.28
X$7974 40 3617 3890 3886 105 3888 105 40 sky130_fd_sc_hd__ha_1
* cell instance $7982 r0 *1 126.96,133.28
X$7982 40 2904 3397 3420 4067 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $7986 r0 *1 143.98,133.28
X$7986 105 3529 105 40 3921 40 sky130_fd_sc_hd__buf_4
* cell instance $7994 r0 *1 155.94,133.28
X$7994 105 3775 3981 3979 105 40 3892 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7995 r0 *1 157.78,133.28
X$7995 105 3404 3769 3981 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $7996 r0 *1 159.16,133.28
X$7996 105 3847 3982 3692 105 40 3894 40 sky130_fd_sc_hd__o21ai_1
* cell instance $7997 r0 *1 161,133.28
X$7997 105 3021 3693 3982 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8000 r0 *1 165.14,133.28
X$8000 105 3355 3771 3983 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8001 r0 *1 166.52,133.28
X$8001 105 3692 3985 3984 105 40 3896 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8002 r0 *1 168.36,133.28
X$8002 105 3514 3771 3985 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8006 r0 *1 174.8,133.28
X$8006 105 3849 3696 3988 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8007 r0 *1 176.18,133.28
X$8007 105 3850 3988 3987 105 40 3899 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8009 r0 *1 178.02,133.28
X$8009 105 3850 3772 3990 105 40 3694 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8015 r0 *1 184.46,133.28
X$8015 105 3587 3986 4503 105 40 3900 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8016 r0 *1 186.3,133.28
X$8016 105 3741 3696 3986 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8017 r0 *1 187.68,133.28
X$8017 105 3851 3696 3929 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8018 r0 *1 189.06,133.28
X$8018 40 2904 3851 3405 3852 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8027 r0 *1 212.98,133.28
X$8027 105 3775 3976 3975 105 40 3903 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8028 r0 *1 214.82,133.28
X$8028 105 3504 3769 3976 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8032 r0 *1 222.64,133.28
X$8032 40 3853 3698 3736 3854 3901 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $8033 r0 *1 227.24,133.28
X$8033 105 3723 3970 3901 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8036 r0 *1 230,133.28
X$8036 105 3853 3698 3438 3968 105 40 3808 40 sky130_fd_sc_hd__o31ai_1
* cell instance $8044 r0 *1 243.8,133.28
X$8044 40 2904 3738 3622 3777 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $8045 r0 *1 253.46,133.28
X$8045 105 3207 3692 3893 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8047 r0 *1 258.52,133.28
X$8047 105 3856 3778 3026 3858 105 3860 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $8050 r0 *1 262.2,133.28
X$8050 105 3861 3860 3862 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8052 r0 *1 264.04,133.28
X$8052 105 3862 3770 4058 105 40 3889 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8055 r0 *1 270.48,133.28
X$8055 105 3159 3850 3957 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8057 r0 *1 272.32,133.28
X$8057 40 3879 3863 3622 3956 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8059 r0 *1 283.36,133.28
X$8059 105 3864 4054 4716 105 40 3954 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8063 r0 *1 287.96,133.28
X$8063 105 3864 4144 3881 40 3322 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $8065 r0 *1 291.64,133.28
X$8065 105 3310 3767 3881 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8067 r0 *1 293.94,133.28
X$8067 40 3879 3938 3706 3952 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8068 r0 *1 304.52,133.28
X$8068 105 3938 3605 3951 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8070 r0 *1 306.36,133.28
X$8070 40 3879 3866 3706 4051 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8072 r0 *1 316.94,133.28
X$8072 105 3532 3944 3946 105 40 3875 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8074 r0 *1 319.24,133.28
X$8074 40 2747 3712 3426 3875 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8076 r0 *1 331.66,133.28
X$8076 40 3715 3865 3708 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $8077 r0 *1 335.8,133.28
X$8077 40 3874 3938 3784 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $8081 r0 *1 342.24,133.28
X$8081 105 3873 3941 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8082 r0 *1 343.62,133.28
X$8082 105 3434 4127 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8086 r0 *1 346.84,133.28
X$8086 105 3871 3943 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8115 m0 *1 1.84,138.72
X$8115 40 4043 3679 3288 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $8117 m0 *1 12.42,138.72
X$8117 40 3500 3838 3994 3904 3872 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $8119 m0 *1 16.1,138.72
X$8119 105 3838 3994 3904 3746 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $8120 m0 *1 17.94,138.72
X$8120 40 3826 3830 3905 3945 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $8122 m0 *1 24.84,138.72
X$8122 105 3713 3261 3906 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8123 m0 *1 26.22,138.72
X$8123 105 4049 3945 3996 3995 3908 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $8125 m0 *1 29.44,138.72
X$8125 40 4050 3261 3907 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $8126 m0 *1 33.58,138.72
X$8126 105 3913 105 40 3905 40 sky130_fd_sc_hd__buf_4
* cell instance $8127 m0 *1 36.34,138.72
X$8127 105 4052 105 40 3833 40 sky130_fd_sc_hd__inv_1
* cell instance $8128 m0 *1 37.72,138.72
X$8128 105 3948 3947 3908 105 40 3683 40 sky130_fd_sc_hd__or3_2
* cell instance $8129 m0 *1 40.48,138.72
X$8129 105 3949 3908 3950 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $8130 m0 *1 43.7,138.72
X$8130 40 3876 1508 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $8131 m0 *1 48.76,138.72
X$8131 40 3909 3756 3831 3540 3878 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $8133 m0 *1 57.04,138.72
X$8133 105 1508 3686 4053 4000 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $8134 m0 *1 58.88,138.72
X$8134 40 3953 3659 3911 3998 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $8135 m0 *1 64.86,138.72
X$8135 105 3998 3911 3688 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8136 m0 *1 66.24,138.72
X$8136 40 3753 4056 3912 3831 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $8138 m0 *1 70.84,138.72
X$8138 40 4002 3377 4057 3831 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $8139 m0 *1 79.12,138.72
X$8139 105 3758 4061 3959 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8140 m0 *1 80.5,138.72
X$8140 105 3914 3841 4006 40 105 3663 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8142 m0 *1 82.8,138.72
X$8142 105 3841 4092 3914 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8145 m0 *1 85.1,138.72
X$8145 105 3915 3960 3841 105 3961 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $8146 m0 *1 86.94,138.72
X$8146 105 3962 3843 3883 105 3915 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $8147 m0 *1 89.7,138.72
X$8147 40 3962 3842 4008 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $8150 m0 *1 101.66,138.72
X$8150 40 9537 3764 3917 105 3918 105 40 sky130_fd_sc_hd__ha_1
* cell instance $8152 m0 *1 107.18,138.72
X$8152 105 3804 4064 3965 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8154 m0 *1 109.02,138.72
X$8154 105 4009 3886 3918 4065 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $8157 m0 *1 112.24,138.72
X$8157 40 4009 3886 3618 105 4223 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $8159 m0 *1 117.76,138.72
X$8159 40 2904 3396 3420 3967 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8163 m0 *1 131.56,138.72
X$8163 105 3064 3919 4152 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8164 m0 *1 132.94,138.72
X$8164 105 3973 3971 3920 105 40 3674 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8165 m0 *1 134.78,138.72
X$8165 105 3464 3919 3971 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8166 m0 *1 136.16,138.72
X$8166 105 4011 3972 3920 105 40 3969 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8167 m0 *1 138,138.72
X$8167 105 3691 3919 3972 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8170 m0 *1 140.76,138.72
X$8170 105 3848 4014 4013 40 105 3973 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8171 m0 *1 142.6,138.72
X$8171 105 3440 4070 3974 105 40 4013 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8172 m0 *1 144.44,138.72
X$8172 105 4015 3464 3921 40 105 3974 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8175 m0 *1 148.58,138.72
X$8175 105 3440 3922 4158 105 40 4073 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8176 m0 *1 150.42,138.72
X$8176 105 3695 40 3977 105 40 sky130_fd_sc_hd__buf_2
* cell instance $8178 m0 *1 155.94,138.72
X$8178 105 3924 3923 4074 40 105 3979 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8181 m0 *1 165.14,138.72
X$8181 105 3924 3980 3928 40 105 3984 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8184 m0 *1 168.36,138.72
X$8184 105 3897 3926 4019 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8188 m0 *1 174.8,138.72
X$8188 105 3924 3770 4022 40 105 3987 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8194 m0 *1 187.22,138.72
X$8194 105 3587 3929 4169 105 40 3852 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8202 m0 *1 205.16,138.72
X$8202 105 3925 40 3698 105 40 sky130_fd_sc_hd__buf_2
* cell instance $8203 m0 *1 207,138.72
X$8203 105 3930 3980 4068 40 105 3978 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8206 m0 *1 214.36,138.72
X$8206 105 4027 4155 4121 105 40 4028 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8207 m0 *1 216.2,138.72
X$8207 105 3930 3923 4028 40 105 3975 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8210 m0 *1 219.42,138.72
X$8210 105 3931 3925 4029 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8215 m0 *1 223.1,138.72
X$8215 105 4029 3778 3561 3931 40 3970 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $8217 m0 *1 227.24,138.72
X$8217 105 3488 4029 3394 3931 40 3932 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $8219 m0 *1 230.92,138.72
X$8219 105 3723 3932 3968 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8220 m0 *1 232.3,138.72
X$8220 105 3698 40 3936 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8225 m0 *1 243.8,138.72
X$8225 40 3895 3488 4031 3027 3779 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $8226 m0 *1 248.4,138.72
X$8226 105 4031 3933 3966 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8228 m0 *1 250.24,138.72
X$8228 105 4063 3770 3966 105 40 3700 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8230 m0 *1 253,138.72
X$8230 105 3933 3802 3963 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8234 m0 *1 257.6,138.72
X$8234 105 4062 3770 3963 105 40 3855 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8236 m0 *1 259.9,138.72
X$8236 40 3488 3856 3934 3207 3858 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $8237 m0 *1 264.5,138.72
X$8237 105 4059 3770 3958 105 40 3935 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8238 m0 *1 266.34,138.72
X$8238 105 3861 3934 3958 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8241 m0 *1 270.02,138.72
X$8241 105 3936 3957 4318 105 40 3733 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8243 m0 *1 272.78,138.72
X$8243 105 3864 3955 4122 105 40 3956 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8244 m0 *1 274.62,138.72
X$8244 105 3863 3780 3955 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8250 m0 *1 279.22,138.72
X$8250 40 3879 3865 3023 4055 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8251 m0 *1 289.8,138.72
X$8251 40 3879 3202 3706 3954 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8252 m0 *1 300.38,138.72
X$8252 105 3937 3951 3592 105 40 3952 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8254 m0 *1 303.14,138.72
X$8254 105 4036 3939 3936 105 40 3655 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8256 m0 *1 305.44,138.72
X$8256 40 3706 9492 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $8257 m0 *1 310.5,138.72
X$8257 105 3025 3850 3939 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8260 m0 *1 313.26,138.72
X$8260 40 3879 4047 3706 4135 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $8262 m0 *1 323.38,138.72
X$8262 40 2747 3873 3426 4046 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $8264 m0 *1 333.04,138.72
X$8264 40 3940 4038 4040 2748 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $8265 m0 *1 337.18,138.72
X$8265 40 2747 4040 3426 3940 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $8267 m0 *1 347.3,138.72
X$8267 105 4044 4128 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8270 r0 *1 1.84,138.72
X$8270 105 4076 3991 3869 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8272 r0 *1 4.14,138.72
X$8272 105 3991 3744 3992 40 4043 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $8274 r0 *1 7.82,138.72
X$8274 105 3838 4078 3905 3991 40 105 40 sky130_fd_sc_hd__nor3b_1
* cell instance $8275 r0 *1 10.58,138.72
X$8275 105 3993 4077 4045 40 105 3838 40 sky130_fd_sc_hd__and3_2
* cell instance $8277 r0 *1 13.8,138.72
X$8277 105 4130 3905 3994 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8281 r0 *1 16.56,138.72
X$8281 105 4131 3993 4077 4080 105 4132 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $8283 r0 *1 19.32,138.72
X$8283 105 3906 3635 4048 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8284 r0 *1 20.7,138.72
X$8284 40 3571 4133 4081 3713 4050 105 105 40 sky130_fd_sc_hd__nor4b_4
* cell instance $8285 r0 *1 29.44,138.72
X$8285 105 3997 4049 4212 4081 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $8286 r0 *1 31.28,138.72
X$8286 40 3945 4083 3995 3996 105 3907 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $8287 r0 *1 35.88,138.72
X$8287 105 3996 3995 3997 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8289 r0 *1 38.18,138.72
X$8289 40 3521 3997 3834 4471 3947 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $8293 r0 *1 44.16,138.72
X$8293 40 4212 3996 4083 3995 105 3831 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $8294 r0 *1 51.98,138.72
X$8294 40 3756 1508 3686 4084 3949 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $8296 r0 *1 57.5,138.72
X$8296 105 3837 3911 3998 4142 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $8297 r0 *1 59.34,138.72
X$8297 105 4140 4085 3999 105 4086 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $8298 r0 *1 61.18,138.72
X$8298 105 1508 3686 3999 4001 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $8300 r0 *1 64.4,138.72
X$8300 105 4001 4000 3838 3913 105 3880 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $8301 r0 *1 67.16,138.72
X$8301 105 3840 4145 4086 40 105 4056 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8303 r0 *1 69,138.72
X$8303 105 4146 4088 4057 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8305 r0 *1 70.84,138.72
X$8305 105 4146 4219 4060 40 4177 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $8307 r0 *1 74.52,138.72
X$8307 105 4003 4089 4004 105 4146 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $8308 r0 *1 77.28,138.72
X$8308 105 4003 4004 4089 4088 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $8309 r0 *1 79.12,138.72
X$8309 105 4147 4089 4093 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $8310 r0 *1 81.42,138.72
X$8310 105 4005 4090 4006 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $8311 r0 *1 83.72,138.72
X$8311 105 3959 3758 4093 40 105 3610 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8313 r0 *1 86.02,138.72
X$8313 105 4007 3915 4008 105 4090 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $8314 r0 *1 88.78,138.72
X$8314 105 4007 4008 3915 4005 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $8321 r0 *1 102.58,138.72
X$8321 40 9562 4064 4009 105 3918 105 40 sky130_fd_sc_hd__ha_1
* cell instance $8323 r0 *1 109.02,138.72
X$8323 105 4148 4096 4065 105 2814 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $8324 r0 *1 112.24,138.72
X$8324 40 4095 3555 3618 4009 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $8330 r0 *1 126.04,138.72
X$8330 105 3396 3919 4150 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8331 r0 *1 127.42,138.72
X$8331 105 4010 4151 4156 105 40 4067 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8332 r0 *1 129.26,138.72
X$8332 105 3397 3919 4151 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8334 r0 *1 131.1,138.72
X$8334 105 4010 4152 4154 105 40 3891 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8337 r0 *1 135.7,138.72
X$8337 105 3531 40 3919 105 40 sky130_fd_sc_hd__buf_2
* cell instance $8338 r0 *1 137.54,138.72
X$8338 105 3531 105 40 3920 40 sky130_fd_sc_hd__buf_4
* cell instance $8341 r0 *1 143.06,138.72
X$8341 105 3977 3926 4070 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8343 r0 *1 144.9,138.72
X$8343 40 40 4015 105 4017 3489 105 sky130_fd_sc_hd__nor2_2
* cell instance $8344 r0 *1 147.2,138.72
X$8344 105 3930 4073 4014 40 105 4156 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8345 r0 *1 149.04,138.72
X$8345 105 4072 3397 3921 40 105 4158 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8347 r0 *1 150.88,138.72
X$8347 40 40 4072 105 3489 4016 105 sky130_fd_sc_hd__nor2_2
* cell instance $8349 r0 *1 153.64,138.72
X$8349 40 40 4101 105 3989 3489 105 sky130_fd_sc_hd__nor2_2
* cell instance $8350 r0 *1 155.94,138.72
X$8350 105 4027 4163 4161 105 40 4074 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8352 r0 *1 158.24,138.72
X$8352 105 4162 3404 3779 40 105 4161 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8355 r0 *1 164.68,138.72
X$8355 105 3848 3980 4018 40 105 3927 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8356 r0 *1 166.52,138.72
X$8356 105 4113 4019 4164 105 40 4018 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8357 r0 *1 168.36,138.72
X$8357 105 4103 4020 4105 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8358 r0 *1 169.74,138.72
X$8358 105 4106 3355 3858 40 105 4164 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8359 r0 *1 171.58,138.72
X$8359 105 4017 4021 4106 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8360 r0 *1 172.96,138.72
X$8360 105 4021 4098 4165 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8362 r0 *1 174.8,138.72
X$8362 105 4108 4020 4075 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8363 r0 *1 176.18,138.72
X$8363 105 4075 4166 3024 40 105 4022 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8365 r0 *1 178.02,138.72
X$8365 105 3848 4023 4167 40 105 3990 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8369 r0 *1 181.7,138.72
X$8369 40 3849 4233 4108 1850 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $8371 r0 *1 188.14,138.72
X$8371 105 4024 3980 4168 40 105 3902 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8373 r0 *1 190.44,138.72
X$8373 105 3989 4021 4114 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8375 r0 *1 192.28,138.72
X$8375 105 4024 4023 4117 40 105 3740 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8376 r0 *1 194.12,138.72
X$8376 105 3925 40 3587 105 40 sky130_fd_sc_hd__buf_2
* cell instance $8377 r0 *1 195.96,138.72
X$8377 105 3930 4025 4023 40 105 4071 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8379 r0 *1 198.72,138.72
X$8379 105 4026 4119 3024 40 105 4025 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8383 r0 *1 203.78,138.72
X$8383 105 3698 40 3850 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8387 r0 *1 208.84,138.72
X$8387 40 40 4069 105 4021 4016 105 sky130_fd_sc_hd__nor2_2
* cell instance $8388 r0 *1 211.14,138.72
X$8388 105 4113 4159 4160 105 40 4068 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8389 r0 *1 212.98,138.72
X$8389 105 4157 3504 3779 40 105 4121 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8391 r0 *1 215.28,138.72
X$8391 40 3774 3931 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $8392 r0 *1 219.42,138.72
X$8392 40 2904 3170 3622 4066 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8401 r0 *1 242.88,138.72
X$8401 105 4033 4030 3438 4063 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $8406 r0 *1 256.68,138.72
X$8406 105 4021 4032 3856 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8407 r0 *1 258.06,138.72
X$8407 40 4033 4062 4030 3736 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $8409 r0 *1 261.74,138.72
X$8409 105 4034 4035 3438 4059 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $8411 r0 *1 264.04,138.72
X$8411 40 4034 4058 4035 3736 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $8412 r0 *1 267.72,138.72
X$8412 105 4035 105 40 3693 40 sky130_fd_sc_hd__buf_4
* cell instance $8413 r0 *1 270.48,138.72
X$8413 105 4035 40 3605 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8414 r0 *1 273.24,138.72
X$8414 105 4035 105 40 3532 40 sky130_fd_sc_hd__buf_4
* cell instance $8417 r0 *1 280.14,138.72
X$8417 105 3528 4123 4311 105 40 4055 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8418 r0 *1 281.98,138.72
X$8418 105 3865 3780 4123 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8420 r0 *1 283.82,138.72
X$8420 105 3202 3767 4054 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8428 r0 *1 293.02,138.72
X$8428 40 3879 4143 3706 4217 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8429 r0 *1 303.6,138.72
X$8429 105 4125 4139 3936 105 40 4051 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8430 r0 *1 305.44,138.72
X$8430 105 3866 3850 4139 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8431 r0 *1 306.82,138.72
X$8431 40 3879 4203 3706 4138 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8433 r0 *1 317.4,138.72
X$8433 105 4038 3605 4134 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8438 r0 *1 325.68,138.72
X$8438 40 4046 4047 3873 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $8440 r0 *1 331.66,138.72
X$8440 105 3321 4042 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8441 r0 *1 333.04,138.72
X$8441 40 4039 4124 3870 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $8442 r0 *1 337.18,138.72
X$8442 40 2747 3870 3426 4039 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $8445 r0 *1 346.84,138.72
X$8445 105 4129 4277 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8473 m0 *1 1.38,144.16
X$8473 40 3680 3992 4170 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $8474 m0 *1 7.36,144.16
X$8474 105 3905 3993 4077 40 105 4076 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8475 m0 *1 9.2,144.16
X$8475 40 40 4077 4078 3993 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $8477 m0 *1 11.96,144.16
X$8477 105 3905 4172 4465 40 105 3872 40 sky130_fd_sc_hd__a21o_1
* cell instance $8478 m0 *1 14.72,144.16
X$8478 105 4078 4079 4130 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8479 m0 *1 16.1,144.16
X$8479 105 4079 105 40 4131 40 sky130_fd_sc_hd__inv_1
* cell instance $8481 m0 *1 18.4,144.16
X$8481 40 4080 3993 4045 4077 105 3945 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $8482 m0 *1 26.22,144.16
X$8482 105 4133 4082 4081 40 105 3749 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8486 m0 *1 29.9,144.16
X$8486 40 4468 4083 3830 4082 3996 3995 105 105 40 sky130_fd_sc_hd__a41oi_4
* cell instance $8488 m0 *1 40.48,144.16
X$8488 40 3999 4212 3722 3996 3995 4083 105 105 40 sky130_fd_sc_hd__a41oi_4
* cell instance $8489 m0 *1 50.6,144.16
X$8489 40 4085 4215 4140 3996 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $8491 m0 *1 57.04,144.16
X$8491 40 4141 4215 4349 4087 105 105 40 sky130_fd_sc_hd__a21boi_4
* cell instance $8492 m0 *1 63.94,144.16
X$8492 40 4060 4176 1760 105 3688 105 40 sky130_fd_sc_hd__ha_1
* cell instance $8493 m0 *1 68.54,144.16
X$8493 40 3840 4218 4060 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $8494 m0 *1 74.52,144.16
X$8494 40 4003 4219 1986 105 4002 105 40 sky130_fd_sc_hd__ha_1
* cell instance $8495 m0 *1 79.12,144.16
X$8495 105 4178 4091 4090 105 4089 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $8496 m0 *1 81.88,144.16
X$8496 105 4178 4091 4090 4147 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $8499 m0 *1 84.64,144.16
X$8499 40 4007 4091 2251 105 4092 105 40 sky130_fd_sc_hd__ha_1
* cell instance $8503 m0 *1 97.06,144.16
X$8503 40 3879 4009 4179 4221 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8504 m0 *1 107.64,144.16
X$8504 105 3555 4096 3917 3918 105 4181 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $8506 m0 *1 110.4,144.16
X$8506 105 4094 4095 4148 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8508 m0 *1 112.24,144.16
X$8508 40 4181 2944 4096 3918 4223 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $8512 m0 *1 125.12,144.16
X$8512 105 4010 4150 4149 105 40 3967 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8513 m0 *1 126.96,144.16
X$8513 105 4097 4409 4182 40 105 4149 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8514 m0 *1 128.8,144.16
X$8514 40 2904 3286 3766 4153 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8516 m0 *1 139.84,144.16
X$8516 105 3286 3919 4225 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8518 m0 *1 141.68,144.16
X$8518 105 3924 4014 4226 40 105 4011 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8519 m0 *1 143.52,144.16
X$8519 105 4024 4014 4099 40 105 4154 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8520 m0 *1 145.36,144.16
X$8520 40 40 4227 105 3489 4098 105 sky130_fd_sc_hd__nor2_2
* cell instance $8521 m0 *1 147.66,144.16
X$8521 105 3440 4185 4100 105 40 4099 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8522 m0 *1 149.5,144.16
X$8522 105 4012 3977 3922 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8523 m0 *1 150.88,144.16
X$8523 105 4101 3064 3921 40 105 4100 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8524 m0 *1 152.72,144.16
X$8524 105 4032 105 40 3592 40 sky130_fd_sc_hd__buf_4
* cell instance $8527 m0 *1 156.86,144.16
X$8527 105 4187 4020 4163 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8528 m0 *1 158.24,144.16
X$8528 105 4098 4186 4162 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8529 m0 *1 159.62,144.16
X$8529 105 4102 3980 4228 40 105 3847 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8531 m0 *1 165.14,144.16
X$8531 105 4113 4105 4104 105 40 3928 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8534 m0 *1 168.36,144.16
X$8534 40 40 4230 105 4021 4188 105 sky130_fd_sc_hd__nor2_2
* cell instance $8535 m0 *1 170.66,144.16
X$8535 105 4165 3514 3858 40 105 4104 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8536 m0 *1 172.5,144.16
X$8536 105 4107 4098 4190 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8537 m0 *1 173.88,144.16
X$8537 40 40 4109 105 4107 4017 105 sky130_fd_sc_hd__nor2_2
* cell instance $8539 m0 *1 176.64,144.16
X$8539 105 4190 3849 4110 40 105 4166 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8540 m0 *1 178.48,144.16
X$8540 105 4111 4112 3024 40 105 4167 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8542 m0 *1 181.24,144.16
X$8542 105 4109 3281 4110 40 105 4112 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8544 m0 *1 186.76,144.16
X$8544 105 4102 4023 4336 40 105 4169 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8545 m0 *1 188.6,144.16
X$8545 105 4194 3851 4115 40 105 4231 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8546 m0 *1 190.44,144.16
X$8546 105 4113 4195 4116 105 40 4168 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8547 m0 *1 192.28,144.16
X$8547 105 4114 3669 4120 40 105 4116 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8550 m0 *1 195.04,144.16
X$8550 105 4337 4229 3024 40 105 4117 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8551 m0 *1 196.88,144.16
X$8551 105 4118 3278 4115 40 105 4229 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8552 m0 *1 198.72,144.16
X$8552 105 4192 3989 4118 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8553 m0 *1 200.1,144.16
X$8553 105 4108 4012 4026 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8555 m0 *1 201.94,144.16
X$8555 105 4196 3114 4110 40 105 4119 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8556 m0 *1 203.78,144.16
X$8556 105 4192 4016 4196 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8557 m0 *1 205.16,144.16
X$8557 105 4030 105 40 3528 40 sky130_fd_sc_hd__buf_4
* cell instance $8558 m0 *1 207.92,144.16
X$8558 105 4069 3543 4120 40 105 4160 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8559 m0 *1 209.76,144.16
X$8559 105 3897 4012 4159 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8560 m0 *1 211.14,144.16
X$8560 105 4016 4186 4157 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8563 m0 *1 215.28,144.16
X$8563 105 4187 4012 4155 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8564 m0 *1 216.66,144.16
X$8564 105 3698 105 40 4224 40 sky130_fd_sc_hd__buf_4
* cell instance $8568 m0 *1 222.64,144.16
X$8568 40 3931 4110 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $8569 m0 *1 226.78,144.16
X$8569 105 3170 3936 4329 40 105 4066 40 sky130_fd_sc_hd__a21o_1
* cell instance $8578 m0 *1 251.16,144.16
X$8578 105 3165 3936 4581 40 105 3273 40 sky130_fd_sc_hd__a21o_1
* cell instance $8580 m0 *1 257.6,144.16
X$8580 105 4035 105 40 3771 40 sky130_fd_sc_hd__buf_4
* cell instance $8586 m0 *1 275.54,144.16
X$8586 105 3159 4264 4312 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8593 m0 *1 284.74,144.16
X$8593 40 3879 4124 3706 4220 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8597 m0 *1 303.6,144.16
X$8597 105 3095 3850 4214 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8600 m0 *1 307.28,144.16
X$8600 105 4198 4213 4211 40 4137 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $8601 m0 *1 310.5,144.16
X$8601 105 3196 3850 4211 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8603 m0 *1 312.34,144.16
X$8603 105 3864 4201 4136 105 4135 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $8604 m0 *1 314.18,144.16
X$8604 105 4047 3780 4136 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8606 m0 *1 317.4,144.16
X$8606 105 3532 4274 4134 105 4210 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $8607 m0 *1 319.24,144.16
X$8607 40 3879 4038 4275 4210 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $8609 m0 *1 329.82,144.16
X$8609 105 4205 40 2748 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8611 m0 *1 333.04,144.16
X$8611 105 4205 105 40 2470 40 sky130_fd_sc_hd__buf_4
* cell instance $8613 m0 *1 337.64,144.16
X$8613 40 2747 3871 4209 4208 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $8615 m0 *1 347.76,144.16
X$8615 105 4040 4278 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8618 r0 *1 5.52,144.16
X$8618 40 3634 4234 4281 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $8619 r0 *1 11.5,144.16
X$8619 105 4284 4281 3904 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8620 r0 *1 12.88,144.16
X$8620 105 4078 4079 4171 4172 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $8626 r0 *1 15.64,144.16
X$8626 40 4170 4141 4286 4173 4290 105 105 40 sky130_fd_sc_hd__nor4b_2
* cell instance $8627 r0 *1 21.16,144.16
X$8627 105 4045 4077 3993 4291 40 105 4290 40 sky130_fd_sc_hd__a31oi_1
* cell instance $8630 r0 *1 24.84,144.16
X$8630 40 4049 3913 4291 4173 4141 105 105 40 sky130_fd_sc_hd__nor4_4
* cell instance $8632 r0 *1 33.12,144.16
X$8632 105 3996 3995 3949 3945 4049 105 4236 40 40 sky130_fd_sc_hd__o2111ai_1
* cell instance $8635 r0 *1 37.72,144.16
X$8635 105 4238 4236 105 3572 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $8643 r0 *1 44.62,144.16
X$8643 40 3909 3949 1591 4174 4141 105 105 40 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $8644 r0 *1 47.84,144.16
X$8644 105 4175 1591 4053 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $8645 r0 *1 51.06,144.16
X$8645 40 4084 3878 4085 4140 3759 4299 105 105 40 sky130_fd_sc_hd__a2111oi_4
* cell instance $8646 r0 *1 61.18,144.16
X$8646 40 3999 4175 3759 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $8647 r0 *1 67.16,144.16
X$8647 105 4175 4298 4297 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8652 r0 *1 69,144.16
X$8652 105 4219 4146 4218 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8654 r0 *1 70.84,144.16
X$8654 40 4175 4176 4177 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $8656 r0 *1 76.82,144.16
X$8656 40 4178 4004 1988 105 4061 105 40 sky130_fd_sc_hd__ha_1
* cell instance $8658 r0 *1 85.1,144.16
X$8658 40 3803 2251 105 105 40 sky130_fd_sc_hd__clkinv_16
* cell instance $8662 r0 *1 96.14,144.16
X$8662 105 3917 4180 4240 105 4221 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $8665 r0 *1 99.36,144.16
X$8665 105 3770 3917 4180 4240 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $8666 r0 *1 101.2,144.16
X$8666 40 4009 3917 105 105 40 sky130_fd_sc_hd__inv_8
* cell instance $8667 r0 *1 105.34,144.16
X$8667 40 9556 4306 3917 105 4094 105 40 sky130_fd_sc_hd__ha_1
* cell instance $8668 r0 *1 109.94,144.16
X$8668 105 4096 4009 4094 3642 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $8671 r0 *1 114.54,144.16
X$8671 40 2585 4242 4179 3584 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $8676 r0 *1 126.04,144.16
X$8676 40 2904 3334 3766 4309 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8677 r0 *1 136.62,144.16
X$8677 105 4010 4225 4315 105 40 4153 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8678 r0 *1 138.46,144.16
X$8678 105 3977 4183 4317 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8679 r0 *1 139.84,144.16
X$8679 105 3977 4184 4245 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8681 r0 *1 142.14,144.16
X$8681 105 3440 4321 4319 105 40 4226 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8682 r0 *1 143.98,144.16
X$8682 105 4248 4020 4321 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8683 r0 *1 145.36,144.16
X$8683 105 4227 3691 3921 40 105 4319 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8685 r0 *1 149.04,144.16
X$8685 105 3977 4364 4185 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8690 r0 *1 151.34,144.16
X$8690 105 4189 3923 4250 40 105 3813 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8694 r0 *1 155.02,144.16
X$8694 105 4323 3332 3779 40 105 4324 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8695 r0 *1 156.86,144.16
X$8695 105 4027 4253 4324 105 40 4250 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8696 r0 *1 158.7,144.16
X$8696 105 4187 4252 4253 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8697 r0 *1 160.08,144.16
X$8697 105 4103 4328 4254 105 40 4228 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8699 r0 *1 162.38,144.16
X$8699 105 3897 4183 4328 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8700 r0 *1 163.76,144.16
X$8700 105 4032 40 3692 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8701 r0 *1 166.52,144.16
X$8701 105 4230 3021 4120 40 105 4254 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8703 r0 *1 168.82,144.16
X$8703 40 4188 4193 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $8704 r0 *1 172.96,144.16
X$8704 105 4189 3980 4333 40 105 3898 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8707 r0 *1 176.18,144.16
X$8707 105 4189 4232 4023 40 105 3629 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8711 r0 *1 178.02,144.16
X$8711 105 4108 3926 4111 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8717 r0 *1 184,144.16
X$8717 105 4108 4183 4191 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8718 r0 *1 185.38,144.16
X$8718 40 40 4194 105 4192 4193 105 sky130_fd_sc_hd__nor2_2
* cell instance $8719 r0 *1 187.68,144.16
X$8719 105 4191 4231 3024 40 105 4336 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8720 r0 *1 189.52,144.16
X$8720 40 4197 2880 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $8721 r0 *1 198.72,144.16
X$8721 105 4097 4335 4023 40 105 3822 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8722 r0 *1 200.56,144.16
X$8722 105 3136 4224 4334 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8731 r0 *1 210.68,144.16
X$8731 105 3931 40 4192 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8732 r0 *1 213.44,144.16
X$8732 105 3931 40 4115 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8733 r0 *1 216.2,144.16
X$8733 105 3925 105 40 4198 40 sky130_fd_sc_hd__buf_4
* cell instance $8735 r0 *1 219.42,144.16
X$8735 40 40 6085 105 3114 4110 105 sky130_fd_sc_hd__nor2_2
* cell instance $8738 r0 *1 223.1,144.16
X$8738 40 3931 4107 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $8741 r0 *1 231.38,144.16
X$8741 105 3695 40 4248 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8748 r0 *1 238.28,144.16
X$8748 105 4186 4246 3895 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8754 r0 *1 250.24,144.16
X$8754 105 4032 40 4035 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8756 r0 *1 253.92,144.16
X$8756 105 4198 4677 4222 40 3208 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $8757 r0 *1 257.14,144.16
X$8757 105 3140 4224 4222 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8763 r0 *1 260.82,144.16
X$8763 105 4030 40 3780 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $8768 r0 *1 267.26,144.16
X$8768 105 2958 3858 4320 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8769 r0 *1 268.64,144.16
X$8769 105 2958 105 40 4314 40 sky130_fd_sc_hd__inv_1
* cell instance $8770 r0 *1 270.02,144.16
X$8770 40 3879 2958 4260 4316 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $8772 r0 *1 280.6,144.16
X$8772 105 4199 4263 4310 40 105 4311 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8783 r0 *1 293.94,144.16
X$8783 105 3936 4305 4303 105 40 4217 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8784 r0 *1 295.78,144.16
X$8784 105 4143 3850 4305 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8786 r0 *1 299,144.16
X$8786 105 4107 4300 4216 40 4302 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $8787 r0 *1 302.22,144.16
X$8787 105 3723 4302 4267 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8788 r0 *1 303.6,144.16
X$8788 105 4198 4268 4214 40 3425 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $8789 r0 *1 306.82,144.16
X$8789 105 3936 4295 4296 105 40 4138 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8790 r0 *1 308.66,144.16
X$8790 105 4203 3850 4295 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8791 r0 *1 310.04,144.16
X$8791 105 3723 4294 4200 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8798 r0 *1 314.64,144.16
X$8798 105 4202 4271 4293 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8803 r0 *1 319.7,144.16
X$8803 105 4204 4113 4273 40 105 4292 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8807 r0 *1 327.52,144.16
X$8807 40 3879 4044 4275 4288 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $8808 r0 *1 336.72,144.16
X$8808 105 3421 4287 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8810 r0 *1 338.56,144.16
X$8810 40 4208 4285 3871 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $8814 r0 *1 342.7,144.16
X$8814 105 4206 4207 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8816 r0 *1 345,144.16
X$8816 105 4283 4389 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8819 r0 *1 347.76,144.16
X$8819 105 4279 4282 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8821 m0 *1 5.06,149.6
X$8821 105 4280 4171 4281 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $8822 m0 *1 8.28,149.6
X$8822 40 4045 4235 4341 4079 4171 105 105 40 sky130_fd_sc_hd__nor4_2
* cell instance $8824 m0 *1 13.34,149.6
X$8824 105 4235 4343 3829 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $8826 m0 *1 16.1,149.6
X$8826 105 4344 4345 3993 4077 4286 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $8828 m0 *1 19.32,149.6
X$8828 40 4077 4045 4212 3993 4080 105 105 40 sky130_fd_sc_hd__and4_2
* cell instance $8830 m0 *1 23.46,149.6
X$8830 40 3835 3751 4133 4347 4397 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $8833 m0 *1 29.44,149.6
X$8833 40 4141 4173 4237 4050 4470 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $8835 m0 *1 34.96,149.6
X$8835 40 4141 3835 4173 4237 4083 4212 105 105 40 sky130_fd_sc_hd__a2111oi_4
* cell instance $8836 m0 *1 45.08,149.6
X$8836 40 4140 4173 4085 4239 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $8837 m0 *1 51.06,149.6
X$8837 40 3995 4239 4085 4140 105 105 40 sky130_fd_sc_hd__or3_4
* cell instance $8841 m0 *1 57.04,149.6
X$8841 40 4239 3293 3759 4299 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $8843 m0 *1 63.94,149.6
X$8843 105 4087 4349 4053 4145 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $8844 m0 *1 65.78,149.6
X$8844 40 4175 4215 3759 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $8845 m0 *1 69.92,149.6
X$8845 40 4177 4299 4176 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $8850 m0 *1 84.64,149.6
X$8850 40 3834 4301 4404 3842 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $8856 m0 *1 95.22,149.6
X$8856 105 3553 2804 105 40 40 sky130_fd_sc_hd__inv_6
* cell instance $8857 m0 *1 98.44,149.6
X$8857 105 3770 4405 4180 4241 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $8858 m0 *1 100.28,149.6
X$8858 105 3918 4180 4241 105 4406 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $8860 m0 *1 102.58,149.6
X$8860 40 3879 4094 4179 4406 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $8865 m0 *1 118.22,149.6
X$8865 40 2904 4243 3766 4355 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8866 m0 *1 128.8,149.6
X$8866 40 4242 4425 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $8868 m0 *1 133.4,149.6
X$8868 105 4248 4245 4313 105 40 4182 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8869 m0 *1 135.24,149.6
X$8869 105 4244 3396 4411 40 105 4313 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8871 m0 *1 137.54,149.6
X$8871 105 3440 4317 4492 105 40 4359 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8873 m0 *1 139.84,149.6
X$8873 105 4102 4409 4359 40 105 4315 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8875 m0 *1 142.6,149.6
X$8875 105 4247 4249 3775 105 40 4355 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8876 m0 *1 144.44,149.6
X$8876 105 4097 3923 4360 40 105 4247 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8877 m0 *1 146.28,149.6
X$8877 105 4027 4322 4494 105 40 4360 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8878 m0 *1 148.12,149.6
X$8878 105 4187 4184 4322 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8880 m0 *1 151.34,149.6
X$8880 105 4243 3769 4249 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8882 m0 *1 154.56,149.6
X$8882 105 4186 4255 4323 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8884 m0 *1 156.4,149.6
X$8884 105 4097 3980 4251 40 105 3816 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8885 m0 *1 158.24,149.6
X$8885 105 4413 3586 4120 40 105 4325 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8886 m0 *1 160.08,149.6
X$8886 105 4103 4327 4325 105 40 4251 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8887 m0 *1 161.92,149.6
X$8887 105 3897 4184 4327 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8891 m0 *1 168.36,149.6
X$8891 105 4021 4255 4417 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8892 m0 *1 169.74,149.6
X$8892 105 4417 3460 4120 40 105 4331 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8893 m0 *1 171.58,149.6
X$8893 105 4113 4332 4331 105 40 4333 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8894 m0 *1 173.42,149.6
X$8894 105 3897 4252 4332 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8896 m0 *1 175.72,149.6
X$8896 105 4108 4252 4418 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8897 m0 *1 177.1,149.6
X$8897 105 4418 4256 3024 40 105 4232 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8898 m0 *1 178.94,149.6
X$8898 40 40 4419 105 4255 4192 105 sky130_fd_sc_hd__nor2_2
* cell instance $8899 m0 *1 181.24,149.6
X$8899 105 4419 3246 4115 40 105 4256 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8903 m0 *1 189.52,149.6
X$8903 105 2880 9485 105 40 40 sky130_fd_sc_hd__inv_6
* cell instance $8904 m0 *1 192.74,149.6
X$8904 105 3897 4364 4195 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8907 m0 *1 195.04,149.6
X$8907 105 4108 4364 4337 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $8908 m0 *1 196.42,149.6
X$8908 105 4367 3098 4115 40 105 4366 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8909 m0 *1 198.26,149.6
X$8909 105 3587 4334 5033 105 40 4368 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8911 m0 *1 200.56,149.6
X$8911 40 3879 3136 4501 4368 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8918 m0 *1 225.4,149.6
X$8918 105 3853 4257 4330 105 4424 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $8919 m0 *1 227.24,149.6
X$8919 105 4424 4421 3936 4258 40 4329 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $8924 m0 *1 236.9,149.6
X$8924 105 4033 4257 4326 105 4422 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $8927 m0 *1 240.12,149.6
X$8927 105 4422 4421 4258 4030 40 3701 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $8930 m0 *1 245.18,149.6
X$8930 40 3590 4258 4035 4421 4259 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $8936 m0 *1 257.14,149.6
X$8936 105 4030 105 40 3769 40 sky130_fd_sc_hd__buf_4
* cell instance $8940 m0 *1 265.88,149.6
X$8940 40 4261 4372 4034 4320 3858 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $8941 m0 *1 270.48,149.6
X$8941 105 4261 4416 4035 3530 4199 105 4371 40 40 sky130_fd_sc_hd__a311oi_1
* cell instance $8942 m0 *1 273.7,149.6
X$8942 105 4199 4378 4491 40 105 4318 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8943 m0 *1 275.54,149.6
X$8943 105 4371 4314 3771 40 105 4316 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8945 m0 *1 277.84,149.6
X$8945 40 3879 4308 4414 4373 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $8946 m0 *1 288.42,149.6
X$8946 105 3528 4307 4375 105 40 4220 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8947 m0 *1 290.26,149.6
X$8947 105 4124 3780 4307 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8950 m0 *1 295.78,149.6
X$8950 105 4265 4310 4481 40 105 4304 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8952 m0 *1 298.08,149.6
X$8952 105 4143 4264 4216 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8953 m0 *1 299.46,149.6
X$8953 105 4265 4408 4378 40 105 4303 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8954 m0 *1 301.3,149.6
X$8954 105 4262 4267 4266 105 40 4408 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8957 m0 *1 305.44,149.6
X$8957 105 3866 4264 4269 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8958 m0 *1 306.82,149.6
X$8958 105 4107 4269 4271 105 40 4294 40 sky130_fd_sc_hd__o21ai_1
* cell instance $8959 m0 *1 308.66,149.6
X$8959 105 4380 4270 4378 105 4125 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $8960 m0 *1 311.88,149.6
X$8960 105 4262 4273 4200 40 4380 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $8961 m0 *1 315.1,149.6
X$8961 105 4270 4310 4272 40 105 4201 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8962 m0 *1 316.94,149.6
X$8962 105 4383 4027 4273 40 105 4272 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8963 m0 *1 318.78,149.6
X$8963 105 4265 4385 4386 40 105 3654 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8964 m0 *1 320.62,149.6
X$8964 105 4270 4385 4292 40 105 4274 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8966 m0 *1 323.38,149.6
X$8966 40 3879 4206 4275 4289 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $8968 m0 *1 333.04,149.6
X$8968 40 4288 4396 4044 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $8970 m0 *1 337.64,149.6
X$8970 40 2747 4129 4209 4395 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $8972 m0 *1 347.76,149.6
X$8972 105 4276 4392 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $8978 r0 *1 4.6,149.6
X$8978 40 4284 4338 4340 4390 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $8979 r0 *1 6.9,149.6
X$8979 105 4391 40 3993 105 40 sky130_fd_sc_hd__buf_2
* cell instance $8980 r0 *1 8.74,149.6
X$8980 105 4338 105 40 4426 40 sky130_fd_sc_hd__buf_4
* cell instance $8981 r0 *1 11.5,149.6
X$8981 105 4340 4339 4342 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $8982 r0 *1 12.88,149.6
X$8982 105 4341 4343 4342 40 105 4465 40 sky130_fd_sc_hd__a21oi_1
* cell instance $8986 r0 *1 15.64,149.6
X$8986 40 4344 4547 4345 4171 4341 4235 105 105 40 sky130_fd_sc_hd__o32ai_1
* cell instance $8987 r0 *1 18.86,149.6
X$8987 40 4080 4427 4506 4346 4428 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $8988 r0 *1 23.46,149.6
X$8988 105 4429 4430 4548 105 4397 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $8990 r0 *1 25.76,149.6
X$8990 105 4347 4431 105 4468 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $8991 r0 *1 28.98,149.6
X$8991 105 4082 4398 40 4399 105 40 sky130_fd_sc_hd__and2_4
* cell instance $8993 r0 *1 33.12,149.6
X$8993 40 40 4049 105 4344 4345 105 sky130_fd_sc_hd__nor2_2
* cell instance $8994 r0 *1 35.42,149.6
X$8994 105 4345 4344 4400 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $8995 r0 *1 37.72,149.6
X$8995 105 4399 105 40 4433 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $8997 r0 *1 40.02,149.6
X$8997 105 4400 40 4083 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9001 r0 *1 44.16,149.6
X$9001 40 4346 4426 105 3834 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $9002 r0 *1 51.52,149.6
X$9002 40 4085 4348 4426 4346 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $9003 r0 *1 57.5,149.6
X$9003 40 4085 3686 4140 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $9004 r0 *1 61.64,149.6
X$9004 40 3998 4346 4426 4401 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $9006 r0 *1 66.24,149.6
X$9006 40 4174 4350 4475 3834 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $9010 r0 *1 70.84,149.6
X$9010 105 4438 4351 4298 40 4349 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9012 r0 *1 74.98,149.6
X$9012 105 4441 4476 4402 4556 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9013 r0 *1 76.82,149.6
X$9013 105 4352 4403 4509 4477 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9016 r0 *1 80.96,149.6
X$9016 105 4442 4353 4404 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9017 r0 *1 82.34,149.6
X$9017 105 4480 4354 4443 4353 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9018 r0 *1 88.78,149.6
X$9018 40 4354 4301 4482 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $9022 r0 *1 99.36,149.6
X$9022 40 9513 3918 4485 4009 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $9023 r0 *1 108.56,149.6
X$9023 105 4094 40 105 3918 40 sky130_fd_sc_hd__inv_4
* cell instance $9024 r0 *1 110.86,149.6
X$9024 40 2585 4357 4179 3617 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $9025 r0 *1 121.9,149.6
X$9025 105 4010 4486 4488 105 40 4309 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9027 r0 *1 123.74,149.6
X$9027 105 4010 4487 4407 105 40 4489 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9030 r0 *1 126.96,149.6
X$9030 105 4420 4409 4356 40 105 4488 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9031 r0 *1 128.8,149.6
X$9031 40 2880 3766 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $9032 r0 *1 138,149.6
X$9032 105 4358 3286 4411 40 105 4492 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9033 r0 *1 139.84,149.6
X$9033 105 3489 4188 4358 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9036 r0 *1 142.6,149.6
X$9036 105 4246 105 40 3775 40 sky130_fd_sc_hd__buf_4
* cell instance $9037 r0 *1 145.36,149.6
X$9037 40 40 4244 105 3489 4361 105 sky130_fd_sc_hd__nor2_2
* cell instance $9038 r0 *1 147.66,149.6
X$9038 105 4361 4186 4412 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9039 r0 *1 149.04,149.6
X$9039 105 4412 4243 3779 40 105 4494 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9046 r0 *1 155.94,149.6
X$9046 105 4361 4362 4413 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9047 r0 *1 157.32,149.6
X$9047 40 3879 4447 4445 4496 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9056 r0 *1 184,149.6
X$9056 105 4420 4023 4363 40 105 4503 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9060 r0 *1 191.82,149.6
X$9060 40 4415 4108 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $9061 r0 *1 195.96,149.6
X$9061 105 4365 4366 4423 40 105 4335 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9062 r0 *1 197.8,149.6
X$9062 105 4192 4361 4367 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9063 r0 *1 199.18,149.6
X$9063 105 4108 4184 4365 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9065 r0 *1 201.02,149.6
X$9065 105 3098 3774 5772 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9067 r0 *1 202.86,149.6
X$9067 105 4425 4502 4357 4500 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $9070 r0 *1 205.62,149.6
X$9070 105 4369 40 4120 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9072 r0 *1 208.84,149.6
X$9072 40 3879 4283 4501 4499 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $9075 r0 *1 225.86,149.6
X$9075 105 4369 105 40 4021 40 sky130_fd_sc_hd__buf_4
* cell instance $9076 r0 *1 228.62,149.6
X$9076 105 4369 40 3858 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9077 r0 *1 231.38,149.6
X$9077 105 4246 105 40 3864 40 sky130_fd_sc_hd__buf_4
* cell instance $9084 r0 *1 241.5,149.6
X$9084 105 3492 4369 4453 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9085 r0 *1 242.88,149.6
X$9085 105 4362 4495 4453 4034 4370 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $9087 r0 *1 246.1,149.6
X$9087 105 4034 4370 4454 105 40 4259 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9089 r0 *1 248.4,149.6
X$9089 105 4369 40 4362 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9090 r0 *1 251.16,149.6
X$9090 105 4415 105 40 3723 40 sky130_fd_sc_hd__buf_4
* cell instance $9096 r0 *1 260.82,149.6
X$9096 105 4030 105 40 3767 40 sky130_fd_sc_hd__buf_4
* cell instance $9098 r0 *1 264.04,149.6
X$9098 105 3861 4455 4416 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9099 r0 *1 265.42,149.6
X$9099 40 4197 3034 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $9100 r0 *1 274.62,149.6
X$9100 105 4415 40 4262 105 40 sky130_fd_sc_hd__buf_2
* cell instance $9101 r0 *1 276.46,149.6
X$9101 105 4107 4372 4312 40 4456 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9103 r0 *1 280.6,149.6
X$9103 40 4376 4374 4381 3865 4186 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9104 r0 *1 285.2,149.6
X$9104 40 4372 4374 4202 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $9106 r0 *1 289.34,149.6
X$9106 105 3936 4483 4484 105 40 4373 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9108 r0 *1 291.64,149.6
X$9108 105 4376 4027 4455 40 105 4263 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9111 r0 *1 294.86,149.6
X$9111 105 4377 3263 4479 4381 40 4410 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $9112 r0 *1 297.62,149.6
X$9112 105 4410 4027 4266 40 105 4481 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9113 r0 *1 299.46,149.6
X$9113 40 40 4479 105 4202 4300 105 sky130_fd_sc_hd__nor2_2
* cell instance $9116 r0 *1 305.9,149.6
X$9116 105 4107 4535 4379 40 4474 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9117 r0 *1 309.12,149.6
X$9117 105 4203 4264 4379 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9118 r0 *1 310.5,149.6
X$9118 105 4377 4047 4293 4381 40 4383 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $9120 r0 *1 313.26,149.6
X$9120 105 3723 4474 4472 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9121 r0 *1 314.64,149.6
X$9121 105 4202 4382 4538 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9123 r0 *1 316.94,149.6
X$9123 105 4384 4113 4266 40 105 4386 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9125 r0 *1 319.24,149.6
X$9125 105 4021 4038 4387 4461 40 4204 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $9127 r0 *1 322.46,149.6
X$9127 40 4384 4469 4461 3538 4021 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9129 r0 *1 327.52,149.6
X$9129 40 4466 4549 4462 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $9130 r0 *1 331.66,149.6
X$9130 40 4289 4467 4206 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $9132 r0 *1 336.72,149.6
X$9132 40 4395 4394 4129 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $9134 r0 *1 340.86,149.6
X$9134 40 4464 4393 4279 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $9139 r0 *1 347.76,149.6
X$9139 105 4545 4543 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $9167 m0 *1 2.3,155.04
X$9167 40 4390 4284 4340 105 4351 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $9170 m0 *1 10.12,155.04
X$9170 40 4284 4343 4433 4390 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $9172 m0 *1 12.88,155.04
X$9172 40 4341 4390 4082 4398 4284 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $9173 m0 *1 17.48,155.04
X$9173 105 4547 4173 4141 4132 40 4234 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $9174 m0 *1 19.78,155.04
X$9174 105 4506 4427 4346 4428 105 4291 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $9177 m0 *1 24.38,155.04
X$9177 105 4430 4431 4429 4548 105 4506 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $9178 m0 *1 27.6,155.04
X$9178 105 4433 4351 4347 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9180 m0 *1 29.44,155.04
X$9180 105 4729 4432 4773 4470 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $9181 m0 *1 31.74,155.04
X$9181 40 4438 4345 4351 4935 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $9182 m0 *1 37.72,155.04
X$9182 105 4507 4435 105 4471 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $9183 m0 *1 40.94,155.04
X$9183 105 4434 4436 4507 105 40 4238 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9184 m0 *1 42.78,155.04
X$9184 105 4435 105 40 3948 40 sky130_fd_sc_hd__inv_1
* cell instance $9187 m0 *1 46.92,155.04
X$9187 40 4508 4437 4434 1508 4084 4701 105 105 40 sky130_fd_sc_hd__a311oi_4
* cell instance $9189 m0 *1 57.04,155.04
X$9189 105 4299 3759 3876 4589 4508 4437 40 105 40 sky130_fd_sc_hd__a311o_1
* cell instance $9191 m0 *1 61.64,155.04
X$9191 40 4438 4434 4351 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $9192 m0 *1 65.78,155.04
X$9192 40 4475 4297 4439 4554 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $9193 m0 *1 69.46,155.04
X$9193 105 4438 4351 4704 40 3911 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9194 m0 *1 72.68,155.04
X$9194 105 4441 4402 4476 105 4509 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $9195 m0 *1 75.44,155.04
X$9195 105 4591 4557 4440 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9196 m0 *1 76.82,155.04
X$9196 105 4402 4444 4559 4619 105 40 4061 40 sky130_fd_sc_hd__o31ai_1
* cell instance $9197 m0 *1 79.58,155.04
X$9197 105 4511 4510 4512 105 4402 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $9200 m0 *1 84.64,155.04
X$9200 105 4480 4444 3760 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9201 m0 *1 86.02,155.04
X$9201 105 4354 4443 4480 105 4442 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $9203 m0 *1 89.24,155.04
X$9203 40 4405 3917 4563 3918 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $9204 m0 *1 98.44,155.04
X$9204 40 3879 3916 4179 4869 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $9205 m0 *1 107.64,155.04
X$9205 105 3916 40 105 2583 40 sky130_fd_sc_hd__inv_2
* cell instance $9210 m0 *1 115.92,155.04
X$9210 40 2585 4566 4179 3845 105 105 40 sky130_fd_sc_hd__edfxtp_1
* cell instance $9211 m0 *1 126.96,155.04
X$9211 105 3334 3919 4486 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9212 m0 *1 128.34,155.04
X$9212 40 3766 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $9214 m0 *1 139.84,155.04
X$9214 105 4627 3334 4411 40 105 4493 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9218 m0 *1 144.9,155.04
X$9218 105 4420 4570 3923 40 105 3846 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9222 m0 *1 155.94,155.04
X$9222 105 4514 4014 4516 40 105 4497 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9223 m0 *1 157.78,155.04
X$9223 105 3692 4446 4497 105 40 4496 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9224 m0 *1 159.62,155.04
X$9224 105 4447 3693 4446 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9230 m0 *1 168.36,155.04
X$9230 105 4448 3767 4574 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9232 m0 *1 170.2,155.04
X$9232 105 4502 105 40 4576 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $9235 m0 *1 176.18,155.04
X$9235 105 4108 4518 4578 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9236 m0 *1 177.56,155.04
X$9236 105 4514 4023 4449 40 105 3675 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9237 m0 *1 179.4,155.04
X$9237 105 4578 4450 4423 40 105 4449 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9238 m0 *1 181.24,155.04
X$9238 105 4579 3245 4115 40 105 4450 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9241 m0 *1 184.46,155.04
X$9241 105 4451 4636 4423 40 105 4363 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9242 m0 *1 186.3,155.04
X$9242 105 4108 4521 4451 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9244 m0 *1 188.14,155.04
X$9244 105 3587 4504 4806 105 40 4582 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9245 m0 *1 189.98,155.04
X$9245 105 4522 4224 4504 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9252 m0 *1 197.34,155.04
X$9252 105 4524 40 4023 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9253 m0 *1 200.1,155.04
X$9253 105 4415 40 3853 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9255 m0 *1 203.32,155.04
X$9255 40 4357 4452 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $9257 m0 *1 208.38,155.04
X$9257 40 4499 3851 4283 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $9260 m0 *1 216.66,155.04
X$9260 105 4461 40 3897 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9265 m0 *1 226.32,155.04
X$9265 105 3931 40 4264 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9268 m0 *1 233.68,155.04
X$9268 105 4415 40 4423 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9279 m0 *1 257.14,155.04
X$9279 40 4415 3024 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $9280 m0 *1 261.28,155.04
X$9280 105 4415 40 4527 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9284 m0 *1 267.26,155.04
X$9284 40 3079 4415 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $9285 m0 *1 271.4,155.04
X$9285 105 4527 4490 4455 105 40 4491 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9286 m0 *1 273.24,155.04
X$9286 105 3723 4456 4490 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9290 m0 *1 277.84,155.04
X$9290 105 4529 4457 4378 40 105 4484 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9292 m0 *1 280.6,155.04
X$9292 105 4262 4571 4458 105 40 4457 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9293 m0 *1 282.44,155.04
X$9293 105 4308 3850 4483 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9295 m0 *1 284.74,155.04
X$9295 105 4377 4124 4528 4381 40 4569 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $9296 m0 *1 287.5,155.04
X$9296 105 4569 4027 4458 40 105 4530 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9297 m0 *1 289.34,155.04
X$9297 105 4529 4310 4530 40 105 4375 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9300 m0 *1 293.94,155.04
X$9300 105 4381 105 40 4027 40 sky130_fd_sc_hd__buf_4
* cell instance $9302 m0 *1 297.16,155.04
X$9302 105 4381 40 3933 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9305 m0 *1 302.68,155.04
X$9305 105 4564 4027 4459 40 105 4478 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9309 m0 *1 305.9,155.04
X$9309 105 4534 4378 4536 40 105 4296 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9310 m0 *1 307.74,155.04
X$9310 105 4527 4472 4459 105 40 4536 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9312 m0 *1 310.04,155.04
X$9312 105 3025 4264 4688 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9313 m0 *1 311.42,155.04
X$9313 105 4537 4473 4310 40 105 3790 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9315 m0 *1 314.18,155.04
X$9315 105 4534 4565 4460 40 105 3946 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9316 m0 *1 316.02,155.04
X$9316 105 4555 4113 4459 40 105 4460 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9317 m0 *1 317.86,155.04
X$9317 40 4555 4539 4461 3712 4021 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9318 m0 *1 322.46,155.04
X$9318 40 4300 4469 4540 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $9319 m0 *1 326.6,155.04
X$9319 40 4550 4848 4276 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $9320 m0 *1 330.74,155.04
X$9320 105 4540 4271 4387 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9324 m0 *1 333.96,155.04
X$9324 105 4205 40 4388 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9325 m0 *1 336.72,155.04
X$9325 105 3824 4463 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $9327 m0 *1 339.94,155.04
X$9327 40 2747 4279 4209 4464 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $9331 r0 *1 4.6,155.04
X$9331 105 4587 4586 4391 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $9332 r0 *1 6.9,155.04
X$9332 40 4280 4339 4505 4340 4770 4438 105 105 40 sky130_fd_sc_hd__a311oi_2
* cell instance $9333 r0 *1 12.42,155.04
X$9333 105 4082 4426 4339 4611 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $9338 r0 *1 15.64,155.04
X$9338 40 4082 4398 105 4438 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $9340 r0 *1 23.46,155.04
X$9340 40 4430 4432 3713 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $9343 r0 *1 34.96,155.04
X$9343 40 4345 4612 4435 4436 105 4237 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $9350 r0 *1 48.3,155.04
X$9350 40 3949 4615 4508 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $9353 r0 *1 56.58,155.04
X$9353 105 4299 4348 4439 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9354 r0 *1 57.96,155.04
X$9354 40 4438 4140 4351 4552 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $9355 r0 *1 63.94,155.04
X$9355 40 4348 4440 4590 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $9360 r0 *1 70.84,155.04
X$9360 105 4352 4509 4403 105 4557 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $9361 r0 *1 73.6,155.04
X$9361 40 4509 4434 4556 4002 4558 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $9362 r0 *1 78.2,155.04
X$9362 105 4434 4592 4558 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9363 r0 *1 79.58,155.04
X$9363 105 4511 4512 4510 4559 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9365 r0 *1 81.88,155.04
X$9365 40 4511 4476 2251 105 4593 105 40 sky130_fd_sc_hd__ha_1
* cell instance $9366 r0 *1 86.48,155.04
X$9366 105 4510 4444 4513 4560 105 40 4092 40 sky130_fd_sc_hd__o31ai_1
* cell instance $9367 r0 *1 89.24,155.04
X$9367 105 4562 4442 4482 105 4510 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $9368 r0 *1 92,155.04
X$9368 105 4562 4482 4442 4513 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9376 r0 *1 103.04,155.04
X$9376 105 1299 105 40 3554 40 sky130_fd_sc_hd__inv_1
* cell instance $9379 r0 *1 105.8,155.04
X$9379 105 4179 105 40 40 sky130_fd_sc_hd__clkinv_1
* cell instance $9380 r0 *1 107.18,155.04
X$9380 40 2880 4179 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $9387 r0 *1 126.04,155.04
X$9387 40 3879 3513 3766 4489 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9388 r0 *1 136.62,155.04
X$9388 105 4248 4568 4493 105 40 4356 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9389 r0 *1 138.46,155.04
X$9389 105 3977 4521 4568 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9392 r0 *1 147.2,155.04
X$9392 105 4027 4628 4629 105 40 4570 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9393 r0 *1 149.04,155.04
X$9393 105 4630 3768 3779 40 105 4629 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9401 r0 *1 156.4,155.04
X$9401 105 4515 4362 4572 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9402 r0 *1 157.78,155.04
X$9402 105 4572 4447 4120 40 105 4634 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9403 r0 *1 159.62,155.04
X$9403 105 4103 4573 4634 105 40 4516 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9404 r0 *1 161.46,155.04
X$9404 105 3897 4518 4573 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9406 r0 *1 166.52,155.04
X$9406 105 3775 4574 4637 105 40 4635 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9407 r0 *1 168.36,155.04
X$9407 105 4425 105 40 5617 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $9408 r0 *1 170.2,155.04
X$9408 105 4514 3923 4519 40 105 4637 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9409 r0 *1 172.04,155.04
X$9409 105 4187 4718 4639 105 40 4519 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9410 r0 *1 173.88,155.04
X$9410 105 4577 4448 3779 40 105 4639 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9411 r0 *1 175.72,155.04
X$9411 105 4515 4186 4577 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9415 r0 *1 177.56,155.04
X$9415 105 3246 4110 4638 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9416 r0 *1 178.94,155.04
X$9416 105 4192 4515 4579 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9421 r0 *1 182.62,155.04
X$9421 105 4192 4517 4580 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9422 r0 *1 184,155.04
X$9422 105 4580 3741 4115 40 105 4636 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9424 r0 *1 186.76,155.04
X$9424 40 3879 4522 4501 4582 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9426 r0 *1 197.8,155.04
X$9426 40 3879 4585 4501 4583 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9430 r0 *1 208.84,155.04
X$9430 40 4500 3774 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $9431 r0 *1 212.98,155.04
X$9431 105 3774 40 105 4632 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $9432 r0 *1 216.2,155.04
X$9432 105 4198 4584 4631 105 40 4523 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9433 r0 *1 218.04,155.04
X$9433 105 3118 4224 4584 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9446 r0 *1 247.94,155.04
X$9446 105 3165 4264 4674 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9447 r0 *1 249.32,155.04
X$9447 105 4625 4524 3936 4525 40 4581 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $9450 r0 *1 256.68,155.04
X$9450 105 4033 4676 4624 105 4526 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $9451 r0 *1 258.52,155.04
X$9451 40 3859 4030 4525 4524 4526 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9458 r0 *1 266.34,155.04
X$9458 105 2831 3858 4623 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9462 r0 *1 270.94,155.04
X$9462 40 3879 2831 4414 4575 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9463 r0 *1 281.52,155.04
X$9463 105 3723 4622 4571 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9464 r0 *1 282.9,155.04
X$9464 105 4308 4264 4621 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9468 r0 *1 286.12,155.04
X$9468 105 4202 4620 4528 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9471 r0 *1 291.64,155.04
X$9471 105 4461 40 3861 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9473 r0 *1 296.24,155.04
X$9473 105 4531 4567 3528 105 40 4617 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9474 r0 *1 298.08,155.04
X$9474 105 4532 3780 4567 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9475 r0 *1 299.46,155.04
X$9475 105 4534 4478 4310 40 105 4531 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9476 r0 *1 301.3,155.04
X$9476 40 4564 4533 4381 4532 4377 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9477 r0 *1 305.9,155.04
X$9477 40 4535 4533 4202 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $9478 r0 *1 310.04,155.04
X$9478 105 4561 4537 4378 105 4213 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9482 r0 *1 313.72,155.04
X$9482 40 40 4539 105 4535 4540 105 sky130_fd_sc_hd__nor2_2
* cell instance $9483 r0 *1 316.02,155.04
X$9483 105 4461 105 40 4113 40 sky130_fd_sc_hd__buf_4
* cell instance $9485 r0 *1 319.24,155.04
X$9485 105 4113 4551 4553 105 4613 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9486 r0 *1 322.46,155.04
X$9486 40 3034 4275 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $9487 r0 *1 331.66,155.04
X$9487 40 3879 4462 4209 4466 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $9490 r0 *1 340.86,155.04
X$9490 40 4610 4546 4545 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $9491 r0 *1 345,155.04
X$9491 105 4462 4542 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $9493 r0 *1 346.84,155.04
X$9493 105 4541 4544 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $9509 m0 *1 1.84,160.48
X$9509 40 3992 4640 4693 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $9511 m0 *1 8.28,160.48
X$9511 105 4586 4587 4611 4640 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $9513 m0 *1 10.58,160.48
X$9513 40 4351 4697 4586 4587 105 4077 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $9515 m0 *1 18.86,160.48
X$9515 105 4429 4340 4548 4427 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9516 m0 *1 20.7,160.48
X$9516 40 4339 4426 4082 4432 4429 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $9520 m0 *1 29.9,160.48
X$9520 40 4399 4346 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $9521 m0 *1 35.42,160.48
X$9521 40 4435 4052 4344 3947 4699 105 105 40 sky130_fd_sc_hd__and4b_1
* cell instance $9522 m0 *1 39.1,160.48
X$9522 105 4588 4052 4612 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $9523 m0 *1 41.4,160.48
X$9523 105 4588 4436 3947 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9526 m0 *1 48.3,160.48
X$9526 40 4701 4508 3293 4589 4433 4426 105 105 40 sky130_fd_sc_hd__a2111oi_2
* cell instance $9527 m0 *1 53.82,160.48
X$9527 105 4438 4616 4351 105 40 4615 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9530 m0 *1 57.04,160.48
X$9530 40 4351 4438 4444 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $9531 m0 *1 64.4,160.48
X$9531 105 4440 4590 105 4298 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $9532 m0 *1 67.62,160.48
X$9532 105 4557 4477 4704 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9534 m0 *1 69.46,160.48
X$9534 40 4352 4591 1986 105 4401 105 40 sky130_fd_sc_hd__ha_1
* cell instance $9535 m0 *1 74.06,160.48
X$9535 105 4511 4480 4441 4352 105 4705 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $9536 m0 *1 76.36,160.48
X$9536 40 4441 4403 1988 105 4592 105 40 sky130_fd_sc_hd__ha_1
* cell instance $9537 m0 *1 80.96,160.48
X$9537 105 4444 4593 4619 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9538 m0 *1 82.34,160.48
X$9538 105 4562 4354 4590 4651 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $9540 m0 *1 84.64,160.48
X$9540 40 4562 4652 4512 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $9544 m0 *1 97.06,160.48
X$9544 105 3770 3765 4180 4786 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $9545 m0 *1 98.9,160.48
X$9545 105 4707 4654 4653 4708 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $9546 m0 *1 100.74,160.48
X$9546 40 4707 4710 2583 105 3554 105 40 sky130_fd_sc_hd__ha_1
* cell instance $9547 m0 *1 105.34,160.48
X$9547 40 9487 4706 4094 4009 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $9550 m0 *1 112.24,160.48
X$9550 40 9540 4711 3916 105 1299 105 40 sky130_fd_sc_hd__ha_1
* cell instance $9551 m0 *1 116.84,160.48
X$9551 40 4712 2585 105 105 40 sky130_fd_sc_hd__inv_8
* cell instance $9554 m0 *1 125.12,160.48
X$9554 105 3513 3919 4487 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9555 m0 *1 126.5,160.48
X$9555 40 4566 4502 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $9556 m0 *1 130.64,160.48
X$9556 105 4514 4409 4594 40 105 4407 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9557 m0 *1 132.48,160.48
X$9557 105 4248 4626 4595 105 40 4594 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9558 m0 *1 134.32,160.48
X$9558 105 3977 4518 4626 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9559 m0 *1 135.7,160.48
X$9559 105 4714 3513 4411 40 105 4595 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9562 m0 *1 139.84,160.48
X$9562 40 40 4627 105 4750 4517 105 sky130_fd_sc_hd__nor2_2
* cell instance $9565 m0 *1 144.9,160.48
X$9565 105 3529 40 4411 105 40 sky130_fd_sc_hd__buf_2
* cell instance $9567 m0 *1 147.2,160.48
X$9567 105 4662 4521 4628 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9569 m0 *1 149.04,160.48
X$9569 105 4186 4517 4630 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9571 m0 *1 154.1,160.48
X$9571 105 3692 4599 4596 105 40 4660 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9572 m0 *1 155.94,160.48
X$9572 105 4420 4014 4597 40 105 4596 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9574 m0 *1 158.7,160.48
X$9574 105 4598 4661 4120 40 105 4633 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9575 m0 *1 160.54,160.48
X$9575 105 4661 3693 4599 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9580 m0 *1 167.44,160.48
X$9580 40 3879 4448 4445 4635 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $9585 m0 *1 188.14,160.48
X$9585 40 1307 4664 4723 4415 4522 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $9589 m0 *1 200.56,160.48
X$9589 40 4501 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $9590 m0 *1 211.6,160.48
X$9590 40 3879 3118 4501 4523 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9594 m0 *1 224.02,160.48
X$9594 105 4671 4495 4672 4415 4330 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $9596 m0 *1 227.24,160.48
X$9596 105 3170 4264 4672 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9600 m0 *1 236.9,160.48
X$9600 105 4603 4495 4600 4033 4326 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $9601 m0 *1 239.66,160.48
X$9601 105 3102 4679 4600 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9603 m0 *1 244.72,160.48
X$9603 105 4671 4602 4674 4415 4675 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $9604 m0 *1 247.48,160.48
X$9604 105 3853 4601 4675 105 4625 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $9610 m0 *1 255.3,160.48
X$9610 105 4603 4602 4678 4033 4624 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $9611 m0 *1 258.06,160.48
X$9611 105 3309 4679 4678 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9612 m0 *1 259.44,160.48
X$9612 40 3613 4035 4525 4524 4719 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9614 m0 *1 265.88,160.48
X$9614 105 3858 4620 4623 4034 4680 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $9615 m0 *1 268.64,160.48
X$9615 105 4680 4604 4035 3530 4529 105 4681 40 40 sky130_fd_sc_hd__a311oi_1
* cell instance $9617 m0 *1 272.32,160.48
X$9617 105 3861 4458 4604 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9621 m0 *1 279.68,160.48
X$9621 105 4369 40 4540 105 40 sky130_fd_sc_hd__buf_2
* cell instance $9623 m0 *1 281.98,160.48
X$9623 105 4620 4107 4621 40 4622 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9625 m0 *1 288.88,160.48
X$9625 105 4605 4618 4378 105 3782 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9626 m0 *1 292.1,160.48
X$9626 105 4715 3933 4685 40 105 4605 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9628 m0 *1 294.4,160.48
X$9628 40 3879 4532 4414 4617 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $9631 m0 *1 305.44,160.48
X$9631 105 4107 4382 4606 40 4687 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9632 m0 *1 308.66,160.48
X$9632 105 4553 4262 4614 40 4561 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9633 m0 *1 311.88,160.48
X$9633 105 4377 3707 4538 4381 40 4607 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $9634 m0 *1 314.64,160.48
X$9634 105 4527 4687 4614 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9636 m0 *1 316.94,160.48
X$9636 105 4113 4609 4608 105 4703 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9637 m0 *1 320.16,160.48
X$9637 105 4385 4537 4613 105 4037 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9638 m0 *1 323.38,160.48
X$9638 40 3879 4276 4275 4550 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $9640 m0 *1 333.04,160.48
X$9640 105 4275 105 40 9516 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $9641 m0 *1 335.8,160.48
X$9641 105 4690 4698 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $9642 m0 *1 337.18,160.48
X$9642 105 4663 4691 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $9644 m0 *1 339.48,160.48
X$9644 40 2747 4545 4209 4610 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $9648 r0 *1 4.14,160.48
X$9648 40 4696 4769 3679 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $9652 r0 *1 15.64,160.48
X$9652 40 4428 4642 4390 4284 4641 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $9654 r0 *1 20.7,160.48
X$9654 40 4928 4730 4430 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $9656 r0 *1 31.28,160.48
X$9656 105 4728 4643 4699 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $9658 r0 *1 34.96,160.48
X$9658 105 4736 4644 4739 40 4642 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9660 r0 *1 38.64,160.48
X$9660 105 4645 105 40 4776 40 sky130_fd_sc_hd__inv_1
* cell instance $9662 r0 *1 40.48,160.48
X$9662 105 4645 4700 4646 4644 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9669 r0 *1 46.46,160.48
X$9669 40 4735 4508 4647 4741 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $9670 r0 *1 54.74,160.48
X$9670 105 4647 4616 4780 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9672 r0 *1 56.58,160.48
X$9672 105 4508 4589 4554 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $9674 r0 *1 61.64,160.48
X$9674 40 4590 4649 4552 1760 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $9677 r0 *1 68.54,160.48
X$9677 105 4557 4590 4591 105 40 4650 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9680 r0 *1 70.84,160.48
X$9680 40 4648 4649 4650 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $9681 r0 *1 75.9,160.48
X$9681 105 2409 4705 4651 4739 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9686 r0 *1 89.24,160.48
X$9686 105 4444 4652 4560 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9689 r0 *1 94.76,160.48
X$9689 105 4706 105 40 4788 40 sky130_fd_sc_hd__inv_1
* cell instance $9691 r0 *1 96.14,160.48
X$9691 105 4746 4180 4786 105 4787 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $9693 r0 *1 98.44,160.48
X$9693 105 2583 4654 4653 4789 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $9694 r0 *1 100.28,160.48
X$9694 105 3554 4653 4708 105 4709 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $9695 r0 *1 102.12,160.48
X$9695 40 3879 1299 4179 4709 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9697 r0 *1 113.16,160.48
X$9697 105 4711 4654 4653 4790 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $9700 r0 *1 117.3,160.48
X$9700 40 4712 4655 3879 4654 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $9706 r0 *1 127.88,160.48
X$9706 105 4826 3919 4950 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9708 r0 *1 129.72,160.48
X$9708 105 4010 4795 4796 105 40 4794 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9709 r0 *1 131.56,160.48
X$9709 105 4656 3919 4795 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9712 r0 *1 135.24,160.48
X$9712 105 4515 4750 4714 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9714 r0 *1 137.54,160.48
X$9714 105 4189 4409 4657 40 105 4796 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9715 r0 *1 139.38,160.48
X$9715 105 3440 4659 4797 105 40 4657 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9716 r0 *1 141.22,160.48
X$9716 105 4658 4656 4411 40 105 4797 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9717 r0 *1 143.06,160.48
X$9717 105 4255 3489 4658 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9718 r0 *1 144.44,160.48
X$9718 105 3977 4252 4659 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9724 r0 *1 154.1,160.48
X$9724 40 3879 4661 4445 4660 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9725 r0 *1 164.68,160.48
X$9725 105 3897 4521 4748 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9728 r0 *1 173.42,160.48
X$9728 105 4662 4518 4718 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9729 r0 *1 174.8,160.48
X$9729 40 4803 4448 4663 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $9733 r0 *1 181.24,160.48
X$9733 105 4720 4721 4023 105 4520 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9737 r0 *1 187.68,160.48
X$9737 105 4722 4023 4807 40 105 4806 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9741 r0 *1 197.8,160.48
X$9741 105 4585 3767 4809 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9742 r0 *1 199.18,160.48
X$9742 40 2880 4501 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $9745 r0 *1 208.84,160.48
X$9745 105 4665 3980 4666 40 105 4810 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9746 r0 *1 210.68,160.48
X$9746 105 4662 4667 4813 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9748 r0 *1 212.52,160.48
X$9748 105 4665 3923 4668 40 105 4631 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9749 r0 *1 214.36,160.48
X$9749 105 4812 4423 4669 40 105 4668 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9750 r0 *1 216.2,160.48
X$9750 105 4724 3118 4115 40 105 4669 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9751 r0 *1 218.04,160.48
X$9751 105 4671 4670 4724 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9755 r0 *1 224.48,160.48
X$9755 105 3931 40 4671 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9756 r0 *1 227.24,160.48
X$9756 105 3931 40 4765 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9766 r0 *1 243.34,160.48
X$9766 40 3879 4549 4260 4673 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9768 r0 *1 255.76,160.48
X$9768 105 3491 4369 4804 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9769 r0 *1 257.14,160.48
X$9769 105 4362 4602 4804 4034 4754 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $9771 r0 *1 259.9,160.48
X$9771 105 4034 4676 4754 105 4719 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $9778 r0 *1 270.94,160.48
X$9778 105 4681 4717 3771 40 105 4575 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9782 r0 *1 276,160.48
X$9782 105 4679 105 40 4186 40 sky130_fd_sc_hd__buf_4
* cell instance $9783 r0 *1 278.76,160.48
X$9783 105 4679 40 4377 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9786 r0 *1 282.9,160.48
X$9786 105 5012 4759 4310 105 4716 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9789 r0 *1 287.04,160.48
X$9789 105 4385 4618 4684 105 3704 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9792 r0 *1 291.64,160.48
X$9792 105 3861 4792 4685 105 4684 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9793 r0 *1 294.86,160.48
X$9793 105 3933 4791 4946 105 4844 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9796 r0 *1 299.46,160.48
X$9796 105 4713 4847 4385 105 3726 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9797 r0 *1 302.68,160.48
X$9797 105 3095 4264 4784 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9799 r0 *1 304.98,160.48
X$9799 105 3196 4264 4606 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9800 r0 *1 306.36,160.48
X$9800 105 4378 4689 4686 105 4036 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9801 r0 *1 309.58,160.48
X$9801 105 4855 4107 4688 40 4762 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9802 r0 *1 312.8,160.48
X$9802 105 4607 3933 4553 40 105 4473 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9805 r0 *1 315.1,160.48
X$9805 105 4703 4689 4385 105 4126 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9808 r0 *1 319.24,160.48
X$9808 40 4609 4702 4461 3373 4766 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9810 r0 *1 324.3,160.48
X$9810 40 3879 4690 4275 4774 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $9812 r0 *1 333.96,160.48
X$9812 40 2747 4541 4209 4772 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $9815 r0 *1 345,160.48
X$9815 105 4694 4692 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $9818 r0 *1 347.3,160.48
X$9818 105 4695 4771 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $9848 m0 *1 3.68,165.92
X$9848 105 4725 4284 4505 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $9849 m0 *1 5.98,165.92
X$9849 40 4611 4586 4726 4433 105 4769 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $9850 m0 *1 10.58,165.92
X$9850 105 4816 4726 4586 4770 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $9852 m0 *1 12.88,165.92
X$9852 40 4082 4587 4398 4854 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $9854 m0 *1 15.64,165.92
X$9854 105 4642 4641 4697 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9856 m0 *1 17.48,165.92
X$9856 105 4642 4641 4339 105 40 40 sky130_fd_sc_hd__or2_2
* cell instance $9857 m0 *1 19.78,165.92
X$9857 40 40 4889 105 4819 4727 105 sky130_fd_sc_hd__nor2_2
* cell instance $9859 m0 *1 22.54,165.92
X$9859 105 4733 4728 4729 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9860 m0 *1 23.92,165.92
X$9860 105 4773 4729 4730 4432 40 3751 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $9862 m0 *1 26.68,165.92
X$9862 105 4732 4731 4819 4727 40 4736 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $9864 m0 *1 29.44,165.92
X$9864 40 4773 4775 4734 4728 4733 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $9866 m0 *1 33.58,165.92
X$9866 105 4731 4643 4735 4857 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9867 m0 *1 35.42,165.92
X$9867 40 4052 4934 4734 4737 4738 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $9868 m0 *1 38.64,165.92
X$9868 105 4737 4776 4734 40 105 4738 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9869 m0 *1 40.48,165.92
X$9869 105 4647 4740 4732 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $9870 m0 *1 43.7,165.92
X$9870 105 4735 4740 4700 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $9872 m0 *1 47.84,165.92
X$9872 40 4588 4778 4779 4741 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $9874 m0 *1 51.98,165.92
X$9874 40 4700 4743 4648 4781 3876 105 105 40 sky130_fd_sc_hd__o22ai_2
* cell instance $9876 m0 *1 57.04,165.92
X$9876 105 4648 4740 4616 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $9878 m0 *1 61.18,165.92
X$9878 105 4438 4351 4552 4087 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $9880 m0 *1 63.94,165.92
X$9880 105 4781 4299 4782 4783 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $9881 m0 *1 65.78,165.92
X$9881 105 4782 4299 4783 4781 4742 105 4745 40 40 sky130_fd_sc_hd__a311oi_1
* cell instance $9882 m0 *1 69,165.92
X$9882 105 4744 4866 4742 4745 40 105 4350 40 sky130_fd_sc_hd__a31oi_1
* cell instance $9890 m0 *1 86.94,165.92
X$9890 40 40 4301 105 4785 4868 105 sky130_fd_sc_hd__nor2_2
* cell instance $9893 m0 *1 93.84,165.92
X$9893 40 4485 4746 105 2803 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $9894 m0 *1 101.2,165.92
X$9894 40 3765 4655 4788 4746 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $9895 m0 *1 106.72,165.92
X$9895 40 4653 4180 4654 4655 105 105 40 sky130_fd_sc_hd__a21boi_2
* cell instance $9901 m0 *1 118.68,165.92
X$9901 105 4793 3016 40 105 4654 40 sky130_fd_sc_hd__nor2b_2
* cell instance $9904 m0 *1 124.66,165.92
X$9904 40 3879 4656 3766 4794 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9910 m0 *1 144.44,165.92
X$9910 105 4187 4877 4798 105 40 4875 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9912 m0 *1 146.74,165.92
X$9912 40 40 4876 105 4186 4747 105 sky130_fd_sc_hd__nor2_2
* cell instance $9916 m0 *1 156.86,165.92
X$9916 40 40 4598 105 4362 4517 105 sky130_fd_sc_hd__nor2_2
* cell instance $9917 m0 *1 159.16,165.92
X$9917 105 4103 4748 4633 105 40 4597 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9923 m0 *1 167.9,165.92
X$9923 40 3879 4663 4445 4803 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $9925 m0 *1 180.32,165.92
X$9925 105 4883 4423 4749 40 105 4720 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9926 m0 *1 182.16,165.92
X$9926 105 4805 4192 4884 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9928 m0 *1 184,165.92
X$9928 105 4884 3077 4115 40 105 4749 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9931 m0 *1 188.6,165.92
X$9931 105 4885 4423 4808 40 105 4807 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9932 m0 *1 190.44,165.92
X$9932 105 4887 4522 4115 40 105 4808 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9933 m0 *1 192.28,165.92
X$9933 105 4192 4747 4887 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9938 m0 *1 200.56,165.92
X$9938 105 3775 4809 4810 105 40 4583 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9939 m0 *1 202.4,165.92
X$9939 40 40 4888 105 4192 4906 105 sky130_fd_sc_hd__nor2_2
* cell instance $9940 m0 *1 204.7,165.92
X$9940 105 4187 4813 4811 105 40 4666 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9941 m0 *1 206.54,165.92
X$9941 105 4886 4585 4835 40 105 4811 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9944 m0 *1 209.76,165.92
X$9944 40 40 4886 105 4603 4670 105 sky130_fd_sc_hd__nor2_2
* cell instance $9945 m0 *1 212.06,165.92
X$9945 105 3853 4667 4812 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $9946 m0 *1 213.44,165.92
X$9946 105 4679 105 40 4202 40 sky130_fd_sc_hd__buf_4
* cell instance $9954 m0 *1 230.46,165.92
X$9954 105 4369 105 40 4766 40 sky130_fd_sc_hd__buf_4
* cell instance $9955 m0 *1 233.22,165.92
X$9955 105 3529 105 40 4750 40 sky130_fd_sc_hd__buf_4
* cell instance $9959 m0 *1 241.04,165.92
X$9959 105 4549 4224 4882 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9960 m0 *1 242.42,165.92
X$9960 40 3394 4107 5346 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $9962 m0 *1 250.24,165.92
X$9962 105 4751 4878 4752 40 105 4836 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9964 m0 *1 252.54,165.92
X$9964 105 4679 40 4835 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9966 m0 *1 255.76,165.92
X$9966 105 4423 4758 4873 40 4837 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9968 m0 *1 259.44,165.92
X$9968 105 4527 4753 4873 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9970 m0 *1 261.28,165.92
X$9970 105 4683 3767 4802 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9972 m0 *1 263.12,165.92
X$9972 105 4839 3933 4758 40 105 4801 40 sky130_fd_sc_hd__a21oi_1
* cell instance $9974 m0 *1 265.42,165.92
X$9974 105 3864 4802 4755 105 40 4871 40 sky130_fd_sc_hd__o21ai_1
* cell instance $9976 m0 *1 267.72,165.92
X$9976 105 4800 40 4378 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $9977 m0 *1 270.48,165.92
X$9977 105 4800 40 4385 105 40 sky130_fd_sc_hd__buf_2
* cell instance $9978 m0 *1 272.32,165.92
X$9978 105 4756 4751 4310 105 4122 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9982 m0 *1 278.3,165.92
X$9982 40 4841 4799 4757 3647 4766 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9983 m0 *1 282.9,165.92
X$9983 105 3861 4841 4758 105 4840 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9985 m0 *1 286.58,165.92
X$9985 40 4792 4843 4757 2746 4766 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9986 m0 *1 291.18,165.92
X$9986 40 4540 4843 4760 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $9987 m0 *1 295.32,165.92
X$9987 40 4760 4867 4603 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $9988 m0 *1 299.46,165.92
X$9988 105 4763 4761 4385 105 3937 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $9990 m0 *1 303.6,165.92
X$9990 105 3723 4762 4849 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $9992 m0 *1 305.44,165.92
X$9992 40 4540 4845 4764 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $9993 m0 *1 309.58,165.92
X$9993 105 4765 4764 4784 40 4860 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9994 m0 *1 312.8,165.92
X$9994 105 4262 4608 4849 40 4686 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $9996 m0 *1 316.48,165.92
X$9996 40 40 4777 105 4540 4382 105 sky130_fd_sc_hd__nor2_2
* cell instance $9997 m0 *1 318.78,165.92
X$9997 40 4551 4461 4777 3594 4766 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $9998 m0 *1 323.38,165.92
X$9998 40 4540 4702 4855 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $9999 m0 *1 327.52,165.92
X$9999 40 4774 4683 4690 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10003 m0 *1 333.96,165.92
X$10003 40 3034 4209 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $10004 m0 *1 343.16,165.92
X$10004 40 4772 4852 4541 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10005 m0 *1 347.3,165.92
X$10005 105 3265 4850 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10007 r0 *1 1.38,165.92
X$10007 40 4725 4814 4171 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $10008 r0 *1 7.36,165.92
X$10008 40 40 4696 105 4814 4815 105 sky130_fd_sc_hd__nor2_2
* cell instance $10009 r0 *1 9.66,165.92
X$10009 105 4816 4921 4815 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10010 r0 *1 11.04,165.92
X$10010 105 4731 4817 4925 105 40 4890 40 sky130_fd_sc_hd__or3_2
* cell instance $10011 r0 *1 13.8,165.92
X$10011 105 4853 105 40 4854 40 sky130_fd_sc_hd__inv_1
* cell instance $10016 r0 *1 16.1,165.92
X$10016 40 4924 4969 4727 4818 4854 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $10018 r0 *1 19.78,165.92
X$10018 40 4819 4727 4818 4643 105 4928 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $10020 r0 *1 28.06,165.92
X$10020 40 4429 4892 4741 4734 4858 105 105 40 sky130_fd_sc_hd__a2bb2oi_2
* cell instance $10022 r0 *1 34.04,165.92
X$10022 40 4935 5074 4857 4889 4820 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10024 r0 *1 39.1,165.92
X$10024 105 4645 4646 4932 105 4435 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10029 r0 *1 43.24,165.92
X$10029 105 4861 40 4741 105 40 sky130_fd_sc_hd__buf_2
* cell instance $10030 r0 *1 45.08,165.92
X$10030 105 4821 4742 4892 40 105 4507 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10031 r0 *1 46.92,165.92
X$10031 105 4742 4743 4822 4821 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10032 r0 *1 48.76,165.92
X$10032 105 4743 4822 4894 105 4778 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $10033 r0 *1 50.6,165.92
X$10033 105 4895 4780 4893 105 4779 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $10035 r0 *1 52.9,165.92
X$10035 105 4823 4589 4895 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10036 r0 *1 54.28,165.92
X$10036 105 4589 4781 4894 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $10037 r0 *1 57.5,165.92
X$10037 105 4823 105 40 4647 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $10041 r0 *1 63.48,165.92
X$10041 40 4552 4865 4782 4824 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10042 r0 *1 67.62,165.92
X$10042 105 4823 4299 4865 4866 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $10049 r0 *1 72.22,165.92
X$10049 105 4824 105 40 4742 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $10051 r0 *1 75.9,165.92
X$10051 40 4824 4868 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $10055 r0 *1 88.78,165.92
X$10055 40 9512 4706 3803 4746 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $10059 r0 *1 98.44,165.92
X$10059 105 2583 4653 4789 105 4869 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $10061 r0 *1 100.74,165.92
X$10061 40 4899 4746 105 2532 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $10062 r0 *1 108.1,165.92
X$10062 40 4306 4899 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $10065 r0 *1 115,165.92
X$10065 40 3879 4826 3766 4825 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10070 r0 *1 126.96,165.92
X$10070 105 4010 4950 4949 105 40 4825 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10072 r0 *1 129.72,165.92
X$10072 105 4721 4409 4827 40 105 4949 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10073 r0 *1 131.56,165.92
X$10073 105 4248 4952 4951 105 40 4827 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10074 r0 *1 133.4,165.92
X$10074 105 3977 4831 4952 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10075 r0 *1 134.78,165.92
X$10075 105 4872 4826 4411 40 105 4951 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10076 r0 *1 136.62,165.92
X$10076 105 4805 4750 4872 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10079 r0 *1 143.52,165.92
X$10079 105 4722 3980 4875 40 105 4954 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10080 r0 *1 145.36,165.92
X$10080 105 4662 4828 4877 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10082 r0 *1 147.2,165.92
X$10082 105 4876 4829 4835 40 105 4798 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10088 r0 *1 153.64,165.92
X$10088 105 4722 4014 4830 40 105 4957 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10089 r0 *1 155.48,165.92
X$10089 105 3592 4956 4957 105 40 4879 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10090 r0 *1 157.32,165.92
X$10090 40 3879 4984 4445 4879 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10099 r0 *1 181.7,165.92
X$10099 105 3853 4831 4883 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10103 r0 *1 188.14,165.92
X$10103 105 3853 4828 4885 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10105 r0 *1 190.44,165.92
X$10105 40 3879 4832 4501 4963 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10108 r0 *1 202.4,165.92
X$10108 105 4888 3136 4115 40 105 4964 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10118 r0 *1 215.74,165.92
X$10118 40 3879 4907 4501 4909 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10121 r0 *1 229.08,165.92
X$10121 105 4679 40 4603 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10125 r0 *1 232.3,165.92
X$10125 105 4679 105 40 3779 40 sky130_fd_sc_hd__buf_4
* cell instance $10129 r0 *1 237.36,165.92
X$10129 105 4662 4874 4834 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10131 r0 *1 239.2,165.92
X$10131 105 4187 4833 4834 40 4756 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $10132 r0 *1 242.42,165.92
X$10132 40 40 4880 105 4603 4881 105 sky130_fd_sc_hd__nor2_2
* cell instance $10133 r0 *1 244.72,165.92
X$10133 105 4880 3863 4835 40 105 4833 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10134 r0 *1 246.56,165.92
X$10134 105 4836 4882 4198 105 40 4673 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10136 r0 *1 249.32,165.92
X$10136 40 4881 4960 4671 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $10138 r0 *1 253.92,165.92
X$10138 105 4752 4838 4837 105 4677 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10139 r0 *1 257.14,165.92
X$10139 105 4757 4874 4959 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10143 r0 *1 258.98,165.92
X$10143 40 4839 5016 4842 4683 4835 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10146 r0 *1 264.5,165.92
X$10146 40 3879 4683 4955 4871 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10149 r0 *1 277.38,165.92
X$10149 105 4840 4838 4385 105 4682 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10150 r0 *1 280.6,165.92
X$10150 40 4870 4799 4540 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $10151 r0 *1 284.74,165.92
X$10151 40 4715 4867 4842 3648 4377 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10156 r0 *1 291.64,165.92
X$10156 40 4791 5079 4842 3310 4377 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10157 r0 *1 296.24,165.92
X$10157 105 4844 4761 4378 105 4144 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10158 r0 *1 299.46,165.92
X$10158 40 4947 4845 4757 3091 4766 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10159 r0 *1 304.06,165.92
X$10159 105 4846 4847 4752 105 4268 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10160 r0 *1 307.28,165.92
X$10160 105 4262 4864 4863 40 4846 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $10161 r0 *1 310.5,165.92
X$10161 105 4527 4860 4863 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10163 r0 *1 312.34,165.92
X$10163 105 4862 3933 4608 40 105 4938 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10166 r0 *1 314.18,165.92
X$10166 105 3864 5002 4913 105 40 4933 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10167 r0 *1 316.02,165.92
X$10167 105 4859 5073 3864 105 40 4856 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10170 r0 *1 319.24,165.92
X$10170 40 3879 4848 4275 4856 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $10171 r0 *1 328.9,165.92
X$10171 40 3879 4915 4209 4929 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $10172 r0 *1 338.1,165.92
X$10172 40 4926 4916 4917 2470 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10175 r0 *1 342.24,165.92
X$10175 105 4832 4768 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10176 r0 *1 343.62,165.92
X$10176 105 3738 4919 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10181 r0 *1 347.76,165.92
X$10181 105 4851 4767 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10196 m0 *1 1.84,171.36
X$10196 40 4814 4920 5249 4889 4890 105 105 40 sky130_fd_sc_hd__nor4_2
* cell instance $10198 m0 *1 6.9,171.36
X$10198 105 4920 4890 4921 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10199 m0 *1 8.28,171.36
X$10199 105 4816 4890 4741 40 105 4999 40 sky130_fd_sc_hd__a21o_1
* cell instance $10201 m0 *1 11.5,171.36
X$10201 105 4818 4853 4923 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10202 m0 *1 12.88,171.36
X$10202 40 4431 4889 4923 4925 4924 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10203 m0 *1 17.48,171.36
X$10203 105 4727 4819 4927 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $10204 m0 *1 19.78,171.36
X$10204 105 4927 105 40 4891 40 sky130_fd_sc_hd__buf_4
* cell instance $10206 m0 *1 23,171.36
X$10206 105 4930 5070 4931 105 40 4548 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10207 m0 *1 24.84,171.36
X$10207 105 4819 4731 4931 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10208 m0 *1 26.22,171.36
X$10208 105 4818 4891 4728 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10209 m0 *1 27.6,171.36
X$10209 105 4737 4889 4932 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10211 m0 *1 29.44,171.36
X$10211 105 4891 4892 4645 105 4934 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $10212 m0 *1 31.28,171.36
X$10212 40 4858 4893 4891 4398 4890 4734 105 105 40 sky130_fd_sc_hd__o32ai_4
* cell instance $10213 m0 *1 41.4,171.36
X$10213 105 4893 105 40 4892 40 sky130_fd_sc_hd__inv_1
* cell instance $10214 m0 *1 42.78,171.36
X$10214 105 4972 4971 4937 40 105 4646 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10216 m0 *1 45.08,171.36
X$10216 40 4861 4824 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $10217 m0 *1 49.22,171.36
X$10217 105 4743 4822 5004 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10218 m0 *1 50.6,171.36
X$10218 40 4436 5005 5004 4824 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10219 m0 *1 54.74,171.36
X$10219 105 4731 4733 4647 4820 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10224 m0 *1 60.26,171.36
X$10224 105 4939 105 40 3759 40 sky130_fd_sc_hd__buf_4
* cell instance $10225 m0 *1 63.02,171.36
X$10225 40 4940 4941 4781 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $10226 m0 *1 69,171.36
X$10226 105 4823 4299 4865 4744 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $10228 m0 *1 71.3,171.36
X$10228 40 4401 4942 5007 4824 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10230 m0 *1 75.9,171.36
X$10230 105 4742 4977 4896 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10232 m0 *1 77.74,171.36
X$10232 105 4896 5008 4592 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10234 m0 *1 79.58,171.36
X$10234 105 4944 4979 4943 105 4976 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $10239 m0 *1 85.1,171.36
X$10239 40 4868 5009 4897 4652 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $10241 m0 *1 91.08,171.36
X$10241 40 4899 4096 105 1760 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $10242 m0 *1 98.44,171.36
X$10242 40 3879 4980 4179 4787 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $10243 m0 *1 107.64,171.36
X$10243 40 4710 4898 4900 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $10247 m0 *1 113.62,171.36
X$10247 105 4900 4653 4790 105 5014 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $10250 m0 *1 118.22,171.36
X$10250 40 3879 4829 4179 4901 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10253 m0 *1 131.56,171.36
X$10253 105 3977 4828 5018 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10259 m0 *1 140.3,171.36
X$10259 105 3775 4902 4954 105 40 4901 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10260 m0 *1 142.14,171.36
X$10260 105 4829 3767 4902 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10262 m0 *1 145.36,171.36
X$10262 105 4662 4831 5091 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10264 m0 *1 147.2,171.36
X$10264 105 4805 4186 5021 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10267 m0 *1 151.34,171.36
X$10267 105 4984 3693 4956 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10268 m0 *1 152.72,171.36
X$10268 105 4362 4747 5022 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10269 m0 *1 154.1,171.36
X$10269 105 5022 4984 4120 40 105 4958 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10270 m0 *1 155.94,171.36
X$10270 105 4445 9500 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $10271 m0 *1 157.78,171.36
X$10271 40 2880 4445 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $10278 m0 *1 181.24,171.36
X$10278 105 4183 4842 5029 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10279 m0 *1 182.62,171.36
X$10279 105 4202 4193 5028 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10283 m0 *1 190.44,171.36
X$10283 40 4963 4988 4832 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10288 m0 *1 200.1,171.36
X$10288 105 4904 3923 4905 40 105 5033 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10289 m0 *1 201.94,171.36
X$10289 105 5032 4423 4964 40 105 4905 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10293 m0 *1 209.76,171.36
X$10293 105 4603 5179 5030 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10294 m0 *1 211.14,171.36
X$10294 105 5030 4907 4835 40 105 4966 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10295 m0 *1 212.98,171.36
X$10295 105 4187 5026 4966 105 40 5027 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10297 m0 *1 216.66,171.36
X$10297 105 3864 4965 4908 105 40 4909 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10298 m0 *1 218.5,171.36
X$10298 105 4907 3767 4965 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10305 m0 *1 227.7,171.36
X$10305 40 3034 4260 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $10307 m0 *1 237.36,171.36
X$10307 105 4246 105 40 4030 40 sky130_fd_sc_hd__buf_4
* cell instance $10309 m0 *1 241.04,171.36
X$10309 40 40 4961 105 4750 4881 105 sky130_fd_sc_hd__nor2_2
* cell instance $10310 m0 *1 243.34,171.36
X$10310 105 4961 4285 3489 40 105 4962 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10311 m0 *1 245.18,171.36
X$10311 105 3853 4874 5023 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10312 m0 *1 246.56,171.36
X$10312 105 5023 5020 4423 40 105 4878 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10316 m0 *1 250.24,171.36
X$10316 105 4549 4960 4765 105 5020 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10318 m0 *1 254.38,171.36
X$10318 105 4103 5019 4959 40 4910 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $10320 m0 *1 258.06,171.36
X$10320 105 4765 4870 5017 40 4753 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $10321 m0 *1 261.28,171.36
X$10321 105 3140 4671 5017 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10322 m0 *1 262.66,171.36
X$10322 40 4870 5016 4603 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $10323 m0 *1 266.8,171.36
X$10323 105 4838 4378 4801 40 105 4755 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10326 m0 *1 270.02,171.36
X$10326 105 4385 4751 4910 105 5015 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10329 m0 *1 274.62,171.36
X$10329 105 4800 40 4310 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10333 m0 *1 280.6,171.36
X$10333 40 4991 4953 4842 3202 4377 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10334 m0 *1 285.2,171.36
X$10334 105 3933 4991 4948 105 5012 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10337 m0 *1 289.8,171.36
X$10337 40 3034 4414 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $10340 m0 *1 300.38,171.36
X$10340 105 3861 4947 4864 105 4713 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10344 m0 *1 305.44,171.36
X$10344 105 3861 4911 4946 105 4763 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10345 m0 *1 308.66,171.36
X$10345 105 4377 4467 4912 4842 40 4995 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $10346 m0 *1 311.42,171.36
X$10346 105 4377 4848 4936 4381 40 4862 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $10347 m0 *1 314.18,171.36
X$10347 40 40 4936 105 4202 4855 105 sky130_fd_sc_hd__nor2_2
* cell instance $10349 m0 *1 316.94,171.36
X$10349 40 3879 4467 4275 4933 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $10351 m0 *1 327.06,171.36
X$10351 105 4209 9569 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10352 m0 *1 328.44,171.36
X$10352 40 4929 4532 4915 3195 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10354 m0 *1 333.04,171.36
X$10354 40 2747 4917 4209 4926 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $10355 m0 *1 342.24,171.36
X$10355 105 4914 4918 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10356 m0 *1 343.62,171.36
X$10356 105 4915 5067 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10357 m0 *1 345,171.36
X$10357 105 4922 5066 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10360 m0 *1 347.76,171.36
X$10360 105 4917 4998 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10363 r0 *1 1.84,171.36
X$10363 105 4967 4920 4693 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $10364 r0 *1 5.06,171.36
X$10364 40 5068 4999 4816 4079 4920 4967 105 105 40 sky130_fd_sc_hd__a32oi_4
* cell instance $10367 r0 *1 15.64,171.36
X$10367 105 4968 105 40 4730 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $10368 r0 *1 18.4,171.36
X$10368 105 4969 4727 4731 4819 40 5037 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $10369 r0 *1 21.16,171.36
X$10369 105 4733 5115 4930 105 5069 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $10370 r0 *1 23,171.36
X$10370 105 4818 4727 4969 5070 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $10372 r0 *1 25.3,171.36
X$10372 105 4730 4733 4727 4818 5000 5071 40 105 40 sky130_fd_sc_hd__a32oi_1
* cell instance $10373 r0 *1 28.52,171.36
X$10373 105 4818 4733 4735 5074 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10374 r0 *1 30.36,171.36
X$10374 105 5255 4775 4645 4858 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $10375 r0 *1 32.66,171.36
X$10375 40 5075 4818 4970 5001 5076 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $10376 r0 *1 37.26,171.36
X$10376 40 4970 4861 5001 5039 105 105 40 sky130_fd_sc_hd__and3_4
* cell instance $10381 r0 *1 43.24,171.36
X$10381 40 4937 4645 4971 4972 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $10383 r0 *1 46,171.36
X$10383 105 5076 5003 4822 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $10384 r0 *1 49.22,171.36
X$10384 40 5157 5077 4734 4743 3759 4973 105 105 40 sky130_fd_sc_hd__a221o_2
* cell instance $10386 r0 *1 54.28,171.36
X$10386 40 4589 4648 4939 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $10387 r0 *1 60.26,171.36
X$10387 40 4941 4940 4735 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $10390 r0 *1 70.84,171.36
X$10390 105 5006 5078 4974 105 5042 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $10392 r0 *1 74.06,171.36
X$10392 105 4975 4976 5044 105 5078 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $10394 r0 *1 77.28,171.36
X$10394 105 4976 4868 4978 5008 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $10395 r0 *1 79.58,171.36
X$10395 105 4944 4943 4979 4978 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10397 r0 *1 81.88,171.36
X$10397 105 4979 4868 5081 5082 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10399 r0 *1 84.18,171.36
X$10399 105 5045 4945 4785 105 5010 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $10400 r0 *1 86.94,171.36
X$10400 105 4785 5045 4945 5047 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10401 r0 *1 88.78,171.36
X$10401 105 5010 5047 5009 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10404 r0 *1 94.76,171.36
X$10404 40 5084 4563 4899 4485 4096 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $10407 r0 *1 98.44,171.36
X$10407 105 4096 40 105 4746 40 sky130_fd_sc_hd__inv_4
* cell instance $10408 r0 *1 100.74,171.36
X$10408 40 9511 4706 3304 4980 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $10409 r0 *1 109.94,171.36
X$10409 40 3879 3016 4179 5014 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10416 r0 *1 126.5,171.36
X$10416 40 3879 4982 3766 4981 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10418 r0 *1 137.54,171.36
X$10418 105 3775 5089 5088 105 40 4981 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10420 r0 *1 139.84,171.36
X$10420 105 4982 3767 5089 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10422 r0 *1 142.14,171.36
X$10422 105 4721 3923 4983 40 105 5088 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10424 r0 *1 144.9,171.36
X$10424 105 4187 5091 5092 105 40 4983 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10425 r0 *1 146.74,171.36
X$10425 105 5021 4982 4835 40 105 5092 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10426 r0 *1 148.58,171.36
X$10426 105 5048 40 3980 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10431 r0 *1 154.56,171.36
X$10431 105 4362 4906 5053 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10432 r0 *1 155.94,171.36
X$10432 40 40 5024 105 4362 4805 105 sky130_fd_sc_hd__nor2_2
* cell instance $10433 r0 *1 158.24,171.36
X$10433 105 5024 4985 4120 40 105 5096 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10435 r0 *1 160.54,171.36
X$10435 105 4103 5098 4958 105 40 4830 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10436 r0 *1 162.38,171.36
X$10436 105 3897 4831 5054 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10437 r0 *1 163.76,171.36
X$10437 105 3897 4828 5098 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10439 r0 *1 165.6,171.36
X$10439 105 4757 4986 5100 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10443 r0 *1 172.96,171.36
X$10443 105 4362 5179 5104 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10444 r0 *1 174.34,171.36
X$10444 105 4903 40 4662 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10445 r0 *1 177.1,171.36
X$10445 105 4017 4202 5055 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10450 r0 *1 181.24,171.36
X$10450 105 4662 5029 5109 105 40 4987 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10451 r0 *1 183.08,171.36
X$10451 105 5028 4988 4835 40 105 5109 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10455 r0 *1 191.36,171.36
X$10455 105 3989 4202 5057 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10460 r0 *1 202.4,171.36
X$10460 40 40 5032 105 3853 5031 105 sky130_fd_sc_hd__nor2_2
* cell instance $10462 r0 *1 204.7,171.36
X$10462 105 4679 4906 5105 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10463 r0 *1 206.08,171.36
X$10463 105 4369 4670 5102 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10468 r0 *1 211.14,171.36
X$10468 105 5050 3980 5027 40 105 4908 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10471 r0 *1 214.36,171.36
X$10471 105 4662 4986 5026 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10473 r0 *1 216.66,171.36
X$10473 105 3853 4986 5025 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10474 r0 *1 218.04,171.36
X$10474 105 4903 40 4187 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10477 r0 *1 222.18,171.36
X$10477 105 4903 40 4842 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10478 r0 *1 224.94,171.36
X$10478 40 3879 5136 4260 5095 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $10485 r0 *1 237.82,171.36
X$10485 105 4248 5093 4962 105 40 5180 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10486 r0 *1 239.66,171.36
X$10486 105 3695 4874 5093 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10488 r0 *1 241.96,171.36
X$10488 40 2375 5090 5061 4549 3723 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $10492 r0 *1 253.46,171.36
X$10492 40 4362 5087 4881 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $10493 r0 *1 257.6,171.36
X$10493 105 3084 5087 4766 105 5019 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10495 r0 *1 260.82,171.36
X$10495 105 3318 3779 5086 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10496 r0 *1 262.2,171.36
X$10496 105 3933 5063 5300 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10499 r0 *1 264.96,171.36
X$10499 105 3315 3858 5085 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10503 r0 *1 274.16,171.36
X$10503 40 4800 4565 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $10504 r0 *1 278.3,171.36
X$10504 40 4990 4989 4757 3591 4766 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10505 r0 *1 282.9,171.36
X$10505 40 5013 4989 4540 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $10507 r0 *1 287.04,171.36
X$10507 105 3861 4990 4948 105 5011 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10510 r0 *1 291.64,171.36
X$10510 105 4414 40 9506 105 40 sky130_fd_sc_hd__clkinv_4
* cell instance $10512 r0 *1 295.32,171.36
X$10512 40 4911 4992 4757 3938 4766 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10513 r0 *1 299.92,171.36
X$10513 40 4540 4992 4993 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $10514 r0 *1 304.06,171.36
X$10514 40 4764 4912 4603 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $10515 r0 *1 308.2,171.36
X$10515 105 4995 3933 4864 40 105 4994 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10516 r0 *1 310.04,171.36
X$10516 105 4847 4310 4994 40 105 4913 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10517 r0 *1 311.88,171.36
X$10517 105 4689 4938 4310 40 105 4859 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10520 r0 *1 314.18,171.36
X$10520 105 4467 3780 5002 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10521 r0 *1 315.56,171.36
X$10521 105 4848 3780 5073 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10527 r0 *1 325.68,171.36
X$10527 40 3879 4546 4209 4996 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $10529 r0 *1 337.18,171.36
X$10529 40 2747 4997 4209 5214 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $10533 r0 *1 347.76,171.36
X$10533 105 4997 5147 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10562 m0 *1 4.14,176.8
X$10562 105 4920 5035 5068 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10563 m0 *1 5.52,176.8
X$10563 105 4891 5036 5035 40 105 4967 40 sky130_fd_sc_hd__a21o_1
* cell instance $10564 m0 *1 8.28,176.8
X$10564 40 4817 5036 4731 4925 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $10565 m0 *1 11.96,176.8
X$10565 40 4586 5112 5036 4891 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $10567 m0 *1 18.86,176.8
X$10567 40 4082 5071 5072 5037 105 105 40 sky130_fd_sc_hd__o21a_4
* cell instance $10568 m0 *1 24.38,176.8
X$10568 40 5072 5151 5069 4818 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $10573 m0 *1 30.82,176.8
X$10573 105 5039 105 40 4818 40 sky130_fd_sc_hd__buf_4
* cell instance $10574 m0 *1 33.58,176.8
X$10574 40 4641 5075 5038 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $10575 m0 *1 39.56,176.8
X$10575 40 4971 4737 4972 5039 4937 105 105 40 sky130_fd_sc_hd__and4_4
* cell instance $10577 m0 *1 44.62,176.8
X$10577 105 5040 4939 5076 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $10578 m0 *1 47.84,176.8
X$10578 105 4740 5040 3876 40 5156 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $10579 m0 *1 51.06,176.8
X$10579 105 5119 5003 3876 3759 40 105 5077 40 sky130_fd_sc_hd__a31oi_1
* cell instance $10580 m0 *1 53.36,176.8
X$10580 105 5003 5223 5005 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10584 m0 *1 57.5,176.8
X$10584 40 4940 5120 4647 1760 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $10585 m0 *1 63.02,176.8
X$10585 40 5006 5041 1986 105 4865 105 40 sky130_fd_sc_hd__ha_1
* cell instance $10586 m0 *1 67.62,176.8
X$10586 40 40 4941 105 5041 5042 105 sky130_fd_sc_hd__nor2_2
* cell instance $10587 m0 *1 69.92,176.8
X$10587 40 4975 4974 1988 105 4942 105 40 sky130_fd_sc_hd__ha_1
* cell instance $10588 m0 *1 74.52,176.8
X$10588 105 4975 5044 4976 5162 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10590 m0 *1 76.82,176.8
X$10590 40 4944 5044 2251 105 4977 105 40 sky130_fd_sc_hd__ha_1
* cell instance $10591 m0 *1 81.42,176.8
X$10591 105 4868 5123 5082 40 105 4593 40 sky130_fd_sc_hd__a21o_1
* cell instance $10593 m0 *1 84.64,176.8
X$10593 105 5124 5046 5010 5081 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10594 m0 *1 86.48,176.8
X$10594 105 5124 5010 5046 105 4979 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $10596 m0 *1 91.08,176.8
X$10596 40 9510 4706 5259 4746 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $10598 m0 *1 100.74,176.8
X$10598 40 4485 4096 105 1986 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $10599 m0 *1 108.1,176.8
X$10599 105 4980 105 40 5125 40 sky130_fd_sc_hd__buf_4
* cell instance $10602 m0 *1 112.24,176.8
X$10602 40 9543 5049 4980 105 4706 105 40 sky130_fd_sc_hd__ha_1
* cell instance $10603 m0 *1 116.84,176.8
X$10603 105 5049 105 40 5126 40 sky130_fd_sc_hd__buf_4
* cell instance $10607 m0 *1 128.8,176.8
X$10607 40 3879 5127 4445 5168 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10611 m0 *1 147.2,176.8
X$10611 105 5048 40 4014 105 40 sky130_fd_sc_hd__buf_2
* cell instance $10612 m0 *1 149.04,176.8
X$10612 105 5048 105 40 3923 40 sky130_fd_sc_hd__buf_4
* cell instance $10614 m0 *1 153.64,176.8
X$10614 105 5050 4014 5051 40 105 5241 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10615 m0 *1 155.48,176.8
X$10615 105 4904 4014 5052 40 105 5094 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10617 m0 *1 157.78,176.8
X$10617 105 4103 5054 5096 105 40 5177 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10618 m0 *1 159.62,176.8
X$10618 105 5053 5175 4120 40 105 5097 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10619 m0 *1 161.46,176.8
X$10619 105 4103 5099 5097 105 40 5052 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10620 m0 *1 163.3,176.8
X$10620 105 4757 5031 5099 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10622 m0 *1 165.14,176.8
X$10622 105 4103 5100 5103 105 40 5051 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10627 m0 *1 170.66,176.8
X$10627 105 5062 40 4757 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10628 m0 *1 173.42,176.8
X$10628 105 5104 5176 4766 40 105 5103 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10630 m0 *1 176.18,176.8
X$10630 105 4662 5056 5108 105 40 5132 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10631 m0 *1 178.02,176.8
X$10631 105 5055 3308 4835 40 105 5108 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10632 m0 *1 179.86,176.8
X$10632 105 4842 3926 5056 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10636 m0 *1 186.3,176.8
X$10636 105 4662 5110 5111 105 40 5181 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10637 m0 *1 188.14,176.8
X$10637 105 4842 4364 5110 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10639 m0 *1 191.36,176.8
X$10639 105 5057 3482 4835 40 105 5111 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10646 m0 *1 200.1,176.8
X$10646 105 4842 5106 5107 105 40 5185 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10647 m0 *1 201.94,176.8
X$10647 105 4842 5031 5106 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10649 m0 *1 203.78,176.8
X$10649 105 5105 5186 4835 40 105 5107 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10651 m0 *1 206.08,176.8
X$10651 105 4757 5058 5101 105 40 5184 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10652 m0 *1 207.92,176.8
X$10652 105 5102 5270 4766 40 105 5101 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10655 m0 *1 214.36,176.8
X$10655 105 5050 3923 5059 40 105 5204 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10657 m0 *1 217.12,176.8
X$10657 105 5025 4423 5183 40 105 5059 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10663 m0 *1 223.56,176.8
X$10663 105 5182 40 4679 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10664 m0 *1 226.32,176.8
X$10664 40 5095 3849 5136 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10665 m0 *1 230.46,176.8
X$10665 105 4260 105 40 9515 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $10669 m0 *1 238.28,176.8
X$10669 105 5062 40 4103 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10672 m0 *1 243.34,176.8
X$10672 105 5178 5060 5090 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10674 m0 *1 246.56,176.8
X$10674 105 3863 4903 3084 5062 105 5060 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $10680 m0 *1 256.68,176.8
X$10680 105 3531 5210 3437 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $10681 m0 *1 258.98,176.8
X$10681 105 3779 5138 5086 4033 5301 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $10683 m0 *1 262.66,176.8
X$10683 105 3861 5063 5174 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10684 m0 *1 264.04,176.8
X$10684 105 3858 5138 5085 4034 5173 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $10685 m0 *1 266.8,176.8
X$10685 40 3879 3315 4955 5140 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10688 m0 *1 279.68,176.8
X$10688 105 3036 4671 5083 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10689 m0 *1 281.06,176.8
X$10689 105 4527 5064 5167 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10690 m0 *1 282.44,176.8
X$10690 40 5013 4953 4603 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $10691 m0 *1 286.58,176.8
X$10691 105 4385 4759 5011 105 5080 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $10692 m0 *1 289.8,176.8
X$10692 40 40 5079 105 4603 4993 105 sky130_fd_sc_hd__nor2_2
* cell instance $10696 m0 *1 295.32,176.8
X$10696 105 4527 5165 5164 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10702 m0 *1 309.12,176.8
X$10702 105 5159 5065 5160 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10703 m0 *1 310.5,176.8
X$10703 105 3707 4381 3594 4461 105 5065 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $10705 m0 *1 316.94,176.8
X$10705 105 4546 3921 5291 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10708 m0 *1 319.7,176.8
X$10708 105 5145 3921 5154 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10711 m0 *1 322.46,176.8
X$10711 105 3440 4459 5152 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10714 m0 *1 325.22,176.8
X$10714 105 5145 3920 5149 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10720 m0 *1 334.88,176.8
X$10720 40 5146 5145 4694 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10721 m0 *1 339.02,176.8
X$10721 40 3879 4694 4209 5146 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $10726 r0 *1 4.6,176.8
X$10726 105 5188 5034 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10727 r0 *1 5.98,176.8
X$10727 40 5036 4891 4390 5112 5215 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $10728 r0 *1 13.34,176.8
X$10728 105 5113 40 4727 105 40 sky130_fd_sc_hd__buf_2
* cell instance $10733 r0 *1 15.64,176.8
X$10733 105 4643 5114 4968 4925 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $10734 r0 *1 17.48,176.8
X$10734 40 5114 5189 4643 4968 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $10735 r0 *1 19.78,176.8
X$10735 105 4733 5115 4969 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10737 r0 *1 22.08,176.8
X$10737 105 4968 4930 5151 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10738 r0 *1 23.46,176.8
X$10738 40 4733 5116 5191 105 105 40 sky130_fd_sc_hd__nand2b_2
* cell instance $10739 r0 *1 26.68,176.8
X$10739 40 5193 5192 4819 5117 105 105 40 sky130_fd_sc_hd__nand3b_4
* cell instance $10741 r0 *1 34.96,176.8
X$10741 40 4737 4971 4972 4937 105 4731 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $10746 r0 *1 43.24,176.8
X$10746 40 5118 5155 5043 4939 105 5193 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $10748 r0 *1 49.68,176.8
X$10748 40 5157 5119 5438 5003 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $10749 r0 *1 53.36,176.8
X$10749 40 3876 4823 5038 5224 105 4893 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $10750 r0 *1 61.18,176.8
X$10750 40 5040 5120 5121 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $10751 r0 *1 66.24,176.8
X$10751 105 5042 5041 4940 40 5121 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $10758 r0 *1 71.3,176.8
X$10758 105 5006 4974 5078 5197 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10759 r0 *1 73.14,176.8
X$10759 105 5078 5162 5007 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10760 r0 *1 74.52,176.8
X$10760 105 2409 5163 5122 5043 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $10761 r0 *1 76.36,176.8
X$10761 105 5006 4944 4785 4975 105 5163 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $10763 r0 *1 79.58,176.8
X$10763 40 5124 5123 4943 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $10764 r0 *1 88.78,176.8
X$10764 40 5045 2803 5046 4897 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $10769 r0 *1 98.44,176.8
X$10769 40 4096 5230 4563 4899 4485 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $10770 r0 *1 106.26,176.8
X$10770 40 3553 5125 4563 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $10772 r0 *1 112.24,176.8
X$10772 40 3879 5188 5333 5231 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $10779 r0 *1 126.96,176.8
X$10779 105 4010 5233 5234 105 40 5168 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10780 r0 *1 128.8,176.8
X$10780 105 5127 5205 5233 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10781 r0 *1 130.18,176.8
X$10781 105 4722 4409 5128 40 105 5234 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10783 r0 *1 132.48,176.8
X$10783 105 4248 5018 5235 105 40 5128 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10785 r0 *1 134.78,176.8
X$10785 105 5170 5127 4411 40 105 5235 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10786 r0 *1 136.62,176.8
X$10786 105 4750 4747 5170 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10789 r0 *1 140.76,176.8
X$10789 105 5048 40 4409 105 40 sky130_fd_sc_hd__buf_2
* cell instance $10790 r0 *1 142.6,176.8
X$10790 40 3879 5175 4445 5129 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10795 r0 *1 153.64,176.8
X$10795 105 3592 5240 5094 105 40 5129 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10796 r0 *1 155.48,176.8
X$10796 105 5176 3693 5130 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10797 r0 *1 156.86,176.8
X$10797 105 4721 4014 5177 40 105 5243 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10800 r0 *1 161.46,176.8
X$10800 40 5131 6321 3514 3849 3691 3404 5245 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $10804 r0 *1 177.1,176.8
X$10804 105 5133 5132 3848 3528 40 5308 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $10811 r0 *1 181.7,176.8
X$10811 105 5133 4987 4102 3528 40 5311 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $10815 r0 *1 187.68,176.8
X$10815 105 5133 5181 4024 3528 40 5203 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $10816 r0 *1 190.44,176.8
X$10816 40 3879 3482 4501 5134 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $10818 r0 *1 200.56,176.8
X$10818 40 5315 4904 4030 5133 5185 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10822 r0 *1 205.16,176.8
X$10822 105 5135 5269 3771 40 105 5246 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10823 r0 *1 207,176.8
X$10823 105 4757 4667 5058 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10825 r0 *1 208.84,176.8
X$10825 40 5135 4665 3532 5133 5184 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $10826 r0 *1 213.44,176.8
X$10826 40 3879 5239 4260 5244 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10829 r0 *1 226.78,176.8
X$10829 105 5062 105 40 4461 40 sky130_fd_sc_hd__buf_4
* cell instance $10839 r0 *1 239.2,176.8
X$10839 105 4751 4565 5180 40 105 5238 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10840 r0 *1 241.04,176.8
X$10840 40 3879 4285 4260 5206 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10841 r0 *1 251.62,176.8
X$10841 40 3863 4549 5232 5137 4285 5245 3084 105 105 40 sky130_fd_sc_hd__mux4_2
* cell instance $10847 r0 *1 264.04,176.8
X$10847 105 5173 5174 3532 3530 5172 105 5139 40 40 sky130_fd_sc_hd__a311oi_1
* cell instance $10848 r0 *1 267.26,176.8
X$10848 105 5139 5171 3771 40 105 5140 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10851 r0 *1 271.86,176.8
X$10851 105 4396 4224 5208 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10853 r0 *1 273.7,176.8
X$10853 105 4765 5138 5169 40 5064 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $10854 r0 *1 276.92,176.8
X$10854 105 4262 5167 5063 105 40 5228 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10855 r0 *1 278.76,176.8
X$10855 105 4396 4671 5169 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10856 r0 *1 280.14,176.8
X$10856 105 4765 5013 5083 40 5141 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $10858 r0 *1 283.82,176.8
X$10858 105 4903 40 4381 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $10862 r0 *1 286.58,176.8
X$10862 105 4262 5225 4948 105 40 5142 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10863 r0 *1 288.42,176.8
X$10863 105 4759 4752 5142 40 105 5227 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10866 r0 *1 291.64,176.8
X$10866 105 4527 5141 5225 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10868 r0 *1 293.48,176.8
X$10868 105 4765 4993 5166 40 5294 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $10869 r0 *1 296.7,176.8
X$10869 105 4262 5222 4946 105 40 5143 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10870 r0 *1 298.54,176.8
X$10870 105 4761 4752 5143 40 105 5220 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10873 r0 *1 302.68,176.8
X$10873 40 1610 5160 5161 4527 3196 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $10874 r0 *1 309.12,176.8
X$10874 40 3707 3196 5144 5202 3150 5158 3594 105 105 40 sky130_fd_sc_hd__mux4_2
* cell instance $10881 r0 *1 319.24,176.8
X$10881 40 5217 4535 5210 5154 5153 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $10882 r0 *1 323.84,176.8
X$10882 105 5211 5149 5216 105 40 5150 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10883 r0 *1 325.68,176.8
X$10883 40 3879 5145 4209 5150 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $10885 r0 *1 336.26,176.8
X$10885 40 2747 3879 105 105 40 sky130_fd_sc_hd__buf_16
* cell instance $10891 r0 *1 347.76,176.8
X$10891 105 5136 5148 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $10893 m0 *1 1.84,182.24
X$10893 105 5035 4920 105 5187 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $10896 m0 *1 6.44,182.24
X$10896 105 4853 5187 4726 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10897 m0 *1 7.82,182.24
X$10897 105 5250 4816 5251 4726 105 5215 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $10898 m0 *1 10.12,182.24
X$10898 40 4817 5112 5189 4818 105 105 40 sky130_fd_sc_hd__a21boi_2
* cell instance $10899 m0 *1 14.26,182.24
X$10899 40 5252 5190 5284 5253 105 4340 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $10900 m0 *1 22.08,182.24
X$10900 105 5191 5116 40 105 4643 40 sky130_fd_sc_hd__nor2b_2
* cell instance $10902 m0 *1 25.76,182.24
X$10902 105 5117 5193 5192 5000 40 105 40 sky130_fd_sc_hd__and3b_1
* cell instance $10904 m0 *1 29.44,182.24
X$10904 40 5189 5190 5001 4970 5039 105 105 40 sky130_fd_sc_hd__nand4b_4
* cell instance $10905 m0 *1 38.18,182.24
X$10905 40 5194 5195 4740 5196 105 4971 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $10906 m0 *1 46,182.24
X$10906 40 4937 5155 5118 5156 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $10908 m0 *1 50.6,182.24
X$10908 105 5196 5194 3876 5195 40 5290 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $10910 m0 *1 53.82,182.24
X$10910 105 3876 4823 5224 105 5223 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $10915 m0 *1 61.64,182.24
X$10915 40 5196 5120 5121 105 105 40 sky130_fd_sc_hd__nand2b_2
* cell instance $10919 m0 *1 68.08,182.24
X$10919 105 5042 5197 4782 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10923 m0 *1 78.66,182.24
X$10923 105 5124 5045 4940 5122 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $10927 m0 *1 86.48,182.24
X$10927 105 4563 5125 4485 105 40 5200 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10928 m0 *1 88.32,182.24
X$10928 40 5259 5198 4899 5126 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $10929 m0 *1 92,182.24
X$10929 105 4096 4563 4485 105 40 5408 40 sky130_fd_sc_hd__o21bai_1
* cell instance $10930 m0 *1 94.76,182.24
X$10930 40 5199 4899 4563 5125 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $10931 m0 *1 98.44,182.24
X$10931 40 5295 5260 5198 5200 5332 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $10933 m0 *1 103.5,182.24
X$10933 40 4563 5125 105 1988 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $10936 m0 *1 112.24,182.24
X$10936 105 3016 105 40 4900 40 sky130_fd_sc_hd__inv_1
* cell instance $10939 m0 *1 115.92,182.24
X$10939 40 5231 4826 5188 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $10944 m0 *1 128.8,182.24
X$10944 105 5261 105 40 4010 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $10945 m0 *1 130.64,182.24
X$10945 105 5261 105 40 3531 40 sky130_fd_sc_hd__buf_4
* cell instance $10946 m0 *1 133.4,182.24
X$10946 105 3531 105 40 5205 40 sky130_fd_sc_hd__buf_4
* cell instance $10949 m0 *1 137.54,182.24
X$10949 105 5050 4409 5265 40 105 5264 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10952 m0 *1 140.3,182.24
X$10952 105 4750 4906 5303 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10955 m0 *1 143.98,182.24
X$10955 105 4750 4670 5456 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $10959 m0 *1 153.18,182.24
X$10959 105 3592 5130 5241 105 40 5267 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10960 m0 *1 155.02,182.24
X$10960 105 5175 3693 5240 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10961 m0 *1 156.4,182.24
X$10961 105 3592 5242 5243 105 40 5383 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10962 m0 *1 158.24,182.24
X$10962 105 4985 3693 5242 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10968 m0 *1 168.82,182.24
X$10968 105 4829 4903 4984 5062 105 5201 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $10970 m0 *1 172.5,182.24
X$10970 40 3879 3308 4445 5248 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $10971 m0 *1 182.16,182.24
X$10971 40 3879 4988 4445 5385 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $10973 m0 *1 192.28,182.24
X$10973 105 5203 5314 3769 40 105 5134 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10979 m0 *1 201.02,182.24
X$10979 105 5315 5313 3769 40 105 5247 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10981 m0 *1 203.32,182.24
X$10981 40 3879 5270 4260 5246 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $10983 m0 *1 214.36,182.24
X$10983 105 4198 5204 5271 105 5244 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $10984 m0 *1 216.2,182.24
X$10984 105 5239 4224 5271 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $10986 m0 *1 218.04,182.24
X$10986 105 5309 5239 4765 40 105 5183 40 sky130_fd_sc_hd__a21oi_1
* cell instance $10991 m0 *1 223.1,182.24
X$10991 105 4502 105 40 5307 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $10994 m0 *1 230.46,182.24
X$10994 40 5306 5272 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $10997 m0 *1 240.12,182.24
X$10997 105 5268 5237 5238 105 40 5206 40 sky130_fd_sc_hd__o21ai_1
* cell instance $10998 m0 *1 241.96,182.24
X$10998 105 4285 5205 5237 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11001 m0 *1 246.1,182.24
X$11001 105 3531 40 5211 105 40 sky130_fd_sc_hd__buf_2
* cell instance $11007 m0 *1 259.44,182.24
X$11007 105 5301 5300 4030 5302 5172 105 5299 40 40 sky130_fd_sc_hd__a311oi_1
* cell instance $11011 m0 *1 268.64,182.24
X$11011 105 5207 5276 5212 4199 40 105 5297 40 sky130_fd_sc_hd__a31oi_1
* cell instance $11012 m0 *1 270.94,182.24
X$11012 105 3440 4455 5207 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11014 m0 *1 273.24,182.24
X$11014 105 4198 5208 5229 105 40 5277 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11015 m0 *1 275.08,182.24
X$11015 105 5172 4752 5228 40 105 5229 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11018 m0 *1 277.84,182.24
X$11018 40 3879 4396 4955 5277 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11019 m0 *1 288.42,182.24
X$11019 105 4198 5226 5227 105 40 5296 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11020 m0 *1 290.26,182.24
X$11020 105 3036 4224 5226 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11021 m0 *1 291.64,182.24
X$11021 105 2836 4671 5166 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11024 m0 *1 294.4,182.24
X$11024 105 4527 5294 5222 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11025 m0 *1 295.78,182.24
X$11025 105 4262 4685 5164 40 5221 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $11027 m0 *1 299.92,182.24
X$11027 105 4198 5219 5220 105 40 5209 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11028 m0 *1 301.76,182.24
X$11028 105 2836 4224 5219 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11031 m0 *1 305.44,182.24
X$11031 40 3879 2836 4414 5209 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11033 m0 *1 316.48,182.24
X$11033 40 5218 5153 5210 5291 4300 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $11034 m0 *1 321.08,182.24
X$11034 40 40 3440 5289 4266 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $11035 m0 *1 323.38,182.24
X$11035 105 5217 5152 5212 4534 40 105 5216 40 sky130_fd_sc_hd__a31oi_1
* cell instance $11036 m0 *1 325.68,182.24
X$11036 105 5288 5287 5211 105 40 4996 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11042 m0 *1 334.88,182.24
X$11042 40 5214 3866 4997 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11043 m0 *1 339.02,182.24
X$11043 40 2747 5281 105 105 40 sky130_fd_sc_hd__buf_16
* cell instance $11046 r0 *1 3.68,182.24
X$11046 40 4920 4970 5249 5316 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $11047 r0 *1 7.36,182.24
X$11047 105 5251 5250 4725 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11048 r0 *1 8.74,182.24
X$11048 105 4817 5250 5251 5316 40 105 40 sky130_fd_sc_hd__nand3b_1
* cell instance $11049 r0 *1 11.5,182.24
X$11049 40 4235 5252 5190 5253 5284 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $11054 r0 *1 15.64,182.24
X$11054 40 5252 5190 4284 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $11055 r0 *1 25.76,182.24
X$11055 105 5286 5320 5117 5321 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $11056 r0 *1 27.6,182.24
X$11056 105 5255 5254 5116 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $11058 r0 *1 30.36,182.24
X$11058 105 5192 5321 5193 5001 40 105 40 sky130_fd_sc_hd__nor3b_1
* cell instance $11061 r0 *1 35.42,182.24
X$11061 105 5323 5358 5324 105 40 5195 40 sky130_fd_sc_hd__or3_2
* cell instance $11063 r0 *1 39.1,182.24
X$11063 40 5192 5194 5195 4740 5043 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $11070 r0 *1 44.62,182.24
X$11070 40 40 5118 5038 5155 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $11071 r0 *1 46.92,182.24
X$11071 105 5040 5155 5118 40 105 5328 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11072 r0 *1 48.76,182.24
X$11072 105 5290 5328 4972 105 4973 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $11073 r0 *1 50.6,182.24
X$11073 105 5194 5195 5003 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11074 r0 *1 51.98,182.24
X$11074 105 5327 5040 5256 5257 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $11075 r0 *1 53.82,182.24
X$11075 105 5327 5196 5256 5360 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $11076 r0 *1 55.66,182.24
X$11076 105 5329 5257 5361 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11077 r0 *1 57.04,182.24
X$11077 40 5258 4648 5441 4939 105 105 40 sky130_fd_sc_hd__nand3b_4
* cell instance $11078 r0 *1 64.4,182.24
X$11078 105 4939 4648 5258 5363 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $11084 r0 *1 70.84,182.24
X$11084 40 4740 1591 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $11085 r0 *1 80.04,182.24
X$11085 40 5317 5331 5292 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $11088 r0 *1 88.78,182.24
X$11088 40 5332 3553 105 105 40 sky130_fd_sc_hd__clkinv_8
* cell instance $11089 r0 *1 94.76,182.24
X$11089 105 5198 4563 5260 4746 40 105 5365 40 sky130_fd_sc_hd__and4_1
* cell instance $11094 r0 *1 98.44,182.24
X$11094 105 5200 5198 5367 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $11095 r0 *1 100.74,182.24
X$11095 40 4485 5125 4899 5410 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $11096 r0 *1 106.72,182.24
X$11096 40 5125 4096 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $11099 r0 *1 115,182.24
X$11099 40 3879 5236 5333 5262 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11106 r0 *1 128.34,182.24
X$11106 105 5236 5205 5334 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11107 r0 *1 129.72,182.24
X$11107 105 4010 5334 5263 105 40 5262 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11109 r0 *1 132.02,182.24
X$11109 105 5261 105 40 5268 40 sky130_fd_sc_hd__buf_4
* cell instance $11110 r0 *1 134.78,182.24
X$11110 105 5268 5375 5376 105 40 5374 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11111 r0 *1 136.62,182.24
X$11111 105 4665 4409 5298 40 105 5376 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11113 r0 *1 138.92,182.24
X$11113 105 4904 4409 5266 40 105 5263 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11115 r0 *1 141.22,182.24
X$11115 105 5303 5236 4411 40 105 5379 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11117 r0 *1 143.52,182.24
X$11117 105 4248 5337 5380 105 40 5298 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11119 r0 *1 145.82,182.24
X$11119 40 40 5381 105 4750 5179 105 sky130_fd_sc_hd__nor2_2
* cell instance $11120 r0 *1 148.12,182.24
X$11120 105 3695 4667 5337 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11127 r0 *1 154.56,182.24
X$11127 40 3879 5176 5333 5267 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11130 r0 *1 167.44,182.24
X$11130 40 6761 3691 3623 4903 3404 105 105 40 sky130_fd_sc_hd__a22o_4
* cell instance $11137 r0 *1 178.94,182.24
X$11137 105 5308 5310 3769 40 105 5248 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11141 r0 *1 183.54,182.24
X$11141 105 5311 5419 3769 40 105 5385 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11145 r0 *1 190.44,182.24
X$11145 105 5312 5201 4664 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11147 r0 *1 192.74,182.24
X$11147 105 3482 105 40 5314 40 sky130_fd_sc_hd__inv_1
* cell instance $11149 r0 *1 195.04,182.24
X$11149 105 3278 4632 5709 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11150 r0 *1 196.42,182.24
X$11150 40 3879 5186 4260 5247 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11154 r0 *1 207,182.24
X$11154 105 5270 105 40 5269 40 sky130_fd_sc_hd__inv_1
* cell instance $11160 r0 *1 217.58,182.24
X$11160 105 4671 5179 5309 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11161 r0 *1 218.96,182.24
X$11161 105 3170 4632 5382 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11163 r0 *1 222.18,182.24
X$11163 40 4502 5306 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $11164 r0 *1 229.54,182.24
X$11164 40 5306 5202 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $11170 r0 *1 236.44,182.24
X$11170 105 5272 105 40 5137 40 sky130_fd_sc_hd__buf_4
* cell instance $11171 r0 *1 239.2,182.24
X$11171 105 5273 40 5378 105 40 sky130_fd_sc_hd__buf_2
* cell instance $11174 r0 *1 243.34,182.24
X$11174 105 4750 4495 5373 5210 5345 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $11175 r0 *1 246.1,182.24
X$11175 105 5343 4421 4258 5211 40 5371 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $11177 r0 *1 249.78,182.24
X$11177 105 4750 4602 5369 5210 5370 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $11178 r0 *1 252.54,182.24
X$11178 105 5305 4524 5211 4525 40 5304 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $11179 r0 *1 255.3,182.24
X$11179 105 5274 5211 5304 40 105 5368 40 sky130_fd_sc_hd__a21o_1
* cell instance $11184 r0 *1 261.74,182.24
X$11184 105 5299 5524 3769 40 105 5275 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11186 r0 *1 264.04,182.24
X$11186 40 3879 3318 4955 5275 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11187 r0 *1 274.62,182.24
X$11187 40 5276 5153 5210 5455 4372 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $11190 r0 *1 280.6,182.24
X$11190 40 3879 3036 4414 5296 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11195 r0 *1 291.64,182.24
X$11195 105 5347 4671 5278 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11197 r0 *1 293.48,182.24
X$11197 105 4765 4760 5278 40 5165 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $11198 r0 *1 296.7,182.24
X$11198 105 4198 5348 5359 105 40 5293 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11199 r0 *1 298.54,182.24
X$11199 40 3879 5347 4414 5293 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11208 r0 *1 319.24,182.24
X$11208 105 5350 4271 5356 5349 5355 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $11209 r0 *1 322,182.24
X$11209 105 5218 5289 5212 4265 40 105 5288 40 sky130_fd_sc_hd__a31oi_1
* cell instance $11210 r0 *1 324.3,182.24
X$11210 105 5279 4273 5354 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11211 r0 *1 325.68,182.24
X$11211 105 4546 3920 5287 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11214 r0 *1 328.44,182.24
X$11214 105 3028 3920 5352 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11215 r0 *1 329.82,182.24
X$11215 40 5281 3028 5280 5285 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11221 r0 *1 342.7,182.24
X$11221 105 5213 105 5351 40 40 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $11224 r0 *1 347.76,182.24
X$11224 105 5282 5283 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $11226 m0 *1 3.22,187.68
X$11226 105 5326 105 40 5317 40 sky130_fd_sc_hd__buf_4
* cell instance $11227 m0 *1 5.98,187.68
X$11227 105 5317 5539 5035 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $11228 m0 *1 8.28,187.68
X$11228 105 5388 4920 5249 5316 5113 105 40 40 sky130_fd_sc_hd__or4_1
* cell instance $11229 m0 *1 11.04,187.68
X$11229 40 5391 5392 5253 5252 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $11230 m0 *1 17.02,187.68
X$11230 40 40 5318 5253 5317 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $11231 m0 *1 19.32,187.68
X$11231 105 5286 5320 5388 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11232 m0 *1 20.7,187.68
X$11232 105 5292 5319 5393 5318 5286 40 105 40 sky130_fd_sc_hd__o22a_1
* cell instance $11234 m0 *1 24.84,187.68
X$11234 105 5255 5254 5317 5292 105 5191 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $11237 m0 *1 29.44,187.68
X$11237 105 5396 5357 5397 105 40 4775 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11238 m0 *1 31.28,187.68
X$11238 105 5322 5398 5318 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11239 m0 *1 32.66,187.68
X$11239 105 5325 5284 5358 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $11240 m0 *1 34.96,187.68
X$11240 40 5358 5118 5323 5324 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $11241 m0 *1 38.64,187.68
X$11241 40 5325 5194 5318 5326 105 105 40 sky130_fd_sc_hd__a21boi_2
* cell instance $11244 m0 *1 44.16,187.68
X$11244 40 5327 5507 4972 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $11245 m0 *1 50.14,187.68
X$11245 105 5317 5257 5401 5400 5119 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $11246 m0 *1 52.9,187.68
X$11246 105 5327 5196 5439 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11247 m0 *1 54.28,187.68
X$11247 105 5362 5361 5360 5400 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $11250 m0 *1 57.04,187.68
X$11250 105 5402 5257 5362 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11251 m0 *1 58.42,187.68
X$11251 40 5442 5477 5476 5441 5363 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $11253 m0 *1 63.94,187.68
X$11253 40 5440 5511 5317 4648 5403 5292 105 105 40 sky130_fd_sc_hd__a221oi_1
* cell instance $11254 m0 *1 67.16,187.68
X$11254 105 4939 5330 5403 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11255 m0 *1 68.54,187.68
X$11255 40 5258 4823 5330 5331 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $11258 m0 *1 78.2,187.68
X$11258 40 4897 5405 5292 5317 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $11260 m0 *1 84.64,187.68
X$11260 105 3553 40 105 5939 40 sky130_fd_sc_hd__inv_4
* cell instance $11264 m0 *1 90.16,187.68
X$11264 105 5554 5260 5366 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11266 m0 *1 93.38,187.68
X$11266 40 5409 5332 5452 105 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $11268 m0 *1 103.96,187.68
X$11268 105 5200 5198 5449 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11270 m0 *1 105.8,187.68
X$11270 40 5943 5126 4899 5125 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $11276 m0 *1 119.14,187.68
X$11276 40 3879 5413 5333 5372 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11277 m0 *1 129.72,187.68
X$11277 40 2880 5333 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $11281 m0 *1 140.76,187.68
X$11281 105 4248 5335 5379 105 40 5266 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11282 m0 *1 142.6,187.68
X$11282 105 4248 5336 5415 105 40 5265 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11283 m0 *1 144.44,187.68
X$11283 105 5456 5416 4411 40 105 5380 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11284 m0 *1 146.28,187.68
X$11284 105 5381 5413 4411 40 105 5415 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11285 m0 *1 148.12,187.68
X$11285 105 3695 5031 5335 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11286 m0 *1 149.5,187.68
X$11286 40 40 4986 5336 3695 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $11289 m0 *1 156.4,187.68
X$11289 40 3879 4985 5333 5383 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11293 m0 *1 168.82,187.68
X$11293 40 5202 5459 4447 3245 3513 4448 5245 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11295 m0 *1 178.94,187.68
X$11295 105 4448 5418 4447 5062 105 5338 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $11297 m0 *1 182.16,187.68
X$11297 105 6435 5338 5420 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11299 m0 *1 184.46,187.68
X$11299 105 4988 105 40 5419 40 sky130_fd_sc_hd__inv_1
* cell instance $11300 m0 *1 185.84,187.68
X$11300 40 1772 5420 5421 3245 3079 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $11304 m0 *1 195.04,187.68
X$11304 40 5384 5463 5465 3278 3400 3482 5339 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11305 m0 *1 204.7,187.68
X$11305 105 5186 105 40 5313 40 sky130_fd_sc_hd__inv_1
* cell instance $11310 m0 *1 212.98,187.68
X$11310 105 5468 40 4369 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $11313 m0 *1 219.88,187.68
X$11313 105 5426 5340 5425 5182 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $11316 m0 *1 223.1,187.68
X$11316 40 5307 5340 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $11317 m0 *1 227.24,187.68
X$11317 105 5566 5341 5428 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $11318 m0 *1 229.54,187.68
X$11318 40 5273 5616 5344 3102 3050 3362 5429 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11319 m0 *1 239.2,187.68
X$11319 40 3879 5344 4955 5377 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11321 m0 *1 250.24,187.68
X$11321 40 3879 5274 4955 5368 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $11322 m0 *1 259.9,187.68
X$11322 40 4955 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $11324 m0 *1 271.4,187.68
X$11324 105 4394 3921 5455 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11327 m0 *1 275.54,187.68
X$11327 105 3529 40 5350 105 40 sky130_fd_sc_hd__buf_2
* cell instance $11329 m0 *1 277.84,187.68
X$11329 105 3529 40 5153 105 40 sky130_fd_sc_hd__buf_2
* cell instance $11331 m0 *1 280.14,187.68
X$11331 40 5131 5450 3591 3036 4852 3202 5245 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11332 m0 *1 289.8,187.68
X$11332 105 3263 5364 3538 5062 105 5451 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $11335 m0 *1 293.94,187.68
X$11335 105 5347 4224 5348 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11336 m0 *1 295.32,187.68
X$11336 105 5221 4618 4752 105 5359 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $11338 m0 *1 299,187.68
X$11338 105 5210 40 5349 105 40 sky130_fd_sc_hd__buf_2
* cell instance $11340 m0 *1 301.76,187.68
X$11340 105 5137 40 105 5510 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11344 m0 *1 307.74,187.68
X$11344 40 5137 5437 3373 3025 4916 4848 5245 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11345 m0 *1 317.4,187.68
X$11345 105 3028 3921 5356 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11347 m0 *1 319.24,187.68
X$11347 40 5588 5350 5349 5435 4855 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $11348 m0 *1 323.84,187.68
X$11348 105 5355 5354 5353 4270 40 105 5431 40 sky130_fd_sc_hd__a31oi_1
* cell instance $11349 m0 *1 326.14,187.68
X$11349 105 5211 5434 5432 105 5433 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $11350 m0 *1 327.98,187.68
X$11350 105 5211 5431 5352 105 5285 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $11357 m0 *1 339.02,187.68
X$11357 40 5351 2747 105 105 40 sky130_fd_sc_hd__buf_16
* cell instance $11360 r0 *1 2.76,187.68
X$11360 105 5412 5386 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $11363 r0 *1 5.52,187.68
X$11363 40 5249 5470 5326 5387 5501 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $11364 r0 *1 8.74,187.68
X$11364 105 5387 5326 5389 40 105 5251 40 sky130_fd_sc_hd__a21o_1
* cell instance $11366 r0 *1 11.96,187.68
X$11366 105 5387 5389 5317 5390 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $11367 r0 *1 13.8,187.68
X$11367 105 5472 5390 5392 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11370 r0 *1 15.64,187.68
X$11370 105 5284 5324 5391 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11373 r0 *1 18.4,187.68
X$11373 105 5393 5319 5326 40 105 5320 40 sky130_fd_sc_hd__a21o_1
* cell instance $11375 r0 *1 21.62,187.68
X$11375 105 5472 5284 5393 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11377 r0 *1 23.46,187.68
X$11377 105 5357 5394 5504 5395 4930 40 105 40 sky130_fd_sc_hd__o22a_1
* cell instance $11379 r0 *1 27.14,187.68
X$11379 105 5326 5292 5254 40 105 5357 40 sky130_fd_sc_hd__a21o_1
* cell instance $11380 r0 *1 29.9,187.68
X$11380 105 5357 5397 5396 40 105 4737 40 sky130_fd_sc_hd__o21a_2
* cell instance $11382 r0 *1 33.58,187.68
X$11382 40 5325 5155 5322 5398 5476 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $11389 r0 *1 45.54,187.68
X$11389 105 5256 5326 5292 105 40 5507 40 sky130_fd_sc_hd__a21boi_1
* cell instance $11391 r0 *1 48.76,187.68
X$11391 40 5438 5399 5589 5507 5509 5196 105 105 40 sky130_fd_sc_hd__o311a_1
* cell instance $11392 r0 *1 52.44,187.68
X$11392 105 5402 5317 5329 5439 105 5401 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $11394 r0 *1 55.66,187.68
X$11394 105 5329 5402 40 5292 105 40 sky130_fd_sc_hd__and2_4
* cell instance $11397 r0 *1 61.18,187.68
X$11397 40 40 5224 105 5442 5440 105 sky130_fd_sc_hd__nor2_2
* cell instance $11400 r0 *1 66.24,187.68
X$11400 40 4865 5444 5443 5404 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11404 r0 *1 71.76,187.68
X$11404 40 40 5317 5404 5292 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $11406 r0 *1 74.98,187.68
X$11406 105 5445 5404 5515 40 105 4942 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11408 r0 *1 77.74,187.68
X$11408 105 5331 5446 5445 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11411 r0 *1 80.5,187.68
X$11411 40 5331 5517 5406 5123 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $11414 r0 *1 88.32,187.68
X$11414 40 5598 5407 5484 5449 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $11418 r0 *1 98.44,187.68
X$11418 40 5521 5366 5408 5409 5682 5601 105 105 40 sky130_fd_sc_hd__a311oi_2
* cell instance $11419 r0 *1 103.96,187.68
X$11419 40 5199 5410 5411 2251 105 5484 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $11420 r0 *1 108.56,187.68
X$11420 40 3879 5412 5333 5526 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $11421 r0 *1 118.22,187.68
X$11421 40 5526 5413 5412 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11424 r0 *1 124.2,187.68
X$11424 105 5413 5205 5527 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11426 r0 *1 126.04,187.68
X$11426 105 3171 5558 105 40 40 sky130_fd_sc_hd__inv_6
* cell instance $11428 r0 *1 129.72,187.68
X$11428 105 5333 9505 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $11430 r0 *1 132.02,187.68
X$11430 40 3879 5416 5333 5374 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11432 r0 *1 143.52,187.68
X$11432 40 5841 5457 5691 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $11438 r0 *1 157.78,187.68
X$11438 40 5489 5535 4985 3077 4826 4982 5245 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11441 r0 *1 168.82,187.68
X$11441 105 5454 105 40 5062 40 sky130_fd_sc_hd__buf_4
* cell instance $11442 r0 *1 171.58,187.68
X$11442 40 5458 5417 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $11444 r0 *1 176.18,187.68
X$11444 105 3355 5461 5462 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $11446 r0 *1 178.48,187.68
X$11446 105 3308 105 40 5310 40 sky130_fd_sc_hd__inv_1
* cell instance $11453 r0 *1 189.98,187.68
X$11453 105 5426 5464 5314 40 105 5537 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11454 r0 *1 191.82,187.68
X$11454 40 5463 2610 5422 5495 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $11456 r0 *1 203.78,187.68
X$11456 105 5236 3645 5423 3702 40 5536 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $11462 r0 *1 210.68,187.68
X$11462 105 5425 5566 5468 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $11463 r0 *1 212.98,187.68
X$11463 40 5425 5341 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $11465 r0 *1 217.58,187.68
X$11465 40 5382 5424 5467 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $11467 r0 *1 222.64,187.68
X$11467 105 5426 5340 5466 40 105 3357 40 sky130_fd_sc_hd__and3_2
* cell instance $11468 r0 *1 225.4,187.68
X$11468 40 5306 5131 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $11469 r0 *1 229.54,187.68
X$11469 105 5340 40 105 5273 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11471 r0 *1 232.76,187.68
X$11471 105 5428 105 40 3529 40 sky130_fd_sc_hd__buf_4
* cell instance $11474 r0 *1 236.44,187.68
X$11474 105 5460 5429 5497 5531 40 5529 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $11475 r0 *1 239.2,187.68
X$11475 105 5427 105 40 5342 40 sky130_fd_sc_hd__buf_4
* cell instance $11476 r0 *1 241.96,187.68
X$11476 105 5344 3529 5373 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11477 r0 *1 243.34,187.68
X$11477 105 5344 5211 5371 40 105 5377 40 sky130_fd_sc_hd__a21o_1
* cell instance $11478 r0 *1 246.1,187.68
X$11478 105 5210 4454 5345 105 5343 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $11480 r0 *1 251.62,187.68
X$11480 105 5210 4676 5370 105 5305 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $11481 r0 *1 253.46,187.68
X$11481 105 5274 3529 5369 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11484 r0 *1 256.22,187.68
X$11484 40 5614 5274 3491 5491 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11486 r0 *1 260.36,187.68
X$11486 105 5685 3318 5364 40 105 5522 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11487 r0 *1 262.2,187.68
X$11487 105 3318 105 40 5524 40 sky130_fd_sc_hd__inv_1
* cell instance $11489 r0 *1 264.04,187.68
X$11489 40 3034 4955 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $11490 r0 *1 273.24,187.68
X$11490 105 5211 5519 5297 105 40 5520 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11491 r0 *1 275.08,187.68
X$11491 105 4394 3920 5519 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11492 r0 *1 276.46,187.68
X$11492 105 3202 5364 3591 5454 105 5604 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $11493 r0 *1 279.22,187.68
X$11493 40 2274 5518 5453 3036 2978 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $11497 r0 *1 289.8,187.68
X$11497 105 5448 5451 5513 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11499 r0 *1 291.64,187.68
X$11499 40 2183 5513 5447 4143 3079 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $11502 r0 *1 302.22,187.68
X$11502 40 5510 5506 3538 4143 4546 3263 5245 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11506 r0 *1 313.26,187.68
X$11506 105 4916 3921 5435 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11507 r0 *1 314.64,187.68
X$11507 105 2673 3921 5505 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11508 r0 *1 316.02,187.68
X$11508 105 5350 4620 5505 5349 5436 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $11513 r0 *1 322.46,187.68
X$11513 40 5281 4916 5280 5430 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $11514 r0 *1 331.66,187.68
X$11514 40 5281 2673 5280 5433 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11516 r0 *1 342.24,187.68
X$11516 40 5500 5274 4695 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11548 m0 *1 2.76,193.12
X$11548 105 5557 5469 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $11551 m0 *1 5.52,193.12
X$11551 40 5470 5317 5387 4816 5501 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $11552 m0 *1 13.34,193.12
X$11552 105 5395 5471 5473 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $11553 m0 *1 15.64,193.12
X$11553 105 5404 5319 5114 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $11554 m0 *1 17.94,193.12
X$11554 105 5395 5474 5115 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11555 m0 *1 19.32,193.12
X$11555 40 5582 5255 5254 5584 5404 105 4968 105 40 sky130_fd_sc_hd__o311ai_4
* cell instance $11558 m0 *1 29.9,193.12
X$11558 40 40 5397 5254 5396 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $11560 m0 *1 32.66,193.12
X$11560 105 5542 5387 5586 5250 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $11562 m0 *1 34.96,193.12
X$11562 40 5540 5475 5542 5541 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $11564 m0 *1 37.72,193.12
X$11564 105 5475 105 40 5326 40 sky130_fd_sc_hd__buf_4
* cell instance $11566 m0 *1 41.4,193.12
X$11566 105 5327 4740 5587 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $11569 m0 *1 47.38,193.12
X$11569 105 5508 4740 5256 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $11571 m0 *1 51.52,193.12
X$11571 105 5476 5477 5256 5327 5509 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $11572 m0 *1 54.28,193.12
X$11572 105 5329 5402 5477 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11575 m0 *1 57.04,193.12
X$11575 105 5546 5545 5589 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11578 m0 *1 62.56,193.12
X$11578 105 5478 5549 5330 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11579 m0 *1 63.94,193.12
X$11579 105 5478 5549 4740 105 5511 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $11581 m0 *1 66.24,193.12
X$11581 105 5479 5480 5481 40 105 5478 40 sky130_fd_sc_hd__o21a_2
* cell instance $11582 m0 *1 69.46,193.12
X$11582 105 5479 5481 5480 5549 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $11583 m0 *1 71.3,193.12
X$11583 105 5482 5550 5514 105 5483 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $11584 m0 *1 74.06,193.12
X$11584 105 5591 5483 5515 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $11586 m0 *1 76.82,193.12
X$11586 105 5593 5552 5331 105 4977 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $11587 m0 *1 79.58,193.12
X$11587 105 5551 5553 5516 105 5550 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $11592 m0 *1 86.94,193.12
X$11592 40 5554 5598 5260 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $11594 m0 *1 96.6,193.12
X$11594 40 5521 5367 5407 5790 5484 5295 105 105 40 sky130_fd_sc_hd__o32ai_4
* cell instance $11595 m0 *1 106.72,193.12
X$11595 40 5411 3016 3304 4710 105 105 40 sky130_fd_sc_hd__nor3b_2
* cell instance $11598 m0 *1 112.24,193.12
X$11598 40 5683 5414 5557 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11599 m0 *1 116.38,193.12
X$11599 40 4710 5720 3016 3304 105 105 40 sky130_fd_sc_hd__or3b_4
* cell instance $11602 m0 *1 121.9,193.12
X$11602 105 5485 40 105 5607 40 sky130_fd_sc_hd__inv_2
* cell instance $11603 m0 *1 123.28,193.12
X$11603 105 5486 5559 5605 40 105 5606 40 sky130_fd_sc_hd__a21o_1
* cell instance $11604 m0 *1 126.04,193.12
X$11604 40 9508 5607 5560 3171 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $11605 m0 *1 135.24,193.12
X$11605 105 5268 5527 5264 105 40 5372 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11606 m0 *1 137.08,193.12
X$11606 105 5560 40 105 5486 40 sky130_fd_sc_hd__inv_2
* cell instance $11610 m0 *1 140.3,193.12
X$11610 105 5612 105 40 5530 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $11611 m0 *1 142.14,193.12
X$11611 40 5612 5487 5558 105 5528 105 40 sky130_fd_sc_hd__ha_1
* cell instance $11613 m0 *1 147.2,193.12
X$11613 105 5488 5530 5487 40 105 5533 40 sky130_fd_sc_hd__a21o_1
* cell instance $11614 m0 *1 149.96,193.12
X$11614 40 5563 5562 5533 5457 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $11616 m0 *1 156.86,193.12
X$11616 40 5564 5615 4454 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $11619 m0 *1 169.28,193.12
X$11619 40 4576 5458 5617 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $11622 m0 *1 175.72,193.12
X$11622 40 5492 5618 5462 5490 5310 5461 105 105 40 sky130_fd_sc_hd__a221oi_2
* cell instance $11624 m0 *1 182.16,193.12
X$11624 40 5491 5422 3064 3669 3174 5414 5492 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11626 m0 *1 192.74,193.12
X$11626 105 5537 5341 5465 40 105 5619 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11630 m0 *1 199.64,193.12
X$11630 40 5417 5620 5427 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $11632 m0 *1 207.46,193.12
X$11632 40 3645 5493 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $11633 m0 *1 212.52,193.12
X$11633 105 5567 40 5566 105 40 sky130_fd_sc_hd__buf_2
* cell instance $11636 m0 *1 215.74,193.12
X$11636 40 1545 5494 5569 5239 2978 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $11639 m0 *1 224.48,193.12
X$11639 40 5466 5534 5340 3249 105 105 40 sky130_fd_sc_hd__and3_4
* cell instance $11640 m0 *1 228.62,193.12
X$11640 105 3492 5566 5531 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11641 m0 *1 230,193.12
X$11641 105 5429 40 105 5532 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11642 m0 *1 233.22,193.12
X$11642 40 5571 5496 5495 3080 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $11643 m0 *1 239.2,193.12
X$11643 40 5572 5496 5344 5573 5062 3492 105 105 40 sky130_fd_sc_hd__a221oi_2
* cell instance $11645 m0 *1 245.18,193.12
X$11645 105 5378 40 105 5525 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11650 m0 *1 252.08,193.12
X$11650 40 5525 5689 3491 3165 5274 3309 5497 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11652 m0 *1 263.58,193.12
X$11652 105 4396 2978 5609 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11653 m0 *1 264.96,193.12
X$11653 105 5687 5341 3315 40 105 5523 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11654 m0 *1 266.8,193.12
X$11654 40 3879 4394 4955 5520 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11658 m0 *1 279.22,193.12
X$11658 105 5603 5604 5518 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11660 m0 *1 281.52,193.12
X$11660 40 5493 5210 5490 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $11662 m0 *1 286.58,193.12
X$11662 40 5131 5512 2746 5347 5498 3648 5245 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11663 m0 *1 296.24,193.12
X$11663 105 5599 5495 5499 40 105 5447 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11666 m0 *1 302.22,193.12
X$11666 105 4546 5493 5596 3702 105 5499 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $11669 m0 *1 306.36,193.12
X$11669 40 5595 3373 5592 5461 5594 5492 4916 105 105 40 sky130_fd_sc_hd__mux4_2
* cell instance $11671 m0 *1 318.32,193.12
X$11671 105 5279 4458 5590 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11672 m0 *1 319.7,193.12
X$11672 105 5436 5590 5353 4529 40 105 5434 40 sky130_fd_sc_hd__a31oi_1
* cell instance $11673 m0 *1 322,193.12
X$11673 105 5279 4608 5577 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11674 m0 *1 323.38,193.12
X$11674 105 5577 5588 5353 4689 40 105 5503 40 sky130_fd_sc_hd__a31oi_1
* cell instance $11675 m0 *1 325.68,193.12
X$11675 105 5211 5502 5503 105 40 5430 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11676 m0 *1 327.52,193.12
X$11676 105 2673 3920 5432 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11678 m0 *1 329.36,193.12
X$11678 105 4916 3920 5502 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11682 m0 *1 333.5,193.12
X$11682 105 5280 9572 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $11686 m0 *1 339.94,193.12
X$11686 40 5281 4695 5280 5500 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $11690 r0 *1 6.44,193.12
X$11690 105 5579 5538 5326 5539 40 4817 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $11691 r0 *1 9.66,193.12
X$11691 105 5471 5538 5664 105 40 4853 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11694 r0 *1 12.88,193.12
X$11694 105 5395 5471 5580 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $11697 r0 *1 15.64,193.12
X$11697 40 5319 5473 5580 5504 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11699 r0 *1 20.7,193.12
X$11699 40 5584 5627 5254 5582 5669 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $11701 r0 *1 25.76,193.12
X$11701 105 5395 5117 5394 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11703 r0 *1 27.6,193.12
X$11703 40 40 5387 105 5322 5585 105 sky130_fd_sc_hd__nor2_2
* cell instance $11705 r0 *1 30.36,193.12
X$11705 105 5389 5541 5540 5670 40 105 5586 40 sky130_fd_sc_hd__and4_1
* cell instance $11707 r0 *1 34.04,193.12
X$11707 40 5541 5540 5542 105 5476 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $11709 r0 *1 41.4,193.12
X$11709 105 5587 5714 5672 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11712 r0 *1 43.24,193.12
X$11712 40 5540 5822 5543 5327 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11713 r0 *1 47.38,193.12
X$11713 105 5544 105 40 4740 40 sky130_fd_sc_hd__buf_4
* cell instance $11715 r0 *1 51.06,193.12
X$11715 40 5545 5327 5547 5713 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $11716 r0 *1 59.34,193.12
X$11716 105 5634 5635 5325 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11718 r0 *1 61.18,193.12
X$11718 105 5548 5676 5478 5635 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $11719 r0 *1 63.48,193.12
X$11719 40 5479 5676 1986 105 5258 105 40 sky130_fd_sc_hd__ha_1
* cell instance $11722 r0 *1 69,193.12
X$11722 105 5480 5677 5444 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11724 r0 *1 70.84,193.12
X$11724 105 5636 5483 5678 105 5480 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $11725 r0 *1 73.6,193.12
X$11725 105 5482 5514 5550 5591 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $11726 r0 *1 75.44,193.12
X$11726 105 5550 5637 5331 105 5593 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $11727 r0 *1 77.28,193.12
X$11727 40 5551 5552 5514 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $11728 r0 *1 86.48,193.12
X$11728 105 5553 5597 5406 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11730 r0 *1 91.54,193.12
X$11730 40 5408 5407 5409 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $11731 r0 *1 95.68,193.12
X$11731 105 5600 5555 5556 5941 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $11735 r0 *1 98.44,193.12
X$11735 40 5601 5452 5554 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $11737 r0 *1 107.18,193.12
X$11737 40 3879 5557 5333 5683 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $11741 r0 *1 120.06,193.12
X$11741 40 5559 5605 5686 105 5558 105 40 sky130_fd_sc_hd__ha_1
* cell instance $11746 r0 *1 126.5,193.12
X$11746 40 5644 5486 5561 5558 5686 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $11748 r0 *1 135.24,193.12
X$11748 40 5608 5561 4183 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $11749 r0 *1 142.6,193.12
X$11749 105 5530 5611 5917 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11750 r0 *1 143.98,193.12
X$11750 105 5416 5205 5375 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11752 r0 *1 147.2,193.12
X$11752 40 5693 5488 5530 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $11756 r0 *1 154.56,193.12
X$11756 105 5563 5648 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $11757 r0 *1 155.94,193.12
X$11757 40 5563 5564 5696 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $11758 r0 *1 166.06,193.12
X$11758 105 5648 40 105 5615 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11759 r0 *1 169.28,193.12
X$11759 105 5696 40 105 4257 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11760 r0 *1 172.5,193.12
X$11760 105 5458 40 105 5567 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11762 r0 *1 176.64,193.12
X$11762 40 5131 5565 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $11765 r0 *1 181.24,193.12
X$11765 40 5492 5649 5618 5702 5700 5705 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $11767 r0 *1 191.36,193.12
X$11767 40 5708 3669 3064 5701 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $11768 r0 *1 195.04,193.12
X$11768 105 5619 5565 5708 5566 5707 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $11771 r0 *1 198.72,193.12
X$11771 40 5621 5536 5706 5703 5602 5568 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $11775 r0 *1 209.76,193.12
X$11775 40 4452 5466 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $11776 r0 *1 215.28,193.12
X$11776 105 5417 40 105 5698 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11778 r0 *1 218.96,193.12
X$11778 40 4425 5426 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $11779 r0 *1 223.1,193.12
X$11779 105 4425 40 105 5429 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11780 r0 *1 226.32,193.12
X$11780 40 5426 5570 5341 5272 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $11782 r0 *1 232.3,193.12
X$11782 105 5570 40 105 6182 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11785 r0 *1 236.44,193.12
X$11785 40 5654 3102 3362 5602 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $11786 r0 *1 240.12,193.12
X$11786 105 5529 5497 5616 40 105 5467 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11787 r0 *1 241.96,193.12
X$11787 40 3879 4914 4955 5692 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $11789 r0 *1 252.08,193.12
X$11789 40 5614 5492 5845 3163 3168 5613 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $11791 r0 *1 261.74,193.12
X$11791 105 5610 5245 5524 40 105 5687 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11793 r0 *1 264.04,193.12
X$11793 40 2368 5609 5684 5522 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $11794 r0 *1 270.02,193.12
X$11794 105 3315 105 40 5171 40 sky130_fd_sc_hd__inv_1
* cell instance $11798 r0 *1 277.38,193.12
X$11798 105 4393 5153 5756 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11801 r0 *1 282.9,193.12
X$11801 105 3648 4903 2746 5062 105 5831 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $11809 r0 *1 294.86,193.12
X$11809 105 5279 4946 5575 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11810 r0 *1 296.24,193.12
X$11810 40 5659 5353 5679 5575 4761 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $11811 r0 *1 300.84,193.12
X$11811 40 5679 5350 5349 5576 4993 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $11812 r0 *1 305.44,193.12
X$11812 105 5574 5153 5576 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11814 r0 *1 308.66,193.12
X$11814 40 2743 5674 5649 5592 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $11819 r0 *1 319.24,193.12
X$11819 105 3150 5153 5671 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11821 r0 *1 321.54,193.12
X$11821 105 5279 4553 5668 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11822 r0 *1 322.92,193.12
X$11822 105 5574 5205 5578 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11823 r0 *1 324.3,193.12
X$11823 105 5353 5667 5668 4537 40 105 5660 40 sky130_fd_sc_hd__a31oi_1
* cell instance $11824 r0 *1 326.6,193.12
X$11824 105 5268 5578 5659 105 40 5581 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11825 r0 *1 328.44,193.12
X$11825 105 5660 5665 5268 105 40 5663 40 sky130_fd_sc_hd__o21ai_1
* cell instance $11826 r0 *1 330.28,193.12
X$11826 105 3150 3920 5665 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11827 r0 *1 331.66,193.12
X$11827 40 5583 5662 4922 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11828 r0 *1 335.8,193.12
X$11828 40 5281 5574 5280 5581 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $11860 m0 *1 1.38,198.56
X$11860 105 5661 5622 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $11862 m0 *1 6.44,198.56
X$11862 40 5501 5623 4920 5625 5476 5624 105 105 40 sky130_fd_sc_hd__o41a_1
* cell instance $11864 m0 *1 11.5,198.56
X$11864 105 5329 5626 5624 5625 40 5539 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $11866 m0 *1 14.72,198.56
X$11866 105 5322 5666 5504 5580 5538 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $11868 m0 *1 18.4,198.56
X$11868 105 5627 5582 5474 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $11869 m0 *1 21.62,198.56
X$11869 105 5582 5255 5627 5628 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $11871 m0 *1 23.92,198.56
X$11871 105 5582 5627 5628 105 5669 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $11873 m0 *1 26.22,198.56
X$11873 105 5630 5629 5626 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $11876 m0 *1 29.44,198.56
X$11876 40 5398 5472 5629 5630 5389 105 105 40 sky130_fd_sc_hd__nand4b_2
* cell instance $11877 m0 *1 34.96,198.56
X$11877 105 5630 5629 5585 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11878 m0 *1 36.34,198.56
X$11878 40 5630 5546 5631 5625 5629 5632 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $11880 m0 *1 46.46,198.56
X$11880 40 5630 5402 5629 5633 105 105 40 sky130_fd_sc_hd__and3_4
* cell instance $11881 m0 *1 50.6,198.56
X$11881 40 5634 5744 5746 5544 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $11883 m0 *1 57.04,198.56
X$11883 105 5675 5634 5508 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $11885 m0 *1 60.26,198.56
X$11885 40 5676 5548 5478 5634 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $11887 m0 *1 68.08,198.56
X$11887 40 5636 5481 1988 105 5443 105 40 sky130_fd_sc_hd__ha_1
* cell instance $11888 m0 *1 72.68,198.56
X$11888 105 5636 5678 5483 5677 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $11889 m0 *1 74.52,198.56
X$11889 40 5482 5678 2251 105 5446 105 40 sky130_fd_sc_hd__ha_1
* cell instance $11890 m0 *1 79.12,198.56
X$11890 105 5551 5516 5553 5637 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $11892 m0 *1 81.42,198.56
X$11892 105 5680 5638 5405 105 5553 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $11895 m0 *1 90.16,198.56
X$11895 105 5681 5719 5718 105 5639 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $11896 m0 *1 92.92,198.56
X$11896 105 5452 5260 5554 5682 40 105 40 sky130_fd_sc_hd__and3b_1
* cell instance $11897 m0 *1 96.14,198.56
X$11897 40 5600 5718 2803 105 5365 105 40 sky130_fd_sc_hd__ha_1
* cell instance $11900 m0 *1 102.12,198.56
X$11900 40 3879 5661 5333 5640 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $11902 m0 *1 112.24,198.56
X$11902 40 5640 5641 5661 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11903 m0 *1 116.38,198.56
X$11903 40 9527 5838 3171 105 5686 105 40 sky130_fd_sc_hd__ha_1
* cell instance $11904 m0 *1 120.98,198.56
X$11904 105 5559 105 40 5755 40 sky130_fd_sc_hd__inv_1
* cell instance $11905 m0 *1 122.36,198.56
X$11905 105 5642 40 105 5758 40 sky130_fd_sc_hd__inv_2
* cell instance $11906 m0 *1 123.74,198.56
X$11906 105 5643 5688 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $11907 m0 *1 125.12,198.56
X$11907 40 5690 5644 5722 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $11908 m0 *1 131.1,198.56
X$11908 40 5690 5647 4184 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $11911 m0 *1 139.84,198.56
X$11911 105 5646 5840 5762 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11912 m0 *1 141.22,198.56
X$11912 40 5647 5691 4252 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $11913 m0 *1 148.58,198.56
X$11913 40 5693 5608 4364 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $11914 m0 *1 155.94,198.56
X$11914 40 5424 3171 5564 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $11918 m0 *1 169.28,198.56
X$11918 105 5272 40 105 5489 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $11919 m0 *1 172.5,198.56
X$11919 105 3623 40 5573 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $11920 m0 *1 175.26,198.56
X$11920 105 5847 4638 5764 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11924 m0 *1 179.86,198.56
X$11924 105 3464 5493 5641 3702 40 5705 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $11926 m0 *1 184,198.56
X$11926 40 5702 2740 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $11927 m0 *1 188.14,198.56
X$11927 40 5768 5414 3174 5464 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $11931 m0 *1 195.04,198.56
X$11931 40 40 5528 105 5709 5650 105 sky130_fd_sc_hd__nor2_2
* cell instance $11932 m0 *1 197.34,198.56
X$11932 105 5707 5769 5771 40 105 5650 40 sky130_fd_sc_hd__a21oi_1
* cell instance $11936 m0 *1 202.4,198.56
X$11936 40 5602 5706 5699 5704 5313 5726 105 105 40 sky130_fd_sc_hd__a221oi_2
* cell instance $11937 m0 *1 207.92,198.56
X$11937 40 5703 1966 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $11938 m0 *1 213.44,198.56
X$11938 105 4907 5418 5176 5062 105 5651 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $11941 m0 *1 218.96,198.56
X$11941 105 5466 40 5620 105 40 sky130_fd_sc_hd__buf_2
* cell instance $11942 m0 *1 220.8,198.56
X$11942 105 5652 5651 5494 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11944 m0 *1 222.64,198.56
X$11944 40 5849 3455 5426 5534 5697 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $11946 m0 *1 231.38,198.56
X$11946 40 5497 5695 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $11947 m0 *1 235.98,198.56
X$11947 40 5460 5653 5694 5378 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $11949 m0 *1 240.12,198.56
X$11949 40 5692 5694 4914 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $11951 m0 *1 244.72,198.56
X$11951 105 4285 5493 5731 3702 105 5761 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $11958 m0 *1 256.68,198.56
X$11958 40 5655 5689 5760 5532 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $11963 m0 *1 272.32,198.56
X$11963 40 5384 5602 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $11966 m0 *1 277.84,198.56
X$11966 105 3695 40 5279 105 40 sky130_fd_sc_hd__buf_2
* cell instance $11968 m0 *1 280.6,198.56
X$11968 40 5736 5350 5349 5657 5013 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $11969 m0 *1 285.2,198.56
X$11969 105 4852 5153 5657 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11971 m0 *1 287.04,198.56
X$11971 40 5131 5752 3938 2836 5574 3310 5245 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $11972 m0 *1 296.7,198.56
X$11972 105 5498 5153 5751 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11976 m0 *1 301.3,198.56
X$11976 105 5662 5153 5750 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11981 m0 *1 306.36,198.56
X$11981 40 5674 5749 5649 5461 5673 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $11982 m0 *1 310.96,198.56
X$11982 40 5673 4848 5658 5492 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $11984 m0 *1 315.1,198.56
X$11984 105 2474 5153 5745 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11986 m0 *1 318.32,198.56
X$11986 40 5667 5350 5349 5671 4382 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $11988 m0 *1 323.38,198.56
X$11988 40 5281 4922 5280 5583 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $11990 m0 *1 333.04,198.56
X$11990 40 5281 3150 5280 5663 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $11994 r0 *1 5.06,198.56
X$11994 105 5672 5710 5470 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $11997 r0 *1 9.2,198.56
X$11997 105 5476 5625 5664 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $11998 r0 *1 10.58,198.56
X$11998 105 6092 5471 5624 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12006 r0 *1 17.02,198.56
X$12006 40 5284 5741 5742 5776 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $12009 r0 *1 25.3,198.56
X$12009 105 5629 5779 5630 5894 105 5666 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $12012 r0 *1 29.9,198.56
X$12012 40 40 5117 105 5711 5255 105 sky130_fd_sc_hd__nor2_2
* cell instance $12013 r0 *1 32.2,198.56
X$12013 105 5743 5322 5820 5585 40 5323 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $12015 r0 *1 34.96,198.56
X$12015 105 5712 5783 5821 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12016 r0 *1 36.34,198.56
X$12016 105 5711 5713 5632 40 105 5782 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12017 r0 *1 38.18,198.56
X$12017 105 5327 5716 5541 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $12019 r0 *1 41.4,198.56
X$12019 105 5675 5712 5543 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12023 r0 *1 44.16,198.56
X$12023 105 5715 5547 5399 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12024 r0 *1 45.54,198.56
X$12024 105 5716 40 3876 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $12025 r0 *1 48.3,198.56
X$12025 40 5712 5717 5547 5634 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $12026 r0 *1 54.28,198.56
X$12026 40 5717 5713 5744 5629 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $12028 r0 *1 60.72,198.56
X$12028 40 5548 5675 1760 105 5788 105 40 sky130_fd_sc_hd__ha_1
* cell instance $12035 r0 *1 71.76,198.56
X$12035 105 5636 5405 5479 5482 105 5789 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $12037 r0 *1 75.9,198.56
X$12037 105 5551 5680 5548 5827 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $12038 r0 *1 77.74,198.56
X$12038 40 5680 5517 5516 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $12041 r0 *1 88.78,198.56
X$12041 105 5600 5556 5555 105 5719 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12042 r0 *1 91.54,198.56
X$12042 40 5828 5555 5556 5681 5600 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $12043 r0 *1 95.22,198.56
X$12043 105 5718 5681 5753 40 105 5829 40 sky130_fd_sc_hd__a21o_1
* cell instance $12046 r0 *1 98.44,198.56
X$12046 105 5718 5681 5719 5830 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $12047 r0 *1 100.28,198.56
X$12047 40 5833 5791 5720 3283 5410 105 105 40 sky130_fd_sc_hd__nor4b_4
* cell instance $12048 r0 *1 109.02,198.56
X$12048 105 5411 2251 1988 5410 105 5832 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $12050 r0 *1 112.24,198.56
X$12050 40 5754 5722 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12051 r0 *1 116.38,198.56
X$12051 40 5754 5645 5721 5558 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $12054 r0 *1 126.04,198.56
X$12054 105 5606 5722 5721 40 105 5757 40 sky130_fd_sc_hd__a21o_1
* cell instance $12056 r0 *1 129.72,198.56
X$12056 40 5793 3559 5642 3171 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $12057 r0 *1 138.92,198.56
X$12057 40 9558 5646 3171 105 5528 105 40 sky130_fd_sc_hd__ha_1
* cell instance $12059 r0 *1 143.98,198.56
X$12059 105 5457 5918 5843 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $12061 r0 *1 147.66,198.56
X$12061 40 5457 5562 5764 5558 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $12064 r0 *1 153.64,198.56
X$12064 105 5457 5762 5724 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12065 r0 *1 155.02,198.56
X$12065 105 5724 5723 5725 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12067 r0 *1 157.32,198.56
X$12067 40 5564 5725 5876 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $12068 r0 *1 163.3,198.56
X$12068 105 3559 5528 5424 5645 6235 105 40 40 sky130_fd_sc_hd__or4_1
* cell instance $12071 r0 *1 168.82,198.56
X$12071 40 5202 5799 3464 3308 3402 3214 5767 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12082 r0 *1 198.26,198.56
X$12082 105 5656 5768 5855 105 5771 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12084 r0 *1 201.02,198.56
X$12084 40 5770 5645 5772 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $12086 r0 *1 205.16,198.56
X$12086 105 5620 40 105 5464 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12088 r0 *1 208.84,198.56
X$12088 105 5427 40 105 5852 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12090 r0 *1 212.52,198.56
X$12090 40 4452 5727 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $12091 r0 *1 218.04,198.56
X$12091 40 5727 5800 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $12093 r0 *1 225.86,198.56
X$12093 105 3274 5766 3552 5765 105 5850 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $12094 r0 *1 228.62,198.56
X$12094 40 5848 5728 5729 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $12097 r0 *1 236.44,198.56
X$12097 105 5728 40 105 5695 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12098 r0 *1 239.66,198.56
X$12098 105 5653 5763 3665 105 40 5571 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12099 r0 *1 241.5,198.56
X$12099 105 5729 105 40 5697 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $12100 r0 *1 243.34,198.56
X$12100 105 5339 5654 5763 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12102 r0 *1 245.64,198.56
X$12102 105 5378 40 105 5734 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12103 r0 *1 248.86,198.56
X$12103 105 5730 5649 5761 40 105 5061 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12104 r0 *1 250.7,198.56
X$12104 40 5497 5760 5920 5732 2968 5733 5734 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12106 r0 *1 260.36,198.56
X$12106 105 5732 105 40 5759 40 sky130_fd_sc_hd__inv_1
* cell instance $12111 r0 *1 265.42,198.56
X$12111 40 5699 5735 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12115 r0 *1 275.54,198.56
X$12115 105 5279 5063 5835 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12116 r0 *1 276.92,198.56
X$12116 40 5836 5350 5349 5756 5138 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $12118 r0 *1 282.44,198.56
X$12118 40 5737 5353 5736 5811 4759 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $12126 r0 *1 296.7,198.56
X$12126 40 5815 5350 5349 5751 4760 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $12127 r0 *1 301.3,198.56
X$12127 40 5824 5350 5349 5750 4870 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $12128 r0 *1 305.9,198.56
X$12128 105 5747 5748 5749 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12129 r0 *1 307.28,198.56
X$12129 105 5279 4758 5823 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12132 r0 *1 312.8,198.56
X$12132 105 5279 4864 5738 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12134 r0 *1 314.18,198.56
X$12134 40 5739 5350 5349 5745 4764 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $12136 r0 *1 319.24,198.56
X$12136 105 5738 5739 5353 4847 40 105 5818 40 sky130_fd_sc_hd__a31oi_1
* cell instance $12138 r0 *1 322.46,198.56
X$12138 40 5281 5282 5280 5816 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $12139 r0 *1 331.66,198.56
X$12139 105 2474 3920 5817 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12141 r0 *1 333.5,198.56
X$12141 40 3034 5280 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $12144 r0 *1 343.62,198.56
X$12144 105 5971 5972 5970 40 105 5740 40 sky130_fd_sc_hd__a21o_1
* cell instance $12176 m0 *1 2.3,204
X$12176 105 5773 40 4920 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $12178 m0 *1 5.52,204
X$12178 105 5710 5775 5774 105 5329 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12179 m0 *1 8.28,204
X$12179 105 5858 5857 5710 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12181 m0 *1 10.12,204
X$12181 40 5775 5633 5774 5322 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $12183 m0 *1 17.02,204
X$12183 40 5742 5776 5893 105 5472 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $12184 m0 *1 22.08,204
X$12184 105 5859 5819 5776 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $12185 m0 *1 24.38,204
X$12185 105 5777 5778 5746 105 5896 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12187 m0 *1 26.68,204
X$12187 105 5857 5858 5670 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $12189 m0 *1 29.44,204
X$12189 40 5779 5743 5788 5670 105 105 5935 40 sky130_fd_sc_hd__or4b_1
* cell instance $12190 m0 *1 33.12,204
X$12190 105 5395 5781 5782 5820 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $12191 m0 *1 34.96,204
X$12191 40 5781 5542 5395 5782 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $12193 m0 *1 38.18,204
X$12193 105 5675 5714 5783 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12194 m0 *1 39.56,204
X$12194 105 5547 5780 5901 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12195 m0 *1 40.94,204
X$12195 105 5544 3876 5783 105 40 5780 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12196 m0 *1 42.78,204
X$12196 105 5675 5544 5822 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12197 m0 *1 44.16,204
X$12197 105 5785 5784 5780 105 5902 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12198 m0 *1 46,204
X$12198 105 5712 40 4939 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $12200 m0 *1 49.22,204
X$12200 40 5630 5825 5786 5713 5634 105 105 40 sky130_fd_sc_hd__a211o_2
* cell instance $12202 m0 *1 53.82,204
X$12202 105 5785 5784 5714 4939 5904 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $12204 m0 *1 57.04,204
X$12204 105 5746 5787 5907 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12207 m0 *1 59.8,204
X$12207 105 4939 5547 5714 5906 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $12208 m0 *1 61.64,204
X$12208 40 2409 5714 5789 5827 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $12209 m0 *1 65.32,204
X$12209 105 5827 2409 4939 5789 40 5787 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $12214 m0 *1 74.52,204
X$12214 40 4898 2409 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12216 m0 *1 82.34,204
X$12216 105 5405 5680 5638 5597 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $12220 m0 *1 90.62,204
X$12220 40 5681 2532 5753 5790 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $12221 m0 *1 99.82,204
X$12221 40 5832 5864 5365 5834 5791 3803 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $12227 m0 *1 114.54,204
X$12227 40 9523 5866 3171 105 5645 105 40 sky130_fd_sc_hd__ha_1
* cell instance $12228 m0 *1 119.14,204
X$12228 105 5792 5643 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $12229 m0 *1 120.52,204
X$12229 105 5838 5755 5642 40 105 5837 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12231 m0 *1 122.82,204
X$12231 105 5722 5644 5721 40 105 5912 40 sky130_fd_sc_hd__a21o_1
* cell instance $12232 m0 *1 125.58,204
X$12232 105 5870 5792 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $12233 m0 *1 126.96,204
X$12233 40 5868 5758 6072 5558 5839 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $12234 m0 *1 135.24,204
X$12234 105 5794 40 5485 105 40 sky130_fd_sc_hd__buf_2
* cell instance $12236 m0 *1 138,204
X$12236 105 5530 5795 5840 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12239 m0 *1 140.76,204
X$12239 105 5530 5487 5796 105 5841 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $12240 m0 *1 143.98,204
X$12240 105 5842 5873 40 105 3989 40 sky130_fd_sc_hd__or2_4
* cell instance $12241 m0 *1 147.2,204
X$12241 40 9531 5723 3171 105 5764 105 40 sky130_fd_sc_hd__ha_1
* cell instance $12242 m0 *1 151.8,204
X$12242 40 5797 5844 5793 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $12243 m0 *1 156.86,204
X$12243 40 5995 5798 3171 4495 5846 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $12244 m0 *1 164.68,204
X$12244 105 5686 5764 6176 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12248 m0 *1 167.9,204
X$12248 40 5272 6026 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $12249 m0 *1 175.26,204
X$12249 105 3355 5417 5923 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12253 m0 *1 184.92,204
X$12253 40 3173 3021 5925 5726 3678 5492 3286 105 105 40 sky130_fd_sc_hd__mux4_2
* cell instance $12260 m0 *1 198.26,204
X$12260 105 3400 5881 5855 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12262 m0 *1 203.32,204
X$12262 105 5175 5854 5704 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $12264 m0 *1 206.08,204
X$12264 105 4452 40 105 5425 40 sky130_fd_sc_hd__inv_4
* cell instance $12265 m0 *1 208.38,204
X$12265 105 5851 5341 3586 40 105 5853 40 sky130_fd_sc_hd__a21boi_0
* cell instance $12266 m0 *1 211.14,204
X$12266 105 5800 105 40 5245 40 sky130_fd_sc_hd__buf_4
* cell instance $12268 m0 *1 214.82,204
X$12268 40 4452 5728 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12269 m0 *1 218.96,204
X$12269 105 5425 4243 5656 105 5851 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12273 m0 *1 222.64,204
X$12273 40 5425 5801 5765 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $12274 m0 *1 230,204
X$12274 105 5769 5850 5849 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12275 m0 *1 231.38,204
X$12275 40 5306 5848 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $12276 m0 *1 236.9,204
X$12276 105 5306 40 105 5656 40 sky130_fd_sc_hd__inv_4
* cell instance $12279 m0 *1 240.58,204
X$12279 40 5765 5921 3207 5427 3441 5885 105 105 40 sky130_fd_sc_hd__a32oi_2
* cell instance $12286 m0 *1 254.84,204
X$12286 105 5735 5803 5845 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12288 m0 *1 256.68,204
X$12288 105 5804 5805 3309 40 105 5803 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12290 m0 *1 259.44,204
X$12290 105 5806 5602 5759 40 105 5804 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12292 m0 *1 262.2,204
X$12292 105 5806 5808 5807 105 40 5684 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12294 m0 *1 264.96,204
X$12294 105 5810 5699 5171 5384 5807 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $12295 m0 *1 267.26,204
X$12295 105 5805 6037 5810 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12298 m0 *1 270.94,204
X$12298 105 2831 105 40 4717 40 sky130_fd_sc_hd__inv_1
* cell instance $12301 m0 *1 274.62,204
X$12301 105 4800 40 5353 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $12303 m0 *1 277.84,204
X$12303 40 5897 5836 5835 5353 5172 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $12304 m0 *1 282.44,204
X$12304 105 5279 4948 5811 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12306 m0 *1 284.28,204
X$12306 40 5854 5814 5574 3938 5812 5813 5602 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12307 m0 *1 293.94,204
X$12307 40 5981 1775 5814 5735 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $12308 m0 *1 302.22,204
X$12308 105 3150 5493 5980 3702 105 5826 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $12311 m0 *1 306.36,204
X$12311 105 5353 5824 5823 4838 40 105 5903 40 sky130_fd_sc_hd__a31oi_1
* cell instance $12313 m0 *1 310.5,204
X$12313 40 5202 6461 4038 3866 3028 4047 5158 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12317 m0 *1 326.14,204
X$12317 105 4852 5205 5898 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12320 m0 *1 328.9,204
X$12320 105 5268 5817 5818 105 40 5891 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12323 m0 *1 333.04,204
X$12323 40 5816 5574 5282 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $12326 m0 *1 338.56,204
X$12326 40 5281 2474 5280 5891 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $12327 r0 *1 1.38,204
X$12327 105 5888 5856 5773 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $12328 r0 *1 3.68,204
X$12328 105 5856 6003 5623 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $12329 r0 *1 6.9,204
X$12329 105 5774 5889 5579 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12333 r0 *1 11.5,204
X$12333 105 5819 5741 5859 105 40 5858 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12334 r0 *1 13.34,204
X$12334 105 5774 5395 5775 105 40 5931 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12338 r0 *1 16.56,204
X$12338 105 5742 5857 5890 105 5389 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $12339 r0 *1 19.78,204
X$12339 105 5741 5860 5819 5859 105 5893 40 40 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $12341 r0 *1 23.92,204
X$12341 105 5895 5896 5857 5780 5858 105 5894 40 40 sky130_fd_sc_hd__a311oi_1
* cell instance $12342 r0 *1 27.14,204
X$12342 40 5779 5900 5899 5863 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $12343 r0 *1 31.28,204
X$12343 105 5746 5821 5899 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12344 r0 *1 32.66,204
X$12344 105 5860 5862 5821 5900 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $12346 r0 *1 35.42,204
X$12346 40 5324 5631 5861 5931 5977 105 105 40 sky130_fd_sc_hd__nor4_2
* cell instance $12348 r0 *1 40.94,204
X$12348 105 5713 105 40 5546 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $12351 r0 *1 43.24,204
X$12351 40 5935 5901 5902 5863 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $12353 r0 *1 47.38,204
X$12353 105 5785 5784 5712 105 5786 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12355 r0 *1 49.68,204
X$12355 105 5544 5860 5862 5825 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $12358 r0 *1 52.9,204
X$12358 105 5546 5904 5905 40 105 5979 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12359 r0 *1 54.74,204
X$12359 105 5860 5862 5787 5905 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $12361 r0 *1 57.04,204
X$12361 105 5715 5907 5906 40 105 6056 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12363 r0 *1 59.8,204
X$12363 105 5863 40 5715 105 40 sky130_fd_sc_hd__buf_2
* cell instance $12365 r0 *1 62.1,204
X$12365 40 5863 5908 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12373 r0 *1 80.04,204
X$12373 40 5909 5517 5908 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $12377 r0 *1 90.16,204
X$12377 40 5828 5829 5230 5865 105 5864 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $12381 r0 *1 99.36,204
X$12381 40 5639 5940 2251 5942 5830 5833 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $12382 r0 *1 109.02,204
X$12382 105 5126 5865 105 40 40 sky130_fd_sc_hd__inv_6
* cell instance $12384 r0 *1 114.08,204
X$12384 105 5866 5945 5985 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12385 r0 *1 115.46,204
X$12385 105 5866 5867 5911 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12386 r0 *1 116.84,204
X$12386 105 5722 5868 5945 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12387 r0 *1 118.22,204
X$12387 105 5722 5837 5867 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12388 r0 *1 119.6,204
X$12388 105 5915 5912 5869 40 105 5987 40 sky130_fd_sc_hd__a21o_1
* cell instance $12389 r0 *1 122.36,204
X$12389 105 5868 5722 5989 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $12392 r0 *1 126.04,204
X$12392 40 5916 5913 5915 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $12393 r0 *1 132.02,204
X$12393 105 5871 5870 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $12394 r0 *1 133.4,204
X$12394 105 3559 5871 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $12395 r0 *1 134.78,204
X$12395 105 5842 5946 40 105 4517 40 sky130_fd_sc_hd__or2_4
* cell instance $12396 r0 *1 138,204
X$12396 40 5844 5842 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12398 r0 *1 142.6,204
X$12398 105 5646 5917 5918 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12399 r0 *1 143.98,204
X$12399 40 5843 5872 5873 5874 105 5875 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $12400 r0 *1 148.58,204
X$12400 40 5995 5875 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $12403 r0 *1 153.64,204
X$12403 105 5842 5872 40 105 4016 40 sky130_fd_sc_hd__or2_4
* cell instance $12404 r0 *1 156.86,204
X$12404 40 5798 5875 3171 105 5878 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $12405 r0 *1 163.3,204
X$12405 40 5846 5876 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $12406 r0 *1 167.9,204
X$12406 40 5996 5798 5424 105 5877 105 40 sky130_fd_sc_hd__ha_1
* cell instance $12407 r0 *1 172.5,204
X$12407 105 5998 5885 5879 5923 40 5922 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $12408 r0 *1 175.26,204
X$12408 105 5922 5879 5799 40 105 6000 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12414 r0 *1 183.54,204
X$12414 40 5953 5767 5419 5879 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $12416 r0 *1 190.44,204
X$12416 40 5880 2089 5925 5495 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $12418 r0 *1 202.4,204
X$12418 105 5999 5926 5610 105 5770 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $12421 r0 *1 206.08,204
X$12421 105 5927 5882 5853 5769 5926 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $12424 r0 *1 209.3,204
X$12424 105 5800 105 40 6354 40 sky130_fd_sc_hd__buf_4
* cell instance $12425 r0 *1 212.06,204
X$12425 40 5797 3778 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12426 r0 *1 216.2,204
X$12426 40 40 5802 105 5426 5425 105 sky130_fd_sc_hd__nor2_2
* cell instance $12429 r0 *1 219.88,204
X$12429 40 5727 5701 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $12430 r0 *1 227.24,204
X$12430 40 5769 5767 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12431 r0 *1 231.38,204
X$12431 105 5765 40 105 5881 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12433 r0 *1 234.6,204
X$12433 105 5341 5417 5994 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12435 r0 *1 236.44,204
X$12435 105 5306 40 5801 105 40 sky130_fd_sc_hd__buf_2
* cell instance $12437 r0 *1 238.74,204
X$12437 105 5427 40 105 5992 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12438 r0 *1 241.96,204
X$12438 40 5924 5883 5921 5983 5346 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $12439 r0 *1 249.78,204
X$12439 105 5765 40 105 6282 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12443 r0 *1 256.22,204
X$12443 105 5806 5920 5991 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12444 r0 *1 257.6,204
X$12444 105 5735 5990 5991 105 40 5613 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12447 r0 *1 259.9,204
X$12447 105 5806 5884 5808 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12451 r0 *1 264.04,204
X$12451 105 5919 5882 5523 5885 5986 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $12452 r0 *1 266.34,204
X$12452 105 4396 4110 5960 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12455 r0 *1 270.48,204
X$12455 40 3024 5914 6043 6068 5962 4308 105 105 40 sky130_fd_sc_hd__o32ai_4
* cell instance $12457 r0 *1 284.28,204
X$12457 40 2887 6226 5965 5735 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $12464 r0 *1 294.86,204
X$12464 105 5279 4685 5886 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12466 r0 *1 297.16,204
X$12466 40 5966 5353 5815 5886 4618 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $12468 r0 *1 302.22,204
X$12468 105 5910 5649 5826 40 105 5161 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12470 r0 *1 305.9,204
X$12470 40 5701 5978 5658 5747 5594 5595 5610 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12478 r0 *1 320.62,204
X$12478 105 5903 5887 5268 105 40 5968 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12479 r0 *1 322.46,204
X$12479 105 5662 5205 5887 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12481 r0 *1 324.76,204
X$12481 105 5268 5898 5737 105 40 5974 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12483 r0 *1 327.06,204
X$12483 105 5268 5975 5897 105 40 5892 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12485 r0 *1 330.74,204
X$12485 40 5281 4393 5280 5892 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $12488 r0 *1 342.24,204
X$12488 40 5973 5498 4851 4388 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $12519 m0 *1 3.22,209.44
X$12519 105 5778 6002 5928 105 5888 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12520 m0 *1 5.06,209.44
X$12520 105 6002 5928 5778 5774 40 5856 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $12522 m0 *1 7.82,209.44
X$12522 105 5930 5929 5928 40 105 6046 40 sky130_fd_sc_hd__a21o_1
* cell instance $12525 m0 *1 16.1,209.44
X$12525 105 5819 5859 5860 5741 5890 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $12526 m0 *1 18.86,209.44
X$12526 40 40 5742 105 5777 5778 105 sky130_fd_sc_hd__nor2_2
* cell instance $12527 m0 *1 21.16,209.44
X$12527 40 5863 5741 6090 5932 5859 5819 105 105 40 sky130_fd_sc_hd__o2111a_2
* cell instance $12528 m0 *1 25.76,209.44
X$12528 105 5930 5932 5860 5862 105 5895 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $12533 m0 *1 31.74,209.44
X$12533 105 6006 5933 5396 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12534 m0 *1 33.12,209.44
X$12534 40 5504 5861 5631 6006 5933 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $12535 m0 *1 37.72,209.44
X$12535 40 6007 6008 5934 5631 6009 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $12536 m0 *1 45.54,209.44
X$12536 40 6006 5545 5863 6129 6011 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $12537 m0 *1 50.14,209.44
X$12537 40 40 5862 5545 5860 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $12538 m0 *1 52.44,209.44
X$12538 105 6056 5979 5633 105 5977 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12543 m0 *1 57.96,209.44
X$12543 40 5713 5934 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12545 m0 *1 63.02,209.44
X$12545 40 5788 6301 6058 5934 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $12548 m0 *1 68.54,209.44
X$12548 105 5936 5908 5937 6014 105 40 5443 40 sky130_fd_sc_hd__o31ai_1
* cell instance $12550 m0 *1 71.76,209.44
X$12550 105 5938 6059 5936 6060 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $12551 m0 *1 73.6,209.44
X$12551 105 5715 6252 6061 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12553 m0 *1 75.44,209.44
X$12553 40 6095 5908 6062 5446 6064 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $12555 m0 *1 80.96,209.44
X$12555 105 6063 5934 6020 105 5552 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12560 m0 *1 86.48,209.44
X$12560 40 5681 5555 5600 105 5791 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $12562 m0 *1 92.92,209.44
X$12562 40 5940 5865 5230 5828 5829 105 105 40 sky130_fd_sc_hd__o211a_4
* cell instance $12563 m0 *1 99.36,209.44
X$12563 105 5942 6067 5790 105 6065 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12565 m0 *1 103.04,209.44
X$12565 40 5790 6067 5944 5942 105 5984 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $12571 m0 *1 115.46,209.44
X$12571 105 5915 5911 6070 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12572 m0 *1 116.84,209.44
X$12572 105 5988 5915 5946 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $12573 m0 *1 120.06,209.44
X$12573 40 5915 6022 5869 5558 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $12574 m0 *1 129.26,209.44
X$12574 105 5757 5915 5869 40 105 6227 40 sky130_fd_sc_hd__a21o_1
* cell instance $12575 m0 *1 132.02,209.44
X$12575 40 5916 5608 4521 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $12578 m0 *1 140.76,209.44
X$12578 105 5948 6073 5611 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12579 m0 *1 142.14,209.44
X$12579 105 5795 5530 5873 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $12580 m0 *1 145.36,209.44
X$12580 40 9533 5948 3171 105 5949 105 40 sky130_fd_sc_hd__ha_1
* cell instance $12581 m0 *1 149.96,209.44
X$12581 40 6233 5950 6025 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $12582 m0 *1 155.94,209.44
X$12582 40 5876 5878 5844 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $12585 m0 *1 167.44,209.44
X$12585 40 5996 5947 3171 5696 105 105 40 sky130_fd_sc_hd__and3_4
* cell instance $12587 m0 *1 172.04,209.44
X$12587 40 5998 5951 5641 5565 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $12588 m0 *1 175.72,209.44
X$12588 40 5952 5951 3214 5461 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $12589 m0 *1 179.4,209.44
X$12589 105 5490 6080 5952 105 40 5700 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12593 m0 *1 184.46,209.44
X$12593 40 6028 6029 3021 5852 6054 5879 105 105 40 sky130_fd_sc_hd__a32oi_2
* cell instance $12594 m0 *1 190.44,209.44
X$12594 40 5686 6030 6083 4110 3851 105 105 40 sky130_fd_sc_hd__o22a_2
* cell instance $12597 m0 *1 195.04,209.44
X$12597 105 3173 5954 3286 5802 105 6001 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $12598 m0 *1 197.8,209.44
X$12598 105 5656 6001 6030 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12601 m0 *1 200.56,209.44
X$12601 105 5426 6084 3396 5802 40 5999 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $12603 m0 *1 204.24,209.44
X$12603 40 5997 5956 3396 3586 5955 3212 5963 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12604 m0 *1 213.9,209.44
X$12604 40 1853 6087 5956 5568 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $12605 m0 *1 219.88,209.44
X$12605 105 5727 105 40 5957 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $12608 m0 *1 222.64,209.44
X$12608 40 5957 5766 5656 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $12609 m0 *1 226.78,209.44
X$12609 105 5769 5656 5882 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12610 m0 *1 228.16,209.44
X$12610 105 5765 40 105 6082 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12614 m0 *1 237.36,209.44
X$12614 40 3361 6326 5924 2835 5994 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $12616 m0 *1 246.1,209.44
X$12616 40 40 6077 105 5341 3027 105 sky130_fd_sc_hd__nor2_2
* cell instance $12620 m0 *1 250.24,209.44
X$12620 40 6790 3357 5993 3647 5992 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $12622 m0 *1 256.68,209.44
X$12622 105 5735 6075 5990 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12623 m0 *1 258.06,209.44
X$12623 105 4393 3168 5961 5958 105 5884 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $12624 m0 *1 260.82,209.44
X$12624 105 5767 6184 4393 5802 40 5959 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $12625 m0 *1 264.04,209.44
X$12625 105 5986 6027 5959 40 105 6036 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12626 m0 *1 265.88,209.44
X$12626 105 6036 5960 6276 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12627 m0 *1 267.26,209.44
X$12627 40 5919 6037 5961 5158 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $12629 m0 *1 271.86,209.44
X$12629 105 6069 6038 6043 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12630 m0 *1 273.24,209.44
X$12630 40 6068 2955 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12632 m0 *1 277.84,209.44
X$12632 40 5962 5914 6043 3024 4308 2100 105 105 40 sky130_fd_sc_hd__o32a_4
* cell instance $12633 m0 *1 286.12,209.44
X$12633 40 5963 5981 5982 2836 6044 3310 5491 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12635 m0 *1 296.7,209.44
X$12635 40 5964 5461 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $12640 m0 *1 310.96,209.44
X$12640 40 6369 4038 6053 5964 5967 5492 3028 105 105 40 sky130_fd_sc_hd__mux4_2
* cell instance $12643 m0 *1 324.76,209.44
X$12643 105 5268 5976 5966 105 40 6051 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12644 m0 *1 326.6,209.44
X$12644 105 5498 5205 5976 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12646 m0 *1 328.44,209.44
X$12646 105 4393 5205 5975 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12650 m0 *1 333.04,209.44
X$12650 40 5281 4852 5280 5974 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $12652 m0 *1 344.54,209.44
X$12652 105 5972 5971 105 5969 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $12659 r0 *1 5.52,209.44
X$12659 40 6003 5775 6123 6046 105 105 40 sky130_fd_sc_hd__a21boi_2
* cell instance $12660 r0 *1 9.66,209.44
X$12660 105 6091 6124 6047 105 5471 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12661 r0 *1 12.42,209.44
X$12661 105 5819 5859 5932 5741 6049 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $12664 r0 *1 15.64,209.44
X$12664 40 40 5774 105 6049 6050 105 sky130_fd_sc_hd__nor2_2
* cell instance $12665 r0 *1 17.94,209.44
X$12665 40 6090 5859 5713 5741 5932 5819 105 105 40 sky130_fd_sc_hd__o2111ai_4
* cell instance $12666 r0 *1 27.6,209.44
X$12666 105 6005 6004 6125 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12668 r0 *1 29.9,209.44
X$12668 40 6126 5255 5715 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $12670 r0 *1 35.88,209.44
X$12670 105 5546 6007 6127 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12671 r0 *1 37.26,209.44
X$12671 40 5781 6007 6008 5713 6009 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $12673 r0 *1 41.4,209.44
X$12673 105 5547 6128 6010 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12677 r0 *1 43.7,209.44
X$12677 40 5933 5547 5546 6010 6011 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $12678 r0 *1 48.3,209.44
X$12678 105 5544 5508 5716 105 6128 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12679 r0 *1 50.14,209.44
X$12679 105 5508 5712 6011 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $12680 r0 *1 52.44,209.44
X$12680 40 6012 6055 5547 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $12682 r0 *1 63.48,209.44
X$12682 40 6057 6012 6131 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $12683 r0 *1 67.62,209.44
X$12683 105 5938 5936 6059 105 6013 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12686 r0 *1 70.84,209.44
X$12686 40 6061 5258 6013 5715 6060 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $12689 r0 *1 80.04,209.44
X$12689 105 6015 6016 5909 105 6097 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12691 r0 *1 83.26,209.44
X$12691 105 6015 5909 6016 6098 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $12692 r0 *1 85.1,209.44
X$12692 105 6259 6019 6018 6017 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $12693 r0 *1 86.94,209.44
X$12693 40 3803 6132 5555 5864 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $12695 r0 *1 93.84,209.44
X$12695 105 6017 5084 5126 6261 40 6344 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $12697 r0 *1 96.14,209.44
X$12697 105 3803 5719 5941 6021 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $12699 r0 *1 98.44,209.44
X$12699 105 6066 6100 6263 6133 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $12700 r0 *1 100.74,209.44
X$12700 105 2251 5940 5833 105 6067 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12701 r0 *1 103.5,209.44
X$12701 105 5940 5833 6021 40 6134 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $12704 r0 *1 112.24,209.44
X$12704 40 9552 6023 3171 105 6022 105 40 sky130_fd_sc_hd__ha_1
* cell instance $12706 r0 *1 117.76,209.44
X$12706 105 6023 6070 6138 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12707 r0 *1 119.14,209.44
X$12707 105 5911 40 105 5988 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12708 r0 *1 122.36,209.44
X$12708 105 5757 40 105 5913 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12712 r0 *1 126.96,209.44
X$12712 105 5686 40 105 5839 40 sky130_fd_sc_hd__inv_2
* cell instance $12713 r0 *1 128.34,209.44
X$12713 40 5989 6071 6141 5793 6072 105 105 40 sky130_fd_sc_hd__and4b_1
* cell instance $12714 r0 *1 132.02,209.44
X$12714 40 5947 5608 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $12715 r0 *1 139.38,209.44
X$12715 105 5688 5794 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $12717 r0 *1 141.22,209.44
X$12717 105 5842 5843 40 105 4255 40 sky130_fd_sc_hd__or2_4
* cell instance $12719 r0 *1 145.36,209.44
X$12719 40 6074 6148 5558 105 5949 105 40 sky130_fd_sc_hd__ha_1
* cell instance $12720 r0 *1 149.96,209.44
X$12720 105 6105 6074 5872 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $12723 r0 *1 153.64,209.44
X$12723 105 6148 6025 5950 105 40 5796 40 sky130_fd_sc_hd__o21bai_1
* cell instance $12725 r0 *1 157.32,209.44
X$12725 40 5947 6076 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $12726 r0 *1 164.68,209.44
X$12726 40 5793 3736 5947 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $12727 r0 *1 169.74,209.44
X$12727 105 5696 40 105 6078 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12728 r0 *1 172.96,209.44
X$12728 105 6026 40 105 6149 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12735 r0 *1 185.38,209.44
X$12735 40 6026 6081 3678 6028 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $12736 r0 *1 190.9,209.44
X$12736 105 6027 6029 6109 105 40 6083 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12737 r0 *1 192.74,209.44
X$12737 105 5953 5341 6031 40 105 6109 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12742 r0 *1 201.48,209.44
X$12742 40 6084 5955 3212 6086 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $12750 r0 *1 216.66,209.44
X$12750 105 5727 105 40 6086 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $12752 r0 *1 220.34,209.44
X$12752 105 6032 6085 6034 105 5949 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $12754 r0 *1 224.48,209.44
X$12754 105 5766 40 105 6146 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $12755 r0 *1 227.7,209.44
X$12755 40 6034 3357 3397 6033 3048 5994 105 105 40 sky130_fd_sc_hd__a221oi_1
* cell instance $12758 r0 *1 231.84,209.44
X$12758 40 6181 3359 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12760 r0 *1 236.44,209.44
X$12760 105 3397 3168 3157 5958 40 6144 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $12762 r0 *1 240.12,209.44
X$12762 40 5800 3138 3049 6079 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $12763 r0 *1 245.64,209.44
X$12763 40 5767 6142 6143 6077 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $12764 r0 *1 251.62,209.44
X$12764 40 5800 6302 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $12765 r0 *1 257.14,209.44
X$12765 40 6075 2968 5733 6035 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $12767 r0 *1 261.28,209.44
X$12767 105 3140 4765 6137 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12773 r0 *1 267.26,209.44
X$12773 105 5341 3865 5656 105 6115 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12775 r0 *1 270.94,209.44
X$12775 105 2831 4461 6039 6040 105 6069 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $12777 r0 *1 274.16,209.44
X$12777 105 5649 6041 5962 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12778 r0 *1 275.54,209.44
X$12778 105 2673 3695 6447 5809 105 6038 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $12780 r0 *1 278.76,209.44
X$12780 40 6042 5964 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $12786 r0 *1 291.64,209.44
X$12786 40 5490 5649 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $12790 r0 *1 306.82,209.44
X$12790 40 2889 6219 5649 6053 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $12794 r0 *1 314.18,209.44
X$12794 40 6214 5978 5437 6054 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $12799 r0 *1 322,209.44
X$12799 40 5281 5662 6052 5968 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $12801 r0 *1 334.42,209.44
X$12801 40 5281 5498 6048 6051 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $12806 r0 *1 346.84,209.44
X$12806 105 6045 40 105 6738 40 sky130_fd_sc_hd__inv_2
* cell instance $12834 m0 *1 1.38,214.88
X$12834 105 6099 6088 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $12838 m0 *1 5.98,214.88
X$12838 105 6089 5930 5929 40 105 5889 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12839 m0 *1 7.82,214.88
X$12839 105 6090 5928 5929 6123 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $12840 m0 *1 9.66,214.88
X$12840 105 6092 6091 6124 6047 105 40 5633 40 sky130_fd_sc_hd__o211a_2
* cell instance $12841 m0 *1 13.34,214.88
X$12841 40 6089 6049 6047 6092 5930 6093 105 105 40 sky130_fd_sc_hd__a41oi_1
* cell instance $12842 m0 *1 16.56,214.88
X$12842 40 6090 6153 6093 5395 6208 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $12845 m0 *1 25.76,214.88
X$12845 105 6004 6005 105 6126 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $12848 m0 *1 29.9,214.88
X$12848 40 6248 6094 6460 6157 6213 105 105 40 sky130_fd_sc_hd__nor4_2
* cell instance $12851 m0 *1 35.88,214.88
X$12851 105 5934 5632 5711 40 105 5861 40 sky130_fd_sc_hd__a21o_1
* cell instance $12853 m0 *1 39.1,214.88
X$12853 40 5397 6127 6009 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $12855 m0 *1 45.54,214.88
X$12855 105 5785 5784 6128 105 6129 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12856 m0 *1 47.38,214.88
X$12856 40 6055 6216 5784 1760 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $12857 m0 *1 52.9,214.88
X$12857 105 5862 105 40 5784 40 sky130_fd_sc_hd__inv_1
* cell instance $12859 m0 *1 55.2,214.88
X$12859 105 6012 40 105 6217 40 sky130_fd_sc_hd__inv_2
* cell instance $12862 m0 *1 57.5,214.88
X$12862 40 6055 6012 5746 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $12864 m0 *1 64.4,214.88
X$12864 105 6159 6013 6160 105 6131 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12865 m0 *1 67.16,214.88
X$12865 40 6161 6253 6059 2251 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $12866 m0 *1 76.36,214.88
X$12866 105 6162 6097 6096 105 6095 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12867 m0 *1 79.12,214.88
X$12867 105 6162 6096 6097 6062 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $12868 m0 *1 80.96,214.88
X$12868 105 6097 6098 5934 40 6063 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $12870 m0 *1 84.64,214.88
X$12870 105 5908 6258 6064 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12871 m0 *1 90.62,214.88
X$12871 40 40 6260 105 5126 5084 105 sky130_fd_sc_hd__nor2_2
* cell instance $12872 m0 *1 92.92,214.88
X$12872 40 6166 6065 6100 2251 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $12873 m0 *1 102.12,214.88
X$12873 40 3879 6099 6167 6101 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $12875 m0 *1 112.24,214.88
X$12875 40 6101 6024 6099 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $12877 m0 *1 116.84,214.88
X$12877 105 5915 5985 6102 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12878 m0 *1 118.22,214.88
X$12878 105 6102 6023 6168 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12882 m0 *1 122.82,214.88
X$12882 105 6103 6138 6139 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12884 m0 *1 124.66,214.88
X$12884 40 6228 5987 6103 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $12887 m0 *1 132.02,214.88
X$12887 105 6074 6171 6073 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12888 m0 *1 133.4,214.88
X$12888 40 5844 6267 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12890 m0 *1 138,214.88
X$12890 105 6074 105 40 6025 40 sky130_fd_sc_hd__inv_1
* cell instance $12892 m0 *1 139.84,214.88
X$12892 105 5842 6072 40 105 4188 40 sky130_fd_sc_hd__or2_4
* cell instance $12893 m0 *1 143.06,214.88
X$12893 105 6147 105 40 6173 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $12894 m0 *1 144.9,214.88
X$12894 105 6025 5948 6104 105 5795 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $12896 m0 *1 149.04,214.88
X$12896 40 5488 6148 6025 6232 105 105 40 sky130_fd_sc_hd__o21bai_2
* cell instance $12898 m0 *1 153.64,214.88
X$12898 40 6233 5608 4012 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $12899 m0 *1 161,214.88
X$12899 105 6176 6107 6177 6629 105 5877 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $12900 m0 *1 163.3,214.88
X$12900 105 6235 6106 5949 6178 40 6107 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $12907 m0 *1 172.5,214.88
X$12907 105 6000 6108 6106 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12909 m0 *1 177.56,214.88
X$12909 105 3281 4110 6108 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12910 m0 *1 178.94,214.88
X$12910 105 5490 6179 3402 6080 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $12913 m0 *1 184.92,214.88
X$12913 40 6110 5880 6031 3851 6081 4988 5964 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12918 m0 *1 201.02,214.88
X$12918 40 5954 6111 5769 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $12922 m0 *1 214.36,214.88
X$12922 105 3543 5698 5341 105 6242 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12923 m0 *1 216.2,214.88
X$12923 40 6180 6111 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $12926 m0 *1 222.64,214.88
X$12926 40 2825 6409 6144 5491 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $12927 m0 *1 228.62,214.88
X$12927 40 40 5958 105 6112 3360 105 sky130_fd_sc_hd__nor2_2
* cell instance $12928 m0 *1 230.92,214.88
X$12928 40 6145 5491 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $12930 m0 *1 241.04,214.88
X$12930 40 5885 6027 6079 5883 6142 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $12933 m0 *1 250.24,214.88
X$12933 40 4683 6182 6114 6113 6183 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $12934 m0 *1 254.84,214.88
X$12934 40 6110 5492 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $12935 m0 *1 258.98,214.88
X$12935 40 6140 6237 5610 5662 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $12937 m0 *1 262.2,214.88
X$12937 105 6236 5954 4394 5802 40 6135 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $12938 m0 *1 265.42,214.88
X$12938 105 6035 6112 4314 40 105 6136 40 sky130_fd_sc_hd__a21oi_1
* cell instance $12939 m0 *1 267.26,214.88
X$12939 105 5879 4314 6115 105 6234 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $12943 m0 *1 272.32,214.88
X$12943 105 3159 4765 6187 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12944 m0 *1 273.7,214.88
X$12944 40 6230 4124 2673 6027 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $12947 m0 *1 278.3,214.88
X$12947 40 5568 5495 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $12948 m0 *1 285.66,214.88
X$12948 40 5701 6117 6044 5982 5812 5813 5610 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12949 m0 *1 295.32,214.88
X$12949 40 6130 6117 5752 5885 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $12950 m0 *1 299.46,214.88
X$12950 105 6118 6191 6116 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12952 m0 *1 301.3,214.88
X$12952 40 6190 4467 6119 5963 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $12955 m0 *1 305.9,214.88
X$12955 40 6218 3091 5965 5854 6300 5384 2474 105 105 40 sky130_fd_sc_hd__mux4_2
* cell instance $12956 m0 *1 314.18,214.88
X$12956 40 5202 6211 3091 3095 2474 4467 5158 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $12960 m0 *1 329.82,214.88
X$12960 105 6206 6196 6195 40 105 6122 40 sky130_fd_sc_hd__a21o_1
* cell instance $12963 m0 *1 333.96,214.88
X$12963 105 6205 40 105 6203 40 sky130_fd_sc_hd__inv_2
* cell instance $12964 m0 *1 335.34,214.88
X$12964 40 9509 6203 6198 6120 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $12966 m0 *1 345,214.88
X$12966 40 6121 6197 6199 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $12968 r0 *1 3.22,214.88
X$12968 105 6152 6150 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $12969 r0 *1 4.6,214.88
X$12969 105 6375 5778 6202 105 5857 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12970 r0 *1 7.36,214.88
X$12970 105 6151 6204 6202 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $12971 r0 *1 8.74,214.88
X$12971 40 5932 6151 6204 6243 6244 105 105 40 sky130_fd_sc_hd__o22a_2
* cell instance $12974 r0 *1 13.8,214.88
X$12974 105 6093 6047 6288 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12978 r0 *1 16.1,214.88
X$12978 40 5932 5859 6153 5741 5860 5819 105 105 40 sky130_fd_sc_hd__o2111ai_4
* cell instance $12979 r0 *1 25.76,214.88
X$12979 105 6153 6210 6125 40 5627 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $12980 r0 *1 28.98,214.88
X$12980 105 6155 6247 6154 105 40 6005 40 sky130_fd_sc_hd__o21ai_1
* cell instance $12981 r0 *1 30.82,214.88
X$12981 40 6156 6004 6008 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $12982 r0 *1 36.8,214.88
X$12982 40 6007 6158 5544 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $12985 r0 *1 43.24,214.88
X$12985 40 6158 5716 6251 6156 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $12986 r0 *1 49.22,214.88
X$12986 105 6463 6377 6155 40 105 6294 40 sky130_fd_sc_hd__a21o_1
* cell instance $12988 r0 *1 52.9,214.88
X$12988 40 6158 6216 6055 6217 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $12990 r0 *1 59.34,214.88
X$12990 105 5908 6253 6014 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $12991 r0 *1 60.72,214.88
X$12991 40 6159 6057 1986 105 6058 105 40 sky130_fd_sc_hd__ha_1
* cell instance $12993 r0 *1 65.78,214.88
X$12993 105 6159 6160 6013 6299 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $12994 r0 *1 67.62,214.88
X$12994 105 5909 6055 6159 6304 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $12998 r0 *1 70.84,214.88
X$12998 105 6161 6095 6220 105 5936 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $12999 r0 *1 73.6,214.88
X$12999 105 6161 6015 5938 6162 105 6163 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $13001 r0 *1 76.36,214.88
X$13001 40 6162 6220 2532 105 6258 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13003 r0 *1 81.42,214.88
X$13003 40 6015 6020 6096 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $13004 r0 *1 90.62,214.88
X$13004 40 6019 6164 2803 105 6132 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13006 r0 *1 95.68,214.88
X$13006 105 6164 6263 6100 6165 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $13009 r0 *1 98.44,214.88
X$13009 40 6133 6261 6165 6166 6100 6265 105 105 40 sky130_fd_sc_hd__o221a_4
* cell instance $13011 r0 *1 107.64,214.88
X$13011 40 3879 6152 6167 6222 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $13013 r0 *1 117.76,214.88
X$13013 105 6312 105 40 6103 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $13014 r0 *1 119.6,214.88
X$13014 105 6227 6103 6225 40 105 6169 40 sky130_fd_sc_hd__a21o_1
* cell instance $13015 r0 *1 122.36,214.88
X$13015 105 6168 40 105 6170 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13018 r0 *1 126.04,214.88
X$13018 105 6170 6103 6071 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13020 r0 *1 129.72,214.88
X$13020 40 5647 6228 4518 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $13022 r0 *1 137.54,214.88
X$13022 40 9557 6172 3171 105 6106 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13023 r0 *1 142.14,214.88
X$13023 105 6173 6478 6316 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13024 r0 *1 143.52,214.88
X$13024 105 6171 40 105 6105 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13025 r0 *1 146.74,214.88
X$13025 105 6172 6173 6231 105 40 6104 40 sky130_fd_sc_hd__o21bai_1
* cell instance $13027 r0 *1 149.96,214.88
X$13027 105 6174 6175 6173 105 6232 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13030 r0 *1 153.64,214.88
X$13030 40 6147 6175 5558 105 6106 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13032 r0 *1 159.16,214.88
X$13032 40 5202 6320 4661 3741 3334 3768 5158 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13042 r0 *1 192.28,214.88
X$13042 105 5964 40 6179 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $13043 r0 *1 195.04,214.88
X$13043 40 1379 6239 6328 3741 3079 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $13045 r0 *1 201.94,214.88
X$13045 105 6111 40 105 6330 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13051 r0 *1 208.84,214.88
X$13051 105 3334 3168 6240 5958 105 6327 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $13055 r0 *1 216.66,214.88
X$13055 105 5727 105 40 6180 40 sky130_fd_sc_hd__buf_4
* cell instance $13056 r0 *1 219.42,214.88
X$13056 105 6242 5885 6272 40 105 6033 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13058 r0 *1 221.72,214.88
X$13058 40 6356 4197 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $13059 r0 *1 230.92,214.88
X$13059 40 3697 5384 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13063 r0 *1 236.44,214.88
X$13063 105 6241 40 105 6325 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13064 r0 *1 239.66,214.88
X$13064 105 6241 40 105 6183 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13065 r0 *1 242.88,214.88
X$13065 40 40 5729 6323 5426 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $13066 r0 *1 245.18,214.88
X$13066 40 6180 6140 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $13067 r0 *1 254.38,214.88
X$13067 40 6238 6114 5993 6274 6137 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $13072 r0 *1 264.04,214.88
X$13072 105 4394 6035 5699 6136 40 105 6277 40 sky130_fd_sc_hd__a31oi_1
* cell instance $13074 r0 *1 266.8,214.88
X$13074 105 6027 6135 6186 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13075 r0 *1 268.18,214.88
X$13075 105 6054 6234 6476 105 6185 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $13076 r0 *1 270.02,214.88
X$13076 105 6186 6187 6185 105 6224 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13079 r0 *1 275.54,214.88
X$13079 105 6179 6229 5914 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13081 r0 *1 277.84,214.88
X$13081 105 6188 6189 5805 4124 105 6041 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $13082 r0 *1 280.6,214.88
X$13082 105 6363 5831 6223 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13083 r0 *1 281.98,214.88
X$13083 105 6190 5806 5568 6116 40 6226 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $13084 r0 *1 284.74,214.88
X$13084 40 2096 6223 6309 5347 3079 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $13088 r0 *1 292.1,214.88
X$13088 105 6191 40 105 5748 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13089 r0 *1 295.32,214.88
X$13089 40 6221 6305 3712 4203 5145 4532 5879 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13092 r0 *1 306.36,214.88
X$13092 40 6219 5649 6382 6179 6215 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $13094 r0 *1 311.88,214.88
X$13094 40 6215 4047 6303 5492 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $13100 r0 *1 319.24,214.88
X$13100 105 6515 6212 6192 40 105 6296 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13102 r0 *1 321.54,214.88
X$13102 40 6284 4608 6193 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $13105 r0 *1 327.06,214.88
X$13105 105 6207 5740 6194 40 105 6196 40 sky130_fd_sc_hd__a21o_1
* cell instance $13106 r0 *1 329.82,214.88
X$13106 105 6371 6209 6286 105 6609 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13107 r0 *1 333.04,214.88
X$13107 105 6196 6206 105 6284 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $13109 r0 *1 337.18,214.88
X$13109 40 6289 6200 5970 6201 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $13112 r0 *1 346.84,214.88
X$13112 105 6198 40 105 6287 40 sky130_fd_sc_hd__inv_2
* cell instance $13142 m0 *1 5.98,220.32
X$13142 40 6151 5777 6204 6243 6244 105 105 40 sky130_fd_sc_hd__o22ai_2
* cell instance $13144 m0 *1 11.5,220.32
X$13144 105 6288 6151 6245 5778 105 6091 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $13145 m0 *1 14.72,220.32
X$13145 105 6093 6246 5930 105 6124 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13147 m0 *1 19.32,220.32
X$13147 40 6291 5859 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13148 m0 *1 23.46,220.32
X$13148 40 5930 6247 6154 6334 6248 6249 105 105 40 sky130_fd_sc_hd__o221a_1
* cell instance $13149 m0 *1 27.6,220.32
X$13149 105 5860 6210 6050 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13151 m0 *1 29.44,220.32
X$13151 40 6155 6248 6247 5778 6154 6249 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $13153 m0 *1 40.94,220.32
X$13153 40 6250 5632 6009 6294 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $13154 m0 *1 43.24,220.32
X$13154 40 6336 6009 6338 6255 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $13155 m0 *1 51.52,220.32
X$13155 40 6155 6339 6298 105 5785 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $13157 m0 *1 57.04,220.32
X$13157 105 6379 6464 6298 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13160 m0 *1 61.18,220.32
X$13160 105 6131 6299 6301 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13161 m0 *1 62.56,220.32
X$13161 40 5938 6160 1988 105 6252 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13163 m0 *1 67.62,220.32
X$13163 105 6254 6256 6255 105 6253 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13164 m0 *1 70.38,220.32
X$13164 105 2409 6163 6304 6379 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13166 m0 *1 72.68,220.32
X$13166 105 6536 6341 6257 105 6340 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13167 m0 *1 75.44,220.32
X$13167 105 6161 6220 6095 5937 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13174 m0 *1 90.62,220.32
X$13174 105 6019 6018 6259 105 6261 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13176 m0 *1 94.3,220.32
X$13176 40 6260 6384 6308 6262 105 105 6383 40 sky130_fd_sc_hd__or4b_1
* cell instance $13178 m0 *1 98.44,220.32
X$13178 105 6066 6261 6164 105 6262 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13180 m0 *1 102.12,220.32
X$13180 40 6385 6100 6264 6260 105 6311 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $13183 m0 *1 112.24,220.32
X$13183 40 6222 6387 6152 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13186 m0 *1 118.68,220.32
X$13186 40 6312 6225 5558 105 6313 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13188 m0 *1 123.74,220.32
X$13188 105 6103 6168 6314 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13190 m0 *1 126.04,220.32
X$13190 105 6103 5987 6225 40 105 6389 40 sky130_fd_sc_hd__a21o_1
* cell instance $13193 m0 *1 131.56,220.32
X$13193 105 6267 6071 40 105 4515 40 sky130_fd_sc_hd__or2_4
* cell instance $13194 m0 *1 134.78,220.32
X$13194 105 6267 6266 40 105 4805 40 sky130_fd_sc_hd__or2_4
* cell instance $13195 m0 *1 138,220.32
X$13195 105 6172 6316 6171 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13197 m0 *1 139.84,220.32
X$13197 105 5989 6267 40 105 4361 40 sky130_fd_sc_hd__or2_4
* cell instance $13198 m0 *1 143.06,220.32
X$13198 105 6267 6317 40 105 4017 40 sky130_fd_sc_hd__or2_4
* cell instance $13199 m0 *1 146.28,220.32
X$13199 105 6318 6269 6268 105 6231 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13200 m0 *1 149.5,220.32
X$13200 105 6173 6175 6393 105 5950 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13202 m0 *1 153.18,220.32
X$13202 40 6270 5608 3926 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $13203 m0 *1 160.54,220.32
X$13203 40 9526 6269 3171 105 6319 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13207 m0 *1 167.9,220.32
X$13207 40 6319 6396 6321 5885 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13210 m0 *1 174.8,220.32
X$13210 105 3460 5417 6557 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13212 m0 *1 177.1,220.32
X$13212 40 6024 6322 6351 5805 3514 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $13214 m0 *1 185.38,220.32
X$13214 105 6324 3284 6189 40 105 6400 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13220 m0 *1 197.8,220.32
X$13220 105 6329 5964 6327 40 105 6328 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13226 m0 *1 212.98,220.32
X$13226 105 4907 6278 6332 5656 6406 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $13227 m0 *1 215.74,220.32
X$13227 105 6140 40 105 6408 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13228 m0 *1 218.96,220.32
X$13228 40 6032 3504 6331 6271 6273 105 105 40 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $13231 m0 *1 223.56,220.32
X$13231 40 5426 5769 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13232 m0 *1 227.7,220.32
X$13232 105 5729 5426 40 6241 105 40 sky130_fd_sc_hd__and2_4
* cell instance $13234 m0 *1 231.38,220.32
X$13234 40 6241 6181 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13236 m0 *1 236.44,220.32
X$13236 40 6241 6326 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13237 m0 *1 240.58,220.32
X$13237 105 5729 40 105 6403 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13240 m0 *1 245.18,220.32
X$13240 40 5885 6402 6237 6238 6633 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $13243 m0 *1 252.08,220.32
X$13243 40 6297 6143 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $13244 m0 *1 256.68,220.32
X$13244 40 6359 4033 6179 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $13245 m0 *1 260.82,220.32
X$13245 40 5384 6275 6112 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $13246 m0 *1 264.96,220.32
X$13246 40 6324 4034 5490 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $13247 m0 *1 269.1,220.32
X$13247 105 6140 5767 6278 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $13248 m0 *1 271.4,220.32
X$13248 105 5767 6281 4717 40 105 6279 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13250 m0 *1 274.16,220.32
X$13250 105 6230 6278 6315 5879 6280 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $13253 m0 *1 277.84,220.32
X$13253 105 6188 6282 6390 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13254 m0 *1 279.22,220.32
X$13254 105 6283 40 6281 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $13255 m0 *1 281.98,220.32
X$13255 105 6283 40 105 6221 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13256 m0 *1 285.2,220.32
X$13256 40 6111 5158 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $13257 m0 *1 292.56,220.32
X$13257 105 6310 5495 6307 40 105 6309 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13259 m0 *1 294.86,220.32
X$13259 40 6042 6364 5145 3712 6367 6306 5492 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13264 m0 *1 307.74,220.32
X$13264 40 6302 6295 6119 6118 6300 6218 6297 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13265 m0 *1 317.4,220.32
X$13265 40 6448 6211 6295 6201 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $13266 m0 *1 322.92,220.32
X$13266 105 6293 105 40 6286 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $13268 m0 *1 325.22,220.32
X$13268 40 6285 6292 105 4273 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $13270 m0 *1 333.04,220.32
X$13270 40 6290 6195 6200 105 6214 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13271 m0 *1 337.64,220.32
X$13271 105 6290 105 40 6206 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $13273 m0 *1 339.94,220.32
X$13273 40 5281 4851 6048 5973 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $13276 r0 *1 5.06,220.32
X$13276 105 6244 6243 6375 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13277 r0 *1 6.44,220.32
X$13277 105 6151 6333 6376 40 105 6002 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13279 r0 *1 10.12,220.32
X$13279 105 6333 6376 6151 40 105 5929 40 sky130_fd_sc_hd__a21o_1
* cell instance $13285 r0 *1 15.64,220.32
X$13285 40 40 6246 105 6245 6151 105 sky130_fd_sc_hd__nor2_2
* cell instance $13288 r0 *1 20.24,220.32
X$13288 105 6093 6246 6412 6090 105 6208 40 40 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $13290 r0 *1 23.92,220.32
X$13290 40 6247 6154 6334 6249 6248 6090 105 105 40 sky130_fd_sc_hd__o221a_4
* cell instance $13291 r0 *1 31.28,220.32
X$13291 105 6249 6248 6210 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13293 r0 *1 34.5,220.32
X$13293 40 6335 6154 6156 6336 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $13297 r0 *1 43.24,220.32
X$13297 105 6337 6335 6377 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13299 r0 *1 45.54,220.32
X$13299 40 6334 6155 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $13300 r0 *1 54.74,220.32
X$13300 40 6255 6339 6298 5860 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $13302 r0 *1 60.72,220.32
X$13302 40 6334 6255 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $13303 r0 *1 66.24,220.32
X$13303 40 6058 6465 6378 6255 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13307 r0 *1 70.84,220.32
X$13307 105 6340 6381 6255 40 6254 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $13310 r0 *1 75.44,220.32
X$13310 40 6341 6343 6538 6258 6342 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $13311 r0 *1 80.04,220.32
X$13311 40 6343 6020 6425 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $13313 r0 *1 87.86,220.32
X$13313 40 6132 6470 6344 6265 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $13316 r0 *1 96.14,220.32
X$13316 105 6100 6166 6263 40 105 6383 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13318 r0 *1 98.44,220.32
X$13318 40 6066 6263 2532 105 6386 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13320 r0 *1 103.5,220.32
X$13320 105 6166 6263 6262 6385 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $13321 r0 *1 105.8,220.32
X$13321 105 6263 6166 6262 105 40 6264 40 sky130_fd_sc_hd__o21ai_1
* cell instance $13322 r0 *1 107.64,220.32
X$13322 105 5834 6134 6386 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13323 r0 *1 109.02,220.32
X$13323 105 6260 6265 5944 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13327 r0 *1 116.84,220.32
X$13327 40 9563 6345 3171 105 6313 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13329 r0 *1 121.9,220.32
X$13329 105 6345 6139 6428 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13332 r0 *1 123.28,220.32
X$13332 105 6345 6314 6346 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13335 r0 *1 126.04,220.32
X$13335 105 6347 6346 6474 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13336 r0 *1 127.42,220.32
X$13336 40 6477 6169 6347 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $13337 r0 *1 133.4,220.32
X$13337 40 5947 5647 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $13339 r0 *1 141.22,220.32
X$13339 105 6269 6348 6478 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13340 r0 *1 142.6,220.32
X$13340 105 6267 6392 40 105 4098 40 sky130_fd_sc_hd__or2_4
* cell instance $13341 r0 *1 145.82,220.32
X$13341 105 6231 6173 6317 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13343 r0 *1 149.96,220.32
X$13343 105 6174 40 105 6349 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13347 r0 *1 153.64,220.32
X$13347 40 6270 6349 6173 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $13348 r0 *1 159.62,220.32
X$13348 40 6505 6394 5558 105 6319 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13349 r0 *1 164.22,220.32
X$13349 40 6448 6320 6350 6022 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $13351 r0 *1 170.2,220.32
X$13351 40 6429 6829 5535 6054 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13352 r0 *1 174.34,220.32
X$13352 105 6397 5879 6398 40 105 5847 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13353 r0 *1 176.18,220.32
X$13353 40 6313 5459 6399 6054 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $13358 r0 *1 181.24,220.32
X$13358 40 5649 6351 6352 4233 6400 6179 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $13362 r0 *1 198.72,220.32
X$13362 40 6330 6404 5413 5176 6353 6387 5767 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13368 r0 *1 211.6,220.32
X$13368 105 6027 6404 6355 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13369 r0 *1 212.98,220.32
X$13369 105 6355 6407 6406 105 6178 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13370 r0 *1 216.2,220.32
X$13370 105 5239 4110 6407 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13373 r0 *1 220.34,220.32
X$13373 40 6559 6357 6482 6409 6275 6112 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $13375 r0 *1 230.92,220.32
X$13375 105 6182 40 105 6273 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13380 r0 *1 236.44,220.32
X$13380 105 6325 40 105 6405 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13381 r0 *1 239.66,220.32
X$13381 105 6403 40 105 6402 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13384 r0 *1 244.26,220.32
X$13384 40 5735 5662 6401 6442 6827 5573 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $13385 r0 *1 253.92,220.32
X$13385 40 6358 5854 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $13390 r0 *1 264.04,220.32
X$13390 105 5997 40 6035 105 40 sky130_fd_sc_hd__buf_2
* cell instance $13391 r0 *1 265.88,220.32
X$13391 105 6359 6395 6322 40 105 6229 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13392 r0 *1 267.72,220.32
X$13392 105 6275 6360 5685 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13394 r0 *1 270.94,220.32
X$13394 105 4308 4110 6446 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13395 r0 *1 272.32,220.32
X$13395 105 6279 5656 6039 40 105 6315 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13397 r0 *1 275.08,220.32
X$13397 105 6280 6448 6361 40 105 6473 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13398 r0 *1 276.92,220.32
X$13398 105 5656 6471 6390 105 6361 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $13399 r0 *1 278.76,220.32
X$13399 105 6391 5568 6362 40 105 5453 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13400 r0 *1 280.6,220.32
X$13400 40 6026 6027 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13402 r0 *1 285.66,220.32
X$13402 40 5495 6388 6364 2369 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $13406 r0 *1 291.64,220.32
X$13406 105 5498 5493 6365 3702 105 6307 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $13407 r0 *1 294.4,220.32
X$13407 105 6189 6468 5490 6324 40 5910 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $13409 r0 *1 297.62,220.32
X$13409 40 5963 6388 6366 4203 6467 4532 5964 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13411 r0 *1 307.74,220.32
X$13411 105 6368 5748 6382 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13412 r0 *1 309.12,220.32
X$13412 40 6380 6462 6303 6368 5967 6369 6281 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13416 r0 *1 319.24,220.32
X$13416 40 5969 6193 105 4864 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $13417 r0 *1 326.6,220.32
X$13417 40 6293 6209 6200 105 6370 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13418 r0 *1 331.2,220.32
X$13418 105 6371 6286 105 6285 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $13420 r0 *1 334.88,220.32
X$13420 105 6289 40 105 5971 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13422 r0 *1 339.02,220.32
X$13422 105 6373 6456 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $13425 r0 *1 340.4,220.32
X$13425 40 6200 6120 105 105 40 sky130_fd_sc_hd__clkinv_8
* cell instance $13427 r0 *1 346.84,220.32
X$13427 40 40 6372 105 6374 6672 105 sky130_fd_sc_hd__nor2_2
* cell instance $13442 m0 *1 5.06,225.76
X$13442 105 6410 6455 6457 105 6244 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13443 m0 *1 7.82,225.76
X$13443 105 6457 6455 6410 6243 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13444 m0 *1 9.66,225.76
X$13444 40 6204 6376 6412 6411 6413 6458 105 105 40 sky130_fd_sc_hd__o2111a_1
* cell instance $13445 m0 *1 13.8,225.76
X$13445 105 6412 6413 6458 105 6333 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13446 m0 *1 16.56,225.76
X$13446 105 6521 105 40 6151 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $13447 m0 *1 18.4,225.76
X$13447 105 6334 6488 6489 6414 40 105 6291 40 sky130_fd_sc_hd__and4_1
* cell instance $13449 m0 *1 22.08,225.76
X$13449 40 6004 6677 6337 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $13452 m0 *1 29.44,225.76
X$13452 40 6415 6460 6094 6247 6157 6526 105 105 40 sky130_fd_sc_hd__o32ai_4
* cell instance $13453 m0 *1 39.56,225.76
X$13453 105 5712 6338 6158 6415 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13454 m0 *1 41.4,225.76
X$13454 40 6251 5544 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13455 m0 *1 45.54,225.76
X$13455 105 6213 6416 6463 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13456 m0 *1 46.92,225.76
X$13456 105 6335 6416 6418 6155 6250 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $13458 m0 *1 51.52,225.76
X$13458 105 6417 6379 6419 105 40 6339 40 sky130_fd_sc_hd__o21ai_1
* cell instance $13459 m0 *1 53.36,225.76
X$13459 105 6338 5712 6464 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13464 m0 *1 65.32,225.76
X$13464 105 6571 6420 6465 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13465 m0 *1 66.7,225.76
X$13465 105 6422 6496 6421 6420 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13466 m0 *1 68.54,225.76
X$13466 105 6421 6343 6423 6466 105 40 6252 40 sky130_fd_sc_hd__o31ai_1
* cell instance $13467 m0 *1 71.3,225.76
X$13467 40 6536 6537 6256 105 2532 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13469 m0 *1 76.36,225.76
X$13469 105 6343 6424 6342 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13476 m0 *1 92.46,225.76
X$13476 40 6260 6259 6469 6265 105 105 40 sky130_fd_sc_hd__nand3b_4
* cell instance $13477 m0 *1 99.82,225.76
X$13477 105 6066 6164 6261 6308 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13478 m0 *1 101.66,225.76
X$13478 40 6426 6542 6134 5834 6265 6260 105 105 40 sky130_fd_sc_hd__a221oi_2
* cell instance $13484 m0 *1 117.76,225.76
X$13484 105 6545 105 40 6347 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $13485 m0 *1 119.6,225.76
X$13485 40 9524 6427 3171 105 6429 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13486 m0 *1 124.2,225.76
X$13486 105 6427 6347 6428 105 40 6472 40 sky130_fd_sc_hd__o21bai_1
* cell instance $13487 m0 *1 126.96,225.76
X$13487 105 6547 6347 6266 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13488 m0 *1 130.18,225.76
X$13488 40 5647 6477 4831 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $13490 m0 *1 138,225.76
X$13490 105 6430 6692 6552 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13493 m0 *1 140.76,225.76
X$13493 40 5647 6431 4020 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $13494 m0 *1 148.12,225.76
X$13494 105 6479 6505 6392 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13496 m0 *1 151.8,225.76
X$13496 40 6431 6432 6268 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $13497 m0 *1 157.78,225.76
X$13497 105 6394 6268 6432 105 40 6393 40 sky130_fd_sc_hd__o21bai_1
* cell instance $13500 m0 *1 161.92,225.76
X$13500 105 6022 6429 6319 6313 40 6177 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $13504 m0 *1 167.44,225.76
X$13504 40 5565 6398 4656 3332 3061 3329 5767 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13505 m0 *1 177.1,225.76
X$13505 40 5767 6448 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13506 m0 *1 181.24,225.76
X$13506 105 3513 5493 6434 3702 105 6433 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $13508 m0 *1 184.46,225.76
X$13508 105 3768 5418 6483 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13509 m0 *1 185.84,225.76
X$13509 105 5127 5493 6436 3702 105 6437 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $13510 m0 *1 188.6,225.76
X$13510 105 6558 5735 6433 40 105 5421 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13511 m0 *1 190.44,225.76
X$13511 105 5649 6885 6437 105 4723 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13514 m0 *1 195.04,225.76
X$13514 105 6275 6483 6964 105 40 6239 40 sky130_fd_sc_hd__o21ai_1
* cell instance $13516 m0 *1 197.34,225.76
X$13516 40 5767 6054 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $13517 m0 *1 202.4,225.76
X$13517 105 5413 5493 6387 3702 105 6438 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $13521 m0 *1 213.44,225.76
X$13521 105 6706 5735 6438 40 105 5569 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13524 m0 *1 216.66,225.76
X$13524 105 6448 6484 6332 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13526 m0 *1 218.5,225.76
X$13526 105 6439 3360 3504 40 105 6357 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13527 m0 *1 220.34,225.76
X$13527 105 5854 3137 7721 40 105 6439 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13530 m0 *1 223.1,225.76
X$13530 105 3558 40 105 6358 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13531 m0 *1 226.32,225.76
X$13531 40 5769 5885 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13532 m0 *1 230.46,225.76
X$13532 105 3543 6440 6482 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13533 m0 *1 231.84,225.76
X$13533 40 5418 4903 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $13534 m0 *1 239.2,225.76
X$13534 105 5694 6441 3050 6449 40 5572 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $13535 m0 *1 242.42,225.76
X$13535 105 6112 3137 105 6322 40 40 sky130_fd_sc_hd__and2_2
* cell instance $13536 m0 *1 245.18,225.76
X$13536 40 6401 5735 6481 5339 6480 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $13539 m0 *1 250.7,225.76
X$13539 40 6035 6275 6441 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $13541 m0 *1 258.52,225.76
X$13541 40 6360 6443 6444 6035 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $13543 m0 *1 262.66,225.76
X$13543 40 6184 6444 6443 5701 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13545 m0 *1 267.26,225.76
X$13545 105 6027 6445 6506 5885 6476 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $13547 m0 *1 271.86,225.76
X$13547 105 6475 40 105 4601 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13548 m0 *1 275.08,225.76
X$13548 40 40 6508 105 6473 6446 105 sky130_fd_sc_hd__nor2_2
* cell instance $13550 m0 *1 277.84,225.76
X$13550 40 6471 6395 6447 5158 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $13551 m0 *1 281.52,225.76
X$13551 105 6026 40 105 6283 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13554 m0 *1 286.12,225.76
X$13554 40 6111 5879 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $13555 m0 *1 293.48,225.76
X$13555 40 6111 6539 6467 6366 6367 6306 6027 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13558 m0 *1 305.44,225.76
X$13558 40 6450 6539 6305 6448 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13559 m0 *1 309.58,225.76
X$13559 40 6535 6534 5506 5885 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13560 m0 *1 313.72,225.76
X$13560 40 6451 5144 6532 6448 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $13561 m0 *1 317.86,225.76
X$13561 40 6370 6462 6461 6054 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13562 m0 *1 322,225.76
X$13562 105 6452 6206 6195 40 105 6371 40 sky130_fd_sc_hd__a21o_1
* cell instance $13563 m0 *1 324.76,225.76
X$13563 40 6453 6292 105 4553 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $13566 m0 *1 333.04,225.76
X$13566 105 6209 6286 6122 40 105 6459 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13568 m0 *1 335.34,225.76
X$13568 40 9548 6121 6120 105 6201 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13569 m0 *1 339.94,225.76
X$13569 40 6045 6200 6518 6454 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $13570 r0 *1 1.38,225.76
X$13570 105 6486 6485 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $13574 r0 *1 5.98,225.76
X$13574 105 6460 6457 6519 40 105 5928 40 sky130_fd_sc_hd__a21o_1
* cell instance $13575 r0 *1 8.74,225.76
X$13575 105 6520 6094 6455 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13577 r0 *1 11.96,225.76
X$13577 105 6487 6522 6092 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13580 r0 *1 15.64,225.76
X$13580 105 6565 6523 6521 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $13581 r0 *1 17.94,225.76
X$13581 40 6334 6488 6489 5819 6414 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $13585 r0 *1 31.74,225.76
X$13585 40 6094 6343 6157 6460 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $13586 r0 *1 37.72,225.76
X$13586 105 6338 6156 40 6526 105 40 sky130_fd_sc_hd__and2_4
* cell instance $13587 r0 *1 40.94,225.76
X$13587 105 5544 6093 6529 6568 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $13590 r0 *1 43.24,225.76
X$13590 40 40 6337 105 6569 6567 105 sky130_fd_sc_hd__nor2_2
* cell instance $13591 r0 *1 45.54,225.76
X$13591 105 5712 6158 6416 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $13592 r0 *1 47.84,225.76
X$13592 105 5544 6530 6490 40 105 6417 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13593 r0 *1 49.68,225.76
X$13593 40 6530 6419 5544 6490 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $13594 r0 *1 51.98,225.76
X$13594 105 6491 6493 6492 105 6570 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13595 r0 *1 54.74,225.76
X$13595 105 6491 6493 6492 6615 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13597 r0 *1 57.04,225.76
X$13597 105 6492 6494 6614 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13598 r0 *1 58.42,225.76
X$13598 105 6531 6571 6495 105 6492 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13599 r0 *1 61.18,225.76
X$13599 40 6422 6495 1988 105 6378 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13600 r0 *1 65.78,225.76
X$13600 40 6497 6496 2251 105 6572 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13604 r0 *1 71.76,225.76
X$13604 105 6497 6537 6340 6423 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13605 r0 *1 73.6,225.76
X$13605 105 6536 6257 6341 6381 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13607 r0 *1 76.36,225.76
X$13607 105 6498 6540 6425 105 6341 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13608 r0 *1 79.12,225.76
X$13608 105 6498 6425 6540 6538 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13613 r0 *1 88.78,225.76
X$13613 40 6574 6499 6575 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $13616 r0 *1 98.44,225.76
X$13616 40 6384 6619 5944 6386 105 105 40 sky130_fd_sc_hd__a21bo_1
* cell instance $13617 r0 *1 102.12,225.76
X$13617 105 6470 6499 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $13620 r0 *1 108.1,225.76
X$13620 40 3879 6486 6167 6621 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $13622 r0 *1 118.22,225.76
X$13622 105 5946 6500 6266 6141 105 6430 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $13623 r0 *1 120.52,225.76
X$13623 40 6545 6501 5558 105 6429 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13627 r0 *1 126.04,225.76
X$13627 105 6428 40 105 6547 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13628 r0 *1 129.26,225.76
X$13628 105 6169 6501 6347 105 6548 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13629 r0 *1 132.48,225.76
X$13629 105 6347 6501 6389 105 6550 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13631 r0 *1 136.16,225.76
X$13631 105 6503 6502 6504 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13632 r0 *1 137.54,225.76
X$13632 40 6551 4747 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13633 r0 *1 141.68,225.76
X$13633 105 6317 6392 6581 6552 40 105 5874 40 sky130_fd_sc_hd__and4_1
* cell instance $13635 r0 *1 145.82,225.76
X$13635 40 6626 5179 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13636 r0 *1 149.96,225.76
X$13636 105 6504 40 105 6479 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13639 r0 *1 153.64,225.76
X$13639 40 6174 6394 6268 6553 105 105 40 sky130_fd_sc_hd__o21bai_2
* cell instance $13640 r0 *1 157.78,225.76
X$13640 105 6505 105 40 6268 40 sky130_fd_sc_hd__inv_1
* cell instance $13644 r0 *1 167.44,225.76
X$13644 40 5202 5610 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13647 r0 *1 173.88,225.76
X$13647 105 6630 6448 5879 6557 40 6397 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $13665 r0 *1 214.36,225.76
X$13665 40 6560 6040 5652 6353 6449 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $13666 r0 *1 218.96,225.76
X$13666 40 5854 6731 3048 105 6559 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $13669 r0 *1 225.4,225.76
X$13669 105 3627 6440 40 5454 105 40 sky130_fd_sc_hd__and2_4
* cell instance $13674 r0 *1 236.44,225.76
X$13674 105 3665 40 6191 105 40 sky130_fd_sc_hd__buf_2
* cell instance $13676 r0 *1 241.96,225.76
X$13676 105 6359 5997 40 5418 105 40 sky130_fd_sc_hd__and2_4
* cell instance $13677 r0 *1 245.18,225.76
X$13677 40 6442 2979 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $13678 r0 *1 252.54,225.76
X$13678 40 6480 4683 6589 6110 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $13679 r0 *1 256.22,225.76
X$13679 105 6282 40 105 6631 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13682 r0 *1 260.36,225.76
X$13682 105 5418 40 105 5364 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13685 r0 *1 264.5,225.76
X$13685 40 6445 6556 6555 6140 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $13687 r0 *1 269.1,225.76
X$13687 105 6027 5879 6554 6506 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $13689 r0 *1 271.4,225.76
X$13689 40 6507 6475 6120 4874 6510 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $13690 r0 *1 279.22,225.76
X$13690 40 6509 6511 5603 6596 6449 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $13691 r0 *1 283.82,225.76
X$13691 105 4852 5493 6600 3702 105 6362 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $13693 r0 *1 286.58,225.76
X$13693 40 6599 6549 5450 6054 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13696 r0 *1 291.64,225.76
X$13696 105 6189 6546 5495 6324 40 6310 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $13697 r0 *1 294.4,225.76
X$13697 105 6189 6512 5735 6324 40 5599 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $13698 r0 *1 297.16,225.76
X$13698 105 6201 6543 6130 6370 40 6544 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $13701 r0 *1 300.84,225.76
X$13701 40 5701 6534 6512 6513 6541 5596 5610 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13703 r0 *1 310.96,225.76
X$13703 105 6302 40 105 6380 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13705 r0 *1 314.18,225.76
X$13705 40 6533 6515 6200 105 6535 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13707 r0 *1 319.24,225.76
X$13707 105 6516 6514 6286 105 40 6613 40 sky130_fd_sc_hd__o21bai_1
* cell instance $13708 r0 *1 322,225.76
X$13708 40 6212 6527 6528 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $13709 r0 *1 327.98,225.76
X$13709 40 6524 6459 6525 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $13711 r0 *1 334.88,225.76
X$13711 40 6207 6451 6194 6200 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $13713 r0 *1 344.08,225.76
X$13713 105 6456 6517 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $13716 r0 *1 346.84,225.76
X$13716 105 6517 40 6205 105 40 sky130_fd_sc_hd__buf_2
* cell instance $13747 m0 *1 4.14,231.2
X$13747 105 6561 6673 6674 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13748 m0 *1 5.52,231.2
X$13748 105 6674 6520 6675 40 105 6003 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13750 m0 *1 8.28,231.2
X$13750 105 6562 6561 6457 6460 40 6519 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $13752 m0 *1 11.5,231.2
X$13752 105 6522 6640 6563 105 40 6376 40 sky130_fd_sc_hd__a21boi_1
* cell instance $13754 m0 *1 14.72,231.2
X$13754 40 6564 6565 6562 105 6334 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $13755 m0 *1 21.16,231.2
X$13755 40 6489 5716 6337 6968 6565 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $13760 m0 *1 31.28,231.2
X$13760 105 6611 6643 6644 6563 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $13763 m0 *1 35.88,231.2
X$13763 105 6612 6568 6213 105 6488 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13764 m0 *1 38.64,231.2
X$13764 105 6566 6093 6529 6567 6569 105 6612 40 40 sky130_fd_sc_hd__o2111ai_1
* cell instance $13765 m0 *1 41.86,231.2
X$13765 105 6567 6569 6213 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $13766 m0 *1 44.16,231.2
X$13766 105 6213 6645 6418 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13767 m0 *1 47.38,231.2
X$13767 40 40 6490 6336 6530 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $13768 m0 *1 49.68,231.2
X$13768 40 6491 6679 1760 105 6336 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13769 m0 *1 54.28,231.2
X$13769 40 40 6338 105 6570 6615 105 sky130_fd_sc_hd__nor2_2
* cell instance $13771 m0 *1 57.04,231.2
X$13771 40 6646 5862 6614 6334 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $13773 m0 *1 65.78,231.2
X$13773 105 6422 6421 6496 105 6571 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13775 m0 *1 69,231.2
X$13775 105 6343 6572 6466 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13777 m0 *1 70.84,231.2
X$13777 105 6497 6340 6537 105 6421 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13778 m0 *1 73.6,231.2
X$13778 40 6498 6424 6257 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $13783 m0 *1 85.56,231.2
X$13783 105 6469 105 40 6682 40 sky130_fd_sc_hd__inv_1
* cell instance $13785 m0 *1 90.62,231.2
X$13785 105 6650 6649 6748 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13788 m0 *1 93.38,231.2
X$13788 105 6616 6574 6575 105 6684 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $13790 m0 *1 96.6,231.2
X$13790 40 6616 6651 2251 105 6619 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13797 m0 *1 112.24,231.2
X$13797 40 6621 6688 6486 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13799 m0 *1 117.3,231.2
X$13799 40 40 6577 105 6875 6579 105 sky130_fd_sc_hd__nor2_2
* cell instance $13800 m0 *1 119.6,231.2
X$13800 105 6576 6622 6472 105 6655 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13801 m0 *1 122.82,231.2
X$13801 105 6623 6624 6500 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13802 m0 *1 126.04,231.2
X$13802 40 6578 6625 6576 6548 105 105 40 sky130_fd_sc_hd__o21bai_2
* cell instance $13804 m0 *1 130.64,231.2
X$13804 105 5844 6500 6551 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $13805 m0 *1 132.94,231.2
X$13805 105 5844 6656 6582 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $13806 m0 *1 135.24,231.2
X$13806 40 6580 4906 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13808 m0 *1 139.84,231.2
X$13808 105 5844 6581 6626 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $13809 m0 *1 142.14,231.2
X$13809 40 6582 4670 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $13810 m0 *1 146.28,231.2
X$13810 105 6583 6627 6581 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13812 m0 *1 149.96,231.2
X$13812 105 6502 6627 6583 105 40 6318 40 sky130_fd_sc_hd__o21bai_1
* cell instance $13814 m0 *1 153.64,231.2
X$13814 40 9532 6502 3171 105 6178 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13815 m0 *1 158.24,231.2
X$13815 105 6505 6504 6348 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13816 m0 *1 159.62,231.2
X$13816 105 6726 6628 6584 6629 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13819 m0 *1 162.84,231.2
X$13819 40 6584 6698 6696 6448 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13822 m0 *1 169.28,231.2
X$13822 105 4656 3623 6585 6511 40 6699 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $13825 m0 *1 175.26,231.2
X$13825 40 6630 6585 6688 6281 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $13829 m0 *1 184.92,231.2
X$13829 40 6330 6698 6701 6632 6586 6436 6027 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13834 m0 *1 198.26,231.2
X$13834 40 5202 6665 5175 3136 5236 5186 5158 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13836 m0 *1 211.6,231.2
X$13836 40 6082 6271 5769 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $13837 m0 *1 215.74,231.2
X$13837 40 6484 6560 6587 5158 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $13841 m0 *1 222.64,231.2
X$13841 40 3697 6440 3558 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $13842 m0 *1 226.78,231.2
X$13842 40 3697 6359 3627 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $13845 m0 *1 236.44,231.2
X$13845 105 6042 40 5339 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $13849 m0 *1 247.02,231.2
X$13849 105 6113 6191 6481 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13853 m0 *1 250.24,231.2
X$13853 105 6054 6588 6633 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13854 m0 *1 251.62,231.2
X$13854 105 6703 6146 6589 6631 105 6588 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $13857 m0 *1 256.68,231.2
X$13857 105 6702 5805 6277 40 105 6590 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13858 m0 *1 258.52,231.2
X$13858 105 5418 40 105 6592 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13859 m0 *1 261.74,231.2
X$13859 40 6591 3865 6590 6700 6555 6592 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $13861 m0 *1 275.08,231.2
X$13861 105 6508 6276 5983 6274 40 6594 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $13863 m0 *1 277.84,231.2
X$13863 105 6595 6756 6695 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13864 m0 *1 281.06,231.2
X$13864 105 6601 6598 6544 6594 105 6593 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $13865 m0 *1 283.36,231.2
X$13865 105 6450 6599 6454 5655 40 6598 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $13866 m0 *1 285.66,231.2
X$13866 105 6120 6597 6668 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13868 m0 *1 287.5,231.2
X$13868 105 6669 6040 6602 5809 105 6363 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $13869 m0 *1 290.26,231.2
X$13869 40 6513 6040 5448 6541 6449 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $13870 m0 *1 294.86,231.2
X$13870 40 6543 6689 5512 6054 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $13873 m0 *1 301.3,231.2
X$13873 105 6533 105 40 6212 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $13874 m0 *1 303.14,231.2
X$13874 105 6671 6670 6603 40 105 6620 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13876 m0 *1 305.44,231.2
X$13876 40 40 6617 105 6206 6618 105 sky130_fd_sc_hd__nor2_2
* cell instance $13877 m0 *1 307.74,231.2
X$13877 40 40 6514 105 6606 6604 105 sky130_fd_sc_hd__nor2_2
* cell instance $13878 m0 *1 310.04,231.2
X$13878 105 6451 6535 6224 6214 40 6601 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $13879 m0 *1 312.34,231.2
X$13879 105 6287 6045 6518 40 105 6605 40 sky130_fd_sc_hd__a21o_1
* cell instance $13880 m0 *1 315.1,231.2
X$13880 105 6605 6289 5970 40 105 6607 40 sky130_fd_sc_hd__a21o_1
* cell instance $13881 m0 *1 317.86,231.2
X$13881 105 6527 6515 6212 105 6678 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13882 m0 *1 321.08,231.2
X$13882 40 6528 6292 105 4266 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $13883 m0 *1 328.44,231.2
X$13883 40 6527 6610 6608 6609 105 105 40 sky130_fd_sc_hd__o21bai_2
* cell instance $13885 m0 *1 333.04,231.2
X$13885 40 9547 6516 6120 105 6370 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13886 m0 *1 337.64,231.2
X$13886 105 6607 6207 105 6453 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $13887 m0 *1 340.86,231.2
X$13887 40 5972 6287 6510 6200 6676 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $13889 r0 *1 2.3,231.2
X$13889 105 6573 6634 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $13890 r0 *1 3.68,231.2
X$13890 105 6635 6636 6457 40 105 6673 40 sky130_fd_sc_hd__a21oi_1
* cell instance $13892 r0 *1 5.98,231.2
X$13892 105 6562 6457 6636 105 6675 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $13894 r0 *1 8.28,231.2
X$13894 105 6638 6637 6636 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13895 r0 *1 9.66,231.2
X$13895 105 6639 6712 6638 6637 6460 105 40 40 sky130_fd_sc_hd__a31o_2
* cell instance $13897 r0 *1 13.34,231.2
X$13897 105 6640 6563 6047 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13904 r0 *1 20.7,231.2
X$13904 40 6677 6564 6565 6562 6641 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $13906 r0 *1 26.22,231.2
X$13906 40 6157 6716 6717 6642 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $13908 r0 *1 33.12,231.2
X$13908 40 6093 6458 6643 6611 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $13910 r0 *1 39.56,231.2
X$13910 105 6645 6644 6529 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13911 r0 *1 40.94,231.2
X$13911 105 5712 6158 6335 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $13915 r0 *1 43.24,231.2
X$13915 105 6645 6566 6641 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13917 r0 *1 47.38,231.2
X$13917 105 6566 105 40 5712 40 sky130_fd_sc_hd__buf_4
* cell instance $13920 r0 *1 51.52,231.2
X$13920 40 6679 6645 6570 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $13922 r0 *1 56.12,231.2
X$13922 40 6531 6493 1986 105 6646 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13925 r0 *1 62.1,231.2
X$13925 105 6531 6495 6571 6494 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13934 r0 *1 74.06,231.2
X$13934 40 6721 6424 6681 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $13938 r0 *1 84.18,231.2
X$13938 105 6647 6648 6747 6811 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $13939 r0 *1 86.02,231.2
X$13939 40 6648 6650 2803 105 6682 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13940 r0 *1 90.62,231.2
X$13940 105 6650 6575 6683 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $13941 r0 *1 92.92,231.2
X$13941 105 6649 6683 6575 6574 6749 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $13943 r0 *1 95.68,231.2
X$13943 105 6651 6650 6575 6652 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $13946 r0 *1 98.44,231.2
X$13946 40 6652 6653 6649 6684 6651 105 105 40 sky130_fd_sc_hd__o22ai_2
* cell instance $13947 r0 *1 103.04,231.2
X$13947 105 6653 6686 6687 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13949 r0 *1 109.94,231.2
X$13949 40 3879 6573 6167 6753 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $13950 r0 *1 119.6,231.2
X$13950 105 5844 6654 6580 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $13951 r0 *1 121.9,231.2
X$13951 105 6690 40 105 6623 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $13955 r0 *1 126.04,231.2
X$13955 40 6691 6550 6576 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $13956 r0 *1 132.02,231.2
X$13956 105 6655 6579 6654 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13957 r0 *1 135.24,231.2
X$13957 105 6878 6579 6655 105 40 6658 40 sky130_fd_sc_hd__o21bai_1
* cell instance $13958 r0 *1 138,231.2
X$13958 105 6656 6654 6692 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $13959 r0 *1 139.38,231.2
X$13959 105 6950 6657 6656 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $13961 r0 *1 143.52,231.2
X$13961 105 6658 6693 6659 105 6583 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13962 r0 *1 146.74,231.2
X$13962 105 6694 6661 6627 105 6553 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13963 r0 *1 149.96,231.2
X$13963 105 6627 6661 6660 105 6432 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $13966 r0 *1 153.64,231.2
X$13966 40 6759 6661 5558 105 6178 105 40 sky130_fd_sc_hd__ha_1
* cell instance $13968 r0 *1 158.7,231.2
X$13968 40 5202 6696 4984 4522 5127 4829 5158 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $13971 r0 *1 171.12,231.2
X$13971 40 6699 6662 3332 4903 6449 3061 105 105 40 sky130_fd_sc_hd__a221oi_2
* cell instance $13979 r0 *1 189.52,231.2
X$13979 40 6632 6040 5312 6586 5809 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $13981 r0 *1 195.04,231.2
X$13981 40 5491 6664 6663 3175 6763 5699 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $13983 r0 *1 204.7,231.2
X$13983 105 3360 105 40 5805 40 sky130_fd_sc_hd__buf_4
* cell instance $13988 r0 *1 212.98,231.2
X$13988 105 6666 6587 5568 6324 40 6706 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $13990 r0 *1 216.2,231.2
X$13990 40 6408 5565 5769 105 6707 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $13992 r0 *1 223.56,231.2
X$13992 40 6667 6705 5769 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $13993 r0 *1 227.7,231.2
X$13993 105 6146 40 105 6667 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14000 r0 *1 238.28,231.2
X$14000 40 3665 6704 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $14005 r0 *1 251.16,231.2
X$14005 105 6440 105 40 6324 40 sky130_fd_sc_hd__buf_4
* cell instance $14008 r0 *1 258.06,231.2
X$14008 40 6054 5232 6758 6454 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $14012 r0 *1 264.5,231.2
X$14012 40 6700 2953 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $14013 r0 *1 268.64,231.2
X$14013 40 6511 6040 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $14014 r0 *1 274.16,231.2
X$14014 40 6507 6597 5655 105 6593 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14016 r0 *1 279.22,231.2
X$14016 40 6302 6549 6697 6509 6596 6600 5610 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $14021 r0 *1 291.64,231.2
X$14021 40 5701 6689 6546 6669 6602 6365 5610 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $14024 r0 *1 303.6,231.2
X$14024 40 9555 6685 6120 105 6224 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14025 r0 *1 308.2,231.2
X$14025 40 6750 6671 6200 105 6224 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14026 r0 *1 312.8,231.2
X$14026 40 9559 6746 6120 105 6535 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14028 r0 *1 317.4,231.2
X$14028 105 6680 105 40 6736 40 sky130_fd_sc_hd__inv_1
* cell instance $14030 r0 *1 319.24,231.2
X$14030 105 6372 6206 6606 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14031 r0 *1 320.62,231.2
X$14031 40 6733 6292 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $14032 r0 *1 329.82,231.2
X$14032 105 6610 6608 6459 105 40 6192 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14033 r0 *1 332.58,231.2
X$14033 40 9553 6604 6120 105 6214 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14035 r0 *1 337.64,231.2
X$14035 40 9554 6672 6120 105 6451 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14038 r0 *1 343.16,231.2
X$14038 105 6454 40 105 6676 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14040 r0 *1 346.84,231.2
X$14040 40 40 6618 105 6923 6672 105 sky130_fd_sc_hd__nor2_2
* cell instance $14069 m0 *1 2.76,236.64
X$14069 40 6709 5741 6710 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $14070 m0 *1 6.9,236.64
X$14070 105 6564 6740 6565 6410 105 6709 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $14071 m0 *1 9.2,236.64
X$14071 105 6635 6711 6520 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14072 m0 *1 10.58,236.64
X$14072 105 6637 6638 6639 6712 6711 105 6411 40 40 sky130_fd_sc_hd__a311oi_1
* cell instance $14074 m0 *1 14.72,236.64
X$14074 105 6714 6742 6713 105 40 6640 40 sky130_fd_sc_hd__o21ai_1
* cell instance $14076 m0 *1 17.48,236.64
X$14076 105 6523 6565 6458 6245 40 6715 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $14078 m0 *1 22.08,236.64
X$14078 105 6642 6717 6716 40 105 6564 40 sky130_fd_sc_hd__a21o_1
* cell instance $14079 m0 *1 24.84,236.64
X$14079 105 6642 6802 6717 105 6457 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14086 m0 *1 38.18,236.64
X$14086 40 6249 6743 6719 6744 6720 105 105 40 sky130_fd_sc_hd__nor4b_4
* cell instance $14087 m0 *1 46.92,236.64
X$14087 105 6569 6567 6641 105 6720 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $14095 m0 *1 63.48,236.64
X$14095 40 6642 6721 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $14097 m0 *1 71.3,236.64
X$14097 40 6780 6721 6722 6256 6867 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $14103 m0 *1 85.56,236.64
X$14103 105 6648 6747 6647 105 6649 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $14106 m0 *1 89.7,236.64
X$14106 105 6748 6574 6723 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14107 m0 *1 92.92,236.64
X$14107 105 6749 6616 105 6751 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $14108 m0 *1 96.14,236.64
X$14108 105 6574 6616 6686 6647 40 105 6752 40 sky130_fd_sc_hd__and4_1
* cell instance $14110 m0 *1 100.28,236.64
X$14110 105 5410 6648 5411 6752 105 6783 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $14112 m0 *1 103.04,236.64
X$14112 105 6686 5865 5410 6813 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $14114 m0 *1 105.34,236.64
X$14114 40 6686 6816 1988 105 6724 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14118 m0 *1 113.16,236.64
X$14118 40 6753 6731 6573 3644 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $14120 m0 *1 118.22,236.64
X$14120 105 6474 6427 6690 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14121 m0 *1 119.6,236.64
X$14121 40 9525 6622 3171 105 6584 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14122 m0 *1 124.2,236.64
X$14122 40 6754 6167 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $14123 m0 *1 133.4,236.64
X$14123 40 6820 6821 5558 105 6628 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14127 m0 *1 139.84,236.64
X$14127 40 6822 6879 6579 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $14128 m0 *1 145.82,236.64
X$14128 105 6627 6824 6503 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14130 m0 *1 147.66,236.64
X$14130 40 6725 6694 6627 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $14131 m0 *1 153.64,236.64
X$14131 105 6759 105 40 6627 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $14132 m0 *1 155.48,236.64
X$14132 40 6076 6725 4986 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $14134 m0 *1 163.76,236.64
X$14134 105 4985 5454 6511 6727 40 6728 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $14136 m0 *1 167.44,236.64
X$14136 40 3623 6785 6728 6663 4826 6449 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $14137 m0 *1 177.1,236.64
X$14137 40 6688 6322 6730 5805 3460 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $14141 m0 *1 184.92,236.64
X$14141 40 5495 6730 6662 3280 6884 5339 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $14143 m0 *1 195.04,236.64
X$14143 40 6729 6666 6664 3360 4982 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $14144 m0 *1 199.64,236.64
X$14144 105 6359 6784 6322 40 105 6763 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14146 m0 *1 203.32,236.64
X$14146 40 5202 6762 5270 3118 5416 4585 5158 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $14147 m0 *1 212.98,236.64
X$14147 40 6726 6762 6832 6448 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $14148 m0 *1 217.12,236.64
X$14148 40 6272 7088 6731 5565 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $14153 m0 *1 223.1,236.64
X$14153 105 3558 3697 105 6666 40 40 sky130_fd_sc_hd__and2_2
* cell instance $14154 m0 *1 225.86,236.64
X$14154 40 6704 6732 6511 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $14157 m0 *1 235.98,236.64
X$14157 105 6322 5339 6830 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $14161 m0 *1 241.5,236.64
X$14161 40 5963 6110 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $14164 m0 *1 247.94,236.64
X$14164 105 5806 6828 6760 105 40 6827 40 sky130_fd_sc_hd__o21ai_1
* cell instance $14167 m0 *1 251.16,236.64
X$14167 40 6760 3647 6703 6110 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $14168 m0 *1 254.84,236.64
X$14168 105 6666 6697 5699 6440 40 6391 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $14169 m0 *1 257.6,236.64
X$14169 105 6666 105 40 6189 40 sky130_fd_sc_hd__buf_4
* cell instance $14171 m0 *1 260.82,236.64
X$14171 105 6666 6112 40 105 6591 40 sky130_fd_sc_hd__nor2b_2
* cell instance $14172 m0 *1 264.04,236.64
X$14172 40 9545 6823 3044 105 6276 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14175 m0 *1 270.94,236.64
X$14175 40 6757 6507 3044 105 6733 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $14178 m0 *1 278.76,236.64
X$14178 40 9544 6755 6120 105 6599 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14180 m0 *1 283.82,236.64
X$14180 40 6872 6193 105 4948 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14181 m0 *1 291.18,236.64
X$14181 40 6734 4455 6733 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $14182 m0 *1 295.32,236.64
X$14182 40 9542 6817 6120 105 6274 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14183 m0 *1 299.92,236.64
X$14183 40 6735 6812 6200 105 6274 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14186 m0 *1 305.44,236.64
X$14186 40 6810 6292 105 4758 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14187 m0 *1 312.8,236.64
X$14187 40 6670 6745 6734 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $14188 m0 *1 318.78,236.64
X$14188 40 6524 6733 105 4458 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14189 m0 *1 326.14,236.64
X$14189 40 6525 6610 6200 105 6508 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14190 m0 *1 330.74,236.64
X$14190 105 5983 105 40 6799 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $14192 m0 *1 333.04,236.64
X$14192 105 6525 105 40 6608 40 sky130_fd_sc_hd__inv_1
* cell instance $14193 m0 *1 334.42,236.64
X$14193 40 5983 6741 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $14194 m0 *1 338.56,236.64
X$14194 40 6739 6454 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $14195 m0 *1 343.16,236.64
X$14195 40 7311 6797 6738 6737 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $14199 r0 *1 2.76,236.64
X$14199 105 6718 6708 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $14202 r0 *1 6.9,236.64
X$14202 40 6637 6638 6712 6565 6639 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $14207 r0 *1 16.1,236.64
X$14207 105 6857 6715 6742 105 6487 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $14209 r0 *1 18.4,236.64
X$14209 105 6765 6094 6764 6523 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $14211 r0 *1 20.7,236.64
X$14211 105 6836 6766 6801 6798 6245 40 105 40 sky130_fd_sc_hd__o22a_1
* cell instance $14213 r0 *1 24.38,236.64
X$14213 105 6767 6642 6717 40 105 6413 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14214 r0 *1 26.22,236.64
X$14214 40 6802 6770 6800 6458 6769 6768 105 105 40 sky130_fd_sc_hd__a2111oi_1
* cell instance $14215 r0 *1 29.9,236.64
X$14215 105 6769 6768 6770 40 105 6767 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14216 r0 *1 31.74,236.64
X$14216 40 6769 6716 6458 6765 6768 6770 105 105 40 sky130_fd_sc_hd__a2111oi_4
* cell instance $14220 r0 *1 43.24,236.64
X$14220 40 6805 6719 6803 6804 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $14221 r0 *1 45.54,236.64
X$14221 105 6569 6567 6641 6744 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $14223 r0 *1 47.84,236.64
X$14223 105 6611 6713 6771 6530 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $14226 r0 *1 51.98,236.64
X$14226 105 6642 105 40 6766 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $14227 r0 *1 53.82,236.64
X$14227 40 6772 6766 6773 6646 6862 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $14228 r0 *1 58.42,236.64
X$14228 105 6774 6776 6775 105 6772 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $14229 r0 *1 61.18,236.64
X$14229 105 6774 6776 6775 6773 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $14230 r0 *1 63.02,236.64
X$14230 105 6778 6777 6863 105 6775 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $14231 r0 *1 65.78,236.64
X$14231 105 6721 6897 6779 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14232 r0 *1 67.16,236.64
X$14232 105 6777 6721 6808 6779 105 40 6572 40 sky130_fd_sc_hd__o31ai_1
* cell instance $14236 r0 *1 70.84,236.64
X$14236 105 6809 6681 6781 6722 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $14242 r0 *1 85.1,236.64
X$14242 105 6811 6649 6782 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $14245 r0 *1 89.7,236.64
X$14245 40 6469 6978 6782 6426 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $14249 r0 *1 99.36,236.64
X$14249 40 6814 6813 6815 6783 6653 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $14250 r0 *1 103.96,236.64
X$14250 105 6816 5865 5410 6815 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $14253 r0 *1 108.1,236.64
X$14253 105 6311 5984 6724 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14255 r0 *1 113.16,236.64
X$14255 40 3879 6718 6167 6819 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $14256 r0 *1 122.82,236.64
X$14256 105 6167 105 40 9517 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $14259 r0 *1 126.04,236.64
X$14259 40 6624 6625 5558 105 6584 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14261 r0 *1 131.56,236.64
X$14261 40 6076 6691 4828 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $14262 r0 *1 138.92,236.64
X$14262 40 6076 6822 5031 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $14263 r0 *1 146.28,236.64
X$14263 105 6693 6825 6824 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14265 r0 *1 148.12,236.64
X$14265 40 6657 6826 5558 105 6726 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14269 r0 *1 153.64,236.64
X$14269 40 6882 6956 6659 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $14274 r0 *1 169.74,236.64
X$14274 40 5701 6829 6729 6727 6785 6784 5610 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $14281 r0 *1 188.6,236.64
X$14281 105 6666 6831 5568 6324 40 6558 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $14287 r0 *1 201.94,236.64
X$14287 40 6628 6665 6842 6448 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $14290 r0 *1 206.54,236.64
X$14290 105 5806 5568 5269 40 105 6834 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14293 r0 *1 209.3,236.64
X$14293 105 6788 6786 6787 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14294 r0 *1 210.68,236.64
X$14294 40 6087 5699 6787 6145 6833 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $14298 r0 *1 224.48,236.64
X$14298 40 3558 6449 3627 3697 105 105 40 sky130_fd_sc_hd__and3_4
* cell instance $14299 r0 *1 228.62,236.64
X$14299 105 3627 40 105 6732 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14301 r0 *1 231.84,236.64
X$14301 40 3697 5963 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $14305 r0 *1 243.8,236.64
X$14305 40 5730 5490 6324 6789 6189 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $14306 r0 *1 248.4,236.64
X$14306 105 6790 6666 6828 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14309 r0 *1 252.54,236.64
X$14309 40 6112 5568 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $14313 r0 *1 260.36,236.64
X$14313 40 6702 6791 6556 5805 6112 6877 105 105 40 sky130_fd_sc_hd__a221oi_1
* cell instance $14315 r0 *1 264.04,236.64
X$14315 40 6791 6554 6236 5997 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $14316 r0 *1 268.18,236.64
X$14316 40 5655 6200 7018 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $14317 r0 *1 278.3,236.64
X$14317 40 3044 6120 105 105 40 sky130_fd_sc_hd__buf_16
* cell instance $14322 r0 *1 291.64,236.64
X$14322 40 6818 6193 105 4946 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14323 r0 *1 299,236.64
X$14323 40 6866 6292 105 4685 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14324 r0 *1 306.36,236.64
X$14324 40 6810 6792 6735 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $14325 r0 *1 312.34,236.64
X$14325 105 6807 6678 6736 105 40 6603 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14327 r0 *1 315.1,236.64
X$14327 105 6603 40 105 6745 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14331 r0 *1 319.7,236.64
X$14331 40 6793 6193 105 4459 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14332 r0 *1 327.06,236.64
X$14332 40 6733 6193 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $14333 r0 *1 334.42,236.64
X$14333 40 6206 6618 6794 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $14336 r0 *1 340.86,236.64
X$14336 40 9488 6797 6739 6120 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $14338 r0 *1 346.84,236.64
X$14338 40 40 6796 105 6795 6680 105 sky130_fd_sc_hd__nor2_2
* cell instance $14369 m0 *1 9.2,242.08
X$14369 40 6094 6806 6800 6856 6835 105 105 40 sky130_fd_sc_hd__o31a_2
* cell instance $14373 m0 *1 16.1,242.08
X$14373 105 6714 6713 6857 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14375 m0 *1 19.32,242.08
X$14375 40 6642 6801 6764 6412 6836 6798 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $14379 m0 *1 36.8,242.08
X$14379 105 6714 6643 6927 105 6804 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $14380 m0 *1 38.64,242.08
X$14380 105 6803 6805 6804 40 105 6743 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14381 m0 *1 40.48,242.08
X$14381 40 6643 6806 6642 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $14382 m0 *1 47.84,242.08
X$14382 105 6611 6837 6713 105 6567 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14383 m0 *1 51.06,242.08
X$14383 105 6806 6861 6643 105 40 6490 40 sky130_fd_sc_hd__o21ai_1
* cell instance $14386 m0 *1 55.2,242.08
X$14386 105 6766 6895 6862 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14389 m0 *1 60.72,242.08
X$14389 105 6775 6766 6838 6933 105 40 6378 40 sky130_fd_sc_hd__o31ai_1
* cell instance $14390 m0 *1 63.48,242.08
X$14390 105 6778 6863 6777 6838 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $14391 m0 *1 65.32,242.08
X$14391 40 6809 6839 6935 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $14392 m0 *1 74.52,242.08
X$14392 40 40 6839 6867 6721 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $14398 m0 *1 89.24,242.08
X$14398 40 6899 6647 6426 105 105 40 sky130_fd_sc_hd__nor2b_4
* cell instance $14399 m0 *1 94.3,242.08
X$14399 105 6426 6470 6870 105 6938 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $14400 m0 *1 96.14,242.08
X$14400 105 6426 6723 6870 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14402 m0 *1 97.98,242.08
X$14402 40 6384 6871 6751 6905 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $14403 m0 *1 106.26,242.08
X$14403 40 6814 6426 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $14404 m0 *1 110.4,242.08
X$14404 105 6724 105 40 6873 40 sky130_fd_sc_hd__inv_1
* cell instance $14409 m0 *1 118.22,242.08
X$14409 105 6624 6690 6840 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14410 m0 *1 119.6,242.08
X$14410 105 6622 6840 6875 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14412 m0 *1 121.9,242.08
X$14412 40 6819 4243 6718 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $14414 m0 *1 126.96,242.08
X$14414 105 6625 6576 6550 105 40 6880 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14415 m0 *1 129.72,242.08
X$14415 105 6578 6821 6579 105 6841 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14416 m0 *1 132.94,242.08
X$14416 40 9529 6878 3171 105 6628 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14419 m0 *1 139.84,242.08
X$14419 105 6578 40 105 6879 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14420 m0 *1 143.06,242.08
X$14420 40 9528 6693 3171 105 6726 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14421 m0 *1 147.66,242.08
X$14421 105 6657 105 40 6659 40 sky130_fd_sc_hd__inv_1
* cell instance $14423 m0 *1 149.96,242.08
X$14423 40 6694 6826 6659 6841 105 105 40 sky130_fd_sc_hd__o21bai_2
* cell instance $14425 m0 *1 154.56,242.08
X$14425 40 6076 6882 4667 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $14434 m0 *1 174.34,242.08
X$14434 40 6040 6961 6761 6352 6909 5809 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $14437 m0 *1 186.76,242.08
X$14437 105 6324 3329 6189 40 105 6884 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14442 m0 *1 195.04,242.08
X$14442 40 6885 5490 6324 6701 6189 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $14443 m0 *1 199.64,242.08
X$14443 105 4661 5805 5806 6886 40 6329 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $14445 m0 *1 203.32,242.08
X$14445 105 5416 5806 5568 6834 40 105 6965 40 sky130_fd_sc_hd__a31oi_1
* cell instance $14446 m0 *1 205.62,242.08
X$14446 40 5701 6788 6843 105 5927 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $14448 m0 *1 211.6,242.08
X$14448 40 6883 2366 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $14449 m0 *1 215.74,242.08
X$14449 40 6833 4243 6843 5963 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $14451 m0 *1 219.88,242.08
X$14451 40 40 6877 105 6112 6145 105 sky130_fd_sc_hd__nor2_2
* cell instance $14454 m0 *1 223.1,242.08
X$14454 40 3627 6112 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $14458 m0 *1 231.84,242.08
X$14458 40 6026 6143 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $14459 m0 *1 239.2,242.08
X$14459 105 6143 105 40 6881 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $14463 m0 *1 247.02,242.08
X$14463 105 6112 105 40 5699 40 sky130_fd_sc_hd__buf_4
* cell instance $14465 m0 *1 250.24,242.08
X$14465 40 6449 5809 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $14466 m0 *1 255.76,242.08
X$14466 105 6591 40 6876 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $14468 m0 *1 258.98,242.08
X$14468 40 5495 5490 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $14471 m0 *1 268.64,242.08
X$14471 105 6757 105 40 6475 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $14472 m0 *1 270.48,242.08
X$14472 40 6756 6953 6276 6200 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $14477 m0 *1 278.3,242.08
X$14477 40 6952 6991 6200 105 6599 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14478 m0 *1 282.9,242.08
X$14478 105 6844 6845 105 6872 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $14480 m0 *1 286.58,242.08
X$14480 105 6874 6913 6846 105 40 6844 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14481 m0 *1 289.34,242.08
X$14481 105 6869 6914 6818 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14482 m0 *1 292.56,242.08
X$14482 40 6868 6944 6200 105 6543 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14483 m0 *1 297.16,242.08
X$14483 105 6848 6847 105 6866 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $14484 m0 *1 300.38,242.08
X$14484 105 6864 6847 6865 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14486 m0 *1 302.22,242.08
X$14486 105 6812 6849 6792 105 40 6939 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14488 m0 *1 305.44,242.08
X$14488 105 6812 6849 6620 105 40 6848 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14490 m0 *1 309.12,242.08
X$14490 40 6680 6807 6200 105 6450 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14491 m0 *1 313.72,242.08
X$14491 105 6735 6860 6859 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14492 m0 *1 315.1,242.08
X$14492 105 6289 40 105 6858 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14493 m0 *1 318.32,242.08
X$14493 105 6296 6680 6793 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14494 m0 *1 321.54,242.08
X$14494 40 9534 6851 6120 105 6508 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14495 m0 *1 326.14,242.08
X$14495 105 6919 6212 105 7053 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $14496 m0 *1 329.36,242.08
X$14496 105 6670 6671 6850 105 6792 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14498 m0 *1 333.04,242.08
X$14498 105 6608 6851 6613 105 6919 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14499 m0 *1 336.26,242.08
X$14499 105 6921 6525 6925 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14500 m0 *1 339.48,242.08
X$14500 105 6604 6617 6854 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14501 m0 *1 340.86,242.08
X$14501 40 6855 6853 6924 6200 6852 105 105 40 sky130_fd_sc_hd__fa_2
* cell instance $14504 r0 *1 4.14,242.08
X$14504 40 6835 6562 6806 6800 6856 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $14511 r0 *1 16.56,242.08
X$14511 105 6561 6967 6765 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14513 r0 *1 19.78,242.08
X$14513 105 6714 6889 6713 105 40 6764 40 sky130_fd_sc_hd__o21ai_1
* cell instance $14516 r0 *1 23,242.08
X$14516 40 6887 6888 6889 6890 105 6801 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $14518 r0 *1 28.52,242.08
X$14518 40 6892 6717 6888 6887 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $14519 r0 *1 30.82,242.08
X$14519 40 6971 6970 6892 6888 6887 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $14520 r0 *1 35.42,242.08
X$14520 105 6893 6926 6927 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14521 r0 *1 38.64,242.08
X$14521 105 6888 6611 6713 6887 105 6805 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $14522 r0 *1 40.94,242.08
X$14522 105 6251 6645 5716 105 7007 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $14525 r0 *1 43.24,242.08
X$14525 105 6645 6566 6929 6930 105 6888 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $14527 r0 *1 46.92,242.08
X$14527 105 6894 6645 6837 5716 6893 40 105 40 sky130_fd_sc_hd__o22a_1
* cell instance $14530 r0 *1 52.9,242.08
X$14530 40 6774 6896 1988 105 6895 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14531 r0 *1 57.5,242.08
X$14531 105 6932 6896 6772 6974 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $14533 r0 *1 61.18,242.08
X$14533 105 6766 6931 6933 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14535 r0 *1 63.02,242.08
X$14535 40 6898 6863 6897 105 2532 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14536 r0 *1 67.62,242.08
X$14536 105 6898 6780 6935 105 6777 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $14539 r0 *1 70.84,242.08
X$14539 105 6809 6781 6681 105 6780 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $14540 r0 *1 73.6,242.08
X$14540 105 6898 6935 6780 6808 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $14543 r0 *1 79.58,242.08
X$14543 40 6936 6900 6899 2803 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $14545 r0 *1 85.56,242.08
X$14545 105 6900 6901 6937 105 40 6902 40 sky130_fd_sc_hd__o21ai_1
* cell instance $14546 r0 *1 87.4,242.08
X$14546 105 6901 6900 6937 6903 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $14547 r0 *1 89.7,242.08
X$14547 40 6940 7040 6938 2251 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $14548 r0 *1 95.22,242.08
X$14548 105 6902 6941 40 105 6943 40 sky130_fd_sc_hd__or2b_1
* cell instance $14551 r0 *1 98.44,242.08
X$14551 105 6904 6905 6723 6942 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $14553 r0 *1 102.12,242.08
X$14553 40 6814 6905 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $14554 r0 *1 106.26,242.08
X$14554 40 6945 6904 6687 6905 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $14555 r0 *1 109.94,242.08
X$14555 105 6946 5943 105 40 7042 40 sky130_fd_sc_hd__and2b_2
* cell instance $14556 r0 *1 113.16,242.08
X$14556 105 7019 5943 7234 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14562 r0 *1 124.2,242.08
X$14562 105 6624 105 40 6576 40 sky130_fd_sc_hd__inv_1
* cell instance $14567 r0 *1 131.1,242.08
X$14567 105 6820 105 40 6579 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $14570 r0 *1 134.32,242.08
X$14570 40 5281 3212 6167 6949 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $14571 r0 *1 144.9,242.08
X$14571 105 6880 6821 6579 105 6907 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14572 r0 *1 148.12,242.08
X$14572 105 6906 40 105 6950 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14574 r0 *1 151.34,242.08
X$14574 105 6955 4012 7082 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14577 r0 *1 153.64,242.08
X$14577 105 6907 40 105 6956 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14579 r0 *1 157.32,242.08
X$14579 105 4017 6908 6957 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14581 r0 *1 162.38,242.08
X$14581 40 5701 6396 3284 6909 6961 6024 6149 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $14588 r0 *1 181.24,242.08
X$14588 40 6962 6040 6435 7031 6449 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $14592 r0 *1 195.04,242.08
X$14592 40 6964 6910 6963 5806 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $14594 r0 *1 200.56,242.08
X$14594 105 5699 6110 7271 40 105 6886 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14598 r0 *1 205.16,242.08
X$14598 105 5805 7026 6965 105 6966 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14600 r0 *1 208.84,242.08
X$14600 40 6876 4585 6966 6883 6911 4903 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $14601 r0 *1 218.5,242.08
X$14601 40 6145 6042 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $14604 r0 *1 231.38,242.08
X$14604 105 6704 40 105 6786 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14610 r0 *1 237.36,242.08
X$14610 105 6830 40 6960 105 40 sky130_fd_sc_hd__buf_2
* cell instance $14613 r0 *1 240.58,242.08
X$14613 40 5701 6758 6789 6959 6958 5731 5610 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $14622 r0 *1 264.96,242.08
X$14622 40 6912 6733 105 3438 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14623 r0 *1 272.32,242.08
X$14623 40 6954 6953 6951 6756 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $14624 r0 *1 278.3,242.08
X$14624 40 6695 5063 6733 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $14625 r0 *1 282.44,242.08
X$14625 40 6914 6874 6200 105 6130 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14628 r0 *1 287.96,242.08
X$14628 105 6913 6948 7064 105 6915 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14630 r0 *1 291.64,242.08
X$14630 105 6874 6913 6869 105 40 7050 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14631 r0 *1 294.4,242.08
X$14631 105 6916 105 40 6947 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $14632 r0 *1 296.24,242.08
X$14632 105 6868 105 40 6847 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $14633 r0 *1 298.08,242.08
X$14633 105 6944 6847 6848 40 105 6846 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14634 r0 *1 299.92,242.08
X$14634 105 6944 6847 6939 40 105 6869 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14635 r0 *1 301.76,242.08
X$14635 105 6865 6917 6916 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14636 r0 *1 303.14,242.08
X$14636 105 6750 40 6670 105 40 sky130_fd_sc_hd__buf_2
* cell instance $14637 r0 *1 304.98,242.08
X$14637 40 40 6860 105 6918 6685 105 sky130_fd_sc_hd__nor2_2
* cell instance $14638 r0 *1 307.28,242.08
X$14638 105 6746 6919 6212 105 40 6934 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14639 r0 *1 310.04,242.08
X$14639 40 9560 7004 6120 105 6450 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14642 r0 *1 315.56,242.08
X$14642 105 6920 40 105 6921 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14644 r0 *1 319.24,242.08
X$14644 40 6922 6736 6928 105 105 40 sky130_fd_sc_hd__xnor2_4
* cell instance $14645 r0 *1 329.36,242.08
X$14645 40 6922 6795 105 105 40 sky130_fd_sc_hd__dlymetal6s4s_1
* cell instance $14646 r0 *1 333.96,242.08
X$14646 40 6912 6741 6737 6120 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $14648 r0 *1 343.16,242.08
X$14648 105 6514 6286 7054 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14650 r0 *1 346.84,242.08
X$14650 40 40 6920 105 6999 6516 105 sky130_fd_sc_hd__nor2_2
* cell instance $14680 m0 *1 6.44,247.52
X$14680 40 6740 6998 6414 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $14681 m0 *1 12.42,247.52
X$14681 105 6611 7001 6967 105 6639 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14685 m0 *1 21.62,247.52
X$14685 40 6798 6611 6713 6892 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $14688 m0 *1 27.6,247.52
X$14688 105 6611 6713 6970 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14690 m0 *1 29.44,247.52
X$14690 40 5711 6891 6969 6970 6246 6971 105 105 40 sky130_fd_sc_hd__a311o_2
* cell instance $14691 m0 *1 33.58,247.52
X$14691 105 7003 6972 6969 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14692 m0 *1 34.96,247.52
X$14692 105 7003 6972 6893 40 6836 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $14693 m0 *1 38.18,247.52
X$14693 105 7006 6973 6803 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14695 m0 *1 40.48,247.52
X$14695 40 6887 6929 6930 7007 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $14698 m0 *1 46.46,247.52
X$14698 40 6837 6894 6645 5716 6891 105 105 40 sky130_fd_sc_hd__o22ai_4
* cell instance $14701 m0 *1 55.2,247.52
X$14701 105 6975 6974 6861 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14703 m0 *1 57.04,247.52
X$14703 105 6932 6772 6896 105 6975 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $14705 m0 *1 60.26,247.52
X$14705 40 6778 6776 2251 105 6931 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14706 m0 *1 64.86,247.52
X$14706 105 6778 6809 6774 6898 105 7063 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $14714 m0 *1 85.56,247.52
X$14714 40 6901 2532 6941 6978 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $14715 m0 *1 94.76,247.52
X$14715 40 6904 7148 6942 7011 7065 6470 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $14716 m0 *1 104.42,247.52
X$14716 40 6871 7012 6542 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $14717 m0 *1 108.56,247.52
X$14717 105 6905 6873 7015 40 6980 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $14719 m0 *1 112.24,247.52
X$14719 40 7017 7019 1986 6980 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $14723 m0 *1 120.98,247.52
X$14723 40 5281 5414 6167 7023 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $14724 m0 *1 131.56,247.52
X$14724 105 5414 6981 7155 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14727 m0 *1 137.08,247.52
X$14727 40 40 6906 105 6878 6577 105 sky130_fd_sc_hd__nor2_2
* cell instance $14729 m0 *1 139.84,247.52
X$14729 40 5281 3173 6167 7024 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $14730 m0 *1 150.42,247.52
X$14730 105 6826 6659 6907 105 40 6660 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14731 m0 *1 153.18,247.52
X$14731 105 4016 6908 7029 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14732 m0 *1 154.56,247.52
X$14732 40 4016 6984 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $14733 m0 *1 160.08,247.52
X$14733 105 7029 6731 6985 40 105 7030 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14742 m0 *1 176.18,247.52
X$14742 40 6354 6399 6831 6962 7031 6434 6986 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $14751 m0 *1 198.72,247.52
X$14751 105 6881 40 6986 105 40 sky130_fd_sc_hd__buf_2
* cell instance $14753 m0 *1 202.4,247.52
X$14753 105 5699 5726 7120 6988 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $14754 m0 *1 204.24,247.52
X$14754 105 5699 7028 6988 40 5621 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $14755 m0 *1 207.46,247.52
X$14755 40 7026 6877 5568 5805 7027 7025 105 105 40 sky130_fd_sc_hd__a221oi_1
* cell instance $14759 m0 *1 213.9,247.52
X$14759 105 6145 105 40 5806 40 sky130_fd_sc_hd__buf_4
* cell instance $14760 m0 *1 216.66,247.52
X$14760 40 5997 6145 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $14762 m0 *1 222.64,247.52
X$14762 105 6042 105 40 5726 40 sky130_fd_sc_hd__buf_4
* cell instance $14763 m0 *1 225.4,247.52
X$14763 40 3558 5997 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $14764 m0 *1 232.76,247.52
X$14764 105 5694 6705 7084 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14768 m0 *1 241.96,247.52
X$14768 40 6989 6959 5178 6958 5809 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $14771 m0 *1 251.16,247.52
X$14771 40 40 6189 7022 5490 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $14774 m0 *1 256.22,247.52
X$14774 105 2968 6990 7021 40 105 7020 40 sky130_fd_sc_hd__a21o_1
* cell instance $14776 m0 *1 259.44,247.52
X$14776 105 6189 5495 7262 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $14780 m0 *1 264.96,247.52
X$14780 40 7018 6954 4676 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $14782 m0 *1 275.54,247.52
X$14782 105 6952 105 40 6845 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $14784 m0 *1 277.84,247.52
X$14784 105 7016 6912 40 3488 105 40 sky130_fd_sc_hd__and2_4
* cell instance $14785 m0 *1 281.06,247.52
X$14785 105 6844 6845 6991 40 105 6951 40 sky130_fd_sc_hd__a21o_1
* cell instance $14786 m0 *1 283.82,247.52
X$14786 105 6756 6992 7013 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14787 m0 *1 285.2,247.52
X$14787 40 9536 6948 6120 105 6130 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14788 m0 *1 289.8,247.52
X$14788 105 6914 105 40 6913 40 sky130_fd_sc_hd__inv_1
* cell instance $14789 m0 *1 291.18,247.52
X$14789 40 9541 6917 6120 105 6543 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14790 m0 *1 295.78,247.52
X$14790 105 6915 6845 7010 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14791 m0 *1 297.16,247.52
X$14791 40 6847 6993 7188 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $14792 m0 *1 303.14,247.52
X$14792 105 6860 40 7008 105 40 sky130_fd_sc_hd__buf_2
* cell instance $14794 m0 *1 305.44,247.52
X$14794 105 6849 6817 6995 105 6993 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14795 m0 *1 308.66,247.52
X$14795 105 6685 7005 6670 105 40 6995 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14796 m0 *1 311.42,247.52
X$14796 40 6670 7005 6994 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $14797 m0 *1 317.4,247.52
X$14797 105 6807 6736 6296 105 40 6850 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14798 m0 *1 320.16,247.52
X$14798 40 7016 4620 6925 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $14799 m0 *1 325.22,247.52
X$14799 40 7051 6996 105 4764 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14801 m0 *1 333.04,247.52
X$14801 105 7135 6212 7002 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14802 m0 *1 334.42,247.52
X$14802 40 7000 4382 6997 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $14804 m0 *1 339.94,247.52
X$14804 40 6858 7310 6996 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $14805 m0 *1 345.92,247.52
X$14805 105 7057 6207 6997 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14808 r0 *1 3.68,247.52
X$14808 105 7033 7056 6410 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14809 r0 *1 6.9,247.52
X$14809 105 7032 7033 7096 105 40 6998 40 sky130_fd_sc_hd__o21ai_1
* cell instance $14811 r0 *1 9.2,247.52
X$14811 105 7097 6713 7058 6806 40 7033 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $14814 r0 *1 13.34,247.52
X$14814 105 6611 7059 6712 105 7035 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $14818 r0 *1 15.64,247.52
X$14818 105 7032 6967 7034 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14820 r0 *1 17.48,247.52
X$14820 40 6968 7193 6711 7034 6798 7035 105 105 40 sky130_fd_sc_hd__a221oi_1
* cell instance $14824 r0 *1 23.92,247.52
X$14824 40 6891 6971 6969 6970 5582 6246 105 105 40 sky130_fd_sc_hd__a311oi_4
* cell instance $14826 r0 *1 35.42,247.52
X$14826 105 7006 6926 6973 105 7003 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14827 r0 *1 38.64,247.52
X$14827 105 7006 6973 6926 6770 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $14835 r0 *1 47.38,247.52
X$14835 105 6837 6566 6894 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14838 r0 *1 54.74,247.52
X$14838 40 6932 7062 1986 105 6771 105 40 sky130_fd_sc_hd__ha_1
* cell instance $14839 r0 *1 59.34,247.52
X$14839 105 6681 7037 6932 6976 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $14841 r0 *1 62.1,247.52
X$14841 105 2409 7063 6976 7038 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $14854 r0 *1 82.8,247.52
X$14854 105 6936 7009 6977 105 6937 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $14855 r0 *1 85.56,247.52
X$14855 105 6936 6977 7009 7039 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $14856 r0 *1 87.4,247.52
X$14856 105 6937 7039 7070 105 7144 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $14858 r0 *1 89.7,247.52
X$14858 105 6900 7040 6941 7108 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $14860 r0 *1 92.46,247.52
X$14860 105 6943 6940 7065 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $14864 r0 *1 96.6,247.52
X$14864 105 7012 40 105 7066 40 sky130_fd_sc_hd__inv_2
* cell instance $14867 r0 *1 99.36,247.52
X$14867 105 7041 6979 105 7067 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $14869 r0 *1 103.04,247.52
X$14869 40 7070 6979 5943 7042 7041 7017 105 105 40 sky130_fd_sc_hd__a41o_1
* cell instance $14870 r0 *1 106.72,247.52
X$14870 40 7110 7042 7041 6979 5943 7017 105 105 40 sky130_fd_sc_hd__a41o_4
* cell instance $14872 r0 *1 115,247.52
X$14872 40 5281 6731 7043 7075 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $14877 r0 *1 126.96,247.52
X$14877 40 5281 6434 7043 7074 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $14878 r0 *1 137.54,247.52
X$14878 105 6731 6981 7115 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14881 r0 *1 140.3,247.52
X$14881 105 6982 7077 7076 105 40 7024 40 sky130_fd_sc_hd__o21ai_1
* cell instance $14882 r0 *1 142.14,247.52
X$14882 105 3173 6981 7077 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14883 r0 *1 143.52,247.52
X$14883 105 6955 4183 7078 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14884 r0 *1 144.9,247.52
X$14884 105 6657 6906 6825 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14885 r0 *1 146.28,247.52
X$14885 105 4188 6908 7079 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14886 r0 *1 147.66,247.52
X$14886 105 3989 6908 7044 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14888 r0 *1 149.5,247.52
X$14888 105 6983 7082 7030 105 40 7160 40 sky130_fd_sc_hd__o21ai_1
* cell instance $14891 r0 *1 151.34,247.52
X$14891 105 7044 5414 6985 40 105 7083 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14893 r0 *1 153.64,247.52
X$14893 105 6983 7086 7087 105 40 7089 40 sky130_fd_sc_hd__o21ai_1
* cell instance $14894 r0 *1 155.48,247.52
X$14894 105 6957 5641 6985 40 105 7087 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14896 r0 *1 158.24,247.52
X$14896 40 5281 5641 7092 7091 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $14909 r0 *1 193.66,247.52
X$14909 40 6910 6987 6350 6354 6963 6881 6240 105 105 40 sky130_fd_sc_hd__mux4_2
* cell instance $14914 r0 *1 204.7,247.52
X$14914 40 7028 7095 7094 6145 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $14917 r0 *1 209.76,247.52
X$14917 40 7025 7093 7045 5997 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $14920 r0 *1 219.42,247.52
X$14920 105 3157 105 40 6331 40 sky130_fd_sc_hd__inv_1
* cell instance $14925 r0 *1 230.46,247.52
X$14925 105 5653 6405 7085 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14928 r0 *1 231.84,247.52
X$14928 105 4495 6908 7084 6960 7081 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $14934 r0 *1 237.82,247.52
X$14934 40 5281 3050 7046 7047 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $14937 r0 *1 249.78,247.52
X$14937 105 4602 7049 6989 7073 40 7072 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $14939 r0 *1 253.46,247.52
X$14939 105 2968 6707 7154 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $14948 r0 *1 264.96,247.52
X$14948 40 7018 6954 6757 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $14949 r0 *1 275.08,247.52
X$14949 105 6757 40 105 7071 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14950 r0 *1 278.3,247.52
X$14950 40 7014 6756 7069 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $14951 r0 *1 284.28,247.52
X$14951 105 6991 6845 7050 40 105 6595 40 sky130_fd_sc_hd__a21oi_1
* cell instance $14955 r0 *1 286.58,247.52
X$14955 105 6915 40 105 7068 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $14956 r0 *1 289.8,247.52
X$14956 105 7010 6755 6992 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14958 r0 *1 291.64,247.52
X$14958 40 7145 6914 6947 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $14959 r0 *1 297.62,247.52
X$14959 105 6917 6993 6847 105 40 7064 40 sky130_fd_sc_hd__o21bai_1
* cell instance $14960 r0 *1 300.38,247.52
X$14960 40 7051 7139 105 4870 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14961 r0 *1 307.74,247.52
X$14961 40 7061 7008 6849 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $14965 r0 *1 314.64,247.52
X$14965 40 7053 7052 6928 7055 7061 105 105 40 sky130_fd_sc_hd__or4_4
* cell instance $14967 r0 *1 319.24,247.52
X$14967 105 6934 7004 6736 105 7005 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $14968 r0 *1 322.46,247.52
X$14968 40 7000 7053 105 4300 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $14970 r0 *1 330.28,247.52
X$14970 40 7016 4271 7054 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $14971 r0 *1 335.34,247.52
X$14971 40 7060 6048 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $14975 r0 *1 345,247.52
X$14975 105 6854 6286 6999 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14977 r0 *1 346.84,247.52
X$14977 40 40 6374 105 6207 6197 105 sky130_fd_sc_hd__nor2_2
* cell instance $14996 m0 *1 6.44,252.96
X$14996 105 7032 7096 7056 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $14997 m0 *1 7.82,252.96
X$14997 40 40 7097 6638 6713 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $14999 m0 *1 10.58,252.96
X$14999 105 7001 7099 6890 7058 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $15000 m0 *1 12.42,252.96
X$15000 105 7100 6967 7059 40 105 6637 40 sky130_fd_sc_hd__a21o_1
* cell instance $15003 m0 *1 16.56,252.96
X$15003 105 7100 105 40 6611 40 sky130_fd_sc_hd__buf_4
* cell instance $15005 m0 *1 21.16,252.96
X$15005 40 7102 7101 6806 7104 7103 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $15007 m0 *1 29.44,252.96
X$15007 40 7101 7104 6769 6891 7102 7103 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $15011 m0 *1 36.34,252.96
X$15011 105 7105 7136 6892 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15014 m0 *1 40.02,252.96
X$15014 40 6926 7138 6566 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $15015 m0 *1 46,252.96
X$15015 40 7036 6569 6611 7140 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $15016 m0 *1 48.3,252.96
X$15016 105 7036 105 40 6713 40 sky130_fd_sc_hd__buf_4
* cell instance $15017 m0 *1 51.06,252.96
X$15017 105 7106 40 105 7141 40 sky130_fd_sc_hd__inv_2
* cell instance $15018 m0 *1 52.44,252.96
X$15018 40 7062 7106 6975 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $15020 m0 *1 57.04,252.96
X$15020 40 7037 7106 6837 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $15024 m0 *1 73.14,252.96
X$15024 40 7229 1988 7142 7011 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $15026 m0 *1 82.8,252.96
X$15026 105 6977 6904 7143 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15028 m0 *1 84.64,252.96
X$15028 105 7144 6899 7110 105 7476 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $15029 m0 *1 87.4,252.96
X$15029 40 7041 6937 7108 7040 7146 105 105 40 sky130_fd_sc_hd__o22a_4
* cell instance $15030 m0 *1 93.84,252.96
X$15030 105 6940 6941 6901 105 7146 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $15032 m0 *1 97.06,252.96
X$15032 105 7110 7012 7147 40 7610 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $15034 m0 *1 101.2,252.96
X$15034 40 6979 7066 7111 1988 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $15035 m0 *1 110.4,252.96
X$15035 105 6687 6905 7015 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15038 m0 *1 113.16,252.96
X$15038 105 7111 7019 7017 105 6946 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $15039 m0 *1 116.38,252.96
X$15039 40 7019 7152 7017 5943 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $15040 m0 *1 118.68,252.96
X$15040 40 5281 6688 7043 7153 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15041 m0 *1 129.26,252.96
X$15041 105 6982 7155 7080 105 40 7023 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15042 m0 *1 131.1,252.96
X$15042 105 6982 7157 7205 105 40 7074 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15043 m0 *1 132.94,252.96
X$15043 105 6434 6981 7157 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15045 m0 *1 134.78,252.96
X$15045 105 7113 7115 6982 105 40 7075 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15047 m0 *1 137.54,252.96
X$15047 105 6982 7158 7180 105 40 6949 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15049 m0 *1 139.84,252.96
X$15049 105 3212 6981 7158 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15051 m0 *1 141.68,252.96
X$15051 105 4102 7112 7116 40 105 7076 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15052 m0 *1 143.52,252.96
X$15052 105 6983 7078 7159 105 40 7116 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15053 m0 *1 145.36,252.96
X$15053 105 7079 3173 7117 40 105 7159 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15054 m0 *1 147.2,252.96
X$15054 105 4024 7118 7119 40 105 7080 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15055 m0 *1 149.04,252.96
X$15055 105 3930 7118 7160 40 105 7113 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15056 m0 *1 150.88,252.96
X$15056 105 6983 7161 7083 105 40 7119 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15058 m0 *1 153.18,252.96
X$15058 105 6955 3926 7086 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15060 m0 *1 155.02,252.96
X$15060 105 3848 7118 7089 40 105 7090 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15061 m0 *1 156.86,252.96
X$15061 105 7293 7164 7090 105 40 7091 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15062 m0 *1 158.7,252.96
X$15062 105 5641 6981 7164 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15070 m0 *1 168.82,252.96
X$15070 105 3214 7124 7167 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15071 m0 *1 170.2,252.96
X$15071 40 5281 3329 7092 7166 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15072 m0 *1 180.78,252.96
X$15072 40 5281 6081 7092 7170 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15079 m0 *1 197.8,252.96
X$15079 40 6354 6842 7094 7095 7120 5423 6281 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $15080 m0 *1 207.46,252.96
X$15080 40 6354 6832 6911 7027 7093 7045 6281 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $15082 m0 *1 218.96,252.96
X$15082 105 7184 6331 7124 40 105 7123 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15089 m0 *1 227.7,252.96
X$15089 105 4495 7125 6989 7085 40 7163 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15090 m0 *1 230.46,252.96
X$15090 105 6960 6078 7081 105 7162 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15091 m0 *1 232.3,252.96
X$15091 40 5281 5694 7046 7126 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $15092 m0 *1 241.96,252.96
X$15092 105 3050 6990 7128 40 105 7047 40 sky130_fd_sc_hd__a21o_1
* cell instance $15093 m0 *1 244.72,252.96
X$15093 105 7121 4495 7048 7022 7156 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15094 m0 *1 247.48,252.96
X$15094 105 3050 6707 7048 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15098 m0 *1 250.7,252.96
X$15098 105 5732 6405 7073 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15100 m0 *1 252.54,252.96
X$15100 105 7121 4602 7154 7022 7151 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15102 m0 *1 255.76,252.96
X$15102 40 5281 2968 7427 7020 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15104 m0 *1 267.26,252.96
X$15104 105 7013 6823 7130 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15105 m0 *1 268.64,252.96
X$15105 40 7187 7018 7130 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $15106 m0 *1 274.62,252.96
X$15106 105 4800 105 40 5212 40 sky130_fd_sc_hd__buf_4
* cell instance $15108 m0 *1 277.84,252.96
X$15108 40 6668 7014 7150 7132 7149 7145 105 105 40 sky130_fd_sc_hd__a41oi_4
* cell instance $15111 m0 *1 289.34,252.96
X$15111 40 6052 9507 105 105 40 sky130_fd_sc_hd__inv_8
* cell instance $15112 m0 *1 293.48,252.96
X$15112 105 7133 6948 7258 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15113 m0 *1 294.86,252.96
X$15113 40 7051 6994 105 4372 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $15114 m0 *1 302.22,252.96
X$15114 105 6914 6916 7133 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15115 m0 *1 303.6,252.96
X$15115 105 6735 105 40 6849 40 sky130_fd_sc_hd__inv_1
* cell instance $15118 m0 *1 305.9,252.96
X$15118 40 6302 6532 6468 7134 7189 5980 6881 105 105 40 sky130_fd_sc_hd__mux4_1
* cell instance $15120 m0 *1 316.48,252.96
X$15120 40 7000 6928 105 4535 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $15121 m0 *1 323.84,252.96
X$15121 105 6670 7137 6918 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15122 m0 *1 325.22,252.96
X$15122 40 7051 6794 105 4855 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $15124 m0 *1 333.04,252.96
X$15124 40 7016 7000 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $15125 m0 *1 340.4,252.96
X$15125 40 7016 4881 6924 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $15126 m0 *1 345.46,252.96
X$15126 105 6197 40 105 7057 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $15130 r0 *1 3.68,252.96
X$15130 105 7171 105 40 7190 40 sky130_fd_sc_hd__inv_1
* cell instance $15131 r0 *1 5.06,252.96
X$15131 40 6835 7032 7190 7172 7096 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $15132 r0 *1 9.66,252.96
X$15132 105 7172 6638 7173 40 105 6710 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15133 r0 *1 11.5,252.96
X$15133 105 7001 7099 7174 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15134 r0 *1 12.88,252.96
X$15134 105 7098 7174 6714 6800 40 7173 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $15141 r0 *1 25.3,252.96
X$15141 105 7102 7101 7104 7103 40 7100 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $15144 r0 *1 33.12,252.96
X$15144 105 7003 6972 7251 7444 7193 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15145 r0 *1 35.88,252.96
X$15145 105 7105 7136 7175 40 6768 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $15146 r0 *1 39.1,252.96
X$15146 105 7105 7136 7175 6972 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $15151 r0 *1 43.7,252.96
X$15151 105 6929 6930 7140 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $15153 r0 *1 46.46,252.96
X$15153 40 7195 7317 6566 7038 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $15156 r0 *1 50.14,252.96
X$15156 40 7037 7196 7140 1760 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $15160 r0 *1 64.86,252.96
X$15160 40 7199 7198 7176 2251 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $15166 r0 *1 75.9,252.96
X$15166 105 7287 7199 7200 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $15170 r0 *1 88.32,252.96
X$15170 105 7107 7070 7177 40 105 7176 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15171 r0 *1 90.16,252.96
X$15171 105 7110 6978 7107 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15172 r0 *1 91.54,252.96
X$15172 40 7109 7178 6904 7177 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $15174 r0 *1 95.68,252.96
X$15174 105 6902 6903 7177 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15179 r0 *1 99.36,252.96
X$15179 105 7110 7067 7147 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15181 r0 *1 101.2,252.96
X$15181 105 6814 7110 40 105 7148 40 sky130_fd_sc_hd__or2_4
* cell instance $15182 r0 *1 104.42,252.96
X$15182 105 6542 7322 6871 105 40 7201 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15184 r0 *1 106.72,252.96
X$15184 40 7042 7041 6904 7017 6979 5943 105 105 40 sky130_fd_sc_hd__a41oi_4
* cell instance $15185 r0 *1 116.84,252.96
X$15185 40 7261 7203 7152 7179 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $15190 r0 *1 126.5,252.96
X$15190 105 6982 7204 7114 105 40 7153 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15191 r0 *1 128.34,252.96
X$15191 105 6688 6981 7204 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15194 r0 *1 132.48,252.96
X$15194 105 4514 7112 7206 40 105 7205 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15196 r0 *1 134.78,252.96
X$15196 105 6955 4518 7207 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15199 r0 *1 138.46,252.96
X$15199 105 4097 7112 7267 40 105 7180 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15201 r0 *1 140.76,252.96
X$15201 105 6955 4184 7208 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15204 r0 *1 144.44,252.96
X$15204 105 4189 7118 7181 40 105 7114 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15205 r0 *1 146.28,252.96
X$15205 105 6983 7211 7210 105 40 7181 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15206 r0 *1 148.12,252.96
X$15206 105 7270 6688 7117 40 105 7210 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15209 r0 *1 150.88,252.96
X$15209 105 6955 4364 7161 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15214 r0 *1 155.02,252.96
X$15214 105 6983 7213 7212 105 40 7272 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15215 r0 *1 156.86,252.96
X$15215 105 6024 6981 7337 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15218 r0 *1 162.84,252.96
X$15218 40 5281 3214 7092 7215 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15219 r0 *1 173.42,252.96
X$15219 105 7182 7218 7277 105 40 7166 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15220 r0 *1 175.26,252.96
X$15220 105 3848 7169 7217 40 105 7216 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15221 r0 *1 177.1,252.96
X$15221 105 3329 7124 7218 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15223 r0 *1 178.48,252.96
X$15223 105 4255 7122 7219 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15229 r0 *1 189.06,252.96
X$15229 40 5281 3400 7223 7222 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15232 r0 *1 202.4,252.96
X$15232 105 6707 105 40 7121 40 sky130_fd_sc_hd__buf_4
* cell instance $15240 r0 *1 211.14,252.96
X$15240 105 6271 6984 7183 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15241 r0 *1 212.52,252.96
X$15241 105 6876 4012 7165 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15242 r0 *1 213.9,252.96
X$15242 105 6876 7165 7221 105 40 7269 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15243 r0 *1 215.74,252.96
X$15243 105 7183 3157 7122 40 105 7221 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15245 r0 *1 218.04,252.96
X$15245 40 5281 3157 7046 7123 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15247 r0 *1 229.08,252.96
X$15247 105 7163 7185 4454 40 105 7910 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15248 r0 *1 230.92,252.96
X$15248 40 7125 6405 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $15252 r0 *1 236.44,252.96
X$15252 105 7162 4421 4258 7186 40 7214 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15253 r0 *1 239.2,252.96
X$15253 105 5694 7186 7214 40 105 7126 40 sky130_fd_sc_hd__a21o_1
* cell instance $15254 r0 *1 241.96,252.96
X$15254 105 7127 4524 4258 6990 40 7128 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15257 r0 *1 246.1,252.96
X$15257 105 7022 4454 7156 105 7127 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15259 r0 *1 248.86,252.96
X$15259 105 7072 7185 4676 40 105 7209 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15260 r0 *1 250.7,252.96
X$15260 40 7049 6405 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $15261 r0 *1 255.3,252.96
X$15261 105 7129 4524 6990 4525 40 7021 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15262 r0 *1 258.06,252.96
X$15262 105 6441 40 6983 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15264 r0 *1 260.82,252.96
X$15264 105 7022 4676 7151 105 7129 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15270 r0 *1 270.02,252.96
X$15270 40 7131 4602 7187 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $15271 r0 *1 274.16,252.96
X$15271 40 7150 7016 7187 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $15273 r0 *1 279.68,252.96
X$15273 105 7068 6845 7149 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $15275 r0 *1 283.36,252.96
X$15275 40 7000 5013 7149 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $15277 r0 *1 288.42,252.96
X$15277 40 40 7069 105 6755 7202 105 sky130_fd_sc_hd__nor2_2
* cell instance $15280 r0 *1 291.64,252.96
X$15280 40 7060 6052 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $15281 r0 *1 300.84,252.96
X$15281 40 6994 7132 7188 7052 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $15283 r0 *1 307.74,252.96
X$15283 40 6989 7134 5159 7189 5809 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $15285 r0 *1 315.56,252.96
X$15285 105 7061 40 105 7139 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $15287 r0 *1 319.24,252.96
X$15287 105 7004 6796 7137 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15289 r0 *1 321.08,252.96
X$15289 40 4382 7197 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $15291 r0 *1 325.68,252.96
X$15291 105 6851 7194 7135 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15292 r0 *1 327.06,252.96
X$15292 40 7016 7051 105 105 40 sky130_fd_sc_hd__buf_12
* cell instance $15293 r0 *1 334.42,252.96
X$15293 105 6607 6207 6194 40 105 6452 40 sky130_fd_sc_hd__a21o_1
* cell instance $15294 r0 *1 337.18,252.96
X$15294 40 7306 7191 6048 7192 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $15297 r0 *1 346.84,252.96
X$15297 105 6997 6925 7054 7248 105 7055 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $15325 m0 *1 3.22,258.4
X$15325 40 6740 7308 7171 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $15330 m0 *1 21.16,258.4
X$15330 40 7102 7101 6714 7104 7103 105 105 40 sky130_fd_sc_hd__a22oi_4
* cell instance $15332 m0 *1 29.44,258.4
X$15332 105 7224 7250 7313 105 7225 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15333 m0 *1 31.28,258.4
X$15333 105 7104 7101 7225 7286 7251 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15334 m0 *1 34.04,258.4
X$15334 105 7195 7226 7227 105 40 7136 40 sky130_fd_sc_hd__a21boi_1
* cell instance $15335 m0 *1 36.8,258.4
X$15335 105 7314 7252 7038 40 7097 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $15336 m0 *1 40.02,258.4
X$15336 105 7138 6251 7175 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $15337 m0 *1 43.24,258.4
X$15337 40 6251 5716 7138 7255 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $15340 m0 *1 50.6,258.4
X$15340 40 7138 7196 7037 7141 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $15346 m0 *1 67.16,258.4
X$15346 105 7228 7229 40 7256 105 40 sky130_fd_sc_hd__and2_4
* cell instance $15347 m0 *1 70.38,258.4
X$15347 40 7256 7228 7288 7230 7198 7142 105 105 40 sky130_fd_sc_hd__a221o_2
* cell instance $15348 m0 *1 74.52,258.4
X$15348 40 7257 7231 5865 7288 7232 7259 105 105 40 sky130_fd_sc_hd__a311oi_4
* cell instance $15352 m0 *1 88.78,258.4
X$15352 105 7200 7232 7233 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15353 m0 *1 90.16,258.4
X$15353 105 7233 7178 7232 6904 6978 7318 40 105 40 sky130_fd_sc_hd__a311o_1
* cell instance $15357 m0 *1 99.82,258.4
X$15357 40 7070 7612 7232 7067 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $15360 m0 *1 107.64,258.4
X$15360 105 6873 7148 6945 7203 7323 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15361 m0 *1 110.4,258.4
X$15361 105 7017 7234 7261 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15363 m0 *1 112.24,258.4
X$15363 105 7041 7111 6979 105 7179 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $15366 m0 *1 119.6,258.4
X$15366 40 5281 6784 7043 7325 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15367 m0 *1 130.18,258.4
X$15367 105 6910 6981 7327 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15369 m0 *1 133.4,258.4
X$15369 105 7241 7207 7235 105 40 7206 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15370 m0 *1 135.24,258.4
X$15370 105 7263 6434 7117 40 105 7235 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15371 m0 *1 137.08,258.4
X$15371 105 7291 4515 7263 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15375 m0 *1 140.3,258.4
X$15375 105 7241 7208 7236 105 40 7267 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15376 m0 *1 142.14,258.4
X$15376 105 7237 3212 7117 40 105 7236 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15378 m0 *1 144.44,258.4
X$15378 105 6908 4361 7237 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15380 m0 *1 146.74,258.4
X$15380 105 6955 4252 7211 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15381 m0 *1 148.12,258.4
X$15381 105 4255 6908 7270 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15382 m0 *1 149.5,258.4
X$15382 105 7334 6024 6985 40 105 7212 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15383 m0 *1 151.34,258.4
X$15383 40 40 7334 105 4098 6908 105 sky130_fd_sc_hd__nor2_2
* cell instance $15385 m0 *1 154.56,258.4
X$15385 105 3924 7118 7272 40 105 7292 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15386 m0 *1 156.4,258.4
X$15386 40 5281 6024 7092 7336 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15388 m0 *1 167.44,258.4
X$15388 40 6754 7092 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $15389 m0 *1 176.64,258.4
X$15389 105 7279 3214 7239 40 105 7278 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15390 m0 *1 178.48,258.4
X$15390 105 4189 7169 7339 40 105 7277 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15391 m0 *1 180.32,258.4
X$15391 105 7219 3329 7220 40 105 7281 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15393 m0 *1 183.08,258.4
X$15393 105 7182 7280 7402 105 40 7170 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15394 m0 *1 184.92,258.4
X$15394 105 6081 7124 7280 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15395 m0 *1 186.3,258.4
X$15395 105 7122 4188 7276 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15396 m0 *1 187.68,258.4
X$15396 105 7276 6081 7220 40 105 7275 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15398 m0 *1 189.98,258.4
X$15398 105 7182 7240 7274 105 40 7222 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15399 m0 *1 191.82,258.4
X$15399 105 4024 7169 7273 40 105 7274 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15402 m0 *1 195.04,258.4
X$15402 105 3400 7124 7240 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15406 m0 *1 201.48,258.4
X$15406 105 6987 105 40 7271 40 sky130_fd_sc_hd__inv_1
* cell instance $15407 m0 *1 202.86,258.4
X$15407 40 5281 6240 7046 7168 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15409 m0 *1 214.36,258.4
X$15409 105 6441 40 7241 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15410 m0 *1 217.12,258.4
X$15410 105 5133 7269 3930 7268 40 7184 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15417 m0 *1 225.86,258.4
X$15417 105 7416 6960 7266 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $15418 m0 *1 228.16,258.4
X$15418 105 5731 7265 6908 105 7264 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $15419 m0 *1 231.38,258.4
X$15419 40 7060 7046 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $15422 m0 *1 241.96,258.4
X$15422 105 7355 4495 7242 7243 7244 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15423 m0 *1 244.72,258.4
X$15423 105 7243 6078 7244 105 7331 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15424 m0 *1 246.56,258.4
X$15424 105 3362 6271 7242 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15427 m0 *1 250.24,258.4
X$15427 40 5281 3362 7046 7245 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15428 m0 *1 260.82,258.4
X$15428 105 7262 40 7243 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15430 m0 *1 264.04,258.4
X$15430 105 6271 40 7253 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15431 m0 *1 266.8,258.4
X$15431 105 6236 6985 7324 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15434 m0 *1 275.54,258.4
X$15434 105 7321 105 40 7131 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $15436 m0 *1 277.84,258.4
X$15436 40 7016 5138 7014 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $15437 m0 *1 282.9,258.4
X$15437 105 7260 7320 7246 4199 40 105 7319 40 sky130_fd_sc_hd__a31oi_1
* cell instance $15439 m0 *1 287.04,258.4
X$15439 40 7000 4993 7145 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $15440 m0 *1 292.1,258.4
X$15440 105 7258 6845 7202 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15442 m0 *1 295.32,258.4
X$15442 40 7051 7188 105 4760 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $15444 m0 *1 303.14,258.4
X$15444 105 6859 6817 6864 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15451 m0 *1 317.4,258.4
X$15451 105 6512 7239 7247 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15453 m0 *1 319.24,258.4
X$15453 40 7254 7253 7243 7247 4300 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $15454 m0 *1 323.84,258.4
X$15454 40 40 6795 105 7002 6746 105 sky130_fd_sc_hd__nor2_2
* cell instance $15456 m0 *1 327.98,258.4
X$15456 105 6525 6920 7194 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15457 m0 *1 329.36,258.4
X$15457 105 6794 6996 6912 6924 40 7248 105 40 sky130_fd_sc_hd__nor4b_1
* cell instance $15459 m0 *1 333.04,258.4
X$15459 40 5281 6512 6048 7249 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15460 m0 *1 343.62,258.4
X$15460 40 7192 4203 7191 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $15461 m0 *1 347.76,258.4
X$15461 105 6799 6373 40 105 40 sky130_fd_sc_hd__buf_1
* cell instance $15462 r0 *1 1.38,258.4
X$15462 105 7282 7307 7404 105 7032 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $15465 r0 *1 5.98,258.4
X$15465 105 7224 7369 7307 7308 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $15468 r0 *1 10.58,258.4
X$15468 105 7309 7282 7341 6712 105 7099 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $15470 r0 *1 13.34,258.4
X$15470 105 7059 7224 7283 40 105 6522 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15473 r0 *1 15.64,258.4
X$15473 40 6967 7312 7283 7226 7250 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $15475 r0 *1 23.92,258.4
X$15475 40 6889 7104 7286 7101 7284 7285 105 105 40 sky130_fd_sc_hd__o32a_1
* cell instance $15476 r0 *1 27.6,258.4
X$15476 40 7285 7286 7104 6458 7101 7284 105 105 40 sky130_fd_sc_hd__o32ai_4
* cell instance $15477 r0 *1 37.72,258.4
X$15477 105 7227 7282 6566 7195 40 7314 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15478 r0 *1 40.48,258.4
X$15478 40 40 7345 105 7379 7138 105 sky130_fd_sc_hd__nor2_2
* cell instance $15483 r0 *1 47.38,258.4
X$15483 40 6643 7315 7316 7317 7101 105 105 40 sky130_fd_sc_hd__a211o_4
* cell instance $15489 r0 *1 67.62,258.4
X$15489 105 7287 7199 7229 7198 40 7381 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15492 r0 *1 70.84,258.4
X$15492 40 7287 7256 7199 7346 7288 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $15494 r0 *1 80.5,258.4
X$15494 40 7289 7231 7259 7288 5865 7257 105 105 40 sky130_fd_sc_hd__a311o_4
* cell instance $15503 r0 *1 102.58,258.4
X$15503 105 7289 7070 6814 7386 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $15505 r0 *1 104.88,258.4
X$15505 105 7413 7070 7545 7322 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $15506 r0 *1 106.72,258.4
X$15506 40 7388 5984 6311 7148 7109 105 105 40 sky130_fd_sc_hd__a211o_2
* cell instance $15507 r0 *1 110.4,258.4
X$15507 40 7289 7109 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $15514 r0 *1 126.5,258.4
X$15514 105 6982 7326 7389 105 40 7325 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15515 r0 *1 128.34,258.4
X$15515 105 6784 6981 7326 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15517 r0 *1 130.18,258.4
X$15517 105 4721 7112 7290 40 105 7389 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15518 r0 *1 132.02,258.4
X$15518 105 7241 7328 7393 105 40 7290 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15519 r0 *1 133.86,258.4
X$15519 105 6955 4831 7328 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15520 r0 *1 135.24,258.4
X$15520 105 7330 6784 7117 40 105 7393 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15521 r0 *1 137.08,258.4
X$15521 105 7291 4805 7330 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15523 r0 *1 138.92,258.4
X$15523 40 40 7349 105 4517 7291 105 sky130_fd_sc_hd__nor2_2
* cell instance $15524 r0 *1 141.22,258.4
X$15524 40 40 7397 105 4906 7291 105 sky130_fd_sc_hd__nor2_2
* cell instance $15527 r0 *1 144.9,258.4
X$15527 105 4670 7291 7333 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15528 r0 *1 146.28,258.4
X$15528 40 40 7398 105 5179 7291 105 sky130_fd_sc_hd__nor2_2
* cell instance $15531 r0 *1 150.42,258.4
X$15531 105 6441 40 6955 105 40 sky130_fd_sc_hd__buf_2
* cell instance $15535 r0 *1 154.1,258.4
X$15535 105 7416 40 6981 105 40 sky130_fd_sc_hd__buf_2
* cell instance $15537 r0 *1 156.4,258.4
X$15537 105 7293 7337 7292 105 40 7336 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15538 r0 *1 158.24,258.4
X$15538 105 7241 4020 7213 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15540 r0 *1 163.3,258.4
X$15540 40 7092 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $15541 r0 *1 174.34,258.4
X$15541 105 7122 4017 7279 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15542 r0 *1 175.72,258.4
X$15542 105 7238 7353 7278 105 40 7217 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15544 r0 *1 177.56,258.4
X$15544 105 7294 3926 7353 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15545 r0 *1 178.94,258.4
X$15545 105 7238 7295 7281 105 40 7339 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15547 r0 *1 181.24,258.4
X$15547 105 7294 4252 7295 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15549 r0 *1 184.46,258.4
X$15549 105 4102 7169 7296 40 105 7402 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15550 r0 *1 186.3,258.4
X$15550 105 7238 7401 7275 105 40 7296 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15554 r0 *1 191.36,258.4
X$15554 105 7294 4364 7297 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15555 r0 *1 192.74,258.4
X$15555 105 7238 7297 7400 105 40 7273 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15556 r0 *1 194.58,258.4
X$15556 105 3989 7122 7298 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15557 r0 *1 195.96,258.4
X$15557 105 7298 3400 7220 40 105 7400 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15560 r0 *1 201.94,258.4
X$15560 105 6240 7124 7340 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15561 r0 *1 203.32,258.4
X$15561 105 7182 7340 7399 105 40 7168 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15563 r0 *1 205.16,258.4
X$15563 105 4420 7169 7299 40 105 7399 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15567 r0 *1 208.84,258.4
X$15567 105 6876 40 7238 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15568 r0 *1 211.6,258.4
X$15568 105 6705 40 6908 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15571 r0 *1 215.74,258.4
X$15571 105 6271 40 7355 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15572 r0 *1 218.5,258.4
X$15572 40 5281 3274 7046 7338 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15573 r0 *1 229.08,258.4
X$15573 40 7335 3488 7391 3138 6908 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $15578 r0 *1 236.44,258.4
X$15578 40 5281 3138 7046 7332 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15579 r0 *1 247.02,258.4
X$15579 105 3362 7425 7329 40 105 7245 40 sky130_fd_sc_hd__a21o_1
* cell instance $15580 r0 *1 249.78,258.4
X$15580 105 7291 4602 7300 6960 7361 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15582 r0 *1 253.46,258.4
X$15582 40 5281 7564 105 105 40 sky130_fd_sc_hd__buf_16
* cell instance $15586 r0 *1 264.96,258.4
X$15586 40 7385 7430 6960 7324 4372 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $15587 r0 *1 269.56,258.4
X$15587 40 5281 6395 6052 7382 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15588 r0 *1 280.14,258.4
X$15588 40 7321 7150 105 105 40 sky130_fd_sc_hd__dlymetal6s4s_1
* cell instance $15589 r0 *1 284.74,258.4
X$15589 40 7320 7253 7243 7301 4372 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $15591 r0 *1 289.34,258.4
X$15591 105 6555 7239 7301 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15595 r0 *1 292.56,258.4
X$15595 105 7186 7456 7363 105 40 7380 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15597 r0 *1 296.24,258.4
X$15597 40 7364 4535 6960 7302 7430 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $15598 r0 *1 300.84,258.4
X$15598 105 7364 7378 5302 4534 40 105 7363 40 sky130_fd_sc_hd__a31oi_1
* cell instance $15601 r0 *1 304.52,258.4
X$15601 105 6369 7293 7366 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15602 r0 *1 305.9,258.4
X$15602 105 7303 4271 7377 7304 7431 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15603 r0 *1 308.66,258.4
X$15603 105 7186 7451 7366 105 7376 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15607 r0 *1 314.64,258.4
X$15607 105 6467 7239 7305 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15611 r0 *1 319.24,258.4
X$15611 40 7375 4535 7243 7305 7253 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $15612 r0 *1 323.84,258.4
X$15612 105 7238 4266 7374 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15613 r0 *1 325.22,258.4
X$15613 105 7238 4459 7373 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15615 r0 *1 327.52,258.4
X$15615 40 5281 6467 6048 7371 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15617 r0 *1 339.02,258.4
X$15617 105 6855 40 105 7310 40 sky130_fd_sc_hd__dlygate4sd1_1
* cell instance $15619 r0 *1 342.24,258.4
X$15619 40 6289 6199 7311 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $15621 r0 *1 346.84,258.4
X$15621 105 6207 7439 6923 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15652 m0 *1 4.6,263.84
X$15652 40 7438 7171 7437 7282 7404 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $15654 m0 *1 9.66,263.84
X$15654 40 7441 7309 7341 7282 6635 6711 105 105 40 sky130_fd_sc_hd__a311oi_2
* cell instance $15655 m0 *1 15.18,263.84
X$15655 40 6890 7312 6711 7283 7282 7250 105 105 40 sky130_fd_sc_hd__a2111oi_2
* cell instance $15657 m0 *1 21.62,263.84
X$15657 40 7227 7226 105 7101 105 40 sky130_fd_sc_hd__nand2_8
* cell instance $15660 m0 *1 30.36,263.84
X$15660 105 7342 7286 7104 7443 105 7444 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $15661 m0 *1 33.58,263.84
X$15661 105 7313 7282 7227 40 105 7342 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15663 m0 *1 35.88,263.84
X$15663 105 7343 7195 7250 105 40 6973 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15664 m0 *1 37.72,263.84
X$15664 105 7343 7344 7250 7105 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $15665 m0 *1 39.56,263.84
X$15665 40 7255 7104 7345 7344 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $15666 m0 *1 47.84,263.84
X$15666 105 7317 7101 7316 7315 40 7036 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15676 m0 *1 63.94,263.84
X$15676 40 7447 6839 7443 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $15678 m0 *1 69.92,263.84
X$15678 105 7229 7198 7541 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $15679 m0 *1 72.22,263.84
X$15679 40 7383 7228 7229 7199 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $15681 m0 *1 76.36,263.84
X$15681 105 7228 7229 7199 7409 7257 105 7448 40 40 sky130_fd_sc_hd__o2111ai_1
* cell instance $15687 m0 *1 90.16,263.84
X$15687 105 5720 7383 7410 7347 105 40 7412 40 sky130_fd_sc_hd__o31ai_1
* cell instance $15689 m0 *1 93.84,263.84
X$15689 40 7257 7409 1760 7323 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $15691 m0 *1 100.28,263.84
X$15691 105 5126 105 40 7347 40 sky130_fd_sc_hd__buf_4
* cell instance $15692 m0 *1 103.04,263.84
X$15692 40 7453 7386 5984 6311 105 105 40 sky130_fd_sc_hd__a21boi_4
* cell instance $15693 m0 *1 109.94,263.84
X$15693 105 7148 6311 5984 40 105 7455 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15698 m0 *1 118.22,263.84
X$15698 40 5281 6910 7043 7390 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15699 m0 *1 128.8,263.84
X$15699 105 6982 7327 7348 105 40 7390 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15700 m0 *1 130.64,263.84
X$15700 105 4420 7112 7414 40 105 7348 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15701 m0 *1 132.48,263.84
X$15701 105 6955 4828 7392 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15702 m0 *1 133.86,263.84
X$15702 105 7241 7394 7395 105 40 7414 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15703 m0 *1 135.7,263.84
X$15703 105 6955 4521 7394 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15705 m0 *1 137.54,263.84
X$15705 105 7349 6910 7117 40 105 7395 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15707 m0 *1 139.84,263.84
X$15707 105 7241 7351 7350 105 40 7415 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15708 m0 *1 141.68,263.84
X$15708 105 7397 5423 7117 40 105 7458 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15711 m0 *1 144.9,263.84
X$15711 105 7333 7045 7117 40 105 7461 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15712 m0 *1 146.74,263.84
X$15712 105 7398 6387 7117 40 105 7350 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15713 m0 *1 148.58,263.84
X$15713 105 6441 4986 7351 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15715 m0 *1 153.64,263.84
X$15715 105 6705 40 7117 105 40 sky130_fd_sc_hd__buf_2
* cell instance $15722 m0 *1 168.36,263.84
X$15722 105 6705 105 40 6985 40 sky130_fd_sc_hd__buf_4
* cell instance $15723 m0 *1 171.12,263.84
X$15723 105 7182 7167 7216 105 40 7215 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15724 m0 *1 172.96,263.84
X$15724 105 3924 7169 7417 40 105 7403 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15725 m0 *1 174.8,263.84
X$15725 105 7182 7352 7403 105 40 7464 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15727 m0 *1 177.56,263.84
X$15727 105 7238 7419 7354 105 40 7417 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15728 m0 *1 179.4,263.84
X$15728 105 7466 3284 7239 40 105 7354 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15732 m0 *1 186.3,263.84
X$15732 105 4183 7294 7401 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15736 m0 *1 192.74,263.84
X$15736 105 6843 7124 7420 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15739 m0 *1 195.04,263.84
X$15739 105 7470 6843 7220 40 105 7422 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15740 m0 *1 196.88,263.84
X$15740 105 4361 7122 7470 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15743 m0 *1 200.56,263.84
X$15743 105 7294 4521 7356 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15744 m0 *1 201.94,263.84
X$15744 105 4517 7355 7423 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15745 m0 *1 203.32,263.84
X$15745 105 7423 6240 7220 40 105 7357 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15746 m0 *1 205.16,263.84
X$15746 105 7418 7356 7357 105 40 7299 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15747 m0 *1 207,263.84
X$15747 105 6876 40 7294 105 40 sky130_fd_sc_hd__buf_2
* cell instance $15750 m0 *1 211.14,263.84
X$15750 105 6271 40 7220 105 40 sky130_fd_sc_hd__buf_2
* cell instance $15753 m0 *1 215.74,263.84
X$15753 105 6271 40 7122 105 40 sky130_fd_sc_hd__buf_2
* cell instance $15755 m0 *1 219.42,263.84
X$15755 105 6271 105 40 7239 40 sky130_fd_sc_hd__buf_4
* cell instance $15757 m0 *1 222.64,263.84
X$15757 105 3781 7416 7424 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15758 m0 *1 224.02,263.84
X$15758 40 7266 7396 3736 7358 6441 105 105 40 sky130_fd_sc_hd__o22ai_2
* cell instance $15760 m0 *1 229.08,263.84
X$15760 105 6983 7391 3438 7266 7471 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $15761 m0 *1 231.38,263.84
X$15761 40 7046 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $15762 m0 *1 242.42,263.84
X$15762 105 7331 4421 4258 7268 40 7329 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15763 m0 *1 245.18,263.84
X$15763 105 7355 4602 7468 7243 7359 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15764 m0 *1 247.94,263.84
X$15764 105 7243 7071 7359 105 7467 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15766 m0 *1 250.24,263.84
X$15766 105 7467 4524 7268 4525 40 7360 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15767 m0 *1 253,263.84
X$15767 105 6960 7071 7361 105 7465 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15768 m0 *1 254.84,263.84
X$15768 105 5733 6705 7300 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15769 m0 *1 256.22,263.84
X$15769 40 5281 6236 7427 7387 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15770 m0 *1 266.8,263.84
X$15770 105 7505 7385 5302 4199 40 105 7384 40 sky130_fd_sc_hd__a31oi_1
* cell instance $15772 m0 *1 269.56,263.84
X$15772 105 6705 40 7303 105 40 sky130_fd_sc_hd__buf_2
* cell instance $15773 m0 *1 271.4,263.84
X$15773 105 7186 7428 7463 105 7382 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15775 m0 *1 273.7,263.84
X$15775 105 7362 7460 5302 4529 40 105 7428 40 sky130_fd_sc_hd__a31oi_1
* cell instance $15780 m0 *1 278.76,263.84
X$15780 105 7238 4455 7260 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15783 m0 *1 281.52,263.84
X$15783 40 5281 6555 6052 7457 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15784 m0 *1 292.1,263.84
X$15784 40 5281 6306 6052 7380 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15785 m0 *1 302.68,263.84
X$15785 105 6983 4459 7378 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15788 m0 *1 305.44,263.84
X$15788 105 6369 6985 7377 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15789 m0 *1 306.82,263.84
X$15789 40 5281 6369 7365 7376 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15790 m0 *1 317.4,263.84
X$15790 105 6188 7239 7449 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15792 m0 *1 319.7,263.84
X$15792 105 7238 4458 7446 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15793 m0 *1 321.08,263.84
X$15793 105 7238 4273 7445 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15794 m0 *1 322.46,263.84
X$15794 105 7246 7254 7374 4265 40 105 7367 40 sky130_fd_sc_hd__a31oi_1
* cell instance $15795 m0 *1 324.76,263.84
X$15795 105 7375 7373 7246 4534 40 105 7434 40 sky130_fd_sc_hd__a31oi_1
* cell instance $15796 m0 *1 327.06,263.84
X$15796 105 7425 7372 7434 105 40 7371 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15797 m0 *1 328.9,263.84
X$15797 105 6467 7368 7372 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15799 m0 *1 330.74,263.84
X$15799 105 7425 7370 7367 105 40 7249 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15801 m0 *1 333.04,263.84
X$15801 105 6512 7368 7370 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15804 m0 *1 335.8,263.84
X$15804 105 6048 9483 105 40 40 sky130_fd_sc_hd__inv_6
* cell instance $15805 m0 *1 339.02,263.84
X$15805 40 5281 7306 105 105 40 sky130_fd_sc_hd__buf_16
* cell instance $15808 r0 *1 2.3,263.84
X$15808 105 7171 7437 7404 7282 40 105 7405 40 sky130_fd_sc_hd__and4_1
* cell instance $15809 r0 *1 5.52,263.84
X$15809 40 7405 7569 7172 6856 7438 7441 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $15813 r0 *1 16.56,263.84
X$15813 105 7312 7282 7250 40 105 6742 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15814 r0 *1 18.4,263.84
X$15814 105 7226 40 7282 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15816 r0 *1 21.62,263.84
X$15816 40 7224 7227 7442 7309 105 6800 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $15817 r0 *1 29.44,263.84
X$15817 105 7406 7286 7285 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $15819 r0 *1 33.58,263.84
X$15819 105 7406 7407 105 7313 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $15821 r0 *1 37.72,263.84
X$15821 40 7195 7345 7255 105 7407 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $15835 r0 *1 73.14,263.84
X$15835 105 7229 7199 7580 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15836 r0 *1 74.52,263.84
X$15836 40 40 7450 7287 7408 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $15839 r0 *1 78.2,263.84
X$15839 40 7231 7448 5126 7408 7450 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $15842 r0 *1 86.94,263.84
X$15842 40 7411 7259 5720 7410 7383 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $15843 r0 *1 94.76,263.84
X$15843 105 7257 7412 7409 7503 40 105 40 sky130_fd_sc_hd__nand3b_1
* cell instance $15847 r0 *1 98.44,263.84
X$15847 105 7409 5126 7411 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $15848 r0 *1 100.74,263.84
X$15848 105 7109 7011 7543 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15850 r0 *1 105.8,263.84
X$15850 40 7413 7504 6311 7454 7148 5984 105 105 40 sky130_fd_sc_hd__a2111oi_0
* cell instance $15852 r0 *1 109.94,263.84
X$15852 105 7289 105 40 7413 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $15861 r0 *1 126.96,263.84
X$15861 40 6754 7043 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $15863 r0 *1 137.08,263.84
X$15863 105 5050 7112 7415 40 105 7512 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15864 r0 *1 138.92,263.84
X$15864 105 4747 7291 7586 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15866 r0 *1 141.22,263.84
X$15866 105 7241 7513 7458 105 40 7459 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15867 r0 *1 143.06,263.84
X$15867 105 6441 5031 7513 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15868 r0 *1 144.44,263.84
X$15868 105 7241 7516 7461 105 40 7514 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15869 r0 *1 146.28,263.84
X$15869 105 6441 4667 7516 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15875 r0 *1 157.32,263.84
X$15875 105 7416 105 40 7293 40 sky130_fd_sc_hd__buf_4
* cell instance $15877 r0 *1 161,263.84
X$15877 40 5281 3284 7092 7464 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15879 r0 *1 172.04,263.84
X$15879 105 3284 7124 7352 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15880 r0 *1 173.42,263.84
X$15880 105 5048 40 7118 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15881 r0 *1 176.18,263.84
X$15881 105 7418 4020 7419 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15883 r0 *1 177.56,263.84
X$15883 40 40 7466 105 7122 4098 105 sky130_fd_sc_hd__nor2_2
* cell instance $15886 r0 *1 181.24,263.84
X$15886 105 4515 7355 7526 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15887 r0 *1 182.62,263.84
X$15887 105 4805 7355 7482 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15888 r0 *1 184,263.84
X$15888 105 7294 4831 7528 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15892 r0 *1 190.44,263.84
X$15892 105 7355 4747 7485 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15893 r0 *1 191.82,263.84
X$15893 105 7182 7420 7486 105 40 7469 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15894 r0 *1 193.66,263.84
X$15894 105 4097 7169 7421 40 105 7486 40 sky130_fd_sc_hd__a21oi_1
* cell instance $15895 r0 *1 195.5,263.84
X$15895 40 5281 6843 7223 7469 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $15898 r0 *1 207,263.84
X$15898 105 6876 4667 7522 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15900 r0 *1 208.84,263.84
X$15900 105 7355 4670 7588 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $15903 r0 *1 214.36,263.84
X$15903 105 6876 4986 7521 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15904 r0 *1 215.74,263.84
X$15904 40 40 7487 105 7355 5179 105 sky130_fd_sc_hd__nor2_2
* cell instance $15907 r0 *1 219.42,263.84
X$15907 105 7268 40 7124 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15909 r0 *1 222.64,263.84
X$15909 40 7396 3274 7338 7424 3530 7416 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $15910 r0 *1 226.32,263.84
X$15910 40 3778 7335 7358 3274 7291 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $15911 r0 *1 230.92,263.84
X$15911 40 7471 3138 7332 7517 4421 7416 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $15913 r0 *1 234.6,263.84
X$15913 105 6441 4874 7515 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15915 r0 *1 236.44,263.84
X$15915 40 7291 7265 4881 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $15916 r0 *1 240.58,263.84
X$15916 105 6705 40 7291 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15918 r0 *1 245.18,263.84
X$15918 105 7268 40 7425 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15919 r0 *1 247.94,263.84
X$15919 105 5920 6271 7468 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15921 r0 *1 249.78,263.84
X$15921 105 5920 7268 7360 40 105 7511 40 sky130_fd_sc_hd__a21o_1
* cell instance $15922 r0 *1 252.54,263.84
X$15922 105 5733 7186 7426 40 105 7509 40 sky130_fd_sc_hd__a21o_1
* cell instance $15923 r0 *1 255.3,263.84
X$15923 105 7465 4524 7186 4525 40 7426 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $15927 r0 *1 260.36,263.84
X$15927 105 7186 7507 7384 105 40 7387 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15928 r0 *1 262.2,263.84
X$15928 105 6236 7293 7507 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15930 r0 *1 264.04,263.84
X$15930 105 6271 40 7432 105 40 sky130_fd_sc_hd__buf_2
* cell instance $15932 r0 *1 266.8,263.84
X$15932 105 6983 4455 7505 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15933 r0 *1 268.18,263.84
X$15933 105 6705 40 7430 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15934 r0 *1 270.94,263.84
X$15934 105 6395 7293 7463 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15935 r0 *1 272.32,263.84
X$15935 105 7462 4458 7460 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15937 r0 *1 274.62,263.84
X$15937 105 7303 4620 7502 7304 7362 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15938 r0 *1 277.38,263.84
X$15938 105 6395 6985 7502 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15941 r0 *1 281.52,263.84
X$15941 105 7425 7501 7319 105 40 7457 40 sky130_fd_sc_hd__o21ai_1
* cell instance $15942 r0 *1 283.36,263.84
X$15942 105 6555 7368 7501 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15944 r0 *1 285.2,263.84
X$15944 105 6960 40 7304 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $15952 r0 *1 293.94,263.84
X$15952 105 6306 7293 7456 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15953 r0 *1 295.32,263.84
X$15953 105 6306 6985 7302 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15955 r0 *1 297.16,263.84
X$15955 40 7488 7430 6960 7429 4300 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $15956 r0 *1 301.76,263.84
X$15956 40 40 6983 7498 4266 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $15957 r0 *1 304.06,263.84
X$15957 105 5596 6985 7429 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15958 r0 *1 305.44,263.84
X$15958 105 5595 6985 7497 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15960 r0 *1 307.28,263.84
X$15960 105 7431 7452 5302 4270 40 105 7451 40 sky130_fd_sc_hd__a31oi_1
* cell instance $15961 r0 *1 309.58,263.84
X$15961 105 7462 4273 7452 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15966 r0 *1 316.02,263.84
X$15966 105 7432 4620 7449 7243 7433 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $15969 r0 *1 319.7,263.84
X$15969 105 7433 7446 7246 4529 40 105 7493 40 sky130_fd_sc_hd__a31oi_1
* cell instance $15971 r0 *1 322.92,263.84
X$15971 105 7494 7445 7246 4270 40 105 7489 40 sky130_fd_sc_hd__a31oi_1
* cell instance $15975 r0 *1 328.44,263.84
X$15975 105 7425 7489 7491 105 7440 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $15976 r0 *1 330.28,263.84
X$15976 105 6303 7368 7491 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $15978 r0 *1 332.58,263.84
X$15978 40 5281 6303 6048 7440 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $15980 r0 *1 342.24,263.84
X$15980 40 7490 6555 7436 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $15982 r0 *1 346.84,263.84
X$15982 105 6121 7568 7439 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16013 m0 *1 7.82,269.28
X$16013 105 7472 7369 7437 7096 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16014 m0 *1 9.66,269.28
X$16014 40 7472 7473 7283 7001 6635 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $16015 m0 *1 14.26,269.28
X$16015 105 7472 7473 7283 7059 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16019 m0 *1 19.32,269.28
X$16019 40 7474 7472 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $16020 m0 *1 23.46,269.28
X$16020 105 7474 105 40 7224 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $16022 m0 *1 25.76,269.28
X$16022 105 7474 7250 7572 40 7284 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $16024 m0 *1 29.44,269.28
X$16024 105 7224 7442 7227 105 40 6644 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16025 m0 *1 31.28,269.28
X$16025 105 7407 40 105 7572 40 sky130_fd_sc_hd__inv_2
* cell instance $16027 m0 *1 33.58,269.28
X$16027 40 7536 7737 1760 105 7534 105 40 sky130_fd_sc_hd__ha_1
* cell instance $16028 m0 *1 38.18,269.28
X$16028 105 7282 7534 7227 7006 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $16029 m0 *1 40.02,269.28
X$16029 105 7344 105 40 7534 40 sky130_fd_sc_hd__inv_1
* cell instance $16031 m0 *1 41.86,269.28
X$16031 40 7379 6566 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $16034 m0 *1 48.3,269.28
X$16034 40 6771 7574 7575 7101 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $16035 m0 *1 52.44,269.28
X$16035 105 7443 7475 7538 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16037 m0 *1 54.74,269.28
X$16037 105 7496 7495 7539 7576 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16045 m0 *1 74.52,269.28
X$16045 105 7580 7408 7450 40 105 7499 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16046 m0 *1 76.36,269.28
X$16046 40 7542 7541 7499 7381 7289 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $16047 m0 *1 79.58,269.28
X$16047 40 7609 7500 7645 7257 105 7410 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $16049 m0 *1 84.64,269.28
X$16049 40 7500 7581 7476 2532 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $16050 m0 *1 90.16,269.28
X$16050 105 7257 7259 7477 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16051 m0 *1 91.54,269.28
X$16051 40 7478 7503 7477 7346 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $16052 m0 *1 95.68,269.28
X$16052 40 7503 7582 7477 7346 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $16053 m0 *1 103.96,269.28
X$16053 105 7478 7454 7584 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16054 m0 *1 105.34,269.28
X$16054 105 7584 7504 7347 7479 40 7583 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $16056 m0 *1 108.1,269.28
X$16056 105 7203 6945 7413 7454 40 7479 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $16060 m0 *1 115.92,269.28
X$16060 40 5281 6387 7043 7548 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16062 m0 *1 126.96,269.28
X$16062 105 7043 9498 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $16063 m0 *1 128.8,269.28
X$16063 105 6387 7585 7480 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16064 m0 *1 130.18,269.28
X$16064 105 4722 7112 7549 40 105 7508 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16065 m0 *1 132.02,269.28
X$16065 105 7241 7392 7510 105 40 7549 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16066 m0 *1 133.86,269.28
X$16066 105 7586 6436 7117 40 105 7510 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16067 m0 *1 135.7,269.28
X$16067 105 7616 7480 7512 105 40 7548 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16068 m0 *1 137.54,269.28
X$16068 105 7481 105 40 6982 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $16072 m0 *1 142.6,269.28
X$16072 105 4665 7112 7514 40 105 7668 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16073 m0 *1 144.44,269.28
X$16073 105 4904 7112 7459 40 105 7587 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16075 m0 *1 147.2,269.28
X$16075 105 7481 40 7416 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16076 m0 *1 149.96,269.28
X$16076 105 7416 105 40 7585 40 sky130_fd_sc_hd__buf_4
* cell instance $16077 m0 *1 152.72,269.28
X$16077 40 5281 3174 7092 7519 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16080 m0 *1 167.44,269.28
X$16080 40 5281 6831 7223 7674 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $16082 m0 *1 178.02,269.28
X$16082 105 7294 4518 7524 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16083 m0 *1 179.4,269.28
X$16083 105 7526 6831 7220 40 105 7525 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16084 m0 *1 181.24,269.28
X$16084 105 7482 6729 7220 40 105 7553 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16087 m0 *1 184.46,269.28
X$16087 105 7182 7483 7679 105 40 7591 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16090 m0 *1 187.68,269.28
X$16090 105 7294 4828 7484 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16091 m0 *1 189.06,269.28
X$16091 105 7418 7484 7529 105 40 7592 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16092 m0 *1 190.9,269.28
X$16092 105 7485 6701 7220 40 105 7529 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16095 m0 *1 195.04,269.28
X$16095 105 7223 105 40 9514 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $16096 m0 *1 197.8,269.28
X$16096 105 7418 7527 7422 105 40 7421 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16097 m0 *1 199.64,269.28
X$16097 105 7294 4184 7527 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16098 m0 *1 201.02,269.28
X$16098 105 7294 5031 7688 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16099 m0 *1 202.4,269.28
X$16099 105 7355 4906 7589 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16103 m0 *1 207,269.28
X$16103 105 7418 7522 7523 105 40 7555 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16104 m0 *1 208.84,269.28
X$16104 105 7588 6911 7220 40 105 7523 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16106 m0 *1 211.6,269.28
X$16106 105 6876 40 7418 105 40 sky130_fd_sc_hd__buf_2
* cell instance $16107 m0 *1 213.44,269.28
X$16107 105 7418 7521 7520 105 40 7557 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16108 m0 *1 215.28,269.28
X$16108 105 7487 6587 7122 40 105 7520 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16116 m0 *1 227.7,269.28
X$16116 105 6705 7416 7335 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16117 m0 *1 229.08,269.28
X$16117 105 7416 3616 7517 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16119 m0 *1 231.38,269.28
X$16119 105 7561 6789 7122 40 105 7518 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16120 m0 *1 233.22,269.28
X$16120 105 7416 40 7186 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16121 m0 *1 235.98,269.28
X$16121 105 7241 7264 7515 40 7722 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $16123 m0 *1 239.66,269.28
X$16123 40 7563 7678 7268 3736 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $16125 m0 *1 243.8,269.28
X$16125 105 7243 40 7563 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16131 m0 *1 251.16,269.28
X$16131 40 7564 5733 7427 7509 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16133 m0 *1 263.58,269.28
X$16133 105 6441 40 7462 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16134 m0 *1 266.34,269.28
X$16134 105 5961 7253 7506 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16135 m0 *1 267.72,269.28
X$16135 105 6589 7253 7567 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16136 m0 *1 269.1,269.28
X$16136 105 7565 5063 7764 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16149 m0 *1 298.54,269.28
X$16149 105 5302 7488 7498 4265 40 105 7579 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16152 m0 *1 303.6,269.28
X$16152 105 7462 4608 7577 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16155 m0 *1 305.9,269.28
X$16155 105 7303 4855 7497 7304 7573 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $16160 m0 *1 318.32,269.28
X$16160 105 6303 7239 7571 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16161 m0 *1 319.7,269.28
X$16161 105 7432 4271 7571 7243 7494 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $16164 m0 *1 325.22,269.28
X$16164 105 7425 7493 7492 105 7570 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $16165 m0 *1 327.06,269.28
X$16165 105 6188 7368 7492 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16173 m0 *1 339.94,269.28
X$16173 40 7306 7436 6048 7490 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $16175 r0 *1 3.22,269.28
X$16175 105 7530 7531 7593 105 6561 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $16176 r0 *1 5.98,269.28
X$16176 105 7530 7531 7532 7533 7593 7594 105 40 40 sky130_fd_sc_hd__o221ai_1
* cell instance $16177 r0 *1 9.2,269.28
X$16177 105 7533 7532 6635 105 40 40 sky130_fd_sc_hd__or2_2
* cell instance $16178 r0 *1 11.5,269.28
X$16178 105 7594 7473 7472 7283 40 7569 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $16186 r0 *1 16.1,269.28
X$16186 40 7316 7309 7341 7226 7802 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $16188 r0 *1 21.16,269.28
X$16188 40 7250 7472 7443 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $16189 r0 *1 28.52,269.28
X$16189 40 7572 7632 7102 7631 105 105 40 sky130_fd_sc_hd__nor3b_4
* cell instance $16192 r0 *1 38.18,269.28
X$16192 40 7600 6929 7535 7250 7474 105 105 40 sky130_fd_sc_hd__o22ai_2
* cell instance $16197 r0 *1 43.24,269.28
X$16197 105 7536 7535 7602 105 7635 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $16200 r0 *1 48.76,269.28
X$16200 105 7603 7537 7574 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16201 r0 *1 50.14,269.28
X$16201 105 7604 7605 7636 7537 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16202 r0 *1 51.98,269.28
X$16202 40 7636 7443 7576 6895 7538 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $16203 r0 *1 56.58,269.28
X$16203 105 7443 7638 7540 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16204 r0 *1 57.96,269.28
X$16204 40 7539 7443 7640 6931 7540 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $16205 r0 *1 62.56,269.28
X$16205 105 7447 7641 7608 7642 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16213 r0 *1 70.84,269.28
X$16213 105 7499 7142 7228 7541 40 7643 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $16215 r0 *1 73.6,269.28
X$16215 40 7743 7142 7541 7499 7228 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $16218 r0 *1 82.34,269.28
X$16218 105 7500 7581 7646 105 7450 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $16219 r0 *1 85.56,269.28
X$16219 40 7647 7476 7648 7109 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $16222 r0 *1 95.22,269.28
X$16222 105 7542 7543 7650 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16226 r0 *1 96.6,269.28
X$16226 105 7545 7542 7544 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16228 r0 *1 98.44,269.28
X$16228 40 7544 7545 7413 7845 7011 7651 105 105 40 sky130_fd_sc_hd__o32ai_4
* cell instance $16229 r0 *1 108.56,269.28
X$16229 40 7546 7547 7613 7658 7455 105 105 40 sky130_fd_sc_hd__o2bb2ai_4
* cell instance $16238 r0 *1 126.04,269.28
X$16238 40 5281 5423 7043 7615 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16239 r0 *1 136.62,269.28
X$16239 105 6982 7665 7587 105 40 7615 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16241 r0 *1 139.38,269.28
X$16241 105 5423 7585 7665 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16243 r0 *1 141.68,269.28
X$16243 40 5281 7045 7043 7667 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16251 r0 *1 155.94,269.28
X$16251 105 3174 7550 7670 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16254 r0 *1 160.08,269.28
X$16254 40 5281 3048 7092 7761 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16256 r0 *1 171.12,269.28
X$16256 105 7182 7675 7551 105 40 7674 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16257 r0 *1 172.96,269.28
X$16257 105 6831 7124 7675 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16259 r0 *1 175.26,269.28
X$16259 105 4514 7169 7552 40 105 7551 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16264 r0 *1 177.56,269.28
X$16264 105 7418 7524 7525 105 40 7552 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16268 r0 *1 181.24,269.28
X$16268 105 7418 7528 7553 105 40 7554 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16271 r0 *1 184.46,269.28
X$16271 40 7564 6729 7223 7591 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16272 r0 *1 195.04,269.28
X$16272 40 6754 7223 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $16273 r0 *1 204.24,269.28
X$16273 105 7418 7688 7692 105 40 7590 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16277 r0 *1 206.08,269.28
X$16277 105 7589 7094 7220 40 105 7692 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16280 r0 *1 208.84,269.28
X$16280 105 4665 7118 7555 40 105 7693 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16282 r0 *1 211.6,269.28
X$16282 105 5050 7118 7557 40 105 7695 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16283 r0 *1 213.44,269.28
X$16283 105 7556 7696 7695 105 40 7767 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16284 r0 *1 215.28,269.28
X$16284 105 6587 7558 7696 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16285 r0 *1 216.66,269.28
X$16285 105 7559 40 7182 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16287 r0 *1 220.34,269.28
X$16287 105 7268 40 7558 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16289 r0 *1 224.94,269.28
X$16289 105 3781 7124 7686 7560 7689 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $16290 r0 *1 227.7,269.28
X$16290 105 7122 7559 7562 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16292 r0 *1 230,269.28
X$16292 105 7518 7685 7418 105 40 7684 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16296 r0 *1 231.84,269.28
X$16296 105 6876 4874 7685 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16297 r0 *1 233.22,269.28
X$16297 105 7562 3778 3552 7239 105 7681 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $16300 r0 *1 237.36,269.28
X$16300 105 3488 7562 3441 7239 105 7680 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $16301 r0 *1 240.12,269.28
X$16301 105 7678 3770 7677 105 40 7560 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16302 r0 *1 241.96,269.28
X$16302 105 7563 7268 3438 7676 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16303 r0 *1 243.8,269.28
X$16303 105 3441 7182 7620 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16305 r0 *1 245.64,269.28
X$16305 40 7564 5920 7046 7511 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16308 r0 *1 257.6,269.28
X$16308 105 6876 40 7565 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16312 r0 *1 260.36,269.28
X$16312 105 7556 7671 7666 105 40 7566 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16313 r0 *1 262.2,269.28
X$16313 105 5961 7558 7671 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16316 r0 *1 264.96,269.28
X$16316 40 7664 7432 7563 7567 4870 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16317 r0 *1 269.56,269.28
X$16317 40 5281 6589 7427 7623 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16318 r0 *1 280.14,269.28
X$16318 105 7556 7660 7656 105 40 7661 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16319 r0 *1 281.98,269.28
X$16319 105 6697 7558 7660 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16320 r0 *1 283.36,269.28
X$16320 105 6697 7253 7659 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16325 r0 *1 286.58,269.28
X$16325 40 7655 7432 7563 7654 4993 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16327 r0 *1 291.64,269.28
X$16327 105 7565 4946 7652 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16328 r0 *1 293.02,269.28
X$16328 105 6546 7253 7758 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16329 r0 *1 294.4,269.28
X$16329 105 7565 4685 7649 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16332 r0 *1 299.92,269.28
X$16332 105 7186 7579 7578 40 7644 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $16333 r0 *1 303.14,269.28
X$16333 105 5596 7293 7578 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16335 r0 *1 304.98,269.28
X$16335 105 7577 7573 5302 4689 40 105 7639 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16336 r0 *1 307.28,269.28
X$16336 40 5281 5595 7365 7753 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16344 r0 *1 320.62,269.28
X$16344 105 5658 7239 7633 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16347 r0 *1 323.38,269.28
X$16347 105 7565 4608 7634 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16350 r0 *1 330.28,269.28
X$16350 40 5281 6188 7365 7570 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16357 r0 *1 344.08,269.28
X$16357 105 6289 6855 7568 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16360 r0 *1 346.84,269.28
X$16360 105 6454 105 40 6852 40 sky130_fd_sc_hd__inv_1
* cell instance $16364 m0 *1 5.98,274.72
X$16364 40 7531 7530 7593 6711 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $16365 m0 *1 11.96,274.72
X$16365 105 7596 7595 7533 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16366 m0 *1 13.34,274.72
X$16366 40 7698 7341 7699 7595 7596 105 105 40 sky130_fd_sc_hd__o22ai_2
* cell instance $16370 m0 *1 23,274.72
X$16370 105 7597 7598 7406 105 7631 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $16371 m0 *1 24.84,274.72
X$16371 40 40 7286 105 7597 7598 105 sky130_fd_sc_hd__nor2_2
* cell instance $16372 m0 *1 27.14,274.72
X$16372 105 7597 7598 7406 7632 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16374 m0 *1 29.44,274.72
X$16374 40 7406 7599 7379 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $16375 m0 *1 35.42,274.72
X$16375 40 7737 7599 7635 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $16377 m0 *1 40.48,274.72
X$16377 40 40 7195 105 7635 7601 105 sky130_fd_sc_hd__nor2_2
* cell instance $16378 m0 *1 42.78,274.72
X$16378 105 7536 7602 7535 7601 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16380 m0 *1 45.54,274.72
X$16380 105 7738 7702 7603 105 7535 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $16381 m0 *1 48.3,274.72
X$16381 105 7604 7636 7605 105 7603 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $16383 m0 *1 51.98,274.72
X$16383 40 7496 7605 2251 105 7475 105 40 sky130_fd_sc_hd__ha_1
* cell instance $16386 m0 *1 57.5,274.72
X$16386 105 7703 7606 7607 105 7539 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $16388 m0 *1 60.72,274.72
X$16388 105 7703 7607 7606 7640 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16389 m0 *1 62.56,274.72
X$16389 40 7742 6897 7606 7443 7642 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $16392 m0 *1 72.68,274.72
X$16392 40 7232 7611 7743 7643 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $16393 m0 *1 76.36,274.72
X$16393 40 7645 7705 7500 7609 105 7408 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $16395 m0 *1 84.64,274.72
X$16395 105 7744 7500 7648 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $16398 m0 *1 93.38,274.72
X$16398 105 7232 7610 7611 40 105 7749 40 sky130_fd_sc_hd__a21o_1
* cell instance $16400 m0 *1 96.6,274.72
X$16400 40 7750 7709 7650 1986 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $16402 m0 *1 102.58,274.72
X$16402 105 7545 7611 7612 7814 105 40 7754 40 sky130_fd_sc_hd__o31ai_1
* cell instance $16403 m0 *1 105.34,274.72
X$16403 40 7653 7289 7203 6945 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $16406 m0 *1 112.24,274.72
X$16406 105 6945 7203 7109 40 105 7714 40 sky130_fd_sc_hd__a21o_1
* cell instance $16407 m0 *1 115,274.72
X$16407 105 6945 7478 7547 7203 105 7658 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $16410 m0 *1 120.06,274.72
X$16410 40 5281 6436 7043 7614 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16411 m0 *1 130.64,274.72
X$16411 105 6982 7662 7508 105 40 7614 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16412 m0 *1 132.48,274.72
X$16412 105 6436 7585 7662 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16414 m0 *1 134.32,274.72
X$16414 105 7777 7778 7663 105 40 7481 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16415 m0 *1 136.16,274.72
X$16415 105 7481 105 40 7616 40 sky130_fd_sc_hd__buf_4
* cell instance $16420 m0 *1 142.14,274.72
X$16420 105 7616 7669 7668 105 40 7667 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16421 m0 *1 143.98,274.72
X$16421 105 7045 7585 7669 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16425 m0 *1 148.58,274.72
X$16425 105 3678 7550 7618 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16426 m0 *1 149.96,274.72
X$16426 105 7617 7670 7717 105 40 7519 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16427 m0 *1 151.8,274.72
X$16427 105 7617 7618 7759 105 40 7760 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16428 m0 *1 153.64,274.72
X$16428 40 5281 3678 7092 7760 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16437 m0 *1 180.78,274.72
X$16437 105 4721 7118 7554 40 105 7679 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16441 m0 *1 188.6,274.72
X$16441 105 4722 7118 7592 40 105 7682 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16444 m0 *1 191.82,274.72
X$16444 105 7556 7619 7682 105 40 7683 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16447 m0 *1 195.04,274.72
X$16447 105 6729 7558 7483 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16448 m0 *1 196.42,274.72
X$16448 105 6701 7558 7619 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16450 m0 *1 199.64,274.72
X$16450 105 4904 7118 7590 40 105 7687 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16451 m0 *1 201.48,274.72
X$16451 105 7556 7690 7687 105 40 7691 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16452 m0 *1 203.32,274.72
X$16452 105 7094 7558 7690 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16454 m0 *1 205.62,274.72
X$16454 105 7556 7694 7693 105 40 7765 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16455 m0 *1 207.46,274.72
X$16455 40 7564 6911 7223 7765 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16457 m0 *1 218.5,274.72
X$16457 105 7559 40 7268 105 40 sky130_fd_sc_hd__buf_2
* cell instance $16461 m0 *1 223.1,274.72
X$16461 40 7564 3552 7046 7689 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16463 m0 *1 234.14,274.72
X$16463 40 40 7561 105 7355 4881 105 sky130_fd_sc_hd__nor2_2
* cell instance $16464 m0 *1 236.44,274.72
X$16464 105 7565 7681 7677 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16465 m0 *1 237.82,274.72
X$16465 105 7565 7680 7723 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16466 m0 *1 239.2,274.72
X$16466 105 7425 3616 7621 7620 7766 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $16467 m0 *1 241.96,274.72
X$16467 105 7723 7676 3770 105 7621 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $16471 m0 *1 247.02,274.72
X$16471 105 7268 40 7368 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16475 m0 *1 253,274.72
X$16475 105 7209 4524 7672 4525 40 7673 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $16477 m0 *1 257.6,274.72
X$16477 40 7060 7427 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $16478 m0 *1 266.8,274.72
X$16478 40 7622 7432 7563 7506 5138 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16479 m0 *1 271.4,274.72
X$16479 105 7622 7764 5212 5172 40 105 7666 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16481 m0 *1 274.62,274.72
X$16481 105 4800 40 7246 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16483 m0 *1 277.84,274.72
X$16483 105 7763 7664 5212 4838 40 105 7762 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16485 m0 *1 281.06,274.72
X$16485 40 7657 7432 7563 7659 5013 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16486 m0 *1 285.66,274.72
X$16486 105 7624 7657 5212 4759 40 105 7656 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16487 m0 *1 287.96,274.72
X$16487 105 7652 7655 5212 4761 40 105 7625 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16488 m0 *1 290.26,274.72
X$16488 105 6044 7253 7654 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16490 m0 *1 292.1,274.72
X$16490 40 7626 7432 7563 7758 4760 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16491 m0 *1 296.7,274.72
X$16491 105 7626 7649 5212 4618 40 105 7808 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16494 m0 *1 303.6,274.72
X$16494 105 6218 7430 7756 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16498 m0 *1 307.74,274.72
X$16498 105 7639 7186 7637 105 7753 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $16499 m0 *1 309.58,274.72
X$16499 105 5595 7293 7637 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16501 m0 *1 312.8,274.72
X$16501 105 6119 7253 7627 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16502 m0 *1 314.18,274.72
X$16502 105 7565 4864 7751 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16503 m0 *1 315.56,274.72
X$16503 40 7746 7432 7563 7627 4764 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16504 m0 *1 320.16,274.72
X$16504 40 7628 7432 7563 7741 7197 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16505 m0 *1 324.76,274.72
X$16505 105 7432 4855 7633 7563 7739 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $16506 m0 *1 327.52,274.72
X$16506 105 7634 7739 7246 4689 40 105 7629 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16507 m0 *1 329.82,274.72
X$16507 105 7425 7629 7734 105 7732 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $16510 m0 *1 333.04,274.72
X$16510 40 5281 5658 7365 7732 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16511 m0 *1 343.62,274.72
X$16511 40 7731 6188 7727 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $16512 m0 *1 347.76,274.72
X$16512 105 6737 40 105 6853 40 sky130_fd_sc_hd__inv_2
* cell instance $16515 r0 *1 6.9,274.72
X$16515 105 7768 7697 7593 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16517 r0 *1 8.74,274.72
X$16517 40 40 6712 105 7533 7532 105 sky130_fd_sc_hd__nor2_2
* cell instance $16519 r0 *1 11.96,274.72
X$16519 105 7698 7699 7595 7596 7473 40 105 40 sky130_fd_sc_hd__o22a_1
* cell instance $16523 r0 *1 16.1,274.72
X$16523 105 7768 7769 7700 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16525 r0 *1 17.94,274.72
X$16525 40 7227 7699 7771 7700 105 105 40 sky130_fd_sc_hd__a21o_4
* cell instance $16527 r0 *1 23.92,274.72
X$16527 40 7103 7474 7804 7733 7286 105 105 40 sky130_fd_sc_hd__nor4b_4
* cell instance $16529 r0 *1 33.12,274.72
X$16529 105 7735 40 7699 105 40 sky130_fd_sc_hd__buf_2
* cell instance $16530 r0 *1 34.96,274.72
X$16530 105 7736 40 7250 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $16533 r0 *1 40.48,274.72
X$16533 105 7474 7736 7701 6930 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $16539 r0 *1 46.46,274.72
X$16539 105 7738 7702 7603 7600 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16541 r0 *1 48.76,274.72
X$16541 40 7604 7702 1988 105 7575 105 40 sky130_fd_sc_hd__ha_1
* cell instance $16543 r0 *1 53.82,274.72
X$16543 105 7496 7495 7539 105 7636 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $16544 r0 *1 56.58,274.72
X$16544 40 7703 7495 2532 105 7638 105 40 sky130_fd_sc_hd__ha_1
* cell instance $16545 r0 *1 61.18,274.72
X$16545 40 7606 7641 7447 7608 105 105 40 sky130_fd_sc_hd__o21a_4
* cell instance $16546 r0 *1 66.7,274.72
X$16546 40 40 7704 7742 7443 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $16554 r0 *1 75.9,274.72
X$16554 105 7609 7705 7645 105 7706 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $16555 r0 *1 78.66,274.72
X$16555 105 7645 7609 7705 7807 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16556 r0 *1 80.5,274.72
X$16556 40 7609 7646 2803 105 7143 105 40 sky130_fd_sc_hd__ha_1
* cell instance $16558 r0 *1 85.56,274.72
X$16558 105 7646 7706 7744 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16560 r0 *1 87.86,274.72
X$16560 105 7750 7708 7747 7745 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $16562 r0 *1 90.16,274.72
X$16562 105 7809 7708 7748 40 105 7707 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16563 r0 *1 92,274.72
X$16563 40 7710 7813 1760 105 7749 105 40 sky130_fd_sc_hd__ha_1
* cell instance $16568 r0 *1 98.44,274.72
X$16568 105 7710 7813 7709 105 7752 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $16569 r0 *1 101.66,274.72
X$16569 105 7774 7709 7710 7773 40 7711 105 40 sky130_fd_sc_hd__nor4_1
* cell instance $16570 r0 *1 103.96,274.72
X$16570 105 7712 7711 7815 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16572 r0 *1 106.26,274.72
X$16572 105 7547 7201 7754 105 40 7713 40 sky130_fd_sc_hd__a21boi_1
* cell instance $16573 r0 *1 109.02,274.72
X$16573 105 7201 7754 7755 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16574 r0 *1 110.4,274.72
X$16574 105 7478 7413 7817 40 105 7546 40 sky130_fd_sc_hd__a21o_1
* cell instance $16577 r0 *1 120.52,274.72
X$16577 105 4655 3016 7820 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $16582 r0 *1 126.04,274.72
X$16582 40 7783 3770 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $16584 r0 *1 130.64,274.72
X$16584 105 7823 7926 7850 7757 40 105 40 sky130_fd_sc_hd__nor3b_1
* cell instance $16587 r0 *1 134.78,274.72
X$16587 40 5281 3061 7043 7715 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16588 r0 *1 145.36,274.72
X$16588 105 7617 7779 7716 105 40 7715 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16590 r0 *1 148.12,274.72
X$16590 105 4189 7718 7827 40 105 7716 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16594 r0 *1 151.34,274.72
X$16594 105 4024 7718 7719 40 105 7717 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16596 r0 *1 153.64,274.72
X$16596 105 7720 4364 7829 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16598 r0 *1 155.48,274.72
X$16598 105 4102 7718 7830 40 105 7759 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16601 r0 *1 160.08,274.72
X$16601 105 7617 7833 7831 105 40 7761 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16603 r0 *1 162.38,274.72
X$16603 105 7720 4012 7832 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16605 r0 *1 164.22,274.72
X$16605 105 3048 7550 7833 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16615 r0 *1 188.6,274.72
X$16615 40 7564 6701 7223 7683 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $16616 r0 *1 198.26,274.72
X$16616 40 7564 7094 7223 7691 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $16620 r0 *1 208.84,274.72
X$16620 105 6911 7558 7694 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16622 r0 *1 210.68,274.72
X$16622 105 7559 40 7556 105 40 sky130_fd_sc_hd__buf_2
* cell instance $16624 r0 *1 212.98,274.72
X$16624 40 7564 6587 7223 7767 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $16625 r0 *1 222.64,274.72
X$16625 105 7088 105 40 7721 40 sky130_fd_sc_hd__inv_1
* cell instance $16626 r0 *1 224.02,274.72
X$16626 105 7783 105 40 4524 40 sky130_fd_sc_hd__buf_4
* cell instance $16627 r0 *1 226.78,274.72
X$16627 105 3552 7368 7686 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16635 r0 *1 237.82,274.72
X$16635 105 6789 7368 7824 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16637 r0 *1 239.66,274.72
X$16637 40 7564 3441 7046 7766 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16640 r0 *1 253,274.72
X$16640 40 7564 5961 7427 7566 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16643 r0 *1 264.04,274.72
X$16643 105 7783 105 40 5302 40 sky130_fd_sc_hd__buf_4
* cell instance $16645 r0 *1 267.72,274.72
X$16645 105 7565 4758 7763 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16648 r0 *1 270.48,274.72
X$16648 40 5281 6697 6052 7661 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16649 r0 *1 281.06,274.72
X$16649 105 7556 7816 7762 105 40 7623 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16650 r0 *1 282.9,274.72
X$16650 105 6589 7558 7816 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16651 r0 *1 284.28,274.72
X$16651 105 7565 4948 7624 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16654 r0 *1 289.34,274.72
X$16654 105 7625 7812 7556 105 40 7811 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16656 r0 *1 291.64,274.72
X$16656 105 6044 7558 7812 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16657 r0 *1 293.02,274.72
X$16657 105 6546 7558 7810 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16660 r0 *1 295.78,274.72
X$16660 105 6365 7430 7792 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16663 r0 *1 301.76,274.72
X$16663 40 7794 7303 7304 7756 4764 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16664 r0 *1 306.36,274.72
X$16664 105 7724 7794 5302 4847 40 105 7795 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16665 r0 *1 308.66,274.72
X$16665 105 7462 4864 7724 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16666 r0 *1 310.04,274.72
X$16666 105 7462 4553 7866 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16667 r0 *1 311.42,274.72
X$16667 105 6218 7293 7806 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16671 r0 *1 315.1,274.72
X$16671 105 7751 7746 5212 4847 40 105 7725 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16675 r0 *1 319.24,274.72
X$16675 105 6468 7253 7741 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16676 r0 *1 320.62,274.72
X$16676 40 40 4553 7740 7565 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $16677 r0 *1 322.92,274.72
X$16677 105 7628 7740 5212 4537 40 105 7803 40 sky130_fd_sc_hd__a31oi_1
* cell instance $16678 r0 *1 325.22,274.72
X$16678 105 7425 7796 7803 105 40 7800 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16679 r0 *1 327.06,274.72
X$16679 105 6468 7368 7796 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16681 r0 *1 329.36,274.72
X$16681 105 7425 7801 7725 105 40 7726 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16682 r0 *1 331.2,274.72
X$16682 105 5658 7368 7734 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16683 r0 *1 332.58,274.72
X$16683 105 6119 7368 7801 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16687 r0 *1 337.18,274.72
X$16687 40 7306 7727 7365 7731 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $16691 r0 *1 347.76,274.72
X$16691 105 7436 7729 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $16721 m0 *1 6.44,280.16
X$16721 105 7697 7768 7530 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $16722 m0 *1 8.74,280.16
X$16722 105 7835 7769 7836 7697 7369 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $16724 m0 *1 12.42,280.16
X$16724 105 7768 7769 7995 7698 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $16726 m0 *1 14.72,280.16
X$16726 105 7697 7595 7700 7770 7596 7802 105 40 40 sky130_fd_sc_hd__o221ai_1
* cell instance $16728 m0 *1 18.4,280.16
X$16728 40 40 7804 105 7770 7836 105 sky130_fd_sc_hd__nor2_2
* cell instance $16729 m0 *1 20.7,280.16
X$16729 105 7699 7700 7771 40 105 7736 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16731 m0 *1 23,280.16
X$16731 40 7474 7878 7920 7879 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $16733 m0 *1 29.44,280.16
X$16733 40 7839 7312 7840 7699 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $16735 m0 *1 38.18,280.16
X$16735 105 7883 7250 7343 7884 40 7252 105 40 sky130_fd_sc_hd__nor4b_1
* cell instance $16737 m0 *1 43.24,280.16
X$16737 40 7738 7602 1986 105 7701 105 40 sky130_fd_sc_hd__ha_1
* cell instance $16744 m0 *1 57.96,280.16
X$16744 40 7641 2803 7607 7704 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $16745 m0 *1 67.16,280.16
X$16745 40 7228 7230 1986 105 7610 105 40 sky130_fd_sc_hd__ha_1
* cell instance $16747 m0 *1 78.66,280.16
X$16747 105 7706 7232 7807 7772 105 40 7888 40 sky130_fd_sc_hd__o31ai_1
* cell instance $16748 m0 *1 81.42,280.16
X$16748 105 7232 7143 7772 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16753 m0 *1 85.56,280.16
X$16753 105 7748 7890 7891 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16754 m0 *1 86.94,280.16
X$16754 40 7708 1988 7809 7318 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $16757 m0 *1 97.52,280.16
X$16757 105 7707 7750 7774 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $16758 m0 *1 99.82,280.16
X$16758 40 7712 7709 7773 7774 7710 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $16760 m0 *1 103.5,280.16
X$16760 105 7712 7711 7545 105 7814 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $16761 m0 *1 105.34,280.16
X$16761 105 5865 7775 7847 7846 7897 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $16763 m0 *1 109.02,280.16
X$16763 105 7893 7775 7817 40 105 40 sky130_fd_sc_hd__or2_1
* cell instance $16769 m0 *1 117.3,280.16
X$16769 40 5281 7776 7849 7819 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $16771 m0 *1 126.96,280.16
X$16771 40 7776 4205 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $16773 m0 *1 133.4,280.16
X$16773 40 7757 7778 7777 4032 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $16775 m0 *1 139.84,280.16
X$16775 40 7899 7778 7777 7559 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $16776 m0 *1 145.82,280.16
X$16776 105 7781 7780 7900 105 40 7827 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16777 m0 *1 147.66,280.16
X$16777 105 7720 4252 7780 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16779 m0 *1 149.5,280.16
X$16779 105 7784 3989 7902 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16780 m0 *1 150.88,280.16
X$16780 105 7902 3174 7852 40 105 7828 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16781 m0 *1 152.72,280.16
X$16781 105 7781 7829 7828 105 40 7719 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16782 m0 *1 154.56,280.16
X$16782 105 7781 7903 7853 105 40 7830 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16783 m0 *1 156.4,280.16
X$16783 105 7782 3678 7852 40 105 7853 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16784 m0 *1 158.24,280.16
X$16784 105 7784 4188 7782 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16786 m0 *1 160.08,280.16
X$16786 105 3930 7718 7854 40 105 7831 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16787 m0 *1 161.92,280.16
X$16787 105 7781 7832 7834 105 40 7854 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16788 m0 *1 163.76,280.16
X$16788 40 40 7904 105 7784 6984 105 sky130_fd_sc_hd__nor2_2
* cell instance $16791 m0 *1 167.44,280.16
X$16791 105 7904 3048 7852 40 105 7834 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16797 m0 *1 184.46,280.16
X$16797 105 7785 4188 7906 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16801 m0 *1 192.28,280.16
X$16801 105 3989 7785 7908 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16806 m0 *1 200.56,280.16
X$16806 105 7786 7271 7787 40 105 7909 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16808 m0 *1 204.24,280.16
X$16808 105 5133 7912 4420 7672 40 7786 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $16812 m0 *1 215.28,280.16
X$16812 105 7185 4012 7914 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16813 m0 *1 216.66,280.16
X$16813 105 5133 7915 3930 7672 40 7913 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $16814 m0 *1 219.42,280.16
X$16814 105 7913 7721 7787 40 105 7826 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16820 m0 *1 229.08,280.16
X$16820 105 7910 4421 4258 7672 40 7859 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $16824 m0 *1 235.06,280.16
X$16824 105 4751 7684 7861 40 105 7825 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16825 m0 *1 236.9,280.16
X$16825 105 7556 7824 7825 105 40 7907 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16830 m0 *1 250.24,280.16
X$16830 40 7870 7783 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $16833 m0 *1 257.6,280.16
X$16833 40 7427 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $16834 m0 *1 268.64,280.16
X$16834 105 6443 7430 7822 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16835 m0 *1 270.02,280.16
X$16835 105 6703 7585 7821 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16836 m0 *1 271.4,280.16
X$16836 105 6703 7430 7789 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16837 m0 *1 272.78,280.16
X$16837 40 7818 7303 7304 7789 4870 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16843 m0 *1 284.74,280.16
X$16843 40 7898 7303 7304 7790 5013 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16844 m0 *1 289.34,280.16
X$16844 105 6600 7430 7790 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16846 m0 *1 291.64,280.16
X$16846 105 7556 7810 7808 105 40 7791 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16847 m0 *1 293.48,280.16
X$16847 105 5813 7430 7892 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16849 m0 *1 295.32,280.16
X$16849 40 7864 7303 7304 7792 4760 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16851 m0 *1 303.6,280.16
X$16851 105 5980 7430 7793 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16853 m0 *1 305.44,280.16
X$16853 40 7885 7303 7304 7793 7197 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $16855 m0 *1 310.5,280.16
X$16855 105 5980 7293 7805 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16856 m0 *1 311.88,280.16
X$16856 40 5281 6218 7365 7867 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16858 m0 *1 326.14,280.16
X$16858 105 7868 105 40 4534 40 sky130_fd_sc_hd__buf_4
* cell instance $16859 m0 *1 328.9,280.16
X$16859 105 7870 7797 7868 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $16863 m0 *1 333.04,280.16
X$16863 40 5281 6468 7872 7800 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16864 m0 *1 343.62,280.16
X$16864 40 7938 6303 7875 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $16865 m0 *1 347.76,280.16
X$16865 105 7630 7797 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $16868 r0 *1 3.22,280.16
X$16868 40 7437 7917 7916 7937 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $16870 r0 *1 8.28,280.16
X$16870 40 7404 7835 7769 7836 7697 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $16871 r0 *1 11.96,280.16
X$16871 40 7098 7837 7697 7769 7877 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $16875 r0 *1 16.56,280.16
X$16875 40 7877 7343 7804 7838 7835 105 7172 105 40 sky130_fd_sc_hd__o311ai_4
* cell instance $16876 r0 *1 26.22,280.16
X$16876 40 7880 7881 7309 7442 105 7315 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $16877 r0 *1 34.04,280.16
X$16877 40 7442 7839 7840 7735 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $16879 r0 *1 38.64,280.16
X$16879 105 6566 7841 7842 40 105 7883 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16881 r0 *1 40.94,280.16
X$16881 105 6566 7841 7842 7884 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $16899 r0 *1 74.98,280.16
X$16899 105 7645 7232 8032 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16901 r0 *1 76.82,280.16
X$16901 105 7923 7887 7886 40 105 7889 40 sky130_fd_sc_hd__a21o_1
* cell instance $16903 r0 *1 80.04,280.16
X$16903 105 7843 7889 7747 105 7844 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $16906 r0 *1 83.26,280.16
X$16906 40 7747 2251 7748 7647 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $16909 r0 *1 94.76,280.16
X$16909 105 7750 7708 7809 7846 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $16913 r0 *1 98.44,280.16
X$16913 40 7752 7848 7950 7951 105 105 40 sky130_fd_sc_hd__and3_4
* cell instance $16914 r0 *1 102.58,280.16
X$16914 40 40 7846 7454 7847 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $16916 r0 *1 105.34,280.16
X$16916 40 7545 3304 7848 7925 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $16917 r0 *1 111.32,280.16
X$16917 105 7547 7893 7775 105 7895 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $16919 r0 *1 114.54,280.16
X$16919 40 7954 7895 7817 7896 7897 105 105 40 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $16921 r0 *1 121.44,280.16
X$16921 105 4655 4793 7819 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $16925 r0 *1 126.04,280.16
X$16925 40 7955 7778 7777 5261 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $16926 r0 *1 132.02,280.16
X$16926 105 7823 7926 7850 7899 40 105 40 sky130_fd_sc_hd__and3b_1
* cell instance $16927 r0 *1 135.24,280.16
X$16927 40 7851 7778 7777 4246 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $16931 r0 *1 144.44,280.16
X$16931 105 3061 7550 7779 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16932 r0 *1 145.82,280.16
X$16932 105 7901 3061 7852 40 105 7900 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16934 r0 *1 148.58,280.16
X$16934 105 7784 4255 7901 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16935 r0 *1 149.96,280.16
X$16935 105 7783 105 40 5048 40 sky130_fd_sc_hd__buf_4
* cell instance $16941 r0 *1 155.02,280.16
X$16941 105 4183 7720 7903 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16944 r0 *1 158.7,280.16
X$16944 105 4515 7784 7963 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16946 r0 *1 160.54,280.16
X$16946 105 4517 7784 8019 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16951 r0 *1 171.58,280.16
X$16951 40 40 7905 105 7785 4255 105 sky130_fd_sc_hd__nor2_2
* cell instance $16952 r0 *1 173.88,280.16
X$16952 105 7905 6585 7856 40 105 7967 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16953 r0 *1 175.72,280.16
X$16953 105 7855 4252 7966 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16957 r0 *1 179.4,280.16
X$16957 105 4515 7785 8024 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $16960 r0 *1 184.92,280.16
X$16960 105 7906 6031 7856 40 105 7965 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16963 r0 *1 191.36,280.16
X$16963 105 7855 4364 7961 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16964 r0 *1 192.74,280.16
X$16964 105 7908 5465 7856 40 105 7962 40 sky130_fd_sc_hd__a21oi_1
* cell instance $16967 r0 *1 198.72,280.16
X$16967 40 7564 6987 7857 7909 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $16970 r0 *1 208.84,280.16
X$16970 105 7185 4521 7958 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16971 r0 *1 210.22,280.16
X$16971 105 7858 5031 7957 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16974 r0 *1 213.9,280.16
X$16974 105 7185 7914 7956 105 40 7915 40 sky130_fd_sc_hd__o21ai_1
* cell instance $16975 r0 *1 215.74,280.16
X$16975 40 7564 7088 7857 7826 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $16976 r0 *1 225.4,280.16
X$16976 40 7564 5653 7860 7911 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16979 r0 *1 236.44,280.16
X$16979 40 7564 6789 7860 7907 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16982 r0 *1 248.4,280.16
X$16982 105 5732 7672 7673 40 105 7952 40 sky130_fd_sc_hd__a21o_1
* cell instance $16983 r0 *1 251.16,280.16
X$16983 40 7564 5732 7427 7952 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $16986 r0 *1 262.2,280.16
X$16986 105 7462 5063 7949 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16988 r0 *1 264.04,280.16
X$16988 105 7783 105 40 4800 40 sky130_fd_sc_hd__buf_4
* cell instance $16990 r0 *1 267.72,280.16
X$16990 105 7303 5138 7822 7304 7947 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $16991 r0 *1 270.48,280.16
X$16991 40 7862 7945 4372 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $16992 r0 *1 274.62,280.16
X$16992 40 4800 5133 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $16993 r0 *1 279.68,280.16
X$16993 40 40 4758 7944 7462 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $16996 r0 *1 284.28,280.16
X$16996 105 7462 4948 7863 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $16997 r0 *1 285.66,280.16
X$16997 105 7863 7898 7246 4759 40 105 7932 40 sky130_fd_sc_hd__a31oi_1
* cell instance $17000 r0 *1 289.8,280.16
X$17000 105 7462 4946 7894 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17002 r0 *1 291.64,280.16
X$17002 40 7942 7303 7304 7892 4993 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $17003 r0 *1 296.24,280.16
X$17003 105 7865 7864 7246 4618 40 105 7941 40 sky130_fd_sc_hd__a31oi_1
* cell instance $17004 r0 *1 298.54,280.16
X$17004 105 7462 4685 7865 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17008 r0 *1 308.2,280.16
X$17008 105 7866 7885 5302 4537 40 105 7933 40 sky130_fd_sc_hd__a31oi_1
* cell instance $17009 r0 *1 310.5,280.16
X$17009 105 7795 7806 7616 105 40 7867 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17010 r0 *1 312.34,280.16
X$17010 105 7933 7805 7616 105 40 7999 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17015 r0 *1 319.24,280.16
X$17015 105 7365 105 40 9519 40 sky130_fd_sc_hd__clkinvlp_4
* cell instance $17016 r0 *1 322,280.16
X$17016 40 4535 7934 7882 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17017 r0 *1 326.14,280.16
X$17017 105 7869 105 40 4270 40 sky130_fd_sc_hd__buf_4
* cell instance $17018 r0 *1 328.9,280.16
X$17018 105 7870 7871 7869 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $17022 r0 *1 334.42,280.16
X$17022 105 7874 7994 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17023 r0 *1 335.8,280.16
X$17023 40 7306 7993 7872 7876 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $17025 r0 *1 345,280.16
X$17025 105 7799 7871 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17028 r0 *1 347.76,280.16
X$17028 105 7191 7730 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17056 m0 *1 1.84,285.6
X$17056 40 7937 7916 7917 105 7307 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $17057 m0 *1 6.9,285.6
X$17057 105 7768 7697 7917 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $17058 m0 *1 9.2,285.6
X$17058 40 40 7968 7283 7918 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $17059 m0 *1 11.5,285.6
X$17059 105 7595 7919 7918 7836 40 105 40 sky130_fd_sc_hd__nor3b_1
* cell instance $17060 m0 *1 14.26,285.6
X$17060 105 7595 7995 7919 7918 40 7771 105 40 sky130_fd_sc_hd__nor4b_1
* cell instance $17061 m0 *1 17.48,285.6
X$17061 105 7770 7697 7700 105 40 7877 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17062 m0 *1 19.32,285.6
X$17062 105 7880 7697 7995 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17063 m0 *1 20.7,285.6
X$17063 105 7878 7879 7920 105 40 7226 40 sky130_fd_sc_hd__a21o_2
* cell instance $17064 m0 *1 23.92,285.6
X$17064 105 7920 7879 7838 7878 40 7881 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17066 m0 *1 27.6,285.6
X$17066 105 7735 7698 7733 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17068 m0 *1 29.44,285.6
X$17068 105 7998 7970 7839 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17069 m0 *1 30.82,285.6
X$17069 40 40 7920 105 7998 7970 105 sky130_fd_sc_hd__nor2_2
* cell instance $17070 m0 *1 33.12,285.6
X$17070 40 7343 7878 7920 7879 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $17072 m0 *1 40.02,285.6
X$17072 105 7841 7842 7344 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $17073 m0 *1 42.32,285.6
X$17073 40 8001 5716 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $17074 m0 *1 46.46,285.6
X$17074 40 7735 7972 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $17080 m0 *1 57.96,285.6
X$17080 105 7973 8005 7943 105 8247 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $17084 m0 *1 66.7,285.6
X$17084 40 7843 7921 7922 7974 7923 105 105 40 sky130_fd_sc_hd__o211a_1
* cell instance $17088 m0 *1 76.82,285.6
X$17088 105 7923 7886 7887 105 7975 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17091 m0 *1 81.42,285.6
X$17091 105 7976 7975 7924 40 105 7925 40 sky130_fd_sc_hd__a21o_1
* cell instance $17094 m0 *1 85.56,285.6
X$17094 40 7710 7708 7747 7750 105 7924 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $17095 m0 *1 93.38,285.6
X$17095 40 7748 7710 7708 7750 105 7951 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $17096 m0 *1 101.2,285.6
X$17096 40 7847 7773 7774 7844 8011 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17097 m0 *1 105.8,285.6
X$17097 105 7925 3293 7848 105 7775 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17098 m0 *1 109.02,285.6
X$17098 40 7848 7893 7925 8012 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $17101 m0 *1 112.24,285.6
X$17101 40 8076 7815 7953 7817 7895 105 105 40 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $17102 m0 *1 115.46,285.6
X$17102 40 8283 7714 7388 7478 7954 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $17104 m0 *1 120.98,285.6
X$17104 105 7783 4655 8013 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17107 m0 *1 126.96,285.6
X$17107 105 7850 7926 7978 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17108 m0 *1 128.34,285.6
X$17108 105 7823 7978 7955 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17109 m0 *1 129.72,285.6
X$17109 105 7850 7823 7926 7663 40 105 40 sky130_fd_sc_hd__and3b_1
* cell instance $17110 m0 *1 132.94,285.6
X$17110 105 7926 7850 7823 8015 40 105 40 sky130_fd_sc_hd__nor3b_1
* cell instance $17111 m0 *1 135.7,285.6
X$17111 105 7823 7850 7926 7851 40 105 40 sky130_fd_sc_hd__nor3b_1
* cell instance $17116 m0 *1 141.22,285.6
X$17116 105 5048 40 7112 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17119 m0 *1 145.82,285.6
X$17119 40 40 8017 105 4017 7784 105 sky130_fd_sc_hd__nor2_2
* cell instance $17122 m0 *1 152.26,285.6
X$17122 40 40 7959 105 4361 7784 105 sky130_fd_sc_hd__nor2_2
* cell instance $17125 m0 *1 158.7,285.6
X$17125 105 7720 4518 8020 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17126 m0 *1 160.08,285.6
X$17126 105 7963 7031 7852 40 105 8090 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17127 m0 *1 161.92,285.6
X$17127 105 8019 6963 7852 40 105 8093 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17130 m0 *1 165.14,285.6
X$17130 105 6707 40 7784 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17136 m0 *1 174.34,285.6
X$17136 105 7788 7966 7967 105 40 7981 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17139 m0 *1 178.48,285.6
X$17139 105 7858 4518 8097 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17140 m0 *1 179.86,285.6
X$17140 105 8024 6962 7856 40 105 7982 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17142 m0 *1 182.16,285.6
X$17142 105 5809 40 7720 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17143 m0 *1 184,285.6
X$17143 105 7965 8025 7788 105 40 7964 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17144 m0 *1 185.84,285.6
X$17144 105 7858 4183 8025 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17147 m0 *1 189.98,285.6
X$17147 105 6754 9484 105 40 40 sky130_fd_sc_hd__inv_6
* cell instance $17151 m0 *1 195.04,285.6
X$17151 105 7962 7961 7788 105 40 7927 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17153 m0 *1 197.8,285.6
X$17153 105 7928 6788 7856 40 105 7960 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17154 m0 *1 199.64,285.6
X$17154 40 40 7928 105 4361 7785 105 sky130_fd_sc_hd__nor2_2
* cell instance $17155 m0 *1 201.94,285.6
X$17155 40 40 8023 105 7785 4906 105 sky130_fd_sc_hd__nor2_2
* cell instance $17157 m0 *1 205.16,285.6
X$17157 105 7929 7958 7185 105 40 7912 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17158 m0 *1 207,285.6
X$17158 105 8103 6987 7930 40 105 7929 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17160 m0 *1 209.3,285.6
X$17160 105 6040 40 7185 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17161 m0 *1 212.06,285.6
X$17161 40 40 8021 105 7862 6984 105 sky130_fd_sc_hd__nor2_2
* cell instance $17162 m0 *1 214.36,285.6
X$17162 105 8021 7088 7930 40 105 7956 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17164 m0 *1 216.66,285.6
X$17164 105 6323 40 7785 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17165 m0 *1 219.42,285.6
X$17165 105 6323 40 7930 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17168 m0 *1 223.56,285.6
X$17168 105 6323 40 7862 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17170 m0 *1 228.16,285.6
X$17170 105 5653 7672 7859 40 105 7911 40 sky130_fd_sc_hd__a21o_1
* cell instance $17171 m0 *1 230.92,285.6
X$17171 40 7783 3530 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $17172 m0 *1 235.06,285.6
X$17172 105 7783 105 40 4421 40 sky130_fd_sc_hd__buf_4
* cell instance $17173 m0 *1 237.82,285.6
X$17173 40 7121 8016 4881 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17174 m0 *1 241.96,285.6
X$17174 40 8919 4258 7783 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17177 m0 *1 250.24,285.6
X$17177 40 7564 6703 7427 7986 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $17178 m0 *1 260.82,285.6
X$17178 40 9421 4525 7783 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17180 m0 *1 265.42,285.6
X$17180 105 7947 7949 5302 5172 40 105 7948 40 sky130_fd_sc_hd__a31oi_1
* cell instance $17182 m0 *1 268.18,285.6
X$17182 105 6040 40 7946 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17185 m0 *1 271.4,285.6
X$17185 105 7788 7988 4455 105 7931 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17186 m0 *1 274.62,285.6
X$17186 105 4800 40 7861 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17188 m0 *1 277.84,285.6
X$17188 105 7246 7818 7944 4838 40 105 8009 40 sky130_fd_sc_hd__a31oi_1
* cell instance $17190 m0 *1 280.6,285.6
X$17190 105 6989 40 7788 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17191 m0 *1 283.36,285.6
X$17191 105 5809 40 7992 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17195 m0 *1 288.42,285.6
X$17195 105 6040 105 40 6989 40 sky130_fd_sc_hd__buf_4
* cell instance $17196 m0 *1 291.18,285.6
X$17196 105 7894 7942 7246 4761 40 105 8131 40 sky130_fd_sc_hd__a31oi_1
* cell instance $17198 m0 *1 295.32,285.6
X$17198 105 5813 7585 8006 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17201 m0 *1 299,285.6
X$17201 40 7990 6989 7989 6366 7940 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17205 m0 *1 305.44,285.6
X$17205 40 4535 7989 7862 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17207 m0 *1 310.5,285.6
X$17207 40 5281 5980 7365 7999 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $17208 m0 *1 321.08,285.6
X$17208 40 7060 7365 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $17209 m0 *1 330.28,285.6
X$17209 105 7870 7994 7939 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $17211 m0 *1 333.04,285.6
X$17211 105 7936 7996 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17214 m0 *1 335.8,285.6
X$17214 40 7876 5347 7993 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $17215 m0 *1 339.94,285.6
X$17215 40 7306 7875 7872 7938 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $17218 r0 *1 5.52,285.6
X$17218 105 7768 7697 7969 7916 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $17220 r0 *1 8.28,285.6
X$17220 105 7918 7968 105 7309 40 40 sky130_fd_sc_hd__and2_2
* cell instance $17222 r0 *1 12.88,285.6
X$17222 105 8057 7937 7769 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $17225 r0 *1 15.64,285.6
X$17225 40 7919 7531 8028 7969 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $17226 r0 *1 19.32,285.6
X$17226 105 7837 8028 7969 7770 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17227 r0 *1 21.16,285.6
X$17227 40 7598 8059 8060 7768 8029 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $17228 r0 *1 25.76,285.6
X$17228 40 8027 7735 7969 7837 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $17231 r0 *1 33.12,285.6
X$17231 105 8029 7379 8061 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $17233 r0 *1 36.8,285.6
X$17233 105 7837 7969 8027 8062 105 40 7841 40 sky130_fd_sc_hd__o31ai_1
* cell instance $17234 r0 *1 39.56,285.6
X$17234 105 8061 7599 8029 5716 7998 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $17238 r0 *1 43.24,285.6
X$17238 40 7701 8002 8000 7879 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $17239 r0 *1 47.38,285.6
X$17239 105 8063 8215 8002 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17240 r0 *1 48.76,285.6
X$17240 105 8030 7972 8244 7971 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $17241 r0 *1 51.06,285.6
X$17241 105 8064 7971 7575 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17243 r0 *1 53.36,285.6
X$17243 105 7972 8031 8065 40 105 7475 40 sky130_fd_sc_hd__a21o_1
* cell instance $17244 r0 *1 56.12,285.6
X$17244 40 7943 7972 7704 105 105 40 sky130_fd_sc_hd__nor2_8
* cell instance $17251 r0 *1 72.22,285.6
X$17251 40 7974 7887 2803 105 8032 105 40 sky130_fd_sc_hd__ha_1
* cell instance $17253 r0 *1 77.28,285.6
X$17253 105 7747 7843 7889 8068 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17254 r0 *1 79.12,285.6
X$17254 40 7747 7890 7975 7976 105 105 40 sky130_fd_sc_hd__a21boi_2
* cell instance $17255 r0 *1 83.26,285.6
X$17255 40 8069 7924 7975 7976 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $17256 r0 *1 89.24,285.6
X$17256 40 7977 7891 7708 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $17257 r0 *1 95.22,285.6
X$17257 105 7710 7750 7809 7950 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $17261 r0 *1 98.44,285.6
X$17261 105 7750 7809 7748 8011 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17262 r0 *1 100.28,285.6
X$17262 105 7775 7977 8071 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17264 r0 *1 102.12,285.6
X$17264 40 8114 7478 7388 7714 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $17265 r0 *1 105.8,285.6
X$17265 40 8034 7714 7388 7478 7347 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $17267 r0 *1 110.86,285.6
X$17267 40 8156 7714 7388 7478 8076 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $17270 r0 *1 118.22,285.6
X$17270 40 8077 8079 4653 7819 8081 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $17276 r0 *1 132.48,285.6
X$17276 40 8015 7778 7777 8083 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $17280 r0 *1 141.68,285.6
X$17280 105 3924 7112 7979 40 105 8433 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17282 r0 *1 143.98,285.6
X$17282 105 7781 8085 8084 105 40 7979 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17283 r0 *1 145.82,285.6
X$17283 105 8018 6961 7852 40 105 8084 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17284 r0 *1 147.66,285.6
X$17284 105 4098 7784 8018 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17285 r0 *1 149.04,285.6
X$17285 105 7980 4020 8085 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17288 r0 *1 151.34,285.6
X$17288 105 7720 4184 8165 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17291 r0 *1 153.64,285.6
X$17291 105 4805 7784 8088 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17294 r0 *1 159.16,285.6
X$17294 105 7980 8020 8090 105 40 8089 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17295 r0 *1 161,285.6
X$17295 105 7980 8091 8093 105 40 8092 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17297 r0 *1 163.3,285.6
X$17297 105 7720 4521 8091 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17299 r0 *1 165.14,285.6
X$17299 105 6707 40 7852 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17303 r0 *1 172.04,285.6
X$17303 40 40 8096 105 7785 4098 105 sky130_fd_sc_hd__nor2_2
* cell instance $17305 r0 *1 174.8,285.6
X$17305 105 7855 4020 8037 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17307 r0 *1 177.1,285.6
X$17307 105 7982 8097 7788 105 40 8098 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17313 r0 *1 188.6,285.6
X$17313 105 7785 4747 8099 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17314 r0 *1 189.98,285.6
X$17314 40 4197 6754 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $17315 r0 *1 199.18,285.6
X$17315 105 7960 8101 7788 105 40 8233 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17316 r0 *1 201.02,285.6
X$17316 105 7858 4184 8101 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17317 r0 *1 202.4,285.6
X$17317 40 40 8178 105 7121 4906 105 sky130_fd_sc_hd__nor2_2
* cell instance $17319 r0 *1 204.7,285.6
X$17319 105 7862 40 7856 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17320 r0 *1 206.54,285.6
X$17320 105 4517 7862 8103 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17323 r0 *1 208.84,285.6
X$17323 40 40 8040 105 7121 4670 105 sky130_fd_sc_hd__nor2_2
* cell instance $17325 r0 *1 212.06,285.6
X$17325 105 7855 8043 8100 105 40 8042 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17326 r0 *1 213.9,285.6
X$17326 105 7983 5031 8022 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17328 r0 *1 216.2,285.6
X$17328 105 8045 7027 7930 40 105 8100 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17329 r0 *1 218.04,285.6
X$17329 105 7983 4667 8041 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17330 r0 *1 219.42,285.6
X$17330 105 5809 40 7980 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17331 r0 *1 221.26,285.6
X$17331 105 5809 40 7983 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17333 r0 *1 224.94,285.6
X$17333 105 6323 40 7984 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17334 r0 *1 227.7,285.6
X$17334 105 6323 40 7940 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17336 r0 *1 230.92,285.6
X$17336 105 6989 40 7858 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17339 r0 *1 233.68,285.6
X$17339 105 6989 40 7855 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17342 r0 *1 236.44,285.6
X$17342 40 40 8094 105 7984 4881 105 sky130_fd_sc_hd__nor2_2
* cell instance $17344 r0 *1 239.2,285.6
X$17344 40 7564 3356 7860 8169 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $17345 r0 *1 249.78,285.6
X$17345 105 7985 7022 8086 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $17347 r0 *1 253,285.6
X$17347 105 6707 40 8047 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17350 r0 *1 257.14,285.6
X$17350 40 7984 8014 4870 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17352 r0 *1 261.28,285.6
X$17352 105 7616 7821 8009 105 40 7986 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17355 r0 *1 264.04,285.6
X$17355 105 6707 40 7882 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17356 r0 *1 266.8,285.6
X$17356 40 7988 7945 6989 6556 7940 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17357 r0 *1 271.4,285.6
X$17357 105 7987 7781 4455 40 105 8080 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17359 r0 *1 274.16,285.6
X$17359 40 4620 8259 7862 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17360 r0 *1 278.3,285.6
X$17360 40 4372 8010 7882 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17361 r0 *1 282.44,285.6
X$17361 40 40 8074 105 7882 4620 105 sky130_fd_sc_hd__nor2_2
* cell instance $17362 r0 *1 284.74,285.6
X$17362 40 4760 8159 7121 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17364 r0 *1 288.88,285.6
X$17364 40 40 8070 105 7121 4993 105 sky130_fd_sc_hd__nor2_2
* cell instance $17366 r0 *1 291.64,285.6
X$17366 40 4760 8008 7984 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17367 r0 *1 295.78,285.6
X$17367 40 4993 8007 7984 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17368 r0 *1 299.92,285.6
X$17368 105 4534 8051 7861 40 105 8067 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17369 r0 *1 301.76,285.6
X$17369 105 7616 8052 7941 105 40 8066 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17370 r0 *1 303.6,285.6
X$17370 105 7990 7788 4459 40 105 8051 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17372 r0 *1 305.9,285.6
X$17372 40 7197 8004 7984 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17373 r0 *1 310.04,285.6
X$17373 40 4855 8003 7862 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17376 r0 *1 314.64,285.6
X$17376 105 4534 5133 8053 40 105 8058 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17377 r0 *1 316.48,285.6
X$17377 40 40 7991 105 7882 4855 105 sky130_fd_sc_hd__nor2_2
* cell instance $17379 r0 *1 319.24,285.6
X$17379 40 7997 7934 7992 6367 8047 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17380 r0 *1 323.84,285.6
X$17380 105 7997 7781 4459 40 105 8053 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17381 r0 *1 325.68,285.6
X$17381 105 7939 105 40 4265 40 sky130_fd_sc_hd__buf_4
* cell instance $17382 r0 *1 328.44,285.6
X$17382 105 7992 105 40 7781 40 sky130_fd_sc_hd__buf_4
* cell instance $17383 r0 *1 331.2,285.6
X$17383 105 8054 105 40 4689 40 sky130_fd_sc_hd__buf_4
* cell instance $17384 r0 *1 333.96,285.6
X$17384 105 7870 7996 8054 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $17385 r0 *1 336.26,285.6
X$17385 40 7060 7872 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $17390 r0 *1 347.76,285.6
X$17390 105 7993 7728 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17419 m0 *1 4.14,291.04
X$17419 105 8136 8104 8026 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $17420 m0 *1 6.44,291.04
X$17420 105 7837 8027 8105 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17422 m0 *1 8.74,291.04
X$17422 40 7968 7595 8027 7969 8026 7919 105 105 40 sky130_fd_sc_hd__o41ai_1
* cell instance $17425 m0 *1 14.26,291.04
X$17425 40 8059 8060 8106 105 7879 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $17426 m0 *1 20.7,291.04
X$17426 105 8309 40 7697 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17427 m0 *1 22.54,291.04
X$17427 105 7768 8057 8059 7838 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $17429 m0 *1 26.22,291.04
X$17429 105 7379 7599 8184 8141 8142 105 40 40 sky130_fd_sc_hd__or4_1
* cell instance $17431 m0 *1 29.44,291.04
X$17431 40 7837 7878 8027 7969 8144 105 105 40 sky130_fd_sc_hd__nor4_4
* cell instance $17434 m0 *1 40.02,291.04
X$17434 105 8145 8107 8062 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17435 m0 *1 41.4,291.04
X$17435 40 8108 8109 1988 105 8000 105 40 sky130_fd_sc_hd__ha_1
* cell instance $17437 m0 *1 46.46,291.04
X$17437 105 8108 8030 8146 105 8063 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $17439 m0 *1 49.68,291.04
X$17439 105 7972 8242 8064 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17440 m0 *1 51.06,291.04
X$17440 105 8243 8110 8216 105 8030 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $17441 m0 *1 53.82,291.04
X$17441 105 8110 7972 8111 8065 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17444 m0 *1 57.04,291.04
X$17444 40 7638 8147 8192 7879 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $17445 m0 *1 61.18,291.04
X$17445 105 7943 7973 8005 8273 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17449 m0 *1 69.92,291.04
X$17449 40 7976 7921 7923 7974 7922 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $17450 m0 *1 74.52,291.04
X$17450 105 7887 8112 8150 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17451 m0 *1 75.9,291.04
X$17451 40 7923 7886 2532 105 7888 105 40 sky130_fd_sc_hd__ha_1
* cell instance $17455 m0 *1 85.1,291.04
X$17455 105 7745 7976 7975 40 105 7773 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17456 m0 *1 86.94,291.04
X$17456 40 8113 7950 7752 7951 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $17457 m0 *1 90.62,291.04
X$17457 40 8069 3293 8113 8153 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $17458 m0 *1 96.6,291.04
X$17458 40 8033 8563 8152 7318 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $17459 m0 *1 98.9,291.04
X$17459 40 7582 7453 7653 8033 5865 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $17461 m0 *1 103.96,291.04
X$17461 105 8114 7845 7583 105 8075 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $17464 m0 *1 108.56,291.04
X$17464 105 7815 8034 8035 7755 40 8155 105 40 sky130_fd_sc_hd__a22o_1
* cell instance $17466 m0 *1 112.24,291.04
X$17466 40 7713 8035 8157 8156 8158 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $17468 m0 *1 120.06,291.04
X$17468 40 5281 4793 7849 8160 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $17469 m0 *1 130.64,291.04
X$17469 40 8079 7777 8197 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $17471 m0 *1 137.54,291.04
X$17471 105 7850 7926 7823 8116 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17473 m0 *1 139.84,291.04
X$17473 40 8116 8162 7777 3925 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $17474 m0 *1 145.82,291.04
X$17474 105 8017 3402 7852 40 105 8163 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17476 m0 *1 148.58,291.04
X$17476 105 7720 3926 8225 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17478 m0 *1 150.88,291.04
X$17478 105 7980 8165 8087 105 40 8164 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17479 m0 *1 152.72,291.04
X$17479 105 7959 5955 7852 40 105 8087 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17480 m0 *1 154.56,291.04
X$17480 105 8088 6785 7852 40 105 8166 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17482 m0 *1 156.86,291.04
X$17482 105 7720 4831 8167 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17489 m0 *1 171.12,291.04
X$17489 40 40 8228 105 4017 7785 105 sky130_fd_sc_hd__nor2_2
* cell instance $17491 m0 *1 174.34,291.04
X$17491 105 8117 8037 7788 105 40 8036 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17492 m0 *1 176.18,291.04
X$17492 105 8096 6909 7856 40 105 8117 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17495 m0 *1 179.4,291.04
X$17495 105 7858 4831 8170 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17497 m0 *1 181.7,291.04
X$17497 40 40 8230 105 7785 4805 105 sky130_fd_sc_hd__nor2_2
* cell instance $17499 m0 *1 184.46,291.04
X$17499 105 7980 8172 8118 105 40 8171 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17500 m0 *1 186.3,291.04
X$17500 105 7720 4828 8172 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17501 m0 *1 187.68,291.04
X$17501 105 7858 4828 8173 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17503 m0 *1 189.98,291.04
X$17503 105 5048 40 7169 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17504 m0 *1 192.74,291.04
X$17504 105 8099 6632 7856 40 105 8174 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17506 m0 *1 195.04,291.04
X$17506 105 8119 6586 8073 40 105 8118 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17507 m0 *1 196.88,291.04
X$17507 40 40 8119 105 7121 4747 105 sky130_fd_sc_hd__nor2_2
* cell instance $17509 m0 *1 199.64,291.04
X$17509 105 8177 40 7985 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17510 m0 *1 202.4,291.04
X$17510 105 7980 8022 8102 105 40 8038 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17511 m0 *1 204.24,291.04
X$17511 105 8178 7120 8073 40 105 8102 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17512 m0 *1 206.08,291.04
X$17512 105 8023 7095 7856 40 105 8039 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17513 m0 *1 207.92,291.04
X$17513 105 8040 7093 8073 40 105 8120 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17514 m0 *1 209.76,291.04
X$17514 105 7980 8041 8120 105 40 8121 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17515 m0 *1 211.6,291.04
X$17515 105 4665 7169 8042 40 105 8044 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17516 m0 *1 213.44,291.04
X$17516 40 40 8180 105 7121 5179 105 sky130_fd_sc_hd__nor2_2
* cell instance $17517 m0 *1 215.74,291.04
X$17517 105 8180 6353 8073 40 105 8179 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17518 m0 *1 217.58,291.04
X$17518 105 7858 4667 8043 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17519 m0 *1 218.96,291.04
X$17519 105 7984 4670 8045 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17520 m0 *1 220.34,291.04
X$17520 105 8182 6560 7930 40 105 8122 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17522 m0 *1 222.64,291.04
X$17522 105 7984 5179 8182 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17523 m0 *1 224.02,291.04
X$17523 105 8123 3736 8181 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17526 m0 *1 228.16,291.04
X$17526 105 7862 8083 8124 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17528 m0 *1 230,291.04
X$17528 105 8123 3438 8125 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17530 m0 *1 231.84,291.04
X$17530 105 7858 4874 8126 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17531 m0 *1 233.22,291.04
X$17531 105 4751 7861 7722 40 105 8095 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17532 m0 *1 235.06,291.04
X$17532 105 5731 7585 8176 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17534 m0 *1 236.9,291.04
X$17534 105 8094 6959 7930 40 105 8175 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17535 m0 *1 238.74,291.04
X$17535 105 7980 8046 8234 105 40 8363 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17536 m0 *1 240.58,291.04
X$17536 105 7983 4874 8046 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17537 m0 *1 241.96,291.04
X$17537 40 8128 3356 8169 8127 3530 7985 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $17538 m0 *1 245.64,291.04
X$17538 105 6707 7985 8168 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17539 m0 *1 247.02,291.04
X$17539 105 8168 3778 3356 8047 105 8048 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $17541 m0 *1 250.24,291.04
X$17541 40 8086 8128 3736 8048 7983 105 105 40 sky130_fd_sc_hd__o22ai_2
* cell instance $17542 m0 *1 254.84,291.04
X$17542 105 6707 40 8073 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17544 m0 *1 258.52,291.04
X$17544 40 4197 7060 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $17545 m0 *1 267.72,291.04
X$17545 105 7930 6037 8130 7946 40 8258 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17546 m0 *1 270.48,291.04
X$17546 105 7616 7948 8049 105 8082 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $17547 m0 *1 272.32,291.04
X$17547 105 4199 5133 8080 40 105 8078 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17549 m0 *1 275.08,291.04
X$17549 40 40 8130 105 7984 5138 105 sky130_fd_sc_hd__nor2_2
* cell instance $17551 m0 *1 277.84,291.04
X$17551 40 7987 8010 7992 6554 8047 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17553 m0 *1 282.9,291.04
X$17553 40 5013 8161 7984 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17555 m0 *1 287.5,291.04
X$17555 40 8072 8159 7983 6602 8073 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17556 m0 *1 292.1,291.04
X$17556 40 7882 8154 5013 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17557 m0 *1 296.24,291.04
X$17557 105 7616 8205 7932 105 40 8151 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17558 m0 *1 298.08,291.04
X$17558 105 7616 8006 8131 105 40 8050 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17560 m0 *1 300.84,291.04
X$17560 40 4764 8219 7984 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17562 m0 *1 305.44,291.04
X$17562 105 6365 7585 8052 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17564 m0 *1 307.28,291.04
X$17564 40 8149 8003 7946 5747 7940 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17565 m0 *1 311.88,291.04
X$17565 105 8149 8132 4608 40 105 8148 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17567 m0 *1 314.18,291.04
X$17567 40 40 8133 105 7882 4764 105 sky130_fd_sc_hd__nor2_2
* cell instance $17569 m0 *1 316.94,291.04
X$17569 105 8047 5594 7991 7992 40 8143 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17570 m0 *1 319.7,291.04
X$17570 40 7197 8134 7882 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17571 m0 *1 323.84,291.04
X$17571 40 7882 8140 4300 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17573 m0 *1 328.44,291.04
X$17573 40 4271 8139 7882 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17575 m0 *1 333.04,291.04
X$17575 40 7306 6119 7872 7726 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $17576 m0 *1 343.62,291.04
X$17576 40 8138 6512 8137 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $17577 m0 *1 347.76,291.04
X$17577 105 7727 7798 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17581 r0 *1 4.14,291.04
X$17581 105 8104 8210 8136 105 40 7918 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17582 r0 *1 5.98,291.04
X$17582 40 8105 8183 8057 7171 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $17583 r0 *1 11.96,291.04
X$17583 105 8106 105 40 7768 40 sky130_fd_sc_hd__buf_4
* cell instance $17587 r0 *1 15.64,291.04
X$17587 105 8057 8212 7768 8059 105 8183 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $17589 r0 *1 21.62,291.04
X$17589 40 8238 8059 8060 7768 105 7842 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $17590 r0 *1 26.22,291.04
X$17590 105 8184 8185 8141 105 40 8186 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17591 r0 *1 28.06,291.04
X$17591 105 6251 8001 7599 105 40 8185 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17593 r0 *1 30.36,291.04
X$17593 105 8187 8142 8186 8144 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $17595 r0 *1 32.66,291.04
X$17595 105 8186 8142 8187 40 105 7840 40 sky130_fd_sc_hd__a21o_1
* cell instance $17596 r0 *1 35.42,291.04
X$17596 40 8189 8191 1986 105 8238 105 40 sky130_fd_sc_hd__ha_1
* cell instance $17598 r0 *1 40.94,291.04
X$17598 105 8188 8189 8108 8269 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $17601 r0 *1 43.24,291.04
X$17601 40 8191 8190 8145 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17602 r0 *1 47.38,291.04
X$17602 105 8108 8146 8030 8215 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17603 r0 *1 49.22,291.04
X$17603 40 8245 8031 8216 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $17604 r0 *1 58.42,291.04
X$17604 40 7973 8192 8246 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $17606 r0 *1 68.08,291.04
X$17606 105 7921 7974 7922 8248 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17611 r0 *1 71.3,291.04
X$17611 105 7974 7922 7921 105 8112 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $17613 r0 *1 74.52,291.04
X$17613 105 8193 8032 8275 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17614 r0 *1 75.9,291.04
X$17614 105 8150 7923 105 8249 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $17615 r0 *1 79.12,291.04
X$17615 105 8194 7888 8278 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17618 r0 *1 82.8,291.04
X$17618 40 8195 8459 7890 8068 8193 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $17619 r0 *1 90.62,291.04
X$17619 40 40 8193 8195 7647 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $17620 r0 *1 92.92,291.04
X$17620 40 8114 8217 8071 105 8279 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $17623 r0 *1 98.44,291.04
X$17623 105 8114 8153 8033 40 8194 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $17625 r0 *1 102.12,291.04
X$17625 105 8033 7454 7845 8114 8420 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $17626 r0 *1 104.42,291.04
X$17626 40 7582 8035 7453 7653 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $17627 r0 *1 110.4,291.04
X$17627 40 40 7651 105 8153 7454 105 sky130_fd_sc_hd__nor2_2
* cell instance $17628 r0 *1 112.7,291.04
X$17628 105 7547 7817 8252 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17629 r0 *1 114.08,291.04
X$17629 105 7547 7953 8158 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17630 r0 *1 115.46,291.04
X$17630 105 7547 7896 8281 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17631 r0 *1 116.84,291.04
X$17631 105 8115 8077 8013 105 8160 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $17632 r0 *1 118.68,291.04
X$17632 40 40 8081 105 8079 4793 105 sky130_fd_sc_hd__nor2_2
* cell instance $17633 r0 *1 120.98,291.04
X$17633 40 8462 8426 8223 8196 8081 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17636 r0 *1 126.04,291.04
X$17636 105 8115 8222 8223 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17638 r0 *1 127.88,291.04
X$17638 40 7778 8162 8197 8079 105 105 40 sky130_fd_sc_hd__a21boi_4
* cell instance $17639 r0 *1 134.78,291.04
X$17639 40 7564 3402 7849 8224 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $17640 r0 *1 145.36,291.04
X$17640 105 7781 8225 8163 105 40 8290 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17643 r0 *1 148.58,291.04
X$17643 105 4721 7718 8226 40 105 8291 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17645 r0 *1 150.42,291.04
X$17645 105 4097 7718 8164 40 105 8292 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17648 r0 *1 153.64,291.04
X$17648 105 5048 40 7718 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17649 r0 *1 155.48,291.04
X$17649 105 7980 8167 8166 105 40 8226 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17650 r0 *1 157.32,291.04
X$17650 105 4420 7718 8092 40 105 8352 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17651 r0 *1 159.16,291.04
X$17651 105 4514 7718 8089 40 105 8293 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17656 r0 *1 172.5,291.04
X$17656 105 8228 5951 7856 40 105 8295 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17658 r0 *1 174.8,291.04
X$17658 105 7855 3926 8255 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17662 r0 *1 178.94,291.04
X$17662 105 7855 8170 8229 105 40 8198 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17665 r0 *1 182.16,291.04
X$17665 105 8230 6727 7856 40 105 8229 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17668 r0 *1 188.6,291.04
X$17668 105 7855 8173 8174 105 40 8505 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17669 r0 *1 190.44,291.04
X$17669 105 5048 40 8232 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17670 r0 *1 192.28,291.04
X$17670 105 5048 105 40 4752 40 sky130_fd_sc_hd__buf_4
* cell instance $17671 r0 *1 195.04,291.04
X$17671 105 4904 4752 8038 40 105 8360 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17674 r0 *1 199.18,291.04
X$17674 40 6754 7857 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $17677 r0 *1 208.84,291.04
X$17677 105 7855 7957 8039 105 40 8391 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17678 r0 *1 210.68,291.04
X$17678 105 4665 4752 8121 40 105 8302 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17679 r0 *1 212.52,291.04
X$17679 105 5050 7169 8199 40 105 8467 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17681 r0 *1 214.82,291.04
X$17681 105 7980 8235 8179 105 40 8304 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17682 r0 *1 216.66,291.04
X$17682 105 7983 4986 8235 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17684 r0 *1 218.5,291.04
X$17684 105 7855 8236 8122 105 40 8199 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17685 r0 *1 220.34,291.04
X$17685 105 7858 4986 8236 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17688 r0 *1 223.1,291.04
X$17688 105 7185 8181 8200 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17689 r0 *1 224.48,291.04
X$17689 105 7858 8200 8237 105 40 8305 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17690 r0 *1 226.32,291.04
X$17690 105 8124 3778 3358 7940 105 8237 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $17691 r0 *1 229.08,291.04
X$17691 105 3488 8124 3361 7940 105 8201 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $17693 r0 *1 231.84,291.04
X$17693 105 7185 8125 8303 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17695 r0 *1 233.68,291.04
X$17695 105 7616 8176 8095 105 40 8301 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17698 r0 *1 236.44,291.04
X$17698 105 7855 8126 8175 105 40 8300 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17700 r0 *1 238.74,291.04
X$17700 105 8016 6958 8073 40 105 8234 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17703 r0 *1 241.96,291.04
X$17703 105 3781 7985 8127 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17706 r0 *1 245.64,291.04
X$17706 105 8168 3488 3049 8047 105 8231 40 40 sky130_fd_sc_hd__a22oi_1
* cell instance $17707 r0 *1 248.4,291.04
X$17707 105 8129 8231 3438 8086 8298 40 105 40 sky130_fd_sc_hd__o22ai_1
* cell instance $17710 r0 *1 252.08,291.04
X$17710 40 8202 8014 7185 6113 7930 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17711 r0 *1 256.68,291.04
X$17711 105 8203 8129 4758 40 105 8297 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17714 r0 *1 258.98,291.04
X$17714 40 8227 8204 7983 6444 8073 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17716 r0 *1 264.04,291.04
X$17716 40 7564 6443 7427 8082 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $17718 r0 *1 275.54,291.04
X$17718 105 8047 6447 8074 7992 40 8286 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17720 r0 *1 279.22,291.04
X$17720 40 8221 8161 7946 6509 7930 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17721 r0 *1 283.82,291.04
X$17721 40 8220 8154 7983 6596 8073 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17723 r0 *1 288.42,291.04
X$17723 105 8073 5812 8070 7983 40 8284 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17725 r0 *1 291.64,291.04
X$17725 40 8282 8008 7946 6669 7930 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17726 r0 *1 296.24,291.04
X$17726 105 6600 7585 8205 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17728 r0 *1 298.08,291.04
X$17728 40 40 8206 105 7862 4300 105 sky130_fd_sc_hd__nor2_2
* cell instance $17730 r0 *1 301.3,291.04
X$17730 40 8218 8219 7946 6118 7940 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17731 r0 *1 305.9,291.04
X$17731 40 8207 8004 7946 7134 7940 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17732 r0 *1 310.5,291.04
X$17732 105 7940 6368 8208 7946 40 8274 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17734 r0 *1 313.26,291.04
X$17734 105 8047 6300 8133 7992 40 8272 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17736 r0 *1 316.48,291.04
X$17736 105 8214 8129 4553 40 105 8270 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17739 r0 *1 319.24,291.04
X$17739 40 8214 8134 7992 7189 8047 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17740 r0 *1 323.84,291.04
X$17740 40 8213 8139 7992 5967 8047 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17741 r0 *1 328.44,291.04
X$17741 105 8209 105 40 4537 40 sky130_fd_sc_hd__buf_4
* cell instance $17742 r0 *1 331.2,291.04
X$17742 105 7870 8211 8209 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $17744 r0 *1 333.96,291.04
X$17744 105 7872 9486 105 40 40 sky130_fd_sc_hd__inv_6
* cell instance $17745 r0 *1 337.18,291.04
X$17745 40 7306 8137 7872 8138 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $17749 r0 *1 347.76,291.04
X$17749 105 7875 7873 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17778 m0 *1 3.68,296.48
X$17778 40 8104 7595 8136 8210 105 105 40 sky130_fd_sc_hd__nor3_4
* cell instance $17779 m0 *1 9.66,296.48
X$17779 40 7532 8026 8210 7919 8060 8059 105 105 40 sky130_fd_sc_hd__a2111oi_2
* cell instance $17781 m0 *1 16.1,296.48
X$17781 40 8057 8333 8267 105 7969 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $17783 m0 *1 24.38,296.48
X$17783 105 8239 40 8059 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17784 m0 *1 26.22,296.48
X$17784 105 8184 8141 8240 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17788 m0 *1 29.44,296.48
X$17788 40 7597 7837 7969 8027 8240 105 105 40 sky130_fd_sc_hd__nor4_2
* cell instance $17790 m0 *1 34.5,296.48
X$17790 40 8188 8190 8029 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $17792 m0 *1 40.94,296.48
X$17792 105 8189 8063 8109 105 8145 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $17793 m0 *1 43.7,296.48
X$17793 40 2409 8334 8241 8269 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $17794 m0 *1 47.38,296.48
X$17794 40 8243 8146 2251 105 8242 105 40 sky130_fd_sc_hd__ha_1
* cell instance $17796 m0 *1 52.44,296.48
X$17796 105 8243 8216 8110 8244 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17797 m0 *1 54.28,296.48
X$17797 105 8245 7943 8243 7973 105 8241 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $17799 m0 *1 57.04,296.48
X$17799 105 8245 8247 8246 105 8110 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $17800 m0 *1 59.8,296.48
X$17800 105 8245 8246 8247 8111 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17803 m0 *1 63.02,296.48
X$17803 105 8247 8273 8147 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17808 m0 *1 73.14,296.48
X$17808 40 8112 8193 8248 8339 8275 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $17810 m0 *1 78.2,296.48
X$17810 40 40 8311 105 8276 8340 105 sky130_fd_sc_hd__nor2_2
* cell instance $17811 m0 *1 80.5,296.48
X$17811 105 8278 8194 8249 40 105 8277 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17815 m0 *1 86.48,296.48
X$17815 105 8069 8113 8152 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17816 m0 *1 87.86,296.48
X$17816 40 8250 8415 7921 5259 105 105 40 sky130_fd_sc_hd__nor3b_2
* cell instance $17817 m0 *1 92.46,296.48
X$17817 105 8001 7318 8217 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17819 m0 *1 94.76,296.48
X$17819 40 8280 8034 7613 8250 8251 105 105 40 sky130_fd_sc_hd__o211ai_2
* cell instance $17822 m0 *1 100.74,296.48
X$17822 40 8153 8251 7582 7453 7653 105 105 40 sky130_fd_sc_hd__nor4_4
* cell instance $17823 m0 *1 108.56,296.48
X$17823 40 8348 7582 7453 7653 8252 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $17825 m0 *1 112.24,296.48
X$17825 40 7845 8281 8035 7547 8349 8283 105 105 40 sky130_fd_sc_hd__a311oi_4
* cell instance $17826 m0 *1 121.9,296.48
X$17826 40 7820 4793 8162 8223 8081 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $17827 m0 *1 129.26,296.48
X$17827 105 8115 8253 8162 40 8177 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $17828 m0 *1 132.48,296.48
X$17828 105 7926 8254 8575 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17833 m0 *1 140.76,296.48
X$17833 105 8320 8287 8289 105 40 8224 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17834 m0 *1 142.6,296.48
X$17834 105 3402 7550 8287 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17835 m0 *1 143.98,296.48
X$17835 105 3848 7718 8290 40 105 8289 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17836 m0 *1 145.82,296.48
X$17836 40 7564 5955 8389 8351 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $17838 m0 *1 157.32,296.48
X$17838 105 6963 7550 8354 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17839 m0 *1 158.7,296.48
X$17839 105 7617 8294 8293 105 40 8355 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17840 m0 *1 160.54,296.48
X$17840 105 7031 7550 8294 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17846 m0 *1 171.12,296.48
X$17846 105 7985 40 7550 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17847 m0 *1 172.96,296.48
X$17847 105 7788 8255 8295 105 40 8357 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17851 m0 *1 181.24,296.48
X$17851 105 4722 7718 8171 40 105 8296 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17854 m0 *1 187.22,296.48
X$17854 105 6586 8323 8390 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17859 m0 *1 195.04,296.48
X$17859 40 7564 7120 7857 8361 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $17860 m0 *1 204.7,296.48
X$17860 40 7564 7093 7857 8299 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $17862 m0 *1 214.82,296.48
X$17862 105 5050 4752 8304 40 105 8438 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17866 m0 *1 222.64,296.48
X$17866 105 3781 8123 8256 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17867 m0 *1 224.02,296.48
X$17867 40 3530 3358 8366 8256 8305 8123 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $17868 m0 *1 227.7,296.48
X$17868 105 8123 3616 8365 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17870 m0 *1 230,296.48
X$17870 105 7185 8201 8303 105 8364 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $17871 m0 *1 231.84,296.48
X$17871 40 7564 5731 7860 8301 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $17872 m0 *1 242.42,296.48
X$17872 105 7985 3616 8362 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17879 m0 *1 254.84,296.48
X$17879 105 8132 8202 4758 105 8324 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17880 m0 *1 258.06,296.48
X$17880 105 8073 6790 8257 7983 40 8203 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17883 m0 *1 262.2,296.48
X$17883 40 4870 8257 7121 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $17884 m0 *1 266.34,296.48
X$17884 105 8258 8132 5063 40 105 8621 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17885 m0 *1 268.18,296.48
X$17885 105 4800 40 8322 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $17887 m0 *1 271.4,296.48
X$17887 40 8285 8259 7946 6039 7940 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $17888 m0 *1 276,296.48
X$17888 105 6443 7585 8049 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17890 m0 *1 277.84,296.48
X$17890 105 6989 40 8132 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17891 m0 *1 279.68,296.48
X$17891 105 8285 8132 4458 40 105 8288 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17893 m0 *1 282.44,296.48
X$17893 105 8129 8220 4948 105 8328 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17894 m0 *1 285.66,296.48
X$17894 105 8221 8132 4948 40 105 8260 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17895 m0 *1 287.5,296.48
X$17895 105 8284 8129 4946 40 105 8329 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17896 m0 *1 289.34,296.48
X$17896 105 8132 8282 4685 105 8612 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17897 m0 *1 292.56,296.48
X$17897 105 7930 5982 8007 7946 40 8346 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17898 m0 *1 295.32,296.48
X$17898 105 8072 8129 4685 40 105 8261 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17899 m0 *1 297.16,296.48
X$17899 105 7940 6513 7946 8206 40 8345 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17900 m0 *1 299.92,296.48
X$17900 105 8345 7788 4266 40 105 8344 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17903 m0 *1 303.14,296.48
X$17903 105 8218 8132 4864 40 105 8343 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17906 m0 *1 307.28,296.48
X$17906 105 4689 8148 7861 40 105 8551 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17907 m0 *1 309.12,296.48
X$17907 105 8132 8274 4273 105 8342 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17908 m0 *1 312.34,296.48
X$17908 105 8132 8207 4553 105 8330 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17909 m0 *1 315.56,296.48
X$17909 105 8272 8129 4864 40 105 8271 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17911 m0 *1 318.32,296.48
X$17911 105 8047 6541 8140 7992 40 8262 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $17912 m0 *1 321.08,296.48
X$17912 105 8143 8129 4608 40 105 8335 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17913 m0 *1 322.92,296.48
X$17913 105 8262 7781 4266 40 105 8268 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17914 m0 *1 324.76,296.48
X$17914 105 7992 40 8129 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17915 m0 *1 326.6,296.48
X$17915 105 8263 105 40 4847 40 sky130_fd_sc_hd__buf_4
* cell instance $17916 m0 *1 329.36,296.48
X$17916 105 7870 8264 8263 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $17920 m0 *1 333.5,296.48
X$17920 40 7306 8265 7872 8332 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $17921 m0 *1 342.7,296.48
X$17921 105 8056 8264 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17922 m0 *1 344.08,296.48
X$17922 105 8265 8266 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17923 m0 *1 345.46,296.48
X$17923 105 8137 8135 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17924 m0 *1 346.84,296.48
X$17924 105 8055 8211 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $17927 r0 *1 1.84,296.48
X$17927 105 8368 8367 8306 105 8472 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17928 r0 *1 5.06,296.48
X$17928 40 7837 8210 8308 8307 105 105 40 sky130_fd_sc_hd__a21o_4
* cell instance $17929 r0 *1 10.58,296.48
X$17929 105 8307 8210 8308 105 8106 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $17935 r0 *1 16.56,296.48
X$17935 105 8267 8333 8057 40 105 8060 40 sky130_fd_sc_hd__and3_2
* cell instance $17936 r0 *1 19.32,296.48
X$17936 105 8267 8333 8212 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17938 r0 *1 21.16,296.48
X$17938 40 8309 8027 8448 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $17939 r0 *1 25.3,296.48
X$17939 105 8370 6251 8373 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $17940 r0 *1 28.52,296.48
X$17940 105 8373 8187 7970 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $17942 r0 *1 32.66,296.48
X$17942 105 8240 105 40 8404 40 sky130_fd_sc_hd__inv_1
* cell instance $17943 r0 *1 34.04,296.48
X$17943 40 8188 8407 1760 105 8404 105 40 sky130_fd_sc_hd__ha_1
* cell instance $17944 r0 *1 38.64,296.48
X$17944 105 8190 40 105 8479 40 sky130_fd_sc_hd__inv_2
* cell instance $17949 r0 *1 43.24,296.48
X$17949 105 8189 8109 8063 8107 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17950 r0 *1 45.08,296.48
X$17950 105 8375 8376 8310 8408 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $17953 r0 *1 51.06,296.48
X$17953 105 8336 105 40 8378 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $17959 r0 *1 66.7,296.48
X$17959 105 8411 8337 8338 40 8312 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $17965 r0 *1 72.22,296.48
X$17965 105 7921 8193 8380 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $17966 r0 *1 73.6,296.48
X$17966 40 8276 8340 2532 105 8339 105 40 sky130_fd_sc_hd__ha_1
* cell instance $17968 r0 *1 80.04,296.48
X$17968 40 8413 8312 8313 8311 8488 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $17971 r0 *1 89.7,296.48
X$17971 105 7921 8382 8315 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17972 r0 *1 91.08,296.48
X$17972 40 7613 8314 8315 8316 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $17974 r0 *1 96.6,296.48
X$17974 105 7977 8194 8417 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17976 r0 *1 98.44,296.48
X$17976 40 8316 8317 8280 105 8657 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $17977 r0 *1 104.88,296.48
X$17977 105 8382 8033 7613 8153 8114 105 8317 40 40 sky130_fd_sc_hd__o2111ai_1
* cell instance $17979 r0 *1 109.02,296.48
X$17979 40 8388 8422 1591 105 8155 105 40 sky130_fd_sc_hd__ha_1
* cell instance $17980 r0 *1 113.62,296.48
X$17980 105 8348 105 40 8347 40 sky130_fd_sc_hd__buf_4
* cell instance $17981 r0 *1 116.38,296.48
X$17981 40 7564 8427 7849 8318 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $17985 r0 *1 126.5,296.48
X$17985 105 8197 8222 8428 40 105 8253 40 sky130_fd_sc_hd__a21oi_1
* cell instance $17986 r0 *1 128.34,296.48
X$17986 40 7564 8431 7849 8429 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $17987 r0 *1 137.54,296.48
X$17987 105 8350 105 40 7926 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $17990 r0 *1 142.14,296.48
X$17990 105 6961 7550 8432 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $17992 r0 *1 143.98,296.48
X$17992 105 8177 40 7617 105 40 sky130_fd_sc_hd__buf_2
* cell instance $17994 r0 *1 146.74,296.48
X$17994 105 7617 8319 8291 105 40 8435 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17995 r0 *1 148.58,296.48
X$17995 105 7617 8436 8292 105 40 8351 40 sky130_fd_sc_hd__o21ai_1
* cell instance $17999 r0 *1 151.8,296.48
X$17999 105 6785 7550 8319 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18001 r0 *1 153.64,296.48
X$18001 105 5955 7550 8436 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18003 r0 *1 155.48,296.48
X$18003 105 7617 8354 8352 105 40 8353 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18005 r0 *1 158.24,296.48
X$18005 40 7564 7031 8389 8355 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18007 r0 *1 172.5,296.48
X$18007 105 3848 8232 8357 40 105 8356 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18008 r0 *1 174.34,296.48
X$18008 105 4189 8232 7981 40 105 8580 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18012 r0 *1 178.94,296.48
X$18012 105 4721 8232 8198 40 105 8503 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18014 r0 *1 181.24,296.48
X$18014 105 7617 8390 8296 105 40 8358 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18015 r0 *1 183.08,296.48
X$18015 40 7564 6586 7857 8358 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18017 r0 *1 194.58,296.48
X$18017 105 7617 8441 8360 105 40 8361 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18019 r0 *1 197.34,296.48
X$18019 40 7857 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $18022 r0 *1 208.84,296.48
X$18022 105 8177 40 8359 105 40 sky130_fd_sc_hd__buf_2
* cell instance $18023 r0 *1 210.68,296.48
X$18023 105 8359 8321 8302 105 40 8299 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18024 r0 *1 212.52,296.48
X$18024 105 7093 8323 8321 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18025 r0 *1 213.9,296.48
X$18025 40 7564 6353 7857 8437 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18028 r0 *1 228.62,296.48
X$18028 40 8364 3361 8434 8365 4421 8123 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $18030 r0 *1 232.3,296.48
X$18030 105 7985 105 40 8320 40 sky130_fd_sc_hd__buf_4
* cell instance $18033 r0 *1 236.44,296.48
X$18033 105 7985 40 8323 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $18034 r0 *1 239.2,296.48
X$18034 105 4751 8363 8322 40 105 8430 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18035 r0 *1 241.04,296.48
X$18035 40 7564 3049 7427 8500 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18036 r0 *1 251.62,296.48
X$18036 105 6790 8323 8392 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18038 r0 *1 256.68,296.48
X$18038 105 8359 8423 8325 105 40 8425 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18039 r0 *1 258.52,296.48
X$18039 105 4838 8297 7861 40 105 8496 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18041 r0 *1 260.36,296.48
X$18041 105 8227 8129 5063 40 105 8326 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18042 r0 *1 262.2,296.48
X$18042 105 6444 8323 8423 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18044 r0 *1 264.04,296.48
X$18044 40 5138 8204 7882 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $18045 r0 *1 268.18,296.48
X$18045 105 5172 8322 8326 40 105 8325 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18046 r0 *1 270.02,296.48
X$18046 105 6990 8419 8078 105 40 8393 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18047 r0 *1 271.86,296.48
X$18047 105 4529 7861 8288 40 105 8418 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18050 r0 *1 275.08,296.48
X$18050 105 4529 8322 8327 40 105 8494 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18053 r0 *1 279.68,296.48
X$18053 105 8286 7781 4458 40 105 8327 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18054 r0 *1 281.52,296.48
X$18054 105 4759 8328 8322 40 105 8416 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18056 r0 *1 283.82,296.48
X$18056 105 4761 8322 8329 40 105 8414 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18059 r0 *1 289.34,296.48
X$18059 105 4618 8261 7861 40 105 8412 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18063 r0 *1 294.4,296.48
X$18063 105 8346 8132 4946 40 105 8610 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18065 r0 *1 298.08,296.48
X$18065 105 4265 8344 7861 40 105 8410 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18069 r0 *1 304.98,296.48
X$18069 105 4847 4565 8343 40 105 8736 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18072 r0 *1 308.2,296.48
X$18072 105 8342 4270 7861 105 8341 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $18073 r0 *1 311.42,296.48
X$18073 105 7862 4271 8208 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18076 r0 *1 314.64,296.48
X$18076 105 4847 8322 8271 40 105 8405 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18081 r0 *1 319.7,296.48
X$18081 105 4689 8322 8335 40 105 8403 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18082 r0 *1 321.54,296.48
X$18082 105 6367 8320 8398 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18083 r0 *1 322.92,296.48
X$18083 105 8213 8129 4273 40 105 8331 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18084 r0 *1 324.76,296.48
X$18084 105 4270 8322 8331 40 105 8397 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18086 r0 *1 327.52,296.48
X$18086 40 7306 6367 8399 8401 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18088 r0 *1 339.02,296.48
X$18088 40 8332 6467 8265 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18122 m0 *1 1.38,301.92
X$18122 40 8509 8368 8369 105 8443 105 40 sky130_fd_sc_hd__mux2i_2
* cell instance $18123 m0 *1 6.44,301.92
X$18123 105 7379 8370 8369 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18124 m0 *1 7.82,301.92
X$18124 105 8473 8370 8001 40 8368 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $18125 m0 *1 11.04,301.92
X$18125 105 8306 7379 8444 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $18126 m0 *1 14.26,301.92
X$18126 40 8372 8371 8334 8333 8445 8444 105 105 40 sky130_fd_sc_hd__a32oi_4
* cell instance $18127 m0 *1 24.38,301.92
X$18127 105 8372 8371 7835 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $18128 m0 *1 26.68,301.92
X$18128 40 8449 8239 8448 8477 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $18130 m0 *1 29.44,301.92
X$18130 105 8372 8371 7880 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18133 m0 *1 36.34,301.92
X$18133 40 8370 8407 8188 8479 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $18134 m0 *1 42.32,301.92
X$18134 105 8480 8310 8378 105 8448 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $18135 m0 *1 45.08,301.92
X$18135 40 40 8371 105 8374 8451 105 sky130_fd_sc_hd__nor2_2
* cell instance $18136 m0 *1 47.38,301.92
X$18136 105 8375 8376 8451 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18137 m0 *1 48.76,301.92
X$18137 40 8336 8377 8409 8452 105 105 40 sky130_fd_sc_hd__or3_4
* cell instance $18139 m0 *1 53.36,301.92
X$18139 40 8376 8453 8347 8379 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $18143 m0 *1 58.88,301.92
X$18143 105 8347 8379 8374 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18147 m0 *1 68.08,301.92
X$18147 105 8455 8483 8456 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18148 m0 *1 69.46,301.92
X$18148 40 8338 8381 2803 105 8380 105 40 sky130_fd_sc_hd__ha_1
* cell instance $18149 m0 *1 74.06,301.92
X$18149 105 8484 8276 8485 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $18150 m0 *1 77.28,301.92
X$18150 105 8340 8381 8413 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18152 m0 *1 79.12,301.92
X$18152 105 8312 8311 8413 105 8384 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $18155 m0 *1 84.64,301.92
X$18155 40 8457 8383 2251 105 8277 105 40 sky130_fd_sc_hd__ha_1
* cell instance $18158 m0 *1 90.62,301.92
X$18158 40 8415 8382 5259 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $18160 m0 *1 95.22,301.92
X$18160 40 8034 8193 8251 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $18161 m0 *1 99.36,301.92
X$18161 105 8457 8384 8383 40 105 8490 40 sky130_fd_sc_hd__a21o_1
* cell instance $18162 m0 *1 102.12,301.92
X$18162 40 8385 8461 1760 105 8420 105 40 sky130_fd_sc_hd__ha_1
* cell instance $18163 m0 *1 106.72,301.92
X$18163 105 8313 8387 8421 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18165 m0 *1 108.56,301.92
X$18165 105 8386 8388 105 7953 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $18171 m0 *1 119.14,301.92
X$18171 105 8196 8891 8013 105 8426 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18172 m0 *1 120.98,301.92
X$18172 40 7849 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $18173 m0 *1 132.02,301.92
X$18173 105 7850 7926 7823 8428 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $18174 m0 *1 133.86,301.92
X$18174 105 7850 8254 8464 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18177 m0 *1 137.54,301.92
X$18177 105 8431 105 40 7850 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $18181 m0 *1 141.22,301.92
X$18181 105 8320 8432 8433 105 40 8498 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18184 m0 *1 145.82,301.92
X$18184 40 7564 6785 8389 8435 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18185 m0 *1 156.4,301.92
X$18185 40 7564 6963 8389 8353 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18189 m0 *1 172.96,301.92
X$18189 105 6585 7787 8579 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18192 m0 *1 177.1,301.92
X$18192 105 4514 8098 8232 40 105 8502 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18193 m0 *1 178.94,301.92
X$18193 105 6727 7787 8577 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18197 m0 *1 183.54,301.92
X$18197 105 4102 8232 7964 40 105 8632 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18200 m0 *1 188.14,301.92
X$18200 105 4722 8232 8505 40 105 8504 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18202 m0 *1 190.44,301.92
X$18202 105 4024 7927 8232 40 105 8442 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18206 m0 *1 195.04,301.92
X$18206 105 7120 8323 8441 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18207 m0 *1 196.42,301.92
X$18207 105 4097 8233 8232 40 105 8508 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18208 m0 *1 198.26,301.92
X$18208 105 4904 8232 8391 40 105 8440 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18209 m0 *1 200.1,301.92
X$18209 40 7564 6788 8530 8507 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18212 m0 *1 212.06,301.92
X$18212 105 8359 8439 8438 105 40 8437 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18213 m0 *1 213.9,301.92
X$18213 105 6353 8323 8439 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18216 m0 *1 219.42,301.92
X$18216 105 8123 40 7787 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $18218 m0 *1 222.64,301.92
X$18218 105 8123 40 7672 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $18220 m0 *1 226.32,301.92
X$18220 105 8083 40 8123 105 40 sky130_fd_sc_hd__buf_2
* cell instance $18222 m0 *1 229.08,301.92
X$18222 40 7564 3361 7860 8434 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18223 m0 *1 239.66,301.92
X$18223 40 7060 7860 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $18226 m0 *1 250.24,301.92
X$18226 105 7985 40 6990 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $18227 m0 *1 253,301.92
X$18227 105 8359 8392 8496 105 40 8497 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18230 m0 *1 258.98,301.92
X$18230 105 4199 7931 7861 40 105 8424 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18231 m0 *1 260.82,301.92
X$18231 40 7306 6444 7427 8425 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $18232 m0 *1 270.48,301.92
X$18232 105 6554 8320 8419 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18237 m0 *1 278.3,301.92
X$18237 105 8359 8394 8416 105 40 8492 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18239 m0 *1 280.6,301.92
X$18239 105 6596 8323 8394 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18240 m0 *1 281.98,301.92
X$18240 105 8359 8395 8414 105 40 8489 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18242 m0 *1 284.28,301.92
X$18242 105 5812 8323 8395 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18244 m0 *1 287.5,301.92
X$18244 105 6602 8323 8396 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18247 m0 *1 290.26,301.92
X$18247 105 8359 8396 8412 105 40 8486 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18249 m0 *1 292.56,301.92
X$18249 40 7306 6602 8535 8486 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18254 m0 *1 310.04,301.92
X$18254 105 8330 4537 4565 105 8663 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $18256 m0 *1 314.18,301.92
X$18256 105 7189 8320 8550 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18257 m0 *1 315.56,301.92
X$18257 105 4537 8322 8270 40 105 8406 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18259 m0 *1 321.08,301.92
X$18259 105 4265 8268 8322 40 105 8478 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18261 m0 *1 323.84,301.92
X$18261 105 6990 8398 8058 105 40 8401 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18262 m0 *1 325.68,301.92
X$18262 105 6990 8402 8403 105 40 8475 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18263 m0 *1 327.52,301.92
X$18263 105 5594 8320 8402 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18270 m0 *1 339.94,301.92
X$18270 40 7306 8471 7872 8474 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18272 r0 *1 1.38,301.92
X$18272 40 8443 8210 8472 8445 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $18275 r0 *1 11.96,301.92
X$18275 105 8509 6251 8446 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $18280 r0 *1 15.64,301.92
X$18280 105 7379 8306 8370 8367 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $18282 r0 *1 18.4,301.92
X$18282 40 8446 8334 8447 8476 105 8267 105 40 sky130_fd_sc_hd__nand4_2
* cell instance $18283 r0 *1 23,301.92
X$18283 105 8447 8513 8476 105 8192 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $18286 r0 *1 27.6,301.92
X$18286 105 8449 8477 8309 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $18289 r0 *1 31.28,301.92
X$18289 40 8549 8548 8514 8028 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $18292 r0 *1 36.34,301.92
X$18292 40 8678 8555 8450 8057 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $18298 r0 *1 43.24,301.92
X$18298 105 8378 8310 8480 40 8028 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $18299 r0 *1 46.46,301.92
X$18299 40 8336 8375 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $18300 r0 *1 50.6,301.92
X$18300 105 8454 8517 8481 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18302 r0 *1 52.9,301.92
X$18302 105 8377 8347 8379 40 105 8554 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18303 r0 *1 54.74,301.92
X$18303 40 8555 8453 8556 8378 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $18304 r0 *1 58.42,301.92
X$18304 105 8376 8454 8374 40 105 8556 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18307 r0 *1 64.4,301.92
X$18307 105 8338 8337 8411 105 8455 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $18310 r0 *1 68.54,301.92
X$18310 105 8338 8411 8337 8483 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $18315 r0 *1 70.84,301.92
X$18315 40 8520 8456 8380 8521 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $18316 r0 *1 76.36,301.92
X$18316 105 8381 8455 8484 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18319 r0 *1 80.04,301.92
X$18319 105 8384 8457 8560 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $18321 r0 *1 83.72,301.92
X$18321 105 8458 8487 8457 8488 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $18322 r0 *1 85.56,301.92
X$18322 40 8487 1988 8562 8459 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $18323 r0 *1 94.76,301.92
X$18323 105 8457 8487 8458 8385 40 105 8491 40 sky130_fd_sc_hd__and4_1
* cell instance $18329 r0 *1 98.9,301.92
X$18329 105 8567 8458 8460 40 105 8387 40 sky130_fd_sc_hd__a21o_1
* cell instance $18330 r0 *1 101.66,301.92
X$18330 40 8386 8491 8385 8461 8384 8387 105 105 40 sky130_fd_sc_hd__a221oi_1
* cell instance $18331 r0 *1 104.88,301.92
X$18331 105 7651 8035 7347 8347 40 105 8620 40 sky130_fd_sc_hd__a31oi_1
* cell instance $18333 r0 *1 107.64,301.92
X$18333 105 8385 8461 8388 105 8493 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18335 r0 *1 109.94,301.92
X$18335 40 8313 8387 8422 7547 8570 8461 105 105 40 sky130_fd_sc_hd__o41ai_4
* cell instance $18336 r0 *1 120.06,301.92
X$18336 105 8079 8495 8462 8526 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $18337 r0 *1 121.9,301.92
X$18337 105 8463 8254 8464 105 8429 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18341 r0 *1 123.74,301.92
X$18341 105 8525 8254 8575 105 8573 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18343 r0 *1 126.04,301.92
X$18343 40 6754 7849 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $18344 r0 *1 135.24,301.92
X$18344 105 8079 8222 8254 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18346 r0 *1 138.46,301.92
X$18346 40 7564 6961 8389 8498 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18347 r0 *1 149.04,301.92
X$18347 40 8578 3768 8527 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18358 r0 *1 167.9,301.92
X$18358 40 7564 6585 8389 8581 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18362 r0 *1 178.48,301.92
X$18362 105 8503 8577 8466 105 40 8465 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18368 r0 *1 187.68,301.92
X$18368 40 7564 5465 7857 8574 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18370 r0 *1 200.1,301.92
X$18370 105 8466 8571 8508 105 40 8507 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18371 r0 *1 201.94,301.92
X$18371 105 6788 7787 8571 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18378 r0 *1 206.54,301.92
X$18378 105 8083 105 40 8466 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $18381 r0 *1 209.76,301.92
X$18381 105 8466 8569 8467 105 40 8506 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18382 r0 *1 211.6,301.92
X$18382 40 7564 6560 7857 8506 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18384 r0 *1 222.64,301.92
X$18384 40 7564 3358 7860 8366 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18388 r0 *1 233.22,301.92
X$18388 105 8083 40 8501 105 40 sky130_fd_sc_hd__buf_2
* cell instance $18391 r0 *1 236.44,301.92
X$18391 105 4751 4565 8300 40 105 8565 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18393 r0 *1 238.74,301.92
X$18393 105 7860 9503 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $18394 r0 *1 240.58,301.92
X$18394 105 6958 8323 8468 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18395 r0 *1 241.96,301.92
X$18395 40 8298 3049 8500 8362 4421 7985 105 105 40 sky130_fd_sc_hd__a221o_1
* cell instance $18396 r0 *1 245.64,301.92
X$18396 105 8359 8468 8430 105 40 8499 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18397 r0 *1 247.48,301.92
X$18397 40 7306 6790 7860 8497 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18398 r0 *1 258.06,301.92
X$18398 105 8424 8558 7672 105 40 8557 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18404 r0 *1 264.04,301.92
X$18404 40 7306 6554 8534 8393 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18405 r0 *1 274.62,301.92
X$18405 105 6990 8469 8494 105 40 8553 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18406 r0 *1 276.46,301.92
X$18406 105 6447 8320 8469 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18409 r0 *1 280.6,301.92
X$18409 40 7306 5812 8534 8489 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18423 r0 *1 313.72,301.92
X$18423 105 8359 8550 8406 105 40 8470 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18424 r0 *1 315.56,301.92
X$18424 105 8359 8547 8405 105 40 8482 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18425 r0 *1 317.4,301.92
X$18425 105 6300 8320 8547 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18427 r0 *1 319.24,301.92
X$18427 105 6541 8320 8544 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18428 r0 *1 320.62,301.92
X$18428 105 6990 8544 8478 105 40 8542 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18429 r0 *1 322.46,301.92
X$18429 105 6990 8545 8397 105 40 8543 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18430 r0 *1 324.3,301.92
X$18430 105 5967 8320 8545 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18431 r0 *1 325.68,301.92
X$18431 40 7306 5594 8399 8475 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18432 r0 *1 336.26,301.92
X$18432 40 8541 6367 8538 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18437 r0 *1 341.32,301.92
X$18437 40 8474 6468 8471 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18441 r0 *1 347.76,301.92
X$18441 105 8471 8400 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $18443 m0 *1 5.06,307.36
X$18443 40 7919 8583 8510 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $18444 m0 *1 11.04,307.36
X$18444 40 8510 8583 7596 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $18446 m0 *1 17.48,307.36
X$18446 105 8540 8511 8447 105 40 8583 40 sky130_fd_sc_hd__or3_2
* cell instance $18448 m0 *1 22.08,307.36
X$18448 105 8511 8540 8510 8512 105 40 8449 40 sky130_fd_sc_hd__o31ai_1
* cell instance $18449 m0 *1 24.84,307.36
X$18449 40 7937 8588 8586 8476 8585 8548 105 105 40 sky130_fd_sc_hd__a311o_2
* cell instance $18451 m0 *1 29.44,307.36
X$18451 40 8546 8639 8515 8584 105 8372 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $18452 m0 *1 37.26,307.36
X$18452 105 8481 8514 8549 40 105 8515 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18453 m0 *1 39.1,307.36
X$18453 105 8589 8310 8516 105 8512 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18455 m0 *1 41.4,307.36
X$18455 105 8408 8378 8376 40 105 8450 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18457 m0 *1 43.7,307.36
X$18457 105 8452 8409 8516 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18458 m0 *1 45.08,307.36
X$18458 105 8377 8589 8480 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18461 m0 *1 47.84,307.36
X$18461 40 8586 8554 8375 8376 8517 105 105 40 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $18462 m0 *1 51.06,307.36
X$18462 105 8452 8409 8518 8519 8517 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $18464 m0 *1 54.28,307.36
X$18464 105 8518 8519 8376 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $18466 m0 *1 57.04,307.36
X$18466 40 8347 8379 8590 8518 8519 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $18470 m0 *1 69.46,307.36
X$18470 40 8520 8613 8411 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $18472 m0 *1 75.44,307.36
X$18472 40 8615 8485 8339 8522 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18474 m0 *1 80.04,307.36
X$18474 105 8520 8277 8523 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18475 m0 *1 81.42,307.36
X$18475 105 8520 8523 8560 105 40 8617 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18478 m0 *1 84.64,307.36
X$18478 40 7613 8520 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $18479 m0 *1 88.78,307.36
X$18479 105 8490 8487 105 8561 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $18480 m0 *1 92,307.36
X$18480 105 8566 8458 8592 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $18481 m0 *1 95.22,307.36
X$18481 40 8618 7977 8522 8563 8279 8194 105 105 40 sky130_fd_sc_hd__a2111o_1
* cell instance $18482 m0 *1 99.36,307.36
X$18482 40 8458 8460 1986 105 8568 105 40 sky130_fd_sc_hd__ha_1
* cell instance $18484 m0 *1 104.42,307.36
X$18484 40 7896 8421 8385 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $18488 m0 *1 112.24,307.36
X$18488 105 8493 8422 40 105 8570 40 sky130_fd_sc_hd__or2b_1
* cell instance $18491 m0 *1 117.76,307.36
X$18491 105 8524 105 40 8463 40 sky130_fd_sc_hd__inv_1
* cell instance $18492 m0 *1 119.14,307.36
X$18492 40 9539 8572 8622 105 8524 105 40 sky130_fd_sc_hd__ha_1
* cell instance $18493 m0 *1 123.74,307.36
X$18493 105 8525 8462 8526 105 8318 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18494 m0 *1 125.58,307.36
X$18494 105 8427 105 40 8525 40 sky130_fd_sc_hd__inv_1
* cell instance $18496 m0 *1 127.42,307.36
X$18496 40 7564 8350 7849 8573 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18500 m0 *1 139.84,307.36
X$18500 40 7564 8527 8660 8578 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18501 m0 *1 149.04,307.36
X$18501 40 8625 4447 8627 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18503 m0 *1 154.1,307.36
X$18503 105 8389 9501 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $18504 m0 *1 155.94,307.36
X$18504 40 6754 8389 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $18509 m0 *1 172.04,307.36
X$18509 105 8466 8579 8580 105 40 8581 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18510 m0 *1 173.88,307.36
X$18510 105 3924 8232 8036 40 105 8595 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18511 m0 *1 175.72,307.36
X$18511 40 7564 6962 8389 8597 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18512 m0 *1 186.3,307.36
X$18512 105 6031 7787 8706 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18513 m0 *1 187.68,307.36
X$18513 105 8466 8528 8504 105 40 8633 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18515 m0 *1 189.98,307.36
X$18515 105 8466 8576 8442 105 40 8574 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18516 m0 *1 191.82,307.36
X$18516 105 5465 7787 8576 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18517 m0 *1 193.2,307.36
X$18517 105 6632 8529 8528 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18520 m0 *1 196.88,307.36
X$18520 40 7564 7095 8530 8631 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $18522 m0 *1 210.22,307.36
X$18522 105 7027 8529 8532 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18523 m0 *1 211.6,307.36
X$18523 105 8466 8532 8044 105 40 8533 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18525 m0 *1 213.9,307.36
X$18525 105 6560 8529 8569 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18532 m0 *1 223.56,307.36
X$18532 105 8123 40 8529 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $18534 m0 *1 226.78,307.36
X$18534 105 8123 40 8531 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $18538 m0 *1 235.52,307.36
X$18538 105 8501 8564 8565 105 40 8628 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18539 m0 *1 237.36,307.36
X$18539 105 6959 8529 8564 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18541 m0 *1 239.2,307.36
X$18541 40 7564 6958 7860 8499 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18544 m0 *1 253.92,307.36
X$18544 105 4838 8324 4565 40 105 8559 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18545 m0 *1 255.76,307.36
X$18545 40 7306 6556 7860 8557 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18550 m0 *1 277.84,307.36
X$18550 40 7306 6596 8534 8492 105 105 40 sky130_fd_sc_hd__dfrtp_2
* cell instance $18553 m0 *1 289.8,307.36
X$18553 105 4761 8610 4565 40 105 8552 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18556 m0 *1 294.4,307.36
X$18556 40 7306 5813 8535 8050 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18559 m0 *1 306.36,307.36
X$18559 105 5747 8531 8536 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18560 m0 *1 307.74,307.36
X$18560 105 8501 8536 8551 105 40 8537 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18561 m0 *1 309.58,307.36
X$18561 40 7306 5747 7365 8537 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18563 m0 *1 320.62,307.36
X$18563 40 7306 6541 8399 8542 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18567 m0 *1 333.04,307.36
X$18567 40 7306 8538 8399 8541 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18568 m0 *1 342.24,307.36
X$18568 40 8608 5658 8607 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18569 m0 *1 346.38,307.36
X$18569 105 8538 8605 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $18573 r0 *1 1.84,307.36
X$18573 40 8582 8136 8546 8447 8606 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $18574 r0 *1 9.66,307.36
X$18574 105 8636 8546 8447 8582 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $18575 r0 *1 11.5,307.36
X$18575 105 8787 8668 8669 8308 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $18580 r0 *1 16.56,307.36
X$18580 105 8638 8672 8674 105 8671 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18581 r0 *1 18.4,307.36
X$18581 40 8511 8476 8540 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $18583 r0 *1 23.46,307.36
X$18583 40 8184 8447 8584 8609 8639 8546 105 105 40 sky130_fd_sc_hd__o2111a_1
* cell instance $18584 r0 *1 27.6,307.36
X$18584 105 8546 8639 8584 8587 8477 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $18585 r0 *1 30.36,307.36
X$18585 105 8586 8514 8549 40 105 8587 40 sky130_fd_sc_hd__a21boi_0
* cell instance $18587 r0 *1 33.58,307.36
X$18587 105 8546 8639 8584 8588 8678 105 40 40 sky130_fd_sc_hd__o211ai_1
* cell instance $18594 r0 *1 44.16,307.36
X$18594 105 8409 8834 8680 105 40 8588 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18597 r0 *1 47.38,307.36
X$18597 105 8454 8591 8590 8680 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $18598 r0 *1 49.22,307.36
X$18598 40 8590 8591 8454 8514 8682 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $18600 r0 *1 58.88,307.36
X$18600 105 8611 8649 8648 8519 105 40 40 sky130_fd_sc_hd__or3b_1
* cell instance $18608 r0 *1 70.84,307.36
X$18608 105 8456 5259 8885 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $18609 r0 *1 74.06,307.36
X$18609 105 8651 8614 8616 40 8688 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $18613 r0 *1 85.1,307.36
X$18613 105 8520 40 105 8522 40 sky130_fd_sc_hd__inv_2
* cell instance $18614 r0 *1 86.48,307.36
X$18614 40 8689 8459 8561 8522 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $18615 r0 *1 90.62,307.36
X$18615 105 8487 8383 8562 40 105 8567 40 sky130_fd_sc_hd__a21o_1
* cell instance $18616 r0 *1 93.38,307.36
X$18616 105 7347 7613 8592 8693 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $18617 r0 *1 95.68,307.36
X$18617 105 7613 105 40 8656 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $18621 r0 *1 98.44,307.36
X$18621 105 8562 8487 8490 40 105 8566 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18623 r0 *1 101.2,307.36
X$18623 105 8619 8075 8620 105 40 8697 40 sky130_fd_sc_hd__a21o_2
* cell instance $18624 r0 *1 104.42,307.36
X$18624 40 40 8636 105 3293 8593 105 sky130_fd_sc_hd__nor2_2
* cell instance $18626 r0 *1 107.18,307.36
X$18626 105 7347 40 8593 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $18632 r0 *1 120.52,307.36
X$18632 40 8495 8659 8427 105 8572 105 40 sky130_fd_sc_hd__ha_1
* cell instance $18636 r0 *1 126.04,307.36
X$18636 105 8463 8462 8702 105 8701 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18637 r0 *1 127.88,307.36
X$18637 105 8703 8427 40 105 8197 40 sky130_fd_sc_hd__nor2b_2
* cell instance $18638 r0 *1 131.1,307.36
X$18638 105 7823 8254 8809 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18640 r0 *1 132.94,307.36
X$18640 40 3307 4498 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $18641 r0 *1 137.08,307.36
X$18641 105 8624 105 40 7823 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $18644 r0 *1 143.06,307.36
X$18644 40 7564 8627 8389 8625 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18650 r0 *1 155.94,307.36
X$18650 40 8708 4829 8629 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18653 r0 *1 161.46,307.36
X$18653 40 7564 6727 8389 8465 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18654 r0 *1 172.04,307.36
X$18654 105 8531 8594 8356 105 40 8710 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18655 r0 *1 173.88,307.36
X$18655 105 8531 8596 8595 105 40 8709 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18656 r0 *1 175.72,307.36
X$18656 105 6909 7787 8596 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18657 r0 *1 177.1,307.36
X$18657 105 8466 8598 8502 105 40 8597 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18659 r0 *1 178.94,307.36
X$18659 105 5951 7787 8594 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18662 r0 *1 181.24,307.36
X$18662 105 6962 7787 8598 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18664 r0 *1 183.08,307.36
X$18664 105 8466 8706 8632 105 40 8707 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18665 r0 *1 184.92,307.36
X$18665 40 7564 6632 7857 8633 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18668 r0 *1 197.8,307.36
X$18668 105 8466 8599 8440 105 40 8631 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18670 r0 *1 200.1,307.36
X$18670 105 7095 8529 8599 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18677 r0 *1 208.84,307.36
X$18677 40 8704 4907 8630 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18679 r0 *1 213.44,307.36
X$18679 40 7564 7027 8530 8533 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18686 r0 *1 236.44,307.36
X$18686 105 8600 105 40 3616 40 sky130_fd_sc_hd__buf_4
* cell instance $18688 r0 *1 239.66,307.36
X$18688 105 8626 105 40 3781 40 sky130_fd_sc_hd__buf_4
* cell instance $18691 r0 *1 244.72,307.36
X$18691 105 4793 40 7870 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $18693 r0 *1 248.4,307.36
X$18693 105 8559 8699 8501 105 40 8729 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18694 r0 *1 250.24,307.36
X$18694 105 6113 8529 8699 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18696 r0 *1 253.46,307.36
X$18696 40 8698 6790 8623 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18700 r0 *1 259.9,307.36
X$18700 105 6556 8531 8558 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18705 r0 *1 264.5,307.36
X$18705 105 5172 8621 4565 40 105 8696 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18707 r0 *1 266.8,307.36
X$18707 105 6037 8529 8695 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18709 r0 *1 269.1,307.36
X$18709 105 7672 8691 8418 105 40 8692 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18710 r0 *1 270.94,307.36
X$18710 105 6039 8531 8691 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18711 r0 *1 272.32,307.36
X$18711 40 7306 6447 8534 8553 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18712 r0 *1 282.9,307.36
X$18712 105 4759 4565 8260 40 105 8687 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18713 r0 *1 284.74,307.36
X$18713 105 8501 8601 8552 105 40 8685 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18715 r0 *1 286.58,307.36
X$18715 105 5982 8529 8601 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18716 r0 *1 287.96,307.36
X$18716 105 4618 4565 8612 40 105 8683 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18722 r0 *1 295.78,307.36
X$18722 105 6513 8531 8602 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18723 r0 *1 297.16,307.36
X$18723 105 7672 8602 8410 105 40 8679 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18724 r0 *1 299,307.36
X$18724 40 7306 6365 8535 8066 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18725 r0 *1 309.58,307.36
X$18725 105 6368 8531 8675 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18732 r0 *1 321.08,307.36
X$18732 40 7306 5967 8399 8543 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18733 r0 *1 331.66,307.36
X$18733 40 8603 6602 8604 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18734 r0 *1 335.8,307.36
X$18734 40 7306 8604 8399 8603 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18740 r0 *1 347.3,307.36
X$18740 105 8604 8539 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $18770 m0 *1 3.68,312.8
X$18770 105 6251 8634 8606 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18771 m0 *1 5.06,312.8
X$18771 40 8307 6251 8546 8667 8635 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $18774 m0 *1 9.66,312.8
X$18774 105 8712 8830 8510 8668 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $18775 m0 *1 11.5,312.8
X$18775 105 8510 8671 8637 40 105 8669 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18776 m0 *1 13.34,312.8
X$18776 105 7379 8634 8639 105 40 40 sky130_fd_sc_hd__or2_2
* cell instance $18777 m0 *1 15.64,312.8
X$18777 40 40 8641 105 8670 8639 105 sky130_fd_sc_hd__nor2_2
* cell instance $18778 m0 *1 17.94,312.8
X$18778 105 8640 8763 8641 105 8540 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $18779 m0 *1 20.7,312.8
X$18779 105 8473 105 40 6251 40 sky130_fd_sc_hd__buf_4
* cell instance $18781 m0 *1 23.92,312.8
X$18781 105 8642 105 40 8447 40 sky130_fd_sc_hd__buf_4
* cell instance $18782 m0 *1 26.68,312.8
X$18782 40 40 8638 105 8643 8639 105 sky130_fd_sc_hd__nor2_2
* cell instance $18786 m0 *1 30.82,312.8
X$18786 105 8514 8586 8549 105 8642 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $18790 m0 *1 40.02,312.8
X$18790 40 8640 8375 8645 8644 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $18791 m0 *1 46,312.8
X$18791 105 8646 8409 8589 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $18793 m0 *1 50.14,312.8
X$18793 105 8646 8681 8682 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $18795 m0 *1 53.36,312.8
X$18795 105 8646 3293 8742 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $18797 m0 *1 57.04,312.8
X$18797 105 8647 8684 8648 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18798 m0 *1 58.42,312.8
X$18798 105 8648 8611 8649 105 40 8518 40 sky130_fd_sc_hd__o21bai_1
* cell instance $18800 m0 *1 65.78,312.8
X$18800 40 8650 2803 8651 8613 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $18801 m0 *1 74.98,312.8
X$18801 40 8616 8521 8745 2532 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $18803 m0 *1 84.64,312.8
X$18803 105 8650 8686 8690 8746 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $18806 m0 *1 89.24,312.8
X$18806 105 8593 8522 8653 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18807 m0 *1 90.62,312.8
X$18807 105 8693 8747 8694 8193 8656 8652 105 40 40 sky130_fd_sc_hd__o221ai_1
* cell instance $18808 m0 *1 93.84,312.8
X$18808 40 8750 8653 8654 8193 8652 8655 105 105 40 sky130_fd_sc_hd__a311oi_2
* cell instance $18809 m0 *1 99.36,312.8
X$18809 105 8563 8279 8753 8655 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $18810 m0 *1 101.2,312.8
X$18810 105 8417 8654 8568 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18812 m0 *1 103.04,312.8
X$18812 105 8347 7613 8658 40 105 8619 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18814 m0 *1 105.8,312.8
X$18814 40 3304 8001 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $18819 m0 *1 113.62,312.8
X$18819 40 7564 8524 7849 8701 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18820 m0 *1 122.82,312.8
X$18820 40 40 8659 8077 8222 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $18821 m0 *1 125.12,312.8
X$18821 40 8759 8703 8705 105 8463 105 40 sky130_fd_sc_hd__ha_1
* cell instance $18822 m0 *1 129.72,312.8
X$18822 40 7564 8624 8660 8761 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18829 m0 *1 148.58,312.8
X$18829 40 7564 8629 8389 8708 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18830 m0 *1 157.78,312.8
X$18830 40 7564 8760 8661 8810 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18833 m0 *1 169.28,312.8
X$18833 40 7564 6909 8661 8709 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18834 m0 *1 179.86,312.8
X$18834 40 7564 6031 8661 8707 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18841 m0 *1 200.1,312.8
X$18841 40 7564 8755 8530 8756 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18842 m0 *1 209.3,312.8
X$18842 40 7564 8630 8530 8704 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18847 m0 *1 227.24,312.8
X$18847 40 8752 3552 8751 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18850 m0 *1 233.68,312.8
X$18850 40 7564 6959 7860 8628 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18854 m0 *1 250.24,312.8
X$18854 40 7306 8623 7860 8698 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18858 m0 *1 264.5,312.8
X$18858 105 8501 8695 8696 105 40 8744 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18860 m0 *1 266.8,312.8
X$18860 40 7306 6039 8534 8692 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18862 m0 *1 277.84,312.8
X$18862 105 8534 9496 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $18863 m0 *1 279.68,312.8
X$18863 40 8743 4529 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $18864 m0 *1 284.74,312.8
X$18864 105 8501 8662 8687 105 40 8741 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18865 m0 *1 286.58,312.8
X$18865 40 7306 6669 8535 8740 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18868 m0 *1 299.46,312.8
X$18868 105 8067 8677 7672 105 40 8737 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18869 m0 *1 301.3,312.8
X$18869 105 6366 8531 8677 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18874 m0 *1 306.36,312.8
X$18874 105 6118 8531 8735 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18875 m0 *1 307.74,312.8
X$18875 105 8341 8675 8501 105 40 8835 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18876 m0 *1 309.58,312.8
X$18876 105 8501 8673 8663 105 40 8676 40 sky130_fd_sc_hd__o21ai_1
* cell instance $18877 m0 *1 311.42,312.8
X$18877 105 7134 8531 8673 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18880 m0 *1 314.18,312.8
X$18880 40 7306 7189 7365 8470 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18882 m0 *1 328.44,312.8
X$18882 40 8734 6541 8666 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18884 m0 *1 333.04,312.8
X$18884 40 7060 8399 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $18885 m0 *1 342.24,312.8
X$18885 105 8666 8732 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $18890 r0 *1 3.68,312.8
X$18890 105 8712 8546 8447 8711 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $18891 r0 *1 5.52,312.8
X$18891 40 8104 8606 8546 8712 8711 105 105 40 sky130_fd_sc_hd__a31o_1
* cell instance $18893 r0 *1 9.2,312.8
X$18893 105 8447 8634 8510 40 105 8667 40 sky130_fd_sc_hd__a21oi_1
* cell instance $18896 r0 *1 12.42,312.8
X$18896 40 40 8001 8762 8712 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $18900 r0 *1 15.64,312.8
X$18900 40 8012 8672 8634 8643 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $18902 r0 *1 18.4,312.8
X$18902 105 8674 8713 8638 105 8511 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $18903 r0 *1 21.16,312.8
X$18903 40 8713 8584 8763 8640 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $18904 r0 *1 29.44,312.8
X$18904 105 8714 40 8674 105 40 sky130_fd_sc_hd__buf_2
* cell instance $18906 r0 *1 33.12,312.8
X$18906 40 8739 8591 8738 8510 8714 8310 105 105 40 sky130_fd_sc_hd__a221oi_4
* cell instance $18909 r0 *1 43.24,312.8
X$18909 40 8714 8375 8645 8644 105 105 40 sky130_fd_sc_hd__a21o_4
* cell instance $18911 r0 *1 49.22,312.8
X$18911 40 40 8591 105 8452 8715 105 sky130_fd_sc_hd__nor2_2
* cell instance $18913 r0 *1 52.44,312.8
X$18913 40 8768 8549 8790 8742 105 105 40 sky130_fd_sc_hd__a21boi_2
* cell instance $18915 r0 *1 57.04,312.8
X$18915 40 8644 8611 8649 8647 8716 105 105 40 sky130_fd_sc_hd__o31a_2
* cell instance $18917 r0 *1 61.18,312.8
X$18917 105 8611 8649 8717 105 8716 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18919 r0 *1 63.48,312.8
X$18919 40 8614 8717 8770 8718 8720 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $18920 r0 *1 68.08,312.8
X$18920 105 8650 8686 8719 8770 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $18924 r0 *1 70.84,312.8
X$18924 105 8792 8616 8771 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $18925 r0 *1 74.06,312.8
X$18925 105 8651 8614 8792 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18927 r0 *1 77.28,312.8
X$18927 105 8688 8745 8773 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $18928 r0 *1 79.58,312.8
X$18928 40 8774 8615 8799 2251 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $18929 r0 *1 88.78,312.8
X$18929 105 8721 8722 8647 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18932 r0 *1 91.54,312.8
X$18932 105 8593 8592 8747 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18933 r0 *1 92.92,312.8
X$18933 105 8656 8592 9301 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18934 r0 *1 94.3,312.8
X$18934 105 7347 8656 7977 8694 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $18937 r0 *1 96.6,312.8
X$18937 105 8563 8279 8654 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $18939 r0 *1 98.44,312.8
X$18939 105 8656 8723 8753 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18940 r0 *1 99.82,312.8
X$18940 105 8656 8724 8697 105 8722 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18942 r0 *1 102.12,312.8
X$18942 105 8658 8775 8724 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $18944 r0 *1 103.96,312.8
X$18944 105 7896 8754 8775 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $18945 r0 *1 107.18,312.8
X$18945 40 7347 8012 3304 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $18947 r0 *1 113.16,312.8
X$18947 40 7564 8622 7849 8804 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18948 r0 *1 122.36,312.8
X$18948 105 8659 8705 8462 8079 105 8758 40 40 sky130_fd_sc_hd__nand4b_1
* cell instance $18951 r0 *1 126.04,312.8
X$18951 105 8659 8759 8462 8079 105 8702 40 40 sky130_fd_sc_hd__nand4b_1
* cell instance $18952 r0 *1 129.26,312.8
X$18952 105 8705 8254 8809 105 8761 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $18955 r0 *1 133.86,312.8
X$18955 40 7564 8726 8660 8725 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18957 r0 *1 143.98,312.8
X$18957 40 8725 5175 8726 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18971 r0 *1 169.74,312.8
X$18971 40 7564 5951 8661 8710 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $18979 r0 *1 190.9,312.8
X$18979 40 8811 6843 8757 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18983 r0 *1 204.24,312.8
X$18983 40 8756 4585 8755 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18986 r0 *1 208.84,312.8
X$18986 40 8727 6911 8728 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $18987 r0 *1 212.98,312.8
X$18987 40 7564 8728 8530 8727 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18990 r0 *1 224.48,312.8
X$18990 40 7564 8751 8802 8752 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $18997 r0 *1 238.74,312.8
X$18997 105 8749 7870 8626 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $18999 r0 *1 241.5,312.8
X$18999 105 8748 7870 8600 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $19000 r0 *1 243.8,312.8
X$19000 40 7306 6113 8802 8729 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19001 r0 *1 254.38,312.8
X$19001 105 4793 8730 8731 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19002 r0 *1 256.68,312.8
X$19002 105 8731 105 40 4199 40 sky130_fd_sc_hd__buf_4
* cell instance $19004 r0 *1 259.44,312.8
X$19004 40 3311 2957 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19006 r0 *1 264.04,312.8
X$19006 40 7306 6037 8534 8744 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19007 r0 *1 274.62,312.8
X$19007 105 7870 9095 8743 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19008 r0 *1 276.92,312.8
X$19008 40 7306 6509 8534 8741 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19010 r0 *1 287.5,312.8
X$19010 105 8683 8791 8501 105 40 8740 40 sky130_fd_sc_hd__o21ai_1
* cell instance $19011 r0 *1 289.34,312.8
X$19011 105 6669 8529 8791 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19015 r0 *1 292.56,312.8
X$19015 40 7306 6044 8535 7811 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19018 r0 *1 304.52,312.8
X$19018 105 8501 8735 8736 105 40 8789 40 sky130_fd_sc_hd__o21ai_1
* cell instance $19019 r0 *1 306.36,312.8
X$19019 40 7306 7134 8535 8676 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19023 r0 *1 319.24,312.8
X$19023 40 7306 8785 8399 8833 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19025 r0 *1 329.36,312.8
X$19025 40 7306 8666 8399 8734 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19026 r0 *1 338.56,312.8
X$19026 105 4205 40 7435 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $19028 r0 *1 341.32,312.8
X$19028 40 8788 6589 8733 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19032 r0 *1 347.76,312.8
X$19032 105 8607 8664 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19060 m0 *1 5.06,318.24
X$19060 40 8754 8712 8634 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $19061 m0 *1 10.12,318.24
X$19061 105 8510 8546 8636 8634 40 105 8787 40 sky130_fd_sc_hd__and4_1
* cell instance $19064 m0 *1 14.72,318.24
X$19064 105 8762 8670 40 8763 105 40 sky130_fd_sc_hd__and2_4
* cell instance $19065 m0 *1 17.94,318.24
X$19065 105 8762 8643 40 8713 105 40 sky130_fd_sc_hd__and2_4
* cell instance $19066 m0 *1 21.16,318.24
X$19066 105 8641 8831 8640 105 8637 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $19067 m0 *1 23,318.24
X$19067 40 8641 8640 8763 8764 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $19069 m0 *1 29.44,318.24
X$19069 40 8714 8670 8643 8546 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $19070 m0 *1 34.96,318.24
X$19070 105 8715 8765 8739 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $19071 m0 *1 37.26,318.24
X$19071 105 8715 8765 8738 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19074 m0 *1 41.4,318.24
X$19074 40 8310 8766 8645 8644 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $19075 m0 *1 47.38,318.24
X$19075 105 8646 8681 8837 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19076 m0 *1 48.76,318.24
X$19076 105 8814 8636 8452 8715 105 8767 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $19077 m0 *1 51.06,318.24
X$19077 40 8814 8790 8473 8715 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $19079 m0 *1 53.82,318.24
X$19079 105 8347 8721 8684 8769 40 105 40 sky130_fd_sc_hd__nor3b_1
* cell instance $19082 m0 *1 57.5,318.24
X$19082 40 8769 8645 8840 8841 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $19084 m0 *1 66.24,318.24
X$19084 105 8650 8719 8686 105 8614 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $19086 m0 *1 69.92,318.24
X$19086 105 8717 8613 8720 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19088 m0 *1 72.22,318.24
X$19088 40 8772 8771 8521 8794 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $19089 m0 *1 77.74,318.24
X$19089 40 40 8615 8795 8772 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $19090 m0 *1 80.04,318.24
X$19090 105 8774 8773 8796 105 40 40 sky130_fd_sc_hd__and2_0
* cell instance $19095 m0 *1 86.02,318.24
X$19095 40 4898 8658 8797 8746 105 105 40 sky130_fd_sc_hd__nor3_2
* cell instance $19099 m0 *1 96.14,318.24
X$19099 105 7347 7977 8723 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19101 m0 *1 99.36,318.24
X$19101 105 8157 8801 8684 105 40 40 sky130_fd_sc_hd__or2_2
* cell instance $19104 m0 *1 103.96,318.24
X$19104 105 5865 105 40 8473 40 sky130_fd_sc_hd__buf_4
* cell instance $19107 m0 *1 108.1,318.24
X$19107 105 5865 8776 3304 40 8803 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $19110 m0 *1 112.24,318.24
X$19110 40 40 8848 105 7347 8776 105 sky130_fd_sc_hd__nor2_2
* cell instance $19115 m0 *1 121.44,318.24
X$19115 105 8622 105 40 8705 40 sky130_fd_sc_hd__inv_1
* cell instance $19116 m0 *1 122.82,318.24
X$19116 105 8705 8462 8758 105 8804 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $19119 m0 *1 126.04,318.24
X$19119 105 8777 8807 8808 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19120 m0 *1 128.34,318.24
X$19120 40 8808 4721 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $19123 m0 *1 136.16,318.24
X$19123 105 4793 40 8777 105 40 sky130_fd_sc_hd__buf_2
* cell instance $19127 m0 *1 139.84,318.24
X$19127 40 9002 4024 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19130 m0 *1 148.12,318.24
X$19130 40 8855 5176 8818 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19133 m0 *1 156.4,318.24
X$19133 40 8856 4985 8819 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19134 m0 *1 160.54,318.24
X$19134 40 8810 4982 8760 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19141 m0 *1 175.26,318.24
X$19141 40 8820 6831 8821 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19145 m0 *1 185.38,318.24
X$19145 40 7564 8757 8778 8811 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19148 m0 *1 195.5,318.24
X$19148 40 7564 8779 8530 8780 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19149 m0 *1 204.7,318.24
X$19149 40 8780 5186 8779 4498 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19151 m0 *1 209.76,318.24
X$19151 40 7564 8805 8530 8806 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19159 m0 *1 227.7,318.24
X$19159 105 3311 40 8700 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $19161 m0 *1 234.14,318.24
X$19161 40 7564 8782 8802 8781 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19162 m0 *1 243.34,318.24
X$19162 40 8781 3049 8782 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19167 m0 *1 253.92,318.24
X$19167 40 7306 8843 8975 8798 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19169 m0 *1 266.8,318.24
X$19169 40 7306 8784 8534 8783 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19170 m0 *1 276,318.24
X$19170 105 6509 8529 8662 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19172 m0 *1 277.84,318.24
X$19172 40 8783 6554 8784 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19173 m0 *1 281.98,318.24
X$19173 105 8793 40 4761 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $19175 m0 *1 285.2,318.24
X$19175 40 7306 5982 8535 8685 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19176 m0 *1 295.78,318.24
X$19176 40 7060 8535 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $19181 m0 *1 314.64,318.24
X$19181 40 7306 6300 8933 8482 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19185 m0 *1 328.44,318.24
X$19185 40 8832 5967 8824 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19187 m0 *1 333.04,318.24
X$19187 105 8399 9566 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19190 m0 *1 338.56,318.24
X$19190 105 8785 8786 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19191 m0 *1 339.94,318.24
X$19191 40 7306 8607 8399 8608 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19193 r0 *1 2.3,318.24
X$19193 40 8634 8828 8829 8899 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $19196 r0 *1 9.66,318.24
X$19196 105 8754 105 40 7379 40 sky130_fd_sc_hd__buf_4
* cell instance $19198 r0 *1 12.88,318.24
X$19198 40 8012 8831 8634 8670 105 105 40 sky130_fd_sc_hd__and3_1
* cell instance $19201 r0 *1 15.64,318.24
X$19201 40 8830 8670 8643 8674 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $19203 r0 *1 20.24,318.24
X$19203 40 8713 8674 8638 8812 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $19204 r0 *1 26.22,318.24
X$19204 40 8141 8447 8764 8812 8963 105 105 40 sky130_fd_sc_hd__a31oi_2
* cell instance $19205 r0 *1 30.82,318.24
X$19205 105 8813 8812 8764 40 105 8585 40 sky130_fd_sc_hd__a21oi_1
* cell instance $19208 r0 *1 34.04,318.24
X$19208 105 8814 8473 8765 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $19214 r0 *1 43.7,318.24
X$19214 105 8409 8646 8878 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $19215 r0 *1 46.92,318.24
X$19215 40 8834 8768 8767 8377 8837 8815 105 105 40 sky130_fd_sc_hd__a41o_1
* cell instance $19216 r0 *1 50.6,318.24
X$19216 105 8860 8907 8838 8880 40 8681 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $19217 r0 *1 53.36,318.24
X$19217 105 8814 8012 8646 8715 105 8815 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $19218 r0 *1 55.66,318.24
X$19218 105 8721 9008 8684 40 8379 105 40 sky130_fd_sc_hd__o21ai_2
* cell instance $19219 r0 *1 58.88,318.24
X$19219 105 7379 8814 8881 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19220 r0 *1 60.26,318.24
X$19220 105 8347 8684 8840 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19223 r0 *1 63.02,318.24
X$19223 105 8611 8649 8841 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19224 r0 *1 64.4,318.24
X$19224 105 8686 8772 8883 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19231 r0 *1 72.22,318.24
X$19231 105 8771 5259 105 9124 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $19232 r0 *1 75.44,318.24
X$19232 40 8795 8844 8796 8886 8772 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $19234 r0 *1 84.18,318.24
X$19234 105 8846 8774 8816 8616 105 8797 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $19235 r0 *1 86.48,318.24
X$19235 40 8773 8816 8846 8845 8774 105 105 40 sky130_fd_sc_hd__and4_4
* cell instance $19241 r0 *1 98.9,318.24
X$19241 105 8157 8801 8721 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $19245 r0 *1 104.42,318.24
X$19245 105 8157 8776 8636 8349 105 8817 40 40 sky130_fd_sc_hd__nand4b_1
* cell instance $19247 r0 *1 108.1,318.24
X$19247 40 8157 8890 8349 8847 105 105 40 sky130_fd_sc_hd__a21bo_1
* cell instance $19248 r0 *1 111.78,318.24
X$19248 40 8848 8801 8803 8349 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $19250 r0 *1 121.9,318.24
X$19250 105 8851 105 40 8115 40 sky130_fd_sc_hd__inv_1
* cell instance $19252 r0 *1 123.28,318.24
X$19252 105 8777 8850 8852 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19254 r0 *1 126.04,318.24
X$19254 40 8852 4722 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $19255 r0 *1 131.1,318.24
X$19255 105 8945 105 40 4514 40 sky130_fd_sc_hd__buf_4
* cell instance $19256 r0 *1 133.86,318.24
X$19256 105 8946 105 40 4189 40 sky130_fd_sc_hd__buf_4
* cell instance $19257 r0 *1 136.62,318.24
X$19257 40 8854 5050 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19260 r0 *1 143.06,318.24
X$19260 40 7564 8818 8660 8855 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19264 r0 *1 153.64,318.24
X$19264 40 7564 8819 8661 8856 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19268 r0 *1 169.28,318.24
X$19268 40 7564 8821 8661 8820 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19275 r0 *1 182.62,318.24
X$19275 40 8898 6081 8897 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19280 r0 *1 196.42,318.24
X$19280 40 8896 6240 8895 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19282 r0 *1 202.4,318.24
X$19282 105 8530 9577 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19283 r0 *1 203.78,318.24
X$19283 40 8853 4420 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19287 r0 *1 208.84,318.24
X$19287 40 6754 8530 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $19289 r0 *1 218.96,318.24
X$19289 40 8806 6587 8805 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19291 r0 *1 226.78,318.24
X$19291 40 7564 8947 8802 8849 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19294 r0 *1 236.44,318.24
X$19294 40 7060 8802 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $19295 r0 *1 245.64,318.24
X$19295 40 7306 8938 8802 8889 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19296 r0 *1 254.84,318.24
X$19296 40 8822 5733 8823 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19298 r0 *1 258.98,318.24
X$19298 105 4793 40 8879 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $19301 r0 *1 264.04,318.24
X$19301 40 8798 6444 8843 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19304 r0 *1 270.94,318.24
X$19304 40 7060 8534 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $19307 r0 *1 282.44,318.24
X$19307 40 8884 6596 8839 2957 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19309 r0 *1 286.58,318.24
X$19309 105 8842 40 4759 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $19313 r0 *1 292.1,318.24
X$19313 40 8535 9493 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $19314 r0 *1 297.16,318.24
X$19314 40 7306 6513 8535 8679 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19315 r0 *1 307.74,318.24
X$19315 40 7306 6368 8836 8835 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19320 r0 *1 320.16,318.24
X$19320 40 8833 6365 8785 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19323 r0 *1 328.44,318.24
X$19323 40 7306 8824 8399 8832 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19328 r0 *1 340.86,318.24
X$19328 40 8873 6119 8825 7435 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19329 r0 *1 345,318.24
X$19329 105 8825 8875 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19332 r0 *1 347.76,318.24
X$19332 105 8733 8665 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19361 m0 *1 3.68,323.68
X$19361 105 8509 105 40 8857 40 sky130_fd_sc_hd__inv_1
* cell instance $19362 m0 *1 5.06,323.68
X$19362 105 8634 8830 8447 8635 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $19363 m0 *1 6.9,323.68
X$19363 40 8857 8187 8306 8445 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $19365 m0 *1 16.1,323.68
X$19365 40 8642 8812 8764 105 8445 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $19366 m0 *1 22.54,323.68
X$19366 40 8642 8812 8764 105 9059 105 40 sky130_fd_sc_hd__nand3_4
* cell instance $19369 m0 *1 30.36,323.68
X$19369 40 8714 8876 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19370 m0 *1 34.5,323.68
X$19370 40 8814 8982 8858 8930 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $19373 m0 *1 43.24,323.68
X$19373 40 8904 9027 8859 8860 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $19374 m0 *1 51.52,323.68
X$19374 105 8814 8754 8880 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $19375 m0 *1 53.82,323.68
X$19375 105 8860 8907 8881 8838 40 8861 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $19377 m0 *1 57.04,323.68
X$19377 40 8001 8859 8882 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $19378 m0 *1 61.18,323.68
X$19378 40 8768 8861 8969 8646 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $19379 m0 *1 64.86,323.68
X$19379 40 8862 1988 9070 8844 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $19380 m0 *1 74.06,323.68
X$19380 105 8887 8862 8885 8314 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $19383 m0 *1 78.2,323.68
X$19383 105 8774 8773 8886 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19384 m0 *1 79.58,323.68
X$19384 105 8846 8799 8796 8936 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $19385 m0 *1 81.42,323.68
X$19385 105 8846 8796 8799 105 8888 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $19387 m0 *1 84.64,323.68
X$19387 40 8846 8937 1988 105 8617 105 40 sky130_fd_sc_hd__ha_1
* cell instance $19388 m0 *1 89.24,323.68
X$19388 105 8816 8846 8799 9103 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $19390 m0 *1 91.54,323.68
X$19390 40 8816 8689 8911 1986 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $19393 m0 *1 105.34,323.68
X$19393 105 8817 8890 8940 8347 40 105 9126 40 sky130_fd_sc_hd__a31oi_1
* cell instance $19394 m0 *1 107.64,323.68
X$19394 105 8593 8776 8941 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19395 m0 *1 109.02,323.68
X$19395 105 8012 8776 8847 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19400 m0 *1 114.08,323.68
X$19400 40 7564 8851 7849 8893 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19401 m0 *1 123.28,323.68
X$19401 105 8851 105 40 8079 40 sky130_fd_sc_hd__buf_4
* cell instance $19403 m0 *1 126.96,323.68
X$19403 105 8777 8863 8864 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19404 m0 *1 129.26,323.68
X$19404 40 8864 4097 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19406 m0 *1 134.32,323.68
X$19406 105 8777 8865 8866 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19407 m0 *1 136.62,323.68
X$19407 105 8866 105 40 3924 40 sky130_fd_sc_hd__buf_4
* cell instance $19410 m0 *1 140.76,323.68
X$19410 40 7564 8949 8660 8867 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19412 m0 *1 151.8,323.68
X$19412 40 7564 8951 8661 8952 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19415 m0 *1 162.84,323.68
X$19415 40 8955 5270 8957 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19418 m0 *1 168.36,323.68
X$19418 40 6754 8661 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $19420 m0 *1 179.4,323.68
X$19420 40 7564 8897 8661 8898 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19425 m0 *1 195.04,323.68
X$19425 40 7564 8895 8778 8896 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19426 m0 *1 204.24,323.68
X$19426 40 7564 8954 8530 8894 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19427 m0 *1 213.44,323.68
X$19427 40 8892 4665 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19428 m0 *1 217.58,323.68
X$19428 40 8953 3930 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19433 m0 *1 225.4,323.68
X$19433 40 8948 5239 8918 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19436 m0 *1 232.3,323.68
X$19436 40 8802 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $19441 m0 *1 250.24,323.68
X$19441 40 8889 6958 8938 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19446 m0 *1 257.6,323.68
X$19446 105 8869 105 40 4838 40 sky130_fd_sc_hd__buf_4
* cell instance $19447 m0 *1 260.36,323.68
X$19447 40 7306 8871 8534 8870 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19448 m0 *1 269.56,323.68
X$19448 40 8870 6443 8871 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19451 m0 *1 277.84,323.68
X$19451 40 7306 8839 8534 8884 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19452 m0 *1 287.04,323.68
X$19452 105 8872 40 4618 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $19453 m0 *1 289.8,323.68
X$19453 40 7306 6600 8535 8151 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19454 m0 *1 300.38,323.68
X$19454 105 8879 8877 8872 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19458 m0 *1 305.44,323.68
X$19458 40 7306 6366 8836 8737 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19459 m0 *1 316.02,323.68
X$19459 40 8934 5595 8977 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19462 m0 *1 322.46,323.68
X$19462 40 8932 5813 8931 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19469 m0 *1 338.56,323.68
X$19469 105 8824 8827 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19470 m0 *1 339.94,323.68
X$19470 40 7306 8733 8399 8788 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19471 r0 *1 1.38,323.68
X$19471 40 8829 8899 8306 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $19478 r0 *1 20.7,323.68
X$19478 40 8900 8509 8901 8674 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $19480 r0 *1 30.82,323.68
X$19480 40 8643 8929 8858 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $19481 r0 *1 36.8,323.68
X$19481 40 8902 8929 8903 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $19482 r0 *1 40.94,323.68
X$19482 105 8929 40 105 8930 40 sky130_fd_sc_hd__inv_2
* cell instance $19487 r0 *1 45.08,323.68
X$19487 105 8377 8878 8813 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19488 r0 *1 46.46,323.68
X$19488 105 8754 8814 8904 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19489 r0 *1 47.84,323.68
X$19489 105 8907 8906 8905 105 8715 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $19490 r0 *1 51.06,323.68
X$19490 40 8904 8984 8859 9028 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $19491 r0 *1 59.34,323.68
X$19491 40 8593 8882 8814 105 105 40 sky130_fd_sc_hd__nand2b_4
* cell instance $19492 r0 *1 64.4,323.68
X$19492 105 8907 8935 8989 105 8900 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $19493 r0 *1 67.62,323.68
X$19493 105 8907 8844 8935 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19498 r0 *1 70.84,323.68
X$19498 105 8794 5259 105 8991 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $19501 r0 *1 75.44,323.68
X$19501 40 40 8617 8908 8717 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $19502 r0 *1 77.74,323.68
X$19502 40 8908 8970 8888 8772 8936 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $19504 r0 *1 86.48,323.68
X$19504 105 8845 8910 8909 9036 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $19505 r0 *1 88.32,323.68
X$19505 105 8816 8937 8888 8909 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $19507 r0 *1 90.62,323.68
X$19507 105 8816 8937 8992 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19508 r0 *1 92,323.68
X$19508 105 8911 8845 8910 9102 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $19509 r0 *1 93.84,323.68
X$19509 40 8912 8845 8910 8911 105 105 40 sky130_fd_sc_hd__or3_4
* cell instance $19512 r0 *1 98.44,323.68
X$19512 40 8776 9104 8690 8912 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $19513 r0 *1 104.42,323.68
X$19513 105 8473 8776 8939 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19514 r0 *1 105.8,323.68
X$19514 40 8940 8939 8349 8941 8157 105 105 40 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $19515 r0 *1 109.02,323.68
X$19515 105 8776 8593 8995 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $19519 r0 *1 118.68,323.68
X$19519 105 8079 8077 8942 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19520 r0 *1 120.06,323.68
X$19520 105 8196 8913 8942 105 8893 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $19521 r0 *1 121.9,323.68
X$19521 40 8997 8115 8971 8913 105 105 40 sky130_fd_sc_hd__mux2i_1
* cell instance $19526 r0 *1 128.34,323.68
X$19526 105 8777 8944 8945 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19527 r0 *1 130.64,323.68
X$19527 105 8777 9171 8946 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19529 r0 *1 134.78,323.68
X$19529 105 8777 8914 8854 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19530 r0 *1 137.08,323.68
X$19530 105 8777 8915 8916 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19531 r0 *1 139.38,323.68
X$19531 105 8916 105 40 3848 40 sky130_fd_sc_hd__buf_4
* cell instance $19532 r0 *1 142.14,323.68
X$19532 40 7564 9000 8660 8950 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19538 r0 *1 155.02,323.68
X$19538 40 8952 4661 8951 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19541 r0 *1 161.92,323.68
X$19541 40 7564 8957 8661 8955 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19543 r0 *1 171.58,323.68
X$19543 40 7564 8994 8661 8996 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19549 r0 *1 187.22,323.68
X$19549 40 8993 6701 8958 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19551 r0 *1 193.2,323.68
X$19551 40 8960 4102 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $19553 r0 *1 198.72,323.68
X$19553 105 8879 8959 8917 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19554 r0 *1 201.02,323.68
X$19554 105 8917 105 40 4904 40 sky130_fd_sc_hd__buf_4
* cell instance $19555 r0 *1 203.78,323.68
X$19555 40 8894 7094 8954 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19561 r0 *1 212.98,323.68
X$19561 105 8879 8956 8892 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19563 r0 *1 215.74,323.68
X$19563 105 8879 9390 8953 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19565 r0 *1 219.88,323.68
X$19565 105 8972 105 40 4751 40 sky130_fd_sc_hd__buf_4
* cell instance $19566 r0 *1 222.64,323.68
X$19566 40 7564 8918 8802 8948 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19568 r0 *1 231.84,323.68
X$19568 40 8849 3394 8947 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19570 r0 *1 236.44,323.68
X$19570 40 7564 8943 8802 8920 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19571 r0 *1 245.64,323.68
X$19571 40 8920 5731 8943 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19575 r0 *1 255.76,323.68
X$19575 40 8988 3140 8922 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19577 r0 *1 259.9,323.68
X$19577 105 8879 8976 8869 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19582 r0 *1 265.88,323.68
X$19582 105 8987 105 40 5172 40 sky130_fd_sc_hd__buf_4
* cell instance $19585 r0 *1 270.94,323.68
X$19585 40 8986 6703 8923 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19588 r0 *1 279.68,323.68
X$19588 105 8879 9092 8793 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19589 r0 *1 281.98,323.68
X$19589 105 8879 8924 8842 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19592 r0 *1 285.66,323.68
X$19592 40 9030 5812 8983 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19598 r0 *1 293.48,323.68
X$19598 40 7306 6546 8535 7791 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19601 r0 *1 305.44,323.68
X$19601 40 7306 6118 8836 8789 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19608 r0 *1 321.54,323.68
X$19608 40 7306 8931 8933 8932 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19610 r0 *1 332.58,323.68
X$19610 40 8926 5594 8925 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19611 r0 *1 336.72,323.68
X$19611 40 7306 8925 8399 8926 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19615 r0 *1 346.84,323.68
X$19615 105 8931 8874 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19644 m0 *1 3.22,329.12
X$19644 40 8829 8828 8857 1760 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $19645 m0 *1 8.74,329.12
X$19645 40 8899 9003 9004 105 105 40 sky130_fd_sc_hd__nand2b_2
* cell instance $19646 m0 *1 11.96,329.12
X$19646 105 9023 8962 8980 105 40 9004 40 sky130_fd_sc_hd__o21ai_1
* cell instance $19647 m0 *1 13.8,329.12
X$19647 105 9023 9005 8961 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19650 m0 *1 16.56,329.12
X$19650 105 9024 8962 105 8963 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $19651 m0 *1 19.78,329.12
X$19651 40 8962 9003 1986 105 8609 105 40 sky130_fd_sc_hd__ha_1
* cell instance $19654 m0 *1 25.76,329.12
X$19654 105 8903 8964 8901 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19655 m0 *1 27.14,329.12
X$19655 105 8966 8967 8965 8964 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $19657 m0 *1 29.44,329.12
X$19657 105 8966 8965 8967 105 8903 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $19658 m0 *1 32.2,329.12
X$19658 40 8858 8982 8670 1760 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $19662 m0 *1 42.78,329.12
X$19662 40 9027 8409 8984 8985 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $19665 m0 *1 55.2,329.12
X$19665 105 8968 40 105 9028 40 sky130_fd_sc_hd__inv_2
* cell instance $19667 m0 *1 57.04,329.12
X$19667 105 8905 8907 8906 8882 40 8969 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $19668 m0 *1 59.8,329.12
X$19668 40 8670 8970 9033 8907 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $19670 m0 *1 64.86,329.12
X$19670 105 8990 8862 8989 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $19672 m0 *1 69,329.12
X$19672 40 8887 1986 9035 8970 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $19673 m0 *1 78.2,329.12
X$19673 40 9012 8772 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $19678 m0 *1 86.02,329.12
X$19678 40 9036 8968 8689 8717 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $19680 m0 *1 96.14,329.12
X$19680 40 8697 8157 8657 8801 105 9184 105 40 sky130_fd_sc_hd__nand4_4
* cell instance $19681 m0 *1 103.96,329.12
X$19681 40 8697 8801 8157 9106 8995 105 105 40 sky130_fd_sc_hd__a31oi_4
* cell instance $19683 m0 *1 112.24,329.12
X$19683 40 7564 8971 9076 8998 105 105 40 sky130_fd_sc_hd__dfstp_1
* cell instance $19684 m0 *1 121.9,329.12
X$19684 105 9040 9013 8997 8196 8079 8998 105 40 40 sky130_fd_sc_hd__o221ai_1
* cell instance $19685 m0 *1 125.12,329.12
X$19685 40 3307 3121 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19689 m0 *1 131.56,329.12
X$19689 40 9043 5416 9046 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19692 m0 *1 137.08,329.12
X$19692 105 8777 9048 9002 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19696 m0 *1 142.6,329.12
X$19696 105 9001 8777 40 105 8972 40 sky130_fd_sc_hd__nor2b_2
* cell instance $19697 m0 *1 145.82,329.12
X$19697 40 6754 8660 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $19699 m0 *1 158.7,329.12
X$19699 40 9053 7031 9014 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19704 m0 *1 171.12,329.12
X$19704 40 9052 6909 9051 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19705 m0 *1 175.26,329.12
X$19705 40 8996 6729 8994 8700 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19709 m0 *1 185.38,329.12
X$19709 40 7564 8958 9049 8993 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19711 m0 *1 195.04,329.12
X$19711 40 9047 7120 9045 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19712 m0 *1 199.18,329.12
X$19712 105 8879 9044 8960 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19715 m0 *1 206.08,329.12
X$19715 105 8879 9190 8853 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19716 m0 *1 208.38,329.12
X$19716 40 9042 3136 9041 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19717 m0 *1 212.52,329.12
X$19717 40 7564 9015 8530 8974 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19722 m0 *1 225.4,329.12
X$19722 40 9039 5653 9038 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19724 m0 *1 230.46,329.12
X$19724 40 7564 9016 8802 9037 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19726 m0 *1 240.58,329.12
X$19726 40 7306 8823 8802 8822 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19728 m0 *1 250.24,329.12
X$19728 105 3311 105 40 8868 40 sky130_fd_sc_hd__buf_4
* cell instance $19730 m0 *1 254.84,329.12
X$19730 40 7306 8922 8975 8988 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19731 m0 *1 264.04,329.12
X$19731 105 8879 9034 8987 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $19733 m0 *1 268.18,329.12
X$19733 40 7306 8923 8534 8986 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19736 m0 *1 278.3,329.12
X$19736 40 9032 6447 9031 7935 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19738 m0 *1 284.28,329.12
X$19738 40 7306 8983 8535 9030 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19739 m0 *1 293.48,329.12
X$19739 40 7306 8981 8535 9029 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19745 m0 *1 310.96,329.12
X$19745 105 3311 105 40 7935 40 sky130_fd_sc_hd__buf_4
* cell instance $19746 m0 *1 313.72,329.12
X$19746 40 7306 8977 8933 8934 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19750 m0 *1 328.44,329.12
X$19750 40 9019 6697 8978 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19752 m0 *1 333.04,329.12
X$19752 40 7306 8978 8933 9019 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19753 m0 *1 342.24,329.12
X$19753 40 9025 6300 9020 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19754 m0 *1 346.38,329.12
X$19754 105 8925 8826 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19755 m0 *1 347.76,329.12
X$19755 105 8977 8927 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19760 r0 *1 11.04,329.12
X$19760 40 8238 9058 8961 8445 105 105 40 sky130_fd_sc_hd__mux2_2
* cell instance $19764 r0 *1 16.1,329.12
X$19764 105 8980 9023 9024 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19766 r0 *1 17.94,329.12
X$19766 40 9054 8980 1988 105 9058 105 40 sky130_fd_sc_hd__ha_1
* cell instance $19768 r0 *1 23,329.12
X$19768 40 8966 8902 1986 105 8900 105 40 sky130_fd_sc_hd__ha_1
* cell instance $19770 r0 *1 28.52,329.12
X$19770 40 8609 9087 9006 8876 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19771 r0 *1 32.66,329.12
X$19771 40 9063 8640 9176 9058 9026 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $19773 r0 *1 38.18,329.12
X$19773 40 9060 8967 1988 105 9006 105 40 sky130_fd_sc_hd__ha_1
* cell instance $19776 r0 *1 43.24,329.12
X$19776 105 4898 9178 9089 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19779 r0 *1 47.38,329.12
X$19779 105 8860 9007 8473 8838 40 9091 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $19781 r0 *1 50.6,329.12
X$19781 105 8905 9007 8754 8906 40 9094 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $19782 r0 *1 53.36,329.12
X$19782 105 8907 8718 9065 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19784 r0 *1 55.66,329.12
X$19784 105 9010 9009 9008 40 105 8377 40 sky130_fd_sc_hd__a21o_1
* cell instance $19785 r0 *1 58.42,329.12
X$19785 40 8454 9008 9009 9010 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $19786 r0 *1 64.4,329.12
X$19786 105 8907 8794 9096 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19787 r0 *1 65.78,329.12
X$19787 105 8862 9011 9098 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19789 r0 *1 67.62,329.12
X$19789 105 9099 9122 8991 105 40 8990 40 sky130_fd_sc_hd__o21bai_1
* cell instance $19793 r0 *1 71.76,329.12
X$19793 105 8862 9011 9071 105 9100 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $19794 r0 *1 74.52,329.12
X$19794 40 8862 8415 8887 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $19795 r0 *1 78.66,329.12
X$19795 105 9125 9011 9101 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19797 r0 *1 80.5,329.12
X$19797 40 9012 8717 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19800 r0 *1 89.24,329.12
X$19800 105 9103 8992 8910 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19803 r0 *1 92,329.12
X$19803 40 9105 9102 8690 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $19809 r0 *1 101.66,329.12
X$19809 40 8697 9072 8157 8801 105 105 40 sky130_fd_sc_hd__and3_4
* cell instance $19811 r0 *1 106.26,329.12
X$19811 40 8349 9106 9010 105 105 40 sky130_fd_sc_hd__xor2_4
* cell instance $19814 r0 *1 120.52,329.12
X$19814 105 8891 105 40 8913 40 sky130_fd_sc_hd__inv_1
* cell instance $19815 r0 *1 121.9,329.12
X$19815 105 8971 8077 9040 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $19817 r0 *1 123.28,329.12
X$19817 105 8971 8196 9075 40 105 9013 40 sky130_fd_sc_hd__a21oi_1
* cell instance $19821 r0 *1 126.5,329.12
X$19821 40 7564 9046 9076 9043 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19822 r0 *1 135.7,329.12
X$19822 40 4205 3307 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19823 r0 *1 139.84,329.12
X$19823 40 9112 7045 9050 9075 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19825 r0 *1 144.44,329.12
X$19825 105 8660 9502 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $19826 r0 *1 146.28,329.12
X$19826 40 8867 4984 8949 3306 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19828 r0 *1 150.42,329.12
X$19828 105 3307 40 8999 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $19830 r0 *1 153.64,329.12
X$19830 40 8950 6785 9000 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19831 r0 *1 157.78,329.12
X$19831 40 7564 9014 8661 9053 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19833 r0 *1 167.9,329.12
X$19833 40 7564 9051 8661 9052 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19837 r0 *1 181.24,329.12
X$19837 40 9111 3281 9110 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19839 r0 *1 189.06,329.12
X$19839 40 7564 9045 8778 9047 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19843 r0 *1 201.48,329.12
X$19843 40 9109 6353 9108 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19848 r0 *1 208.84,329.12
X$19848 40 7564 9041 8530 9042 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19849 r0 *1 218.04,329.12
X$19849 40 8974 6910 9015 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19850 r0 *1 222.18,329.12
X$19850 40 7564 9038 8802 9039 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19853 r0 *1 231.84,329.12
X$19853 40 4205 3311 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $19856 r0 *1 238.28,329.12
X$19856 40 9037 3138 9016 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19858 r0 *1 243.34,329.12
X$19858 40 7306 9017 9216 9081 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19859 r0 *1 252.54,329.12
X$19859 40 9081 5920 9017 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19860 r0 *1 256.68,329.12
X$19860 105 3311 105 40 8800 40 sky130_fd_sc_hd__buf_4
* cell instance $19865 r0 *1 264.04,329.12
X$19865 40 9097 6236 9082 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19869 r0 *1 276.46,329.12
X$19869 40 7306 9031 8975 9032 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19876 r0 *1 294.4,329.12
X$19876 40 9029 6306 8981 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19879 r0 *1 299.92,329.12
X$19879 40 7306 5596 8836 7644 105 105 40 sky130_fd_sc_hd__dfrtp_4
* cell instance $19883 r0 *1 314.64,329.12
X$19883 40 9088 6369 9018 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19887 r0 *1 326.6,329.12
X$19887 40 7306 9133 8933 9086 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19888 r0 *1 335.8,329.12
X$19888 105 9018 9022 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19889 r0 *1 337.18,329.12
X$19889 40 7306 9020 8933 9025 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19892 r0 *1 346.84,329.12
X$19892 105 9020 8928 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $19924 m0 *1 11.5,334.56
X$19924 105 9054 9055 9056 105 9023 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $19925 m0 *1 14.26,334.56
X$19925 105 9054 9056 9055 9005 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $19926 m0 *1 16.1,334.56
X$19926 105 9137 9172 9057 9134 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $19928 m0 *1 18.4,334.56
X$19928 105 9057 9136 9059 105 9138 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $19929 m0 *1 20.24,334.56
X$19929 105 9059 9085 9135 105 8000 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $19930 m0 *1 23.46,334.56
X$19930 105 9059 9113 9085 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19932 m0 *1 25.3,334.56
X$19932 105 8965 9114 9087 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19933 m0 *1 26.68,334.56
X$19933 105 9256 9367 8876 105 9142 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $19936 m0 *1 29.44,334.56
X$19936 105 9060 9063 9061 105 8965 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $19937 m0 *1 32.2,334.56
X$19937 105 9062 9115 9203 105 9063 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $19938 m0 *1 34.96,334.56
X$19938 105 9060 9061 9063 9114 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $19939 m0 *1 36.8,334.56
X$19939 40 9062 9061 2251 105 9090 105 40 sky130_fd_sc_hd__ha_1
* cell instance $19940 m0 *1 41.4,334.56
X$19940 105 9062 8966 9060 9089 105 9146 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $19942 m0 *1 44.62,334.56
X$19942 105 9064 9065 9090 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19943 m0 *1 46,334.56
X$19943 40 9146 9094 9091 8766 8454 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $19944 m0 *1 50.6,334.56
X$19944 105 8985 9122 9147 40 105 9064 40 sky130_fd_sc_hd__a21oi_1
* cell instance $19946 m0 *1 53.36,334.56
X$19946 105 9118 9119 9066 40 105 9007 40 sky130_fd_sc_hd__a21o_1
* cell instance $19949 m0 *1 57.04,334.56
X$19949 40 8838 8968 9066 9118 9119 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $19952 m0 *1 63.02,334.56
X$19952 105 9096 8907 9369 40 105 9006 40 sky130_fd_sc_hd__a21oi_1
* cell instance $19954 m0 *1 65.32,334.56
X$19954 105 8991 9098 9067 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19955 m0 *1 66.7,334.56
X$19955 40 9033 8887 9069 9067 9121 9068 105 105 40 sky130_fd_sc_hd__o32a_1
* cell instance $19956 m0 *1 70.38,334.56
X$19956 105 9070 9100 8887 105 9068 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $19957 m0 *1 72.22,334.56
X$19957 105 8862 9071 9070 40 105 9069 40 sky130_fd_sc_hd__a21o_1
* cell instance $19958 m0 *1 74.98,334.56
X$19958 105 8887 9035 9069 105 9156 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $19960 m0 *1 79.12,334.56
X$19960 105 8415 9124 9125 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $19961 m0 *1 80.5,334.56
X$19961 105 9122 8415 9124 9211 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $19969 m0 *1 96.6,334.56
X$19969 40 8690 9104 9162 1760 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $19971 m0 *1 103.04,334.56
X$19971 40 9072 9012 105 105 40 sky130_fd_sc_hd__buf_8
* cell instance $19979 m0 *1 118.68,334.56
X$19979 105 9166 9074 9073 40 105 9107 40 sky130_fd_sc_hd__a21oi_1
* cell instance $19981 m0 *1 121.44,334.56
X$19981 105 9074 105 40 8196 40 sky130_fd_sc_hd__inv_1
* cell instance $19982 m0 *1 122.82,334.56
X$19982 105 3307 40 9075 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $19983 m0 *1 125.58,334.56
X$19983 40 7564 9077 9076 9078 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19984 m0 *1 134.78,334.56
X$19984 40 9078 6436 9077 9075 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19990 m0 *1 145.82,334.56
X$19990 40 7564 9168 8660 9170 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19993 m0 *1 160.54,334.56
X$19993 40 9167 6963 9165 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $19997 m0 *1 167.44,334.56
X$19997 40 7564 9129 8661 9164 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $19999 m0 *1 177.1,334.56
X$19999 40 7564 9110 9049 9111 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20006 m0 *1 197.8,334.56
X$20006 40 7564 9108 8778 9109 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20010 m0 *1 210.22,334.56
X$20010 40 9161 7093 9159 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20016 m0 *1 223.56,334.56
X$20016 40 9158 7088 9157 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20017 m0 *1 227.7,334.56
X$20017 105 3311 40 8973 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $20020 m0 *1 232.76,334.56
X$20020 105 3311 40 9189 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $20022 m0 *1 235.98,334.56
X$20022 40 7306 9130 9216 9079 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20023 m0 *1 245.18,334.56
X$20023 40 9079 6789 9130 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20026 m0 *1 250.24,334.56
X$20026 40 9155 6113 9154 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20029 m0 *1 258.52,334.56
X$20029 40 7306 9082 8975 9097 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20030 m0 *1 267.72,334.56
X$20030 40 8975 9491 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $20031 m0 *1 272.78,334.56
X$20031 105 9151 9095 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20037 m0 *1 278.76,334.56
X$20037 40 9149 6395 9148 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20040 m0 *1 285.66,334.56
X$20040 40 7306 9131 8836 9093 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20041 m0 *1 294.86,334.56
X$20041 105 4205 40 9080 105 40 sky130_fd_sc_hd__clkbuf_4
* cell instance $20044 m0 *1 299.92,334.56
X$20044 40 8836 9490 105 105 40 sky130_fd_sc_hd__clkbuf_8
* cell instance $20046 m0 *1 305.44,334.56
X$20046 40 7306 9143 8836 9132 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20047 m0 *1 314.64,334.56
X$20047 40 7306 9018 8933 9088 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20048 m0 *1 323.84,334.56
X$20048 40 9141 6044 9140 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20049 m0 *1 327.98,334.56
X$20049 40 9086 6546 9133 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20052 m0 *1 333.04,334.56
X$20052 40 9139 6218 9253 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20055 m0 *1 339.94,334.56
X$20055 40 7306 8825 8399 8873 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20059 r0 *1 12.42,334.56
X$20059 105 9134 9055 9135 40 105 40 sky130_fd_sc_hd__or2_0
* cell instance $20065 r0 *1 17.02,334.56
X$20065 40 9137 9056 2251 105 9113 105 40 sky130_fd_sc_hd__ha_1
* cell instance $20066 r0 *1 21.62,334.56
X$20066 105 9138 9174 9059 105 8242 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $20067 r0 *1 24.38,334.56
X$20067 40 40 9198 105 8640 9200 105 sky130_fd_sc_hd__nor2_2
* cell instance $20070 r0 *1 28.06,334.56
X$20070 105 9115 9175 8876 105 9116 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $20071 r0 *1 29.9,334.56
X$20071 105 9062 9203 9115 9176 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $20072 r0 *1 31.74,334.56
X$20072 105 9116 9202 8876 105 9113 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $20073 r0 *1 34.5,334.56
X$20073 105 9177 9316 9117 105 9144 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $20074 r0 *1 37.26,334.56
X$20074 40 9117 9145 8985 105 105 40 sky130_fd_sc_hd__nor2_4
* cell instance $20075 r0 *1 41.4,334.56
X$20075 105 8640 9090 9026 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $20078 r0 *1 43.24,334.56
X$20078 40 9127 9177 9117 9260 105 105 40 sky130_fd_sc_hd__nand3_2
* cell instance $20079 r0 *1 46.92,334.56
X$20079 105 9179 9296 9206 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $20080 r0 *1 48.3,334.56
X$20080 40 9007 8907 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $20081 r0 *1 52.44,334.56
X$20081 40 8906 9028 9066 9118 9119 105 105 40 sky130_fd_sc_hd__a211oi_2
* cell instance $20082 r0 *1 57.04,334.56
X$20082 105 9118 9119 9120 8001 105 9009 40 40 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $20083 r0 *1 60.26,334.56
X$20083 40 9180 9010 9120 8001 105 105 40 sky130_fd_sc_hd__o21bai_2
* cell instance $20084 r0 *1 64.4,334.56
X$20084 105 9118 9181 9180 40 105 8649 40 sky130_fd_sc_hd__a21o_1
* cell instance $20086 r0 *1 67.62,334.56
X$20086 105 9071 9070 8991 9121 40 105 40 sky130_fd_sc_hd__nor3b_1
* cell instance $20089 r0 *1 70.84,334.56
X$20089 105 8862 9099 9070 40 105 9210 40 sky130_fd_sc_hd__a21o_1
* cell instance $20091 r0 *1 74.06,334.56
X$20091 105 8887 9035 9210 105 9123 40 40 sky130_fd_sc_hd__a21oi_2
* cell instance $20093 r0 *1 78.2,334.56
X$20093 40 9012 9122 9123 9339 9211 9184 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $20095 r0 *1 88.32,334.56
X$20095 105 9125 105 40 9214 40 sky130_fd_sc_hd__inv_1
* cell instance $20097 r0 *1 90.16,334.56
X$20097 105 9160 9236 9213 9183 40 9372 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $20098 r0 *1 92.92,334.56
X$20098 40 9160 9126 9215 9127 9214 9012 105 105 40 sky130_fd_sc_hd__o41a_1
* cell instance $20103 r0 *1 98.9,334.56
X$20103 105 9320 8618 9162 105 40 40 sky130_fd_sc_hd__and2_1
* cell instance $20105 r0 *1 101.66,334.56
X$20105 40 9105 9120 9162 9012 105 105 40 sky130_fd_sc_hd__mux2i_4
* cell instance $20107 r0 *1 110.86,334.56
X$20107 40 7564 9074 9076 9222 105 105 40 sky130_fd_sc_hd__dfstp_1
* cell instance $20108 r0 *1 120.52,334.56
X$20108 105 9074 8913 9075 40 105 9222 40 sky130_fd_sc_hd__a21o_1
* cell instance $20111 r0 *1 123.74,334.56
X$20111 105 9185 9186 9074 105 9169 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $20113 r0 *1 126.04,334.56
X$20113 105 8913 3307 9185 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $20114 r0 *1 127.42,334.56
X$20114 105 8891 9238 9186 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $20115 r0 *1 128.8,334.56
X$20115 105 9226 8944 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20116 r0 *1 130.18,334.56
X$20116 105 9187 9171 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20118 r0 *1 132.48,334.56
X$20118 40 9227 6434 9128 9075 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20119 r0 *1 136.62,334.56
X$20119 40 7564 9050 9076 9112 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20120 r0 *1 145.82,334.56
X$20120 105 8726 9230 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20122 r0 *1 149.04,334.56
X$20122 40 9170 6961 9168 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20128 r0 *1 158.7,334.56
X$20128 40 7564 9165 9049 9167 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20132 r0 *1 171.12,334.56
X$20132 40 9164 5951 9129 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20139 r0 *1 185.84,334.56
X$20139 40 9228 6586 9163 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20142 r0 *1 192.28,334.56
X$20142 40 9243 5465 9245 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20143 r0 *1 196.42,334.56
X$20143 105 9224 8959 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20144 r0 *1 197.8,334.56
X$20144 40 6754 8778 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $20149 r0 *1 208.84,334.56
X$20149 40 7564 9159 8778 9161 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20151 r0 *1 218.96,334.56
X$20151 40 7564 9157 8530 9158 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20156 r0 *1 233.22,334.56
X$20156 105 9220 9219 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20161 r0 *1 238.28,334.56
X$20161 40 9218 3361 9192 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20167 r0 *1 247.48,334.56
X$20167 40 7306 9154 9216 9155 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20169 r0 *1 257.6,334.56
X$20169 40 9212 5961 9153 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20173 r0 *1 264.04,334.56
X$20173 40 7306 9150 8975 9152 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20174 r0 *1 273.24,334.56
X$20174 40 7306 9148 8975 9149 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20175 r0 *1 282.44,334.56
X$20175 40 9209 4308 9195 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20178 r0 *1 287.04,334.56
X$20178 40 9093 5982 9131 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20182 r0 *1 295.78,334.56
X$20182 40 7306 9251 8836 9207 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20183 r0 *1 304.98,334.56
X$20183 40 7060 8836 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $20185 r0 *1 314.18,334.56
X$20185 40 9132 5596 9143 8868 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20188 r0 *1 319.24,334.56
X$20188 40 9205 7134 9204 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20191 r0 *1 326.14,334.56
X$20191 40 7060 8933 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $20192 r0 *1 335.34,334.56
X$20192 40 7306 9199 8933 9201 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20194 r0 *1 344.54,334.56
X$20194 105 9133 9021 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20197 r0 *1 346.84,334.56
X$20197 105 8978 8979 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20228 m0 *1 12.42,340
X$20228 105 9137 9057 9172 105 9055 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $20229 m0 *1 15.18,340
X$20229 105 9173 9231 9312 105 9057 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $20230 m0 *1 17.94,340
X$20230 40 9173 9172 2532 105 9174 105 40 sky130_fd_sc_hd__ha_1
* cell instance $20231 m0 *1 22.54,340
X$20231 40 9059 9198 9232 8031 105 105 40 sky130_fd_sc_hd__mux2_4
* cell instance $20234 m0 *1 29.44,340
X$20234 105 9142 8876 9145 105 9174 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $20235 m0 *1 32.2,340
X$20235 40 9258 9203 9202 105 2532 105 40 sky130_fd_sc_hd__ha_1
* cell instance $20237 m0 *1 37.26,340
X$20237 40 9368 9202 9144 9259 8985 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $20238 m0 *1 45.08,340
X$20238 40 9177 9261 2803 105 8883 105 40 sky130_fd_sc_hd__ha_1
* cell instance $20240 m0 *1 50.14,340
X$20240 40 8905 9339 9179 105 105 40 sky130_fd_sc_hd__xnor2_2
* cell instance $20245 m0 *1 58.42,340
X$20245 40 9119 9118 9008 9182 9180 105 105 40 sky130_fd_sc_hd__a211oi_4
* cell instance $20246 m0 *1 65.78,340
X$20246 40 9263 8794 9071 2251 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $20247 m0 *1 74.98,340
X$20247 40 9371 9415 9234 8001 9182 105 105 40 sky130_fd_sc_hd__a22oi_2
* cell instance $20248 m0 *1 79.58,340
X$20248 40 9183 9156 9101 9237 9235 9184 105 105 40 sky130_fd_sc_hd__o221a_1
* cell instance $20252 m0 *1 86.48,340
X$20252 40 8001 9120 9160 9236 105 9066 105 40 sky130_fd_sc_hd__o211ai_4
* cell instance $20255 m0 *1 97.06,340
X$20255 40 9269 9118 9270 105 105 40 sky130_fd_sc_hd__nand2_4
* cell instance $20256 m0 *1 101.2,340
X$20256 105 9271 9272 9237 40 105 9270 40 sky130_fd_sc_hd__a21o_1
* cell instance $20257 m0 *1 103.96,340
X$20257 105 9072 105 40 9237 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $20263 m0 *1 113.16,340
X$20263 105 8971 9223 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20264 m0 *1 114.54,340
X$20264 40 9274 5127 9275 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20266 m0 *1 119.14,340
X$20266 105 9075 9238 9169 105 9377 40 40 sky130_fd_sc_hd__o21ai_0
* cell instance $20267 m0 *1 120.98,340
X$20267 40 6754 9076 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $20268 m0 *1 130.18,340
X$20268 40 7564 9128 9076 9227 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20270 m0 *1 139.84,340
X$20270 105 9128 9229 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20271 m0 *1 141.22,340
X$20271 40 9280 5423 9281 9075 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20272 m0 *1 145.36,340
X$20272 105 9240 9001 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20274 m0 *1 147.66,340
X$20274 40 7564 9241 8660 9188 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20275 m0 *1 156.86,340
X$20275 40 9188 5955 9241 8999 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20277 m0 *1 162.84,340
X$20277 40 9335 6727 9242 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20283 m0 *1 174.34,340
X$20283 40 9286 6585 9402 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20286 m0 *1 179.86,340
X$20286 40 7564 9163 9049 9228 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20287 m0 *1 189.06,340
X$20287 40 9303 6632 9244 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20292 m0 *1 195.96,340
X$20292 105 9244 9291 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20294 m0 *1 197.8,340
X$20294 105 8778 9494 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $20295 m0 *1 199.64,340
X$20295 105 9245 9225 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20297 m0 *1 201.94,340
X$20297 40 9332 7095 9293 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20298 m0 *1 206.08,340
X$20298 105 9293 9404 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20301 m0 *1 208.84,340
X$20301 105 8779 9295 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20305 m0 *1 213.44,340
X$20305 40 9294 6560 9292 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20307 m0 *1 218.04,340
X$20307 40 9246 7027 9288 8973 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20310 m0 *1 223.1,340
X$20310 105 8728 9290 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20312 m0 *1 224.94,340
X$20312 105 9157 9221 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20314 m0 *1 226.78,340
X$20314 40 9289 3358 9220 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20315 m0 *1 230.92,340
X$20315 40 7306 9192 9216 9218 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20316 m0 *1 240.12,340
X$20316 105 9016 9285 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20317 m0 *1 241.5,340
X$20317 105 9323 9191 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20318 m0 *1 242.88,340
X$20318 105 9192 9284 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20320 m0 *1 244.72,340
X$20320 105 9130 9283 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20321 m0 *1 246.1,340
X$20321 105 8943 9217 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20323 m0 *1 248.4,340
X$20323 105 9247 8730 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20325 m0 *1 250.24,340
X$20325 105 8823 9282 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20326 m0 *1 251.62,340
X$20326 40 9393 5732 9279 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20327 m0 *1 255.76,340
X$20327 40 7306 9153 8975 9212 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20330 m0 *1 266.34,340
X$20330 40 7060 8975 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $20331 m0 *1 275.54,340
X$20331 105 9249 9276 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20334 m0 *1 277.84,340
X$20334 40 7306 9195 8975 9209 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20336 m0 *1 287.5,340
X$20336 40 9273 6669 9267 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20337 m0 *1 291.64,340
X$20337 40 7306 9265 8836 9208 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20338 m0 *1 300.84,340
X$20338 40 9207 6513 9251 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20342 m0 *1 307.74,340
X$20342 40 7306 9204 8836 9205 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20343 m0 *1 316.94,340
X$20343 105 4205 105 40 9193 40 sky130_fd_sc_hd__buf_4
* cell instance $20344 m0 *1 319.7,340
X$20344 40 7306 9140 8933 9141 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20345 m0 *1 328.9,340
X$20345 105 4205 105 40 8921 40 sky130_fd_sc_hd__buf_4
* cell instance $20348 m0 *1 333.04,340
X$20348 40 9201 7189 9199 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20349 m0 *1 337.18,340
X$20349 40 7306 9254 8933 9257 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20350 m0 *1 346.38,340
X$20350 105 9199 9083 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20351 m0 *1 347.76,340
X$20351 105 9254 9084 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20361 r0 *1 15.64,340
X$20361 105 9231 9366 9232 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $20362 r0 *1 17.02,340
X$20362 105 9173 9312 9231 9136 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $20363 r0 *1 18.86,340
X$20363 40 9337 9312 2803 105 9198 105 40 sky130_fd_sc_hd__ha_1
* cell instance $20365 r0 *1 23.92,340
X$20365 105 9233 9314 9200 105 9256 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $20367 r0 *1 27.14,340
X$20367 40 9233 9145 9315 2803 105 105 40 sky130_fd_sc_hd__ha_4
* cell instance $20370 r0 *1 40.94,340
X$20370 105 9177 9117 9316 9259 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $20375 r0 *1 43.24,340
X$20375 105 4898 9206 9260 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $20376 r0 *1 44.62,340
X$20376 40 9144 9296 9261 9122 105 105 40 sky130_fd_sc_hd__o21ai_4
* cell instance $20377 r0 *1 50.6,340
X$20377 40 9296 9297 2532 105 8718 105 40 sky130_fd_sc_hd__ha_1
* cell instance $20378 r0 *1 55.2,340
X$20378 40 8985 9066 9119 9118 105 105 40 sky130_fd_sc_hd__a21oi_4
* cell instance $20380 r0 *1 61.64,340
X$20380 40 9182 8611 9119 9118 105 105 40 sky130_fd_sc_hd__a21boi_2
* cell instance $20382 r0 *1 67.62,340
X$20382 105 9263 9297 9071 40 105 9099 40 sky130_fd_sc_hd__a21o_1
* cell instance $20387 r0 *1 70.84,340
X$20387 105 9298 40 8646 105 40 sky130_fd_sc_hd__buf_2
* cell instance $20390 r0 *1 74.06,340
X$20390 40 9299 8452 9120 9234 9341 105 105 40 sky130_fd_sc_hd__o31ai_4
* cell instance $20391 r0 *1 81.88,340
X$20391 40 9237 9235 9156 9318 9101 9184 105 105 40 sky130_fd_sc_hd__o221ai_4
* cell instance $20392 r0 *1 91.54,340
X$20392 105 9236 9160 105 9182 40 40 sky130_fd_sc_hd__and2_2
* cell instance $20394 r0 *1 94.76,340
X$20394 105 9301 9300 8473 8618 40 9373 105 40 sky130_fd_sc_hd__nor4b_1
* cell instance $20399 r0 *1 98.44,340
X$20399 40 9236 8750 9184 9127 105 105 40 sky130_fd_sc_hd__or3_4
* cell instance $20401 r0 *1 103.04,340
X$20401 105 9300 8593 9105 9272 40 105 40 sky130_fd_sc_hd__nand3b_1
* cell instance $20402 r0 *1 105.8,340
X$20402 105 9301 105 40 9320 40 sky130_fd_sc_hd__inv_1
* cell instance $20403 r0 *1 107.18,340
X$20403 40 7564 9275 9076 9274 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20404 r0 *1 116.38,340
X$20404 40 7564 9239 9076 9107 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20409 r0 *1 126.04,340
X$20409 105 9185 8891 9239 105 40 9073 40 sky130_fd_sc_hd__o21bai_1
* cell instance $20410 r0 *1 128.8,340
X$20410 105 9239 9325 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20412 r0 *1 131.1,340
X$20412 105 9324 9048 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20413 r0 *1 132.48,340
X$20413 40 7564 9281 9076 9280 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20414 r0 *1 141.68,340
X$20414 105 9327 9328 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20415 r0 *1 143.06,340
X$20415 40 7564 9331 8660 9329 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20422 r0 *1 157.32,340
X$20422 105 9333 9334 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20425 r0 *1 160.08,340
X$20425 40 7564 9242 9049 9335 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20427 r0 *1 169.74,340
X$20427 105 9049 9504 105 40 40 sky130_fd_sc_hd__clkinv_2
* cell instance $20428 r0 *1 171.58,340
X$20428 40 7306 9287 9049 9336 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20433 r0 *1 181.24,340
X$20433 40 9336 6962 9287 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20434 r0 *1 185.38,340
X$20434 105 8994 9302 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20436 r0 *1 187.68,340
X$20436 105 9163 9481 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20437 r0 *1 189.06,340
X$20437 40 7564 9245 8778 9243 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20439 r0 *1 199.18,340
X$20439 40 7306 9293 8778 9332 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20444 r0 *1 208.84,340
X$20444 105 8895 9330 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20445 r0 *1 210.22,340
X$20445 40 7306 9292 8778 9294 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20446 r0 *1 219.42,340
X$20446 105 9015 9439 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20447 r0 *1 220.8,340
X$20447 40 7306 9288 9216 9246 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20449 r0 *1 230.92,340
X$20449 40 9326 5344 9323 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20456 r0 *1 236.9,340
X$20456 40 9216 105 105 40 sky130_fd_sc_hd__bufinv_16
* cell instance $20457 r0 *1 247.94,340
X$20457 40 7306 9278 9216 9322 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20458 r0 *1 257.14,340
X$20458 105 9038 9321 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20463 r0 *1 259.44,340
X$20463 40 9319 6556 9277 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20467 r0 *1 266.8,340
X$20467 105 9017 9305 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20470 r0 *1 269.56,340
X$20470 40 7306 9249 8975 9387 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20471 r0 *1 278.76,340
X$20471 40 7306 9250 8975 9307 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20475 r0 *1 287.96,340
X$20475 105 8871 9309 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20476 r0 *1 289.34,340
X$20476 105 9150 9194 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20479 r0 *1 291.64,340
X$20479 105 9031 9308 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20480 r0 *1 293.02,340
X$20480 105 9195 9317 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20481 r0 *1 294.4,340
X$20481 105 8839 9268 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20482 r0 *1 295.78,340
X$20482 105 9266 8924 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20486 r0 *1 300.84,340
X$20486 40 7306 9264 8836 9311 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20487 r0 *1 310.04,340
X$20487 40 9311 6366 9264 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20492 r0 *1 314.64,340
X$20492 40 9252 6368 9262 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20494 r0 *1 319.24,340
X$20494 40 7306 9262 8933 9252 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20496 r0 *1 328.9,340
X$20496 40 9313 5980 9365 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20497 r0 *1 333.04,340
X$20497 40 7306 9253 8933 9139 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20501 r0 *1 342.24,340
X$20501 40 9257 6600 9254 8800 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20504 r0 *1 347.76,340
X$20504 105 9253 9196 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20509 m0 *1 13.34,345.44
X$20509 105 9337 9338 8513 105 9231 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $20510 m0 *1 16.1,345.44
X$20510 105 9337 8513 9338 9366 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $20511 m0 *1 27.14,345.44
X$20511 105 9200 9233 9314 9367 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $20513 m0 *1 29.44,345.44
X$20513 105 9258 9256 9315 105 9115 40 40 sky130_fd_sc_hd__o21a_1
* cell instance $20514 m0 *1 32.2,345.44
X$20514 105 9258 9200 8858 9233 105 9178 40 40 sky130_fd_sc_hd__nand4_1
* cell instance $20518 m0 *1 44.62,345.44
X$20518 40 40 8883 9368 8985 105 105 sky130_fd_sc_hd__nand2_2
* cell instance $20519 m0 *1 46.92,345.44
X$20519 105 9296 9261 9144 9147 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $20522 m0 *1 50.6,345.44
X$20522 40 9179 9339 8860 105 105 40 sky130_fd_sc_hd__xor2_2
* cell instance $20524 m0 *1 57.04,345.44
X$20524 40 9451 9340 9028 1760 105 105 40 sky130_fd_sc_hd__ha_2
* cell instance $20527 m0 *1 63.94,345.44
X$20527 105 9011 9263 9369 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $20530 m0 *1 68.54,345.44
X$20530 105 9183 9340 9181 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $20532 m0 *1 71.3,345.44
X$20532 105 9179 8754 9318 9371 105 40 40 sky130_fd_sc_hd__nand3_1
* cell instance $20533 m0 *1 73.14,345.44
X$20533 105 9122 9297 9011 40 105 40 sky130_fd_sc_hd__nand2b_1
* cell instance $20536 m0 *1 76.82,345.44
X$20536 40 9298 9120 9234 9341 9299 105 105 40 sky130_fd_sc_hd__o31a_1
* cell instance $20538 m0 *1 80.5,345.44
X$20538 105 9297 9122 9235 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $20542 m0 *1 84.64,345.44
X$20542 105 9342 9183 9339 8473 40 105 9345 40 sky130_fd_sc_hd__and4_1
* cell instance $20543 m0 *1 87.86,345.44
X$20543 40 9344 9318 9236 9343 9342 9160 105 105 40 sky130_fd_sc_hd__a221oi_1
* cell instance $20544 m0 *1 91.08,345.44
X$20544 40 9372 9345 9344 9299 9120 105 105 40 sky130_fd_sc_hd__o31ai_2
* cell instance $20546 m0 *1 97.52,345.44
X$20546 105 9346 9237 9373 105 40 9269 40 sky130_fd_sc_hd__o21ai_1
* cell instance $20548 m0 *1 100.28,345.44
X$20548 105 8618 9320 9300 8593 40 9346 105 40 sky130_fd_sc_hd__a211oi_1
* cell instance $20549 m0 *1 103.04,345.44
X$20549 105 8593 105 40 8754 40 sky130_fd_sc_hd__buf_4
* cell instance $20550 m0 *1 105.8,345.44
X$20550 105 8593 9300 9105 9271 105 40 40 sky130_fd_sc_hd__or3_1
* cell instance $20553 m0 *1 110.4,345.44
X$20553 105 9347 9348 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20556 m0 *1 112.7,345.44
X$20556 40 9375 5236 9347 3121 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20557 m0 *1 116.84,345.44
X$20557 40 7564 9349 9076 9377 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20558 m0 *1 126.04,345.44
X$20558 105 9349 105 40 9238 40 sky130_fd_sc_hd__inv_1
* cell instance $20559 m0 *1 127.42,345.44
X$20559 40 7564 9327 9076 9379 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20560 m0 *1 136.62,345.44
X$20560 105 9381 8914 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20561 m0 *1 138,345.44
X$20561 105 9380 8915 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20563 m0 *1 139.84,345.44
X$20563 40 9329 3561 9331 9075 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20565 m0 *1 144.44,345.44
X$20565 105 8527 9350 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20566 m0 *1 145.82,345.44
X$20566 105 9168 9382 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20567 m0 *1 147.2,345.44
X$20567 40 7564 9333 8660 9351 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20568 m0 *1 156.4,345.44
X$20568 105 8629 9383 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20569 m0 *1 157.78,345.44
X$20569 40 7564 9352 9049 9426 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20571 m0 *1 167.44,345.44
X$20571 105 9242 9384 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20572 m0 *1 168.82,345.44
X$20572 105 9352 9465 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20575 m0 *1 174.34,345.44
X$20575 40 6754 9049 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $20576 m0 *1 183.54,345.44
X$20576 40 7306 9244 9049 9303 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20577 m0 *1 192.74,345.44
X$20577 105 9110 9386 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20580 m0 *1 195.04,345.44
X$20580 40 7306 9354 8778 9353 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20581 m0 *1 204.24,345.44
X$20581 105 8757 9388 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20582 m0 *1 205.62,345.44
X$20582 40 7306 9389 8778 9355 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20583 m0 *1 214.82,345.44
X$20583 105 9159 9304 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20584 m0 *1 216.2,345.44
X$20584 105 8954 9392 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20585 m0 *1 217.58,345.44
X$20585 105 9356 9390 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20586 m0 *1 218.96,345.44
X$20586 105 8630 9391 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20587 m0 *1 220.34,345.44
X$20587 105 9041 9357 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20590 m0 *1 222.64,345.44
X$20590 105 9292 9394 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20591 m0 *1 224.02,345.44
X$20591 40 7306 9220 9216 9289 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20592 m0 *1 233.22,345.44
X$20592 105 8805 9397 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20593 m0 *1 234.6,345.44
X$20593 105 8918 9398 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20595 m0 *1 236.9,345.44
X$20595 40 7060 9216 105 105 40 sky130_fd_sc_hd__clkbuf_16
* cell instance $20596 m0 *1 246.1,345.44
X$20596 105 9395 105 40 8919 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $20597 m0 *1 247.94,345.44
X$20597 105 8751 9396 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20600 m0 *1 250.24,345.44
X$20600 40 7306 9279 9216 9393 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20603 m0 *1 264.04,345.44
X$20603 105 8938 9248 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20604 m0 *1 265.42,345.44
X$20604 105 9154 9359 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20607 m0 *1 268.64,345.44
X$20607 40 9152 3159 9150 8921 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20608 m0 *1 272.78,345.44
X$20608 40 9387 6037 9249 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20611 m0 *1 277.84,345.44
X$20611 105 9360 9420 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20613 m0 *1 279.68,345.44
X$20613 40 7306 9362 8975 9361 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20614 m0 *1 288.88,345.44
X$20614 40 7306 9267 8836 9273 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20615 m0 *1 298.08,345.44
X$20615 40 9208 4143 9265 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20616 m0 *1 302.22,345.44
X$20616 105 9267 9310 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20617 m0 *1 303.6,345.44
X$20617 105 9251 9376 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20619 m0 *1 305.44,345.44
X$20619 40 7306 9363 8836 9374 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20620 m0 *1 314.64,345.44
X$20620 40 7306 9364 8933 9370 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20626 m0 *1 333.04,345.44
X$20626 40 7306 9365 8933 9313 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20627 m0 *1 342.24,345.44
X$20627 105 9140 9197 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20628 m0 *1 343.62,345.44
X$20628 105 9365 9255 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20650 r0 *1 31.28,345.44
X$20650 105 9258 9315 9256 9175 40 105 40 sky130_fd_sc_hd__nor3_1
* cell instance $20663 r0 *1 57.04,345.44
X$20663 40 9451 9179 105 105 40 sky130_fd_sc_hd__buf_6
* cell instance $20664 r0 *1 61.18,345.44
X$20664 105 9339 9340 40 105 9119 40 sky130_fd_sc_hd__or2_4
* cell instance $20672 r0 *1 73.14,345.44
X$20672 105 8754 9340 9179 9318 105 9415 40 40 sky130_fd_sc_hd__a211o_1
* cell instance $20675 r0 *1 77.74,345.44
X$20675 105 9318 9339 9179 9340 40 105 9427 40 sky130_fd_sc_hd__a31oi_1
* cell instance $20676 r0 *1 80.04,345.44
X$20676 105 8473 9427 9341 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $20681 r0 *1 85.1,345.44
X$20681 105 9340 9179 9342 40 105 40 sky130_fd_sc_hd__nor2b_1
* cell instance $20682 r0 *1 87.4,345.44
X$20682 105 8754 9340 105 9343 40 40 sky130_fd_sc_hd__xor2_1
* cell instance $20683 r0 *1 90.62,345.44
X$20683 105 9179 9340 9300 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $20684 r0 *1 92,345.44
X$20684 105 9179 8754 9213 105 40 40 sky130_fd_sc_hd__nand2_1
* cell instance $20687 r0 *1 94.76,345.44
X$20687 105 9105 8473 9215 105 40 40 sky130_fd_sc_hd__xnor2_1
* cell instance $20692 r0 *1 99.82,345.44
X$20692 40 7564 9347 9076 9375 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20693 r0 *1 109.02,345.44
X$20693 105 9275 9453 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20694 r0 *1 110.4,345.44
X$20694 105 9399 8807 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20697 r0 *1 113.16,345.44
X$20697 105 9452 8850 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20698 r0 *1 114.54,345.44
X$20698 105 9428 8863 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20699 r0 *1 115.92,345.44
X$20699 105 9349 9480 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20700 r0 *1 117.3,345.44
X$20700 105 9046 9479 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20701 r0 *1 118.68,345.44
X$20701 105 9075 9239 9166 40 105 40 sky130_fd_sc_hd__nor2_1
* cell instance $20702 r0 *1 120.06,345.44
X$20702 105 9076 9575 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20703 r0 *1 121.44,345.44
X$20703 105 9077 9455 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20704 r0 *1 122.82,345.44
X$20704 105 9429 8865 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20706 r0 *1 124.2,345.44
X$20706 105 9281 9430 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20708 r0 *1 126.04,345.44
X$20708 40 8891 9456 105 105 40 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $20709 r0 *1 130.64,345.44
X$20709 105 9423 105 40 8222 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $20710 r0 *1 132.48,345.44
X$20710 40 9379 6784 9327 9075 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20711 r0 *1 136.62,345.44
X$20711 105 9331 9422 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20712 r0 *1 138,345.44
X$20712 105 9050 9400 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20714 r0 *1 139.84,345.44
X$20714 105 9431 105 9423 40 40 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $20715 r0 *1 143.52,345.44
X$20715 105 8949 9433 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20716 r0 *1 144.9,345.44
X$20716 105 8818 9401 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20717 r0 *1 146.28,345.44
X$20717 105 8951 9432 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20718 r0 *1 147.66,345.44
X$20718 105 8627 9458 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20719 r0 *1 149.04,345.44
X$20719 105 9000 9459 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20721 r0 *1 150.42,345.44
X$20721 105 9241 9460 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20722 r0 *1 151.8,345.44
X$20722 105 8819 9461 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20724 r0 *1 153.64,345.44
X$20724 40 9351 4656 9333 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20725 r0 *1 157.78,345.44
X$20725 105 9165 9462 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20727 r0 *1 159.62,345.44
X$20727 105 9014 9463 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20729 r0 *1 161.46,345.44
X$20729 105 8760 9464 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20730 r0 *1 162.84,345.44
X$20730 40 9426 4522 9352 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20732 r0 *1 167.44,345.44
X$20732 105 8957 9466 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20733 r0 *1 168.82,345.44
X$20733 105 9051 9467 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20734 r0 *1 170.2,345.44
X$20734 40 7306 9402 9049 9286 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20736 r0 *1 179.4,345.44
X$20736 105 9287 9468 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20738 r0 *1 181.24,345.44
X$20738 105 9129 9434 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20739 r0 *1 182.62,345.44
X$20739 105 8821 9469 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20740 r0 *1 184,345.44
X$20740 105 9402 9470 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20741 r0 *1 185.38,345.44
X$20741 40 7306 9403 9049 9435 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20743 r0 *1 195.04,345.44
X$20743 40 9435 6031 9403 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20744 r0 *1 199.18,345.44
X$20744 105 8897 9471 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20745 r0 *1 200.56,345.44
X$20745 105 9403 9437 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20746 r0 *1 201.94,345.44
X$20746 105 8958 9438 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20748 r0 *1 204.24,345.44
X$20748 40 9353 6788 9354 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20751 r0 *1 208.84,345.44
X$20751 105 9045 9436 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20752 r0 *1 210.22,345.44
X$20752 105 9473 9044 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20753 r0 *1 211.6,345.44
X$20753 105 9354 9425 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20754 r0 *1 212.98,345.44
X$20754 105 9405 9190 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20755 r0 *1 214.36,345.44
X$20755 105 8755 9472 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20756 r0 *1 215.74,345.44
X$20756 105 9108 9474 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20758 r0 *1 218.04,345.44
X$20758 40 9355 6987 9389 9189 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20760 r0 *1 222.64,345.44
X$20760 105 9440 8956 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20761 r0 *1 224.02,345.44
X$20761 105 9389 9424 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20762 r0 *1 225.4,345.44
X$20762 105 9288 9476 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20763 r0 *1 226.78,345.44
X$20763 40 7306 9323 9216 9326 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20766 r0 *1 236.44,345.44
X$20766 40 7306 9360 9216 9441 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20767 r0 *1 245.64,345.44
X$20767 40 9322 3441 9278 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20769 r0 *1 250.24,345.44
X$20769 40 9441 6959 9360 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20770 r0 *1 254.38,345.44
X$20770 105 8947 9442 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20771 r0 *1 255.76,345.44
X$20771 105 9443 8749 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20772 r0 *1 257.14,345.44
X$20772 105 8782 9477 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20773 r0 *1 258.52,345.44
X$20773 105 9478 8748 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20775 r0 *1 259.9,345.44
X$20775 105 9278 9306 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20776 r0 *1 261.28,345.44
X$20776 105 9406 105 40 9421 40 sky130_fd_sc_hd__clkbuf_2
* cell instance $20779 r0 *1 264.04,345.44
X$20779 40 7306 9277 8975 9319 105 105 40 sky130_fd_sc_hd__dfrtp_1
* cell instance $20780 r0 *1 273.24,345.44
X$20780 40 9307 6039 9250 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20782 r0 *1 277.84,345.44
X$20782 105 8623 9444 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20783 r0 *1 279.22,345.44
X$20783 105 9279 9482 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20784 r0 *1 280.6,345.44
X$20784 105 9445 9034 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20785 r0 *1 281.98,345.44
X$20785 105 8843 9407 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20786 r0 *1 283.36,345.44
X$20786 105 8922 9419 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20787 r0 *1 284.74,345.44
X$20787 105 9475 8976 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20790 r0 *1 287.04,345.44
X$20790 40 9361 6509 9362 9080 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20792 r0 *1 291.64,345.44
X$20792 105 9082 9408 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20793 r0 *1 293.02,345.44
X$20793 105 9277 9418 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20794 r0 *1 294.4,345.44
X$20794 105 9153 9358 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20795 r0 *1 295.78,345.44
X$20795 105 8784 9385 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20796 r0 *1 297.16,345.44
X$20796 105 8923 9417 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20797 r0 *1 298.54,345.44
X$20797 105 9250 9416 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20798 r0 *1 299.92,345.44
X$20798 105 9148 9378 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20799 r0 *1 301.3,345.44
X$20799 105 9409 8877 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20800 r0 *1 302.68,345.44
X$20800 105 8983 9410 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20803 r0 *1 305.44,345.44
X$20803 105 9362 9446 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20804 r0 *1 306.82,345.44
X$20804 105 9448 9092 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20805 r0 *1 308.2,345.44
X$20805 40 9374 6118 9363 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20806 r0 *1 312.34,345.44
X$20806 105 9131 9457 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20808 r0 *1 313.72,345.44
X$20808 105 9265 9447 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20809 r0 *1 315.1,345.44
X$20809 105 8981 9414 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20810 r0 *1 316.48,345.44
X$20810 105 9264 9411 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20813 r0 *1 319.24,345.44
X$20813 40 9370 5747 9364 9193 105 105 40 sky130_fd_sc_hd__mux2_1
* cell instance $20814 r0 *1 323.38,345.44
X$20814 105 9143 9449 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20815 r0 *1 324.76,345.44
X$20815 105 9363 9412 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20816 r0 *1 326.14,345.44
X$20816 105 9204 9413 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20817 r0 *1 327.52,345.44
X$20817 105 9262 9450 40 105 40 sky130_fd_sc_hd__clkbuf_1
* cell instance $20818 r0 *1 328.9,345.44
X$20818 105 9364 9454 40 105 40 sky130_fd_sc_hd__clkbuf_1
.ENDS parameterized_fft

* cell sky130_fd_sc_hd__dfxtp_1
* pin VGND
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfxtp_1 1 9 12 13 14 15 18
* net 1 VGND
* net 9 Q
* net 12 CLK
* net 13 D
* net 14 VPWR
* net 15 VPB
* device instance $1 r0 *1 1.83,2.275 pfet_01v8_hvt
M$1 4 13 14 15 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=57750000000P PS=1360000U PD=695000U
* device instance $2 r0 *1 2.255,2.275 pfet_01v8_hvt
M$2 5 3 4 15 pfet_01v8_hvt L=150000U W=420000U AS=57750000000P AD=68250000000P
+ PS=695000U PD=745000U
* device instance $3 r0 *1 2.73,2.275 pfet_01v8_hvt
M$3 16 2 5 15 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=76650000000P
+ PS=745000U PD=785000U
* device instance $4 r0 *1 3.245,2.275 pfet_01v8_hvt
M$4 16 6 14 15 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=76650000000P PS=1260000U PD=785000U
* device instance $5 r0 *1 3.905,2.11 pfet_01v8_hvt
M$5 6 5 14 15 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=109500000000P PS=1260000U PD=1075000U
* device instance $6 r0 *1 4.38,2.275 pfet_01v8_hvt
M$6 7 2 6 15 pfet_01v8_hvt L=150000U W=420000U AS=109500000000P AD=56700000000P
+ PS=1075000U PD=690000U
* device instance $7 r0 *1 4.8,2.275 pfet_01v8_hvt
M$7 17 3 7 15 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=88200000000P
+ PS=690000U PD=840000U
* device instance $8 r0 *1 5.37,2.275 pfet_01v8_hvt
M$8 14 8 17 15 pfet_01v8_hvt L=150000U W=420000U AS=88200000000P
+ AD=111300000000P PS=840000U PD=1370000U
* device instance $9 r0 *1 0.47,2.135 pfet_01v8_hvt
M$9 14 12 2 15 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $10 r0 *1 0.89,2.135 pfet_01v8_hvt
M$10 3 2 14 15 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $11 r0 *1 6.42,1.985 pfet_01v8_hvt
M$11 14 7 8 15 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=135000000000P PS=2540000U PD=1270000U
* device instance $12 r0 *1 6.84,1.985 pfet_01v8_hvt
M$12 9 8 14 15 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $13 r0 *1 6.43,0.56 nfet_01v8
M$13 1 7 8 18 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $14 r0 *1 6.85,0.56 nfet_01v8
M$14 9 8 1 18 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $15 r0 *1 2.39,0.415 nfet_01v8
M$15 5 2 4 18 nfet_01v8 L=150000U W=360000U AS=81300000000P AD=62100000000P
+ PS=830000U PD=705000U
* device instance $16 r0 *1 2.885,0.415 nfet_01v8
M$16 11 3 5 18 nfet_01v8 L=150000U W=360000U AS=62100000000P AD=69600000000P
+ PS=705000U PD=765000U
* device instance $17 r0 *1 4.48,0.415 nfet_01v8
M$17 7 3 6 18 nfet_01v8 L=150000U W=360000U AS=98900000000P AD=68400000000P
+ PS=995000U PD=740000U
* device instance $18 r0 *1 5.01,0.415 nfet_01v8
M$18 10 2 7 18 nfet_01v8 L=150000U W=360000U AS=68400000000P AD=66000000000P
+ PS=740000U PD=745000U
* device instance $19 r0 *1 1.83,0.445 nfet_01v8
M$19 4 13 1 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=81300000000P
+ PS=1360000U PD=830000U
* device instance $20 r0 *1 3.38,0.445 nfet_01v8
M$20 1 6 11 18 nfet_01v8 L=150000U W=420000U AS=69600000000P AD=120950000000P
+ PS=765000U PD=1085000U
* device instance $21 r0 *1 5.485,0.445 nfet_01v8
M$21 1 8 10 18 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=109200000000P
+ PS=745000U PD=1360000U
* device instance $22 r0 *1 3.975,0.555 nfet_01v8
M$22 6 5 1 18 nfet_01v8 L=150000U W=640000U AS=120950000000P AD=98900000000P
+ PS=1085000U PD=995000U
* device instance $23 r0 *1 0.47,0.445 nfet_01v8
M$23 1 12 2 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $24 r0 *1 0.89,0.445 nfet_01v8
M$24 3 2 1 18 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dfxtp_1

* cell sky130_fd_sc_hd__dfxtp_4
* pin VGND
* pin Q
* pin CLK
* pin D
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__dfxtp_4 1 9 12 13 14 15 18
* net 1 VGND
* net 9 Q
* net 12 CLK
* net 13 D
* net 14 VPB
* net 15 VPWR
* device instance $1 r0 *1 6.465,1.985 pfet_01v8_hvt
M$1 15 7 8 14 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=162500000000P PS=2560000U PD=1325000U
* device instance $2 r0 *1 6.94,1.985 pfet_01v8_hvt
M$2 9 8 15 14 pfet_01v8_hvt L=150000U W=4000000U AS=575000000000P
+ AD=692500000000P PS=5150000U PD=6385000U
* device instance $6 r0 *1 0.47,2.135 pfet_01v8_hvt
M$6 15 12 2 14 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $7 r0 *1 0.89,2.135 pfet_01v8_hvt
M$7 3 2 15 14 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $8 r0 *1 1.83,2.275 pfet_01v8_hvt
M$8 4 13 15 14 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=67200000000P PS=1360000U PD=740000U
* device instance $9 r0 *1 2.3,2.275 pfet_01v8_hvt
M$9 5 3 4 14 pfet_01v8_hvt L=150000U W=420000U AS=67200000000P AD=66150000000P
+ PS=740000U PD=735000U
* device instance $10 r0 *1 2.765,2.275 pfet_01v8_hvt
M$10 16 2 5 14 pfet_01v8_hvt L=150000U W=420000U AS=66150000000P
+ AD=69300000000P PS=735000U PD=750000U
* device instance $11 r0 *1 3.245,2.275 pfet_01v8_hvt
M$11 16 6 15 14 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=69300000000P PS=1260000U PD=750000U
* device instance $12 r0 *1 3.905,2.11 pfet_01v8_hvt
M$12 6 5 15 14 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=109500000000P PS=1260000U PD=1075000U
* device instance $13 r0 *1 4.38,2.275 pfet_01v8_hvt
M$13 7 2 6 14 pfet_01v8_hvt L=150000U W=420000U AS=109500000000P
+ AD=56700000000P PS=1075000U PD=690000U
* device instance $14 r0 *1 4.8,2.275 pfet_01v8_hvt
M$14 17 3 7 14 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=91350000000P PS=690000U PD=855000U
* device instance $15 r0 *1 5.385,2.275 pfet_01v8_hvt
M$15 15 8 17 14 pfet_01v8_hvt L=150000U W=420000U AS=91350000000P
+ AD=121800000000P PS=855000U PD=1420000U
* device instance $16 r0 *1 6.465,0.56 nfet_01v8
M$16 1 7 8 18 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $17 r0 *1 6.94,0.56 nfet_01v8
M$17 9 8 1 18 nfet_01v8 L=150000U W=2600000U AS=373750000000P AD=453375000000P
+ PS=3750000U PD=4645000U
* device instance $21 r0 *1 2.305,0.415 nfet_01v8
M$21 5 2 4 18 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $22 r0 *1 2.785,0.415 nfet_01v8
M$22 11 3 5 18 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=68700000000P
+ PS=690000U PD=760000U
* device instance $23 r0 *1 4.51,0.415 nfet_01v8
M$23 7 3 6 18 nfet_01v8 L=150000U W=360000U AS=98900000000P AD=65700000000P
+ PS=995000U PD=725000U
* device instance $24 r0 *1 5.025,0.415 nfet_01v8
M$24 10 2 7 18 nfet_01v8 L=150000U W=360000U AS=65700000000P AD=66000000000P
+ PS=725000U PD=745000U
* device instance $25 r0 *1 1.83,0.445 nfet_01v8
M$25 4 13 1 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=66000000000P
+ PS=1360000U PD=745000U
* device instance $26 r0 *1 3.275,0.445 nfet_01v8
M$26 1 6 11 18 nfet_01v8 L=150000U W=420000U AS=68700000000P AD=149300000000P
+ PS=760000U PD=1220000U
* device instance $27 r0 *1 5.5,0.445 nfet_01v8
M$27 1 8 10 18 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=119700000000P
+ PS=745000U PD=1410000U
* device instance $28 r0 *1 4.005,0.555 nfet_01v8
M$28 6 5 1 18 nfet_01v8 L=150000U W=640000U AS=149300000000P AD=98900000000P
+ PS=1220000U PD=995000U
* device instance $29 r0 *1 0.47,0.445 nfet_01v8
M$29 1 12 2 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $30 r0 *1 0.89,0.445 nfet_01v8
M$30 3 2 1 18 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dfxtp_4

* cell sky130_fd_sc_hd__clkinv_4
* pin VPB
* pin A
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_4 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 Y
* net 5 VPWR
* device instance $1 r0 *1 0.515,1.985 pfet_01v8_hvt
M$1 4 2 5 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.005e+12P AD=1.045e+12P
+ PS=9010000U PD=9090000U
* device instance $7 r0 *1 0.945,0.445 nfet_01v8
M$7 4 2 3 6 nfet_01v8 L=150000U W=1680000U AS=315000000000P AD=342300000000P
+ PS=3600000U PD=3730000U
.ENDS sky130_fd_sc_hd__clkinv_4

* cell sky130_fd_sc_hd__dfxtp_2
* pin VGND
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfxtp_2 1 9 12 13 14 15 18
* net 1 VGND
* net 9 Q
* net 12 CLK
* net 13 D
* net 14 VPWR
* net 15 VPB
* device instance $1 r0 *1 6.42,1.985 pfet_01v8_hvt
M$1 14 7 8 15 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=135000000000P PS=2540000U PD=1270000U
* device instance $2 r0 *1 6.84,1.985 pfet_01v8_hvt
M$2 9 8 14 15 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $4 r0 *1 1.83,2.275 pfet_01v8_hvt
M$4 4 13 14 15 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=57750000000P PS=1360000U PD=695000U
* device instance $5 r0 *1 2.255,2.275 pfet_01v8_hvt
M$5 5 3 4 15 pfet_01v8_hvt L=150000U W=420000U AS=57750000000P AD=68250000000P
+ PS=695000U PD=745000U
* device instance $6 r0 *1 2.73,2.275 pfet_01v8_hvt
M$6 16 2 5 15 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=76650000000P
+ PS=745000U PD=785000U
* device instance $7 r0 *1 3.245,2.275 pfet_01v8_hvt
M$7 16 6 14 15 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=76650000000P PS=1260000U PD=785000U
* device instance $8 r0 *1 3.905,2.11 pfet_01v8_hvt
M$8 6 5 14 15 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=109500000000P PS=1260000U PD=1075000U
* device instance $9 r0 *1 4.38,2.275 pfet_01v8_hvt
M$9 7 2 6 15 pfet_01v8_hvt L=150000U W=420000U AS=109500000000P AD=56700000000P
+ PS=1075000U PD=690000U
* device instance $10 r0 *1 4.8,2.275 pfet_01v8_hvt
M$10 17 3 7 15 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=88200000000P PS=690000U PD=840000U
* device instance $11 r0 *1 5.37,2.275 pfet_01v8_hvt
M$11 14 8 17 15 pfet_01v8_hvt L=150000U W=420000U AS=88200000000P
+ AD=111300000000P PS=840000U PD=1370000U
* device instance $12 r0 *1 0.47,2.135 pfet_01v8_hvt
M$12 14 12 2 15 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $13 r0 *1 0.89,2.135 pfet_01v8_hvt
M$13 3 2 14 15 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $14 r0 *1 6.43,0.56 nfet_01v8
M$14 1 7 8 18 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $15 r0 *1 6.85,0.56 nfet_01v8
M$15 9 8 1 18 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $17 r0 *1 2.39,0.415 nfet_01v8
M$17 5 2 4 18 nfet_01v8 L=150000U W=360000U AS=81300000000P AD=62100000000P
+ PS=830000U PD=705000U
* device instance $18 r0 *1 2.885,0.415 nfet_01v8
M$18 10 3 5 18 nfet_01v8 L=150000U W=360000U AS=62100000000P AD=69600000000P
+ PS=705000U PD=765000U
* device instance $19 r0 *1 4.48,0.415 nfet_01v8
M$19 7 3 6 18 nfet_01v8 L=150000U W=360000U AS=98900000000P AD=68400000000P
+ PS=995000U PD=740000U
* device instance $20 r0 *1 5.01,0.415 nfet_01v8
M$20 11 2 7 18 nfet_01v8 L=150000U W=360000U AS=68400000000P AD=66000000000P
+ PS=740000U PD=745000U
* device instance $21 r0 *1 1.83,0.445 nfet_01v8
M$21 4 13 1 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=81300000000P
+ PS=1360000U PD=830000U
* device instance $22 r0 *1 3.38,0.445 nfet_01v8
M$22 1 6 10 18 nfet_01v8 L=150000U W=420000U AS=69600000000P AD=120950000000P
+ PS=765000U PD=1085000U
* device instance $23 r0 *1 5.485,0.445 nfet_01v8
M$23 1 8 11 18 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=109200000000P
+ PS=745000U PD=1360000U
* device instance $24 r0 *1 3.975,0.555 nfet_01v8
M$24 6 5 1 18 nfet_01v8 L=150000U W=640000U AS=120950000000P AD=98900000000P
+ PS=1085000U PD=995000U
* device instance $25 r0 *1 0.47,0.445 nfet_01v8
M$25 1 12 2 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $26 r0 *1 0.89,0.445 nfet_01v8
M$26 3 2 1 18 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dfxtp_2

* cell sky130_fd_sc_hd__and4bb_1
* pin VGND
* pin C
* pin D
* pin X
* pin B_N
* pin A_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4bb_1 1 4 5 6 7 12 13 14 15
* net 1 VGND
* net 4 C
* net 5 D
* net 6 X
* net 7 B_N
* net 12 A_N
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 2.07,2.275 pfet_01v8_hvt
M$1 8 2 13 14 pfet_01v8_hvt L=150000U W=420000U AS=121800000000P
+ AD=58800000000P PS=1420000U PD=700000U
* device instance $2 r0 *1 2.5,2.275 pfet_01v8_hvt
M$2 13 3 8 14 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=73500000000P
+ PS=700000U PD=770000U
* device instance $3 r0 *1 3,2.275 pfet_01v8_hvt
M$3 8 4 13 14 pfet_01v8_hvt L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $4 r0 *1 3.52,2.275 pfet_01v8_hvt
M$4 8 5 13 14 pfet_01v8_hvt L=150000U W=420000U AS=172000000000P
+ AD=77700000000P PS=1460000U PD=790000U
* device instance $5 r0 *1 4.13,1.985 pfet_01v8_hvt
M$5 6 8 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=172000000000P
+ AD=260000000000P PS=1460000U PD=2520000U
* device instance $6 r0 *1 0.61,2.275 pfet_01v8_hvt
M$6 13 12 2 14 pfet_01v8_hvt L=150000U W=420000U AS=168000000000P
+ AD=58800000000P PS=1640000U PD=700000U
* device instance $7 r0 *1 1.04,2.275 pfet_01v8_hvt
M$7 3 7 13 14 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P
+ AD=134400000000P PS=700000U PD=1480000U
* device instance $8 r0 *1 2.07,0.675 nfet_01v8
M$8 9 2 8 15 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=58800000000P
+ PS=1400000U PD=700000U
* device instance $9 r0 *1 2.5,0.675 nfet_01v8
M$9 10 3 9 15 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=73500000000P
+ PS=700000U PD=770000U
* device instance $10 r0 *1 3,0.675 nfet_01v8
M$10 11 4 10 15 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $11 r0 *1 3.52,0.675 nfet_01v8
M$11 11 5 1 15 nfet_01v8 L=150000U W=420000U AS=126500000000P AD=77700000000P
+ PS=1110000U PD=790000U
* device instance $12 r0 *1 4.13,0.56 nfet_01v8
M$12 6 8 1 15 nfet_01v8 L=150000U W=650000U AS=126500000000P AD=165400000000P
+ PS=1110000U PD=1820000U
* device instance $13 r0 *1 0.61,0.445 nfet_01v8
M$13 1 12 2 15 nfet_01v8 L=150000U W=420000U AS=168000000000P AD=58800000000P
+ PS=1640000U PD=700000U
* device instance $14 r0 *1 1.04,0.445 nfet_01v8
M$14 3 7 1 15 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=138600000000P
+ PS=700000U PD=1500000U
.ENDS sky130_fd_sc_hd__and4bb_1

* cell sky130_fd_sc_hd__and4bb_4
* pin VGND
* pin B_N
* pin X
* pin C
* pin D
* pin A_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4bb_4 1 4 5 6 11 12 13 14 15
* net 1 VGND
* net 4 B_N
* net 5 X
* net 6 C
* net 11 D
* net 12 A_N
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 3 4 13 14 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 13 14 pfet_01v8_hvt L=150000U W=4000000U AS=545750000000P
+ AD=580000000000P PS=5135000U PD=5160000U
* device instance $6 r0 *1 2.705,1.985 pfet_01v8_hvt
M$6 2 11 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=165000000000P PS=1350000U PD=1330000U
* device instance $7 r0 *1 3.185,1.985 pfet_01v8_hvt
M$7 13 6 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=210000000000P PS=1330000U PD=1420000U
* device instance $8 r0 *1 3.755,1.985 pfet_01v8_hvt
M$8 2 3 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=210000000000P
+ AD=165000000000P PS=1420000U PD=1330000U
* device instance $9 r0 *1 4.235,1.985 pfet_01v8_hvt
M$9 13 7 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=311650000000P PS=1330000U PD=2125000U
* device instance $10 r0 *1 5.51,2.275 pfet_01v8_hvt
M$10 7 12 13 14 pfet_01v8_hvt L=150000U W=420000U AS=311650000000P
+ AD=109200000000P PS=2125000U PD=1360000U
* device instance $11 r0 *1 0.47,0.445 nfet_01v8
M$11 1 4 3 15 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $12 r0 *1 0.945,0.56 nfet_01v8
M$12 5 2 1 15 nfet_01v8 L=150000U W=2600000U AS=360250000000P AD=377000000000P
+ PS=3735000U PD=3760000U
* device instance $16 r0 *1 2.705,0.56 nfet_01v8
M$16 8 11 1 15 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=107250000000P
+ PS=1000000U PD=980000U
* device instance $17 r0 *1 3.185,0.56 nfet_01v8
M$17 10 6 8 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=136500000000P
+ PS=980000U PD=1070000U
* device instance $18 r0 *1 3.755,0.56 nfet_01v8
M$18 9 3 10 15 nfet_01v8 L=150000U W=650000U AS=136500000000P AD=107250000000P
+ PS=1070000U PD=980000U
* device instance $19 r0 *1 4.235,0.56 nfet_01v8
M$19 2 7 9 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
* device instance $20 r0 *1 5.51,0.445 nfet_01v8
M$20 7 12 1 15 nfet_01v8 L=150000U W=420000U AS=176400000000P AD=109200000000P
+ PS=1680000U PD=1360000U
.ENDS sky130_fd_sc_hd__and4bb_4

* cell sky130_fd_sc_hd__a32o_2
* pin VGND
* pin X
* pin A1
* pin A2
* pin B2
* pin B1
* pin A3
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a32o_2 1 2 4 5 6 7 8 13 14 15
* net 1 VGND
* net 2 X
* net 4 A1
* net 5 A2
* net 6 B2
* net 7 B1
* net 8 A3
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 3 6 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 12 7 3 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.67,1.985 pfet_01v8_hvt
M$3 13 4 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=215000000000P PS=1270000U PD=1430000U
* device instance $4 r0 *1 3.25,1.985 pfet_01v8_hvt
M$4 12 5 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=135000000000P PS=1430000U PD=1270000U
* device instance $5 r0 *1 3.67,1.985 pfet_01v8_hvt
M$5 13 8 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 13 3 2 14 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 2 3 1 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=297375000000P
+ PS=2740000U PD=2215000U
* device instance $10 r0 *1 1.685,0.56 nfet_01v8
M$10 11 6 1 15 nfet_01v8 L=150000U W=650000U AS=209625000000P AD=115375000000P
+ PS=1295000U PD=1005000U
* device instance $11 r0 *1 2.19,0.56 nfet_01v8
M$11 3 7 11 15 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=107250000000P
+ PS=1005000U PD=980000U
* device instance $12 r0 *1 2.67,0.56 nfet_01v8
M$12 10 4 3 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=139750000000P
+ PS=980000U PD=1080000U
* device instance $13 r0 *1 3.25,0.56 nfet_01v8
M$13 9 5 10 15 nfet_01v8 L=150000U W=650000U AS=139750000000P AD=87750000000P
+ PS=1080000U PD=920000U
* device instance $14 r0 *1 3.67,0.56 nfet_01v8
M$14 1 8 9 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__a32o_2

* cell sky130_fd_sc_hd__o2111ai_2
* pin VGND
* pin D1
* pin Y
* pin C1
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2111ai_2 1 2 4 5 7 9 10 11 13 14
* net 1 VGND
* net 2 D1
* net 4 Y
* net 5 C1
* net 7 B1
* net 9 A2
* net 10 A1
* net 11 VPWR
* net 13 VPB
* device instance $1 r0 *1 3.69,1.985 pfet_01v8_hvt
M$1 4 9 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=435000000000P
+ AD=280000000000P PS=3870000U PD=2560000U
* device instance $3 r0 *1 4.55,1.985 pfet_01v8_hvt
M$3 11 10 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=470000000000P PS=2560000U PD=3940000U
* device instance $5 r0 *1 0.555,1.985 pfet_01v8_hvt
M$5 4 2 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $7 r0 *1 1.415,1.985 pfet_01v8_hvt
M$7 4 5 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=280000000000P PS=2560000U PD=2560000U
* device instance $9 r0 *1 2.275,1.985 pfet_01v8_hvt
M$9 4 7 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $11 r0 *1 2.83,0.56 nfet_01v8
M$11 6 7 8 14 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=182000000000P
+ PS=2770000U PD=1860000U
* device instance $13 r0 *1 3.69,0.56 nfet_01v8
M$13 1 9 8 14 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=182000000000P
+ PS=1860000U PD=1860000U
* device instance $15 r0 *1 4.55,0.56 nfet_01v8
M$15 1 10 8 14 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=305500000000P
+ PS=1860000U PD=2890000U
* device instance $17 r0 *1 0.555,0.56 nfet_01v8
M$17 4 2 3 14 nfet_01v8 L=150000U W=1300000U AS=315250000000P AD=182000000000P
+ PS=2920000U PD=1860000U
* device instance $19 r0 *1 1.415,0.56 nfet_01v8
M$19 6 5 3 14 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=282750000000P
+ PS=1860000U PD=2820000U
.ENDS sky130_fd_sc_hd__o2111ai_2

* cell sky130_fd_sc_hd__and2b_1
* pin VPB
* pin B
* pin A_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__and2b_1 1 3 5 6 7 8 9
* net 1 VPB
* net 3 B
* net 5 A_N
* net 6 X
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 8 5 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=71400000000P
+ PS=1360000U PD=760000U
* device instance $2 r0 *1 0.96,2.275 pfet_01v8_hvt
M$2 2 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=71400000000P AD=60900000000P
+ PS=760000U PD=710000U
* device instance $3 r0 *1 1.4,2.275 pfet_01v8_hvt
M$3 2 3 8 1 pfet_01v8_hvt L=150000U W=420000U AS=227900000000P AD=60900000000P
+ PS=1740000U PD=710000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=227900000000P
+ AD=260000000000P PS=1740000U PD=2520000U
* device instance $5 r0 *1 1.41,0.445 nfet_01v8
M$5 10 4 2 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=50400000000P
+ PS=1360000U PD=660000U
* device instance $6 r0 *1 1.8,0.445 nfet_01v8
M$6 7 3 10 9 nfet_01v8 L=150000U W=420000U AS=50400000000P AD=101300000000P
+ PS=660000U PD=990000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=101300000000P AD=169000000000P
+ PS=990000U PD=1820000U
* device instance $8 r0 *1 0.47,0.445 nfet_01v8
M$8 4 5 7 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and2b_1

* cell sky130_fd_sc_hd__or4b_2
* pin VPB
* pin A
* pin C
* pin B
* pin D_N
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or4b_2 1 2 3 4 5 7 8 9 11
* net 1 VPB
* net 2 A
* net 3 C
* net 4 B
* net 5 D_N
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 8 5 10 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=169300000000P PS=1360000U PD=1500000U
* device instance $2 r0 *1 1.86,1.695 pfet_01v8_hvt
M$2 14 2 8 1 pfet_01v8_hvt L=150000U W=420000U AS=168350000000P AD=69300000000P
+ PS=1495000U PD=750000U
* device instance $3 r0 *1 2.34,1.695 pfet_01v8_hvt
M$3 13 4 14 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $4 r0 *1 2.7,1.695 pfet_01v8_hvt
M$4 12 3 13 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $5 r0 *1 3.18,1.695 pfet_01v8_hvt
M$5 6 10 12 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=109200000000P PS=750000U PD=1360000U
* device instance $6 r0 *1 0.955,1.985 pfet_01v8_hvt
M$6 9 6 8 1 pfet_01v8_hvt L=150000U W=2000000U AS=304300000000P
+ AD=303350000000P PS=2770000U PD=2765000U
* device instance $8 r0 *1 0.47,0.475 nfet_01v8
M$8 10 5 7 11 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $9 r0 *1 1.86,0.475 nfet_01v8
M$9 6 2 7 11 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=69300000000P
+ PS=985000U PD=750000U
* device instance $10 r0 *1 2.34,0.475 nfet_01v8
M$10 7 4 6 11 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $11 r0 *1 2.76,0.475 nfet_01v8
M$11 6 3 7 11 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $12 r0 *1 3.18,0.475 nfet_01v8
M$12 7 10 6 11 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $13 r0 *1 0.955,0.56 nfet_01v8
M$13 9 6 7 11 nfet_01v8 L=150000U W=1300000U AS=188000000000P AD=188000000000P
+ PS=1905000U PD=1905000U
.ENDS sky130_fd_sc_hd__or4b_2

* cell sky130_fd_sc_hd__o221ai_2
* pin VGND
* pin C1
* pin Y
* pin B1
* pin B2
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o221ai_2 1 3 4 6 7 8 9 10 13 14
* net 1 VGND
* net 3 C1
* net 4 Y
* net 6 B1
* net 7 B2
* net 8 A1
* net 9 A2
* net 10 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 4 3 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=530000000000P PS=3790000U PD=3060000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 6 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=530000000000P
+ AD=310000000000P PS=3060000U PD=2620000U
* device instance $4 r0 *1 2.255,1.985 pfet_01v8_hvt
M$4 4 7 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $7 r0 *1 3.595,1.985 pfet_01v8_hvt
M$7 12 8 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $8 r0 *1 4.015,1.985 pfet_01v8_hvt
M$8 4 9 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $11 r0 *1 1.835,0.56 nfet_01v8
M$11 2 6 5 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=201500000000P
+ PS=2740000U PD=1920000U
* device instance $12 r0 *1 2.255,0.56 nfet_01v8
M$12 5 7 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $15 r0 *1 3.595,0.56 nfet_01v8
M$15 1 8 5 14 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $16 r0 *1 4.015,0.56 nfet_01v8
M$16 5 9 1 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $19 r0 *1 0.475,0.56 nfet_01v8
M$19 4 3 2 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__o221ai_2

* cell sky130_fd_sc_hd__o32ai_2
* pin VGND
* pin Y
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o32ai_2 1 3 4 5 6 7 8 12 13 14
* net 1 VGND
* net 3 Y
* net 4 B2
* net 5 B1
* net 6 A3
* net 7 A2
* net 8 A1
* net 12 VPB
* net 13 VPWR
* device instance $1 r0 *1 4.95,1.985 pfet_01v8_hvt
M$1 11 8 13 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=415000000000P PS=3790000U PD=3830000U
* device instance $3 r0 *1 2.73,1.985 pfet_01v8_hvt
M$3 3 6 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 3.57,1.985 pfet_01v8_hvt
M$5 11 7 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 0.47,1.985 pfet_01v8_hvt
M$7 3 4 9 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $9 r0 *1 1.31,1.985 pfet_01v8_hvt
M$9 13 5 9 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 0.47,0.56 nfet_01v8
M$11 3 4 2 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $13 r0 *1 1.31,0.56 nfet_01v8
M$13 3 5 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $15 r0 *1 2.15,0.56 nfet_01v8
M$15 1 6 2 14 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=344500000000P
+ PS=2360000U PD=2360000U
* device instance $17 r0 *1 3.51,0.56 nfet_01v8
M$17 1 7 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=344500000000P
+ PS=1840000U PD=2360000U
* device instance $19 r0 *1 4.87,0.56 nfet_01v8
M$19 1 8 2 14 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=315250000000P
+ PS=2360000U PD=2920000U
.ENDS sky130_fd_sc_hd__o32ai_2

* cell sky130_fd_sc_hd__o31a_4
* pin VGND
* pin X
* pin B1
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31a_4 1 2 5 6 7 8 9 12 13
* net 1 VGND
* net 2 X
* net 5 B1
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.585,1.985 pfet_01v8_hvt
M$1 2 3 9 12 pfet_01v8_hvt L=150000U W=4000000U AS=680000000000P
+ AD=555000000000P PS=6360000U PD=5110000U
* device instance $5 r0 *1 2.295,1.985 pfet_01v8_hvt
M$5 3 5 9 12 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=425000000000P PS=2560000U PD=3850000U
* device instance $7 r0 *1 3.715,1.985 pfet_01v8_hvt
M$7 3 6 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $9 r0 *1 4.555,1.985 pfet_01v8_hvt
M$9 11 7 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $10 r0 *1 4.975,1.985 pfet_01v8_hvt
M$10 9 8 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $13 r0 *1 2.835,0.56 nfet_01v8
M$13 3 5 4 13 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=188500000000P
+ PS=2780000U PD=1880000U
* device instance $15 r0 *1 3.715,0.56 nfet_01v8
M$15 1 6 4 13 nfet_01v8 L=150000U W=1300000U AS=188500000000P AD=175500000000P
+ PS=1880000U PD=1840000U
* device instance $17 r0 *1 4.555,0.56 nfet_01v8
M$17 1 7 4 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $18 r0 *1 4.975,0.56 nfet_01v8
M$18 4 8 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $21 r0 *1 0.585,0.56 nfet_01v8
M$21 2 3 1 13 nfet_01v8 L=150000U W=2600000U AS=442000000000P AD=442000000000P
+ PS=4610000U PD=4610000U
.ENDS sky130_fd_sc_hd__o31a_4

* cell sky130_fd_sc_hd__o21bai_4
* pin VGND
* pin A2
* pin B1_N
* pin Y
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o21bai_4 1 2 3 6 7 8 10 11
* net 1 VGND
* net 2 A2
* net 3 B1_N
* net 6 Y
* net 7 A1
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.52,1.985 pfet_01v8_hvt
M$1 8 3 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=135000000000P PS=2560000U PD=1270000U
* device instance $2 r0 *1 0.94,1.985 pfet_01v8_hvt
M$2 6 4 8 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 3.14,1.985 pfet_01v8_hvt
M$6 6 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $10 r0 *1 4.82,1.985 pfet_01v8_hvt
M$10 8 7 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=685000000000P PS=5080000U PD=6370000U
* device instance $14 r0 *1 1.46,0.56 nfet_01v8
M$14 6 4 5 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $18 r0 *1 3.14,0.56 nfet_01v8
M$18 1 2 5 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
* device instance $22 r0 *1 4.82,0.56 nfet_01v8
M$22 1 7 5 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $26 r0 *1 0.52,0.56 nfet_01v8
M$26 4 3 1 11 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=169000000000P
+ PS=1860000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21bai_4

* cell sky130_fd_sc_hd__xnor3_1
* pin VGND
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xnor3_1 1 2 6 11 12 13 14 15
* net 1 VGND
* net 2 X
* net 6 C
* net 11 B
* net 12 A
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 5.455,1.805 pfet_01v8_hvt
M$1 10 9 8 14 pfet_01v8_hvt L=150000U W=640000U AS=243100000000P
+ AD=246000000000P PS=1445000U PD=1525000U
* device instance $2 r0 *1 6.33,1.965 pfet_01v8_hvt
M$2 4 11 10 14 pfet_01v8_hvt L=150000U W=640000U AS=246000000000P
+ AD=145800000000P PS=1525000U PD=1205000U
* device instance $3 r0 *1 4.7,1.905 pfet_01v8_hvt
M$3 8 11 5 14 pfet_01v8_hvt L=150000U W=840000U AS=352800000000P
+ AD=243100000000P PS=2520000U PD=1445000U
* device instance $4 r0 *1 6.845,2.065 pfet_01v8_hvt
M$4 4 9 5 14 pfet_01v8_hvt L=150000U W=840000U AS=171500000000P
+ AD=145800000000P PS=1355000U PD=1205000U
* device instance $5 r0 *1 7.35,1.985 pfet_01v8_hvt
M$5 13 12 5 14 pfet_01v8_hvt L=150000U W=1000000U AS=171500000000P
+ AD=135000000000P PS=1355000U PD=1270000U
* device instance $6 r0 *1 7.77,1.985 pfet_01v8_hvt
M$6 10 5 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=285000000000P PS=1270000U PD=2570000U
* device instance $7 r0 *1 1.005,1.805 pfet_01v8_hvt
M$7 7 6 13 14 pfet_01v8_hvt L=150000U W=640000U AS=169000000000P
+ AD=179200000000P PS=1365000U PD=1840000U
* device instance $8 r0 *1 0.49,1.985 pfet_01v8_hvt
M$8 13 3 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=169000000000P PS=2560000U PD=1365000U
* device instance $9 r0 *1 3.6,1.985 pfet_01v8_hvt
M$9 9 11 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=256550000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $10 r0 *1 2.54,1.905 pfet_01v8_hvt
M$10 8 7 3 14 pfet_01v8_hvt L=150000U W=840000U AS=152950000000P
+ AD=322350000000P PS=1315000U PD=2450000U
* device instance $11 r0 *1 2.055,2.045 pfet_01v8_hvt
M$11 4 6 3 14 pfet_01v8_hvt L=150000U W=840000U AS=152950000000P
+ AD=273000000000P PS=1315000U PD=2330000U
* device instance $12 r0 *1 2.12,0.565 nfet_01v8
M$12 3 6 8 15 nfet_01v8 L=150000U W=640000U AS=172800000000P AD=92800000000P
+ PS=1820000U PD=930000U
* device instance $13 r0 *1 2.56,0.565 nfet_01v8
M$13 4 7 3 15 nfet_01v8 L=150000U W=640000U AS=92800000000P AD=224000000000P
+ PS=930000U PD=1980000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=116500000000P
+ PS=1820000U PD=1035000U
* device instance $15 r0 *1 1.005,0.675 nfet_01v8
M$15 7 6 1 15 nfet_01v8 L=150000U W=420000U AS=116500000000P AD=178500000000P
+ PS=1035000U PD=1690000U
* device instance $16 r0 *1 5.455,0.455 nfet_01v8
M$16 10 9 4 15 nfet_01v8 L=150000U W=420000U AS=182050000000P AD=192650000000P
+ PS=1245000U PD=1285000U
* device instance $17 r0 *1 6.85,0.535 nfet_01v8
M$17 5 9 8 15 nfet_01v8 L=150000U W=600000U AS=140825000000P AD=110000000000P
+ PS=1100000U PD=990000U
* device instance $18 r0 *1 7.35,0.555 nfet_01v8
M$18 1 12 5 15 nfet_01v8 L=150000U W=640000U AS=110000000000P AD=86400000000P
+ PS=990000U PD=910000U
* device instance $19 r0 *1 7.77,0.555 nfet_01v8
M$19 10 5 1 15 nfet_01v8 L=150000U W=640000U AS=86400000000P AD=182400000000P
+ PS=910000U PD=1850000U
* device instance $20 r0 *1 4.7,0.565 nfet_01v8
M$20 4 11 5 15 nfet_01v8 L=150000U W=640000U AS=162750000000P AD=182050000000P
+ PS=1800000U PD=1245000U
* device instance $21 r0 *1 6.25,0.565 nfet_01v8
M$21 10 11 8 15 nfet_01v8 L=150000U W=640000U AS=140825000000P AD=192650000000P
+ PS=1100000U PD=1285000U
* device instance $22 r0 *1 3.77,0.56 nfet_01v8
M$22 9 11 1 15 nfet_01v8 L=150000U W=650000U AS=188500000000P AD=165150000000P
+ PS=1880000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor3_1

* cell sky130_fd_sc_hd__or4_2
* pin VPB
* pin D
* pin C
* pin B
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or4_2 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 D
* net 3 C
* net 4 B
* net 5 A
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 13 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $2 r0 *1 0.95,1.695 pfet_01v8_hvt
M$2 12 3 13 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $3 r0 *1 1.31,1.695 pfet_01v8_hvt
M$3 11 4 12 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $4 r0 *1 1.79,1.695 pfet_01v8_hvt
M$4 8 5 11 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $5 r0 *1 2.28,1.985 pfet_01v8_hvt
M$5 9 6 8 1 pfet_01v8_hvt L=150000U W=2000000U AS=283250000000P
+ AD=440000000000P PS=2610000U PD=3880000U
* device instance $7 r0 *1 0.47,0.475 nfet_01v8
M$7 6 2 7 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $8 r0 *1 0.95,0.475 nfet_01v8
M$8 7 3 6 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $9 r0 *1 1.37,0.475 nfet_01v8
M$9 6 4 7 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $10 r0 *1 1.79,0.475 nfet_01v8
M$10 6 5 7 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $11 r0 *1 2.28,0.56 nfet_01v8
M$11 9 6 7 10 nfet_01v8 L=150000U W=1300000U AS=189625000000P AD=286000000000P
+ PS=1910000U PD=2830000U
.ENDS sky130_fd_sc_hd__or4_2

* cell sky130_fd_sc_hd__maj3_1
* pin VGND
* pin C
* pin X
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__maj3_1 1 3 4 8 9 10 11 15
* net 1 VGND
* net 3 C
* net 4 X
* net 8 A
* net 9 B
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.915 pfet_01v8_hvt
M$1 13 3 2 11 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=44100000000P PS=1360000U PD=630000U
* device instance $2 r0 *1 0.83,1.915 pfet_01v8_hvt
M$2 10 8 13 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=56700000000P PS=630000U PD=690000U
* device instance $3 r0 *1 1.25,1.915 pfet_01v8_hvt
M$3 12 8 10 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=44100000000P PS=690000U PD=630000U
* device instance $4 r0 *1 1.61,1.915 pfet_01v8_hvt
M$4 2 9 12 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=56700000000P
+ PS=630000U PD=690000U
* device instance $5 r0 *1 2.03,1.915 pfet_01v8_hvt
M$5 14 9 2 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=44100000000P
+ PS=690000U PD=630000U
* device instance $6 r0 *1 2.39,1.915 pfet_01v8_hvt
M$6 14 3 10 11 pfet_01v8_hvt L=150000U W=420000U AS=249200000000P
+ AD=44100000000P PS=1565000U PD=630000U
* device instance $7 r0 *1 3.105,1.985 pfet_01v8_hvt
M$7 4 2 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=249200000000P
+ AD=365000000000P PS=1565000U PD=2730000U
* device instance $8 r0 *1 0.47,0.445 nfet_01v8
M$8 5 3 2 15 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 0.83,0.445 nfet_01v8
M$9 1 8 5 15 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=56700000000P
+ PS=630000U PD=690000U
* device instance $10 r0 *1 1.25,0.445 nfet_01v8
M$10 6 8 1 15 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=44100000000P
+ PS=690000U PD=630000U
* device instance $11 r0 *1 1.61,0.445 nfet_01v8
M$11 2 9 6 15 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=56700000000P
+ PS=630000U PD=690000U
* device instance $12 r0 *1 2.03,0.445 nfet_01v8
M$12 7 9 2 15 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=44100000000P
+ PS=690000U PD=630000U
* device instance $13 r0 *1 2.39,0.445 nfet_01v8
M$13 1 3 7 15 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=147400000000P
+ PS=630000U PD=1215000U
* device instance $14 r0 *1 3.105,0.56 nfet_01v8
M$14 4 2 1 15 nfet_01v8 L=150000U W=650000U AS=147400000000P AD=237250000000P
+ PS=1215000U PD=2030000U
.ENDS sky130_fd_sc_hd__maj3_1

* cell sky130_fd_sc_hd__and4b_2
* pin VGND
* pin B
* pin C
* pin X
* pin A_N
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4b_2 1 4 5 6 7 8 12 13 14
* net 1 VGND
* net 4 B
* net 5 C
* net 6 X
* net 7 A_N
* net 8 D
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 12 7 2 13 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,2.275 pfet_01v8_hvt
M$2 3 2 12 13 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=98700000000P
+ PS=690000U PD=890000U
* device instance $3 r0 *1 1.51,2.275 pfet_01v8_hvt
M$3 12 4 3 13 pfet_01v8_hvt L=150000U W=420000U AS=98700000000P
+ AD=128100000000P PS=890000U PD=1030000U
* device instance $4 r0 *1 2.27,2.275 pfet_01v8_hvt
M$4 3 5 12 13 pfet_01v8_hvt L=150000U W=420000U AS=128100000000P
+ AD=66150000000P PS=1030000U PD=735000U
* device instance $5 r0 *1 2.735,2.275 pfet_01v8_hvt
M$5 3 8 12 13 pfet_01v8_hvt L=150000U W=420000U AS=143250000000P
+ AD=66150000000P PS=1330000U PD=735000U
* device instance $6 r0 *1 3.215,1.985 pfet_01v8_hvt
M$6 6 3 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=295750000000P
+ AD=412500000000P PS=2635000U PD=3825000U
* device instance $8 r0 *1 1.41,0.445 nfet_01v8
M$8 10 2 3 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 1.77,0.445 nfet_01v8
M$9 11 4 10 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=73500000000P
+ PS=630000U PD=770000U
* device instance $10 r0 *1 2.27,0.445 nfet_01v8
M$10 9 5 11 14 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=61950000000P
+ PS=770000U PD=715000U
* device instance $11 r0 *1 2.715,0.445 nfet_01v8
M$11 1 8 9 14 nfet_01v8 L=150000U W=420000U AS=61950000000P AD=103975000000P
+ PS=715000U PD=1000000U
* device instance $12 r0 *1 3.215,0.56 nfet_01v8
M$12 6 3 1 14 nfet_01v8 L=150000U W=1300000U AS=203100000000P AD=268125000000P
+ PS=1955000U PD=2775000U
* device instance $14 r0 *1 0.47,0.445 nfet_01v8
M$14 2 7 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and4b_2

* cell sky130_fd_sc_hd__o41a_2
* pin VGND
* pin X
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o41a_2 1 2 5 6 7 8 9 10 11 15
* net 1 VGND
* net 2 X
* net 5 B1
* net 6 A4
* net 7 A3
* net 8 A2
* net 9 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=440000000000P PS=3790000U PD=2880000U
* device instance $3 r0 *1 1.65,1.985 pfet_01v8_hvt
M$3 3 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=302500000000P PS=1610000U PD=1605000U
* device instance $4 r0 *1 2.405,1.985 pfet_01v8_hvt
M$4 13 6 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=302500000000P
+ AD=177500000000P PS=1605000U PD=1355000U
* device instance $5 r0 *1 2.91,1.985 pfet_01v8_hvt
M$5 14 7 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=177500000000P
+ AD=175000000000P PS=1355000U PD=1350000U
* device instance $6 r0 *1 3.41,1.985 pfet_01v8_hvt
M$6 12 8 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=175000000000P PS=1350000U PD=1350000U
* device instance $7 r0 *1 3.91,1.985 pfet_01v8_hvt
M$7 10 9 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=410000000000P PS=1350000U PD=2820000U
* device instance $8 r0 *1 1.89,0.56 nfet_01v8
M$8 4 5 3 15 nfet_01v8 L=150000U W=650000U AS=208000000000P AD=118625000000P
+ PS=1940000U PD=1015000U
* device instance $9 r0 *1 2.405,0.56 nfet_01v8
M$9 1 6 4 15 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=115375000000P
+ PS=1015000U PD=1005000U
* device instance $10 r0 *1 2.91,0.56 nfet_01v8
M$10 4 7 1 15 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=113750000000P
+ PS=1005000U PD=1000000U
* device instance $11 r0 *1 3.41,0.56 nfet_01v8
M$11 1 8 4 15 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=113750000000P
+ PS=1000000U PD=1000000U
* device instance $12 r0 *1 3.91,0.56 nfet_01v8
M$12 4 9 1 15 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=266500000000P
+ PS=1000000U PD=2120000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 2 3 1 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__o41a_2

* cell sky130_fd_sc_hd__or4b_4
* pin VGND
* pin X
* pin D_N
* pin C
* pin B
* pin A
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or4b_4 1 4 5 6 7 8 9 10 14
* net 1 VGND
* net 4 X
* net 5 D_N
* net 6 C
* net 7 B
* net 8 A
* net 9 VPB
* net 10 VPWR
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 11 2 3 9 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=190000000000P PS=2520000U PD=1380000U
* device instance $2 r0 *1 1.94,1.985 pfet_01v8_hvt
M$2 13 6 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $3 r0 *1 2.36,1.985 pfet_01v8_hvt
M$3 12 7 13 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 2.78,1.985 pfet_01v8_hvt
M$4 10 8 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=190000000000P PS=1270000U PD=1380000U
* device instance $5 r0 *1 3.31,1.985 pfet_01v8_hvt
M$5 4 3 10 9 pfet_01v8_hvt L=150000U W=4000000U AS=595000000000P
+ AD=665000000000P PS=5190000U PD=6330000U
* device instance $9 r0 *1 0.47,2.275 pfet_01v8_hvt
M$9 2 5 10 9 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $10 r0 *1 1.41,0.56 nfet_01v8
M$10 3 2 1 14 nfet_01v8 L=150000U W=650000U AS=165350000000P AD=123500000000P
+ PS=1820000U PD=1030000U
* device instance $11 r0 *1 1.94,0.56 nfet_01v8
M$11 1 6 3 14 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=87750000000P
+ PS=1030000U PD=920000U
* device instance $12 r0 *1 2.36,0.56 nfet_01v8
M$12 3 7 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $13 r0 *1 2.78,0.56 nfet_01v8
M$13 1 8 3 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $14 r0 *1 3.31,0.56 nfet_01v8
M$14 4 3 1 14 nfet_01v8 L=150000U W=2600000U AS=386750000000P AD=442000000000P
+ PS=3790000U PD=4610000U
* device instance $18 r0 *1 0.47,0.675 nfet_01v8
M$18 2 5 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=107850000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or4b_4

* cell sky130_fd_sc_hd__o32ai_1
* pin VGND
* pin B1
* pin Y
* pin B2
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32ai_1 1 2 4 5 6 7 8 9 10 12
* net 1 VGND
* net 2 B1
* net 4 Y
* net 5 B2
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 4 5 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=305000000000P PS=1210000U PD=1610000U
* device instance $3 r0 *1 1.59,1.985 pfet_01v8_hvt
M$3 13 6 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=245000000000P PS=1610000U PD=1490000U
* device instance $4 r0 *1 2.23,1.985 pfet_01v8_hvt
M$4 14 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=245000000000P
+ AD=135000000000P PS=1490000U PD=1270000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 9 8 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=280000000000P PS=1270000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 4 2 3 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 0.945,0.56 nfet_01v8
M$7 3 5 4 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=100750000000P
+ PS=975000U PD=960000U
* device instance $8 r0 *1 1.405,0.56 nfet_01v8
M$8 1 6 3 12 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=219375000000P
+ PS=960000U PD=1325000U
* device instance $9 r0 *1 2.23,0.56 nfet_01v8
M$9 3 7 1 12 nfet_01v8 L=150000U W=650000U AS=219375000000P AD=87750000000P
+ PS=1325000U PD=920000U
* device instance $10 r0 *1 2.65,0.56 nfet_01v8
M$10 1 8 3 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=234000000000P
+ PS=920000U PD=2020000U
.ENDS sky130_fd_sc_hd__o32ai_1

* cell sky130_fd_sc_hd__nor4b_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_2 1 2 4 5 6 7 9 12 13
* net 1 VGND
* net 2 Y
* net 4 A
* net 5 B
* net 6 C
* net 7 D_N
* net 9 VPWR
* net 12 VPB
* device instance $1 r0 *1 4.905,2.275 pfet_01v8_hvt
M$1 9 7 3 12 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $2 r0 *1 2.705,1.985 pfet_01v8_hvt
M$2 10 6 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $4 r0 *1 3.545,1.985 pfet_01v8_hvt
M$4 2 3 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 9 4 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $8 r0 *1 1.31,1.985 pfet_01v8_hvt
M$8 10 5 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $10 r0 *1 2.705,0.56 nfet_01v8
M$10 2 6 1 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $12 r0 *1 3.545,0.56 nfet_01v8
M$12 2 3 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $14 r0 *1 4.905,0.675 nfet_01v8
M$14 1 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $15 r0 *1 0.47,0.56 nfet_01v8
M$15 2 4 1 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $17 r0 *1 1.31,0.56 nfet_01v8
M$17 2 5 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor4b_2

* cell sky130_fd_sc_hd__a2bb2oi_2
* pin VGND
* pin Y
* pin B1
* pin B2
* pin A1_N
* pin A2_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2bb2oi_2 1 3 5 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 5 B1
* net 6 B2
* net 7 A1_N
* net 8 A2_N
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.645,1.985 pfet_01v8_hvt
M$1 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 4.485,1.985 pfet_01v8_hvt
M$3 4 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $5 r0 *1 0.605,1.985 pfet_01v8_hvt
M$5 10 5 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $6 r0 *1 1.025,1.985 pfet_01v8_hvt
M$6 12 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 2.285,1.985 pfet_01v8_hvt
M$9 3 4 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 0.605,0.56 nfet_01v8
M$11 2 5 1 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $12 r0 *1 1.025,0.56 nfet_01v8
M$12 3 6 2 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $15 r0 *1 2.285,0.56 nfet_01v8
M$15 3 4 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=344500000000P
+ PS=1840000U PD=2360000U
* device instance $17 r0 *1 3.645,0.56 nfet_01v8
M$17 4 7 1 13 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=175500000000P
+ PS=2360000U PD=1840000U
* device instance $19 r0 *1 4.485,0.56 nfet_01v8
M$19 4 8 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__a2bb2oi_2

* cell sky130_fd_sc_hd__a32oi_1
* pin VPB
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a32oi_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A3
* net 5 A2
* net 6 A1
* net 8 Y
* net 9 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=215000000000P PS=1270000U PD=1430000U
* device instance $3 r0 *1 1.47,1.985 pfet_01v8_hvt
M$3 10 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=135000000000P PS=1430000U PD=1270000U
* device instance $4 r0 *1 1.89,1.985 pfet_01v8_hvt
M$4 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=140000000000P PS=1270000U PD=1280000U
* device instance $5 r0 *1 2.32,1.985 pfet_01v8_hvt
M$5 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=260000000000P PS=1280000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $7 r0 *1 0.85,0.56 nfet_01v8
M$7 8 3 14 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=152750000000P
+ PS=880000U PD=1120000U
* device instance $8 r0 *1 1.47,0.56 nfet_01v8
M$8 12 6 8 11 nfet_01v8 L=150000U W=650000U AS=152750000000P AD=71500000000P
+ PS=1120000U PD=870000U
* device instance $9 r0 *1 1.84,0.56 nfet_01v8
M$9 13 5 12 11 nfet_01v8 L=150000U W=650000U AS=71500000000P AD=107250000000P
+ PS=870000U PD=980000U
* device instance $10 r0 *1 2.32,0.56 nfet_01v8
M$10 9 4 13 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a32oi_1

* cell sky130_fd_sc_hd__and4_2
* pin VGND
* pin B
* pin C
* pin X
* pin A
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4_2 1 3 4 5 6 7 11 12 13
* net 1 VGND
* net 3 B
* net 4 C
* net 5 X
* net 6 A
* net 7 D
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 2 6 11 12 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=74550000000P PS=1360000U PD=775000U
* device instance $2 r0 *1 0.975,2.275 pfet_01v8_hvt
M$2 11 3 2 12 pfet_01v8_hvt L=150000U W=420000U AS=74550000000P AD=77700000000P
+ PS=775000U PD=790000U
* device instance $3 r0 *1 1.495,2.275 pfet_01v8_hvt
M$3 2 4 11 12 pfet_01v8_hvt L=150000U W=420000U AS=77700000000P AD=58800000000P
+ PS=790000U PD=700000U
* device instance $4 r0 *1 1.925,2.275 pfet_01v8_hvt
M$4 2 7 11 12 pfet_01v8_hvt L=150000U W=420000U AS=279950000000P
+ AD=58800000000P PS=1615000U PD=700000U
* device instance $5 r0 *1 2.69,1.985 pfet_01v8_hvt
M$5 5 2 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=444950000000P
+ AD=465000000000P PS=2945000U PD=3930000U
* device instance $7 r0 *1 0.47,0.445 nfet_01v8
M$7 8 6 2 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=61950000000P
+ PS=1360000U PD=715000U
* device instance $8 r0 *1 0.915,0.445 nfet_01v8
M$8 9 3 8 13 nfet_01v8 L=150000U W=420000U AS=61950000000P AD=79800000000P
+ PS=715000U PD=800000U
* device instance $9 r0 *1 1.445,0.445 nfet_01v8
M$9 10 4 9 13 nfet_01v8 L=150000U W=420000U AS=79800000000P AD=69300000000P
+ PS=800000U PD=750000U
* device instance $10 r0 *1 1.925,0.445 nfet_01v8
M$10 1 7 10 13 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=175150000000P
+ PS=750000U PD=1265000U
* device instance $11 r0 *1 2.69,0.56 nfet_01v8
M$11 5 2 1 13 nfet_01v8 L=150000U W=1300000U AS=282400000000P AD=302250000000P
+ PS=2245000U PD=2880000U
.ENDS sky130_fd_sc_hd__and4_2

* cell sky130_fd_sc_hd__a31o_4
* pin VGND
* pin A3
* pin A2
* pin A1
* pin B1
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31o_4 1 2 3 4 5 7 13 14 15
* net 1 VGND
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 7 X
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 13 2 12 14 pfet_01v8_hvt L=150000U W=2000000U AS=425000000000P
+ AD=300000000000P PS=3850000U PD=2600000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 12 3 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=300000000000P PS=2540000U PD=2600000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 13 4 12 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $7 r0 *1 3.11,1.985 pfet_01v8_hvt
M$7 6 5 12 14 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=395000000000P PS=2600000U PD=3790000U
* device instance $9 r0 *1 4.47,1.985 pfet_01v8_hvt
M$9 7 6 13 14 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=905000000000P PS=6330000U PD=6810000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 8 2 1 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $14 r0 *1 0.89,0.56 nfet_01v8
M$14 9 3 8 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 6 4 9 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $16 r0 *1 1.73,0.56 nfet_01v8
M$16 11 4 6 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $17 r0 *1 2.15,0.56 nfet_01v8
M$17 10 3 11 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $18 r0 *1 2.63,0.56 nfet_01v8
M$18 1 2 10 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $19 r0 *1 3.11,0.56 nfet_01v8
M$19 6 5 1 15 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=344500000000P
+ PS=1900000U PD=2360000U
* device instance $21 r0 *1 4.47,0.56 nfet_01v8
M$21 7 6 1 15 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=432250000000P
+ PS=4200000U PD=4580000U
.ENDS sky130_fd_sc_hd__a31o_4

* cell sky130_fd_sc_hd__a41oi_2
* pin VGND
* pin Y
* pin B1
* pin A1
* pin A2
* pin A3
* pin A4
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_2 1 2 6 7 8 9 10 12 13 14
* net 1 VGND
* net 2 Y
* net 6 B1
* net 7 A1
* net 8 A2
* net 9 A3
* net 10 A4
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 1.08,1.985 pfet_01v8_hvt
M$1 2 6 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.92,1.985 pfet_01v8_hvt
M$3 12 7 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 2.76,1.985 pfet_01v8_hvt
M$5 12 8 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=280000000000P PS=2540000U PD=2560000U
* device instance $7 r0 *1 3.62,1.985 pfet_01v8_hvt
M$7 12 9 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=530000000000P
+ AD=520000000000P PS=3060000U PD=3040000U
* device instance $9 r0 *1 4.96,1.985 pfet_01v8_hvt
M$9 12 10 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 4.12,0.56 nfet_01v8
M$11 4 9 5 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $13 r0 *1 4.96,0.56 nfet_01v8
M$13 1 10 5 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $15 r0 *1 1.92,0.56 nfet_01v8
M$15 2 7 3 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $17 r0 *1 2.76,0.56 nfet_01v8
M$17 4 8 3 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $19 r0 *1 0.56,0.56 nfet_01v8
M$19 2 6 1 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__a41oi_2

* cell sky130_fd_sc_hd__clkinv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_1 1 2 3 4 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.47,2.065 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1680000U AS=331800000000P
+ AD=348600000000P PS=3310000U PD=3350000U
* device instance $3 r0 *1 0.885,0.445 nfet_01v8
M$3 4 2 5 6 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=119700000000P
+ PS=1360000U PD=1410000U
.ENDS sky130_fd_sc_hd__clkinv_1

* cell sky130_fd_sc_hd__edfxtp_1
* pin VGND
* pin DE
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__edfxtp_1 1 5 11 17 18 19 20 26
* net 1 VGND
* net 5 DE
* net 11 Q
* net 17 CLK
* net 18 D
* net 19 VPWR
* net 20 VPB
* device instance $1 r0 *1 9.925,2.165 pfet_01v8_hvt
M$1 7 10 19 20 pfet_01v8_hvt L=150000U W=640000U AS=154000000000P
+ AD=172800000000P PS=1335000U PD=1820000U
* device instance $2 r0 *1 10.41,1.985 pfet_01v8_hvt
M$2 11 10 19 20 pfet_01v8_hvt L=150000U W=1000000U AS=154000000000P
+ AD=280000000000P PS=1335000U PD=2560000U
* device instance $3 r0 *1 7.425,2.275 pfet_01v8_hvt
M$3 24 9 19 20 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=64050000000P PS=1360000U PD=725000U
* device instance $4 r0 *1 7.88,2.275 pfet_01v8_hvt
M$4 10 2 24 20 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P
+ AD=56700000000P PS=725000U PD=690000U
* device instance $5 r0 *1 8.3,2.275 pfet_01v8_hvt
M$5 25 3 10 20 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=88200000000P PS=690000U PD=840000U
* device instance $6 r0 *1 8.87,2.275 pfet_01v8_hvt
M$6 19 7 25 20 pfet_01v8_hvt L=150000U W=420000U AS=88200000000P
+ AD=111300000000P PS=840000U PD=1370000U
* device instance $7 r0 *1 1.83,2.165 pfet_01v8_hvt
M$7 21 18 4 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=67200000000P PS=1800000U PD=850000U
* device instance $8 r0 *1 2.19,2.165 pfet_01v8_hvt
M$8 19 6 21 20 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=166400000000P PS=850000U PD=1800000U
* device instance $9 r0 *1 0.47,2.135 pfet_01v8_hvt
M$9 19 17 2 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $10 r0 *1 0.89,2.135 pfet_01v8_hvt
M$10 3 2 19 20 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $11 r0 *1 3.13,2.165 pfet_01v8_hvt
M$11 19 5 6 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=92800000000P PS=1800000U PD=930000U
* device instance $12 r0 *1 3.57,2.165 pfet_01v8_hvt
M$12 22 5 19 20 pfet_01v8_hvt L=150000U W=640000U AS=92800000000P
+ AD=115200000000P PS=930000U PD=1000000U
* device instance $13 r0 *1 4.08,2.165 pfet_01v8_hvt
M$13 4 7 22 20 pfet_01v8_hvt L=150000U W=640000U AS=115200000000P
+ AD=159850000000P PS=1000000U PD=1265000U
* device instance $14 r0 *1 4.855,2.275 pfet_01v8_hvt
M$14 8 3 4 20 pfet_01v8_hvt L=150000U W=420000U AS=159850000000P
+ AD=64050000000P PS=1265000U PD=725000U
* device instance $15 r0 *1 5.31,2.275 pfet_01v8_hvt
M$15 23 2 8 20 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P
+ AD=76650000000P PS=725000U PD=785000U
* device instance $16 r0 *1 5.825,2.275 pfet_01v8_hvt
M$16 23 9 19 20 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=76650000000P PS=1260000U PD=785000U
* device instance $17 r0 *1 6.485,2.11 pfet_01v8_hvt
M$17 9 8 19 20 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=195000000000P PS=1260000U PD=2020000U
* device instance $18 r0 *1 9.925,0.445 nfet_01v8
M$18 1 10 7 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $19 r0 *1 10.41,0.56 nfet_01v8
M$19 11 10 1 26 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=182000000000P
+ PS=985000U PD=1860000U
* device instance $20 r0 *1 7.98,0.415 nfet_01v8
M$20 10 3 15 26 nfet_01v8 L=150000U W=360000U AS=67800000000P AD=68400000000P
+ PS=755000U PD=740000U
* device instance $21 r0 *1 8.51,0.415 nfet_01v8
M$21 13 2 10 26 nfet_01v8 L=150000U W=360000U AS=68400000000P AD=66000000000P
+ PS=740000U PD=745000U
* device instance $22 r0 *1 7.495,0.445 nfet_01v8
M$22 15 9 1 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=67800000000P
+ PS=1360000U PD=755000U
* device instance $23 r0 *1 8.985,0.445 nfet_01v8
M$23 1 7 13 26 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=109200000000P
+ PS=745000U PD=1360000U
* device instance $24 r0 *1 0.47,0.445 nfet_01v8
M$24 1 17 2 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $25 r0 *1 0.89,0.445 nfet_01v8
M$25 3 2 1 26 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $26 r0 *1 1.83,0.445 nfet_01v8
M$26 12 18 4 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $27 r0 *1 2.19,0.445 nfet_01v8
M$27 1 5 12 26 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=109200000000P
+ PS=630000U PD=1360000U
* device instance $28 r0 *1 4.99,0.415 nfet_01v8
M$28 8 2 4 26 nfet_01v8 L=150000U W=360000U AS=144600000000P AD=52200000000P
+ PS=1180000U PD=650000U
* device instance $29 r0 *1 5.43,0.415 nfet_01v8
M$29 16 3 8 26 nfet_01v8 L=150000U W=360000U AS=52200000000P AD=75900000000P
+ PS=650000U PD=800000U
* device instance $30 r0 *1 3.13,0.445 nfet_01v8
M$30 1 5 6 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $31 r0 *1 3.57,0.445 nfet_01v8
M$31 14 6 1 26 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=75600000000P
+ PS=710000U PD=780000U
* device instance $32 r0 *1 4.08,0.445 nfet_01v8
M$32 4 7 14 26 nfet_01v8 L=150000U W=420000U AS=75600000000P AD=144600000000P
+ PS=780000U PD=1180000U
* device instance $33 r0 *1 5.96,0.445 nfet_01v8
M$33 1 9 16 26 nfet_01v8 L=150000U W=420000U AS=75900000000P AD=120950000000P
+ PS=800000U PD=1085000U
* device instance $34 r0 *1 6.555,0.555 nfet_01v8
M$34 9 8 1 26 nfet_01v8 L=150000U W=640000U AS=120950000000P AD=166400000000P
+ PS=1085000U PD=1800000U
.ENDS sky130_fd_sc_hd__edfxtp_1

* cell sky130_fd_sc_hd__clkinv_16
* pin VGND
* pin A
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_16 1 2 3 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=24000000U AS=3.59e+12P AD=3.58e+12P
+ PS=32180000U PD=32160000U
* device instance $25 r0 *1 2.205,0.445 nfet_01v8
M$25 3 2 1 6 nfet_01v8 L=150000U W=6720000U AS=1.0332e+12P AD=1.0332e+12P
+ PS=12060000U PD=12060000U
.ENDS sky130_fd_sc_hd__clkinv_16

* cell sky130_fd_sc_hd__a22o_4
* pin VGND
* pin X
* pin B2
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a22o_4 1 3 4 6 7 9 10 12 13
* net 1 VGND
* net 3 X
* net 4 B2
* net 6 B1
* net 7 A2
* net 9 A1
* net 10 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.555,1.985 pfet_01v8_hvt
M$1 3 2 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=665000000000P PS=6370000U PD=6330000U
* device instance $5 r0 *1 2.755,1.985 pfet_01v8_hvt
M$5 2 4 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=310000000000P PS=3790000U PD=2620000U
* device instance $6 r0 *1 3.175,1.985 pfet_01v8_hvt
M$6 11 6 2 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 4.515,1.985 pfet_01v8_hvt
M$9 10 7 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $10 r0 *1 4.935,1.985 pfet_01v8_hvt
M$10 11 9 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $13 r0 *1 0.555,0.56 nfet_01v8
M$13 3 2 1 13 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=520000000000P
+ PS=4620000U PD=4200000U
* device instance $17 r0 *1 2.755,0.56 nfet_01v8
M$17 5 4 1 13 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=201500000000P
+ PS=2360000U PD=1920000U
* device instance $18 r0 *1 3.175,0.56 nfet_01v8
M$18 2 6 5 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $21 r0 *1 4.515,0.56 nfet_01v8
M$21 8 7 1 13 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $22 r0 *1 4.935,0.56 nfet_01v8
M$22 2 9 8 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
.ENDS sky130_fd_sc_hd__a22o_4

* cell sky130_fd_sc_hd__or3b_4
* pin VGND
* pin C_N
* pin X
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or3b_4 1 3 5 6 7 8 9 12
* net 1 VGND
* net 3 C_N
* net 5 X
* net 6 A
* net 7 B
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.47,2.01 pfet_01v8_hvt
M$1 4 3 8 9 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=550750000000P
+ AD=540000000000P PS=5145000U PD=5080000U
* device instance $6 r0 *1 2.635,1.985 pfet_01v8_hvt
M$6 11 6 8 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $7 r0 *1 3.055,1.985 pfet_01v8_hvt
M$7 10 7 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $8 r0 *1 3.535,1.985 pfet_01v8_hvt
M$8 2 4 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $9 r0 *1 0.47,0.445 nfet_01v8
M$9 1 3 4 12 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $10 r0 *1 0.955,0.56 nfet_01v8
M$10 5 2 1 12 nfet_01v8 L=150000U W=2600000U AS=363500000000P AD=351000000000P
+ PS=3745000U PD=3680000U
* device instance $14 r0 *1 2.635,0.56 nfet_01v8
M$14 2 6 1 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $15 r0 *1 3.055,0.56 nfet_01v8
M$15 1 7 2 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $16 r0 *1 3.535,0.56 nfet_01v8
M$16 2 4 1 12 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__or3b_4

* cell sky130_fd_sc_hd__o211a_4
* pin VGND
* pin X
* pin B1
* pin C1
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211a_4 1 2 5 6 7 8 11 12 15
* net 1 VGND
* net 2 X
* net 5 B1
* net 6 C1
* net 7 A1
* net 8 A2
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.86,1.985 pfet_01v8_hvt
M$1 2 3 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $5 r0 *1 2.58,1.985 pfet_01v8_hvt
M$5 3 5 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=335000000000P
+ AD=412500000000P PS=2670000U PD=2825000U
* device instance $6 r0 *1 3.235,1.985 pfet_01v8_hvt
M$6 11 6 3 12 pfet_01v8_hvt L=150000U W=2000000U AS=392500000000P
+ AD=335000000000P PS=2785000U PD=2670000U
* device instance $9 r0 *1 4.675,1.985 pfet_01v8_hvt
M$9 13 7 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=140000000000P PS=1320000U PD=1280000U
* device instance $10 r0 *1 5.105,1.985 pfet_01v8_hvt
M$10 3 8 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $11 r0 *1 5.535,1.985 pfet_01v8_hvt
M$11 14 8 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $12 r0 *1 5.965,1.985 pfet_01v8_hvt
M$12 11 7 14 12 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $13 r0 *1 2.71,0.56 nfet_01v8
M$13 9 5 4 15 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $14 r0 *1 3.07,0.56 nfet_01v8
M$14 3 6 9 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=144625000000P
+ PS=860000U PD=1095000U
* device instance $15 r0 *1 3.665,0.56 nfet_01v8
M$15 10 6 3 15 nfet_01v8 L=150000U W=650000U AS=144625000000P AD=91000000000P
+ PS=1095000U PD=930000U
* device instance $16 r0 *1 4.095,0.56 nfet_01v8
M$16 4 5 10 15 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=104000000000P
+ PS=930000U PD=970000U
* device instance $17 r0 *1 4.565,0.56 nfet_01v8
M$17 1 7 4 15 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=299000000000P
+ PS=1900000U PD=2870000U
* device instance $18 r0 *1 5.105,0.56 nfet_01v8
M$18 4 8 1 15 nfet_01v8 L=150000U W=1300000U AS=217750000000P AD=182000000000P
+ PS=1970000U PD=1860000U
* device instance $21 r0 *1 0.47,0.56 nfet_01v8
M$21 2 3 1 15 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=455000000000P
+ PS=4580000U PD=4650000U
.ENDS sky130_fd_sc_hd__o211a_4

* cell sky130_fd_sc_hd__a311o_1
* pin VPB
* pin C1
* pin B1
* pin A1
* pin A2
* pin A3
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a311o_1 1 2 3 4 5 6 7 8 10 12
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 X
* net 8 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 11 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=285000000000P
+ AD=142500000000P PS=2570000U PD=1285000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 9 6 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=142500000000P
+ AD=165000000000P PS=1285000U PD=1330000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 10 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=305000000000P PS=1330000U PD=1610000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 9 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=162500000000P PS=1610000U PD=1325000U
* device instance $5 r0 *1 2.645,1.985 pfet_01v8_hvt
M$5 15 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=207500000000P PS=1325000U PD=1415000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 11 2 15 1 pfet_01v8_hvt L=150000U W=1000000U AS=207500000000P
+ AD=260000000000P PS=1415000U PD=2520000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 8 11 7 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112125000000P
+ PS=1820000U PD=995000U
* device instance $8 r0 *1 0.965,0.56 nfet_01v8
M$8 14 6 8 12 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=125125000000P
+ PS=995000U PD=1035000U
* device instance $9 r0 *1 1.5,0.56 nfet_01v8
M$9 13 5 14 12 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=169000000000P
+ PS=1035000U PD=1170000U
* device instance $10 r0 *1 2.17,0.56 nfet_01v8
M$10 11 4 13 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1170000U PD=975000U
* device instance $11 r0 *1 2.645,0.56 nfet_01v8
M$11 8 3 11 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=134875000000P
+ PS=975000U PD=1065000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 11 2 8 12 nfet_01v8 L=150000U W=650000U AS=134875000000P AD=169000000000P
+ PS=1065000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311o_1

* cell sky130_fd_sc_hd__a41o_4
* pin VGND
* pin X
* pin B1
* pin A1
* pin A2
* pin A3
* pin A4
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41o_4 1 3 4 6 7 9 11 12 14 15
* net 1 VGND
* net 3 X
* net 4 B1
* net 6 A1
* net 7 A2
* net 9 A3
* net 11 A4
* net 12 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 12 14 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=665000000000P PS=6330000U PD=6330000U
* device instance $5 r0 *1 2.67,1.985 pfet_01v8_hvt
M$5 2 4 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=280000000000P PS=3790000U PD=2560000U
* device instance $7 r0 *1 3.53,1.985 pfet_01v8_hvt
M$7 12 6 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=270000000000P PS=2560000U PD=2540000U
* device instance $9 r0 *1 4.37,1.985 pfet_01v8_hvt
M$9 12 7 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=280000000000P PS=2540000U PD=2560000U
* device instance $11 r0 *1 5.23,1.985 pfet_01v8_hvt
M$11 12 9 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=530000000000P
+ AD=520000000000P PS=3060000U PD=3040000U
* device instance $13 r0 *1 6.57,1.985 pfet_01v8_hvt
M$13 12 11 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $15 r0 *1 5.73,0.56 nfet_01v8
M$15 8 9 10 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $17 r0 *1 6.57,0.56 nfet_01v8
M$17 1 11 10 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P
+ AD=256750000000P PS=1840000U PD=2740000U
* device instance $19 r0 *1 0.47,0.56 nfet_01v8
M$19 3 2 1 15 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=357500000000P
+ PS=4580000U PD=3700000U
* device instance $23 r0 *1 2.17,0.56 nfet_01v8
M$23 2 4 1 15 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=256750000000P
+ PS=1860000U PD=2740000U
* device instance $25 r0 *1 3.53,0.56 nfet_01v8
M$25 2 6 5 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $27 r0 *1 4.37,0.56 nfet_01v8
M$27 8 7 5 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a41o_4

* cell sky130_fd_sc_hd__and2b_2
* pin VPB
* pin A_N
* pin B
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and2b_2 1 2 4 5 7 8 9
* net 1 VPB
* net 2 A_N
* net 4 B
* net 5 VPWR
* net 7 VGND
* net 8 X
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=76650000000P
+ PS=1360000U PD=785000U
* device instance $2 r0 *1 0.985,2.275 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=76650000000P AD=60900000000P
+ PS=785000U PD=710000U
* device instance $3 r0 *1 1.425,2.275 pfet_01v8_hvt
M$3 6 4 5 1 pfet_01v8_hvt L=150000U W=420000U AS=228950000000P AD=60900000000P
+ PS=1745000U PD=710000U
* device instance $4 r0 *1 2.32,1.985 pfet_01v8_hvt
M$4 8 6 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=363950000000P
+ AD=395000000000P PS=3015000U PD=3790000U
* device instance $6 r0 *1 1.41,0.445 nfet_01v8
M$6 10 3 6 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $7 r0 *1 1.83,0.445 nfet_01v8
M$7 7 4 10 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=101875000000P
+ PS=690000U PD=990000U
* device instance $8 r0 *1 2.32,0.56 nfet_01v8
M$8 8 6 7 9 nfet_01v8 L=150000U W=1300000U AS=189625000000P AD=263250000000P
+ PS=1910000U PD=2760000U
* device instance $10 r0 *1 0.47,0.445 nfet_01v8
M$10 3 2 7 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and2b_2

* cell sky130_fd_sc_hd__and4b_1
* pin VGND
* pin B
* pin C
* pin X
* pin A_N
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4b_1 1 4 5 6 7 8 12 13 14
* net 1 VGND
* net 4 B
* net 5 C
* net 6 X
* net 7 A_N
* net 8 D
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 12 7 2 13 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,2.275 pfet_01v8_hvt
M$2 3 2 12 13 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=98700000000P
+ PS=690000U PD=890000U
* device instance $3 r0 *1 1.51,2.275 pfet_01v8_hvt
M$3 12 4 3 13 pfet_01v8_hvt L=150000U W=420000U AS=98700000000P
+ AD=128100000000P PS=890000U PD=1030000U
* device instance $4 r0 *1 2.27,2.275 pfet_01v8_hvt
M$4 3 5 12 13 pfet_01v8_hvt L=150000U W=420000U AS=128100000000P
+ AD=66150000000P PS=1030000U PD=735000U
* device instance $5 r0 *1 2.735,2.275 pfet_01v8_hvt
M$5 3 8 12 13 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=66150000000P PS=1325000U PD=735000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 6 3 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 1.41,0.445 nfet_01v8
M$7 11 2 3 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $8 r0 *1 1.77,0.445 nfet_01v8
M$8 10 4 11 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=73500000000P
+ PS=630000U PD=770000U
* device instance $9 r0 *1 2.27,0.445 nfet_01v8
M$9 9 5 10 14 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=60900000000P
+ PS=770000U PD=710000U
* device instance $10 r0 *1 2.71,0.445 nfet_01v8
M$10 1 8 9 14 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=103400000000P
+ PS=710000U PD=1000000U
* device instance $11 r0 *1 3.21,0.56 nfet_01v8
M$11 6 3 1 14 nfet_01v8 L=150000U W=650000U AS=103400000000P AD=169000000000P
+ PS=1000000U PD=1820000U
* device instance $12 r0 *1 0.47,0.445 nfet_01v8
M$12 1 7 2 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and4b_1

* cell sky130_fd_sc_hd__o311a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311a_1 1 2 5 6 7 8 9 11 12 15
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 C1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.48,1.985 pfet_01v8_hvt
M$1 11 4 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=312500000000P PS=2520000U PD=1625000U
* device instance $2 r0 *1 1.255,1.985 pfet_01v8_hvt
M$2 14 5 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=312500000000P
+ AD=180000000000P PS=1625000U PD=1360000U
* device instance $3 r0 *1 1.765,1.985 pfet_01v8_hvt
M$3 13 6 14 12 pfet_01v8_hvt L=150000U W=1000000U AS=180000000000P
+ AD=210000000000P PS=1360000U PD=1420000U
* device instance $4 r0 *1 2.335,1.985 pfet_01v8_hvt
M$4 4 7 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=210000000000P
+ AD=137500000000P PS=1420000U PD=1275000U
* device instance $5 r0 *1 2.76,1.985 pfet_01v8_hvt
M$5 11 8 4 12 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=150000000000P PS=1275000U PD=1300000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 4 9 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=150000000000P
+ AD=260000000000P PS=1300000U PD=2520000U
* device instance $7 r0 *1 0.48,0.56 nfet_01v8
M$7 1 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=203125000000P
+ PS=1820000U PD=1275000U
* device instance $8 r0 *1 1.255,0.56 nfet_01v8
M$8 3 5 1 15 nfet_01v8 L=150000U W=650000U AS=203125000000P AD=117000000000P
+ PS=1275000U PD=1010000U
* device instance $9 r0 *1 1.765,0.56 nfet_01v8
M$9 1 6 3 15 nfet_01v8 L=150000U W=650000U AS=117000000000P AD=136500000000P
+ PS=1010000U PD=1070000U
* device instance $10 r0 *1 2.335,0.56 nfet_01v8
M$10 3 7 1 15 nfet_01v8 L=150000U W=650000U AS=136500000000P AD=118625000000P
+ PS=1070000U PD=1015000U
* device instance $11 r0 *1 2.85,0.56 nfet_01v8
M$11 10 8 3 15 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=68250000000P
+ PS=1015000U PD=860000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 4 9 10 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__o311a_1

* cell sky130_fd_sc_hd__a211o_2
* pin VGND
* pin X
* pin A2
* pin A1
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a211o_2 1 2 5 6 7 8 9 11 12
* net 1 VGND
* net 2 X
* net 5 A2
* net 6 A1
* net 7 B1
* net 8 C1
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 9 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=195000000000P PS=2520000U PD=1390000U
* device instance $2 r0 *1 2.37,1.985 pfet_01v8_hvt
M$2 10 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=165000000000P PS=1390000U PD=1330000U
* device instance $3 r0 *1 2.85,1.985 pfet_01v8_hvt
M$3 13 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=105000000000P PS=1330000U PD=1210000U
* device instance $4 r0 *1 3.21,1.985 pfet_01v8_hvt
M$4 3 8 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 2 3 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 2 3 1 12 nfet_01v8 L=150000U W=1300000U AS=260000000000P AD=290875000000P
+ PS=2750000U PD=2195000U
* device instance $9 r0 *1 1.665,0.56 nfet_01v8
M$9 4 5 1 12 nfet_01v8 L=150000U W=650000U AS=199875000000P AD=133250000000P
+ PS=1265000U PD=1060000U
* device instance $10 r0 *1 2.225,0.56 nfet_01v8
M$10 3 6 4 12 nfet_01v8 L=150000U W=650000U AS=133250000000P AD=115375000000P
+ PS=1060000U PD=1005000U
* device instance $11 r0 *1 2.73,0.56 nfet_01v8
M$11 1 7 3 12 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=107250000000P
+ PS=1005000U PD=980000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 3 8 1 12 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a211o_2

* cell sky130_fd_sc_hd__nand4b_4
* pin VGND
* pin D
* pin Y
* pin A_N
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_4 1 2 5 8 9 10 11 12 13
* net 1 VGND
* net 2 D
* net 5 Y
* net 8 A_N
* net 9 B
* net 10 C
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 5 3 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 3.09,1.985 pfet_01v8_hvt
M$5 5 9 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=800000000000P PS=5080000U PD=5600000U
* device instance $9 r0 *1 5.29,1.985 pfet_01v8_hvt
M$9 5 10 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=540000000000P PS=5600000U PD=5080000U
* device instance $13 r0 *1 6.97,1.985 pfet_01v8_hvt
M$13 5 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $17 r0 *1 0.47,1.985 pfet_01v8_hvt
M$17 11 8 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $18 r0 *1 5.29,0.56 nfet_01v8
M$18 6 10 7 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $22 r0 *1 6.97,0.56 nfet_01v8
M$22 1 2 7 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 8 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $27 r0 *1 1.41,0.56 nfet_01v8
M$27 5 3 4 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $31 r0 *1 3.09,0.56 nfet_01v8
M$31 6 9 4 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand4b_4

* cell sky130_fd_sc_hd__nand3b_4
* pin VGND
* pin B
* pin A_N
* pin Y
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_4 1 2 4 6 8 9 10 11
* net 1 VGND
* net 2 B
* net 4 A_N
* net 6 Y
* net 8 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 5.29,1.985 pfet_01v8_hvt
M$1 6 8 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=765000000000P PS=6330000U PD=6530000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 9 4 3 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $6 r0 *1 1.41,1.985 pfet_01v8_hvt
M$6 6 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $10 r0 *1 3.09,1.985 pfet_01v8_hvt
M$10 6 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $14 r0 *1 5.29,0.56 nfet_01v8
M$14 7 8 1 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=497250000000P
+ PS=4580000U PD=4780000U
* device instance $18 r0 *1 1.41,0.56 nfet_01v8
M$18 6 3 5 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $22 r0 *1 3.09,0.56 nfet_01v8
M$22 7 2 5 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 4 3 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3b_4

* cell sky130_fd_sc_hd__o21a_2
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__o21a_2 1 3 4 5 6 7 8 10
* net 1 VPB
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=397500000000P
+ AD=537500000000P PS=3795000U PD=3075000U
* device instance $3 r0 *1 1.845,1.985 pfet_01v8_hvt
M$3 2 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=400000000000P
+ AD=140000000000P PS=1800000U PD=1280000U
* device instance $4 r0 *1 2.275,1.985 pfet_01v8_hvt
M$4 11 4 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=160000000000P PS=1280000U PD=1320000U
* device instance $5 r0 *1 2.745,1.985 pfet_01v8_hvt
M$5 7 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=265000000000P PS=1320000U PD=2530000U
* device instance $6 r0 *1 1.845,0.56 nfet_01v8
M$6 9 3 2 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $7 r0 *1 2.275,0.56 nfet_01v8
M$7 6 4 9 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=104000000000P
+ PS=930000U PD=970000U
* device instance $8 r0 *1 2.745,0.56 nfet_01v8
M$8 9 5 6 10 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=172250000000P
+ PS=970000U PD=1830000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 8 2 6 10 nfet_01v8 L=150000U W=1300000U AS=258375000000P AD=261625000000P
+ PS=2745000U PD=2755000U
.ENDS sky130_fd_sc_hd__o21a_2

* cell sky130_fd_sc_hd__a41oi_1
* pin VGND
* pin Y
* pin A3
* pin A2
* pin B1
* pin A4
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_1 1 2 3 4 8 9 10 11 12 14
* net 1 VGND
* net 2 Y
* net 3 A3
* net 4 A2
* net 8 B1
* net 9 A4
* net 10 A1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 13 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=212500000000P PS=2520000U PD=1425000U
* device instance $2 r0 *1 1.045,1.985 pfet_01v8_hvt
M$2 11 9 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=205000000000P PS=1425000U PD=1410000U
* device instance $3 r0 *1 1.605,1.985 pfet_01v8_hvt
M$3 13 3 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=155000000000P PS=1410000U PD=1310000U
* device instance $4 r0 *1 2.065,1.985 pfet_01v8_hvt
M$4 11 4 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=212500000000P PS=1310000U PD=1425000U
* device instance $5 r0 *1 2.64,1.985 pfet_01v8_hvt
M$5 13 10 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=370000000000P PS=1425000U PD=2740000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 8 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=169000000000P
+ PS=1175000U PD=1820000U
* device instance $7 r0 *1 1.105,0.56 nfet_01v8
M$7 5 9 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=113750000000P
+ PS=1175000U PD=1000000U
* device instance $8 r0 *1 1.605,0.56 nfet_01v8
M$8 7 3 5 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $9 r0 *1 2.065,0.56 nfet_01v8
M$9 6 4 7 14 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=138125000000P
+ PS=960000U PD=1075000U
* device instance $10 r0 *1 2.64,0.56 nfet_01v8
M$10 2 10 6 14 nfet_01v8 L=150000U W=650000U AS=138125000000P AD=240500000000P
+ PS=1075000U PD=2040000U
.ENDS sky130_fd_sc_hd__a41oi_1

* cell sky130_fd_sc_hd__o211a_2
* pin VPB
* pin C1
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__o211a_2 1 2 3 4 5 7 9 10 11
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A2
* net 5 A1
* net 7 VPWR
* net 9 VGND
* net 10 X
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.905,1.985 pfet_01v8_hvt
M$2 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=367500000000P PS=1280000U PD=1735000U
* device instance $3 r0 *1 1.79,1.985 pfet_01v8_hvt
M$3 13 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=367500000000P
+ AD=105000000000P PS=1735000U PD=1210000U
* device instance $4 r0 *1 2.15,1.985 pfet_01v8_hvt
M$4 7 5 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $5 r0 *1 2.69,1.985 pfet_01v8_hvt
M$5 10 6 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=335000000000P
+ AD=405000000000P PS=2670000U PD=3810000U
* device instance $7 r0 *1 1.77,0.56 nfet_01v8
M$7 8 4 9 11 nfet_01v8 L=150000U W=650000U AS=165350000000P AD=91000000000P
+ PS=1820000U PD=930000U
* device instance $8 r0 *1 2.2,0.56 nfet_01v8
M$8 9 5 8 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=104000000000P
+ PS=930000U PD=970000U
* device instance $9 r0 *1 2.67,0.56 nfet_01v8
M$9 10 6 9 11 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=321750000000P
+ PS=1900000U PD=2940000U
* device instance $11 r0 *1 0.475,0.56 nfet_01v8
M$11 12 2 6 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $12 r0 *1 0.835,0.56 nfet_01v8
M$12 8 3 12 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=165350000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__o211a_2

* cell sky130_fd_sc_hd__or4b_1
* pin VGND
* pin D_N
* pin X
* pin C
* pin A
* pin VPWR
* pin VPB
* pin B
* pin
.SUBCKT sky130_fd_sc_hd__or4b_1 1 2 5 6 7 8 9 10 14
* net 1 VGND
* net 2 D_N
* net 5 X
* net 6 C
* net 7 A
* net 8 VPWR
* net 9 VPB
* net 10 B
* device instance $1 r0 *1 1.41,1.695 pfet_01v8_hvt
M$1 11 3 4 9 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=68250000000P
+ PS=1360000U PD=745000U
* device instance $2 r0 *1 1.885,1.695 pfet_01v8_hvt
M$2 13 6 11 9 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=45150000000P
+ PS=745000U PD=635000U
* device instance $3 r0 *1 2.25,1.695 pfet_01v8_hvt
M$3 12 10 13 9 pfet_01v8_hvt L=150000U W=420000U AS=45150000000P
+ AD=64050000000P PS=635000U PD=725000U
* device instance $4 r0 *1 2.705,1.695 pfet_01v8_hvt
M$4 8 7 12 9 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P AD=148250000000P
+ PS=725000U PD=1340000U
* device instance $5 r0 *1 3.195,1.985 pfet_01v8_hvt
M$5 5 4 8 9 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=275000000000P PS=1340000U PD=2550000U
* device instance $6 r0 *1 0.47,1.695 pfet_01v8_hvt
M$6 3 2 8 9 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $7 r0 *1 1.41,0.475 nfet_01v8
M$7 4 3 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=64050000000P
+ PS=1360000U PD=725000U
* device instance $8 r0 *1 1.865,0.475 nfet_01v8
M$8 1 6 4 14 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=56700000000P
+ PS=725000U PD=690000U
* device instance $9 r0 *1 2.285,0.475 nfet_01v8
M$9 4 10 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $10 r0 *1 2.705,0.475 nfet_01v8
M$10 4 7 1 14 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $11 r0 *1 3.195,0.56 nfet_01v8
M$11 5 4 1 14 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=178750000000P
+ PS=990000U PD=1850000U
* device instance $12 r0 *1 0.47,0.475 nfet_01v8
M$12 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or4b_1

* cell sky130_fd_sc_hd__o2111a_2
* pin VGND
* pin X
* pin C1
* pin D1
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2111a_2 1 2 4 6 7 8 9 12 13 15
* net 1 VGND
* net 2 X
* net 4 C1
* net 6 D1
* net 7 B1
* net 8 A2
* net 9 A1
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=505000000000P PS=3810000U PD=3010000U
* device instance $3 r0 *1 1.785,1.985 pfet_01v8_hvt
M$3 3 6 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=140000000000P PS=1730000U PD=1280000U
* device instance $4 r0 *1 2.215,1.985 pfet_01v8_hvt
M$4 12 4 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=195000000000P PS=1280000U PD=1390000U
* device instance $5 r0 *1 2.755,1.985 pfet_01v8_hvt
M$5 3 7 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $6 r0 *1 3.295,1.985 pfet_01v8_hvt
M$6 14 8 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $7 r0 *1 3.835,1.985 pfet_01v8_hvt
M$7 12 9 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=265000000000P PS=1390000U PD=2530000U
* device instance $8 r0 *1 1.855,0.56 nfet_01v8
M$8 10 6 3 15 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $9 r0 *1 2.215,0.56 nfet_01v8
M$9 11 4 10 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=126750000000P
+ PS=860000U PD=1040000U
* device instance $10 r0 *1 2.755,0.56 nfet_01v8
M$10 5 7 11 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 3.295,0.56 nfet_01v8
M$11 1 8 5 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $12 r0 *1 3.835,0.56 nfet_01v8
M$12 5 9 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=172250000000P
+ PS=1040000U PD=1830000U
* device instance $13 r0 *1 0.475,0.56 nfet_01v8
M$13 2 3 1 15 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=263250000000P
+ PS=2760000U PD=2760000U
.ENDS sky130_fd_sc_hd__o2111a_2

* cell sky130_fd_sc_hd__nand4b_2
* pin VGND
* pin Y
* pin A_N
* pin B
* pin C
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_2 1 4 7 8 9 10 11 12 13
* net 1 VGND
* net 4 Y
* net 7 A_N
* net 8 B
* net 9 C
* net 10 D
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 4 2 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 2.25,1.985 pfet_01v8_hvt
M$3 4 8 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=505000000000P PS=2540000U PD=3010000U
* device instance $5 r0 *1 3.56,1.985 pfet_01v8_hvt
M$5 4 9 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=505000000000P
+ AD=315000000000P PS=3010000U PD=2630000U
* device instance $7 r0 *1 4.49,1.985 pfet_01v8_hvt
M$7 4 10 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=315000000000P
+ AD=535000000000P PS=2630000U PD=4070000U
* device instance $9 r0 *1 0.47,2.275 pfet_01v8_hvt
M$9 11 7 2 12 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $10 r0 *1 3.61,0.56 nfet_01v8
M$10 5 9 6 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=204750000000P
+ PS=2740000U PD=1930000U
* device instance $12 r0 *1 4.54,0.56 nfet_01v8
M$12 1 10 6 13 nfet_01v8 L=150000U W=1300000U AS=204750000000P AD=256750000000P
+ PS=1930000U PD=2740000U
* device instance $14 r0 *1 1.41,0.56 nfet_01v8
M$14 4 2 3 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $16 r0 *1 2.25,0.56 nfet_01v8
M$16 5 8 3 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $18 r0 *1 0.47,0.445 nfet_01v8
M$18 1 7 2 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__nand4b_2

* cell sky130_fd_sc_hd__o2111ai_4
* pin VGND
* pin D1
* pin A2
* pin Y
* pin C1
* pin B1
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2111ai_4 1 2 3 4 6 9 10 11 13 14
* net 1 VGND
* net 2 D1
* net 3 A2
* net 4 Y
* net 6 C1
* net 9 B1
* net 10 A1
* net 11 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 11 6 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=642500000000P PS=5080000U PD=5285000U
* device instance $9 r0 *1 4.035,1.985 pfet_01v8_hvt
M$9 11 9 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=642500000000P
+ AD=552500000000P PS=5285000U PD=5105000U
* device instance $13 r0 *1 5.74,1.985 pfet_01v8_hvt
M$13 12 3 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=552500000000P
+ AD=658350000000P PS=5105000U PD=6330000U
* device instance $17 r0 *1 7.93,1.985 pfet_01v8_hvt
M$17 12 10 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=657850000000P
+ AD=665000000000P PS=6330000U PD=6330000U
* device instance $21 r0 *1 4.35,0.56 nfet_01v8
M$21 7 9 8 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=359125000000P
+ PS=4580000U PD=3705000U
* device instance $25 r0 *1 6.055,0.56 nfet_01v8
M$25 1 3 8 14 nfet_01v8 L=150000U W=2600000U AS=365625000000P AD=365625000000P
+ PS=3725000U PD=3725000U
* device instance $29 r0 *1 7.78,0.56 nfet_01v8
M$29 1 10 8 14 nfet_01v8 L=150000U W=2600000U AS=359125000000P AD=448500000000P
+ PS=3705000U PD=4630000U
* device instance $33 r0 *1 0.47,0.56 nfet_01v8
M$33 4 2 5 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $37 r0 *1 2.15,0.56 nfet_01v8
M$37 7 6 5 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o2111ai_4

* cell sky130_fd_sc_hd__a2111oi_1
* pin VGND
* pin Y
* pin A2
* pin D1
* pin C1
* pin B1
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_1 1 2 3 4 5 6 7 10 11 14
* net 1 VGND
* net 2 Y
* net 3 A2
* net 4 D1
* net 5 C1
* net 6 B1
* net 7 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.01,1.985 pfet_01v8_hvt
M$1 12 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=755000000000P
+ AD=172500000000P PS=3510000U PD=1345000U
* device instance $2 r0 *1 1.505,1.985 pfet_01v8_hvt
M$2 13 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=185000000000P PS=1345000U PD=1370000U
* device instance $3 r0 *1 2.025,1.985 pfet_01v8_hvt
M$3 9 6 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=185000000000P
+ AD=290000000000P PS=1370000U PD=1580000U
* device instance $4 r0 *1 2.755,1.985 pfet_01v8_hvt
M$4 10 7 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=137500000000P PS=1580000U PD=1275000U
* device instance $5 r0 *1 3.18,1.985 pfet_01v8_hvt
M$5 9 3 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=290000000000P PS=1275000U PD=2580000U
* device instance $6 r0 *1 0.97,0.56 nfet_01v8
M$6 2 4 1 14 nfet_01v8 L=150000U W=650000U AS=481000000000P AD=125125000000P
+ PS=2780000U PD=1035000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=120250000000P
+ PS=1035000U PD=1020000U
* device instance $8 r0 *1 2.025,0.56 nfet_01v8
M$8 2 6 1 14 nfet_01v8 L=150000U W=650000U AS=120250000000P AD=191750000000P
+ PS=1020000U PD=1240000U
* device instance $9 r0 *1 2.765,0.56 nfet_01v8
M$9 8 7 2 14 nfet_01v8 L=150000U W=650000U AS=191750000000P AD=84500000000P
+ PS=1240000U PD=910000U
* device instance $10 r0 *1 3.175,0.56 nfet_01v8
M$10 1 3 8 14 nfet_01v8 L=150000U W=650000U AS=84500000000P AD=191750000000P
+ PS=910000U PD=1890000U
.ENDS sky130_fd_sc_hd__a2111oi_1

* cell sky130_fd_sc_hd__o221a_4
* pin VGND
* pin C1
* pin B1
* pin B2
* pin A1
* pin A2
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o221a_4 1 3 5 7 8 9 10 11 14 15
* net 1 VGND
* net 3 C1
* net 5 B1
* net 7 B2
* net 8 A1
* net 9 A2
* net 10 X
* net 11 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 11 14 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 12 5 11 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=530000000000P PS=2540000U PD=3060000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 4 7 12 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $7 r0 *1 3.51,1.985 pfet_01v8_hvt
M$7 13 8 11 14 pfet_01v8_hvt L=150000U W=2000000U AS=530000000000P
+ AD=270000000000P PS=3060000U PD=2540000U
* device instance $8 r0 *1 3.93,1.985 pfet_01v8_hvt
M$8 4 9 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $11 r0 *1 5.19,1.985 pfet_01v8_hvt
M$11 10 4 11 14 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $15 r0 *1 0.47,0.56 nfet_01v8
M$15 4 3 2 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $17 r0 *1 1.31,0.56 nfet_01v8
M$17 6 5 2 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $18 r0 *1 1.73,0.56 nfet_01v8
M$18 2 7 6 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $21 r0 *1 3.51,0.56 nfet_01v8
M$21 6 8 1 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $22 r0 *1 3.93,0.56 nfet_01v8
M$22 1 9 6 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $25 r0 *1 5.19,0.56 nfet_01v8
M$25 10 4 1 15 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o221a_4

* cell sky130_fd_sc_hd__a2111oi_4
* pin VGND
* pin D1
* pin Y
* pin C1
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_4 1 2 3 4 5 7 8 12 13 14
* net 1 VGND
* net 2 D1
* net 3 Y
* net 4 C1
* net 5 B1
* net 7 A1
* net 8 A2
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 4.44,1.985 pfet_01v8_hvt
M$1 11 5 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=680000000000P
+ AD=565000000000P PS=6360000U PD=5130000U
* device instance $5 r0 *1 6.17,1.985 pfet_01v8_hvt
M$5 12 7 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=575000000000P
+ AD=630000000000P PS=5150000U PD=5260000U
* device instance $9 r0 *1 8.03,1.985 pfet_01v8_hvt
M$9 12 8 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=730000000000P PS=5330000U PD=6460000U
* device instance $13 r0 *1 0.48,1.985 pfet_01v8_hvt
M$13 3 2 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $17 r0 *1 2.2,1.985 pfet_01v8_hvt
M$17 11 4 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=560000000000P
+ AD=680000000000P PS=5120000U PD=6360000U
* device instance $21 r0 *1 6.38,0.56 nfet_01v8
M$21 3 7 6 14 nfet_01v8 L=150000U W=2600000U AS=455000000000P AD=394875000000P
+ PS=4650000U PD=3815000U
* device instance $25 r0 *1 8.195,0.56 nfet_01v8
M$25 1 8 6 14 nfet_01v8 L=150000U W=2600000U AS=394875000000P AD=445250000000P
+ PS=3815000U PD=4620000U
* device instance $29 r0 *1 0.49,0.56 nfet_01v8
M$29 3 2 1 14 nfet_01v8 L=150000U W=2600000U AS=451750000000P AD=386750000000P
+ PS=4640000U PD=3790000U
* device instance $33 r0 *1 2.28,0.56 nfet_01v8
M$33 3 4 1 14 nfet_01v8 L=150000U W=2600000U AS=390000000000P AD=399750000000P
+ PS=3800000U PD=3830000U
* device instance $37 r0 *1 4.11,0.56 nfet_01v8
M$37 3 5 1 14 nfet_01v8 L=150000U W=2600000U AS=399750000000P AD=455000000000P
+ PS=3830000U PD=4650000U
.ENDS sky130_fd_sc_hd__a2111oi_4

* cell sky130_fd_sc_hd__a31o_2
* pin VPB
* pin B1
* pin A1
* pin A2
* pin A3
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a31o_2 1 2 3 4 5 6 7 8 11
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 A3
* net 6 X
* net 7 VPWR
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 10 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 7 4 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $5 r0 *1 2.21,1.985 pfet_01v8_hvt
M$5 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $6 r0 *1 2.69,1.985 pfet_01v8_hvt
M$6 10 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=320000000000P PS=1330000U PD=2640000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 6 10 8 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $9 r0 *1 1.31,0.56 nfet_01v8
M$9 13 5 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 1.73,0.56 nfet_01v8
M$10 12 4 13 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $11 r0 *1 2.21,0.56 nfet_01v8
M$11 10 3 12 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=126750000000P
+ PS=980000U PD=1040000U
* device instance $12 r0 *1 2.75,0.56 nfet_01v8
M$12 8 2 10 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=169000000000P
+ PS=1040000U PD=1820000U
.ENDS sky130_fd_sc_hd__a31o_2

* cell sky130_fd_sc_hd__o22ai_4
* pin VGND
* pin A2
* pin B1
* pin B2
* pin A1
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_4 1 2 3 4 6 7 8 10 12
* net 1 VGND
* net 2 A2
* net 3 B1
* net 4 B2
* net 6 A1
* net 7 Y
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.5,1.985 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=4000000U AS=695000000000P
+ AD=565000000000P PS=6390000U PD=5130000U
* device instance $4 r0 *1 1.76,1.985 pfet_01v8_hvt
M$4 7 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $9 r0 *1 3.91,1.985 pfet_01v8_hvt
M$9 11 3 8 10 pfet_01v8_hvt L=150000U W=4000000U AS=565000000000P
+ AD=665000000000P PS=5130000U PD=6330000U
* device instance $12 r0 *1 5.17,1.985 pfet_01v8_hvt
M$12 7 4 11 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $17 r0 *1 0.5,0.56 nfet_01v8
M$17 1 6 5 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=367250000000P
+ PS=4580000U PD=3730000U
* device instance $20 r0 *1 1.76,0.56 nfet_01v8
M$20 5 2 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
* device instance $25 r0 *1 3.91,0.56 nfet_01v8
M$25 7 3 5 12 nfet_01v8 L=150000U W=2600000U AS=367250000000P AD=432250000000P
+ PS=3730000U PD=4580000U
* device instance $28 r0 *1 5.17,0.56 nfet_01v8
M$28 5 4 7 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
.ENDS sky130_fd_sc_hd__o22ai_4

* cell sky130_fd_sc_hd__a211o_4
* pin VGND
* pin X
* pin B1
* pin C1
* pin A2
* pin A1
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211o_4 1 2 4 5 6 7 10 11 15
* net 1 VGND
* net 2 X
* net 4 B1
* net 5 C1
* net 6 A2
* net 7 A1
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 11 10 pfet_01v8_hvt L=150000U W=4000000U AS=680000000000P
+ AD=680000000000P PS=6360000U PD=6360000U
* device instance $5 r0 *1 2.7,1.985 pfet_01v8_hvt
M$5 13 4 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=140000000000P PS=2520000U PD=1280000U
* device instance $6 r0 *1 3.13,1.985 pfet_01v8_hvt
M$6 3 5 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $7 r0 *1 3.56,1.985 pfet_01v8_hvt
M$7 14 5 3 10 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=160000000000P PS=1280000U PD=1320000U
* device instance $8 r0 *1 4.03,1.985 pfet_01v8_hvt
M$8 12 4 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=195000000000P PS=1320000U PD=1390000U
* device instance $9 r0 *1 4.57,1.985 pfet_01v8_hvt
M$9 11 6 12 10 pfet_01v8_hvt L=150000U W=2000000U AS=335000000000P
+ AD=455000000000P PS=2670000U PD=3910000U
* device instance $10 r0 *1 5.11,1.985 pfet_01v8_hvt
M$10 12 7 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=335000000000P
+ AD=280000000000P PS=2670000U PD=2560000U
* device instance $13 r0 *1 0.865,0.56 nfet_01v8
M$13 2 3 1 15 nfet_01v8 L=150000U W=2600000U AS=450125000000P AD=370500000000P
+ PS=4635000U PD=3740000U
* device instance $17 r0 *1 2.605,0.56 nfet_01v8
M$17 3 4 1 15 nfet_01v8 L=150000U W=1300000U AS=219375000000P AD=243750000000P
+ PS=1975000U PD=2050000U
* device instance $18 r0 *1 3.075,0.56 nfet_01v8
M$18 1 5 3 15 nfet_01v8 L=150000U W=1300000U AS=212875000000P AD=235625000000P
+ PS=1955000U PD=2025000U
* device instance $21 r0 *1 4.68,0.56 nfet_01v8
M$21 8 6 1 15 nfet_01v8 L=150000U W=650000U AS=139750000000P AD=91000000000P
+ PS=1080000U PD=930000U
* device instance $22 r0 *1 5.11,0.56 nfet_01v8
M$22 3 7 8 15 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $23 r0 *1 5.54,0.56 nfet_01v8
M$23 9 7 3 15 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $24 r0 *1 5.97,0.56 nfet_01v8
M$24 1 6 9 15 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=169000000000P
+ PS=930000U PD=1820000U
.ENDS sky130_fd_sc_hd__a211o_4

* cell sky130_fd_sc_hd__a311o_4
* pin VGND
* pin X
* pin C1
* pin B1
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a311o_4 1 3 6 7 8 9 10 13 14 15
* net 1 VGND
* net 3 X
* net 6 C1
* net 7 B1
* net 8 A3
* net 9 A2
* net 10 A1
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 6 11 14 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 12 7 11 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 2.67,1.985 pfet_01v8_hvt
M$5 3 2 13 14 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 4.35,1.985 pfet_01v8_hvt
M$9 12 8 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=300000000000P PS=2540000U PD=2600000U
* device instance $11 r0 *1 5.25,1.985 pfet_01v8_hvt
M$11 12 9 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=460000000000P PS=2600000U PD=2920000U
* device instance $13 r0 *1 6.47,1.985 pfet_01v8_hvt
M$13 12 10 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=460000000000P
+ AD=395000000000P PS=2920000U PD=3790000U
* device instance $15 r0 *1 5.63,0.56 nfet_01v8
M$15 4 9 5 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $17 r0 *1 6.47,0.56 nfet_01v8
M$17 2 10 5 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $19 r0 *1 0.47,0.56 nfet_01v8
M$19 2 6 1 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $21 r0 *1 1.31,0.56 nfet_01v8
M$21 2 7 1 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $23 r0 *1 2.15,0.56 nfet_01v8
M$23 3 2 1 15 nfet_01v8 L=150000U W=2600000U AS=357500000000P AD=481000000000P
+ PS=3700000U PD=4080000U
* device instance $27 r0 *1 4.23,0.56 nfet_01v8
M$27 4 8 1 15 nfet_01v8 L=150000U W=1300000U AS=299000000000P AD=256750000000P
+ PS=2220000U PD=2740000U
.ENDS sky130_fd_sc_hd__a311o_4

* cell sky130_fd_sc_hd__a221o_2
* pin VGND
* pin B1
* pin A1
* pin X
* pin C1
* pin B2
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221o_2 1 3 4 5 8 9 10 13 14 15
* net 1 VGND
* net 3 B1
* net 4 A1
* net 5 X
* net 8 C1
* net 9 B2
* net 10 A2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=165000000000P PS=2520000U PD=1330000U
* device instance $2 r0 *1 2.73,1.985 pfet_01v8_hvt
M$2 13 10 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=157500000000P PS=1330000U PD=1315000U
* device instance $3 r0 *1 3.195,1.985 pfet_01v8_hvt
M$3 5 2 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=292500000000P
+ AD=420000000000P PS=2585000U PD=3840000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 11 8 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $6 r0 *1 0.89,1.985 pfet_01v8_hvt
M$6 12 9 11 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 11 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $8 r0 *1 2.25,0.56 nfet_01v8
M$8 7 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 1 10 7 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=102375000000P
+ PS=980000U PD=965000U
* device instance $10 r0 *1 3.195,0.56 nfet_01v8
M$10 5 2 1 15 nfet_01v8 L=150000U W=1300000U AS=190125000000P AD=273000000000P
+ PS=1885000U PD=2790000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 8 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $13 r0 *1 0.95,0.56 nfet_01v8
M$13 6 9 1 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=68250000000P
+ PS=980000U PD=860000U
* device instance $14 r0 *1 1.31,0.56 nfet_01v8
M$14 2 3 6 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221o_2

* cell sky130_fd_sc_hd__nor3b_4
* pin VGND
* pin A
* pin B
* pin Y
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_4 1 2 3 4 5 7 10 11
* net 1 VGND
* net 2 A
* net 3 B
* net 4 Y
* net 5 C_N
* net 7 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.11,1.985 pfet_01v8_hvt
M$1 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 4.79,1.985 pfet_01v8_hvt
M$5 4 6 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 7 5 6 10 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=135000000000P PS=2560000U PD=1270000U
* device instance $10 r0 *1 0.91,1.985 pfet_01v8_hvt
M$10 8 2 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $14 r0 *1 0.49,0.56 nfet_01v8
M$14 1 5 6 11 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $15 r0 *1 0.91,0.56 nfet_01v8
M$15 4 2 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $19 r0 *1 3.11,0.56 nfet_01v8
M$19 4 3 1 11 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $23 r0 *1 4.79,0.56 nfet_01v8
M$23 4 6 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor3b_4

* cell sky130_fd_sc_hd__nor4b_4
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_4 1 3 4 6 7 8 9 12 13
* net 1 VGND
* net 3 Y
* net 4 A
* net 6 B
* net 7 C
* net 8 D_N
* net 9 VPWR
* net 12 VPB
* device instance $1 r0 *1 8.23,1.985 pfet_01v8_hvt
M$1 9 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=280000000000P PS=2520000U PD=2560000U
* device instance $2 r0 *1 4.35,1.985 pfet_01v8_hvt
M$2 10 7 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $6 r0 *1 6.03,1.985 pfet_01v8_hvt
M$6 3 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $10 r0 *1 0.47,1.985 pfet_01v8_hvt
M$10 9 4 5 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $14 r0 *1 2.15,1.985 pfet_01v8_hvt
M$14 10 6 5 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $18 r0 *1 0.47,0.56 nfet_01v8
M$18 3 4 1 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $22 r0 *1 2.15,0.56 nfet_01v8
M$22 3 6 1 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $26 r0 *1 4.35,0.56 nfet_01v8
M$26 3 7 1 13 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $30 r0 *1 6.03,0.56 nfet_01v8
M$30 3 2 1 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $34 r0 *1 8.23,0.56 nfet_01v8
M$34 1 8 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=182000000000P
+ PS=1820000U PD=1860000U
.ENDS sky130_fd_sc_hd__nor4b_4

* cell sky130_fd_sc_hd__o211a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211a_1 1 2 5 6 7 8 10 11 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 B1
* net 8 C1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 12 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=162500000000P PS=2520000U PD=1325000U
* device instance $2 r0 *1 1.885,1.985 pfet_01v8_hvt
M$2 4 6 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=220000000000P PS=1325000U PD=1440000U
* device instance $3 r0 *1 2.475,1.985 pfet_01v8_hvt
M$3 10 7 4 11 pfet_01v8_hvt L=150000U W=1000000U AS=220000000000P
+ AD=175000000000P PS=1440000U PD=1350000U
* device instance $4 r0 *1 2.975,1.985 pfet_01v8_hvt
M$4 4 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=300000000000P PS=1350000U PD=2600000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 1.885,0.56 nfet_01v8
M$7 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=143000000000P
+ PS=975000U PD=1090000U
* device instance $8 r0 *1 2.475,0.56 nfet_01v8
M$8 9 7 3 13 nfet_01v8 L=150000U W=650000U AS=143000000000P AD=113750000000P
+ PS=1090000U PD=1000000U
* device instance $9 r0 *1 2.975,0.56 nfet_01v8
M$9 4 8 9 13 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=195000000000P
+ PS=1000000U PD=1900000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o211a_1

* cell sky130_fd_sc_hd__o22a_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22a_1 1 2 3 4 5 6 7 10 11
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 6 X
* net 7 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=372500000000P PS=2560000U PD=1745000U
* device instance $2 r0 *1 1.385,1.985 pfet_01v8_hvt
M$2 13 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=372500000000P
+ AD=117500000000P PS=1745000U PD=1235000U
* device instance $3 r0 *1 1.77,1.985 pfet_01v8_hvt
M$3 8 3 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=117500000000P
+ AD=235000000000P PS=1235000U PD=1470000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=235000000000P
+ AD=105000000000P PS=1470000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 8 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.83,0.56 nfet_01v8
M$7 9 3 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 7 4 9 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=87750000000P
+ PS=1000000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 9 5 7 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 7 8 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22a_1

* cell sky130_fd_sc_hd__o41ai_1
* pin VGND
* pin Y
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o41ai_1 1 2 4 5 6 7 8 9 10 14
* net 1 VGND
* net 2 Y
* net 4 B1
* net 5 A4
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=312500000000P PS=1270000U PD=1625000U
* device instance $3 r0 *1 1.665,1.985 pfet_01v8_hvt
M$3 13 6 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=312500000000P
+ AD=135000000000P PS=1625000U PD=1270000U
* device instance $4 r0 *1 2.085,1.985 pfet_01v8_hvt
M$4 12 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=175000000000P PS=1270000U PD=1350000U
* device instance $5 r0 *1 2.585,1.985 pfet_01v8_hvt
M$5 9 8 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=280000000000P PS=1350000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 3 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=203125000000P
+ PS=1820000U PD=1275000U
* device instance $7 r0 *1 1.245,0.56 nfet_01v8
M$7 1 5 3 14 nfet_01v8 L=150000U W=650000U AS=203125000000P AD=87750000000P
+ PS=1275000U PD=920000U
* device instance $8 r0 *1 1.665,0.56 nfet_01v8
M$8 3 6 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 2.085,0.56 nfet_01v8
M$9 1 7 3 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $10 r0 *1 2.585,0.56 nfet_01v8
M$10 3 8 1 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=182000000000P
+ PS=1000000U PD=1860000U
.ENDS sky130_fd_sc_hd__o41ai_1

* cell sky130_fd_sc_hd__nor4_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_2 1 2 3 4 5 6 8 11 12
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 5 C
* net 6 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.57,1.985 pfet_01v8_hvt
M$3 2 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 8 3 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 9 4 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.57,0.56 nfet_01v8
M$11 2 6 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 2 3 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $15 r0 *1 1.33,0.56 nfet_01v8
M$15 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nor4_2

* cell sky130_fd_sc_hd__or4_1
* pin VPB
* pin A
* pin B
* pin C
* pin D
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or4_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 D
* net 7 X
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 13 5 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $2 r0 *1 0.95,1.695 pfet_01v8_hvt
M$2 12 4 13 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $3 r0 *1 1.31,1.695 pfet_01v8_hvt
M$3 11 3 12 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $4 r0 *1 1.79,1.695 pfet_01v8_hvt
M$4 8 2 11 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $5 r0 *1 2.28,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=270000000000P PS=1340000U PD=2540000U
* device instance $6 r0 *1 0.47,0.475 nfet_01v8
M$6 6 5 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $7 r0 *1 0.95,0.475 nfet_01v8
M$7 9 4 6 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $8 r0 *1 1.37,0.475 nfet_01v8
M$8 6 3 9 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $9 r0 *1 1.79,0.475 nfet_01v8
M$9 6 2 9 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $10 r0 *1 2.28,0.56 nfet_01v8
M$10 7 6 9 10 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=175500000000P
+ PS=990000U PD=1840000U
.ENDS sky130_fd_sc_hd__or4_1

* cell sky130_fd_sc_hd__nand4_2
* pin VGND
* pin D
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4_2 1 5 6 7 8 9 10 11 12
* net 1 VGND
* net 5 D
* net 6 C
* net 7 B
* net 8 A
* net 9 VPWR
* net 10 Y
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=350000000000P PS=2540000U PD=2700000U
* device instance $5 r0 *1 2.31,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=350000000000P
+ AD=470000000000P PS=2700000U PD=2940000U
* device instance $7 r0 *1 3.55,1.985 pfet_01v8_hvt
M$7 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=470000000000P
+ AD=555000000000P PS=2940000U PD=4110000U
* device instance $9 r0 *1 2.71,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.55,0.56 nfet_01v8
M$11 10 8 4 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=321750000000P
+ PS=1840000U PD=2940000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nand4_2

* cell sky130_fd_sc_hd__o311ai_4
* pin VGND
* pin A1
* pin A2
* pin A3
* pin B1
* pin C1
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_4 1 2 4 5 7 8 10 12 13 14
* net 1 VGND
* net 2 A1
* net 4 A2
* net 5 A3
* net 7 B1
* net 8 C1
* net 10 VPWR
* net 12 Y
* net 13 VPB
* device instance $1 r0 *1 4.43,1.985 pfet_01v8_hvt
M$1 11 5 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=550000000000P PS=6330000U PD=5100000U
* device instance $5 r0 *1 6.13,1.985 pfet_01v8_hvt
M$5 10 7 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=550000000000P
+ AD=540000000000P PS=5100000U PD=5080000U
* device instance $9 r0 *1 7.81,1.985 pfet_01v8_hvt
M$9 10 8 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 0.55,1.985 pfet_01v8_hvt
M$13 10 2 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $17 r0 *1 2.23,1.985 pfet_01v8_hvt
M$17 11 4 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 6.17,0.56 nfet_01v8
M$21 3 7 6 14 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $25 r0 *1 7.85,0.56 nfet_01v8
M$25 12 8 6 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=445250000000P
+ PS=3680000U PD=4620000U
* device instance $29 r0 *1 0.55,0.56 nfet_01v8
M$29 3 2 1 14 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $33 r0 *1 2.23,0.56 nfet_01v8
M$33 3 4 1 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=357500000000P
+ PS=3680000U PD=3700000U
* device instance $37 r0 *1 3.93,0.56 nfet_01v8
M$37 3 5 1 14 nfet_01v8 L=150000U W=2600000U AS=357500000000P AD=445250000000P
+ PS=3700000U PD=4620000U
.ENDS sky130_fd_sc_hd__o311ai_4

* cell sky130_fd_sc_hd__a32oi_4
* pin VGND
* pin B2
* pin B1
* pin A2
* pin Y
* pin A1
* pin A3
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a32oi_4 1 2 3 4 6 7 10 12 13 14
* net 1 VGND
* net 2 B2
* net 3 B1
* net 4 A2
* net 6 Y
* net 7 A1
* net 10 A3
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 2 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 6 3 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=550000000000P PS=5080000U PD=5100000U
* device instance $9 r0 *1 3.85,1.985 pfet_01v8_hvt
M$9 12 7 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=752500000000P
+ AD=860000000000P PS=5505000U PD=5720000U
* device instance $13 r0 *1 6.17,1.985 pfet_01v8_hvt
M$13 12 4 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=657500000000P
+ AD=800000000000P PS=5315000U PD=5600000U
* device instance $17 r0 *1 8.37,1.985 pfet_01v8_hvt
M$17 12 10 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=665000000000P PS=5600000U PD=6330000U
* device instance $21 r0 *1 8.37,0.56 nfet_01v8
M$21 9 10 1 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $25 r0 *1 0.47,0.56 nfet_01v8
M$25 1 2 5 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 2.15,0.56 nfet_01v8
M$29 6 3 5 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $33 r0 *1 4.35,0.56 nfet_01v8
M$33 6 7 8 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=396500000000P
+ PS=4580000U PD=3820000U
* device instance $37 r0 *1 6.17,0.56 nfet_01v8
M$37 9 4 8 14 nfet_01v8 L=150000U W=2600000U AS=396500000000P AD=432250000000P
+ PS=3820000U PD=4580000U
.ENDS sky130_fd_sc_hd__a32oi_4

* cell sky130_fd_sc_hd__o2111a_1
* pin VGND
* pin X
* pin C1
* pin B1
* pin D1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2111a_1 1 2 4 5 7 8 9 12 13 14
* net 1 VGND
* net 2 X
* net 4 C1
* net 5 B1
* net 7 D1
* net 8 A2
* net 9 A1
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 3 2 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=382500000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,1.985 pfet_01v8_hvt
M$2 3 7 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=382500000000P
+ AD=217500000000P PS=1765000U PD=1435000U
* device instance $3 r0 *1 1.97,1.985 pfet_01v8_hvt
M$3 12 4 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=217500000000P
+ AD=305000000000P PS=1435000U PD=1610000U
* device instance $4 r0 *1 2.73,1.985 pfet_01v8_hvt
M$4 3 5 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=212500000000P PS=1610000U PD=1425000U
* device instance $5 r0 *1 3.305,1.985 pfet_01v8_hvt
M$5 15 8 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=105000000000P PS=1425000U PD=1210000U
* device instance $6 r0 *1 3.665,1.985 pfet_01v8_hvt
M$6 12 9 15 13 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=265000000000P PS=1210000U PD=2530000U
* device instance $7 r0 *1 1.455,0.56 nfet_01v8
M$7 11 7 3 14 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=118625000000P
+ PS=1910000U PD=1015000U
* device instance $8 r0 *1 1.97,0.56 nfet_01v8
M$8 10 4 11 14 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=118625000000P
+ PS=1015000U PD=1015000U
* device instance $9 r0 *1 2.485,0.56 nfet_01v8
M$9 6 5 10 14 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=198250000000P
+ PS=1015000U PD=1260000U
* device instance $10 r0 *1 3.245,0.56 nfet_01v8
M$10 1 8 6 14 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=87750000000P
+ PS=1260000U PD=920000U
* device instance $11 r0 *1 3.665,0.56 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=172250000000P
+ PS=920000U PD=1830000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 3 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o2111a_1

* cell sky130_fd_sc_hd__a31o_1
* pin VGND
* pin X
* pin A3
* pin A2
* pin A1
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31o_1 1 2 6 7 8 9 11 12 13
* net 1 VGND
* net 2 X
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 B1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 3 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=172500000000P PS=2530000U PD=1345000U
* device instance $2 r0 *1 0.97,1.985 pfet_01v8_hvt
M$2 10 6 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=160000000000P PS=1345000U PD=1320000U
* device instance $3 r0 *1 1.44,1.985 pfet_01v8_hvt
M$3 11 7 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=165000000000P PS=1320000U PD=1330000U
* device instance $4 r0 *1 1.92,1.985 pfet_01v8_hvt
M$4 10 8 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $5 r0 *1 2.4,1.985 pfet_01v8_hvt
M$5 3 9 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=320000000000P PS=1330000U PD=2640000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=112125000000P
+ PS=1830000U PD=995000U
* device instance $7 r0 *1 0.97,0.56 nfet_01v8
M$7 4 6 1 13 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=104000000000P
+ PS=995000U PD=970000U
* device instance $8 r0 *1 1.44,0.56 nfet_01v8
M$8 5 7 4 13 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=107250000000P
+ PS=970000U PD=980000U
* device instance $9 r0 *1 1.92,0.56 nfet_01v8
M$9 3 8 5 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.4,0.56 nfet_01v8
M$10 1 9 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=208000000000P
+ PS=980000U PD=1940000U
.ENDS sky130_fd_sc_hd__a31o_1

* cell sky130_fd_sc_hd__nand2b_2
* pin VGND
* pin Y
* pin A_N
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_2 1 4 5 6 7 8 9
* net 1 VGND
* net 4 Y
* net 5 A_N
* net 6 B
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 5 2 8 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=146800000000P
+ PS=1360000U PD=1340000U
* device instance $2 r0 *1 0.96,1.985 pfet_01v8_hvt
M$2 4 2 7 8 pfet_01v8_hvt L=150000U W=2000000U AS=311800000000P
+ AD=500000000000P PS=2670000U PD=3000000U
* device instance $4 r0 *1 2.26,1.985 pfet_01v8_hvt
M$4 4 6 7 8 pfet_01v8_hvt L=150000U W=2000000U AS=470000000000P
+ AD=410000000000P PS=2940000U PD=3820000U
* device instance $6 r0 *1 1.48,0.56 nfet_01v8
M$6 4 2 3 9 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $8 r0 *1 2.32,0.56 nfet_01v8
M$8 1 6 3 9 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 2 5 1 9 nfet_01v8 L=150000U W=420000U AS=194000000000P AD=109200000000P
+ PS=1950000U PD=1360000U
.ENDS sky130_fd_sc_hd__nand2b_2

* cell sky130_fd_sc_hd__o31a_2
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31a_2 1 2 5 6 7 8 9 10 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.615,1.985 pfet_01v8_hvt
M$1 2 4 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=580000000000P
+ AD=370000000000P PS=4160000U PD=2740000U
* device instance $3 r0 *1 1.655,1.985 pfet_01v8_hvt
M$3 11 5 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=135000000000P PS=1390000U PD=1270000U
* device instance $4 r0 *1 2.075,1.985 pfet_01v8_hvt
M$4 12 6 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $5 r0 *1 2.555,1.985 pfet_01v8_hvt
M$5 4 7 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=212500000000P PS=1330000U PD=1425000U
* device instance $6 r0 *1 3.13,1.985 pfet_01v8_hvt
M$6 9 8 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=340000000000P PS=1425000U PD=2680000U
* device instance $7 r0 *1 0.615,0.56 nfet_01v8
M$7 2 4 1 13 nfet_01v8 L=150000U W=1300000U AS=377000000000P AD=240500000000P
+ PS=3110000U PD=2040000U
* device instance $9 r0 *1 1.655,0.56 nfet_01v8
M$9 3 5 1 13 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $10 r0 *1 2.075,0.56 nfet_01v8
M$10 1 6 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $11 r0 *1 2.555,0.56 nfet_01v8
M$11 3 7 1 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $12 r0 *1 3.035,0.56 nfet_01v8
M$12 4 8 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=201500000000P
+ PS=980000U PD=1920000U
.ENDS sky130_fd_sc_hd__o31a_2

* cell sky130_fd_sc_hd__a41o_1
* pin VGND
* pin X
* pin A2
* pin A3
* pin B1
* pin A1
* pin A4
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41o_1 1 2 4 5 6 7 8 12 13 15
* net 1 VGND
* net 2 X
* net 4 A2
* net 5 A3
* net 6 B1
* net 7 A1
* net 8 A4
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 14 6 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 1.83,1.985 pfet_01v8_hvt
M$2 12 7 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.25,1.985 pfet_01v8_hvt
M$3 14 4 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.73,1.985 pfet_01v8_hvt
M$4 12 5 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $5 r0 *1 3.21,1.985 pfet_01v8_hvt
M$5 14 8 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 12 3 2 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=160875000000P
+ PS=1820000U PD=1145000U
* device instance $8 r0 *1 1.115,0.56 nfet_01v8
M$8 3 6 1 15 nfet_01v8 L=150000U W=650000U AS=160875000000P AD=183625000000P
+ PS=1145000U PD=1215000U
* device instance $9 r0 *1 1.83,0.56 nfet_01v8
M$9 10 7 3 15 nfet_01v8 L=150000U W=650000U AS=183625000000P AD=87750000000P
+ PS=1215000U PD=920000U
* device instance $10 r0 *1 2.25,0.56 nfet_01v8
M$10 9 4 10 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $11 r0 *1 2.73,0.56 nfet_01v8
M$11 11 5 9 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 1 8 11 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a41o_1

* cell sky130_fd_sc_hd__or3b_1
* pin VPB
* pin A
* pin B
* pin C_N
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3b_1 1 2 3 5 6 7 8 10
* net 1 VPB
* net 2 A
* net 3 B
* net 5 C_N
* net 6 X
* net 7 VPWR
* net 8 VGND
* device instance $1 r0 *1 1.41,1.695 pfet_01v8_hvt
M$1 11 4 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.77,1.695 pfet_01v8_hvt
M$2 12 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=68250000000P
+ PS=630000U PD=745000U
* device instance $3 r0 *1 2.245,1.695 pfet_01v8_hvt
M$3 7 2 12 1 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=148250000000P
+ PS=745000U PD=1340000U
* device instance $4 r0 *1 2.735,1.985 pfet_01v8_hvt
M$4 6 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=275000000000P PS=1340000U PD=2550000U
* device instance $5 r0 *1 0.47,1.695 pfet_01v8_hvt
M$5 4 5 7 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.41,0.475 nfet_01v8
M$6 8 4 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $7 r0 *1 1.83,0.475 nfet_01v8
M$7 9 3 8 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 2.25,0.475 nfet_01v8
M$8 9 2 8 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=56700000000P
+ PS=985000U PD=690000U
* device instance $9 r0 *1 2.735,0.56 nfet_01v8
M$9 6 9 8 10 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=178750000000P
+ PS=985000U PD=1850000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or3b_1

* cell sky130_fd_sc_hd__or2_4
* pin VPB
* pin A
* pin B
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or2_4 1 2 3 4 5 6 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 VGND
* net 5 VPWR
* net 6 X
* device instance $1 r0 *1 0.53,1.985 pfet_01v8_hvt
M$1 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=105000000000P PS=2560000U PD=1210000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 5 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=177500000000P PS=1210000U PD=1355000U
* device instance $3 r0 *1 1.395,1.985 pfet_01v8_hvt
M$3 6 7 5 1 pfet_01v8_hvt L=150000U W=4000000U AS=582500000000P
+ AD=685000000000P PS=5165000U PD=6370000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 7 3 4 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 0.89,0.56 nfet_01v8
M$8 4 2 7 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=115375000000P
+ PS=920000U PD=1005000U
* device instance $9 r0 *1 1.395,0.56 nfet_01v8
M$9 6 7 4 8 nfet_01v8 L=150000U W=2600000U AS=378625000000P AD=432250000000P
+ PS=3765000U PD=4580000U
.ENDS sky130_fd_sc_hd__or2_4

* cell sky130_fd_sc_hd__a21boi_2
* pin VGND
* pin B1_N
* pin Y
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_2 1 2 4 5 6 9 10 12
* net 1 VGND
* net 2 B1_N
* net 4 Y
* net 5 A2
* net 6 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 4 3 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 2.26,1.985 pfet_01v8_hvt
M$3 9 5 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=275000000000P
+ AD=420000000000P PS=2550000U PD=3840000U
* device instance $4 r0 *1 2.68,1.985 pfet_01v8_hvt
M$4 11 6 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=275000000000P
+ AD=280000000000P PS=2550000U PD=2560000U
* device instance $7 r0 *1 0.475,2.1 pfet_01v8_hvt
M$7 3 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P
+ AD=111300000000P PS=1370000U PD=1370000U
* device instance $8 r0 *1 0.68,0.445 nfet_01v8
M$8 1 2 3 12 nfet_01v8 L=150000U W=420000U AS=126000000000P AD=183125000000P
+ PS=1440000U PD=1240000U
* device instance $9 r0 *1 1.42,0.56 nfet_01v8
M$9 4 3 1 12 nfet_01v8 L=150000U W=1300000U AS=270875000000P AD=195000000000P
+ PS=2160000U PD=1900000U
* device instance $11 r0 *1 2.32,0.56 nfet_01v8
M$11 8 5 1 12 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=68250000000P
+ PS=980000U PD=860000U
* device instance $12 r0 *1 2.68,0.56 nfet_01v8
M$12 4 6 8 12 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=91000000000P
+ PS=860000U PD=930000U
* device instance $13 r0 *1 3.11,0.56 nfet_01v8
M$13 7 6 4 12 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $14 r0 *1 3.54,0.56 nfet_01v8
M$14 1 5 7 12 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=185250000000P
+ PS=930000U PD=1870000U
.ENDS sky130_fd_sc_hd__a21boi_2

* cell sky130_fd_sc_hd__o2bb2ai_1
* pin VPB
* pin A1_N
* pin A2_N
* pin B2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2bb2ai_1 1 2 3 4 5 6 8 10 11
* net 1 VPB
* net 2 A1_N
* net 3 A2_N
* net 4 B2
* net 5 B1
* net 6 VPWR
* net 8 Y
* net 10 VGND
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=275000000000P
+ AD=135000000000P PS=2550000U PD=1270000U
* device instance $2 r0 *1 0.905,1.985 pfet_01v8_hvt
M$2 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=420000000000P PS=1270000U PD=1840000U
* device instance $3 r0 *1 1.895,1.985 pfet_01v8_hvt
M$3 8 7 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=420000000000P
+ AD=135000000000P PS=1840000U PD=1270000U
* device instance $4 r0 *1 2.315,1.985 pfet_01v8_hvt
M$4 13 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 6 5 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=275000000000P PS=1270000U PD=2550000U
* device instance $6 r0 *1 1.895,0.56 nfet_01v8
M$6 9 7 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.315,0.56 nfet_01v8
M$7 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 2.735,0.56 nfet_01v8
M$8 9 5 10 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.485,0.56 nfet_01v8
M$9 12 2 10 11 nfet_01v8 L=150000U W=650000U AS=178750000000P AD=68250000000P
+ PS=1850000U PD=860000U
* device instance $10 r0 *1 0.845,0.56 nfet_01v8
M$10 7 3 12 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=240500000000P
+ PS=860000U PD=2040000U
.ENDS sky130_fd_sc_hd__o2bb2ai_1

* cell sky130_fd_sc_hd__o221a_1
* pin VGND
* pin X
* pin C1
* pin B1
* pin B2
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o221a_1 1 5 6 7 8 9 10 11 12 15
* net 1 VGND
* net 5 X
* net 6 C1
* net 7 B1
* net 8 B2
* net 9 A2
* net 10 A1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.67,1.985 pfet_01v8_hvt
M$1 11 6 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=340000000000P
+ AD=165000000000P PS=2680000U PD=1330000U
* device instance $2 r0 *1 1.15,1.985 pfet_01v8_hvt
M$2 13 7 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=105000000000P PS=1330000U PD=1210000U
* device instance $3 r0 *1 1.51,1.985 pfet_01v8_hvt
M$3 2 8 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=412500000000P PS=1210000U PD=1825000U
* device instance $4 r0 *1 2.485,1.985 pfet_01v8_hvt
M$4 14 9 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=412500000000P
+ AD=105000000000P PS=1825000U PD=1210000U
* device instance $5 r0 *1 2.845,1.985 pfet_01v8_hvt
M$5 11 10 14 12 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $6 r0 *1 3.325,1.985 pfet_01v8_hvt
M$6 5 2 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=280000000000P PS=1330000U PD=2560000U
* device instance $7 r0 *1 2.485,0.56 nfet_01v8
M$7 4 9 1 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.905,0.56 nfet_01v8
M$8 1 10 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 3.325,0.56 nfet_01v8
M$9 5 2 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
* device instance $10 r0 *1 0.67,0.56 nfet_01v8
M$10 3 6 2 15 nfet_01v8 L=150000U W=650000U AS=201500000000P AD=99125000000P
+ PS=1920000U PD=955000U
* device instance $11 r0 *1 1.125,0.56 nfet_01v8
M$11 4 7 3 15 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=87750000000P
+ PS=955000U PD=920000U
* device instance $12 r0 *1 1.545,0.56 nfet_01v8
M$12 3 8 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221a_1

* cell sky130_fd_sc_hd__o32a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B2
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32a_1 1 2 5 6 7 8 9 10 11 15
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B2
* net 9 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=335000000000P
+ AD=135000000000P PS=2670000U PD=1270000U
* device instance $2 r0 *1 1.06,1.985 pfet_01v8_hvt
M$2 13 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.54,1.985 pfet_01v8_hvt
M$3 12 6 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=195000000000P PS=1330000U PD=1390000U
* device instance $4 r0 *1 2.08,1.985 pfet_01v8_hvt
M$4 4 7 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $5 r0 *1 2.62,1.985 pfet_01v8_hvt
M$5 14 8 4 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=205000000000P PS=1390000U PD=1410000U
* device instance $6 r0 *1 3.18,1.985 pfet_01v8_hvt
M$6 10 9 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=290000000000P PS=1410000U PD=2580000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 1 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 1.06,0.56 nfet_01v8
M$8 3 5 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 1.54,0.56 nfet_01v8
M$9 1 6 3 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=126750000000P
+ PS=980000U PD=1040000U
* device instance $10 r0 *1 2.08,0.56 nfet_01v8
M$10 3 7 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 2.62,0.56 nfet_01v8
M$11 4 8 3 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=133250000000P
+ PS=1040000U PD=1060000U
* device instance $12 r0 *1 3.18,0.56 nfet_01v8
M$12 3 9 4 15 nfet_01v8 L=150000U W=650000U AS=133250000000P AD=188500000000P
+ PS=1060000U PD=1880000U
.ENDS sky130_fd_sc_hd__o32a_1

* cell sky130_fd_sc_hd__a311o_2
* pin VGND
* pin X
* pin A3
* pin A2
* pin A1
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a311o_2 1 2 6 7 8 9 10 11 13 15
* net 1 VGND
* net 2 X
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 B1
* net 10 C1
* net 11 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=375000000000P PS=3790000U PD=2750000U
* device instance $3 r0 *1 1.52,1.985 pfet_01v8_hvt
M$3 12 6 11 13 pfet_01v8_hvt L=150000U W=1000000U AS=240000000000P
+ AD=170000000000P PS=1480000U PD=1340000U
* device instance $4 r0 *1 2.01,1.985 pfet_01v8_hvt
M$4 11 7 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=170000000000P
+ AD=185000000000P PS=1340000U PD=1370000U
* device instance $5 r0 *1 2.53,1.985 pfet_01v8_hvt
M$5 12 8 11 13 pfet_01v8_hvt L=150000U W=1000000U AS=185000000000P
+ AD=210000000000P PS=1370000U PD=1420000U
* device instance $6 r0 *1 3.1,1.985 pfet_01v8_hvt
M$6 14 9 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=210000000000P
+ AD=210000000000P PS=1420000U PD=1420000U
* device instance $7 r0 *1 3.67,1.985 pfet_01v8_hvt
M$7 3 10 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=210000000000P
+ AD=260000000000P PS=1420000U PD=2520000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 2 3 1 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=243750000000P
+ PS=2740000U PD=2050000U
* device instance $10 r0 *1 1.52,0.56 nfet_01v8
M$10 5 6 1 15 nfet_01v8 L=150000U W=650000U AS=156000000000P AD=110500000000P
+ PS=1130000U PD=990000U
* device instance $11 r0 *1 2.01,0.56 nfet_01v8
M$11 4 7 5 15 nfet_01v8 L=150000U W=650000U AS=110500000000P AD=120250000000P
+ PS=990000U PD=1020000U
* device instance $12 r0 *1 2.53,0.56 nfet_01v8
M$12 3 8 4 15 nfet_01v8 L=150000U W=650000U AS=120250000000P AD=133250000000P
+ PS=1020000U PD=1060000U
* device instance $13 r0 *1 3.09,0.56 nfet_01v8
M$13 1 9 3 15 nfet_01v8 L=150000U W=650000U AS=133250000000P AD=139750000000P
+ PS=1060000U PD=1080000U
* device instance $14 r0 *1 3.67,0.56 nfet_01v8
M$14 3 10 1 15 nfet_01v8 L=150000U W=650000U AS=139750000000P AD=169000000000P
+ PS=1080000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311o_2

* cell sky130_fd_sc_hd__or3_2
* pin VPB
* pin B
* pin A
* pin C
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or3_2 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 C
* net 5 VPWR
* net 6 VGND
* net 7 X
* device instance $1 r0 *1 0.485,1.695 pfet_01v8_hvt
M$1 11 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.845,1.695 pfet_01v8_hvt
M$2 10 2 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $3 r0 *1 1.325,1.695 pfet_01v8_hvt
M$3 5 3 10 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $4 r0 *1 1.815,1.985 pfet_01v8_hvt
M$4 7 8 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=283250000000P
+ AD=450000000000P PS=2610000U PD=3900000U
* device instance $6 r0 *1 0.485,0.475 nfet_01v8
M$6 6 4 8 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $7 r0 *1 0.905,0.475 nfet_01v8
M$7 8 2 6 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 1.325,0.475 nfet_01v8
M$8 8 3 6 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $9 r0 *1 1.815,0.56 nfet_01v8
M$9 7 8 6 9 nfet_01v8 L=150000U W=1300000U AS=189625000000P AD=273000000000P
+ PS=1910000U PD=2790000U
.ENDS sky130_fd_sc_hd__or3_2

* cell sky130_fd_sc_hd__a21o_4
* pin VGND
* pin X
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a21o_4 1 3 4 5 6 9 11 12
* net 1 VGND
* net 3 X
* net 4 B1
* net 5 A2
* net 6 A1
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.75,1.985 pfet_01v8_hvt
M$1 2 4 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 3.59,1.985 pfet_01v8_hvt
M$3 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=530000000000P PS=2540000U PD=4060000U
* device instance $4 r0 *1 4.01,1.985 pfet_01v8_hvt
M$4 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $7 r0 *1 0.495,1.985 pfet_01v8_hvt
M$7 3 2 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=705000000000P
+ AD=705000000000P PS=6410000U PD=6410000U
* device instance $11 r0 *1 0.495,0.56 nfet_01v8
M$11 3 2 1 12 nfet_01v8 L=150000U W=2600000U AS=458250000000P AD=537875000000P
+ PS=4660000U PD=4255000U
* device instance $15 r0 *1 2.75,0.56 nfet_01v8
M$15 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=352625000000P AD=188500000000P
+ PS=2385000U PD=1880000U
* device instance $17 r0 *1 3.63,0.56 nfet_01v8
M$17 8 5 1 12 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=74750000000P
+ PS=960000U PD=880000U
* device instance $18 r0 *1 4.01,0.56 nfet_01v8
M$18 2 6 8 12 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=87750000000P
+ PS=880000U PD=920000U
* device instance $19 r0 *1 4.43,0.56 nfet_01v8
M$19 7 6 2 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $20 r0 *1 4.85,0.56 nfet_01v8
M$20 1 5 7 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__a21o_4

* cell sky130_fd_sc_hd__a21boi_1
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_1 1 2 3 4 6 7 9 10
* net 1 VPB
* net 2 B1_N
* net 3 A1
* net 4 A2
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 1.425,1.985 pfet_01v8_hvt
M$1 8 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.855,1.985 pfet_01v8_hvt
M$2 6 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 2.285,1.985 pfet_01v8_hvt
M$3 8 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.475,2.275 pfet_01v8_hvt
M$4 6 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=111300000000P
+ PS=1370000U PD=1370000U
* device instance $5 r0 *1 0.765,0.445 nfet_01v8
M$5 7 2 5 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=101875000000P
+ PS=1370000U PD=990000U
* device instance $6 r0 *1 1.255,0.56 nfet_01v8
M$6 9 5 7 10 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=143000000000P
+ PS=990000U PD=1090000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 3 9 10 nfet_01v8 L=150000U W=650000U AS=143000000000P AD=91000000000P
+ PS=1090000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 7 4 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21boi_1

* cell sky130_fd_sc_hd__a2111oi_0
* pin VGND
* pin D1
* pin Y
* pin A1
* pin C1
* pin B1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_0 1 2 3 4 6 7 8 9 10 14
* net 1 VGND
* net 2 D1
* net 3 Y
* net 4 A1
* net 6 C1
* net 7 B1
* net 8 A2
* net 9 VPB
* net 10 VPWR
* device instance $1 r0 *1 0.77,2.165 pfet_01v8_hvt
M$1 12 2 3 9 pfet_01v8_hvt L=150000U W=640000U AS=188800000000P AD=67200000000P
+ PS=1870000U PD=850000U
* device instance $2 r0 *1 1.13,2.165 pfet_01v8_hvt
M$2 13 6 12 9 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P AD=67200000000P
+ PS=850000U PD=850000U
* device instance $3 r0 *1 1.49,2.165 pfet_01v8_hvt
M$3 11 7 13 9 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P AD=89600000000P
+ PS=850000U PD=920000U
* device instance $4 r0 *1 1.92,2.165 pfet_01v8_hvt
M$4 10 4 11 9 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P
+ AD=121600000000P PS=920000U PD=1020000U
* device instance $5 r0 *1 2.45,2.165 pfet_01v8_hvt
M$5 11 8 10 9 pfet_01v8_hvt L=150000U W=640000U AS=121600000000P
+ AD=195200000000P PS=1020000U PD=1890000U
* device instance $6 r0 *1 0.7,0.445 nfet_01v8
M$6 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=126000000000P AD=58800000000P
+ PS=1440000U PD=700000U
* device instance $7 r0 *1 1.13,0.445 nfet_01v8
M$7 1 6 3 14 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=73500000000P
+ PS=700000U PD=770000U
* device instance $8 r0 *1 1.63,0.445 nfet_01v8
M$8 3 7 1 14 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=58800000000P
+ PS=770000U PD=700000U
* device instance $9 r0 *1 2.06,0.445 nfet_01v8
M$9 5 4 3 14 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=44100000000P
+ PS=700000U PD=630000U
* device instance $10 r0 *1 2.42,0.445 nfet_01v8
M$10 1 8 5 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=119700000000P
+ PS=630000U PD=1410000U
.ENDS sky130_fd_sc_hd__a2111oi_0

* cell sky130_fd_sc_hd__nor4_4
* pin VGND
* pin C
* pin Y
* pin A
* pin B
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_4 1 2 3 4 6 7 8 11 12
* net 1 VGND
* net 2 C
* net 3 Y
* net 4 A
* net 6 B
* net 7 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.37,1.985 pfet_01v8_hvt
M$1 9 2 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.05,1.985 pfet_01v8_hvt
M$5 3 7 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 8 4 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $13 r0 *1 2.17,1.985 pfet_01v8_hvt
M$13 9 6 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 3 4 1 12 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $21 r0 *1 2.17,0.56 nfet_01v8
M$21 3 6 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $25 r0 *1 4.37,0.56 nfet_01v8
M$25 3 2 1 12 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $29 r0 *1 6.05,0.56 nfet_01v8
M$29 3 7 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor4_4

* cell sky130_fd_sc_hd__and4_1
* pin VPB
* pin D
* pin C
* pin B
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and4_1 1 3 4 5 6 7 8 9 10
* net 1 VPB
* net 3 D
* net 4 C
* net 5 B
* net 6 A
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 2 6 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=73500000000P
+ PS=1360000U PD=770000U
* device instance $2 r0 *1 0.97,2.275 pfet_01v8_hvt
M$2 8 5 2 1 pfet_01v8_hvt L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $3 r0 *1 1.49,2.275 pfet_01v8_hvt
M$3 2 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=77700000000P AD=58800000000P
+ PS=790000U PD=700000U
* device instance $4 r0 *1 1.92,2.275 pfet_01v8_hvt
M$4 2 3 8 1 pfet_01v8_hvt L=150000U W=420000U AS=312450000000P AD=58800000000P
+ PS=1680000U PD=700000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=312450000000P
+ AD=260000000000P PS=1680000U PD=2520000U
* device instance $6 r0 *1 0.47,0.445 nfet_01v8
M$6 13 6 2 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $7 r0 *1 0.91,0.445 nfet_01v8
M$7 11 5 13 10 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=79800000000P
+ PS=710000U PD=800000U
* device instance $8 r0 *1 1.44,0.445 nfet_01v8
M$8 12 4 11 10 nfet_01v8 L=150000U W=420000U AS=79800000000P AD=69300000000P
+ PS=800000U PD=750000U
* device instance $9 r0 *1 1.92,0.445 nfet_01v8
M$9 7 3 12 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=196275000000P
+ PS=750000U PD=1330000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 9 2 7 10 nfet_01v8 L=150000U W=650000U AS=196275000000P AD=169000000000P
+ PS=1330000U PD=1820000U
.ENDS sky130_fd_sc_hd__and4_1

* cell sky130_fd_sc_hd__a311oi_4
* pin VGND
* pin A3
* pin C1
* pin A2
* pin A1
* pin Y
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_4 1 2 3 5 7 8 9 10 13 14
* net 1 VGND
* net 2 A3
* net 3 C1
* net 5 A2
* net 7 A1
* net 8 Y
* net 9 B1
* net 10 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 11 5 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $9 r0 *1 3.83,1.985 pfet_01v8_hvt
M$9 11 7 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 6.03,1.985 pfet_01v8_hvt
M$13 11 9 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=650000000000P PS=6330000U PD=5300000U
* device instance $17 r0 *1 7.93,1.985 pfet_01v8_hvt
M$17 8 3 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=650000000000P
+ AD=665000000000P PS=5300000U PD=6330000U
* device instance $21 r0 *1 4.35,0.56 nfet_01v8
M$21 6 7 8 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $25 r0 *1 6.03,0.56 nfet_01v8
M$25 1 9 8 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=422500000000P
+ PS=3680000U PD=3900000U
* device instance $29 r0 *1 7.93,0.56 nfet_01v8
M$29 1 3 8 14 nfet_01v8 L=150000U W=2600000U AS=422500000000P AD=432250000000P
+ PS=3900000U PD=4580000U
* device instance $33 r0 *1 0.47,0.56 nfet_01v8
M$33 1 2 4 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $37 r0 *1 2.15,0.56 nfet_01v8
M$37 6 5 4 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__a311oi_4

* cell sky130_fd_sc_hd__a211oi_4
* pin VGND
* pin A2
* pin A1
* pin Y
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_4 1 2 4 5 6 7 8 9 14
* net 1 VGND
* net 2 A2
* net 4 A1
* net 5 Y
* net 6 B1
* net 7 C1
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 10 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 10 4 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $9 r0 *1 3.83,1.985 pfet_01v8_hvt
M$9 11 6 10 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $11 r0 *1 4.67,1.985 pfet_01v8_hvt
M$11 13 6 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=150000000000P PS=1270000U PD=1300000U
* device instance $12 r0 *1 5.12,1.985 pfet_01v8_hvt
M$12 5 7 13 9 pfet_01v8_hvt L=150000U W=1000000U AS=150000000000P
+ AD=140000000000P PS=1300000U PD=1280000U
* device instance $13 r0 *1 5.55,1.985 pfet_01v8_hvt
M$13 11 7 5 9 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=290000000000P PS=2560000U PD=2580000U
* device instance $15 r0 *1 6.43,1.985 pfet_01v8_hvt
M$15 12 7 5 9 pfet_01v8_hvt L=150000U W=1000000U AS=150000000000P
+ AD=155000000000P PS=1300000U PD=1310000U
* device instance $16 r0 *1 6.89,1.985 pfet_01v8_hvt
M$16 10 6 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 3 2 1 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $20 r0 *1 1.73,0.56 nfet_01v8
M$20 5 4 3 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
* device instance $25 r0 *1 3.83,0.56 nfet_01v8
M$25 5 6 1 14 nfet_01v8 L=150000U W=2600000U AS=378625000000P AD=477750000000P
+ PS=3765000U PD=4720000U
* device instance $28 r0 *1 5.17,0.56 nfet_01v8
M$28 1 7 5 14 nfet_01v8 L=150000U W=2600000U AS=352625000000P AD=354250000000P
+ PS=3685000U PD=3690000U
.ENDS sky130_fd_sc_hd__a211oi_4

* cell sky130_fd_sc_hd__o31a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31a_1 1 2 5 6 7 8 9 10 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.65,1.985 pfet_01v8_hvt
M$1 9 4 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=360000000000P
+ AD=195000000000P PS=2720000U PD=1390000U
* device instance $2 r0 *1 1.19,1.985 pfet_01v8_hvt
M$2 12 5 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=135000000000P PS=1390000U PD=1270000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 11 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.09,1.985 pfet_01v8_hvt
M$4 4 7 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=212500000000P PS=1330000U PD=1425000U
* device instance $5 r0 *1 2.665,1.985 pfet_01v8_hvt
M$5 9 8 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=345000000000P PS=1425000U PD=2690000U
* device instance $6 r0 *1 0.65,0.56 nfet_01v8
M$6 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=234000000000P AD=126750000000P
+ PS=2020000U PD=1040000U
* device instance $7 r0 *1 1.19,0.56 nfet_01v8
M$7 3 5 1 13 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.61,0.56 nfet_01v8
M$8 1 6 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 2.09,0.56 nfet_01v8
M$9 3 7 1 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.57,0.56 nfet_01v8
M$10 4 8 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=201500000000P
+ PS=980000U PD=1920000U
.ENDS sky130_fd_sc_hd__o31a_1

* cell sky130_fd_sc_hd__o2bb2ai_4
* pin VGND
* pin A2_N
* pin A1_N
* pin Y
* pin B2
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2bb2ai_4 1 2 3 7 8 9 11 12 13
* net 1 VGND
* net 2 A2_N
* net 3 A1_N
* net 7 Y
* net 8 B2
* net 9 B1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 6.54,1.985 pfet_01v8_hvt
M$1 7 8 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 8.22,1.985 pfet_01v8_hvt
M$5 11 9 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=685000000000P PS=5080000U PD=6370000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 5 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $13 r0 *1 2.17,1.985 pfet_01v8_hvt
M$13 5 3 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=785000000000P PS=5080000U PD=5570000U
* device instance $17 r0 *1 4.34,1.985 pfet_01v8_hvt
M$17 7 5 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=785000000000P
+ AD=665000000000P PS=5570000U PD=6330000U
* device instance $21 r0 *1 4.37,0.56 nfet_01v8
M$21 7 5 6 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=510250000000P
+ PS=4580000U PD=4170000U
* device instance $25 r0 *1 6.54,0.56 nfet_01v8
M$25 1 8 6 13 nfet_01v8 L=150000U W=2600000U AS=510250000000P AD=351000000000P
+ PS=4170000U PD=3680000U
* device instance $29 r0 *1 8.22,0.56 nfet_01v8
M$29 1 9 6 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $33 r0 *1 0.49,0.56 nfet_01v8
M$33 5 2 4 13 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $37 r0 *1 2.17,0.56 nfet_01v8
M$37 1 3 4 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o2bb2ai_4

* cell sky130_fd_sc_hd__o41ai_4
* pin VGND
* pin A4
* pin A3
* pin A1
* pin Y
* pin B1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o41ai_4 1 2 3 4 6 7 8 9 13 14
* net 1 VGND
* net 2 A4
* net 3 A3
* net 4 A1
* net 6 Y
* net 7 B1
* net 8 A2
* net 9 VPWR
* net 13 VPB
* device instance $1 r0 *1 6.55,1.985 pfet_01v8_hvt
M$1 11 8 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 8.23,1.985 pfet_01v8_hvt
M$5 9 4 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=685000000000P PS=5080000U PD=6370000U
* device instance $9 r0 *1 0.47,1.985 pfet_01v8_hvt
M$9 6 7 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=665000000000P PS=6330000U PD=6330000U
* device instance $13 r0 *1 2.67,1.985 pfet_01v8_hvt
M$13 6 2 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $17 r0 *1 4.35,1.985 pfet_01v8_hvt
M$17 11 3 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 6.55,0.56 nfet_01v8
M$21 1 8 5 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $25 r0 *1 8.23,0.56 nfet_01v8
M$25 1 4 5 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=445250000000P
+ PS=3680000U PD=4620000U
* device instance $29 r0 *1 0.47,0.56 nfet_01v8
M$29 6 7 5 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=432250000000P
+ PS=4580000U PD=4580000U
* device instance $33 r0 *1 2.67,0.56 nfet_01v8
M$33 1 2 5 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $37 r0 *1 4.35,0.56 nfet_01v8
M$37 1 3 5 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o41ai_4

* cell sky130_fd_sc_hd__nand4b_1
* pin VPB
* pin A_N
* pin B
* pin C
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_1 1 2 3 4 6 7 8 9 10
* net 1 VPB
* net 2 A_N
* net 3 B
* net 4 C
* net 6 D
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=195000000000P PS=1385000U PD=1390000U
* device instance $5 r0 *1 2.58,1.985 pfet_01v8_hvt
M$5 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $6 r0 *1 0.545,0.675 nfet_01v8
M$6 5 2 9 10 nfet_01v8 L=150000U W=420000U AS=118125000000P AD=111300000000P
+ PS=1040000U PD=1370000U
* device instance $7 r0 *1 1.085,0.56 nfet_01v8
M$7 11 6 9 10 nfet_01v8 L=150000U W=650000U AS=118125000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.505,0.56 nfet_01v8
M$8 13 4 11 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $9 r0 *1 2.04,0.56 nfet_01v8
M$9 12 3 13 10 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=126750000000P
+ PS=1035000U PD=1040000U
* device instance $10 r0 *1 2.58,0.56 nfet_01v8
M$10 8 5 12 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=227500000000P
+ PS=1040000U PD=2000000U
.ENDS sky130_fd_sc_hd__nand4b_1

* cell sky130_fd_sc_hd__a21o_2
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_2 1 3 4 5 7 8 9 10
* net 1 VPB
* net 3 B1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 VGND
* net 9 X
* device instance $1 r0 *1 1.855,1.985 pfet_01v8_hvt
M$1 6 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 2.285,1.985 pfet_01v8_hvt
M$2 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=157500000000P PS=1280000U PD=1315000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 6 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157500000000P
+ AD=260000000000P PS=1315000U PD=2520000U
* device instance $4 r0 *1 0.475,1.985 pfet_01v8_hvt
M$4 9 2 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=405000000000P PS=3810000U PD=3810000U
* device instance $6 r0 *1 0.645,0.56 nfet_01v8
M$6 9 2 8 10 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=201500000000P
+ PS=2760000U PD=1920000U
* device instance $8 r0 *1 1.565,0.56 nfet_01v8
M$8 2 3 8 10 nfet_01v8 L=150000U W=650000U AS=110500000000P AD=162500000000P
+ PS=990000U PD=1150000U
* device instance $9 r0 *1 2.215,0.56 nfet_01v8
M$9 11 4 2 10 nfet_01v8 L=150000U W=650000U AS=162500000000P AD=123500000000P
+ PS=1150000U PD=1030000U
* device instance $10 r0 *1 2.745,0.56 nfet_01v8
M$10 8 5 11 10 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=172250000000P
+ PS=1030000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_2

* cell sky130_fd_sc_hd__or2_2
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or2_2 1 2 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 4 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.53,1.695 pfet_01v8_hvt
M$1 9 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.89,1.695 pfet_01v8_hvt
M$2 6 2 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=155750000000P
+ PS=630000U PD=1355000U
* device instance $3 r0 *1 1.395,1.985 pfet_01v8_hvt
M$3 5 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=290750000000P
+ AD=395000000000P PS=2625000U PD=3790000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 3 4 7 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.89,0.445 nfet_01v8
M$6 7 2 3 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=106750000000P
+ PS=690000U PD=1005000U
* device instance $7 r0 *1 1.395,0.56 nfet_01v8
M$7 5 3 7 8 nfet_01v8 L=150000U W=1300000U AS=194500000000P AD=256750000000P
+ PS=1925000U PD=2740000U
.ENDS sky130_fd_sc_hd__or2_2

* cell sky130_fd_sc_hd__and2_1
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 X
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.65,2.065 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $2 r0 *1 1.07,2.065 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=166550000000P AD=56700000000P
+ PS=1390000U PD=690000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=166550000000P
+ AD=475000000000P PS=1390000U PD=2950000U
* device instance $4 r0 *1 0.65,0.585 nfet_01v8
M$4 9 2 6 8 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $5 r0 *1 1.07,0.585 nfet_01v8
M$5 9 3 7 8 nfet_01v8 L=150000U W=420000U AS=111800000000P AD=56700000000P
+ PS=1040000U PD=690000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 4 6 7 8 nfet_01v8 L=150000U W=650000U AS=111800000000P AD=182000000000P
+ PS=1040000U PD=1860000U
.ENDS sky130_fd_sc_hd__and2_1

* cell sky130_fd_sc_hd__nand3b_1
* pin VPB
* pin A_N
* pin C
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A_N
* net 3 C
* net 4 B
* net 5 Y
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 8 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 8 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 5 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=280000000000P PS=1385000U PD=2560000U
* device instance $5 r0 *1 0.6,0.675 nfet_01v8
M$5 6 2 7 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $6 r0 *1 1.085,0.56 nfet_01v8
M$6 11 3 7 9 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $8 r0 *1 2.04,0.56 nfet_01v8
M$8 5 6 10 9 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=182000000000P
+ PS=1035000U PD=1860000U
.ENDS sky130_fd_sc_hd__nand3b_1

* cell sky130_fd_sc_hd__or3_4
* pin VGND
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or3_4 1 3 4 5 6 7 8 11
* net 1 VGND
* net 3 X
* net 4 C
* net 5 B
* net 6 A
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 2 8 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 5 10 8 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 6 9 8 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=400000000000P PS=1270000U PD=1800000U
* device instance $4 r0 *1 2.26,1.985 pfet_01v8_hvt
M$4 3 2 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=805000000000P
+ AD=765000000000P PS=5610000U PD=6530000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 4 2 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $9 r0 *1 0.89,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 1 6 2 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=260000000000P
+ PS=920000U PD=1450000U
* device instance $11 r0 *1 2.26,0.56 nfet_01v8
M$11 3 2 1 11 nfet_01v8 L=150000U W=2600000U AS=523250000000P AD=468000000000P
+ PS=4210000U PD=4690000U
.ENDS sky130_fd_sc_hd__or3_4

* cell sky130_fd_sc_hd__o41a_1
* pin VGND
* pin X
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o41a_1 1 2 5 6 7 8 9 10 11 15
* net 1 VGND
* net 2 X
* net 5 B1
* net 6 A4
* net 7 A3
* net 8 A2
* net 9 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.8,1.985 pfet_01v8_hvt
M$1 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=425000000000P
+ AD=135000000000P PS=2850000U PD=1270000U
* device instance $2 r0 *1 1.22,1.985 pfet_01v8_hvt
M$2 3 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=1520000U
* device instance $3 r0 *1 1.89,1.985 pfet_01v8_hvt
M$3 12 6 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=220000000000P PS=1520000U PD=1440000U
* device instance $4 r0 *1 2.48,1.985 pfet_01v8_hvt
M$4 13 7 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=220000000000P
+ AD=195000000000P PS=1440000U PD=1390000U
* device instance $5 r0 *1 3.02,1.985 pfet_01v8_hvt
M$5 14 8 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $6 r0 *1 3.56,1.985 pfet_01v8_hvt
M$6 10 9 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $7 r0 *1 1.53,0.56 nfet_01v8
M$7 4 5 3 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 1.95,0.56 nfet_01v8
M$8 1 6 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $9 r0 *1 2.48,0.56 nfet_01v8
M$9 4 7 1 15 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=126750000000P
+ PS=1030000U PD=1040000U
* device instance $10 r0 *1 3.02,0.56 nfet_01v8
M$10 1 8 4 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 3.56,0.56 nfet_01v8
M$11 4 9 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=195000000000P
+ PS=1040000U PD=1900000U
* device instance $12 r0 *1 0.59,0.56 nfet_01v8
M$12 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=247000000000P AD=169000000000P
+ PS=2060000U PD=1820000U
.ENDS sky130_fd_sc_hd__o41a_1

* cell sky130_fd_sc_hd__o221ai_1
* pin VPB
* pin C1
* pin B1
* pin A2
* pin A1
* pin B2
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o221ai_1 1 2 3 4 5 6 8 10 11 12
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 B2
* net 8 Y
* net 10 VPWR
* net 11 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=380000000000P PS=2560000U PD=1760000U
* device instance $2 r0 *1 1.4,1.985 pfet_01v8_hvt
M$2 14 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=380000000000P
+ AD=120000000000P PS=1760000U PD=1240000U
* device instance $3 r0 *1 1.79,1.985 pfet_01v8_hvt
M$3 8 6 14 1 pfet_01v8_hvt L=150000U W=1000000U AS=120000000000P
+ AD=225000000000P PS=1240000U PD=1450000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 13 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=105000000000P PS=1450000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.4,0.56 nfet_01v8
M$6 9 3 7 12 nfet_01v8 L=150000U W=650000U AS=165200000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.82,0.56 nfet_01v8
M$7 7 6 9 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=117000000000P
+ PS=920000U PD=1010000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 11 4 7 12 nfet_01v8 L=150000U W=650000U AS=117000000000P AD=87750000000P
+ PS=1010000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 5 11 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 9 2 8 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=165400000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221ai_1

* cell sky130_fd_sc_hd__dfstp_1
* pin VGND
* pin SET_B
* pin Q
* pin CLK
* pin D
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__dfstp_1 1 6 11 17 18 19 20 24
* net 1 VGND
* net 6 SET_B
* net 11 Q
* net 17 CLK
* net 18 D
* net 19 VPB
* net 20 VPWR
* device instance $1 r0 *1 6.925,2.275 pfet_01v8_hvt
M$1 8 6 20 19 pfet_01v8_hvt L=150000U W=420000U AS=122850000000P
+ AD=109200000000P PS=1170000U PD=1360000U
* device instance $2 r0 *1 7.405,2.065 pfet_01v8_hvt
M$2 9 8 20 19 pfet_01v8_hvt L=150000U W=840000U AS=122850000000P
+ AD=218400000000P PS=1170000U PD=2200000U
* device instance $3 r0 *1 0.47,2.135 pfet_01v8_hvt
M$3 20 17 2 19 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $4 r0 *1 0.89,2.135 pfet_01v8_hvt
M$4 3 2 20 19 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $5 r0 *1 1.83,2.065 pfet_01v8_hvt
M$5 4 18 20 19 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=124950000000P PS=2200000U PD=1175000U
* device instance $6 r0 *1 2.315,2.275 pfet_01v8_hvt
M$6 5 3 4 19 pfet_01v8_hvt L=150000U W=420000U AS=124950000000P AD=56700000000P
+ PS=1175000U PD=690000U
* device instance $7 r0 *1 2.735,2.275 pfet_01v8_hvt
M$7 21 2 5 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=94500000000P
+ PS=690000U PD=870000U
* device instance $8 r0 *1 3.335,2.275 pfet_01v8_hvt
M$8 20 7 21 19 pfet_01v8_hvt L=150000U W=420000U AS=94500000000P
+ AD=79800000000P PS=870000U PD=800000U
* device instance $9 r0 *1 3.865,2.275 pfet_01v8_hvt
M$9 7 6 20 19 pfet_01v8_hvt L=150000U W=420000U AS=79800000000P AD=56700000000P
+ PS=800000U PD=690000U
* device instance $10 r0 *1 4.285,2.275 pfet_01v8_hvt
M$10 20 5 7 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $11 r0 *1 4.705,2.275 pfet_01v8_hvt
M$11 22 5 20 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=48300000000P PS=690000U PD=650000U
* device instance $12 r0 *1 5.085,2.275 pfet_01v8_hvt
M$12 8 2 22 19 pfet_01v8_hvt L=150000U W=420000U AS=48300000000P
+ AD=81900000000P PS=650000U PD=810000U
* device instance $13 r0 *1 5.625,2.275 pfet_01v8_hvt
M$13 23 3 8 19 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P
+ AD=44100000000P PS=810000U PD=630000U
* device instance $14 r0 *1 5.985,2.275 pfet_01v8_hvt
M$14 20 9 23 19 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=109200000000P PS=630000U PD=1360000U
* device instance $15 r0 *1 8.345,2.165 pfet_01v8_hvt
M$15 10 8 20 19 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P
+ AD=166400000000P PS=1325000U PD=1800000U
* device instance $16 r0 *1 8.82,1.985 pfet_01v8_hvt
M$16 11 10 20 19 pfet_01v8_hvt L=150000U W=1000000U AS=149000000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $17 r0 *1 0.47,0.445 nfet_01v8
M$17 1 17 2 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $18 r0 *1 0.89,0.445 nfet_01v8
M$18 3 2 1 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $19 r0 *1 2.305,0.415 nfet_01v8
M$19 5 2 4 24 nfet_01v8 L=150000U W=360000U AS=93500000000P AD=72000000000P
+ PS=965000U PD=760000U
* device instance $20 r0 *1 2.855,0.415 nfet_01v8
M$20 14 3 5 24 nfet_01v8 L=150000U W=360000U AS=72000000000P AD=67050000000P
+ PS=760000U PD=750000U
* device instance $21 r0 *1 3.335,0.445 nfet_01v8
M$21 1 7 14 24 nfet_01v8 L=150000U W=420000U AS=67050000000P AD=88200000000P
+ PS=750000U PD=840000U
* device instance $22 r0 *1 3.905,0.445 nfet_01v8
M$22 16 6 1 24 nfet_01v8 L=150000U W=420000U AS=88200000000P AD=44100000000P
+ PS=840000U PD=630000U
* device instance $23 r0 *1 4.265,0.445 nfet_01v8
M$23 7 5 16 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=109200000000P
+ PS=630000U PD=1360000U
* device instance $24 r0 *1 1.83,0.555 nfet_01v8
M$24 4 18 1 24 nfet_01v8 L=150000U W=640000U AS=166400000000P AD=93500000000P
+ PS=1800000U PD=965000U
* device instance $25 r0 *1 5.205,0.445 nfet_01v8
M$25 15 5 1 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $26 r0 *1 5.565,0.445 nfet_01v8
M$26 8 3 15 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $27 r0 *1 6.045,0.445 nfet_01v8
M$27 12 2 8 24 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $28 r0 *1 6.405,0.445 nfet_01v8
M$28 13 9 12 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=48300000000P
+ PS=630000U PD=650000U
* device instance $29 r0 *1 6.785,0.445 nfet_01v8
M$29 1 6 13 24 nfet_01v8 L=150000U W=420000U AS=48300000000P AD=113700000000P
+ PS=650000U PD=1010000U
* device instance $30 r0 *1 7.405,0.505 nfet_01v8
M$30 9 8 1 24 nfet_01v8 L=150000U W=540000U AS=113700000000P AD=140400000000P
+ PS=1010000U PD=1600000U
* device instance $31 r0 *1 8.345,0.445 nfet_01v8
M$31 1 8 10 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $32 r0 *1 8.82,0.56 nfet_01v8
M$32 11 10 1 24 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
.ENDS sky130_fd_sc_hd__dfstp_1

* cell sky130_fd_sc_hd__a21bo_1
* pin VGND
* pin B1_N
* pin X
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a21bo_1 1 2 5 6 7 9 11 12
* net 1 VGND
* net 2 B1_N
* net 5 X
* net 6 A1
* net 7 A2
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.415,1.985 pfet_01v8_hvt
M$1 10 3 4 11 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=135000000000P PS=2530000U PD=1270000U
* device instance $2 r0 *1 1.835,1.985 pfet_01v8_hvt
M$2 9 6 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=140000000000P PS=1270000U PD=1280000U
* device instance $3 r0 *1 2.265,1.985 pfet_01v8_hvt
M$3 10 7 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 3.21,1.985 pfet_01v8_hvt
M$4 5 4 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.47,2.275 pfet_01v8_hvt
M$5 9 2 3 11 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $6 r0 *1 0.815,0.445 nfet_01v8
M$6 1 2 3 12 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=135900000000P
+ PS=1370000U PD=1100000U
* device instance $7 r0 *1 1.415,0.56 nfet_01v8
M$7 4 3 1 12 nfet_01v8 L=150000U W=650000U AS=135900000000P AD=87750000000P
+ PS=1100000U PD=920000U
* device instance $8 r0 *1 1.835,0.56 nfet_01v8
M$8 8 6 4 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=91000000000P
+ PS=920000U PD=930000U
* device instance $9 r0 *1 2.265,0.56 nfet_01v8
M$9 1 7 8 12 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=258375000000P
+ PS=930000U PD=1445000U
* device instance $10 r0 *1 3.21,0.56 nfet_01v8
M$10 5 4 1 12 nfet_01v8 L=150000U W=650000U AS=258375000000P AD=169000000000P
+ PS=1445000U PD=1820000U
.ENDS sky130_fd_sc_hd__a21bo_1

* cell sky130_fd_sc_hd__a2111o_1
* pin VGND
* pin X
* pin A1
* pin D1
* pin C1
* pin B1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a2111o_1 1 2 4 5 6 7 8 11 12 15
* net 1 VGND
* net 2 X
* net 4 A1
* net 5 D1
* net 6 C1
* net 7 B1
* net 8 A2
* net 11 VPB
* net 12 VPWR
* device instance $1 r0 *1 1.595,1.985 pfet_01v8_hvt
M$1 13 5 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=385000000000P
+ AD=125000000000P PS=2770000U PD=1250000U
* device instance $2 r0 *1 1.995,1.985 pfet_01v8_hvt
M$2 14 6 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=125000000000P
+ AD=180000000000P PS=1250000U PD=1360000U
* device instance $3 r0 *1 2.505,1.985 pfet_01v8_hvt
M$3 10 7 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=180000000000P
+ AD=280000000000P PS=1360000U PD=1560000U
* device instance $4 r0 *1 3.215,1.985 pfet_01v8_hvt
M$4 12 4 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=135000000000P PS=1560000U PD=1270000U
* device instance $5 r0 *1 3.635,1.985 pfet_01v8_hvt
M$5 10 8 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=290000000000P PS=1270000U PD=2580000U
* device instance $6 r0 *1 0.5,1.985 pfet_01v8_hvt
M$6 12 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=265000000000P PS=2580000U PD=2530000U
* device instance $7 r0 *1 0.54,0.56 nfet_01v8
M$7 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=214500000000P AD=274625000000P
+ PS=1960000U PD=1495000U
* device instance $8 r0 *1 1.535,0.56 nfet_01v8
M$8 3 5 1 15 nfet_01v8 L=150000U W=650000U AS=274625000000P AD=100750000000P
+ PS=1495000U PD=960000U
* device instance $9 r0 *1 1.995,0.56 nfet_01v8
M$9 1 6 3 15 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=117000000000P
+ PS=960000U PD=1010000U
* device instance $10 r0 *1 2.505,0.56 nfet_01v8
M$10 3 7 1 15 nfet_01v8 L=150000U W=650000U AS=117000000000P AD=185250000000P
+ PS=1010000U PD=1220000U
* device instance $11 r0 *1 3.225,0.56 nfet_01v8
M$11 9 4 3 15 nfet_01v8 L=150000U W=650000U AS=185250000000P AD=82875000000P
+ PS=1220000U PD=905000U
* device instance $12 r0 *1 3.63,0.56 nfet_01v8
M$12 1 8 9 15 nfet_01v8 L=150000U W=650000U AS=82875000000P AD=188500000000P
+ PS=905000U PD=1880000U
.ENDS sky130_fd_sc_hd__a2111o_1

* cell sky130_fd_sc_hd__nor3b_1
* pin VPB
* pin B
* pin A
* pin C_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 C_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 2.055,1.86 pfet_01v8_hvt
M$1 8 4 7 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 11 8 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=320000000000P
+ AD=135000000000P PS=2640000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 10 2 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.57,1.985 pfet_01v8_hvt
M$4 7 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $5 r0 *1 0.73,0.56 nfet_01v8
M$5 6 8 5 9 nfet_01v8 L=150000U W=650000U AS=221000000000P AD=87750000000P
+ PS=1980000U PD=920000U
* device instance $6 r0 *1 1.15,0.56 nfet_01v8
M$6 5 2 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.57,0.56 nfet_01v8
M$7 6 3 5 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $8 r0 *1 2.055,0.675 nfet_01v8
M$8 8 4 6 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor3b_1

* cell sky130_fd_sc_hd__or2b_1
* pin VPB
* pin B_N
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or2b_1 1 2 3 5 7 8 9
* net 1 VPB
* net 2 B_N
* net 3 A
* net 5 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 1.43,1.695 pfet_01v8_hvt
M$1 10 4 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.79,1.695 pfet_01v8_hvt
M$2 7 3 10 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=148250000000P
+ PS=630000U PD=1340000U
* device instance $3 r0 *1 2.28,1.985 pfet_01v8_hvt
M$3 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=270000000000P PS=1340000U PD=2540000U
* device instance $4 r0 *1 0.47,1.695 pfet_01v8_hvt
M$4 4 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=117600000000P
+ PS=1360000U PD=1400000U
* device instance $5 r0 *1 0.47,0.475 nfet_01v8
M$5 5 2 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=157500000000P
+ PS=1360000U PD=1170000U
* device instance $6 r0 *1 1.37,0.475 nfet_01v8
M$6 6 4 5 9 nfet_01v8 L=150000U W=420000U AS=157500000000P AD=56700000000P
+ PS=1170000U PD=690000U
* device instance $7 r0 *1 1.79,0.475 nfet_01v8
M$7 6 3 5 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $8 r0 *1 2.28,0.56 nfet_01v8
M$8 8 6 5 9 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=175500000000P
+ PS=990000U PD=1840000U
.ENDS sky130_fd_sc_hd__or2b_1

* cell sky130_fd_sc_hd__and3b_1
* pin VPB
* pin C
* pin B
* pin A_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__and3b_1 1 2 3 5 7 8 9 10
* net 1 VPB
* net 2 C
* net 3 B
* net 5 A_N
* net 7 X
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 2.275,1.695 pfet_01v8_hvt
M$1 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=142225000000P
+ PS=815000U PD=1335000U
* device instance $2 r0 *1 1.38,1.765 pfet_01v8_hvt
M$2 9 4 6 1 pfet_01v8_hvt L=150000U W=420000U AS=108500000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 1.8,1.765 pfet_01v8_hvt
M$3 9 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 2.75,1.985 pfet_01v8_hvt
M$4 7 6 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,2.275 pfet_01v8_hvt
M$5 4 5 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=108700000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.405,0.475 nfet_01v8
M$6 12 4 6 10 nfet_01v8 L=150000U W=420000U AS=107825000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 1.765,0.475 nfet_01v8
M$7 11 3 12 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 2.17,0.475 nfet_01v8
M$8 11 2 8 10 nfet_01v8 L=150000U W=420000U AS=122275000000P AD=53550000000P
+ PS=1080000U PD=675000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 6 8 10 nfet_01v8 L=150000U W=650000U AS=122275000000P AD=169000000000P
+ PS=1080000U PD=1820000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=107850000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and3b_1

* cell sky130_fd_sc_hd__a2111oi_2
* pin VGND
* pin Y
* pin C1
* pin D1
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_2 1 2 3 4 5 6 7 10 11 16
* net 1 VGND
* net 2 Y
* net 3 C1
* net 4 D1
* net 5 B1
* net 6 A1
* net 7 A2
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.64,1.985 pfet_01v8_hvt
M$1 10 6 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=420000000000P
+ AD=475000000000P PS=3840000U PD=3950000U
* device instance $2 r0 *1 4.07,1.985 pfet_01v8_hvt
M$2 13 7 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=300000000000P PS=2560000U PD=2600000U
* device instance $5 r0 *1 0.5,1.985 pfet_01v8_hvt
M$5 14 3 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=285000000000P
+ AD=140000000000P PS=2570000U PD=1280000U
* device instance $6 r0 *1 0.93,1.985 pfet_01v8_hvt
M$6 2 4 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $7 r0 *1 1.36,1.985 pfet_01v8_hvt
M$7 15 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $8 r0 *1 1.79,1.985 pfet_01v8_hvt
M$8 12 3 15 11 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=160000000000P PS=1280000U PD=1320000U
* device instance $9 r0 *1 2.26,1.985 pfet_01v8_hvt
M$9 13 5 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=400000000000P PS=2600000U PD=3800000U
* device instance $11 r0 *1 0.5,0.56 nfet_01v8
M$11 1 3 2 16 nfet_01v8 L=150000U W=1300000U AS=312000000000P AD=196625000000P
+ PS=2910000U PD=1905000U
* device instance $12 r0 *1 0.93,0.56 nfet_01v8
M$12 2 4 1 16 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=217750000000P
+ PS=1860000U PD=1970000U
* device instance $15 r0 *1 2.375,0.56 nfet_01v8
M$15 1 5 2 16 nfet_01v8 L=150000U W=1300000U AS=232375000000P AD=217750000000P
+ PS=2015000U PD=1970000U
* device instance $17 r0 *1 3.345,0.56 nfet_01v8
M$17 9 6 2 16 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=178750000000P
+ PS=930000U PD=1200000U
* device instance $18 r0 *1 4.045,0.56 nfet_01v8
M$18 1 7 9 16 nfet_01v8 L=150000U W=650000U AS=178750000000P AD=112125000000P
+ PS=1200000U PD=995000U
* device instance $19 r0 *1 4.54,0.56 nfet_01v8
M$19 8 7 1 16 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=91000000000P
+ PS=995000U PD=930000U
* device instance $20 r0 *1 4.97,0.56 nfet_01v8
M$20 2 6 8 16 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a2111oi_2

* cell sky130_fd_sc_hd__a211o_1
* pin VPB
* pin B1
* pin C1
* pin A1
* pin A2
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a211o_1 1 2 3 4 5 7 8 9 11
* net 1 VPB
* net 2 B1
* net 3 C1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 X
* net 9 VGND
* device instance $1 r0 *1 1.425,1.985 pfet_01v8_hvt
M$1 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.855,1.985 pfet_01v8_hvt
M$2 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 2.285,1.985 pfet_01v8_hvt
M$3 13 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 2.745,1.985 pfet_01v8_hvt
M$4 6 3 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.475,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=265000000000P PS=2530000U PD=2530000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 9 6 8 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=260000000000P
+ PS=1830000U PD=1450000U
* device instance $7 r0 *1 1.425,0.56 nfet_01v8
M$7 12 5 9 11 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=91000000000P
+ PS=1450000U PD=930000U
* device instance $8 r0 *1 1.855,0.56 nfet_01v8
M$8 6 4 12 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $9 r0 *1 2.285,0.56 nfet_01v8
M$9 9 2 6 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $10 r0 *1 2.745,0.56 nfet_01v8
M$10 6 3 9 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211o_1

* cell sky130_fd_sc_hd__a21boi_4
* pin VGND
* pin Y
* pin B1_N
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_4 1 3 5 6 7 8 9 11
* net 1 VGND
* net 3 Y
* net 5 B1_N
* net 6 A2
* net 7 A1
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.505,1.985 pfet_01v8_hvt
M$1 8 5 2 9 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=265000000000P PS=2530000U PD=2530000U
* device instance $2 r0 *1 1.455,1.985 pfet_01v8_hvt
M$2 3 2 10 9 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=575000000000P PS=6370000U PD=5150000U
* device instance $6 r0 *1 3.205,1.985 pfet_01v8_hvt
M$6 8 6 10 9 pfet_01v8_hvt L=150000U W=4000000U AS=575000000000P
+ AD=690000000000P PS=5150000U PD=6380000U
* device instance $7 r0 *1 3.645,1.985 pfet_01v8_hvt
M$7 10 7 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=565000000000P
+ AD=560000000000P PS=5130000U PD=5120000U
* device instance $14 r0 *1 0.625,0.56 nfet_01v8
M$14 1 5 2 11 nfet_01v8 L=150000U W=650000U AS=269750000000P AD=123500000000P
+ PS=2130000U PD=1030000U
* device instance $15 r0 *1 1.155,0.56 nfet_01v8
M$15 3 2 1 11 nfet_01v8 L=150000U W=2600000U AS=396500000000P AD=474500000000P
+ PS=3820000U PD=4060000U
* device instance $19 r0 *1 3.215,0.56 nfet_01v8
M$19 4 6 1 11 nfet_01v8 L=150000U W=2600000U AS=474500000000P AD=445250000000P
+ PS=4060000U PD=4620000U
* device instance $20 r0 *1 3.645,0.56 nfet_01v8
M$20 3 7 4 11 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=364000000000P
+ PS=3720000U PD=3720000U
.ENDS sky130_fd_sc_hd__a21boi_4

* cell sky130_fd_sc_hd__o2111ai_1
* pin VPB
* pin D1
* pin C1
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2111ai_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 D1
* net 3 C1
* net 4 B1
* net 5 A2
* net 6 A1
* net 8 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.67,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.1,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=195000000000P PS=1280000U PD=1390000U
* device instance $3 r0 *1 1.64,1.985 pfet_01v8_hvt
M$3 9 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=202500000000P PS=1390000U PD=1405000U
* device instance $4 r0 *1 2.195,1.985 pfet_01v8_hvt
M$4 14 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=202500000000P
+ AD=195000000000P PS=1405000U PD=1390000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 8 6 14 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=265000000000P PS=1390000U PD=2530000U
* device instance $6 r0 *1 0.74,0.56 nfet_01v8
M$6 13 2 9 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $7 r0 *1 1.1,0.56 nfet_01v8
M$7 12 3 13 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=126750000000P
+ PS=860000U PD=1040000U
* device instance $8 r0 *1 1.64,0.56 nfet_01v8
M$8 7 4 12 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=131625000000P
+ PS=1040000U PD=1055000U
* device instance $9 r0 *1 2.195,0.56 nfet_01v8
M$9 10 5 7 11 nfet_01v8 L=150000U W=650000U AS=131625000000P AD=126750000000P
+ PS=1055000U PD=1040000U
* device instance $10 r0 *1 2.735,0.56 nfet_01v8
M$10 7 6 10 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=172250000000P
+ PS=1040000U PD=1830000U
.ENDS sky130_fd_sc_hd__o2111ai_1

* cell sky130_fd_sc_hd__a311oi_2
* pin VGND
* pin Y
* pin A3
* pin A2
* pin A1
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_2 1 4 5 6 7 8 9 10 13 14
* net 1 VGND
* net 4 Y
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 B1
* net 9 C1
* net 10 VPWR
* net 13 VPB
* device instance $1 r0 *1 3.54,1.985 pfet_01v8_hvt
M$1 11 8 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=2790000U
* device instance $3 r0 *1 4.63,1.985 pfet_01v8_hvt
M$3 4 9 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=2790000U PD=3790000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 11 5 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 11 6 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=275000000000P
+ AD=285000000000P PS=2550000U PD=2570000U
* device instance $9 r0 *1 2.18,1.985 pfet_01v8_hvt
M$9 11 7 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=395000000000P PS=2560000U PD=3790000U
* device instance $11 r0 *1 2.67,0.56 nfet_01v8
M$11 3 7 4 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=185250000000P
+ PS=2740000U PD=1870000U
* device instance $13 r0 *1 3.54,0.56 nfet_01v8
M$13 1 8 4 14 nfet_01v8 L=150000U W=1300000U AS=185250000000P AD=256750000000P
+ PS=1870000U PD=2090000U
* device instance $15 r0 *1 4.63,0.56 nfet_01v8
M$15 1 9 4 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2090000U PD=2740000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 1 5 2 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $19 r0 *1 1.31,0.56 nfet_01v8
M$19 3 6 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a311oi_2

* cell sky130_fd_sc_hd__nand4_4
* pin VGND
* pin D
* pin A
* pin C
* pin B
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4_4 1 2 3 5 7 9 10 11 12
* net 1 VGND
* net 2 D
* net 3 A
* net 5 C
* net 7 B
* net 9 VPWR
* net 10 Y
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 10 5 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=800000000000P PS=5080000U PD=5600000U
* device instance $9 r0 *1 4.35,1.985 pfet_01v8_hvt
M$9 10 7 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=570000000000P PS=5600000U PD=5140000U
* device instance $13 r0 *1 6.09,1.985 pfet_01v8_hvt
M$13 10 3 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=570000000000P
+ AD=665000000000P PS=5140000U PD=6330000U
* device instance $17 r0 *1 4.35,0.56 nfet_01v8
M$17 6 7 8 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=370500000000P
+ PS=4580000U PD=3740000U
* device instance $21 r0 *1 6.09,0.56 nfet_01v8
M$21 10 3 8 12 nfet_01v8 L=150000U W=2600000U AS=370500000000P AD=432250000000P
+ PS=3740000U PD=4580000U
* device instance $25 r0 *1 0.47,0.56 nfet_01v8
M$25 1 2 4 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 2.15,0.56 nfet_01v8
M$29 6 5 4 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand4_4

* cell sky130_fd_sc_hd__o211ai_4
* pin VGND
* pin A1
* pin A2
* pin C1
* pin B1
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_4 1 2 3 4 6 10 11 12 14
* net 1 VGND
* net 2 A1
* net 3 A2
* net 4 C1
* net 6 B1
* net 10 VPWR
* net 11 Y
* net 12 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 13 2 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=580000000000P PS=6370000U PD=5160000U
* device instance $4 r0 *1 1.765,1.985 pfet_01v8_hvt
M$4 11 3 13 12 pfet_01v8_hvt L=150000U W=4000000U AS=560000000000P
+ AD=560000000000P PS=5120000U PD=5120000U
* device instance $9 r0 *1 3.955,1.985 pfet_01v8_hvt
M$9 11 6 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=575000000000P AD=1.09e+12P
+ PS=5150000U PD=7180000U
* device instance $12 r0 *1 5.235,1.985 pfet_01v8_hvt
M$12 10 4 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $17 r0 *1 0.475,0.56 nfet_01v8
M$17 1 2 5 14 nfet_01v8 L=150000U W=2600000U AS=448500000000P AD=373750000000P
+ PS=4630000U PD=3750000U
* device instance $20 r0 *1 1.765,0.56 nfet_01v8
M$20 5 3 1 14 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=367250000000P
+ PS=3720000U PD=3730000U
* device instance $25 r0 *1 3.955,0.56 nfet_01v8
M$25 7 6 5 14 nfet_01v8 L=150000U W=1300000U AS=191750000000P AD=182000000000P
+ PS=1890000U PD=1860000U
* device instance $27 r0 *1 4.815,0.56 nfet_01v8
M$27 9 6 5 14 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=87750000000P
+ PS=930000U PD=920000U
* device instance $28 r0 *1 5.235,0.56 nfet_01v8
M$28 11 4 9 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $29 r0 *1 5.655,0.56 nfet_01v8
M$29 7 4 11 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $31 r0 *1 6.495,0.56 nfet_01v8
M$31 8 4 11 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=104000000000P
+ PS=920000U PD=970000U
* device instance $32 r0 *1 6.965,0.56 nfet_01v8
M$32 5 6 8 14 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=256750000000P
+ PS=970000U PD=2090000U
.ENDS sky130_fd_sc_hd__o211ai_4

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__nand3_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_2 1 3 5 6 7 8 9 10
* net 1 VGND
* net 3 Y
* net 5 A
* net 6 B
* net 7 C
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 3 7 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=445000000000P PS=3790000U PD=3890000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 3 6 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $7 r0 *1 2.67,0.56 nfet_01v8
M$7 4 7 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=289250000000P
+ PS=2740000U PD=2840000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 5 2 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.31,0.56 nfet_01v8
M$11 4 6 2 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand3_2

* cell sky130_fd_sc_hd__and2_0
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_0 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.54,2.275 pfet_01v8_hvt
M$1 4 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=60900000000P
+ PS=1370000U PD=710000U
* device instance $2 r0 *1 0.98,2.275 pfet_01v8_hvt
M$2 4 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=184100000000P AD=60900000000P
+ PS=1260000U PD=710000U
* device instance $3 r0 *1 1.75,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=184100000000P AD=169600000000P
+ PS=1260000U PD=1810000U
* device instance $4 r0 *1 0.54,0.445 nfet_01v8
M$4 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=1370000U PD=630000U
* device instance $5 r0 *1 0.9,0.445 nfet_01v8
M$5 7 3 9 8 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=96600000000P
+ PS=630000U PD=880000U
* device instance $6 r0 *1 1.51,0.445 nfet_01v8
M$6 5 4 7 8 nfet_01v8 L=150000U W=420000U AS=96600000000P AD=111300000000P
+ PS=880000U PD=1370000U
.ENDS sky130_fd_sc_hd__and2_0

* cell sky130_fd_sc_hd__nor3b_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_2 1 2 3 4 6 9 10 11
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 6 C_N
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 2 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=415000000000P PS=3830000U PD=3830000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 9 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 4.13,1.695 pfet_01v8_hvt
M$7 9 6 5 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $8 r0 *1 4.13,0.675 nfet_01v8
M$8 1 6 5 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=269750000000P
+ PS=2740000U PD=2780000U
* device instance $11 r0 *1 0.49,0.56 nfet_01v8
M$11 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $13 r0 *1 1.33,0.56 nfet_01v8
M$13 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3b_2

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__o32ai_4
* pin VGND
* pin B1
* pin A2
* pin A1
* pin Y
* pin A3
* pin B2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32ai_4 1 2 3 4 6 7 8 12 13 14
* net 1 VGND
* net 2 B1
* net 3 A2
* net 4 A1
* net 6 Y
* net 7 A3
* net 8 B2
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 4.365,1.985 pfet_01v8_hvt
M$1 6 7 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.045,1.985 pfet_01v8_hvt
M$5 11 3 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 8.245,1.985 pfet_01v8_hvt
M$9 11 4 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=712500000000P
+ AD=712500000000P PS=6425000U PD=6425000U
* device instance $13 r0 *1 0.47,1.985 pfet_01v8_hvt
M$13 6 8 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=547500000000P PS=6330000U PD=5095000U
* device instance $17 r0 *1 2.165,1.985 pfet_01v8_hvt
M$17 12 2 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=547500000000P
+ AD=665000000000P PS=5095000U PD=6330000U
* device instance $21 r0 *1 0.47,0.56 nfet_01v8
M$21 6 8 5 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=355875000000P
+ PS=4580000U PD=3695000U
* device instance $25 r0 *1 2.165,0.56 nfet_01v8
M$25 6 2 5 14 nfet_01v8 L=150000U W=2600000U AS=355875000000P AD=351000000000P
+ PS=3695000U PD=3680000U
* device instance $29 r0 *1 3.845,0.56 nfet_01v8
M$29 1 7 5 14 nfet_01v8 L=150000U W=2600000U AS=403000000000P AD=520000000000P
+ PS=3840000U PD=4200000U
* device instance $33 r0 *1 6.045,0.56 nfet_01v8
M$33 1 3 5 14 nfet_01v8 L=150000U W=2600000U AS=468000000000P AD=520000000000P
+ PS=4040000U PD=4200000U
* device instance $37 r0 *1 8.245,0.56 nfet_01v8
M$37 1 4 5 14 nfet_01v8 L=150000U W=2600000U AS=550875000000P AD=463125000000P
+ PS=4295000U PD=4675000U
.ENDS sky130_fd_sc_hd__o32ai_4

* cell sky130_fd_sc_hd__a31oi_2
* pin VGND
* pin Y
* pin A3
* pin A2
* pin A1
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_2 1 4 5 6 7 8 10 11 12
* net 1 VGND
* net 4 Y
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=545000000000P
+ AD=590000000000P PS=3090000U PD=3180000U
* device instance $7 r0 *1 3.63,1.985 pfet_01v8_hvt
M$7 4 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=355000000000P
+ AD=435000000000P PS=2710000U PD=3870000U
* device instance $9 r0 *1 2.67,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=214500000000P
+ PS=2770000U PD=1960000U
* device instance $11 r0 *1 3.63,0.56 nfet_01v8
M$11 1 8 4 12 nfet_01v8 L=150000U W=1300000U AS=230750000000P AD=282750000000P
+ PS=2010000U PD=2820000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a31oi_2

* cell sky130_fd_sc_hd__o32a_4
* pin VGND
* pin A1
* pin A2
* pin A3
* pin B1
* pin B2
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32a_4 1 3 4 5 7 8 9 11 14 15
* net 1 VGND
* net 3 A1
* net 4 A2
* net 5 A3
* net 7 B1
* net 8 B2
* net 9 X
* net 11 VPWR
* net 14 VPB
* device instance $1 r0 *1 6.26,1.985 pfet_01v8_hvt
M$1 9 6 11 14 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=665000000000P PS=6330000U PD=6330000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 11 3 10 14 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 12 4 10 14 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 4.03,1.985 pfet_01v8_hvt
M$9 11 7 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $11 r0 *1 4.87,1.985 pfet_01v8_hvt
M$11 6 8 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=285000000000P
+ AD=410000000000P PS=2570000U PD=3820000U
* device instance $13 r0 *1 2.67,1.985 pfet_01v8_hvt
M$13 6 5 12 14 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $15 r0 *1 6.26,0.56 nfet_01v8
M$15 9 6 1 15 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=432250000000P
+ PS=4580000U PD=4580000U
* device instance $19 r0 *1 0.47,0.56 nfet_01v8
M$19 1 3 2 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $21 r0 *1 1.31,0.56 nfet_01v8
M$21 1 4 2 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=182000000000P
+ PS=1840000U PD=1860000U
* device instance $23 r0 *1 2.17,0.56 nfet_01v8
M$23 1 5 2 15 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=256750000000P
+ PS=1860000U PD=2740000U
* device instance $25 r0 *1 4.03,0.56 nfet_01v8
M$25 2 7 6 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $27 r0 *1 4.87,0.56 nfet_01v8
M$27 2 8 6 15 nfet_01v8 L=150000U W=1300000U AS=185250000000P AD=266500000000P
+ PS=1870000U PD=2770000U
.ENDS sky130_fd_sc_hd__o32a_4

* cell sky130_fd_sc_hd__xor2_4
* pin VGND
* pin A
* pin B
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xor2_4 1 2 3 6 8 10 11
* net 1 VGND
* net 2 A
* net 3 B
* net 6 X
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 8.255,1.985 pfet_01v8_hvt
M$1 9 4 6 10 pfet_01v8_hvt L=150000U W=4000000U AS=677450000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 4.365,1.985 pfet_01v8_hvt
M$5 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 6.045,1.985 pfet_01v8_hvt
M$9 8 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=661800000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 0.485,1.985 pfet_01v8_hvt
M$13 8 2 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=680000000000P
+ AD=540000000000P PS=6360000U PD=5080000U
* device instance $17 r0 *1 2.165,1.985 pfet_01v8_hvt
M$17 4 3 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 8.255,0.56 nfet_01v8
M$21 6 4 1 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $25 r0 *1 4.365,0.56 nfet_01v8
M$25 6 3 5 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 6.045,0.56 nfet_01v8
M$29 1 2 5 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $33 r0 *1 0.485,0.56 nfet_01v8
M$33 4 2 1 11 nfet_01v8 L=150000U W=2600000U AS=442000000000P AD=351000000000P
+ PS=4610000U PD=3680000U
* device instance $37 r0 *1 2.165,0.56 nfet_01v8
M$37 4 3 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__xor2_4

* cell sky130_fd_sc_hd__inv_8
* pin VGND
* pin A
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__inv_8 1 2 3 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.635,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=8000000U AS=1.205e+12P AD=1.205e+12P
+ PS=11410000U PD=11410000U
* device instance $9 r0 *1 0.635,0.56 nfet_01v8
M$9 3 2 1 6 nfet_01v8 L=150000U W=5200000U AS=783250000000P AD=783250000000P
+ PS=8260000U PD=8260000U
.ENDS sky130_fd_sc_hd__inv_8

* cell sky130_fd_sc_hd__a41oi_4
* pin VGND
* pin B1
* pin A4
* pin Y
* pin A1
* pin A2
* pin A3
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_4 1 2 3 4 6 8 10 12 13 14
* net 1 VGND
* net 2 B1
* net 3 A4
* net 4 Y
* net 6 A1
* net 8 A2
* net 10 A3
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 2 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=695000000000P PS=6330000U PD=5390000U
* device instance $5 r0 *1 2.46,1.985 pfet_01v8_hvt
M$5 12 6 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=865000000000P
+ AD=757500000000P PS=5730000U PD=5515000U
* device instance $9 r0 *1 4.575,1.985 pfet_01v8_hvt
M$9 12 8 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=790000000000P
+ AD=752500000000P PS=5580000U PD=5505000U
* device instance $13 r0 *1 6.68,1.985 pfet_01v8_hvt
M$13 12 10 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=550000000000P
+ AD=540000000000P PS=5100000U PD=5080000U
* device instance $17 r0 *1 8.36,1.985 pfet_01v8_hvt
M$17 12 3 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=695000000000P PS=5080000U PD=6390000U
* device instance $21 r0 *1 6.68,0.56 nfet_01v8
M$21 7 10 9 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $25 r0 *1 8.36,0.56 nfet_01v8
M$25 1 3 9 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=451750000000P
+ PS=3680000U PD=4640000U
* device instance $29 r0 *1 0.47,0.56 nfet_01v8
M$29 4 2 1 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=432250000000P
+ PS=4580000U PD=4580000U
* device instance $33 r0 *1 2.8,0.56 nfet_01v8
M$33 4 6 5 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $37 r0 *1 4.48,0.56 nfet_01v8
M$37 7 8 5 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__a41oi_4

* cell sky130_fd_sc_hd__clkinv_8
* pin VGND
* pin Y
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_8 1 2 3 4 5 6
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 4 5 pfet_01v8_hvt L=150000U W=12000000U AS=1.7475e+12P AD=1.7475e+12P
+ PS=16495000U PD=16495000U
* device instance $13 r0 *1 1.415,0.445 nfet_01v8
M$13 2 3 1 6 nfet_01v8 L=150000U W=3360000U AS=522900000000P AD=522900000000P
+ PS=6270000U PD=6270000U
.ENDS sky130_fd_sc_hd__clkinv_8

* cell sky130_fd_sc_hd__o21bai_2
* pin VGND
* pin Y
* pin B1_N
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o21bai_2 1 4 5 6 7 8 10 11
* net 1 VGND
* net 4 Y
* net 5 B1_N
* net 6 A2
* net 7 A1
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.475,1.695 pfet_01v8_hvt
M$1 8 5 2 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=145750000000P PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.96,1.985 pfet_01v8_hvt
M$2 4 2 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=280750000000P
+ AD=395000000000P PS=2605000U PD=3790000U
* device instance $4 r0 *1 2.32,1.985 pfet_01v8_hvt
M$4 4 6 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $6 r0 *1 3.16,1.985 pfet_01v8_hvt
M$6 8 7 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $8 r0 *1 1.48,0.56 nfet_01v8
M$8 4 2 3 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $10 r0 *1 2.32,0.56 nfet_01v8
M$10 1 6 3 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $12 r0 *1 3.16,0.56 nfet_01v8
M$12 1 7 3 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
* device instance $14 r0 *1 0.475,0.675 nfet_01v8
M$14 2 5 1 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__o21bai_2

* cell sky130_fd_sc_hd__nor4_1
* pin VPB
* pin D
* pin B
* pin A
* pin C
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 D
* net 3 B
* net 4 A
* net 5 C
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=130000000000P PS=2520000U PD=1260000U
* device instance $2 r0 *1 0.88,1.985 pfet_01v8_hvt
M$2 10 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=130000000000P
+ AD=190000000000P PS=1260000U PD=1380000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 12 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 8 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=118625000000P
+ PS=1820000U PD=1015000U
* device instance $6 r0 *1 0.985,0.56 nfet_01v8
M$6 6 5 7 9 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=89375000000P
+ PS=1015000U PD=925000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 7 3 6 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=87750000000P
+ PS=925000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor4_1

* cell sky130_fd_sc_hd__or4_4
* pin VGND
* pin D
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or4_4 1 2 4 5 6 7 8 9 13
* net 1 VGND
* net 2 D
* net 4 X
* net 5 C
* net 6 B
* net 7 A
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 2 3 9 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=190000000000P PS=2520000U PD=1380000U
* device instance $2 r0 *1 1.025,1.985 pfet_01v8_hvt
M$2 12 5 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $3 r0 *1 1.445,1.985 pfet_01v8_hvt
M$3 11 6 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.865,1.985 pfet_01v8_hvt
M$4 8 7 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=190000000000P PS=1270000U PD=1380000U
* device instance $5 r0 *1 2.395,1.985 pfet_01v8_hvt
M$5 4 3 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=595000000000P
+ AD=675000000000P PS=5190000U PD=6350000U
* device instance $9 r0 *1 0.495,0.56 nfet_01v8
M$9 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=123500000000P
+ PS=1820000U PD=1030000U
* device instance $10 r0 *1 1.025,0.56 nfet_01v8
M$10 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=87750000000P
+ PS=1030000U PD=920000U
* device instance $11 r0 *1 1.445,0.56 nfet_01v8
M$11 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $12 r0 *1 1.865,0.56 nfet_01v8
M$12 1 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $13 r0 *1 2.395,0.56 nfet_01v8
M$13 4 3 1 13 nfet_01v8 L=150000U W=2600000U AS=386750000000P AD=442000000000P
+ PS=3790000U PD=4610000U
.ENDS sky130_fd_sc_hd__or4_4

* cell sky130_fd_sc_hd__dlymetal6s4s_1
* pin VGND
* pin X
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dlymetal6s4s_1 1 5 8 9 10 11
* net 1 VGND
* net 5 X
* net 8 A
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.655,2.275 pfet_01v8_hvt
M$1 6 5 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 4.13,1.985 pfet_01v8_hvt
M$2 7 6 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 2.06,2.275 pfet_01v8_hvt
M$3 4 3 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $4 r0 *1 2.535,1.985 pfet_01v8_hvt
M$4 5 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $5 r0 *1 0.645,2.275 pfet_01v8_hvt
M$5 2 8 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $6 r0 *1 1.12,1.985 pfet_01v8_hvt
M$6 3 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 3.655,0.445 nfet_01v8
M$7 1 5 6 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $8 r0 *1 4.13,0.56 nfet_01v8
M$8 7 6 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $9 r0 *1 2.06,0.445 nfet_01v8
M$9 1 3 4 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $10 r0 *1 2.535,0.56 nfet_01v8
M$10 5 4 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 0.645,0.445 nfet_01v8
M$11 1 8 2 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $12 r0 *1 1.12,0.56 nfet_01v8
M$12 3 2 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
.ENDS sky130_fd_sc_hd__dlymetal6s4s_1

* cell sky130_fd_sc_hd__buf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 3 2 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 4 2 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 3 2 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 4 2 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__buf_1

* cell sky130_fd_sc_hd__nand2b_4
* pin VGND
* pin B
* pin Y
* pin A_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_4 1 2 5 6 7 8 9
* net 1 VGND
* net 2 B
* net 5 Y
* net 6 A_N
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 5 3 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=547500000000P PS=6330000U PD=5095000U
* device instance $5 r0 *1 3.105,1.985 pfet_01v8_hvt
M$5 5 2 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=547500000000P
+ AD=795000000000P PS=5095000U PD=6590000U
* device instance $9 r0 *1 0.47,1.985 pfet_01v8_hvt
M$9 7 6 3 8 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $10 r0 *1 1.41,0.56 nfet_01v8
M$10 5 3 4 9 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=355875000000P
+ PS=4580000U PD=3695000U
* device instance $14 r0 *1 3.105,0.56 nfet_01v8
M$14 1 2 4 9 nfet_01v8 L=150000U W=2600000U AS=355875000000P AD=516750000000P
+ PS=3695000U PD=4840000U
* device instance $18 r0 *1 0.47,0.56 nfet_01v8
M$18 1 6 3 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_4

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__nor4b_1
* pin VPB
* pin C
* pin B
* pin A
* pin D_N
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_1 1 2 3 4 5 6 7 8 10
* net 1 VPB
* net 2 C
* net 3 B
* net 4 A
* net 5 D_N
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 2.535,1.89 pfet_01v8_hvt
M$1 9 5 8 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 13 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=520000000000P
+ AD=135000000000P PS=3040000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 12 2 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.63,1.985 pfet_01v8_hvt
M$4 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=135000000000P PS=1330000U PD=1270000U
* device instance $5 r0 *1 2.05,1.985 pfet_01v8_hvt
M$5 8 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $6 r0 *1 0.73,0.56 nfet_01v8
M$6 7 9 6 10 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $7 r0 *1 1.15,0.56 nfet_01v8
M$7 6 2 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.63,0.56 nfet_01v8
M$8 7 3 6 10 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $9 r0 *1 2.05,0.56 nfet_01v8
M$9 6 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $10 r0 *1 2.535,0.675 nfet_01v8
M$10 9 5 6 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor4b_1

* cell sky130_fd_sc_hd__xor2_1
* pin VPB
* pin B
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xor2_1 1 2 3 6 7 8 9
* net 1 VPB
* net 2 B
* net 3 A
* net 6 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=300000000000P PS=2520000U PD=2600000U
* device instance $2 r0 *1 0.51,1.985 pfet_01v8_hvt
M$2 11 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $3 r0 *1 0.93,1.985 pfet_01v8_hvt
M$3 6 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.35,1.985 pfet_01v8_hvt
M$4 5 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.77,1.985 pfet_01v8_hvt
M$5 6 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.51,0.56 nfet_01v8
M$6 4 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.93,0.56 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.35,0.56 nfet_01v8
M$8 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 1.77,0.56 nfet_01v8
M$9 7 2 10 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=250250000000P
+ PS=920000U PD=1420000U
* device instance $10 r0 *1 2.69,0.56 nfet_01v8
M$10 8 4 7 9 nfet_01v8 L=150000U W=650000U AS=250250000000P AD=208000000000P
+ PS=1420000U PD=1940000U
.ENDS sky130_fd_sc_hd__xor2_1

* cell sky130_fd_sc_hd__fa_2
* pin VGND
* pin COUT
* pin CIN
* pin SUM
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__fa_2 1 2 6 8 12 13 14 15 21
* net 1 VGND
* net 2 COUT
* net 6 CIN
* net 8 SUM
* net 12 A
* net 13 B
* net 14 VPWR
* net 15 VPB
* device instance $1 r0 *1 4.07,2.165 pfet_01v8_hvt
M$1 17 13 14 15 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $2 r0 *1 4.49,2.165 pfet_01v8_hvt
M$2 14 6 17 15 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=86400000000P PS=910000U PD=910000U
* device instance $3 r0 *1 4.91,2.165 pfet_01v8_hvt
M$3 17 12 14 15 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=94400000000P PS=910000U PD=935000U
* device instance $4 r0 *1 5.355,2.165 pfet_01v8_hvt
M$4 7 3 17 15 pfet_01v8_hvt L=150000U W=640000U AS=94400000000P AD=88000000000P
+ PS=935000U PD=915000U
* device instance $5 r0 *1 5.78,2.165 pfet_01v8_hvt
M$5 19 6 7 15 pfet_01v8_hvt L=150000U W=640000U AS=88000000000P
+ AD=103625000000P PS=915000U PD=965000U
* device instance $6 r0 *1 6.255,2.17 pfet_01v8_hvt
M$6 20 13 19 15 pfet_01v8_hvt L=150000U W=630000U AS=103625000000P
+ AD=122850000000P PS=965000U PD=1020000U
* device instance $7 r0 *1 6.795,2.17 pfet_01v8_hvt
M$7 20 12 14 15 pfet_01v8_hvt L=150000U W=630000U AS=148625000000P
+ AD=122850000000P PS=1325000U PD=1020000U
* device instance $8 r0 *1 7.27,1.985 pfet_01v8_hvt
M$8 8 7 14 15 pfet_01v8_hvt L=150000U W=2000000U AS=283625000000P
+ AD=395000000000P PS=2595000U PD=3790000U
* device instance $10 r0 *1 0.475,1.985 pfet_01v8_hvt
M$10 2 3 14 15 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=283625000000P PS=3790000U PD=2595000U
* device instance $12 r0 *1 1.37,2.17 pfet_01v8_hvt
M$12 18 12 14 15 pfet_01v8_hvt L=150000U W=630000U AS=148625000000P
+ AD=92925000000P PS=1325000U PD=925000U
* device instance $13 r0 *1 1.815,2.17 pfet_01v8_hvt
M$13 3 13 18 15 pfet_01v8_hvt L=150000U W=630000U AS=92925000000P
+ AD=102375000000P PS=925000U PD=955000U
* device instance $14 r0 *1 2.29,2.17 pfet_01v8_hvt
M$14 16 6 3 15 pfet_01v8_hvt L=150000U W=630000U AS=102375000000P
+ AD=85050000000P PS=955000U PD=900000U
* device instance $15 r0 *1 2.71,2.17 pfet_01v8_hvt
M$15 14 12 16 15 pfet_01v8_hvt L=150000U W=630000U AS=85050000000P
+ AD=85050000000P PS=900000U PD=900000U
* device instance $16 r0 *1 3.13,2.17 pfet_01v8_hvt
M$16 16 13 14 15 pfet_01v8_hvt L=150000U W=630000U AS=85050000000P
+ AD=163800000000P PS=900000U PD=1780000U
* device instance $17 r0 *1 4.07,0.445 nfet_01v8
M$17 5 13 1 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $18 r0 *1 4.49,0.445 nfet_01v8
M$18 1 6 5 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $19 r0 *1 4.91,0.445 nfet_01v8
M$19 5 12 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=61950000000P
+ PS=690000U PD=715000U
* device instance $20 r0 *1 5.355,0.445 nfet_01v8
M$20 7 3 5 21 nfet_01v8 L=150000U W=420000U AS=61950000000P AD=81900000000P
+ PS=715000U PD=810000U
* device instance $21 r0 *1 5.895,0.445 nfet_01v8
M$21 10 6 7 21 nfet_01v8 L=150000U W=420000U AS=81900000000P AD=44100000000P
+ PS=810000U PD=630000U
* device instance $22 r0 *1 6.255,0.445 nfet_01v8
M$22 11 13 10 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $23 r0 *1 6.735,0.445 nfet_01v8
M$23 1 12 11 21 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=102350000000P
+ PS=750000U PD=995000U
* device instance $24 r0 *1 7.23,0.56 nfet_01v8
M$24 8 7 1 21 nfet_01v8 L=150000U W=1300000U AS=229100000000P AD=295750000000P
+ PS=2035000U PD=2860000U
* device instance $26 r0 *1 1.395,0.445 nfet_01v8
M$26 9 12 1 21 nfet_01v8 L=150000U W=420000U AS=103400000000P AD=68250000000P
+ PS=1000000U PD=745000U
* device instance $27 r0 *1 1.87,0.445 nfet_01v8
M$27 3 13 9 21 nfet_01v8 L=150000U W=420000U AS=68250000000P AD=56700000000P
+ PS=745000U PD=690000U
* device instance $28 r0 *1 2.29,0.445 nfet_01v8
M$28 4 6 3 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $29 r0 *1 2.71,0.445 nfet_01v8
M$29 1 12 4 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $30 r0 *1 3.13,0.445 nfet_01v8
M$30 4 13 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $31 r0 *1 0.475,0.56 nfet_01v8
M$31 2 3 1 21 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=191150000000P
+ PS=2740000U PD=1920000U
.ENDS sky130_fd_sc_hd__fa_2

* cell sky130_fd_sc_hd__xor2_2
* pin VGND
* pin A
* pin B
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xor2_2 1 3 4 6 8 10 11
* net 1 VGND
* net 3 A
* net 4 B
* net 6 X
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 4.94,1.985 pfet_01v8_hvt
M$1 6 2 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=415000000000P PS=3790000U PD=3830000U
* device instance $3 r0 *1 2.685,1.985 pfet_01v8_hvt
M$3 8 3 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 3.525,1.985 pfet_01v8_hvt
M$5 8 4 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=422500000000P PS=2595000U PD=3845000U
* device instance $7 r0 *1 0.485,1.985 pfet_01v8_hvt
M$7 8 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=410000000000P
+ AD=270000000000P PS=3820000U PD=2540000U
* device instance $9 r0 *1 1.325,1.985 pfet_01v8_hvt
M$9 2 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 4.94,0.56 nfet_01v8
M$11 6 2 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
* device instance $13 r0 *1 2.685,0.56 nfet_01v8
M$13 1 3 5 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 3.525,0.56 nfet_01v8
M$15 6 4 5 11 nfet_01v8 L=150000U W=1300000U AS=193375000000P AD=274625000000P
+ PS=1895000U PD=2795000U
* device instance $17 r0 *1 0.485,0.56 nfet_01v8
M$17 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $19 r0 *1 1.325,0.56 nfet_01v8
M$19 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__xor2_2

* cell sky130_fd_sc_hd__xnor2_4
* pin VGND
* pin B
* pin A
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_4 1 2 3 7 8 10 11
* net 1 VGND
* net 2 B
* net 3 A
* net 7 Y
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 4.435,1.985 pfet_01v8_hvt
M$1 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.115,1.985 pfet_01v8_hvt
M$5 7 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 8.335,1.985 pfet_01v8_hvt
M$9 8 5 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $13 r0 *1 0.545,1.985 pfet_01v8_hvt
M$13 8 2 5 10 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $17 r0 *1 2.225,1.985 pfet_01v8_hvt
M$17 8 3 5 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 8.335,0.56 nfet_01v8
M$21 7 5 6 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $25 r0 *1 4.435,0.56 nfet_01v8
M$25 6 3 1 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 6.115,0.56 nfet_01v8
M$29 6 2 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $33 r0 *1 0.545,0.56 nfet_01v8
M$33 5 2 4 11 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $37 r0 *1 2.225,0.56 nfet_01v8
M$37 1 3 4 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__xnor2_4

* cell sky130_fd_sc_hd__o21bai_1
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21bai_1 1 2 4 5 7 8 9 10
* net 1 VPB
* net 2 B1_N
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 VGND
* net 9 Y
* device instance $1 r0 *1 0.86,1.97 pfet_01v8_hvt
M$1 3 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=178250000000P AD=109200000000P
+ PS=1400000U PD=1360000U
* device instance $2 r0 *1 1.41,1.985 pfet_01v8_hvt
M$2 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=178250000000P
+ AD=152500000000P PS=1400000U PD=1305000U
* device instance $3 r0 *1 1.865,1.985 pfet_01v8_hvt
M$3 11 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=127500000000P PS=1305000U PD=1255000U
* device instance $4 r0 *1 2.27,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=127500000000P
+ AD=280000000000P PS=1255000U PD=2560000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 5 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.675 nfet_01v8
M$8 3 2 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__o21bai_1

* cell sky130_fd_sc_hd__or3_1
* pin VPB
* pin A
* pin B
* pin C
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.48,1.695 pfet_01v8_hvt
M$1 11 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.84,1.695 pfet_01v8_hvt
M$2 10 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $3 r0 *1 1.32,1.695 pfet_01v8_hvt
M$3 6 2 10 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $4 r0 *1 1.81,1.985 pfet_01v8_hvt
M$4 5 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=280000000000P PS=1340000U PD=2560000U
* device instance $5 r0 *1 0.48,0.475 nfet_01v8
M$5 7 4 8 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.9,0.475 nfet_01v8
M$6 8 3 7 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $7 r0 *1 1.32,0.475 nfet_01v8
M$7 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $8 r0 *1 1.81,0.56 nfet_01v8
M$8 5 8 7 9 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=182000000000P
+ PS=990000U PD=1860000U
.ENDS sky130_fd_sc_hd__or3_1

* cell sky130_fd_sc_hd__and3_2
* pin VPB
* pin A
* pin B
* pin C
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and3_2 1 2 3 4 6 7 8 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 1.375,1.695 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=150750000000P
+ PS=815000U PD=1345000U
* device instance $2 r0 *1 0.48,1.765 pfet_01v8_hvt
M$2 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 0.9,1.765 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 1.87,1.985 pfet_01v8_hvt
M$4 8 5 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=285750000000P
+ AD=395000000000P PS=2615000U PD=3790000U
* device instance $6 r0 *1 0.485,0.475 nfet_01v8
M$6 11 2 5 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 0.845,0.475 nfet_01v8
M$7 10 3 11 9 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 1.25,0.475 nfet_01v8
M$8 10 4 6 9 nfet_01v8 L=150000U W=420000U AS=130400000000P AD=53550000000P
+ PS=1105000U PD=675000U
* device instance $9 r0 *1 1.855,0.56 nfet_01v8
M$9 8 5 6 9 nfet_01v8 L=150000U W=1300000U AS=218150000000P AD=266500000000P
+ PS=2025000U PD=2770000U
.ENDS sky130_fd_sc_hd__and3_2

* cell sky130_fd_sc_hd__o21ai_4
* pin VGND
* pin A2
* pin B1
* pin A1
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_4 1 2 3 5 6 7 8 10
* net 1 VGND
* net 2 A2
* net 3 B1
* net 5 A1
* net 6 Y
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.5,1.985 pfet_01v8_hvt
M$1 9 5 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=580000000000P PS=6370000U PD=5160000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 2 9 8 pfet_01v8_hvt L=150000U W=4000000U AS=560000000000P
+ AD=560000000000P PS=5120000U PD=5120000U
* device instance $9 r0 *1 3.98,1.985 pfet_01v8_hvt
M$9 6 3 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=580000000000P
+ AD=685000000000P PS=5160000U PD=6370000U
* device instance $13 r0 *1 0.5,0.56 nfet_01v8
M$13 1 5 4 10 nfet_01v8 L=150000U W=2600000U AS=458250000000P AD=364000000000P
+ PS=4660000U PD=3720000U
* device instance $16 r0 *1 1.79,0.56 nfet_01v8
M$16 4 2 1 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=377000000000P
+ PS=3720000U PD=3760000U
* device instance $21 r0 *1 3.98,0.56 nfet_01v8
M$21 6 3 4 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=458250000000P
+ PS=3720000U PD=4660000U
.ENDS sky130_fd_sc_hd__o21ai_4

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__nor3_4
* pin VGND
* pin A
* pin Y
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3_4 1 2 3 4 5 7 9 10
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 B
* net 5 C
* net 7 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 7 2 6 9 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $5 r0 *1 2.17,1.985 pfet_01v8_hvt
M$5 8 4 6 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $8 r0 *1 3.43,1.985 pfet_01v8_hvt
M$8 3 5 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 3 2 1 10 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $17 r0 *1 2.17,0.56 nfet_01v8
M$17 3 4 1 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $20 r0 *1 3.43,0.56 nfet_01v8
M$20 1 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
.ENDS sky130_fd_sc_hd__nor3_4

* cell sky130_fd_sc_hd__o31ai_4
* pin VGND
* pin B1
* pin Y
* pin A1
* pin A2
* pin A3
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_4 1 2 4 5 6 7 10 11 12
* net 1 VGND
* net 2 B1
* net 4 Y
* net 5 A1
* net 6 A2
* net 7 A3
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.385,1.985 pfet_01v8_hvt
M$1 9 7 4 11 pfet_01v8_hvt L=150000U W=4000000U AS=667800000000P
+ AD=540000000000P PS=6380000U PD=5080000U
* device instance $5 r0 *1 6.065,1.985 pfet_01v8_hvt
M$5 10 2 4 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 10 5 8 11 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $13 r0 *1 2.17,1.985 pfet_01v8_hvt
M$13 9 6 8 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665500000000P PS=5080000U PD=6370000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 1 5 3 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 2.17,0.56 nfet_01v8
M$21 1 6 3 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
* device instance $25 r0 *1 3.85,0.56 nfet_01v8
M$25 1 7 3 12 nfet_01v8 L=150000U W=2600000U AS=524875000000P AD=524875000000P
+ PS=4215000U PD=4215000U
* device instance $29 r0 *1 6.065,0.56 nfet_01v8
M$29 4 2 3 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o31ai_4

* cell sky130_fd_sc_hd__a32oi_2
* pin VGND
* pin A3
* pin Y
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a32oi_2 1 2 4 7 8 9 10 12 13 14
* net 1 VGND
* net 2 A3
* net 4 Y
* net 7 B2
* net 8 B1
* net 9 A1
* net 10 A2
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 7 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 4 8 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 12 9 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=512500000000P
+ AD=527500000000P PS=3025000U PD=3055000U
* device instance $7 r0 *1 3.505,1.985 pfet_01v8_hvt
M$7 12 10 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=455000000000P
+ AD=442500000000P PS=2910000U PD=2885000U
* device instance $9 r0 *1 4.69,1.985 pfet_01v8_hvt
M$9 12 2 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=472500000000P
+ AD=595000000000P PS=2945000U PD=4190000U
* device instance $11 r0 *1 4.99,0.56 nfet_01v8
M$11 6 2 1 14 nfet_01v8 L=150000U W=1300000U AS=325000000000P AD=289250000000P
+ PS=2950000U PD=2840000U
* device instance $13 r0 *1 2.725,0.56 nfet_01v8
M$13 4 9 5 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=178750000000P
+ PS=2740000U PD=1850000U
* device instance $15 r0 *1 3.575,0.56 nfet_01v8
M$15 6 10 5 14 nfet_01v8 L=150000U W=1300000U AS=178750000000P AD=256750000000P
+ PS=1850000U PD=2740000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 1 7 3 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $19 r0 *1 1.31,0.56 nfet_01v8
M$19 4 8 3 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a32oi_2

* cell sky130_fd_sc_hd__o22a_2
* pin VGND
* pin X
* pin B1
* pin B2
* pin A2
* pin A1
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22a_2 1 2 4 6 7 8 9 10 13
* net 1 VGND
* net 2 X
* net 4 B1
* net 6 B2
* net 7 A2
* net 8 A1
* net 9 VPB
* net 10 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 2 3 10 9 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=525000000000P PS=3830000U PD=3050000U
* device instance $3 r0 *1 1.84,1.985 pfet_01v8_hvt
M$3 11 4 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=390000000000P
+ AD=105000000000P PS=1780000U PD=1210000U
* device instance $4 r0 *1 2.2,1.985 pfet_01v8_hvt
M$4 3 6 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=235000000000P PS=1210000U PD=1470000U
* device instance $5 r0 *1 2.82,1.985 pfet_01v8_hvt
M$5 12 7 3 9 pfet_01v8_hvt L=150000U W=1000000U AS=235000000000P
+ AD=105000000000P PS=1470000U PD=1210000U
* device instance $6 r0 *1 3.18,1.985 pfet_01v8_hvt
M$6 10 8 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=280000000000P PS=1210000U PD=2560000U
* device instance $7 r0 *1 1.84,0.56 nfet_01v8
M$7 3 4 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.26,0.56 nfet_01v8
M$8 5 6 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $9 r0 *1 2.79,0.56 nfet_01v8
M$9 1 7 5 13 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=87750000000P
+ PS=1030000U PD=920000U
* device instance $10 r0 *1 3.21,0.56 nfet_01v8
M$10 5 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $11 r0 *1 0.48,0.56 nfet_01v8
M$11 2 3 1 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__o22a_2

* cell sky130_fd_sc_hd__inv_4
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_4 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 VPWR
* net 5 Y
* device instance $1 r0 *1 0.52,1.985 pfet_01v8_hvt
M$1 5 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=665000000000P PS=6330000U PD=6330000U
* device instance $5 r0 *1 0.52,0.56 nfet_01v8
M$5 5 2 3 6 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=432250000000P
+ PS=4580000U PD=4580000U
.ENDS sky130_fd_sc_hd__inv_4

* cell sky130_fd_sc_hd__nor2b_4
* pin VGND
* pin Y
* pin A
* pin B_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_4 1 3 4 5 7 8 9
* net 1 VGND
* net 3 Y
* net 4 A
* net 5 B_N
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 4.4,1.985 pfet_01v8_hvt
M$1 7 5 2 8 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=280000000000P PS=2540000U PD=2560000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 7 4 6 8 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $6 r0 *1 2.17,1.985 pfet_01v8_hvt
M$6 3 2 6 8 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=685000000000P PS=5080000U PD=6370000U
* device instance $10 r0 *1 0.49,0.56 nfet_01v8
M$10 3 4 1 9 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $14 r0 *1 2.17,0.56 nfet_01v8
M$14 3 2 1 9 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $18 r0 *1 4.4,0.56 nfet_01v8
M$18 1 5 2 9 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=175500000000P
+ PS=1860000U PD=1840000U
.ENDS sky130_fd_sc_hd__nor2b_4

* cell sky130_fd_sc_hd__a21boi_0
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_0 1 2 3 4 6 8 9 10
* net 1 VPB
* net 2 B1_N
* net 3 A1
* net 4 A2
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 1.425,2.165 pfet_01v8_hvt
M$1 5 7 9 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=89600000000P
+ PS=1810000U PD=920000U
* device instance $2 r0 *1 1.855,2.165 pfet_01v8_hvt
M$2 8 3 5 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=89600000000P
+ PS=920000U PD=920000U
* device instance $3 r0 *1 2.285,2.165 pfet_01v8_hvt
M$3 5 4 8 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=169600000000P
+ PS=920000U PD=1810000U
* device instance $4 r0 *1 0.475,2.275 pfet_01v8_hvt
M$4 8 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=111300000000P
+ PS=1370000U PD=1370000U
* device instance $5 r0 *1 0.475,0.445 nfet_01v8
M$5 6 2 7 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=130200000000P
+ PS=1370000U PD=1040000U
* device instance $6 r0 *1 1.245,0.445 nfet_01v8
M$6 9 7 6 10 nfet_01v8 L=150000U W=420000U AS=130200000000P AD=111300000000P
+ PS=1040000U PD=950000U
* device instance $7 r0 *1 1.925,0.445 nfet_01v8
M$7 11 3 9 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=950000U PD=630000U
* device instance $8 r0 *1 2.285,0.445 nfet_01v8
M$8 6 4 11 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=111300000000P
+ PS=630000U PD=1370000U
.ENDS sky130_fd_sc_hd__a21boi_0

* cell sky130_fd_sc_hd__mux2i_4
* pin VGND
* pin A0
* pin Y
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_4 1 2 3 7 8 10 11 13
* net 1 VGND
* net 2 A0
* net 3 Y
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.35,1.985 pfet_01v8_hvt
M$1 9 8 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.03,1.985 pfet_01v8_hvt
M$5 12 6 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=567500000000P
+ AD=590000000000P PS=5135000U PD=5180000U
* device instance $9 r0 *1 7.81,1.985 pfet_01v8_hvt
M$9 6 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=157500000000P
+ AD=260000000000P PS=1315000U PD=2520000U
* device instance $10 r0 *1 0.47,1.985 pfet_01v8_hvt
M$10 9 2 3 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $14 r0 *1 2.15,1.985 pfet_01v8_hvt
M$14 12 7 3 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $18 r0 *1 4.35,0.56 nfet_01v8
M$18 5 8 1 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $22 r0 *1 6.03,0.56 nfet_01v8
M$22 4 6 1 13 nfet_01v8 L=150000U W=2600000U AS=368875000000P AD=383500000000P
+ PS=3735000U PD=3780000U
* device instance $26 r0 *1 7.81,0.56 nfet_01v8
M$26 6 8 1 13 nfet_01v8 L=150000U W=650000U AS=102375000000P AD=169000000000P
+ PS=965000U PD=1820000U
* device instance $27 r0 *1 0.47,0.56 nfet_01v8
M$27 4 2 3 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $31 r0 *1 2.15,0.56 nfet_01v8
M$31 5 7 3 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__mux2i_4

* cell sky130_fd_sc_hd__mux2_2
* pin VGND
* pin X
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_2 1 2 4 5 6 10 11 14
* net 1 VGND
* net 2 X
* net 4 A0
* net 5 A1
* net 6 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=312800000000P PS=3790000U PD=2685000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 12 9 10 11 pfet_01v8_hvt L=150000U W=640000U AS=177800000000P
+ AD=228800000000P PS=1415000U PD=1355000U
* device instance $4 r0 *1 2.32,2.165 pfet_01v8_hvt
M$4 3 5 12 11 pfet_01v8_hvt L=150000U W=640000U AS=228800000000P
+ AD=131200000000P PS=1355000U PD=1050000U
* device instance $5 r0 *1 2.88,2.165 pfet_01v8_hvt
M$5 13 4 3 11 pfet_01v8_hvt L=150000U W=640000U AS=131200000000P
+ AD=67200000000P PS=1050000U PD=850000U
* device instance $6 r0 *1 3.24,2.165 pfet_01v8_hvt
M$6 10 6 13 11 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=86400000000P PS=850000U PD=910000U
* device instance $7 r0 *1 3.66,2.165 pfet_01v8_hvt
M$7 9 6 10 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=172800000000P PS=910000U PD=1820000U
* device instance $8 r0 *1 1.365,0.445 nfet_01v8
M$8 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=68250000000P
+ PS=975000U PD=745000U
* device instance $9 r0 *1 1.84,0.445 nfet_01v8
M$9 3 4 7 14 nfet_01v8 L=150000U W=420000U AS=68250000000P AD=173250000000P
+ PS=745000U PD=1245000U
* device instance $10 r0 *1 2.815,0.445 nfet_01v8
M$10 8 5 3 14 nfet_01v8 L=150000U W=420000U AS=173250000000P AD=57750000000P
+ PS=1245000U PD=695000U
* device instance $11 r0 *1 3.24,0.445 nfet_01v8
M$11 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=57750000000P AD=56700000000P
+ PS=695000U PD=690000U
* device instance $12 r0 *1 3.66,0.445 nfet_01v8
M$12 9 6 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=113400000000P
+ PS=690000U PD=1380000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 2 3 1 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=184750000000P
+ PS=2740000U PD=1895000U
.ENDS sky130_fd_sc_hd__mux2_2

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__mux4_2
* pin VGND
* pin A2
* pin A0
* pin X
* pin S0
* pin A3
* pin S1
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux4_2 1 3 8 9 14 15 16 17 18 19 24
* net 1 VGND
* net 3 A2
* net 8 A0
* net 9 X
* net 14 S0
* net 15 A3
* net 16 S1
* net 17 A1
* net 18 VPWR
* net 19 VPB
* device instance $1 r0 *1 5.225,2.165 pfet_01v8_hvt
M$1 22 17 18 19 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=137750000000P PS=1800000U PD=1165000U
* device instance $2 r0 *1 5.9,2.275 pfet_01v8_hvt
M$2 7 2 22 19 pfet_01v8_hvt L=150000U W=420000U AS=137750000000P
+ AD=56700000000P PS=1165000U PD=690000U
* device instance $3 r0 *1 6.32,2.275 pfet_01v8_hvt
M$3 7 14 23 19 pfet_01v8_hvt L=150000U W=420000U AS=105350000000P
+ AD=56700000000P PS=995000U PD=690000U
* device instance $4 r0 *1 6.825,2.165 pfet_01v8_hvt
M$4 23 8 18 19 pfet_01v8_hvt L=150000U W=640000U AS=154000000000P
+ AD=105350000000P PS=1335000U PD=995000U
* device instance $5 r0 *1 7.31,1.985 pfet_01v8_hvt
M$5 9 6 18 19 pfet_01v8_hvt L=150000U W=2000000U AS=289000000000P
+ AD=475000000000P PS=2605000U PD=3950000U
* device instance $7 r0 *1 3.865,1.85 pfet_01v8_hvt
M$7 6 5 4 19 pfet_01v8_hvt L=150000U W=540000U AS=140400000000P AD=72900000000P
+ PS=1600000U PD=810000U
* device instance $8 r0 *1 4.285,1.85 pfet_01v8_hvt
M$8 7 16 6 19 pfet_01v8_hvt L=150000U W=540000U AS=72900000000P
+ AD=140400000000P PS=810000U PD=1600000U
* device instance $9 r0 *1 2.505,2.045 pfet_01v8_hvt
M$9 18 15 21 19 pfet_01v8_hvt L=150000U W=640000U AS=164500000000P
+ AD=86400000000P PS=1330000U PD=910000U
* device instance $10 r0 *1 2.925,2.045 pfet_01v8_hvt
M$10 5 16 18 19 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $11 r0 *1 0.47,2.165 pfet_01v8_hvt
M$11 18 14 2 19 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $12 r0 *1 0.89,2.165 pfet_01v8_hvt
M$12 20 3 18 19 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=95750000000P PS=910000U PD=965000U
* device instance $13 r0 *1 1.365,2.275 pfet_01v8_hvt
M$13 4 14 20 19 pfet_01v8_hvt L=150000U W=420000U AS=95750000000P
+ AD=56700000000P PS=965000U PD=690000U
* device instance $14 r0 *1 1.785,2.275 pfet_01v8_hvt
M$14 4 2 21 19 pfet_01v8_hvt L=150000U W=420000U AS=164500000000P
+ AD=56700000000P PS=1330000U PD=690000U
* device instance $15 r0 *1 1.365,0.415 nfet_01v8
M$15 4 2 10 24 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=71100000000P
+ PS=745000U PD=755000U
* device instance $16 r0 *1 1.91,0.415 nfet_01v8
M$16 11 14 4 24 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=67050000000P
+ PS=755000U PD=750000U
* device instance $17 r0 *1 0.47,0.445 nfet_01v8
M$17 1 14 2 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $18 r0 *1 0.89,0.445 nfet_01v8
M$18 10 3 1 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=66000000000P
+ PS=690000U PD=745000U
* device instance $19 r0 *1 2.39,0.445 nfet_01v8
M$19 1 15 11 24 nfet_01v8 L=150000U W=420000U AS=67050000000P AD=81900000000P
+ PS=750000U PD=810000U
* device instance $20 r0 *1 2.93,0.445 nfet_01v8
M$20 5 16 1 24 nfet_01v8 L=150000U W=420000U AS=81900000000P AD=113400000000P
+ PS=810000U PD=1380000U
* device instance $21 r0 *1 5.78,0.415 nfet_01v8
M$21 7 14 13 24 nfet_01v8 L=150000U W=360000U AS=78600000000P AD=72000000000P
+ PS=805000U PD=760000U
* device instance $22 r0 *1 6.33,0.415 nfet_01v8
M$22 12 2 7 24 nfet_01v8 L=150000U W=360000U AS=72000000000P AD=66000000000P
+ PS=760000U PD=745000U
* device instance $23 r0 *1 5.245,0.445 nfet_01v8
M$23 13 17 1 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=78600000000P
+ PS=1360000U PD=805000U
* device instance $24 r0 *1 6.805,0.445 nfet_01v8
M$24 1 8 12 24 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=106750000000P
+ PS=745000U PD=1005000U
* device instance $25 r0 *1 7.31,0.56 nfet_01v8
M$25 9 6 1 24 nfet_01v8 L=150000U W=1300000U AS=194500000000P AD=308750000000P
+ PS=1925000U PD=2900000U
* device instance $27 r0 *1 3.88,0.445 nfet_01v8
M$27 6 16 4 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=57750000000P
+ PS=1360000U PD=695000U
* device instance $28 r0 *1 4.305,0.445 nfet_01v8
M$28 7 5 6 24 nfet_01v8 L=150000U W=420000U AS=57750000000P AD=109200000000P
+ PS=695000U PD=1360000U
.ENDS sky130_fd_sc_hd__mux4_2

* cell sky130_fd_sc_hd__and3_4
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_4 1 3 4 5 6 9 10 11
* net 1 VGND
* net 3 B
* net 4 X
* net 5 A
* net 6 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.85,1.985 pfet_01v8_hvt
M$1 9 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=197500000000P PS=2610000U PD=1395000U
* device instance $2 r0 *1 1.395,1.985 pfet_01v8_hvt
M$2 2 3 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=140000000000P PS=1395000U PD=1280000U
* device instance $3 r0 *1 1.825,1.985 pfet_01v8_hvt
M$3 9 6 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=177500000000P PS=1280000U PD=1355000U
* device instance $4 r0 *1 2.33,1.985 pfet_01v8_hvt
M$4 4 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=597500000000P
+ AD=705000000000P PS=5195000U PD=6410000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 5 2 11 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=128375000000P
+ PS=1910000U PD=1045000U
* device instance $9 r0 *1 1.395,0.56 nfet_01v8
M$9 7 3 8 11 nfet_01v8 L=150000U W=650000U AS=128375000000P AD=68250000000P
+ PS=1045000U PD=860000U
* device instance $10 r0 *1 1.755,0.56 nfet_01v8
M$10 1 6 7 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=138125000000P
+ PS=860000U PD=1075000U
* device instance $11 r0 *1 2.33,0.56 nfet_01v8
M$11 4 2 1 11 nfet_01v8 L=150000U W=2600000U AS=411125000000P AD=458250000000P
+ PS=3865000U PD=4660000U
.ENDS sky130_fd_sc_hd__and3_4

* cell sky130_fd_sc_hd__o221ai_4
* pin VGND
* pin B2
* pin A2
* pin C1
* pin Y
* pin B1
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o221ai_4 1 2 3 5 6 8 9 10 11 14
* net 1 VGND
* net 2 B2
* net 3 A2
* net 5 C1
* net 6 Y
* net 8 B1
* net 9 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 5 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=800000000000P PS=6370000U PD=5600000U
* device instance $5 r0 *1 2.69,1.985 pfet_01v8_hvt
M$5 12 8 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=580000000000P PS=5600000U PD=5160000U
* device instance $8 r0 *1 3.95,1.985 pfet_01v8_hvt
M$8 6 2 12 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $13 r0 *1 6.13,1.985 pfet_01v8_hvt
M$13 13 9 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=580000000000P
+ AD=700000000000P PS=5160000U PD=6400000U
* device instance $14 r0 *1 6.55,1.985 pfet_01v8_hvt
M$14 6 3 13 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $21 r0 *1 0.49,0.56 nfet_01v8
M$21 6 5 4 14 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=432250000000P
+ PS=4620000U PD=4580000U
* device instance $25 r0 *1 2.69,0.56 nfet_01v8
M$25 4 8 7 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=377000000000P
+ PS=4580000U PD=3760000U
* device instance $28 r0 *1 3.95,0.56 nfet_01v8
M$28 7 2 4 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
* device instance $33 r0 *1 6.13,0.56 nfet_01v8
M$33 1 9 7 14 nfet_01v8 L=150000U W=2600000U AS=377000000000P AD=432250000000P
+ PS=3760000U PD=4580000U
* device instance $34 r0 *1 6.55,0.56 nfet_01v8
M$34 7 3 1 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
.ENDS sky130_fd_sc_hd__o221ai_4

* cell sky130_fd_sc_hd__and2_2
* pin VPB
* pin A
* pin B
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_2 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 VPWR
* net 6 X
* net 7 VGND
* device instance $1 r0 *1 0.66,2.065 pfet_01v8_hvt
M$1 4 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $2 r0 *1 1.08,2.065 pfet_01v8_hvt
M$2 4 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=166550000000P AD=56700000000P
+ PS=1390000U PD=690000U
* device instance $3 r0 *1 1.62,1.985 pfet_01v8_hvt
M$3 6 4 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=361550000000P
+ AD=575000000000P PS=2780000U PD=4150000U
* device instance $5 r0 *1 0.66,0.585 nfet_01v8
M$5 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $6 r0 *1 1.08,0.585 nfet_01v8
M$6 9 3 7 8 nfet_01v8 L=150000U W=420000U AS=111800000000P AD=56700000000P
+ PS=1040000U PD=690000U
* device instance $7 r0 *1 1.62,0.56 nfet_01v8
M$7 6 4 7 8 nfet_01v8 L=150000U W=1300000U AS=238550000000P AD=373750000000P
+ PS=2080000U PD=3100000U
.ENDS sky130_fd_sc_hd__and2_2

* cell sky130_fd_sc_hd__nor2_8
* pin VGND
* pin A
* pin B
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor2_8 1 2 3 4 6 7 8
* net 1 VGND
* net 2 A
* net 3 B
* net 4 Y
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 5 7 pfet_01v8_hvt L=150000U W=8000000U AS=1.225e+12P AD=1.08e+12P
+ PS=11450000U PD=10160000U
* device instance $9 r0 *1 3.85,1.985 pfet_01v8_hvt
M$9 4 3 5 7 pfet_01v8_hvt L=150000U W=8000000U AS=1.08e+12P AD=1.215e+12P
+ PS=10160000U PD=11430000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 4 2 1 8 nfet_01v8 L=150000U W=5200000U AS=796250000000P AD=702000000000P
+ PS=8300000U PD=7360000U
* device instance $25 r0 *1 3.85,0.56 nfet_01v8
M$25 4 3 1 8 nfet_01v8 L=150000U W=5200000U AS=702000000000P AD=783250000000P
+ PS=7360000U PD=8260000U
.ENDS sky130_fd_sc_hd__nor2_8

* cell sky130_fd_sc_hd__a22oi_4
* pin VGND
* pin B1
* pin B2
* pin Y
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_4 1 2 4 5 7 8 10 11 12
* net 1 VGND
* net 2 B1
* net 4 B2
* net 5 Y
* net 7 A1
* net 8 A2
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 5 2 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=800000000000P PS=5080000U PD=5600000U
* device instance $9 r0 *1 4.35,1.985 pfet_01v8_hvt
M$9 10 7 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=540000000000P PS=5600000U PD=5080000U
* device instance $13 r0 *1 6.03,1.985 pfet_01v8_hvt
M$13 10 8 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=705000000000P PS=5080000U PD=6410000U
* device instance $17 r0 *1 4.35,0.56 nfet_01v8
M$17 5 7 6 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 6.03,0.56 nfet_01v8
M$21 1 8 6 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $25 r0 *1 0.47,0.56 nfet_01v8
M$25 1 4 3 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 2.15,0.56 nfet_01v8
M$29 5 2 3 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__a22oi_4

* cell sky130_fd_sc_hd__dlymetal6s2s_1
* pin VGND
* pin X
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dlymetal6s2s_1 1 3 8 9 10 11
* net 1 VGND
* net 3 X
* net 8 A
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.655,2.275 pfet_01v8_hvt
M$1 6 5 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 4.13,1.985 pfet_01v8_hvt
M$2 7 6 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 2.24,2.275 pfet_01v8_hvt
M$3 4 3 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $4 r0 *1 2.715,1.985 pfet_01v8_hvt
M$4 5 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $5 r0 *1 0.645,2.275 pfet_01v8_hvt
M$5 2 8 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $6 r0 *1 1.12,1.985 pfet_01v8_hvt
M$6 3 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 3.655,0.445 nfet_01v8
M$7 1 5 6 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $8 r0 *1 4.13,0.56 nfet_01v8
M$8 7 6 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $9 r0 *1 2.24,0.445 nfet_01v8
M$9 1 3 4 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $10 r0 *1 2.715,0.56 nfet_01v8
M$10 5 4 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 0.645,0.445 nfet_01v8
M$11 1 8 2 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $12 r0 *1 1.12,0.56 nfet_01v8
M$12 3 2 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
.ENDS sky130_fd_sc_hd__dlymetal6s2s_1

* cell sky130_fd_sc_hd__and2_4
* pin VPB
* pin A
* pin B
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__and2_4 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 VGND
* net 6 X
* net 7 VPWR
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 4 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.905,1.985 pfet_01v8_hvt
M$2 7 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=177500000000P PS=1280000U PD=1355000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=4000000U AS=597500000000P
+ AD=705000000000P PS=5195000U PD=6410000U
* device instance $7 r0 *1 0.475,0.56 nfet_01v8
M$7 9 2 4 8 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $8 r0 *1 0.835,0.56 nfet_01v8
M$8 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=138125000000P
+ PS=860000U PD=1075000U
* device instance $9 r0 *1 1.41,0.56 nfet_01v8
M$9 6 4 5 8 nfet_01v8 L=150000U W=2600000U AS=411125000000P AD=458250000000P
+ PS=3865000U PD=4660000U
.ENDS sky130_fd_sc_hd__and2_4

* cell sky130_fd_sc_hd__mux2i_2
* pin VGND
* pin S
* pin A0
* pin A1
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_2 1 2 6 7 8 11 12 13
* net 1 VGND
* net 2 S
* net 6 A0
* net 7 A1
* net 8 VPWR
* net 11 Y
* net 12 VPB
* device instance $1 r0 *1 3.09,1.985 pfet_01v8_hvt
M$1 9 6 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=290000000000P PS=3790000U PD=2580000U
* device instance $3 r0 *1 3.97,1.985 pfet_01v8_hvt
M$3 10 7 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=292500000000P
+ AD=592500000000P PS=2585000U PD=4185000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $6 r0 *1 0.89,1.985 pfet_01v8_hvt
M$6 9 2 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $8 r0 *1 1.73,1.985 pfet_01v8_hvt
M$8 10 3 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $10 r0 *1 3.09,0.56 nfet_01v8
M$10 5 6 11 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=188500000000P
+ PS=2740000U PD=1880000U
* device instance $12 r0 *1 3.97,0.56 nfet_01v8
M$12 4 7 11 13 nfet_01v8 L=150000U W=1300000U AS=190125000000P AD=385125000000P
+ PS=1885000U PD=3135000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 2 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $15 r0 *1 0.89,0.56 nfet_01v8
M$15 4 2 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 1.73,0.56 nfet_01v8
M$17 5 3 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__mux2i_2

* cell sky130_fd_sc_hd__o31ai_2
* pin VGND
* pin A1
* pin A2
* pin A3
* pin Y
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_2 1 3 4 5 6 7 9 11 12
* net 1 VGND
* net 3 A1
* net 4 A2
* net 5 A3
* net 6 Y
* net 7 B1
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 10 5 6 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.55,1.985 pfet_01v8_hvt
M$3 9 7 6 11 pfet_01v8_hvt L=150000U W=2000000U AS=330000000000P
+ AD=455000000000P PS=2660000U PD=3910000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 9 3 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 10 4 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 1 3 2 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 1.33,0.56 nfet_01v8
M$11 1 4 2 12 nfet_01v8 L=150000U W=1300000U AS=286000000000P AD=325000000000P
+ PS=2180000U PD=2300000U
* device instance $13 r0 *1 2.63,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=240500000000P AD=201500000000P
+ PS=2040000U PD=1920000U
* device instance $15 r0 *1 3.55,0.56 nfet_01v8
M$15 6 7 2 12 nfet_01v8 L=150000U W=1300000U AS=214500000000P AD=295750000000P
+ PS=1960000U PD=2860000U
.ENDS sky130_fd_sc_hd__o31ai_2

* cell sky130_fd_sc_hd__a2bb2oi_1
* pin VGND
* pin Y
* pin B2
* pin A1_N
* pin A2_N
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2bb2oi_1 1 3 4 5 6 7 10 11 13
* net 1 VGND
* net 3 Y
* net 4 B2
* net 5 A1_N
* net 6 A2_N
* net 7 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.91,1.985 pfet_01v8_hvt
M$1 9 2 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=340000000000P
+ AD=135000000000P PS=2680000U PD=1270000U
* device instance $2 r0 *1 2.33,1.985 pfet_01v8_hvt
M$2 10 4 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 12 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $5 r0 *1 0.83,1.985 pfet_01v8_hvt
M$5 2 6 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 5 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 1 6 2 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=282750000000P
+ PS=920000U PD=1520000U
* device instance $8 r0 *1 1.91,0.56 nfet_01v8
M$8 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=282750000000P AD=87750000000P
+ PS=1520000U PD=920000U
* device instance $9 r0 *1 2.33,0.56 nfet_01v8
M$9 8 4 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 1 7 8 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__a2bb2oi_1

* cell sky130_fd_sc_hd__buf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 2 3 6 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.08e+12P AD=1.205e+12P
+ PS=10160000U PD=11410000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 2 3 7 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $15 r0 *1 1.73,0.56 nfet_01v8
M$15 4 3 1 7 nfet_01v8 L=150000U W=5200000U AS=702000000000P AD=783250000000P
+ PS=7360000U PD=8260000U
.ENDS sky130_fd_sc_hd__buf_8

* cell sky130_fd_sc_hd__o22a_4
* pin VGND
* pin X
* pin B1
* pin B2
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o22a_4 1 3 5 6 7 8 9 12 13
* net 1 VGND
* net 3 X
* net 5 B1
* net 6 B2
* net 7 A1
* net 8 A2
* net 9 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.555,1.985 pfet_01v8_hvt
M$1 3 2 9 12 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=800000000000P PS=6370000U PD=5600000U
* device instance $5 r0 *1 2.755,1.985 pfet_01v8_hvt
M$5 10 5 9 12 pfet_01v8_hvt L=150000U W=2000000U AS=530000000000P
+ AD=310000000000P PS=3060000U PD=2620000U
* device instance $6 r0 *1 3.175,1.985 pfet_01v8_hvt
M$6 2 6 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 4.515,1.985 pfet_01v8_hvt
M$9 11 7 9 12 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $10 r0 *1 4.935,1.985 pfet_01v8_hvt
M$10 2 8 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $13 r0 *1 2.755,0.56 nfet_01v8
M$13 2 5 4 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=201500000000P
+ PS=2740000U PD=1920000U
* device instance $14 r0 *1 3.175,0.56 nfet_01v8
M$14 4 6 2 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 4.515,0.56 nfet_01v8
M$17 1 7 4 13 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $18 r0 *1 4.935,0.56 nfet_01v8
M$18 4 8 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $21 r0 *1 0.555,0.56 nfet_01v8
M$21 3 2 1 13 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=432250000000P
+ PS=4620000U PD=4580000U
.ENDS sky130_fd_sc_hd__o22a_4

* cell sky130_fd_sc_hd__nand3_4
* pin VGND
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_4 1 2 5 6 7 8 9 10
* net 1 VGND
* net 2 C
* net 5 B
* net 6 A
* net 7 VPWR
* net 8 Y
* net 9 VPB
* device instance $1 r0 *1 4.35,1.985 pfet_01v8_hvt
M$1 8 6 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=675000000000P PS=6330000U PD=6350000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 2.15,1.985 pfet_01v8_hvt
M$9 8 5 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 4.35,0.56 nfet_01v8
M$13 8 6 4 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=438750000000P
+ PS=4580000U PD=4600000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 1 2 3 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 2.15,0.56 nfet_01v8
M$21 4 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand3_4

* cell sky130_fd_sc_hd__a22oi_2
* pin VGND
* pin B2
* pin B1
* pin Y
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_2 1 3 4 5 7 8 10 11 12
* net 1 VGND
* net 3 B2
* net 4 B1
* net 5 Y
* net 7 A1
* net 8 A2
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 3.51,1.985 pfet_01v8_hvt
M$3 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 9 3 5 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 9 4 5 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 2.67,0.56 nfet_01v8
M$9 5 7 6 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 3.51,0.56 nfet_01v8
M$11 1 8 6 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 3 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 5 4 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a22oi_2

* cell sky130_fd_sc_hd__or2_0
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_0 1 2 3 4 6 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 9 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.985 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=98950000000P
+ PS=630000U PD=975000U
* device instance $3 r0 *1 1.52,2.095 pfet_01v8_hvt
M$3 4 5 7 1 pfet_01v8_hvt L=150000U W=640000U AS=98950000000P AD=217600000000P
+ PS=975000U PD=1960000U
* device instance $4 r0 *1 0.615,0.675 nfet_01v8
M$4 5 2 6 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.675 nfet_01v8
M$5 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=70350000000P
+ PS=690000U PD=755000U
* device instance $6 r0 *1 1.52,0.675 nfet_01v8
M$6 4 5 6 8 nfet_01v8 L=150000U W=420000U AS=70350000000P AD=109200000000P
+ PS=755000U PD=1360000U
.ENDS sky130_fd_sc_hd__or2_0

* cell sky130_fd_sc_hd__a221o_1
* pin VGND
* pin B1
* pin A1
* pin X
* pin C1
* pin B2
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221o_1 1 3 4 5 8 9 10 13 14 15
* net 1 VGND
* net 3 B1
* net 4 A1
* net 5 X
* net 8 C1
* net 9 B2
* net 10 A2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=165000000000P PS=2520000U PD=1330000U
* device instance $2 r0 *1 2.73,1.985 pfet_01v8_hvt
M$2 13 10 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=157500000000P PS=1330000U PD=1315000U
* device instance $3 r0 *1 3.195,1.985 pfet_01v8_hvt
M$3 5 2 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=157500000000P
+ AD=260000000000P PS=1315000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 11 8 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 12 9 11 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $6 r0 *1 1.31,1.985 pfet_01v8_hvt
M$6 11 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $7 r0 *1 2.25,0.56 nfet_01v8
M$7 7 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $8 r0 *1 2.73,0.56 nfet_01v8
M$8 1 10 7 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=102375000000P
+ PS=980000U PD=965000U
* device instance $9 r0 *1 3.195,0.56 nfet_01v8
M$9 5 2 1 15 nfet_01v8 L=150000U W=650000U AS=102375000000P AD=169000000000P
+ PS=965000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 8 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $11 r0 *1 0.95,0.56 nfet_01v8
M$11 6 9 1 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=68250000000P
+ PS=980000U PD=860000U
* device instance $12 r0 *1 1.31,0.56 nfet_01v8
M$12 2 3 6 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221o_1

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__nand2_2
* pin VGND
* pin
* pin B
* pin Y
* pin A
* pin VPB
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nand2_2 1 2 4 5 6 7 8
* net 1 VGND
* net 4 B
* net 5 Y
* net 6 A
* net 7 VPB
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 5 6 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 1 4 3 2 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 5 6 3 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand2_2

* cell sky130_fd_sc_hd__clkbuf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 1.335,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.12e+12P AD=1.245e+12P
+ PS=10240000U PD=11490000U
* device instance $11 r0 *1 0.475,0.445 nfet_01v8
M$11 3 2 1 7 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=117600000000P
+ PS=2070000U PD=1400000U
* device instance $13 r0 *1 1.335,0.445 nfet_01v8
M$13 4 3 1 7 nfet_01v8 L=150000U W=3360000U AS=470400000000P AD=525000000000P
+ PS=5600000U PD=6280000U
.ENDS sky130_fd_sc_hd__clkbuf_8

* cell sky130_fd_sc_hd__o211ai_2
* pin VGND
* pin Y
* pin A1
* pin C1
* pin B1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_2 1 3 5 6 7 8 9 11 12
* net 1 VGND
* net 3 Y
* net 5 A1
* net 6 C1
* net 7 B1
* net 8 A2
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.775,1.985 pfet_01v8_hvt
M$1 3 8 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 3.635,1.985 pfet_01v8_hvt
M$3 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $5 r0 *1 0.495,1.985 pfet_01v8_hvt
M$5 3 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $7 r0 *1 1.355,1.985 pfet_01v8_hvt
M$7 3 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $9 r0 *1 2.775,0.56 nfet_01v8
M$9 4 8 1 12 nfet_01v8 L=150000U W=1300000U AS=276250000000P AD=182000000000P
+ PS=2800000U PD=1860000U
* device instance $11 r0 *1 3.635,0.56 nfet_01v8
M$11 4 5 1 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=276250000000P
+ PS=1860000U PD=2800000U
* device instance $13 r0 *1 0.495,0.56 nfet_01v8
M$13 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=276250000000P AD=182000000000P
+ PS=2800000U PD=1860000U
* device instance $15 r0 *1 1.355,0.56 nfet_01v8
M$15 4 7 2 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=276250000000P
+ PS=1860000U PD=2800000U
.ENDS sky130_fd_sc_hd__o211ai_2

* cell sky130_fd_sc_hd__buf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_16 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=935000000000P
+ AD=810000000000P PS=8870000U PD=7620000U
* device instance $7 r0 *1 2.99,1.985 pfet_01v8_hvt
M$7 4 3 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $23 r0 *1 0.47,0.56 nfet_01v8
M$23 3 2 1 7 nfet_01v8 L=150000U W=3900000U AS=607750000000P AD=526500000000P
+ PS=6420000U PD=5520000U
* device instance $29 r0 *1 2.99,0.56 nfet_01v8
M$29 4 3 1 7 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__buf_16

* cell sky130_fd_sc_hd__bufinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__bufinv_16 1 5 6 7 8
* net 1 VGND
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 5 2 7 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 3 2 6 7 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=810000000000P PS=7620000U PD=7620000U
* device instance $10 r0 *1 4.25,1.985 pfet_01v8_hvt
M$10 4 3 6 7 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 5 2 8 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $29 r0 *1 1.73,0.56 nfet_01v8
M$29 3 2 1 8 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=526500000000P
+ PS=5520000U PD=5520000U
* device instance $35 r0 *1 4.25,0.56 nfet_01v8
M$35 4 3 1 8 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__bufinv_16

* cell sky130_fd_sc_hd__nor2b_2
* pin VPB
* pin B_N
* pin A
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_2 1 2 4 5 7 8 9
* net 1 VPB
* net 2 B_N
* net 4 A
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 2.69,2.275 pfet_01v8_hvt
M$1 7 2 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 7 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $4 r0 *1 1.33,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $6 r0 *1 2.69,0.675 nfet_01v8
M$6 5 2 3 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $7 r0 *1 0.49,0.56 nfet_01v8
M$7 8 4 5 9 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $9 r0 *1 1.33,0.56 nfet_01v8
M$9 8 3 5 9 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor2b_2

* cell sky130_fd_sc_hd__a311oi_1
* pin VPB
* pin A3
* pin A2
* pin B1
* pin A1
* pin C1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_1 1 2 3 4 5 6 7 9 10 11
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 B1
* net 5 A1
* net 6 C1
* net 7 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 0.895,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 1.325,1.985 pfet_01v8_hvt
M$3 8 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=165000000000P PS=1280000U PD=1330000U
* device instance $4 r0 *1 1.805,1.985 pfet_01v8_hvt
M$4 14 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=172500000000P PS=1330000U PD=1345000U
* device instance $5 r0 *1 2.3,1.985 pfet_01v8_hvt
M$5 9 6 14 1 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=260000000000P PS=1345000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 13 2 10 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=89375000000P
+ PS=1820000U PD=925000U
* device instance $7 r0 *1 0.895,0.56 nfet_01v8
M$7 12 3 13 11 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 1.325,0.56 nfet_01v8
M$8 9 5 12 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=115375000000P
+ PS=930000U PD=1005000U
* device instance $9 r0 *1 1.83,0.56 nfet_01v8
M$9 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=112125000000P
+ PS=1005000U PD=995000U
* device instance $10 r0 *1 2.325,0.56 nfet_01v8
M$10 9 6 10 11 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=169000000000P
+ PS=995000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311oi_1

* cell sky130_fd_sc_hd__clkbuf_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_2 1 2 3 4 6 7
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 6 X
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=162500000000P PS=2530000U PD=1325000U
* device instance $2 r0 *1 0.95,1.985 pfet_01v8_hvt
M$2 6 5 3 1 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=395000000000P PS=2595000U PD=3790000U
* device instance $4 r0 *1 0.475,0.445 nfet_01v8
M$4 4 2 5 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=68250000000P
+ PS=1370000U PD=745000U
* device instance $5 r0 *1 0.95,0.445 nfet_01v8
M$5 6 5 4 7 nfet_01v8 L=150000U W=840000U AS=124950000000P AD=165900000000P
+ PS=1435000U PD=2050000U
.ENDS sky130_fd_sc_hd__clkbuf_2

* cell sky130_fd_sc_hd__a22o_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a22o_1 1 2 3 4 5 6 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 VGND
* net 9 X
* net 10 VPWR
* device instance $1 r0 *1 1.82,1.985 pfet_01v8_hvt
M$1 7 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=252900000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $2 r0 *1 2.29,1.985 pfet_01v8_hvt
M$2 10 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=155000000000P PS=1320000U PD=1310000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 8 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=252850000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 1.79,0.56 nfet_01v8
M$6 12 4 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=113750000000P
+ PS=1820000U PD=1000000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 5 12 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $8 r0 *1 2.75,0.56 nfet_01v8
M$8 9 8 6 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=169000000000P
+ PS=960000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 13 2 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $10 r0 *1 0.85,0.56 nfet_01v8
M$10 8 3 13 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22o_1

* cell sky130_fd_sc_hd__mux2_4
* pin VGND
* pin S
* pin A0
* pin A1
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_4 1 3 4 6 7 10 11 14
* net 1 VGND
* net 3 S
* net 4 A0
* net 6 A1
* net 7 X
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.37,1.985 pfet_01v8_hvt
M$1 10 3 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 3.79,1.985 pfet_01v8_hvt
M$2 7 5 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 1.905,1.985 pfet_01v8_hvt
M$6 5 4 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $7 r0 *1 2.375,1.985 pfet_01v8_hvt
M$7 12 6 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=300000000000P PS=1320000U PD=2600000U
* device instance $8 r0 *1 0.47,1.985 pfet_01v8_hvt
M$8 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=162500000000P PS=2520000U PD=1325000U
* device instance $9 r0 *1 0.945,1.985 pfet_01v8_hvt
M$9 12 2 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=280000000000P PS=1325000U PD=2560000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 3 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=108875000000P
+ PS=1820000U PD=985000U
* device instance $11 r0 *1 0.955,0.56 nfet_01v8
M$11 8 2 1 14 nfet_01v8 L=150000U W=650000U AS=108875000000P AD=260000000000P
+ PS=985000U PD=1450000U
* device instance $12 r0 *1 1.905,0.56 nfet_01v8
M$12 5 4 8 14 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=104000000000P
+ PS=1450000U PD=970000U
* device instance $13 r0 *1 2.375,0.56 nfet_01v8
M$13 9 6 5 14 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=274625000000P
+ PS=970000U PD=1495000U
* device instance $14 r0 *1 3.37,0.56 nfet_01v8
M$14 1 3 9 14 nfet_01v8 L=150000U W=650000U AS=274625000000P AD=87750000000P
+ PS=1495000U PD=920000U
* device instance $15 r0 *1 3.79,0.56 nfet_01v8
M$15 7 5 1 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__mux2_4

* cell sky130_fd_sc_hd__a221oi_1
* pin VGND
* pin Y
* pin B1
* pin A1
* pin C1
* pin B2
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_1 1 2 3 4 5 6 7 10 11 14
* net 1 VGND
* net 2 Y
* net 3 B1
* net 4 A1
* net 5 C1
* net 6 B2
* net 7 A2
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 13 4 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=152500000000P PS=2520000U PD=1305000U
* device instance $2 r0 *1 2.705,1.985 pfet_01v8_hvt
M$2 10 7 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=305000000000P PS=1305000U PD=2610000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 12 5 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 13 6 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 12 3 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 2.25,0.56 nfet_01v8
M$6 9 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=99125000000P
+ PS=1820000U PD=955000U
* device instance $7 r0 *1 2.705,0.56 nfet_01v8
M$7 1 7 9 14 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=198250000000P
+ PS=955000U PD=1910000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $9 r0 *1 0.945,0.56 nfet_01v8
M$9 8 6 1 14 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=69875000000P
+ PS=975000U PD=865000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 2 3 8 14 nfet_01v8 L=150000U W=650000U AS=69875000000P AD=169000000000P
+ PS=865000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221oi_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__o22ai_2
* pin VGND
* pin B1
* pin Y
* pin B2
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_2 1 3 4 5 6 7 9 11 12
* net 1 VGND
* net 3 B1
* net 4 Y
* net 5 B2
* net 6 A2
* net 7 A1
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 4 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.57,1.985 pfet_01v8_hvt
M$3 9 7 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 9 3 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 4 5 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 4 3 2 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 1.33,0.56 nfet_01v8
M$11 4 5 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=357500000000P
+ PS=1840000U PD=2400000U
* device instance $13 r0 *1 2.73,0.56 nfet_01v8
M$13 1 6 2 12 nfet_01v8 L=150000U W=1300000U AS=357500000000P AD=175500000000P
+ PS=2400000U PD=1840000U
* device instance $15 r0 *1 3.57,0.56 nfet_01v8
M$15 1 7 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__o22ai_2

* cell sky130_fd_sc_hd__a211oi_2
* pin VGND
* pin Y
* pin C1
* pin B1
* pin A1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_2 1 2 4 5 6 7 10 11 12
* net 1 VGND
* net 2 Y
* net 4 C1
* net 5 B1
* net 6 A1
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.765,1.985 pfet_01v8_hvt
M$1 9 6 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 3.625,1.985 pfet_01v8_hvt
M$3 9 7 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $5 r0 *1 0.525,1.985 pfet_01v8_hvt
M$5 2 4 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $7 r0 *1 1.385,1.985 pfet_01v8_hvt
M$7 9 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $9 r0 *1 2.765,0.56 nfet_01v8
M$9 2 6 3 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $11 r0 *1 3.625,0.56 nfet_01v8
M$11 1 7 3 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
* device instance $13 r0 *1 0.525,0.56 nfet_01v8
M$13 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $15 r0 *1 1.385,0.56 nfet_01v8
M$15 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__a211oi_2

* cell sky130_fd_sc_hd__a31oi_4
* pin VGND
* pin A3
* pin A2
* pin A1
* pin Y
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_4 1 2 4 6 7 8 10 11 12
* net 1 VGND
* net 2 A3
* net 4 A2
* net 6 A1
* net 7 Y
* net 8 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 10 4 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=550000000000P PS=5080000U PD=5100000U
* device instance $9 r0 *1 3.85,1.985 pfet_01v8_hvt
M$9 10 6 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=550000000000P
+ AD=790000000000P PS=5100000U PD=5580000U
* device instance $13 r0 *1 6.03,1.985 pfet_01v8_hvt
M$13 7 8 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=790000000000P
+ AD=725000000000P PS=5580000U PD=6450000U
* device instance $17 r0 *1 4.35,0.56 nfet_01v8
M$17 5 6 7 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 6.03,0.56 nfet_01v8
M$21 1 8 7 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=471250000000P
+ PS=3680000U PD=4700000U
* device instance $25 r0 *1 0.47,0.56 nfet_01v8
M$25 1 2 3 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 2.15,0.56 nfet_01v8
M$29 5 4 3 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__a31oi_4

* cell sky130_fd_sc_hd__nand2_4
* pin VGND
* pin B
* pin Y
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand2_4 1 3 4 5 6 7 8
* net 1 VGND
* net 3 B
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 6 7 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 4 5 6 7 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 1 3 2 8 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $13 r0 *1 2.15,0.56 nfet_01v8
M$13 4 5 2 8 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand2_4

* cell sky130_fd_sc_hd__inv_6
* pin VPB
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__inv_6 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 3 2 4 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.105e+12P AD=945000000000P
+ PS=9210000U PD=8890000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 3 2 5 6 nfet_01v8 L=150000U W=3900000U AS=685750000000P AD=614250000000P
+ PS=6660000U PD=6440000U
.ENDS sky130_fd_sc_hd__inv_6

* cell sky130_fd_sc_hd__dlygate4sd1_1
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd1_1 1 2 4 7 8 9
* net 1 VPB
* net 2 A
* net 4 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 1.84,1.915 pfet_01v8_hvt
M$1 6 5 7 1 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 2.315,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.47,2.275 pfet_01v8_hvt
M$3 7 2 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 0.89,2.275 pfet_01v8_hvt
M$4 5 3 7 1 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 1.83,0.675 nfet_01v8
M$5 6 5 4 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $6 r0 *1 2.315,0.56 nfet_01v8
M$6 8 6 4 9 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=169000000000P
+ PS=985000U PD=1820000U
* device instance $7 r0 *1 0.47,0.445 nfet_01v8
M$7 4 2 3 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 0.89,0.445 nfet_01v8
M$8 5 3 4 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd1_1

* cell sky130_fd_sc_hd__dfrtp_2
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_2 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=2000000U AS=436200000000P
+ AD=395000000000P PS=3930000U PD=3790000U
* device instance $3 r0 *1 5.35,2.065 pfet_01v8_hvt
M$3 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $4 r0 *1 5.845,2.275 pfet_01v8_hvt
M$4 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $5 r0 *1 6.275,2.275 pfet_01v8_hvt
M$5 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $6 r0 *1 6.695,2.275 pfet_01v8_hvt
M$6 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $7 r0 *1 7.235,2.275 pfet_01v8_hvt
M$7 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $8 r0 *1 7.655,2.275 pfet_01v8_hvt
M$8 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $9 r0 *1 2.225,2.275 pfet_01v8_hvt
M$9 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $10 r0 *1 2.685,2.275 pfet_01v8_hvt
M$10 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $11 r0 *1 3.18,2.275 pfet_01v8_hvt
M$11 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $12 r0 *1 3.88,2.275 pfet_01v8_hvt
M$12 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $13 r0 *1 4.365,2.275 pfet_01v8_hvt
M$13 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $14 r0 *1 0.47,2.135 pfet_01v8_hvt
M$14 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $15 r0 *1 0.89,2.135 pfet_01v8_hvt
M$15 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $16 r0 *1 8.73,0.56 nfet_01v8
M$16 9 8 1 21 nfet_01v8 L=150000U W=1300000U AS=296450000000P AD=256750000000P
+ PS=2940000U PD=2740000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 11 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 12 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 11 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 12 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
* device instance $29 r0 *1 0.47,0.445 nfet_01v8
M$29 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $30 r0 *1 0.89,0.445 nfet_01v8
M$30 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dfrtp_2

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__dfrtp_4
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_4 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.63,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=710000000000P PS=6330000U PD=6420000U
* device instance $5 r0 *1 5.35,2.065 pfet_01v8_hvt
M$5 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $6 r0 *1 5.845,2.275 pfet_01v8_hvt
M$6 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $7 r0 *1 6.275,2.275 pfet_01v8_hvt
M$7 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $8 r0 *1 6.695,2.275 pfet_01v8_hvt
M$8 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $9 r0 *1 7.235,2.275 pfet_01v8_hvt
M$9 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $10 r0 *1 7.655,2.275 pfet_01v8_hvt
M$10 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $11 r0 *1 2.225,2.275 pfet_01v8_hvt
M$11 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $12 r0 *1 2.685,2.275 pfet_01v8_hvt
M$12 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $13 r0 *1 3.18,2.275 pfet_01v8_hvt
M$13 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $14 r0 *1 3.88,2.275 pfet_01v8_hvt
M$14 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $15 r0 *1 4.365,2.275 pfet_01v8_hvt
M$15 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $16 r0 *1 0.47,2.135 pfet_01v8_hvt
M$16 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $17 r0 *1 0.89,2.135 pfet_01v8_hvt
M$17 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $18 r0 *1 8.63,0.56 nfet_01v8
M$18 9 8 1 21 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $22 r0 *1 2.64,0.415 nfet_01v8
M$22 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $23 r0 *1 3.12,0.415 nfet_01v8
M$23 10 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $24 r0 *1 5.465,0.415 nfet_01v8
M$24 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $25 r0 *1 6.01,0.415 nfet_01v8
M$25 13 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $26 r0 *1 2.165,0.445 nfet_01v8
M$26 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $27 r0 *1 3.95,0.445 nfet_01v8
M$27 11 16 10 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $28 r0 *1 4.31,0.445 nfet_01v8
M$28 1 6 11 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $29 r0 *1 6.49,0.445 nfet_01v8
M$29 1 8 13 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $30 r0 *1 7.235,0.445 nfet_01v8
M$30 12 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $31 r0 *1 7.69,0.445 nfet_01v8
M$31 8 7 12 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $32 r0 *1 4.97,0.555 nfet_01v8
M$32 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
* device instance $33 r0 *1 0.47,0.445 nfet_01v8
M$33 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $34 r0 *1 0.89,0.445 nfet_01v8
M$34 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dfrtp_4

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 2.64,0.415 nfet_01v8
M$16 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $17 r0 *1 3.12,0.415 nfet_01v8
M$17 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $18 r0 *1 5.465,0.415 nfet_01v8
M$18 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $19 r0 *1 6.01,0.415 nfet_01v8
M$19 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $20 r0 *1 2.165,0.445 nfet_01v8
M$20 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $21 r0 *1 3.95,0.445 nfet_01v8
M$21 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $22 r0 *1 4.31,0.445 nfet_01v8
M$22 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $23 r0 *1 6.49,0.445 nfet_01v8
M$23 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $24 r0 *1 7.235,0.445 nfet_01v8
M$24 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $25 r0 *1 7.69,0.445 nfet_01v8
M$25 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $26 r0 *1 4.97,0.555 nfet_01v8
M$26 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
* device instance $27 r0 *1 0.47,0.445 nfet_01v8
M$27 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $28 r0 *1 0.89,0.445 nfet_01v8
M$28 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__ha_2
* pin VGND
* pin SUM
* pin COUT
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_2 1 2 6 7 8 10 11 13
* net 1 VGND
* net 2 SUM
* net 6 COUT
* net 7 B
* net 8 A
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=446600000000P PS=3830000U PD=3075000U
* device instance $3 r0 *1 1.845,2.165 pfet_01v8_hvt
M$3 3 5 10 11 pfet_01v8_hvt L=150000U W=640000U AS=291600000000P
+ AD=86400000000P PS=1765000U PD=910000U
* device instance $4 r0 *1 2.265,2.165 pfet_01v8_hvt
M$4 12 7 3 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=128000000000P PS=910000U PD=1040000U
* device instance $5 r0 *1 2.815,2.165 pfet_01v8_hvt
M$5 10 8 12 11 pfet_01v8_hvt L=150000U W=640000U AS=128000000000P
+ AD=227200000000P PS=1040000U PD=1350000U
* device instance $6 r0 *1 3.675,2.165 pfet_01v8_hvt
M$6 5 7 10 11 pfet_01v8_hvt L=150000U W=640000U AS=227200000000P
+ AD=92800000000P PS=1350000U PD=930000U
* device instance $7 r0 *1 4.115,2.165 pfet_01v8_hvt
M$7 5 8 10 11 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P
+ AD=92800000000P PS=1325000U PD=930000U
* device instance $8 r0 *1 4.59,1.985 pfet_01v8_hvt
M$8 6 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=304000000000P
+ AD=415000000000P PS=2635000U PD=3830000U
* device instance $10 r0 *1 3.755,0.445 nfet_01v8
M$10 9 7 5 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $11 r0 *1 4.115,0.445 nfet_01v8
M$11 1 8 9 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $12 r0 *1 4.59,0.56 nfet_01v8
M$12 6 5 1 13 nfet_01v8 L=150000U W=1300000U AS=197750000000P AD=269750000000P
+ PS=1935000U PD=2780000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 2 3 1 13 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=269750000000P
+ PS=2780000U PD=2780000U
* device instance $16 r0 *1 1.87,0.445 nfet_01v8
M$16 4 5 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 2.29,0.445 nfet_01v8
M$17 1 7 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $18 r0 *1 2.71,0.445 nfet_01v8
M$18 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__ha_2

* cell sky130_fd_sc_hd__ha_1
* pin VGND
* pin SUM
* pin COUT
* pin A
* pin VPWR
* pin B
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_1 1 2 5 8 9 10 11 13
* net 1 VGND
* net 2 SUM
* net 5 COUT
* net 8 A
* net 9 VPWR
* net 10 B
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 9 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=236050000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,2.275 pfet_01v8_hvt
M$2 3 7 9 11 pfet_01v8_hvt L=150000U W=420000U AS=236050000000P AD=56700000000P
+ PS=1765000U PD=690000U
* device instance $3 r0 *1 1.805,2.275 pfet_01v8_hvt
M$3 12 10 3 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=84000000000P PS=690000U PD=820000U
* device instance $4 r0 *1 2.355,2.275 pfet_01v8_hvt
M$4 9 8 12 11 pfet_01v8_hvt L=150000U W=420000U AS=84000000000P
+ AD=149100000000P PS=820000U PD=1130000U
* device instance $5 r0 *1 3.215,2.275 pfet_01v8_hvt
M$5 7 10 9 11 pfet_01v8_hvt L=150000U W=420000U AS=149100000000P
+ AD=60900000000P PS=1130000U PD=710000U
* device instance $6 r0 *1 3.655,2.275 pfet_01v8_hvt
M$6 7 8 9 11 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P AD=60900000000P
+ PS=1325000U PD=710000U
* device instance $7 r0 *1 4.13,1.985 pfet_01v8_hvt
M$7 5 7 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $8 r0 *1 3.295,0.445 nfet_01v8
M$8 6 10 7 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 3.655,0.445 nfet_01v8
M$9 1 8 6 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $10 r0 *1 4.13,0.56 nfet_01v8
M$10 5 7 1 13 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 0.47,0.56 nfet_01v8
M$11 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $12 r0 *1 1.41,0.445 nfet_01v8
M$12 4 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $13 r0 *1 1.83,0.445 nfet_01v8
M$13 1 10 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $14 r0 *1 2.25,0.445 nfet_01v8
M$14 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__ha_1

* cell sky130_fd_sc_hd__ha_4
* pin VGND
* pin SUM
* pin B
* pin COUT
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_4 1 3 5 7 8 11 12 15
* net 1 VGND
* net 3 SUM
* net 5 B
* net 7 COUT
* net 8 A
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=787500000000P PS=6330000U PD=5575000U
* device instance $5 r0 *1 2.645,1.985 pfet_01v8_hvt
M$5 2 6 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=517500000000P
+ AD=282500000000P PS=3035000U PD=2565000U
* device instance $7 r0 *1 3.51,1.985 pfet_01v8_hvt
M$7 13 8 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=147500000000P PS=1295000U PD=1295000U
* device instance $8 r0 *1 3.955,1.985 pfet_01v8_hvt
M$8 2 5 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=135000000000P PS=1295000U PD=1270000U
* device instance $9 r0 *1 4.375,1.985 pfet_01v8_hvt
M$9 14 5 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=287500000000P PS=1270000U PD=1575000U
* device instance $10 r0 *1 5.1,1.985 pfet_01v8_hvt
M$10 11 8 14 12 pfet_01v8_hvt L=150000U W=1000000U AS=287500000000P
+ AD=230000000000P PS=1575000U PD=1460000U
* device instance $11 r0 *1 5.71,1.985 pfet_01v8_hvt
M$11 6 8 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=365000000000P
+ AD=310000000000P PS=2730000U PD=2620000U
* device instance $12 r0 *1 6.13,1.985 pfet_01v8_hvt
M$12 11 5 6 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $15 r0 *1 7.47,1.985 pfet_01v8_hvt
M$15 7 6 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=580000000000P
+ AD=665000000000P PS=5160000U PD=6330000U
* device instance $19 r0 *1 5.34,0.56 nfet_01v8
M$19 1 8 4 15 nfet_01v8 L=150000U W=1300000U AS=273000000000P AD=183625000000P
+ PS=2790000U PD=1865000U
* device instance $20 r0 *1 5.76,0.56 nfet_01v8
M$20 10 8 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=71500000000P
+ PS=920000U PD=870000U
* device instance $21 r0 *1 6.13,0.56 nfet_01v8
M$21 6 5 10 15 nfet_01v8 L=150000U W=650000U AS=71500000000P AD=87750000000P
+ PS=870000U PD=920000U
* device instance $22 r0 *1 6.55,0.56 nfet_01v8
M$22 9 5 6 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $23 r0 *1 6.97,0.56 nfet_01v8
M$23 1 8 9 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $24 r0 *1 7.47,0.56 nfet_01v8
M$24 7 6 1 15 nfet_01v8 L=150000U W=2600000U AS=377000000000P AD=432250000000P
+ PS=3760000U PD=4580000U
* device instance $28 r0 *1 0.47,0.56 nfet_01v8
M$28 3 2 1 15 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=432250000000P
+ PS=4580000U PD=4580000U
* device instance $32 r0 *1 2.67,0.56 nfet_01v8
M$32 2 6 4 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $35 r0 *1 3.955,0.56 nfet_01v8
M$35 4 5 1 15 nfet_01v8 L=150000U W=1300000U AS=183625000000P AD=256750000000P
+ PS=1865000U PD=2740000U
.ENDS sky130_fd_sc_hd__ha_4

* cell sky130_fd_sc_hd__fa_1
* pin VGND
* pin COUT
* pin SUM
* pin A
* pin CIN
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__fa_1 1 2 7 11 12 13 16 17 21
* net 1 VGND
* net 2 COUT
* net 7 SUM
* net 11 A
* net 12 CIN
* net 13 B
* net 16 VPWR
* net 17 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 16 3 2 17 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=147850000000P PS=2520000U PD=1345000U
* device instance $2 r0 *1 0.965,2.275 pfet_01v8_hvt
M$2 18 11 16 17 pfet_01v8_hvt L=150000U W=420000U AS=147850000000P
+ AD=63000000000P PS=1345000U PD=720000U
* device instance $3 r0 *1 1.415,2.275 pfet_01v8_hvt
M$3 3 13 18 17 pfet_01v8_hvt L=150000U W=420000U AS=63000000000P
+ AD=56700000000P PS=720000U PD=690000U
* device instance $4 r0 *1 1.835,2.275 pfet_01v8_hvt
M$4 14 12 3 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $5 r0 *1 2.255,2.275 pfet_01v8_hvt
M$5 16 11 14 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $6 r0 *1 2.675,2.275 pfet_01v8_hvt
M$6 14 13 16 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=109200000000P PS=690000U PD=1360000U
* device instance $7 r0 *1 3.615,2.275 pfet_01v8_hvt
M$7 15 13 16 17 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $8 r0 *1 4.035,2.275 pfet_01v8_hvt
M$8 16 12 15 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $9 r0 *1 4.455,2.275 pfet_01v8_hvt
M$9 15 11 16 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=61950000000P PS=690000U PD=715000U
* device instance $10 r0 *1 4.9,2.275 pfet_01v8_hvt
M$10 6 3 15 17 pfet_01v8_hvt L=150000U W=420000U AS=61950000000P
+ AD=69300000000P PS=715000U PD=750000U
* device instance $11 r0 *1 5.38,2.275 pfet_01v8_hvt
M$11 19 12 6 17 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=44100000000P PS=750000U PD=630000U
* device instance $12 r0 *1 5.74,2.275 pfet_01v8_hvt
M$12 20 13 19 17 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $13 r0 *1 6.22,2.275 pfet_01v8_hvt
M$13 20 11 16 17 pfet_01v8_hvt L=150000U W=420000U AS=147850000000P
+ AD=69300000000P PS=1345000U PD=750000U
* device instance $14 r0 *1 6.715,1.985 pfet_01v8_hvt
M$14 7 6 16 17 pfet_01v8_hvt L=150000U W=1000000U AS=147850000000P
+ AD=260000000000P PS=1345000U PD=2520000U
* device instance $15 r0 *1 0.965,0.445 nfet_01v8
M$15 8 11 1 21 nfet_01v8 L=150000U W=420000U AS=102350000000P AD=63000000000P
+ PS=995000U PD=720000U
* device instance $16 r0 *1 1.415,0.445 nfet_01v8
M$16 3 13 8 21 nfet_01v8 L=150000U W=420000U AS=63000000000P AD=56700000000P
+ PS=720000U PD=690000U
* device instance $17 r0 *1 1.835,0.445 nfet_01v8
M$17 4 12 3 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $18 r0 *1 2.255,0.445 nfet_01v8
M$18 1 11 4 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $19 r0 *1 2.675,0.445 nfet_01v8
M$19 4 13 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $20 r0 *1 0.47,0.56 nfet_01v8
M$20 1 3 2 21 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=102350000000P
+ PS=1820000U PD=995000U
* device instance $21 r0 *1 3.615,0.445 nfet_01v8
M$21 5 13 1 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $22 r0 *1 4.035,0.445 nfet_01v8
M$22 1 12 5 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $23 r0 *1 4.455,0.445 nfet_01v8
M$23 5 11 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=61950000000P
+ PS=690000U PD=715000U
* device instance $24 r0 *1 4.9,0.445 nfet_01v8
M$24 6 3 5 21 nfet_01v8 L=150000U W=420000U AS=61950000000P AD=69300000000P
+ PS=715000U PD=750000U
* device instance $25 r0 *1 5.38,0.445 nfet_01v8
M$25 10 12 6 21 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $26 r0 *1 5.74,0.445 nfet_01v8
M$26 9 13 10 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $27 r0 *1 6.22,0.445 nfet_01v8
M$27 1 11 9 21 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=102350000000P
+ PS=750000U PD=995000U
* device instance $28 r0 *1 6.715,0.56 nfet_01v8
M$28 7 6 1 21 nfet_01v8 L=150000U W=650000U AS=102350000000P AD=169000000000P
+ PS=995000U PD=1820000U
.ENDS sky130_fd_sc_hd__fa_1

* cell sky130_fd_sc_hd__mux4_1
* pin VGND
* pin S0
* pin X
* pin A1
* pin A0
* pin A3
* pin A2
* pin S1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux4_1 1 3 8 9 10 14 15 16 18 19 24
* net 1 VGND
* net 3 S0
* net 8 X
* net 9 A1
* net 10 A0
* net 14 A3
* net 15 A2
* net 16 S1
* net 18 VPWR
* net 19 VPB
* device instance $1 r0 *1 9.19,1.985 pfet_01v8_hvt
M$1 8 7 18 19 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 7.8,2.04 pfet_01v8_hvt
M$2 13 6 7 19 pfet_01v8_hvt L=150000U W=420000U AS=92087500000P
+ AD=268800000000P PS=990000U PD=2120000U
* device instance $3 r0 *1 7.315,2.275 pfet_01v8_hvt
M$3 11 16 7 19 pfet_01v8_hvt L=150000U W=420000U AS=92087500000P
+ AD=109200000000P PS=990000U PD=1360000U
* device instance $4 r0 *1 4.12,2.025 pfet_01v8_hvt
M$4 13 3 22 19 pfet_01v8_hvt L=150000U W=420000U AS=107900000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $5 r0 *1 4.54,2.025 pfet_01v8_hvt
M$5 23 12 13 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=90125000000P PS=690000U PD=995000U
* device instance $6 r0 *1 5.015,2.275 pfet_01v8_hvt
M$6 18 14 23 19 pfet_01v8_hvt L=150000U W=420000U AS=90125000000P
+ AD=56700000000P PS=995000U PD=690000U
* device instance $7 r0 *1 5.435,2.275 pfet_01v8_hvt
M$7 22 15 18 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=109200000000P PS=690000U PD=1360000U
* device instance $8 r0 *1 6.375,2.275 pfet_01v8_hvt
M$8 6 16 18 19 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $9 r0 *1 1.83,2.025 pfet_01v8_hvt
M$9 11 12 20 19 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $10 r0 *1 2.25,2.025 pfet_01v8_hvt
M$10 21 3 11 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=107900000000P PS=690000U PD=1360000U
* device instance $11 r0 *1 0.47,2.275 pfet_01v8_hvt
M$11 18 9 20 19 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $12 r0 *1 0.89,2.275 pfet_01v8_hvt
M$12 21 10 18 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=109200000000P PS=690000U PD=1360000U
* device instance $13 r0 *1 3.19,2.275 pfet_01v8_hvt
M$13 18 3 12 19 pfet_01v8_hvt L=150000U W=420000U AS=108300000000P
+ AD=107900000000P PS=1360000U PD=1360000U
* device instance $14 r0 *1 3.675,0.695 nfet_01v8
M$14 13 3 4 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $15 r0 *1 4.095,0.695 nfet_01v8
M$15 5 12 13 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=107950000000P
+ PS=690000U PD=1360000U
* device instance $16 r0 *1 2.735,0.66 nfet_01v8
M$16 1 3 12 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $17 r0 *1 7.325,0.445 nfet_01v8
M$17 7 16 13 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=151025000000P
+ PS=1360000U PD=1285000U
* device instance $18 r0 *1 8.09,0.695 nfet_01v8
M$18 11 6 7 24 nfet_01v8 L=150000U W=420000U AS=151025000000P AD=109200000000P
+ PS=1285000U PD=1360000U
* device instance $19 r0 *1 6.385,0.445 nfet_01v8
M$19 6 16 1 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $20 r0 *1 5.025,0.445 nfet_01v8
M$20 1 14 4 24 nfet_01v8 L=150000U W=420000U AS=107900000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $21 r0 *1 5.445,0.445 nfet_01v8
M$21 5 15 1 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $22 r0 *1 0.47,0.445 nfet_01v8
M$22 1 9 2 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $23 r0 *1 0.89,0.445 nfet_01v8
M$23 17 10 1 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $24 r0 *1 1.31,0.445 nfet_01v8
M$24 11 12 17 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=85225000000P
+ PS=690000U PD=925000U
* device instance $25 r0 *1 1.795,0.615 nfet_01v8
M$25 2 3 11 24 nfet_01v8 L=150000U W=420000U AS=85225000000P AD=109200000000P
+ PS=925000U PD=1360000U
* device instance $26 r0 *1 9.19,0.56 nfet_01v8
M$26 8 7 1 24 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__mux4_1

* cell sky130_fd_sc_hd__buf_12
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_12 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 4 3 5 6 pfet_01v8_hvt L=150000U W=12000000U AS=1.62e+12P AD=1.865e+12P
+ PS=15240000U PD=16730000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 3 2 1 7 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 2.15,0.56 nfet_01v8
M$21 4 3 1 7 nfet_01v8 L=150000U W=7800000U AS=1.053e+12P AD=1.21225e+12P
+ PS=11040000U PD=12180000U
.ENDS sky130_fd_sc_hd__buf_12

* cell sky130_fd_sc_hd__a22oi_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=300000000000P PS=1270000U PD=2600000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 1.83,0.56 nfet_01v8
M$5 11 4 8 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 2.19,0.56 nfet_01v8
M$6 9 5 11 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=234000000000P
+ PS=860000U PD=2020000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 12 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 3 12 10 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22oi_1

* cell sky130_fd_sc_hd__clkinvlp_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__clkinvlp_4 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.525,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=250000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 0.475,0.51 nfet_01v8
M$5 8 2 4 6 nfet_01v8 L=150000U W=550000U AS=145750000000P AD=57750000000P
+ PS=1630000U PD=760000U
* device instance $6 r0 *1 0.835,0.51 nfet_01v8
M$6 5 2 8 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=77000000000P
+ PS=760000U PD=830000U
* device instance $7 r0 *1 1.265,0.51 nfet_01v8
M$7 7 2 5 6 nfet_01v8 L=150000U W=550000U AS=77000000000P AD=57750000000P
+ PS=830000U PD=760000U
* device instance $8 r0 *1 1.625,0.51 nfet_01v8
M$8 4 2 7 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=145750000000P
+ PS=760000U PD=1630000U
.ENDS sky130_fd_sc_hd__clkinvlp_4

* cell sky130_fd_sc_hd__o21a_4
* pin VGND
* pin X
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o21a_4 1 2 5 6 7 8 9 12
* net 1 VGND
* net 2 X
* net 5 B1
* net 6 A1
* net 7 A2
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.795,1.985 pfet_01v8_hvt
M$1 2 3 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=570000000000P PS=6370000U PD=5140000U
* device instance $5 r0 *1 2.535,1.985 pfet_01v8_hvt
M$5 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=290000000000P
+ AD=450000000000P PS=2580000U PD=2900000U
* device instance $7 r0 *1 3.735,1.985 pfet_01v8_hvt
M$7 10 6 8 9 pfet_01v8_hvt L=150000U W=1000000U AS=310000000000P
+ AD=140000000000P PS=1620000U PD=1280000U
* device instance $8 r0 *1 4.165,1.985 pfet_01v8_hvt
M$8 3 7 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $9 r0 *1 4.595,1.985 pfet_01v8_hvt
M$9 11 7 3 9 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $10 r0 *1 5.025,1.985 pfet_01v8_hvt
M$10 8 6 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=285000000000P PS=1280000U PD=2570000U
* device instance $11 r0 *1 2.715,0.56 nfet_01v8
M$11 3 5 4 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=208000000000P
+ PS=2760000U PD=1940000U
* device instance $13 r0 *1 3.655,0.56 nfet_01v8
M$13 1 6 4 12 nfet_01v8 L=150000U W=1300000U AS=208000000000P AD=289250000000P
+ PS=1940000U PD=2840000U
* device instance $14 r0 *1 4.165,0.56 nfet_01v8
M$14 4 7 1 12 nfet_01v8 L=150000U W=1300000U AS=208000000000P AD=182000000000P
+ PS=1940000U PD=1860000U
* device instance $17 r0 *1 0.475,0.56 nfet_01v8
M$17 2 3 1 12 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=445250000000P
+ PS=4620000U PD=4620000U
.ENDS sky130_fd_sc_hd__o21a_4

* cell sky130_fd_sc_hd__mux2_1
* pin VGND
* pin X
* pin A1
* pin A0
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_1 1 2 3 5 9 10 11 14
* net 1 VGND
* net 2 X
* net 3 A1
* net 5 A0
* net 9 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.015,2.08 pfet_01v8_hvt
M$1 12 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=158350000000P
+ AD=76650000000P PS=1395000U PD=785000U
* device instance $2 r0 *1 1.53,2.08 pfet_01v8_hvt
M$2 4 5 12 11 pfet_01v8_hvt L=150000U W=420000U AS=76650000000P
+ AD=193200000000P PS=785000U PD=1340000U
* device instance $3 r0 *1 2.6,2.08 pfet_01v8_hvt
M$3 13 3 4 11 pfet_01v8_hvt L=150000U W=420000U AS=193200000000P
+ AD=44100000000P PS=1340000U PD=630000U
* device instance $4 r0 *1 2.96,2.08 pfet_01v8_hvt
M$4 10 6 13 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $5 r0 *1 3.44,2.08 pfet_01v8_hvt
M$5 6 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=117600000000P PS=750000U PD=1400000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=158350000000P PS=2520000U PD=1395000U
* device instance $7 r0 *1 1.015,0.445 nfet_01v8
M$7 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=112850000000P AD=69300000000P
+ PS=1045000U PD=750000U
* device instance $8 r0 *1 1.495,0.445 nfet_01v8
M$8 4 3 7 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=99750000000P
+ PS=750000U PD=895000U
* device instance $9 r0 *1 2.12,0.445 nfet_01v8
M$9 8 5 4 14 nfet_01v8 L=150000U W=420000U AS=99750000000P AD=69300000000P
+ PS=895000U PD=750000U
* device instance $10 r0 *1 2.6,0.445 nfet_01v8
M$10 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=144900000000P
+ PS=750000U PD=1110000U
* device instance $11 r0 *1 3.44,0.445 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=420000U AS=144900000000P AD=109200000000P
+ PS=1110000U PD=1360000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112850000000P
+ PS=1820000U PD=1045000U
.ENDS sky130_fd_sc_hd__mux2_1

* cell sky130_fd_sc_hd__buf_2
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_2 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.125 pfet_01v8_hvt
M$1 2 3 6 1 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P AD=166400000000P
+ PS=1325000U PD=1800000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=284000000000P
+ AD=400000000000P PS=2595000U PD=3800000U
* device instance $4 r0 *1 0.47,0.445 nfet_01v8
M$4 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $5 r0 *1 0.945,0.56 nfet_01v8
M$5 5 2 4 7 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=260000000000P
+ PS=1895000U PD=2750000U
.ENDS sky130_fd_sc_hd__buf_2

* cell sky130_fd_sc_hd__a221oi_4
* pin VGND
* pin B1
* pin A1
* pin C1
* pin Y
* pin B2
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_4 1 2 3 4 5 7 8 11 12 14
* net 1 VGND
* net 2 B1
* net 3 A1
* net 4 C1
* net 5 Y
* net 7 B2
* net 8 A2
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 2.69,1.985 pfet_01v8_hvt
M$1 10 7 13 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=580000000000P PS=6330000U PD=5160000U
* device instance $4 r0 *1 3.95,1.985 pfet_01v8_hvt
M$4 13 2 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $9 r0 *1 6.13,1.985 pfet_01v8_hvt
M$9 11 8 13 12 pfet_01v8_hvt L=150000U W=4000000U AS=580000000000P
+ AD=700000000000P PS=5160000U PD=6400000U
* device instance $10 r0 *1 6.55,1.985 pfet_01v8_hvt
M$10 13 3 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $17 r0 *1 0.49,1.985 pfet_01v8_hvt
M$17 5 4 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=665000000000P PS=6370000U PD=6330000U
* device instance $21 r0 *1 0.49,0.56 nfet_01v8
M$21 5 4 1 14 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=357500000000P
+ PS=4620000U PD=3700000U
* device instance $25 r0 *1 2.19,0.56 nfet_01v8
M$25 6 7 1 14 nfet_01v8 L=150000U W=2600000U AS=357500000000P AD=539500000000P
+ PS=3700000U PD=4260000U
* device instance $28 r0 *1 3.95,0.56 nfet_01v8
M$28 5 2 6 14 nfet_01v8 L=150000U W=2600000U AS=513500000000P AD=351000000000P
+ PS=4180000U PD=3680000U
* device instance $33 r0 *1 6.13,0.56 nfet_01v8
M$33 9 8 1 14 nfet_01v8 L=150000U W=2600000U AS=377000000000P AD=432250000000P
+ PS=3760000U PD=4580000U
* device instance $34 r0 *1 6.55,0.56 nfet_01v8
M$34 5 3 9 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
.ENDS sky130_fd_sc_hd__a221oi_4

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 12 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 11 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 11 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__xnor2_2
* pin VGND
* pin Y
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_2 1 5 6 7 8 9 11
* net 1 VGND
* net 5 Y
* net 6 B
* net 7 A
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 4.96,1.985 pfet_01v8_hvt
M$1 5 3 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=415000000000P PS=3790000U PD=3830000U
* device instance $3 r0 *1 2.725,1.985 pfet_01v8_hvt
M$3 8 7 10 9 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 3.565,1.985 pfet_01v8_hvt
M$5 5 6 10 9 pfet_01v8_hvt L=150000U W=2000000U AS=287500000000P
+ AD=412500000000P PS=2575000U PD=3825000U
* device instance $7 r0 *1 0.485,1.985 pfet_01v8_hvt
M$7 8 6 3 9 pfet_01v8_hvt L=150000U W=2000000U AS=410000000000P
+ AD=270000000000P PS=3820000U PD=2540000U
* device instance $9 r0 *1 1.325,1.985 pfet_01v8_hvt
M$9 8 7 3 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $11 r0 *1 4.96,0.56 nfet_01v8
M$11 4 3 5 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
* device instance $13 r0 *1 2.725,0.56 nfet_01v8
M$13 4 7 1 11 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $15 r0 *1 3.565,0.56 nfet_01v8
M$15 4 6 1 11 nfet_01v8 L=150000U W=1300000U AS=186875000000P AD=268125000000P
+ PS=1875000U PD=2775000U
* device instance $17 r0 *1 0.485,0.56 nfet_01v8
M$17 3 6 2 11 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $19 r0 *1 1.325,0.56 nfet_01v8
M$19 1 7 2 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__xnor2_2

* cell sky130_fd_sc_hd__a211oi_1
* pin VPB
* pin A2
* pin A1
* pin C1
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A2
* net 3 A1
* net 4 C1
* net 5 B1
* net 6 VGND
* net 7 Y
* net 9 VPWR
* device instance $1 r0 *1 0.62,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.05,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 1.48,1.985 pfet_01v8_hvt
M$3 12 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 1.94,1.985 pfet_01v8_hvt
M$4 7 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.62,0.56 nfet_01v8
M$5 11 2 6 10 nfet_01v8 L=150000U W=650000U AS=266500000000P AD=91000000000P
+ PS=2120000U PD=930000U
* device instance $6 r0 *1 1.05,0.56 nfet_01v8
M$6 7 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $7 r0 *1 1.48,0.56 nfet_01v8
M$7 6 5 7 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $8 r0 *1 1.94,0.56 nfet_01v8
M$8 7 4 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211oi_1

* cell sky130_fd_sc_hd__and4_4
* pin VGND
* pin A
* pin B
* pin C
* pin X
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4_4 1 2 4 5 6 7 11 12 13
* net 1 VGND
* net 2 A
* net 4 B
* net 5 C
* net 6 X
* net 7 D
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 4 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=155000000000P PS=1270000U PD=1310000U
* device instance $3 r0 *1 1.35,1.985 pfet_01v8_hvt
M$3 3 5 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=215000000000P PS=1310000U PD=1430000U
* device instance $4 r0 *1 1.93,1.985 pfet_01v8_hvt
M$4 11 7 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=165000000000P PS=1430000U PD=1330000U
* device instance $5 r0 *1 2.41,1.985 pfet_01v8_hvt
M$5 6 3 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=570000000000P
+ AD=665000000000P PS=5140000U PD=6330000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 8 2 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=79625000000P
+ PS=1820000U PD=895000U
* device instance $10 r0 *1 0.865,0.56 nfet_01v8
M$10 9 4 8 13 nfet_01v8 L=150000U W=650000U AS=79625000000P AD=108875000000P
+ PS=895000U PD=985000U
* device instance $11 r0 *1 1.35,0.56 nfet_01v8
M$11 10 5 9 13 nfet_01v8 L=150000U W=650000U AS=108875000000P AD=141375000000P
+ PS=985000U PD=1085000U
* device instance $12 r0 *1 1.935,0.56 nfet_01v8
M$12 1 7 10 13 nfet_01v8 L=150000U W=650000U AS=141375000000P AD=105625000000P
+ PS=1085000U PD=975000U
* device instance $13 r0 *1 2.41,0.56 nfet_01v8
M$13 6 3 1 13 nfet_01v8 L=150000U W=2600000U AS=368875000000P AD=432250000000P
+ PS=3735000U PD=4580000U
.ENDS sky130_fd_sc_hd__and4_4

* cell sky130_fd_sc_hd__or2_1
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 5 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.695 pfet_01v8_hvt
M$1 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.695 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=145750000000P
+ PS=630000U PD=1335000U
* device instance $3 r0 *1 1.52,1.985 pfet_01v8_hvt
M$3 4 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=340000000000P PS=1335000U PD=2680000U
* device instance $4 r0 *1 0.615,0.445 nfet_01v8
M$4 6 2 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.445 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=100250000000P
+ PS=690000U PD=985000U
* device instance $6 r0 *1 1.52,0.56 nfet_01v8
M$6 4 6 5 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=169000000000P
+ PS=985000U PD=1820000U
.ENDS sky130_fd_sc_hd__or2_1

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__a221oi_2
* pin VGND
* pin C1
* pin Y
* pin B2
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_2 1 2 3 4 6 7 9 10 11 14
* net 1 VGND
* net 2 C1
* net 3 Y
* net 4 B2
* net 6 B1
* net 7 A2
* net 9 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.84,1.985 pfet_01v8_hvt
M$1 12 4 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=310000000000P PS=3790000U PD=2620000U
* device instance $2 r0 *1 2.26,1.985 pfet_01v8_hvt
M$2 13 6 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 3.6,1.985 pfet_01v8_hvt
M$5 10 7 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $6 r0 *1 4.02,1.985 pfet_01v8_hvt
M$6 13 9 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 0.48,1.985 pfet_01v8_hvt
M$9 3 2 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=395000000000P PS=3810000U PD=3790000U
* device instance $11 r0 *1 0.48,0.56 nfet_01v8
M$11 3 2 1 14 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=344500000000P
+ PS=2760000U PD=2360000U
* device instance $13 r0 *1 1.84,0.56 nfet_01v8
M$13 5 4 1 14 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=201500000000P
+ PS=2360000U PD=1920000U
* device instance $14 r0 *1 2.26,0.56 nfet_01v8
M$14 3 6 5 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 3.6,0.56 nfet_01v8
M$17 8 7 1 14 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $18 r0 *1 4.02,0.56 nfet_01v8
M$18 3 9 8 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
.ENDS sky130_fd_sc_hd__a221oi_2

* cell sky130_fd_sc_hd__xnor2_1
* pin VPB
* pin B
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_1 1 2 3 4 5 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 Y
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.51,1.985 pfet_01v8_hvt
M$1 8 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=135000000000P PS=2600000U PD=1270000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=365000000000P PS=1270000U PD=1730000U
* device instance $3 r0 *1 1.81,1.985 pfet_01v8_hvt
M$3 11 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=105000000000P PS=1730000U PD=1210000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 4 2 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 5 8 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=360000000000P PS=1330000U PD=2720000U
* device instance $6 r0 *1 2.29,0.56 nfet_01v8
M$6 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 4 8 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=195000000000P
+ PS=920000U PD=1900000U
* device instance $8 r0 *1 0.57,0.56 nfet_01v8
M$8 10 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $9 r0 *1 0.93,0.56 nfet_01v8
M$9 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=87750000000P
+ PS=860000U PD=920000U
* device instance $10 r0 *1 1.35,0.56 nfet_01v8
M$10 6 3 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor2_1

* cell sky130_fd_sc_hd__nor3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 6 4 5 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $6 r0 *1 1.31,0.56 nfet_01v8
M$6 6 2 5 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor3_1

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__a21oi_2
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_2 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=275000000000P PS=3830000U PD=2550000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 6 2 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=275000000000P PS=2560000U PD=2550000U
* device instance $5 r0 *1 2.19,1.985 pfet_01v8_hvt
M$5 7 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=495000000000P PS=2540000U PD=3990000U
* device instance $7 r0 *1 0.495,0.56 nfet_01v8
M$7 10 4 8 9 nfet_01v8 L=150000U W=650000U AS=185250000000P AD=89375000000P
+ PS=1870000U PD=925000U
* device instance $8 r0 *1 0.92,0.56 nfet_01v8
M$8 7 2 10 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $9 r0 *1 1.35,0.56 nfet_01v8
M$9 11 2 7 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=68250000000P
+ PS=930000U PD=860000U
* device instance $10 r0 *1 1.71,0.56 nfet_01v8
M$10 8 4 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=107250000000P
+ PS=860000U PD=980000U
* device instance $11 r0 *1 2.19,0.56 nfet_01v8
M$11 7 3 8 9 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=347750000000P
+ PS=1900000U PD=3020000U
.ENDS sky130_fd_sc_hd__a21oi_2

* cell sky130_fd_sc_hd__o21ai_2
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_2 1 2 3 4 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 7 VGND
* net 8 Y
* net 9 VPWR
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 6 2 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=440000000000P
+ AD=300000000000P PS=3880000U PD=2600000U
* device instance $2 r0 *1 0.915,1.985 pfet_01v8_hvt
M$2 8 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=315000000000P PS=2560000U PD=2630000U
* device instance $5 r0 *1 2.315,1.985 pfet_01v8_hvt
M$5 8 4 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=405000000000P PS=2600000U PD=3810000U
* device instance $7 r0 *1 0.485,0.56 nfet_01v8
M$7 7 2 5 10 nfet_01v8 L=150000U W=1300000U AS=299000000000P AD=182000000000P
+ PS=2870000U PD=1860000U
* device instance $8 r0 *1 0.915,0.56 nfet_01v8
M$8 5 3 7 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=217750000000P
+ PS=1860000U PD=1970000U
* device instance $11 r0 *1 2.315,0.56 nfet_01v8
M$11 8 4 5 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__o21ai_2

* cell sky130_fd_sc_hd__nor2_2
* pin VGND
* pin
* pin Y
* pin VPB
* pin A
* pin B
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nor2_2 1 2 3 4 5 6 8
* net 1 VGND
* net 3 Y
* net 4 VPB
* net 5 A
* net 6 B
* net 8 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 8 5 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 1.33,1.985 pfet_01v8_hvt
M$3 3 6 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,0.56 nfet_01v8
M$5 3 5 1 2 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $7 r0 *1 1.33,0.56 nfet_01v8
M$7 3 6 1 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor2_2

* cell sky130_fd_sc_hd__inv_2
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_2 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 VPWR
* net 5 Y
* device instance $1 r0 *1 0.48,1.985 pfet_01v8_hvt
M$1 5 2 4 1 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $3 r0 *1 0.48,0.56 nfet_01v8
M$3 5 2 3 6 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__inv_2

* cell sky130_fd_sc_hd__nor2_4
* pin VGND
* pin B
* pin Y
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor2_4 1 2 3 4 6 7 8
* net 1 VGND
* net 2 B
* net 3 Y
* net 4 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 4 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $5 r0 *1 2.17,1.985 pfet_01v8_hvt
M$5 3 2 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=675000000000P PS=5080000U PD=6350000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 3 4 1 8 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $13 r0 *1 2.17,0.56 nfet_01v8
M$13 3 2 1 8 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor2_4

* cell sky130_fd_sc_hd__o21a_1
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21a_1 1 2 3 4 5 7 8 10
* net 1 VPB
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=327500000000P PS=2560000U PD=1655000U
* device instance $2 r0 *1 1.295,1.985 pfet_01v8_hvt
M$2 9 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=327500000000P
+ AD=195000000000P PS=1655000U PD=1390000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=152500000000P PS=1390000U PD=1305000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 5 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=260000000000P PS=1305000U PD=2520000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 3 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 8 9 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21a_1

* cell sky130_fd_sc_hd__a21oi_4
* pin VGND
* pin Y
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_4 1 2 4 5 6 7 8 10
* net 1 VGND
* net 2 Y
* net 4 B1
* net 5 A2
* net 6 A1
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 4 9 8 pfet_01v8_hvt L=150000U W=4000000U AS=680000000000P
+ AD=575000000000P PS=6360000U PD=5150000U
* device instance $5 r0 *1 2.225,1.985 pfet_01v8_hvt
M$5 7 5 9 8 pfet_01v8_hvt L=150000U W=4000000U AS=575000000000P
+ AD=690000000000P PS=5150000U PD=6380000U
* device instance $6 r0 *1 2.665,1.985 pfet_01v8_hvt
M$6 9 6 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=565000000000P
+ AD=560000000000P PS=5130000U PD=5120000U
* device instance $13 r0 *1 0.475,0.56 nfet_01v8
M$13 2 4 1 10 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=377000000000P
+ PS=4620000U PD=3760000U
* device instance $17 r0 *1 2.235,0.56 nfet_01v8
M$17 3 5 1 10 nfet_01v8 L=150000U W=2600000U AS=377000000000P AD=445250000000P
+ PS=3760000U PD=4620000U
* device instance $18 r0 *1 2.665,0.56 nfet_01v8
M$18 2 6 3 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=364000000000P
+ PS=3720000U PD=3720000U
.ENDS sky130_fd_sc_hd__a21oi_4

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 0.89,0.56 nfet_01v8
M$8 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
* device instance $9 r0 *1 1.85,0.56 nfet_01v8
M$9 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 2.27,0.56 nfet_01v8
M$10 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__nor3_2
* pin VGND
* pin A
* pin Y
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3_2 1 2 3 4 5 7 9 10
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 B
* net 5 C
* net 7 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 7 2 6 9 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 6 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 3 5 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 3 2 1 10 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $11 r0 *1 1.33,0.56 nfet_01v8
M$11 3 4 1 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3_2

* cell sky130_fd_sc_hd__o21ai_1
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 VGND
* net 8 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 8 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=174000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.37,2.135 pfet_01v8_hvt
M$3 5 3 8 1 pfet_01v8_hvt L=150000U W=700000U AS=174000000000P AD=182000000000P
+ PS=1390000U PD=1920000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $5 r0 *1 0.95,0.56 nfet_01v8
M$5 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 8 3 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21ai_1

* cell sky130_fd_sc_hd__clkbuf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_16 1 3 4 5 6 7
* net 1 VGND
* net 3 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $5 r0 *1 2.195,1.985 pfet_01v8_hvt
M$5 4 2 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.2375e+12P AD=2.3625e+12P
+ PS=20475000U PD=21725000U
* device instance $21 r0 *1 0.475,0.445 nfet_01v8
M$21 2 3 1 7 nfet_01v8 L=150000U W=1680000U AS=287700000000P AD=235200000000P
+ PS=3470000U PD=2800000U
* device instance $25 r0 *1 2.195,0.445 nfet_01v8
M$25 4 2 1 7 nfet_01v8 L=150000U W=6720000U AS=939750000000P AD=992250000000P
+ PS=11195000U PD=11865000U
.ENDS sky130_fd_sc_hd__clkbuf_16

* cell sky130_fd_sc_hd__clkinv_2
* pin VPB
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_2 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 4 2 3 1 pfet_01v8_hvt L=150000U W=3000000U AS=545000000000P
+ AD=545000000000P PS=5090000U PD=5090000U
* device instance $4 r0 *1 0.94,0.445 nfet_01v8
M$4 3 2 5 6 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=168000000000P
+ PS=2070000U PD=2060000U
.ENDS sky130_fd_sc_hd__clkinv_2

* cell sky130_fd_sc_hd__nand2_8
* pin VGND
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand2_8 1 2 3 5 6 7 8
* net 1 VGND
* net 2 B
* net 3 A
* net 5 VPWR
* net 6 Y
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 2 5 7 pfet_01v8_hvt L=150000U W=8000000U AS=1.205e+12P AD=1.08e+12P
+ PS=11410000U PD=10160000U
* device instance $9 r0 *1 3.83,1.985 pfet_01v8_hvt
M$9 6 3 5 7 pfet_01v8_hvt L=150000U W=8000000U AS=1.08e+12P AD=1.325e+12P
+ PS=10160000U PD=11650000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 1 2 4 8 nfet_01v8 L=150000U W=5200000U AS=783250000000P AD=702000000000P
+ PS=8260000U PD=7360000U
* device instance $25 r0 *1 3.83,0.56 nfet_01v8
M$25 6 3 4 8 nfet_01v8 L=150000U W=5200000U AS=702000000000P AD=861250000000P
+ PS=7360000U PD=8500000U
.ENDS sky130_fd_sc_hd__nand2_8

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__clkbuf_4
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 6 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=165000000000P PS=2530000U PD=1330000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=4000000U AS=585000000000P
+ AD=720000000000P PS=5170000U PD=6440000U
* device instance $6 r0 *1 0.475,0.445 nfet_01v8
M$6 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=70350000000P
+ PS=1370000U PD=755000U
* device instance $7 r0 *1 0.96,0.445 nfet_01v8
M$7 5 2 4 7 nfet_01v8 L=150000U W=1680000U AS=246750000000P AD=298200000000P
+ PS=2855000U PD=3520000U
.ENDS sky130_fd_sc_hd__clkbuf_4

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1
