* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT leading_zero_counter data_in[0] data_in[10] data_in[11]
+ data_in[12] data_in[13] data_in[14] data_in[15] data_in[16]
+ data_in[17] data_in[18] data_in[19] data_in[1] data_in[20]
+ data_in[21] data_in[22] data_in[23] data_in[24] data_in[25]
+ data_in[26] data_in[27] data_in[28] data_in[29] data_in[2]
+ data_in[30] data_in[31] data_in[3] data_in[4] data_in[5] data_in[6]
+ data_in[7] data_in[8] data_in[9] valid_input zero_count[0]
+ zero_count[1] zero_count[2] zero_count[3] zero_count[4] zero_count[5]
X_058_ net32 net31 net3 net2 VSS VSS VDD VDD _003_ sky130_fd_sc_hd__nor4_1
X_059_ net5 net4 net7 net6 VSS VSS VDD VDD _004_ sky130_fd_sc_hd__nor4_1
X_060_ net26 net23 net30 net29 VSS VSS VDD VDD _005_ sky130_fd_sc_hd__nor4_1
X_061_ net12 net1 VSS VSS VDD VDD _006_ sky130_fd_sc_hd__nor2_1
X_062_ net28 net27 VSS VSS VDD VDD _007_ sky130_fd_sc_hd__nor2_1
X_063_ _005_ _006_ _007_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__and3_1
X_064_ _003_ _004_ _008_ VSS VSS VDD VDD net38 sky130_fd_sc_hd__nand3_1
X_065_ net9 net8 net11 net10 VSS VSS VDD VDD _009_ sky130_fd_sc_hd__or4_1
X_066_ net14 net13 net16 net15 VSS VSS VDD VDD _010_ sky130_fd_sc_hd__or4_1
X_067_ _009_ _010_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__nor2_1
X_068_ net18 net17 net20 net19 VSS VSS VDD VDD _012_ sky130_fd_sc_hd__nor4_1
X_069_ net22 net21 VSS VSS VDD VDD _013_ sky130_fd_sc_hd__nor2_1
X_070_ net25 net24 VSS VSS VDD VDD _014_ sky130_fd_sc_hd__nor2_1
X_071_ _011_ _012_ _013_ _014_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__nand4_1
X_072_ net38 _015_ VSS VSS VDD VDD net39 sky130_fd_sc_hd__nor2_1
X_073_ net38 _015_ VSS VSS VDD VDD net33 sky130_fd_sc_hd__or2_0
X_074_ net29 VSS VSS VDD VDD _016_ sky130_fd_sc_hd__inv_1
X_075_ net30 net31 VSS VSS VDD VDD _017_ sky130_fd_sc_hd__nand2b_1
X_076_ _016_ _017_ net28 VSS VSS VDD VDD _018_ sky130_fd_sc_hd__a21oi_1
X_077_ net1 net23 net27 VSS VSS VDD VDD _019_ sky130_fd_sc_hd__nor3_1
X_078_ _018_ _019_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__nor2b_1
X_079_ net4 VSS VSS VDD VDD _021_ sky130_fd_sc_hd__inv_1
X_080_ net5 _021_ net3 VSS VSS VDD VDD _022_ sky130_fd_sc_hd__a21oi_1
X_081_ net28 net30 net32 VSS VSS VDD VDD _023_ sky130_fd_sc_hd__nor3_1
X_082_ net2 _022_ _023_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__o21ai_0
X_083_ net19 VSS VSS VDD VDD _025_ sky130_fd_sc_hd__inv_1
X_084_ net22 net24 VSS VSS VDD VDD _026_ sky130_fd_sc_hd__nand2b_1
X_085_ net19 net21 VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nor2_1
X_086_ net20 _025_ _026_ _027_ net18 VSS VSS VDD VDD _028_
+ sky130_fd_sc_hd__a221oi_1
X_087_ net13 net15 net17 VSS VSS VDD VDD _029_ sky130_fd_sc_hd__or3_1
X_088_ net13 VSS VSS VDD VDD _030_ sky130_fd_sc_hd__inv_1
X_089_ net13 net15 VSS VSS VDD VDD _031_ sky130_fd_sc_hd__nor2_1
X_090_ net7 net9 net11 VSS VSS VDD VDD _032_ sky130_fd_sc_hd__or3_1
X_091_ net14 _030_ net16 _031_ _032_ VSS VSS VDD VDD _033_
+ sky130_fd_sc_hd__a221oi_1
X_092_ _028_ _029_ _033_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__o21ai_1
X_093_ net9 net10 VSS VSS VDD VDD _035_ sky130_fd_sc_hd__and2b_1
X_094_ net8 _035_ net7 VSS VSS VDD VDD _036_ sky130_fd_sc_hd__o21bai_1
X_095_ net2 net4 net6 VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nor3_1
X_096_ _018_ _019_ _036_ _037_ VSS VSS VDD VDD _038_ sky130_fd_sc_hd__and4b_1
X_097_ net23 VSS VSS VDD VDD _039_ sky130_fd_sc_hd__inv_1
X_098_ net26 _039_ net12 VSS VSS VDD VDD _040_ sky130_fd_sc_hd__a21oi_1
X_099_ net1 _040_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__nor2_1
X_100_ _020_ _024_ _034_ _038_ _041_ VSS VSS VDD VDD net34
+ sky130_fd_sc_hd__a221oi_1
X_101_ net11 net10 VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nor2_1
X_102_ net18 net17 VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nor2_1
X_103_ net14 net13 VSS VSS VDD VDD _044_ sky130_fd_sc_hd__nor2_1
X_104_ net20 net19 _013_ _043_ _044_ VSS VSS VDD VDD _045_
+ sky130_fd_sc_hd__o311ai_2
X_105_ net16 net15 _044_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__o21ai_0
X_106_ net5 net4 net9 net8 VSS VSS VDD VDD _047_ sky130_fd_sc_hd__or4_1
X_107_ _042_ _045_ _046_ _047_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__a31oi_1
X_108_ net7 net6 VSS VSS VDD VDD _049_ sky130_fd_sc_hd__nor2_1
X_109_ net3 net2 VSS VSS VDD VDD _050_ sky130_fd_sc_hd__nor2_1
X_110_ net5 net4 _049_ _005_ _050_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__o311ai_0
X_111_ net26 net23 VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nor2_1
X_112_ net32 net31 VSS VSS VDD VDD _053_ sky130_fd_sc_hd__nor2_1
X_113_ net30 net29 _053_ _007_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__o31ai_1
X_114_ _052_ _054_ _006_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__a21boi_0
X_115_ _048_ _051_ _055_ VSS VSS VDD VDD net35 sky130_fd_sc_hd__o21ai_0
X_116_ net30 net29 VSS VSS VDD VDD _056_ sky130_fd_sc_hd__nor2_1
X_117_ _056_ _007_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__nand2_1
X_118_ _010_ _012_ _009_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__o21bai_1
X_119_ _004_ _000_ _003_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__a21boi_0
X_120_ _057_ _001_ _052_ _006_ VSS VSS VDD VDD net36 sky130_fd_sc_hd__o211ai_1
X_121_ _003_ _004_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__nand2_1
X_122_ _002_ _011_ _008_ VSS VSS VDD VDD net37 sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_1
Xinput2 data_in[10] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput3 data_in[11] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput4 data_in[12] VSS VSS VDD VDD net4 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput5 data_in[13] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput6 data_in[14] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput7 data_in[15] VSS VSS VDD VDD net7 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput8 data_in[16] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput9 data_in[17] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput10 data_in[18] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput11 data_in[19] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput12 data_in[1] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput13 data_in[20] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput14 data_in[21] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput15 data_in[22] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput16 data_in[23] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput17 data_in[24] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput18 data_in[25] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xinput19 data_in[26] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xinput20 data_in[27] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
Xinput21 data_in[28] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
Xinput22 data_in[29] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
Xinput23 data_in[2] VSS VSS VDD VDD net23 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput24 data_in[30] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
Xinput25 data_in[31] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
Xinput26 data_in[3] VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_1
Xinput27 data_in[4] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
Xinput28 data_in[5] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_1
Xinput29 data_in[6] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_1
Xinput30 data_in[7] VSS VSS VDD VDD net30 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput31 data_in[8] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_1
Xinput32 data_in[9] VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_1
Xoutput33 net33 VSS VSS VDD VDD valid_input sky130_fd_sc_hd__clkbuf_1
Xoutput34 net34 VSS VSS VDD VDD zero_count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput35 net35 VSS VSS VDD VDD zero_count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput36 net36 VSS VSS VDD VDD zero_count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput37 net37 VSS VSS VDD VDD zero_count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput38 net38 VSS VSS VDD VDD zero_count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput39 net39 VSS VSS VDD VDD zero_count[5] sky130_fd_sc_hd__clkbuf_1
.ENDS leading_zero_counter
