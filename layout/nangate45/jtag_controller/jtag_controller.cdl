* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT jtag_controller clk dr_in[0] dr_in[10] dr_in[11] dr_in[12]
+ dr_in[13] dr_in[14] dr_in[15] dr_in[16] dr_in[17] dr_in[18]
+ dr_in[19] dr_in[1] dr_in[20] dr_in[21] dr_in[22] dr_in[23]
+ dr_in[24] dr_in[25] dr_in[26] dr_in[27] dr_in[28] dr_in[29]
+ dr_in[2] dr_in[30] dr_in[31] dr_in[3] dr_in[4] dr_in[5] dr_in[6]
+ dr_in[7] dr_in[8] dr_in[9] dr_out[0] dr_out[10] dr_out[11]
+ dr_out[12] dr_out[13] dr_out[14] dr_out[15] dr_out[16] dr_out[17]
+ dr_out[18] dr_out[19] dr_out[1] dr_out[20] dr_out[21] dr_out[22]
+ dr_out[23] dr_out[24] dr_out[25] dr_out[26] dr_out[27] dr_out[28]
+ dr_out[29] dr_out[2] dr_out[30] dr_out[31] dr_out[3] dr_out[4]
+ dr_out[5] dr_out[6] dr_out[7] dr_out[8] dr_out[9] dr_shift_en
+ instruction[0] instruction[1] instruction[2] instruction[3]
+ instruction[4] rst_n tck tdi tdo tms trst_n update_dr
X_247_ tap_state\[3\] _076_ VDD VSS BUF_X4
X_248_ _076_ _077_ VDD VSS INV_X2
X_249_ tap_state\[0\] _078_ VDD VSS BUF_X4
X_250_ tap_state\[1\] _078_ _079_ VDD VSS NOR2_X2
X_251_ _077_ tap_state\[2\] _079_ _080_ VDD VSS NAND3_X2
X_252_ _080_ net68 VDD VSS INV_X2
X_253_ dr_shift_reg\[0\] _081_ VDD VSS INV_X1
X_254_ tap_state\[1\] _082_ VDD VSS BUF_X4
X_255_ _082_ _078_ _083_ VDD VSS NAND2_X1
X_256_ tap_state\[2\] _084_ VDD VSS BUF_X4
X_257_ _077_ _084_ _085_ VDD VSS NOR2_X2
X_258_ ir_shift_reg\[0\] _085_ _086_ VDD VSS NAND2_X1
X_259_ _081_ _080_ _083_ _086_ _000_ VDD VSS OAI22_X1
X_260_ _079_ _085_ _087_ VDD VSS NAND2_X4
X_261_ _087_ _088_ VDD VSS BUF_X4
X_262_ _088_ net75 VDD VSS INV_X1
X_263_ net33 _001_ VDD VSS INV_X8
X_264_ dr_shift_reg\[17\] net44 _088_ _002_ VDD VSS MUX2_X1
X_265_ dr_shift_reg\[18\] net45 _088_ _003_ VDD VSS MUX2_X1
X_266_ dr_shift_reg\[19\] net46 _088_ _004_ VDD VSS MUX2_X1
X_267_ dr_shift_reg\[1\] net47 _088_ _005_ VDD VSS MUX2_X1
X_268_ dr_shift_reg\[20\] net48 _088_ _006_ VDD VSS MUX2_X1
X_269_ dr_shift_reg\[21\] net49 _088_ _007_ VDD VSS MUX2_X1
X_270_ dr_shift_reg\[22\] net50 _088_ _008_ VDD VSS MUX2_X1
X_271_ dr_shift_reg\[23\] net51 _088_ _009_ VDD VSS MUX2_X1
X_272_ dr_shift_reg\[24\] net52 _088_ _010_ VDD VSS MUX2_X1
X_273_ _087_ _089_ VDD VSS BUF_X4
X_274_ dr_shift_reg\[25\] net53 _089_ _011_ VDD VSS MUX2_X1
X_275_ dr_shift_reg\[26\] net54 _089_ _012_ VDD VSS MUX2_X1
X_276_ dr_shift_reg\[27\] net55 _089_ _013_ VDD VSS MUX2_X1
X_277_ dr_shift_reg\[28\] net56 _089_ _014_ VDD VSS MUX2_X1
X_278_ dr_shift_reg\[29\] net57 _089_ _015_ VDD VSS MUX2_X1
X_279_ dr_shift_reg\[2\] net58 _089_ _016_ VDD VSS MUX2_X1
X_280_ dr_shift_reg\[30\] net59 _089_ _017_ VDD VSS MUX2_X1
X_281_ dr_shift_reg\[31\] net60 _089_ _018_ VDD VSS MUX2_X1
X_282_ dr_shift_reg\[3\] net61 _089_ _019_ VDD VSS MUX2_X1
X_283_ dr_shift_reg\[4\] net62 _089_ _020_ VDD VSS MUX2_X1
X_284_ _087_ _090_ VDD VSS BUF_X4
X_285_ dr_shift_reg\[5\] net63 _090_ _021_ VDD VSS MUX2_X1
X_286_ dr_shift_reg\[6\] net64 _090_ _022_ VDD VSS MUX2_X1
X_287_ dr_shift_reg\[7\] net65 _090_ _023_ VDD VSS MUX2_X1
X_288_ dr_shift_reg\[8\] net66 _090_ _024_ VDD VSS MUX2_X1
X_289_ dr_shift_reg\[9\] net67 _090_ _025_ VDD VSS MUX2_X1
X_290_ dr_shift_reg\[1\] net68 _091_ VDD VSS NAND2_X1
X_291_ _076_ tap_state\[2\] _092_ VDD VSS NOR2_X2
X_292_ _082_ _078_ _092_ _093_ VDD VSS NAND3_X4
X_293_ _080_ _093_ _094_ VDD VSS NAND2_X4
X_294_ _094_ _095_ VDD VSS BUF_X8
X_295_ net1 _096_ VDD VSS INV_X1
X_296_ _093_ _097_ VDD VSS BUF_X4
X_297_ _091_ _095_ _081_ _096_ _097_ _026_ VDD VSS OAI221_X1
X_298_ dr_shift_reg\[11\] net68 _098_ VDD VSS NAND2_X1
X_299_ net2 _099_ VDD VSS INV_X1
X_300_ dr_shift_reg\[10\] _100_ VDD VSS INV_X1
X_301_ _098_ _097_ _099_ _100_ _095_ _027_ VDD VSS OAI221_X1
X_302_ net3 dr_shift_reg\[12\] _097_ _101_ VDD VSS MUX2_X1
X_303_ dr_shift_reg\[11\] _101_ _095_ _028_ VDD VSS MUX2_X1
X_304_ net4 dr_shift_reg\[13\] _097_ _102_ VDD VSS MUX2_X1
X_305_ dr_shift_reg\[12\] _102_ _095_ _029_ VDD VSS MUX2_X1
X_306_ net5 dr_shift_reg\[14\] _097_ _103_ VDD VSS MUX2_X1
X_307_ dr_shift_reg\[13\] _103_ _095_ _030_ VDD VSS MUX2_X1
X_308_ dr_shift_reg\[14\] dr_shift_reg\[15\] net68 _104_ VDD
+ VSS MUX2_X1
X_309_ net6 _104_ _097_ _031_ VDD VSS MUX2_X1
X_310_ net7 dr_shift_reg\[16\] _097_ _105_ VDD VSS MUX2_X1
X_311_ dr_shift_reg\[15\] _105_ _095_ _032_ VDD VSS MUX2_X1
X_312_ net8 dr_shift_reg\[17\] _097_ _106_ VDD VSS MUX2_X1
X_313_ dr_shift_reg\[16\] _106_ _095_ _033_ VDD VSS MUX2_X1
X_314_ net9 dr_shift_reg\[18\] _097_ _107_ VDD VSS MUX2_X1
X_315_ dr_shift_reg\[17\] _107_ _095_ _034_ VDD VSS MUX2_X1
X_316_ _093_ _108_ VDD VSS BUF_X8
X_317_ net10 dr_shift_reg\[19\] _108_ _109_ VDD VSS MUX2_X1
X_318_ dr_shift_reg\[18\] _109_ _095_ _035_ VDD VSS MUX2_X1
X_319_ net11 dr_shift_reg\[20\] _108_ _110_ VDD VSS MUX2_X1
X_320_ dr_shift_reg\[19\] _110_ _095_ _036_ VDD VSS MUX2_X1
X_321_ net12 dr_shift_reg\[2\] _108_ _111_ VDD VSS MUX2_X1
X_322_ _094_ _112_ VDD VSS BUF_X8
X_323_ dr_shift_reg\[1\] _111_ _112_ _037_ VDD VSS MUX2_X1
X_324_ net13 dr_shift_reg\[21\] _108_ _113_ VDD VSS MUX2_X1
X_325_ dr_shift_reg\[20\] _113_ _112_ _038_ VDD VSS MUX2_X1
X_326_ net14 dr_shift_reg\[22\] _108_ _114_ VDD VSS MUX2_X1
X_327_ dr_shift_reg\[21\] _114_ _112_ _039_ VDD VSS MUX2_X1
X_328_ net15 dr_shift_reg\[23\] _108_ _115_ VDD VSS MUX2_X1
X_329_ dr_shift_reg\[22\] _115_ _112_ _040_ VDD VSS MUX2_X1
X_330_ net16 dr_shift_reg\[24\] _108_ _116_ VDD VSS MUX2_X1
X_331_ dr_shift_reg\[23\] _116_ _112_ _041_ VDD VSS MUX2_X1
X_332_ net17 dr_shift_reg\[25\] _108_ _117_ VDD VSS MUX2_X1
X_333_ dr_shift_reg\[24\] _117_ _112_ _042_ VDD VSS MUX2_X1
X_334_ net18 dr_shift_reg\[26\] _108_ _118_ VDD VSS MUX2_X1
X_335_ dr_shift_reg\[25\] _118_ _112_ _043_ VDD VSS MUX2_X1
X_336_ net19 dr_shift_reg\[27\] _108_ _119_ VDD VSS MUX2_X1
X_337_ dr_shift_reg\[26\] _119_ _112_ _044_ VDD VSS MUX2_X1
X_338_ _093_ _120_ VDD VSS BUF_X4
X_339_ net20 dr_shift_reg\[28\] _120_ _121_ VDD VSS MUX2_X1
X_340_ dr_shift_reg\[27\] _121_ _112_ _045_ VDD VSS MUX2_X1
X_341_ net21 dr_shift_reg\[29\] _120_ _122_ VDD VSS MUX2_X1
X_342_ dr_shift_reg\[28\] _122_ _112_ _046_ VDD VSS MUX2_X1
X_343_ net22 dr_shift_reg\[30\] _120_ _123_ VDD VSS MUX2_X1
X_344_ _094_ _124_ VDD VSS BUF_X8
X_345_ dr_shift_reg\[29\] _123_ _124_ _047_ VDD VSS MUX2_X1
X_346_ net23 dr_shift_reg\[3\] _120_ _125_ VDD VSS MUX2_X1
X_347_ dr_shift_reg\[2\] _125_ _124_ _048_ VDD VSS MUX2_X1
X_348_ dr_shift_reg\[30\] dr_shift_reg\[31\] net68 _126_ VDD
+ VSS MUX2_X1
X_349_ net24 _126_ _097_ _049_ VDD VSS MUX2_X1
X_350_ net25 net34 _120_ _127_ VDD VSS MUX2_X1
X_351_ dr_shift_reg\[31\] _127_ _124_ _050_ VDD VSS MUX2_X1
X_352_ net26 dr_shift_reg\[4\] _120_ _128_ VDD VSS MUX2_X1
X_353_ dr_shift_reg\[3\] _128_ _124_ _051_ VDD VSS MUX2_X1
X_354_ net27 dr_shift_reg\[5\] _120_ _129_ VDD VSS MUX2_X1
X_355_ dr_shift_reg\[4\] _129_ _124_ _052_ VDD VSS MUX2_X1
X_356_ net28 dr_shift_reg\[6\] _120_ _130_ VDD VSS MUX2_X1
X_357_ dr_shift_reg\[5\] _130_ _124_ _053_ VDD VSS MUX2_X1
X_358_ net29 dr_shift_reg\[7\] _120_ _131_ VDD VSS MUX2_X1
X_359_ dr_shift_reg\[6\] _131_ _124_ _054_ VDD VSS MUX2_X1
X_360_ net30 dr_shift_reg\[8\] _120_ _132_ VDD VSS MUX2_X1
X_361_ dr_shift_reg\[7\] _132_ _124_ _055_ VDD VSS MUX2_X1
X_362_ net31 dr_shift_reg\[9\] _093_ _133_ VDD VSS MUX2_X1
X_363_ dr_shift_reg\[8\] _133_ _124_ _056_ VDD VSS MUX2_X1
X_364_ net32 dr_shift_reg\[10\] _093_ _134_ VDD VSS MUX2_X1
X_365_ dr_shift_reg\[9\] _134_ _124_ _057_ VDD VSS MUX2_X1
X_366_ _078_ _135_ VDD VSS INV_X2
X_367_ _135_ ir_shift_reg\[1\] _136_ VDD VSS OR2_X1
X_368_ _082_ _085_ _137_ VDD VSS NAND2_X2
X_369_ _136_ ir_shift_reg\[0\] _137_ _063_ VDD VSS MUX2_X1
X_370_ _135_ ir_shift_reg\[2\] _138_ VDD VSS OR2_X1
X_371_ _138_ ir_shift_reg\[1\] _137_ _064_ VDD VSS MUX2_X1
X_372_ _135_ ir_shift_reg\[3\] _139_ VDD VSS OR2_X1
X_373_ _139_ ir_shift_reg\[2\] _137_ _065_ VDD VSS MUX2_X1
X_374_ _135_ ir_shift_reg\[4\] _140_ VDD VSS OR2_X1
X_375_ _140_ ir_shift_reg\[3\] _137_ _066_ VDD VSS MUX2_X1
X_376_ _078_ net34 _141_ VDD VSS AND2_X1
X_377_ _141_ ir_shift_reg\[4\] _137_ _067_ VDD VSS MUX2_X1
X_378_ dr_shift_reg\[0\] net36 _090_ _068_ VDD VSS MUX2_X1
X_379_ dr_shift_reg\[10\] net37 _090_ _069_ VDD VSS MUX2_X1
X_380_ dr_shift_reg\[11\] net38 _090_ _070_ VDD VSS MUX2_X1
X_381_ dr_shift_reg\[12\] net39 _090_ _071_ VDD VSS MUX2_X1
X_382_ dr_shift_reg\[13\] net40 _090_ _072_ VDD VSS MUX2_X1
X_383_ dr_shift_reg\[14\] net41 _087_ _073_ VDD VSS MUX2_X1
X_384_ dr_shift_reg\[15\] net42 _087_ _074_ VDD VSS MUX2_X1
X_385_ dr_shift_reg\[16\] net43 _087_ _075_ VDD VSS MUX2_X1
X_386_ _076_ _084_ _142_ VDD VSS NAND2_X1
X_387_ _083_ _142_ _143_ VDD VSS OR2_X2
X_388_ ir_shift_reg\[0\] net69 _143_ _058_ VDD VSS MUX2_X1
X_389_ ir_shift_reg\[1\] net70 _143_ _059_ VDD VSS MUX2_X1
X_390_ ir_shift_reg\[2\] net71 _143_ _060_ VDD VSS MUX2_X1
X_391_ ir_shift_reg\[3\] net72 _143_ _061_ VDD VSS MUX2_X1
X_392_ ir_shift_reg\[4\] net73 _143_ _062_ VDD VSS MUX2_X1
X_393_ _084_ _144_ VDD VSS INV_X1
X_394_ tms _145_ VDD VSS BUF_X2
X_395_ _145_ _146_ VDD VSS INV_X1
X_396_ _084_ _146_ _082_ _147_ VDD VSS AOI21_X1
X_397_ _144_ _145_ _147_ _135_ _148_ VDD VSS OAI22_X1
X_398_ _076_ _145_ _149_ VDD VSS NAND2_X1
X_399_ _145_ _076_ _078_ _150_ VDD VSS AOI21_X1
X_400_ _149_ _150_ _082_ _151_ VDD VSS OAI21_X1
X_401_ _084_ _149_ _135_ _152_ VDD VSS OAI21_X1
X_402_ _077_ _148_ _151_ _152_ next_tap_state\[0\] VDD VSS
+ AOI22_X1
X_403_ _084_ _145_ _153_ VDD VSS XNOR2_X1
X_404_ _082_ _076_ _153_ _154_ VDD VSS NOR3_X1
X_405_ _077_ _084_ _145_ _155_ VDD VSS NOR3_X1
X_406_ _078_ _154_ _155_ _156_ VDD VSS OAI21_X1
X_407_ _084_ _146_ _157_ VDD VSS NOR2_X1
X_408_ _149_ _157_ _082_ _158_ VDD VSS MUX2_X1
X_409_ _156_ _142_ _146_ _078_ _158_ next_tap_state\[1\] VDD
+ VSS OAI221_X1
X_410_ _078_ _145_ _159_ VDD VSS AND2_X1
X_411_ _144_ _159_ _077_ _160_ VDD VSS AOI21_X1
X_412_ _082_ _160_ _161_ VDD VSS NOR2_X1
X_413_ _084_ _159_ _162_ VDD VSS NAND2_X1
X_414_ _162_ _145_ _077_ _163_ VDD VSS OAI21_X1
X_415_ _161_ _092_ _135_ _082_ _163_ next_tap_state\[2\] VDD
+ VSS AOI221_X1
X_416_ _146_ _084_ _135_ _164_ VDD VSS AOI21_X1
X_417_ _143_ _164_ _076_ _165_ VDD VSS OAI21_X1
X_418_ _135_ _145_ _166_ VDD VSS NOR2_X1
X_419_ _135_ _076_ _166_ _082_ _167_ VDD VSS OAI22_X1
X_420_ _165_ _167_ _144_ next_tap_state\[3\] VDD VSS AOI21_X1
Xdr_reg\[0\]$_DFFE_NN0P_ _068_ net35 _001_ net36 _242_ VDD
+ VSS DFFR_X1
Xdr_reg\[10\]$_DFFE_NN0P_ _069_ net35 _001_ net37 _241_ VDD
+ VSS DFFR_X1
Xdr_reg\[11\]$_DFFE_NN0P_ _070_ net35 _001_ net38 _240_ VDD
+ VSS DFFR_X1
Xdr_reg\[12\]$_DFFE_NN0P_ _071_ net35 _001_ net39 _239_ VDD
+ VSS DFFR_X1
Xdr_reg\[13\]$_DFFE_NN0P_ _072_ net35 _001_ net40 _238_ VDD
+ VSS DFFR_X1
Xdr_reg\[14\]$_DFFE_NN0P_ _073_ net35 _001_ net41 _237_ VDD
+ VSS DFFR_X1
Xdr_reg\[15\]$_DFFE_NN0P_ _074_ net35 _001_ net42 _236_ VDD
+ VSS DFFR_X1
Xdr_reg\[16\]$_DFFE_NN0P_ _075_ net35 _001_ net43 _235_ VDD
+ VSS DFFR_X1
Xdr_reg\[17\]$_DFFE_NN0P_ _002_ net35 _001_ net44 _234_ VDD
+ VSS DFFR_X1
Xdr_reg\[18\]$_DFFE_NN0P_ _003_ net35 _001_ net45 _233_ VDD
+ VSS DFFR_X1
Xdr_reg\[19\]$_DFFE_NN0P_ _004_ net35 _001_ net46 _232_ VDD
+ VSS DFFR_X1
Xdr_reg\[1\]$_DFFE_NN0P_ _005_ net35 _001_ net47 _231_ VDD
+ VSS DFFR_X1
Xdr_reg\[20\]$_DFFE_NN0P_ _006_ net35 _001_ net48 _230_ VDD
+ VSS DFFR_X1
Xdr_reg\[21\]$_DFFE_NN0P_ _007_ net35 _001_ net49 _229_ VDD
+ VSS DFFR_X1
Xdr_reg\[22\]$_DFFE_NN0P_ _008_ net35 _001_ net50 _228_ VDD
+ VSS DFFR_X1
Xdr_reg\[23\]$_DFFE_NN0P_ _009_ net35 _001_ net51 _227_ VDD
+ VSS DFFR_X1
Xdr_reg\[24\]$_DFFE_NN0P_ _010_ net35 _001_ net52 _226_ VDD
+ VSS DFFR_X1
Xdr_reg\[25\]$_DFFE_NN0P_ _011_ net35 _001_ net53 _225_ VDD
+ VSS DFFR_X1
Xdr_reg\[26\]$_DFFE_NN0P_ _012_ net35 _001_ net54 _224_ VDD
+ VSS DFFR_X1
Xdr_reg\[27\]$_DFFE_NN0P_ _013_ net35 _001_ net55 _223_ VDD
+ VSS DFFR_X1
Xdr_reg\[28\]$_DFFE_NN0P_ _014_ net35 _001_ net56 _222_ VDD
+ VSS DFFR_X1
Xdr_reg\[29\]$_DFFE_NN0P_ _015_ net35 _001_ net57 _221_ VDD
+ VSS DFFR_X1
Xdr_reg\[2\]$_DFFE_NN0P_ _016_ net35 _001_ net58 _220_ VDD
+ VSS DFFR_X1
Xdr_reg\[30\]$_DFFE_NN0P_ _017_ net35 _001_ net59 _219_ VDD
+ VSS DFFR_X1
Xdr_reg\[31\]$_DFFE_NN0P_ _018_ net35 _001_ net60 _218_ VDD
+ VSS DFFR_X1
Xdr_reg\[3\]$_DFFE_NN0P_ _019_ net35 _001_ net61 _217_ VDD
+ VSS DFFR_X1
Xdr_reg\[4\]$_DFFE_NN0P_ _020_ net35 _001_ net62 _216_ VDD
+ VSS DFFR_X1
Xdr_reg\[5\]$_DFFE_NN0P_ _021_ net35 _001_ net63 _215_ VDD
+ VSS DFFR_X1
Xdr_reg\[6\]$_DFFE_NN0P_ _022_ net35 _001_ net64 _214_ VDD
+ VSS DFFR_X1
Xdr_reg\[7\]$_DFFE_NN0P_ _023_ net35 _001_ net65 _213_ VDD
+ VSS DFFR_X1
Xdr_reg\[8\]$_DFFE_NN0P_ _024_ net35 _001_ net66 _212_ VDD
+ VSS DFFR_X1
Xdr_reg\[9\]$_DFFE_NN0P_ _025_ net35 _001_ net67 _211_ VDD
+ VSS DFFR_X1
Xdr_shift_reg\[0\]$_DFFE_PN0P_ _026_ net35 net33 dr_shift_reg\[0\]
+ _210_ VDD VSS DFFR_X1
Xdr_shift_reg\[10\]$_DFFE_PN0P_ _027_ net35 net33 dr_shift_reg\[10\]
+ _209_ VDD VSS DFFR_X1
Xdr_shift_reg\[11\]$_DFFE_PN0P_ _028_ net35 net33 dr_shift_reg\[11\]
+ _208_ VDD VSS DFFR_X1
Xdr_shift_reg\[12\]$_DFFE_PN0P_ _029_ net35 net33 dr_shift_reg\[12\]
+ _207_ VDD VSS DFFR_X1
Xdr_shift_reg\[13\]$_DFFE_PN0P_ _030_ net35 net33 dr_shift_reg\[13\]
+ _206_ VDD VSS DFFR_X1
Xdr_shift_reg\[14\]$_DFFE_PN0P_ _031_ net35 net33 dr_shift_reg\[14\]
+ _205_ VDD VSS DFFR_X1
Xdr_shift_reg\[15\]$_DFFE_PN0P_ _032_ net35 net33 dr_shift_reg\[15\]
+ _204_ VDD VSS DFFR_X1
Xdr_shift_reg\[16\]$_DFFE_PN0P_ _033_ net35 net33 dr_shift_reg\[16\]
+ _203_ VDD VSS DFFR_X1
Xdr_shift_reg\[17\]$_DFFE_PN0P_ _034_ net35 net33 dr_shift_reg\[17\]
+ _202_ VDD VSS DFFR_X1
Xdr_shift_reg\[18\]$_DFFE_PN0P_ _035_ net35 net33 dr_shift_reg\[18\]
+ _201_ VDD VSS DFFR_X1
Xdr_shift_reg\[19\]$_DFFE_PN0P_ _036_ net35 net33 dr_shift_reg\[19\]
+ _200_ VDD VSS DFFR_X1
Xdr_shift_reg\[1\]$_DFFE_PN0P_ _037_ net35 net33 dr_shift_reg\[1\]
+ _199_ VDD VSS DFFR_X1
Xdr_shift_reg\[20\]$_DFFE_PN0P_ _038_ net35 net33 dr_shift_reg\[20\]
+ _198_ VDD VSS DFFR_X1
Xdr_shift_reg\[21\]$_DFFE_PN0P_ _039_ net35 net33 dr_shift_reg\[21\]
+ _197_ VDD VSS DFFR_X1
Xdr_shift_reg\[22\]$_DFFE_PN0P_ _040_ net35 net33 dr_shift_reg\[22\]
+ _196_ VDD VSS DFFR_X1
Xdr_shift_reg\[23\]$_DFFE_PN0P_ _041_ net35 net33 dr_shift_reg\[23\]
+ _195_ VDD VSS DFFR_X1
Xdr_shift_reg\[24\]$_DFFE_PN0P_ _042_ net35 net33 dr_shift_reg\[24\]
+ _194_ VDD VSS DFFR_X1
Xdr_shift_reg\[25\]$_DFFE_PN0P_ _043_ net35 net33 dr_shift_reg\[25\]
+ _193_ VDD VSS DFFR_X1
Xdr_shift_reg\[26\]$_DFFE_PN0P_ _044_ net35 net33 dr_shift_reg\[26\]
+ _192_ VDD VSS DFFR_X1
Xdr_shift_reg\[27\]$_DFFE_PN0P_ _045_ net35 net33 dr_shift_reg\[27\]
+ _191_ VDD VSS DFFR_X1
Xdr_shift_reg\[28\]$_DFFE_PN0P_ _046_ net35 net33 dr_shift_reg\[28\]
+ _190_ VDD VSS DFFR_X1
Xdr_shift_reg\[29\]$_DFFE_PN0P_ _047_ net35 net33 dr_shift_reg\[29\]
+ _189_ VDD VSS DFFR_X1
Xdr_shift_reg\[2\]$_DFFE_PN0P_ _048_ net35 net33 dr_shift_reg\[2\]
+ _188_ VDD VSS DFFR_X1
Xdr_shift_reg\[30\]$_DFFE_PN0P_ _049_ net35 net33 dr_shift_reg\[30\]
+ _187_ VDD VSS DFFR_X1
Xdr_shift_reg\[31\]$_DFFE_PN0P_ _050_ net35 net33 dr_shift_reg\[31\]
+ _186_ VDD VSS DFFR_X1
Xdr_shift_reg\[3\]$_DFFE_PN0P_ _051_ net35 net33 dr_shift_reg\[3\]
+ _185_ VDD VSS DFFR_X1
Xdr_shift_reg\[4\]$_DFFE_PN0P_ _052_ net35 net33 dr_shift_reg\[4\]
+ _184_ VDD VSS DFFR_X1
Xdr_shift_reg\[5\]$_DFFE_PN0P_ _053_ net35 net33 dr_shift_reg\[5\]
+ _183_ VDD VSS DFFR_X1
Xdr_shift_reg\[6\]$_DFFE_PN0P_ _054_ net35 net33 dr_shift_reg\[6\]
+ _182_ VDD VSS DFFR_X1
Xdr_shift_reg\[7\]$_DFFE_PN0P_ _055_ net35 net33 dr_shift_reg\[7\]
+ _181_ VDD VSS DFFR_X1
Xdr_shift_reg\[8\]$_DFFE_PN0P_ _056_ net35 net33 dr_shift_reg\[8\]
+ _180_ VDD VSS DFFR_X1
Xdr_shift_reg\[9\]$_DFFE_PN0P_ _057_ net35 net33 dr_shift_reg\[9\]
+ _179_ VDD VSS DFFR_X1
Xir_reg\[0\]$_DFFE_NN1N_ _058_ net35 _001_ net69 _178_ VDD
+ VSS DFFS_X1
Xir_reg\[1\]$_DFFE_NN0N_ _059_ net35 _001_ net70 _177_ VDD
+ VSS DFFR_X1
Xir_reg\[2\]$_DFFE_NN0N_ _060_ net35 _001_ net71 _176_ VDD
+ VSS DFFR_X1
Xir_reg\[3\]$_DFFE_NN0N_ _061_ net35 _001_ net72 _175_ VDD
+ VSS DFFR_X1
Xir_reg\[4\]$_DFFE_NN0N_ _062_ net35 _001_ net73 _174_ VDD
+ VSS DFFR_X1
Xir_shift_reg\[0\]$_DFFE_PN1P_ _063_ net35 net33 ir_shift_reg\[0\]
+ _173_ VDD VSS DFFS_X1
Xir_shift_reg\[1\]$_DFFE_PN0P_ _064_ net35 net33 ir_shift_reg\[1\]
+ _172_ VDD VSS DFFR_X1
Xir_shift_reg\[2\]$_DFFE_PN0P_ _065_ net35 net33 ir_shift_reg\[2\]
+ _171_ VDD VSS DFFR_X1
Xir_shift_reg\[3\]$_DFFE_PN0P_ _066_ net35 net33 ir_shift_reg\[3\]
+ _170_ VDD VSS DFFR_X1
Xir_shift_reg\[4\]$_DFFE_PN0P_ _067_ net35 net33 ir_shift_reg\[4\]
+ _243_ VDD VSS DFFR_X1
Xtap_state\[0\]$_DFF_PN0_ next_tap_state\[0\] net35 net33
+ tap_state\[0\] _244_ VDD VSS DFFR_X1
Xtap_state\[1\]$_DFF_PN0_ next_tap_state\[1\] net35 net33
+ tap_state\[1\] _245_ VDD VSS DFFR_X1
Xtap_state\[2\]$_DFF_PN0_ next_tap_state\[2\] net35 net33
+ tap_state\[2\] _246_ VDD VSS DFFR_X2
Xtap_state\[3\]$_DFF_PN0_ next_tap_state\[3\] net35 net33
+ tap_state\[3\] _169_ VDD VSS DFFR_X1
Xtdo_mux$_DFF_NN0_ _000_ net35 _001_ net74 _168_ VDD VSS DFFR_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_51 VDD VSS TAPCELL_X1
Xinput1 dr_in[0] net1 VDD VSS BUF_X1
Xinput2 dr_in[10] net2 VDD VSS BUF_X1
Xinput3 dr_in[11] net3 VDD VSS BUF_X1
Xinput4 dr_in[12] net4 VDD VSS BUF_X1
Xinput5 dr_in[13] net5 VDD VSS BUF_X1
Xinput6 dr_in[14] net6 VDD VSS BUF_X1
Xinput7 dr_in[15] net7 VDD VSS BUF_X1
Xinput8 dr_in[16] net8 VDD VSS BUF_X1
Xinput9 dr_in[17] net9 VDD VSS BUF_X1
Xinput10 dr_in[18] net10 VDD VSS BUF_X1
Xinput11 dr_in[19] net11 VDD VSS BUF_X1
Xinput12 dr_in[1] net12 VDD VSS BUF_X1
Xinput13 dr_in[20] net13 VDD VSS BUF_X1
Xinput14 dr_in[21] net14 VDD VSS BUF_X1
Xinput15 dr_in[22] net15 VDD VSS BUF_X1
Xinput16 dr_in[23] net16 VDD VSS BUF_X1
Xinput17 dr_in[24] net17 VDD VSS BUF_X1
Xinput18 dr_in[25] net18 VDD VSS BUF_X1
Xinput19 dr_in[26] net19 VDD VSS BUF_X1
Xinput20 dr_in[27] net20 VDD VSS BUF_X1
Xinput21 dr_in[28] net21 VDD VSS BUF_X1
Xinput22 dr_in[29] net22 VDD VSS BUF_X1
Xinput23 dr_in[2] net23 VDD VSS BUF_X1
Xinput24 dr_in[30] net24 VDD VSS BUF_X1
Xinput25 dr_in[31] net25 VDD VSS BUF_X1
Xinput26 dr_in[3] net26 VDD VSS BUF_X1
Xinput27 dr_in[4] net27 VDD VSS BUF_X1
Xinput28 dr_in[5] net28 VDD VSS BUF_X1
Xinput29 dr_in[6] net29 VDD VSS BUF_X1
Xinput30 dr_in[7] net30 VDD VSS BUF_X1
Xinput31 dr_in[8] net31 VDD VSS BUF_X1
Xinput32 dr_in[9] net32 VDD VSS BUF_X1
Xinput33 tck net33 VDD VSS BUF_X8
Xinput34 tdi net34 VDD VSS BUF_X1
Xinput35 trst_n net35 VDD VSS BUF_X16
Xoutput36 net36 dr_out[0] VDD VSS BUF_X1
Xoutput37 net37 dr_out[10] VDD VSS BUF_X1
Xoutput38 net38 dr_out[11] VDD VSS BUF_X1
Xoutput39 net39 dr_out[12] VDD VSS BUF_X1
Xoutput40 net40 dr_out[13] VDD VSS BUF_X1
Xoutput41 net41 dr_out[14] VDD VSS BUF_X1
Xoutput42 net42 dr_out[15] VDD VSS BUF_X1
Xoutput43 net43 dr_out[16] VDD VSS BUF_X1
Xoutput44 net44 dr_out[17] VDD VSS BUF_X1
Xoutput45 net45 dr_out[18] VDD VSS BUF_X1
Xoutput46 net46 dr_out[19] VDD VSS BUF_X1
Xoutput47 net47 dr_out[1] VDD VSS BUF_X1
Xoutput48 net48 dr_out[20] VDD VSS BUF_X1
Xoutput49 net49 dr_out[21] VDD VSS BUF_X1
Xoutput50 net50 dr_out[22] VDD VSS BUF_X1
Xoutput51 net51 dr_out[23] VDD VSS BUF_X1
Xoutput52 net52 dr_out[24] VDD VSS BUF_X1
Xoutput53 net53 dr_out[25] VDD VSS BUF_X1
Xoutput54 net54 dr_out[26] VDD VSS BUF_X1
Xoutput55 net55 dr_out[27] VDD VSS BUF_X1
Xoutput56 net56 dr_out[28] VDD VSS BUF_X1
Xoutput57 net57 dr_out[29] VDD VSS BUF_X1
Xoutput58 net58 dr_out[2] VDD VSS BUF_X1
Xoutput59 net59 dr_out[30] VDD VSS BUF_X1
Xoutput60 net60 dr_out[31] VDD VSS BUF_X1
Xoutput61 net61 dr_out[3] VDD VSS BUF_X1
Xoutput62 net62 dr_out[4] VDD VSS BUF_X1
Xoutput63 net63 dr_out[5] VDD VSS BUF_X1
Xoutput64 net64 dr_out[6] VDD VSS BUF_X1
Xoutput65 net65 dr_out[7] VDD VSS BUF_X1
Xoutput66 net66 dr_out[8] VDD VSS BUF_X1
Xoutput67 net67 dr_out[9] VDD VSS BUF_X1
Xoutput68 net68 dr_shift_en VDD VSS BUF_X1
Xoutput69 net69 instruction[0] VDD VSS BUF_X1
Xoutput70 net70 instruction[1] VDD VSS BUF_X1
Xoutput71 net71 instruction[2] VDD VSS BUF_X1
Xoutput72 net72 instruction[3] VDD VSS BUF_X1
Xoutput73 net73 instruction[4] VDD VSS BUF_X1
Xoutput74 net74 tdo VDD VSS BUF_X1
Xoutput75 net75 update_dr VDD VSS BUF_X1
.ENDS jtag_controller
