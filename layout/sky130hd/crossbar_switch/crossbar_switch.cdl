* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT crossbar_switch clk data_in[0] data_in[10] data_in[11]
+ data_in[12] data_in[13] data_in[14] data_in[15] data_in[16]
+ data_in[17] data_in[18] data_in[19] data_in[1] data_in[20]
+ data_in[21] data_in[22] data_in[23] data_in[24] data_in[25]
+ data_in[26] data_in[27] data_in[28] data_in[29] data_in[2]
+ data_in[30] data_in[31] data_in[3] data_in[4] data_in[5] data_in[6]
+ data_in[7] data_in[8] data_in[9] data_out[0] data_out[10]
+ data_out[11] data_out[12] data_out[13] data_out[14] data_out[15]
+ data_out[16] data_out[17] data_out[18] data_out[19] data_out[1]
+ data_out[20] data_out[21] data_out[22] data_out[23] data_out[24]
+ data_out[25] data_out[26] data_out[27] data_out[28] data_out[29]
+ data_out[2] data_out[30] data_out[31] data_out[3] data_out[4]
+ data_out[5] data_out[6] data_out[7] data_out[8] data_out[9]
+ rst_n select[0] select[1] select[2] select[3] select[4] select[5]
+ select[6] select[7]
X_40_ select[4] VSS VSS VDD VDD _02_ sky130_fd_sc_hd__buf_6
X_41_ select[5] VSS VSS VDD VDD _03_ sky130_fd_sc_hd__clkbuf_4
X_42_ net2 net32 net9 net18 _02_ _03_ VSS VSS VDD VDD _16_
+ sky130_fd_sc_hd__mux4_1
X_43_ net13 net33 net10 net19 _02_ _03_ VSS VSS VDD VDD _17_
+ sky130_fd_sc_hd__mux4_1
X_44_ net24 net3 net11 net20 _02_ _03_ VSS VSS VDD VDD _18_
+ sky130_fd_sc_hd__mux4_1
X_45_ net27 net4 net12 net21 _02_ _03_ VSS VSS VDD VDD _19_
+ sky130_fd_sc_hd__mux4_1
X_46_ net28 net5 net14 net22 _02_ _03_ VSS VSS VDD VDD _20_
+ sky130_fd_sc_hd__mux4_1
X_47_ net29 net6 net15 net23 _02_ _03_ VSS VSS VDD VDD _21_
+ sky130_fd_sc_hd__mux4_1
X_48_ net30 net7 net16 net25 _02_ _03_ VSS VSS VDD VDD _22_
+ sky130_fd_sc_hd__mux4_1
X_49_ net31 net8 net17 net26 _02_ _03_ VSS VSS VDD VDD _23_
+ sky130_fd_sc_hd__mux4_1
X_50_ select[2] VSS VSS VDD VDD _04_ sky130_fd_sc_hd__buf_6
X_51_ select[3] VSS VSS VDD VDD _05_ sky130_fd_sc_hd__clkbuf_4
X_52_ net2 net32 net9 net18 _04_ _05_ VSS VSS VDD VDD _08_
+ sky130_fd_sc_hd__mux4_1
X_53_ net13 net33 net10 net19 _04_ _05_ VSS VSS VDD VDD _09_
+ sky130_fd_sc_hd__mux4_1
X_54_ net24 net3 net11 net20 _04_ _05_ VSS VSS VDD VDD _10_
+ sky130_fd_sc_hd__mux4_1
X_55_ net27 net4 net12 net21 _04_ _05_ VSS VSS VDD VDD _11_
+ sky130_fd_sc_hd__mux4_1
X_56_ net28 net5 net14 net22 _04_ _05_ VSS VSS VDD VDD _12_
+ sky130_fd_sc_hd__mux4_1
X_57_ net29 net6 net15 net23 _04_ _05_ VSS VSS VDD VDD _13_
+ sky130_fd_sc_hd__mux4_1
X_58_ net30 net7 net16 net25 _04_ _05_ VSS VSS VDD VDD _14_
+ sky130_fd_sc_hd__mux4_1
X_59_ net31 net8 net17 net26 _04_ _05_ VSS VSS VDD VDD _15_
+ sky130_fd_sc_hd__mux4_1
X_60_ select[6] VSS VSS VDD VDD _06_ sky130_fd_sc_hd__buf_6
X_61_ select[7] VSS VSS VDD VDD _07_ sky130_fd_sc_hd__clkbuf_4
X_62_ net2 net32 net9 net18 _06_ _07_ VSS VSS VDD VDD _24_
+ sky130_fd_sc_hd__mux4_1
X_63_ net13 net33 net10 net19 _06_ _07_ VSS VSS VDD VDD _25_
+ sky130_fd_sc_hd__mux4_1
X_64_ net24 net3 net11 net20 _06_ _07_ VSS VSS VDD VDD _26_
+ sky130_fd_sc_hd__mux4_1
X_65_ net27 net4 net12 net21 _06_ _07_ VSS VSS VDD VDD _27_
+ sky130_fd_sc_hd__mux4_1
X_66_ net28 net5 net14 net22 _06_ _07_ VSS VSS VDD VDD _28_
+ sky130_fd_sc_hd__mux4_1
X_67_ net29 net6 net15 net23 _06_ _07_ VSS VSS VDD VDD _29_
+ sky130_fd_sc_hd__mux4_1
X_68_ net30 net7 net16 net25 _06_ _07_ VSS VSS VDD VDD _30_
+ sky130_fd_sc_hd__mux4_1
X_69_ net31 net8 net17 net26 _06_ _07_ VSS VSS VDD VDD _31_
+ sky130_fd_sc_hd__mux4_1
X_70_ select[0] VSS VSS VDD VDD _00_ sky130_fd_sc_hd__buf_6
X_71_ select[1] VSS VSS VDD VDD _01_ sky130_fd_sc_hd__clkbuf_4
X_72_ net2 net32 net9 net18 _00_ _01_ VSS VSS VDD VDD _32_
+ sky130_fd_sc_hd__mux4_1
X_73_ net13 net33 net10 net19 _00_ _01_ VSS VSS VDD VDD _33_
+ sky130_fd_sc_hd__mux4_1
X_74_ net24 net3 net11 net20 _00_ _01_ VSS VSS VDD VDD _34_
+ sky130_fd_sc_hd__mux4_1
X_75_ net27 net4 net12 net21 _00_ _01_ VSS VSS VDD VDD _35_
+ sky130_fd_sc_hd__mux4_1
X_76_ net28 net5 net14 net22 _00_ _01_ VSS VSS VDD VDD _36_
+ sky130_fd_sc_hd__mux4_1
X_77_ net29 net6 net15 net23 _00_ _01_ VSS VSS VDD VDD _37_
+ sky130_fd_sc_hd__mux4_1
X_78_ net30 net7 net16 net25 _00_ _01_ VSS VSS VDD VDD _38_
+ sky130_fd_sc_hd__mux4_1
X_79_ net31 net8 net17 net26 _00_ _01_ VSS VSS VDD VDD _39_
+ sky130_fd_sc_hd__mux4_1
Xdata_out\[0\]$_DFF_PN0_ clknet_2_1__leaf_clk _32_ net1 VSS
+ VSS VDD VDD net34 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[10\]$_DFF_PN0_ clknet_2_3__leaf_clk _10_ net1 VSS
+ VSS VDD VDD net35 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[11\]$_DFF_PN0_ clknet_2_2__leaf_clk _11_ net1 VSS
+ VSS VDD VDD net36 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[12\]$_DFF_PN0_ clknet_2_2__leaf_clk _12_ net1 VSS
+ VSS VDD VDD net37 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[13\]$_DFF_PN0_ clknet_2_1__leaf_clk _13_ net1 VSS
+ VSS VDD VDD net38 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[14\]$_DFF_PN0_ clknet_2_0__leaf_clk _14_ net1 VSS
+ VSS VDD VDD net39 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[15\]$_DFF_PN0_ clknet_2_1__leaf_clk _15_ net1 VSS
+ VSS VDD VDD net40 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[16\]$_DFF_PN0_ clknet_2_0__leaf_clk _16_ net1 VSS
+ VSS VDD VDD net41 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[17\]$_DFF_PN0_ clknet_2_3__leaf_clk _17_ net1 VSS
+ VSS VDD VDD net42 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[18\]$_DFF_PN0_ clknet_2_3__leaf_clk _18_ net1 VSS
+ VSS VDD VDD net43 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[19\]$_DFF_PN0_ clknet_2_0__leaf_clk _19_ net1 VSS
+ VSS VDD VDD net44 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[1\]$_DFF_PN0_ clknet_2_2__leaf_clk _33_ net1 VSS
+ VSS VDD VDD net45 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[20\]$_DFF_PN0_ clknet_2_2__leaf_clk _20_ net1 VSS
+ VSS VDD VDD net46 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[21\]$_DFF_PN0_ clknet_2_1__leaf_clk _21_ net1 VSS
+ VSS VDD VDD net47 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[22\]$_DFF_PN0_ clknet_2_0__leaf_clk _22_ net1 VSS
+ VSS VDD VDD net48 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[23\]$_DFF_PN0_ clknet_2_1__leaf_clk _23_ net1 VSS
+ VSS VDD VDD net49 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[24\]$_DFF_PN0_ clknet_2_1__leaf_clk _24_ net1 VSS
+ VSS VDD VDD net50 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[25\]$_DFF_PN0_ clknet_2_2__leaf_clk _25_ net1 VSS
+ VSS VDD VDD net51 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[26\]$_DFF_PN0_ clknet_2_3__leaf_clk _26_ net1 VSS
+ VSS VDD VDD net52 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[27\]$_DFF_PN0_ clknet_2_2__leaf_clk _27_ net1 VSS
+ VSS VDD VDD net53 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[28\]$_DFF_PN0_ clknet_2_2__leaf_clk _28_ net1 VSS
+ VSS VDD VDD net54 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[29\]$_DFF_PN0_ clknet_2_3__leaf_clk _29_ net1 VSS
+ VSS VDD VDD net55 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[2\]$_DFF_PN0_ clknet_2_3__leaf_clk _34_ net1 VSS
+ VSS VDD VDD net56 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[30\]$_DFF_PN0_ clknet_2_0__leaf_clk _30_ net1 VSS
+ VSS VDD VDD net57 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[31\]$_DFF_PN0_ clknet_2_1__leaf_clk _31_ net1 VSS
+ VSS VDD VDD net58 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[3\]$_DFF_PN0_ clknet_2_2__leaf_clk _35_ net1 VSS
+ VSS VDD VDD net59 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[4\]$_DFF_PN0_ clknet_2_2__leaf_clk _36_ net1 VSS
+ VSS VDD VDD net60 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[5\]$_DFF_PN0_ clknet_2_3__leaf_clk _37_ net1 VSS
+ VSS VDD VDD net61 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[6\]$_DFF_PN0_ clknet_2_0__leaf_clk _38_ net1 VSS
+ VSS VDD VDD net62 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[7\]$_DFF_PN0_ clknet_2_1__leaf_clk _39_ net1 VSS
+ VSS VDD VDD net63 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[8\]$_DFF_PN0_ clknet_2_0__leaf_clk _08_ net1 VSS
+ VSS VDD VDD net64 sky130_fd_sc_hd__dfrtp_1
Xdata_out\[9\]$_DFF_PN0_ clknet_2_3__leaf_clk _09_ net1 VSS
+ VSS VDD VDD net65 sky130_fd_sc_hd__dfrtp_1
Xhold1 net66 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_12
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 data_in[10] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 data_in[11] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 data_in[12] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 data_in[13] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 data_in[14] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 data_in[15] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 data_in[16] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 data_in[17] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 data_in[18] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 data_in[19] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 data_in[1] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput13 data_in[20] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput14 data_in[21] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput15 data_in[22] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput16 data_in[23] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput17 data_in[24] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xinput18 data_in[25] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xinput19 data_in[26] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
Xinput20 data_in[27] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
Xinput21 data_in[28] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
Xinput22 data_in[29] VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_1
Xinput23 data_in[2] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
Xinput24 data_in[30] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
Xinput25 data_in[31] VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_1
Xinput26 data_in[3] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
Xinput27 data_in[4] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_1
Xinput28 data_in[5] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_1
Xinput29 data_in[6] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_1
Xinput30 data_in[7] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_1
Xinput31 data_in[8] VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_1
Xinput32 data_in[9] VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_1
Xoutput33 net34 VSS VSS VDD VDD data_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput34 net35 VSS VSS VDD VDD data_out[10] sky130_fd_sc_hd__clkbuf_1
Xoutput35 net36 VSS VSS VDD VDD data_out[11] sky130_fd_sc_hd__clkbuf_1
Xoutput36 net37 VSS VSS VDD VDD data_out[12] sky130_fd_sc_hd__clkbuf_1
Xoutput37 net38 VSS VSS VDD VDD data_out[13] sky130_fd_sc_hd__clkbuf_1
Xoutput38 net39 VSS VSS VDD VDD data_out[14] sky130_fd_sc_hd__clkbuf_1
Xoutput39 net40 VSS VSS VDD VDD data_out[15] sky130_fd_sc_hd__clkbuf_1
Xoutput40 net41 VSS VSS VDD VDD data_out[16] sky130_fd_sc_hd__clkbuf_1
Xoutput41 net42 VSS VSS VDD VDD data_out[17] sky130_fd_sc_hd__clkbuf_1
Xoutput42 net43 VSS VSS VDD VDD data_out[18] sky130_fd_sc_hd__clkbuf_1
Xoutput43 net44 VSS VSS VDD VDD data_out[19] sky130_fd_sc_hd__clkbuf_1
Xoutput44 net45 VSS VSS VDD VDD data_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput45 net46 VSS VSS VDD VDD data_out[20] sky130_fd_sc_hd__clkbuf_1
Xoutput46 net47 VSS VSS VDD VDD data_out[21] sky130_fd_sc_hd__clkbuf_1
Xoutput47 net48 VSS VSS VDD VDD data_out[22] sky130_fd_sc_hd__clkbuf_1
Xoutput48 net49 VSS VSS VDD VDD data_out[23] sky130_fd_sc_hd__clkbuf_1
Xoutput49 net50 VSS VSS VDD VDD data_out[24] sky130_fd_sc_hd__clkbuf_1
Xoutput50 net51 VSS VSS VDD VDD data_out[25] sky130_fd_sc_hd__clkbuf_1
Xoutput51 net52 VSS VSS VDD VDD data_out[26] sky130_fd_sc_hd__clkbuf_1
Xoutput52 net53 VSS VSS VDD VDD data_out[27] sky130_fd_sc_hd__clkbuf_1
Xoutput53 net54 VSS VSS VDD VDD data_out[28] sky130_fd_sc_hd__clkbuf_1
Xoutput54 net55 VSS VSS VDD VDD data_out[29] sky130_fd_sc_hd__clkbuf_1
Xoutput55 net56 VSS VSS VDD VDD data_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput56 net57 VSS VSS VDD VDD data_out[30] sky130_fd_sc_hd__clkbuf_1
Xoutput57 net58 VSS VSS VDD VDD data_out[31] sky130_fd_sc_hd__clkbuf_1
Xoutput58 net59 VSS VSS VDD VDD data_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput59 net60 VSS VSS VDD VDD data_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput60 net61 VSS VSS VDD VDD data_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput61 net62 VSS VSS VDD VDD data_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput62 net63 VSS VSS VDD VDD data_out[7] sky130_fd_sc_hd__clkbuf_1
Xoutput63 net64 VSS VSS VDD VDD data_out[8] sky130_fd_sc_hd__clkbuf_1
Xoutput64 net65 VSS VSS VDD VDD data_out[9] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_2_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_8
Xclkload1 clknet_2_1__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkbuf_1
Xclkload2 clknet_2_3__leaf_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net66 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS crossbar_switch
