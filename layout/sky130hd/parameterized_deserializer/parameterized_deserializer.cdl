* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_deserializer clk enable load parallel_out[0]
+ parallel_out[1] parallel_out[2] parallel_out[3] parallel_out[4]
+ parallel_out[5] parallel_out[6] parallel_out[7] rst_n rx_busy
+ rx_done serial_in sync_detected VSS VDD
Xinput5 serial_in VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkdlybuf4s50_1
X_066_ net1 state\[1\] state\[0\] VSS VSS VDD VDD _043_ sky130_fd_sc_hd__a21oi_1
X_067_ net1 net2 _043_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__a21oi_1
X_068_ state\[2\] VSS VSS VDD VDD _044_ sky130_fd_sc_hd__inv_1
X_069_ net1 VSS VSS VDD VDD _045_ sky130_fd_sc_hd__inv_1
X_070_ clk_div_counter\[2\] _007_ bit_counter\[2\] _003_ VSS
+ VSS VDD VDD _046_ sky130_fd_sc_hd__nand4b_1
X_071_ _045_ bit_counter\[3\] _046_ VSS VSS VDD VDD _047_
+ sky130_fd_sc_hd__or3_1
X_072_ _045_ net2 state\[1\] VSS VSS VDD VDD _048_ sky130_fd_sc_hd__o21ai_0
X_073_ _044_ _047_ _048_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__o21ai_0
X_074_ state\[0\] net1 net2 state\[2\] _047_ VSS VSS VDD VDD
+ _002_ sky130_fd_sc_hd__a32o_1
X_075_ clk_div_counter\[0\] VSS VSS VDD VDD _005_ sky130_fd_sc_hd__inv_1
X_076_ clk_div_counter\[1\] VSS VSS VDD VDD _006_ sky130_fd_sc_hd__inv_1
X_077_ clk_div_counter\[2\] state\[2\] _007_ net1 VSS VSS
+ VDD VDD _049_ sky130_fd_sc_hd__and4b_1
Xinput4 rst_n VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkdlybuf4s50_1
X_079_ state\[2\] net1 state\[0\] VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nand3b_1
X_080_ _049_ _051_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nor2b_1
Xinput3 load VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkdlybuf4s50_1
X_082_ _049_ _052_ bit_counter\[0\] VSS VSS VDD VDD _011_
+ sky130_fd_sc_hd__mux2_2
X_083_ _004_ _049_ _052_ bit_counter\[1\] VSS VSS VDD VDD
+ _012_ sky130_fd_sc_hd__a22o_1
X_084_ state\[0\] state\[2\] net1 VSS VSS VDD VDD _054_ sky130_fd_sc_hd__o21ai_0
X_085_ bit_counter\[2\] _054_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__nand2_1
X_086_ clk_div_counter\[2\] _007_ net1 _003_ VSS VSS VDD VDD
+ _056_ sky130_fd_sc_hd__and4b_1
X_087_ bit_counter\[2\] _056_ _046_ state\[2\] VSS VSS VDD
+ VDD _057_ sky130_fd_sc_hd__o211ai_1
X_088_ _055_ _057_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__nand2_1
X_089_ bit_counter\[3\] _051_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__nand2_1
X_090_ bit_counter\[2\] bit_counter\[0\] bit_counter\[1\]
+ _049_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__nand4_1
X_091_ bit_counter\[3\] _058_ _059_ VSS VSS VDD VDD _014_
+ sky130_fd_sc_hd__mux2i_1
X_092_ _045_ clk_div_counter\[0\] _009_ VSS VSS VDD VDD _060_
+ sky130_fd_sc_hd__or3_1
X_093_ net1 _005_ _060_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__o21ai_0
X_094_ net1 _008_ VSS VSS VDD VDD _061_ sky130_fd_sc_hd__nand2_1
X_095_ net1 _006_ _009_ _061_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__o22ai_1
X_096_ clk_div_counter\[2\] _010_ net1 VSS VSS VDD VDD _017_
+ sky130_fd_sc_hd__mux2_2
X_097_ net1 state\[1\] VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nand2_1
X_098_ shift_reg\[0\] net5 _036_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__mux2_2
X_099_ shift_reg\[1\] net6 _036_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__mux2_2
X_100_ shift_reg\[2\] net7 _036_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__mux2_2
X_101_ shift_reg\[3\] net8 _036_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__mux2_2
X_102_ shift_reg\[4\] net9 _036_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__mux2_2
X_103_ shift_reg\[5\] net10 _036_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__mux2_2
X_104_ shift_reg\[6\] net11 _036_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__mux2_2
X_105_ shift_reg\[7\] net12 _036_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__mux2_2
X_106_ net13 VSS VSS VDD VDD _037_ sky130_fd_sc_hd__inv_1
X_107_ net1 net2 VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nand2_1
X_108_ net2 _037_ _038_ state\[1\] VSS VSS VDD VDD _039_ sky130_fd_sc_hd__o22ai_1
X_109_ net13 _036_ _039_ state\[0\] VSS VSS VDD VDD _026_
+ sky130_fd_sc_hd__a22o_1
X_110_ state\[0\] net1 VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nand2_1
X_111_ net14 _040_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__nand2_1
X_112_ _036_ _041_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nand2_1
X_113_ net4 _049_ _052_ shift_reg\[0\] VSS VSS VDD VDD _028_
+ sky130_fd_sc_hd__a22o_1
X_114_ shift_reg\[0\] _049_ _052_ shift_reg\[1\] VSS VSS VDD
+ VDD _029_ sky130_fd_sc_hd__a22o_1
X_115_ shift_reg\[1\] _049_ _052_ shift_reg\[2\] VSS VSS VDD
+ VDD _030_ sky130_fd_sc_hd__a22o_1
X_116_ shift_reg\[2\] _049_ _052_ shift_reg\[3\] VSS VSS VDD
+ VDD _031_ sky130_fd_sc_hd__a22o_1
X_117_ shift_reg\[3\] _049_ _052_ shift_reg\[4\] VSS VSS VDD
+ VDD _032_ sky130_fd_sc_hd__a22o_1
X_118_ shift_reg\[4\] _049_ _052_ shift_reg\[5\] VSS VSS VDD
+ VDD _033_ sky130_fd_sc_hd__a22o_1
X_119_ shift_reg\[5\] _049_ _052_ shift_reg\[6\] VSS VSS VDD
+ VDD _034_ sky130_fd_sc_hd__a22o_1
X_120_ shift_reg\[6\] _049_ _052_ shift_reg\[7\] VSS VSS VDD
+ VDD _035_ sky130_fd_sc_hd__a22o_1
X_121_ bit_counter\[0\] bit_counter\[1\] VSS VSS VDD VDD _003_
+ _004_ sky130_fd_sc_hd__ha_1
X_122_ _005_ _006_ VSS VSS VDD VDD _007_ _008_ sky130_fd_sc_hd__ha_1
X_123_ clk_div_counter\[0\] clk_div_counter\[1\] VSS VSS VDD
+ VDD _062_ _063_ sky130_fd_sc_hd__ha_1
X_124_ clk_div_counter\[2\] _062_ VSS VSS VDD VDD _009_ _010_
+ sky130_fd_sc_hd__ha_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput2 enable VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkdlybuf4s50_1
Xbit_counter\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _011_ net16
+ VSS VSS VDD VDD bit_counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xbit_counter\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _012_ net16
+ VSS VSS VDD VDD bit_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xbit_counter\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _013_ net16
+ VSS VSS VDD VDD bit_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xbit_counter\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _014_ net16
+ VSS VSS VDD VDD bit_counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xclk_div_counter\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _015_
+ net16 VSS VSS VDD VDD clk_div_counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xclk_div_counter\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _016_
+ net16 VSS VSS VDD VDD clk_div_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xclk_div_counter\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _017_
+ net16 VSS VSS VDD VDD clk_div_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _018_
+ net16 VSS VSS VDD VDD net5 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _019_
+ net16 VSS VSS VDD VDD net6 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _020_
+ net16 VSS VSS VDD VDD net7 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _021_
+ net16 VSS VSS VDD VDD net8 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _022_
+ net16 VSS VSS VDD VDD net9 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _023_
+ net16 VSS VSS VDD VDD net10 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _024_
+ net16 VSS VSS VDD VDD net11 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _025_
+ net16 VSS VSS VDD VDD net12 sky130_fd_sc_hd__dfrtp_1
Xrx_busy$_DFFE_PN0P_ clknet_1_1__leaf_clk _026_ net16 VSS
+ VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xrx_done$_DFFE_PN0P_ clknet_1_1__leaf_clk _027_ net16 VSS
+ VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _028_ net16
+ VSS VSS VDD VDD shift_reg\[0\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _029_ net16
+ VSS VSS VDD VDD shift_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _030_ net16
+ VSS VSS VDD VDD shift_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _031_ net16
+ VSS VSS VDD VDD shift_reg\[3\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _032_ net16
+ VSS VSS VDD VDD shift_reg\[4\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _033_ net16
+ VSS VSS VDD VDD shift_reg\[5\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _034_ net16
+ VSS VSS VDD VDD shift_reg\[6\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _035_ net16
+ VSS VSS VDD VDD shift_reg\[7\] sky130_fd_sc_hd__dfrtp_1
Xstate\[0\]$_DFF_PN1_ clknet_1_1__leaf_clk _000_ net16 VSS
+ VSS VDD VDD state\[0\] sky130_fd_sc_hd__dfstp_2
Xstate\[1\]$_DFF_PN0_ clknet_1_1__leaf_clk _001_ net16 VSS
+ VSS VDD VDD state\[1\] sky130_fd_sc_hd__dfrtp_1
Xstate\[2\]$_DFF_PN0_ clknet_1_1__leaf_clk _002_ net16 VSS
+ VSS VDD VDD state\[2\] sky130_fd_sc_hd__dfrtp_1
X_126__1 VSS VSS VDD VDD _unconnected_0 sync_detected sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput6 net5 VSS VSS VDD VDD parallel_out[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput7 net6 VSS VSS VDD VDD parallel_out[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput8 net7 VSS VSS VDD VDD parallel_out[2] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput9 net8 VSS VSS VDD VDD parallel_out[3] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput10 net9 VSS VSS VDD VDD parallel_out[4] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput11 net10 VSS VSS VDD VDD parallel_out[5] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput12 net11 VSS VSS VDD VDD parallel_out[6] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput13 net12 VSS VSS VDD VDD parallel_out[7] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput14 net13 VSS VSS VDD VDD rx_busy sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput15 net14 VSS VSS VDD VDD rx_done sky130_fd_sc_hd__clkdlybuf4s50_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xplace17 net3 VSS VSS VDD VDD net16 sky130_fd_sc_hd__buf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkbuf_8
.ENDS parameterized_deserializer
