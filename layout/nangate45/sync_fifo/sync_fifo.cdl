* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT sync_fifo almost_empty almost_full clk empty full
+ rd_count[0] rd_count[1] rd_count[2] rd_count[3] rd_count[4]
+ rd_data[0] rd_data[1] rd_data[2] rd_data[3] rd_data[4] rd_data[5]
+ rd_data[6] rd_data[7] rd_en rst_n wr_count[0] wr_count[1]
+ wr_count[2] wr_count[3] wr_count[4] wr_data[0] wr_data[1]
+ wr_data[2] wr_data[3] wr_data[4] wr_data[5] wr_data[6] wr_data[7]
+ wr_en
X_0570_ _0553_ _0558_ _0550_ _0151_ VDD VSS NAND3_X1
X_0571_ _0552_ _0557_ _0553_ _0152_ VDD VSS AOI21_X1
X_0572_ _0151_ _0152_ _0153_ VDD VSS NAND2_X1
X_0573_ wr_ptr\[4\] rd_ptr\[4\] _0154_ VDD VSS XOR2_X2
X_0574_ _0153_ _0154_ _0155_ VDD VSS XOR2_X2
X_0575_ _0155_ net11 VDD VSS INV_X4
X_0576_ _0569_ net7 VDD VSS INV_X2
X_0577_ _0558_ _0550_ net9 VDD VSS XOR2_X2
X_0578_ _0554_ _0557_ _0156_ VDD VSS OR2_X1
X_0579_ _0568_ _0549_ VDD VSS INV_X1
X_0580_ _0156_ _0549_ _0555_ _0157_ VDD VSS AOI21_X2
X_0581_ _0558_ _0557_ _0158_ VDD VSS OR2_X1
X_0582_ _0553_ _0158_ _0159_ VDD VSS NAND2_X1
X_0583_ _0157_ _0159_ _0160_ VDD VSS NOR2_X2
X_0584_ _0554_ _0557_ _0161_ VDD VSS NOR2_X1
X_0585_ _0555_ _0162_ VDD VSS INV_X1
X_0586_ _0161_ _0568_ _0162_ _0163_ VDD VSS OAI21_X2
X_0587_ _0553_ _0163_ _0158_ _0164_ VDD VSS AOI21_X4
X_0588_ _0160_ _0164_ _0165_ VDD VSS OR2_X1
X_0589_ _0165_ net10 VDD VSS INV_X2
X_0590_ net8 net7 net9 _0166_ VDD VSS OR3_X4
X_0591_ _0166_ _0167_ VDD VSS INV_X4
X_0592_ net11 _0167_ _0164_ _0160_ _0168_ VDD VSS OAI211_X4
X_0593_ _0168_ _0169_ VDD VSS BUF_X8
X_0594_ _0169_ _0170_ VDD VSS BUF_X16
X_0595_ _0170_ net6 VDD VSS INV_X4
X_0596_ net11 net10 _0166_ net5 VDD VSS NOR3_X4
X_0597_ wr_data[0] _0171_ VDD VSS BUF_X2
X_0598_ _0171_ _0172_ VDD VSS BUF_X2
X_0599_ wr_ptr\[2\] _0173_ VDD VSS BUF_X4
X_0600_ _0173_ _0174_ VDD VSS INV_X8
X_0601_ _0561_ _0175_ VDD VSS CLKBUF_X3
X_0602_ wr_en _0176_ VDD VSS BUF_X1
X_0603_ _0176_ _0177_ VDD VSS INV_X1
X_0604_ _0177_ wr_ptr\[3\] _0178_ VDD VSS NOR2_X1
X_0605_ _0178_ _0179_ VDD VSS BUF_X8
X_0606_ _0174_ _0175_ _0170_ _0179_ _0180_ VDD VSS NAND4_X4
X_0607_ _0172_ mem\[0\]\[0\] _0180_ _0004_ VDD VSS MUX2_X1
X_0608_ wr_data[1] _0181_ VDD VSS CLKBUF_X2
X_0609_ _0181_ _0182_ VDD VSS BUF_X2
X_0610_ _0182_ mem\[0\]\[1\] _0180_ _0005_ VDD VSS MUX2_X1
X_0611_ wr_data[2] _0183_ VDD VSS CLKBUF_X2
X_0612_ _0183_ _0184_ VDD VSS BUF_X2
X_0613_ _0184_ mem\[0\]\[2\] _0180_ _0006_ VDD VSS MUX2_X1
X_0614_ wr_data[3] _0185_ VDD VSS CLKBUF_X2
X_0615_ _0185_ _0186_ VDD VSS BUF_X2
X_0616_ _0186_ mem\[0\]\[3\] _0180_ _0007_ VDD VSS MUX2_X1
X_0617_ wr_data[4] _0187_ VDD VSS BUF_X2
X_0618_ _0187_ _0188_ VDD VSS BUF_X2
X_0619_ _0188_ mem\[0\]\[4\] _0180_ _0008_ VDD VSS MUX2_X1
X_0620_ wr_data[5] _0189_ VDD VSS BUF_X2
X_0621_ _0189_ _0190_ VDD VSS BUF_X2
X_0622_ _0190_ mem\[0\]\[5\] _0180_ _0009_ VDD VSS MUX2_X1
X_0623_ wr_data[6] _0191_ VDD VSS BUF_X2
X_0624_ _0191_ _0192_ VDD VSS BUF_X2
X_0625_ _0192_ mem\[0\]\[6\] _0180_ _0010_ VDD VSS MUX2_X1
X_0626_ wr_data[7] _0193_ VDD VSS BUF_X2
X_0627_ _0193_ _0194_ VDD VSS BUF_X2
X_0628_ _0194_ mem\[0\]\[7\] _0180_ _0011_ VDD VSS MUX2_X1
X_0629_ _0562_ _0195_ VDD VSS CLKBUF_X3
X_0630_ _0176_ wr_ptr\[3\] _0196_ VDD VSS AND2_X1
X_0631_ _0196_ _0197_ VDD VSS BUF_X4
X_0632_ _0174_ _0195_ _0170_ _0197_ _0198_ VDD VSS NAND4_X4
X_0633_ _0172_ mem\[10\]\[0\] _0198_ _0012_ VDD VSS MUX2_X1
X_0634_ _0182_ mem\[10\]\[1\] _0198_ _0013_ VDD VSS MUX2_X1
X_0635_ _0184_ mem\[10\]\[2\] _0198_ _0014_ VDD VSS MUX2_X1
X_0636_ _0186_ mem\[10\]\[3\] _0198_ _0015_ VDD VSS MUX2_X1
X_0637_ _0188_ mem\[10\]\[4\] _0198_ _0016_ VDD VSS MUX2_X1
X_0638_ _0190_ mem\[10\]\[5\] _0198_ _0017_ VDD VSS MUX2_X1
X_0639_ _0192_ mem\[10\]\[6\] _0198_ _0018_ VDD VSS MUX2_X1
X_0640_ _0194_ mem\[10\]\[7\] _0198_ _0019_ VDD VSS MUX2_X1
X_0641_ _0566_ _0199_ VDD VSS CLKBUF_X3
X_0642_ _0174_ _0199_ _0170_ _0197_ _0200_ VDD VSS NAND4_X4
X_0643_ _0172_ mem\[11\]\[0\] _0200_ _0020_ VDD VSS MUX2_X1
X_0644_ _0182_ mem\[11\]\[1\] _0200_ _0021_ VDD VSS MUX2_X1
X_0645_ _0184_ mem\[11\]\[2\] _0200_ _0022_ VDD VSS MUX2_X1
X_0646_ _0186_ mem\[11\]\[3\] _0200_ _0023_ VDD VSS MUX2_X1
X_0647_ _0188_ mem\[11\]\[4\] _0200_ _0024_ VDD VSS MUX2_X1
X_0648_ _0190_ mem\[11\]\[5\] _0200_ _0025_ VDD VSS MUX2_X1
X_0649_ _0192_ mem\[11\]\[6\] _0200_ _0026_ VDD VSS MUX2_X1
X_0650_ _0194_ mem\[11\]\[7\] _0200_ _0027_ VDD VSS MUX2_X1
X_0651_ _0173_ _0175_ _0169_ _0197_ _0201_ VDD VSS AND4_X1
X_0652_ _0201_ _0202_ VDD VSS BUF_X8
X_0653_ mem\[12\]\[0\] _0172_ _0202_ _0028_ VDD VSS MUX2_X1
X_0654_ mem\[12\]\[1\] _0182_ _0202_ _0029_ VDD VSS MUX2_X1
X_0655_ mem\[12\]\[2\] _0184_ _0202_ _0030_ VDD VSS MUX2_X1
X_0656_ mem\[12\]\[3\] _0186_ _0202_ _0031_ VDD VSS MUX2_X1
X_0657_ mem\[12\]\[4\] _0188_ _0202_ _0032_ VDD VSS MUX2_X1
X_0658_ mem\[12\]\[5\] _0190_ _0202_ _0033_ VDD VSS MUX2_X1
X_0659_ mem\[12\]\[6\] _0192_ _0202_ _0034_ VDD VSS MUX2_X1
X_0660_ mem\[12\]\[7\] _0194_ _0202_ _0035_ VDD VSS MUX2_X1
X_0661_ _0564_ _0203_ VDD VSS CLKBUF_X3
X_0662_ _0173_ _0203_ _0169_ _0197_ _0204_ VDD VSS AND4_X1
X_0663_ _0204_ _0205_ VDD VSS BUF_X8
X_0664_ mem\[13\]\[0\] _0172_ _0205_ _0036_ VDD VSS MUX2_X1
X_0665_ mem\[13\]\[1\] _0182_ _0205_ _0037_ VDD VSS MUX2_X1
X_0666_ mem\[13\]\[2\] _0184_ _0205_ _0038_ VDD VSS MUX2_X1
X_0667_ mem\[13\]\[3\] _0186_ _0205_ _0039_ VDD VSS MUX2_X1
X_0668_ mem\[13\]\[4\] _0188_ _0205_ _0040_ VDD VSS MUX2_X1
X_0669_ mem\[13\]\[5\] _0190_ _0205_ _0041_ VDD VSS MUX2_X1
X_0670_ mem\[13\]\[6\] _0192_ _0205_ _0042_ VDD VSS MUX2_X1
X_0671_ mem\[13\]\[7\] _0194_ _0205_ _0043_ VDD VSS MUX2_X1
X_0672_ _0173_ _0195_ _0169_ _0197_ _0206_ VDD VSS AND4_X1
X_0673_ _0206_ _0207_ VDD VSS BUF_X8
X_0674_ mem\[14\]\[0\] _0172_ _0207_ _0044_ VDD VSS MUX2_X1
X_0675_ mem\[14\]\[1\] _0182_ _0207_ _0045_ VDD VSS MUX2_X1
X_0676_ mem\[14\]\[2\] _0184_ _0207_ _0046_ VDD VSS MUX2_X1
X_0677_ mem\[14\]\[3\] _0186_ _0207_ _0047_ VDD VSS MUX2_X1
X_0678_ mem\[14\]\[4\] _0188_ _0207_ _0048_ VDD VSS MUX2_X1
X_0679_ mem\[14\]\[5\] _0190_ _0207_ _0049_ VDD VSS MUX2_X1
X_0680_ mem\[14\]\[6\] _0192_ _0207_ _0050_ VDD VSS MUX2_X1
X_0681_ mem\[14\]\[7\] _0194_ _0207_ _0051_ VDD VSS MUX2_X1
X_0682_ wr_ptr\[2\] _0199_ _0168_ _0197_ _0208_ VDD VSS AND4_X1
X_0683_ _0208_ _0209_ VDD VSS BUF_X4
X_0684_ mem\[15\]\[0\] _0172_ _0209_ _0052_ VDD VSS MUX2_X1
X_0685_ mem\[15\]\[1\] _0182_ _0209_ _0053_ VDD VSS MUX2_X1
X_0686_ mem\[15\]\[2\] _0184_ _0209_ _0054_ VDD VSS MUX2_X1
X_0687_ mem\[15\]\[3\] _0186_ _0209_ _0055_ VDD VSS MUX2_X1
X_0688_ mem\[15\]\[4\] _0188_ _0209_ _0056_ VDD VSS MUX2_X1
X_0689_ mem\[15\]\[5\] _0190_ _0209_ _0057_ VDD VSS MUX2_X1
X_0690_ mem\[15\]\[6\] _0192_ _0209_ _0058_ VDD VSS MUX2_X1
X_0691_ mem\[15\]\[7\] _0194_ _0209_ _0059_ VDD VSS MUX2_X1
X_0692_ _0174_ _0203_ _0170_ _0179_ _0210_ VDD VSS NAND4_X4
X_0693_ _0172_ mem\[1\]\[0\] _0210_ _0060_ VDD VSS MUX2_X1
X_0694_ _0182_ mem\[1\]\[1\] _0210_ _0061_ VDD VSS MUX2_X1
X_0695_ _0184_ mem\[1\]\[2\] _0210_ _0062_ VDD VSS MUX2_X1
X_0696_ _0186_ mem\[1\]\[3\] _0210_ _0063_ VDD VSS MUX2_X1
X_0697_ _0188_ mem\[1\]\[4\] _0210_ _0064_ VDD VSS MUX2_X1
X_0698_ _0190_ mem\[1\]\[5\] _0210_ _0065_ VDD VSS MUX2_X1
X_0699_ _0192_ mem\[1\]\[6\] _0210_ _0066_ VDD VSS MUX2_X1
X_0700_ _0194_ mem\[1\]\[7\] _0210_ _0067_ VDD VSS MUX2_X1
X_0701_ _0174_ _0195_ _0170_ _0179_ _0211_ VDD VSS NAND4_X4
X_0702_ _0172_ mem\[2\]\[0\] _0211_ _0068_ VDD VSS MUX2_X1
X_0703_ _0182_ mem\[2\]\[1\] _0211_ _0069_ VDD VSS MUX2_X1
X_0704_ _0184_ mem\[2\]\[2\] _0211_ _0070_ VDD VSS MUX2_X1
X_0705_ _0186_ mem\[2\]\[3\] _0211_ _0071_ VDD VSS MUX2_X1
X_0706_ _0188_ mem\[2\]\[4\] _0211_ _0072_ VDD VSS MUX2_X1
X_0707_ _0190_ mem\[2\]\[5\] _0211_ _0073_ VDD VSS MUX2_X1
X_0708_ _0192_ mem\[2\]\[6\] _0211_ _0074_ VDD VSS MUX2_X1
X_0709_ _0194_ mem\[2\]\[7\] _0211_ _0075_ VDD VSS MUX2_X1
X_0710_ _0174_ _0199_ _0170_ _0179_ _0212_ VDD VSS NAND4_X4
X_0711_ _0172_ mem\[3\]\[0\] _0212_ _0076_ VDD VSS MUX2_X1
X_0712_ _0182_ mem\[3\]\[1\] _0212_ _0077_ VDD VSS MUX2_X1
X_0713_ _0184_ mem\[3\]\[2\] _0212_ _0078_ VDD VSS MUX2_X1
X_0714_ _0186_ mem\[3\]\[3\] _0212_ _0079_ VDD VSS MUX2_X1
X_0715_ _0188_ mem\[3\]\[4\] _0212_ _0080_ VDD VSS MUX2_X1
X_0716_ _0190_ mem\[3\]\[5\] _0212_ _0081_ VDD VSS MUX2_X1
X_0717_ _0192_ mem\[3\]\[6\] _0212_ _0082_ VDD VSS MUX2_X1
X_0718_ _0194_ mem\[3\]\[7\] _0212_ _0083_ VDD VSS MUX2_X1
X_0719_ _0173_ _0175_ _0169_ _0179_ _0213_ VDD VSS NAND4_X4
X_0720_ _0171_ mem\[4\]\[0\] _0213_ _0084_ VDD VSS MUX2_X1
X_0721_ _0181_ mem\[4\]\[1\] _0213_ _0085_ VDD VSS MUX2_X1
X_0722_ _0183_ mem\[4\]\[2\] _0213_ _0086_ VDD VSS MUX2_X1
X_0723_ _0185_ mem\[4\]\[3\] _0213_ _0087_ VDD VSS MUX2_X1
X_0724_ _0187_ mem\[4\]\[4\] _0213_ _0088_ VDD VSS MUX2_X1
X_0725_ _0189_ mem\[4\]\[5\] _0213_ _0089_ VDD VSS MUX2_X1
X_0726_ _0191_ mem\[4\]\[6\] _0213_ _0090_ VDD VSS MUX2_X1
X_0727_ _0193_ mem\[4\]\[7\] _0213_ _0091_ VDD VSS MUX2_X1
X_0728_ _0173_ _0203_ _0169_ _0179_ _0214_ VDD VSS NAND4_X4
X_0729_ _0171_ mem\[5\]\[0\] _0214_ _0092_ VDD VSS MUX2_X1
X_0730_ _0181_ mem\[5\]\[1\] _0214_ _0093_ VDD VSS MUX2_X1
X_0731_ _0183_ mem\[5\]\[2\] _0214_ _0094_ VDD VSS MUX2_X1
X_0732_ _0185_ mem\[5\]\[3\] _0214_ _0095_ VDD VSS MUX2_X1
X_0733_ _0187_ mem\[5\]\[4\] _0214_ _0096_ VDD VSS MUX2_X1
X_0734_ _0189_ mem\[5\]\[5\] _0214_ _0097_ VDD VSS MUX2_X1
X_0735_ _0191_ mem\[5\]\[6\] _0214_ _0098_ VDD VSS MUX2_X1
X_0736_ _0193_ mem\[5\]\[7\] _0214_ _0099_ VDD VSS MUX2_X1
X_0737_ _0173_ _0195_ _0169_ _0179_ _0215_ VDD VSS NAND4_X4
X_0738_ _0171_ mem\[6\]\[0\] _0215_ _0100_ VDD VSS MUX2_X1
X_0739_ _0181_ mem\[6\]\[1\] _0215_ _0101_ VDD VSS MUX2_X1
X_0740_ _0183_ mem\[6\]\[2\] _0215_ _0102_ VDD VSS MUX2_X1
X_0741_ _0185_ mem\[6\]\[3\] _0215_ _0103_ VDD VSS MUX2_X1
X_0742_ _0187_ mem\[6\]\[4\] _0215_ _0104_ VDD VSS MUX2_X1
X_0743_ _0189_ mem\[6\]\[5\] _0215_ _0105_ VDD VSS MUX2_X1
X_0744_ _0191_ mem\[6\]\[6\] _0215_ _0106_ VDD VSS MUX2_X1
X_0745_ _0193_ mem\[6\]\[7\] _0215_ _0107_ VDD VSS MUX2_X1
X_0746_ _0173_ _0199_ _0169_ _0179_ _0216_ VDD VSS NAND4_X4
X_0747_ _0171_ mem\[7\]\[0\] _0216_ _0108_ VDD VSS MUX2_X1
X_0748_ _0181_ mem\[7\]\[1\] _0216_ _0109_ VDD VSS MUX2_X1
X_0749_ _0183_ mem\[7\]\[2\] _0216_ _0110_ VDD VSS MUX2_X1
X_0750_ _0185_ mem\[7\]\[3\] _0216_ _0111_ VDD VSS MUX2_X1
X_0751_ _0187_ mem\[7\]\[4\] _0216_ _0112_ VDD VSS MUX2_X1
X_0752_ _0189_ mem\[7\]\[5\] _0216_ _0113_ VDD VSS MUX2_X1
X_0753_ _0191_ mem\[7\]\[6\] _0216_ _0114_ VDD VSS MUX2_X1
X_0754_ _0193_ mem\[7\]\[7\] _0216_ _0115_ VDD VSS MUX2_X1
X_0755_ _0174_ _0175_ _0169_ _0197_ _0217_ VDD VSS NAND4_X4
X_0756_ _0171_ mem\[8\]\[0\] _0217_ _0116_ VDD VSS MUX2_X1
X_0757_ _0181_ mem\[8\]\[1\] _0217_ _0117_ VDD VSS MUX2_X1
X_0758_ _0183_ mem\[8\]\[2\] _0217_ _0118_ VDD VSS MUX2_X1
X_0759_ _0185_ mem\[8\]\[3\] _0217_ _0119_ VDD VSS MUX2_X1
X_0760_ _0187_ mem\[8\]\[4\] _0217_ _0120_ VDD VSS MUX2_X1
X_0761_ _0189_ mem\[8\]\[5\] _0217_ _0121_ VDD VSS MUX2_X1
X_0762_ _0191_ mem\[8\]\[6\] _0217_ _0122_ VDD VSS MUX2_X1
X_0763_ _0193_ mem\[8\]\[7\] _0217_ _0123_ VDD VSS MUX2_X1
X_0764_ _0174_ _0203_ _0169_ _0197_ _0218_ VDD VSS NAND4_X4
X_0765_ _0171_ mem\[9\]\[0\] _0218_ _0124_ VDD VSS MUX2_X1
X_0766_ _0181_ mem\[9\]\[1\] _0218_ _0125_ VDD VSS MUX2_X1
X_0767_ _0183_ mem\[9\]\[2\] _0218_ _0126_ VDD VSS MUX2_X1
X_0768_ _0185_ mem\[9\]\[3\] _0218_ _0127_ VDD VSS MUX2_X1
X_0769_ _0187_ mem\[9\]\[4\] _0218_ _0128_ VDD VSS MUX2_X1
X_0770_ _0189_ mem\[9\]\[5\] _0218_ _0129_ VDD VSS MUX2_X1
X_0771_ _0191_ mem\[9\]\[6\] _0218_ _0130_ VDD VSS MUX2_X1
X_0772_ _0193_ mem\[9\]\[7\] _0218_ _0131_ VDD VSS MUX2_X1
X_0773_ net2 _0219_ VDD VSS INV_X2
X_0774_ net1 _0166_ _0220_ VDD VSS NAND2_X1
X_0775_ net1 _0157_ _0159_ _0221_ VDD VSS OAI21_X1
X_0776_ net1 _0222_ VDD VSS INV_X1
X_0777_ _0220_ _0221_ _0164_ _0155_ _0222_ _0223_ VDD VSS
+ OAI221_X2
X_0778_ _0223_ _0224_ VDD VSS BUF_X4
X_0779_ _0224_ _0225_ VDD VSS BUF_X8
X_0780_ rd_data_reg\[0\] _0225_ _0226_ VDD VSS NOR2_X1
X_0781_ rd_ptr\[0\] _0227_ VDD VSS CLKBUF_X3
X_0782_ _0227_ _0228_ VDD VSS BUF_X4
X_0783_ _0228_ _0229_ VDD VSS BUF_X4
X_0784_ rd_ptr\[2\] _0230_ VDD VSS BUF_X4
X_0785_ _0230_ _0231_ VDD VSS BUF_X4
X_0786_ mem\[0\]\[0\] mem\[4\]\[0\] _0231_ _0232_ VDD VSS
+ MUX2_X1
X_0787_ _0229_ _0232_ _0233_ VDD VSS NOR2_X1
X_0788_ _0228_ _0234_ VDD VSS INV_X1
X_0789_ mem\[1\]\[0\] mem\[5\]\[0\] _0231_ _0235_ VDD VSS
+ MUX2_X1
X_0790_ _0234_ _0235_ _0236_ VDD VSS NOR2_X1
X_0791_ rd_ptr\[1\] _0237_ VDD VSS BUF_X4
X_0792_ _0237_ _0238_ VDD VSS BUF_X4
X_0793_ rd_ptr\[3\] _0239_ VDD VSS CLKBUF_X3
X_0794_ _0238_ _0239_ _0240_ VDD VSS OR2_X4
X_0795_ _0239_ _0241_ VDD VSS INV_X2
X_0796_ _0238_ _0241_ _0242_ VDD VSS NAND2_X4
X_0797_ _0230_ _0243_ VDD VSS BUF_X4
X_0798_ mem\[2\]\[0\] mem\[6\]\[0\] _0243_ _0244_ VDD VSS
+ MUX2_X1
X_0799_ _0229_ _0244_ _0245_ VDD VSS NOR2_X1
X_0800_ mem\[3\]\[0\] mem\[7\]\[0\] _0230_ _0246_ VDD VSS
+ MUX2_X1
X_0801_ _0234_ _0246_ _0247_ VDD VSS NOR2_X1
X_0802_ _0233_ _0236_ _0240_ _0242_ _0245_ _0247_ _0248_ VDD
+ VSS OAI33_X1
X_0803_ mem\[9\]\[0\] mem\[11\]\[0\] _0237_ _0249_ VDD VSS
+ MUX2_X1
X_0804_ mem\[13\]\[0\] mem\[15\]\[0\] _0237_ _0250_ VDD VSS
+ MUX2_X1
X_0805_ _0249_ _0250_ _0231_ _0251_ VDD VSS MUX2_X1
X_0806_ mem\[12\]\[0\] mem\[14\]\[0\] _0237_ _0252_ VDD VSS
+ MUX2_X1
X_0807_ _0237_ _0253_ VDD VSS BUF_X4
X_0808_ mem\[8\]\[0\] mem\[10\]\[0\] _0253_ _0254_ VDD VSS
+ MUX2_X1
X_0809_ _0231_ _0255_ VDD VSS INV_X2
X_0810_ _0252_ _0254_ _0255_ _0256_ VDD VSS MUX2_X1
X_0811_ _0251_ _0256_ _0234_ _0257_ VDD VSS MUX2_X1
X_0812_ _0248_ _0257_ _0239_ _0258_ VDD VSS AOI21_X1
X_0813_ _0225_ _0258_ _0259_ VDD VSS AND2_X1
X_0814_ _0219_ _0226_ _0259_ _0132_ VDD VSS NOR3_X1
X_0815_ net2 _0260_ VDD VSS BUF_X2
X_0816_ _0260_ _0261_ VDD VSS BUF_X2
X_0817_ mem\[12\]\[1\] mem\[14\]\[1\] _0237_ _0262_ VDD VSS
+ MUX2_X1
X_0818_ mem\[13\]\[1\] mem\[15\]\[1\] _0237_ _0263_ VDD VSS
+ MUX2_X1
X_0819_ _0262_ _0263_ _0227_ _0264_ VDD VSS MUX2_X1
X_0820_ mem\[8\]\[1\] mem\[10\]\[1\] _0237_ _0265_ VDD VSS
+ MUX2_X1
X_0821_ mem\[9\]\[1\] mem\[11\]\[1\] _0237_ _0266_ VDD VSS
+ MUX2_X1
X_0822_ _0265_ _0266_ _0227_ _0267_ VDD VSS MUX2_X1
X_0823_ _0264_ _0267_ _0255_ _0268_ VDD VSS MUX2_X1
X_0824_ mem\[0\]\[1\] mem\[4\]\[1\] rd_ptr\[2\] _0269_ VDD
+ VSS MUX2_X1
X_0825_ mem\[1\]\[1\] mem\[5\]\[1\] _0230_ _0270_ VDD VSS
+ MUX2_X1
X_0826_ _0269_ _0270_ _0227_ _0271_ VDD VSS MUX2_X1
X_0827_ mem\[2\]\[1\] mem\[6\]\[1\] _0230_ _0272_ VDD VSS
+ MUX2_X1
X_0828_ mem\[3\]\[1\] mem\[7\]\[1\] _0230_ _0273_ VDD VSS
+ MUX2_X1
X_0829_ _0272_ _0273_ _0227_ _0274_ VDD VSS MUX2_X1
X_0830_ _0271_ _0274_ _0238_ _0275_ VDD VSS MUX2_X1
X_0831_ _0268_ _0275_ _0241_ _0276_ VDD VSS MUX2_X1
X_0832_ rd_data_reg\[1\] _0276_ _0225_ _0277_ VDD VSS MUX2_X1
X_0833_ _0261_ _0277_ _0133_ VDD VSS AND2_X1
X_0834_ _0230_ _0278_ VDD VSS BUF_X4
X_0835_ mem\[2\]\[2\] mem\[6\]\[2\] _0278_ _0279_ VDD VSS
+ MUX2_X1
X_0836_ mem\[3\]\[2\] mem\[7\]\[2\] _0231_ _0280_ VDD VSS
+ MUX2_X1
X_0837_ _0279_ _0280_ _0229_ _0281_ VDD VSS MUX2_X1
X_0838_ mem\[0\]\[2\] mem\[4\]\[2\] _0243_ _0282_ VDD VSS
+ MUX2_X1
X_0839_ mem\[1\]\[2\] mem\[5\]\[2\] _0243_ _0283_ VDD VSS
+ MUX2_X1
X_0840_ _0227_ _0284_ VDD VSS BUF_X4
X_0841_ _0282_ _0283_ _0284_ _0285_ VDD VSS MUX2_X1
X_0842_ _0242_ _0281_ _0285_ _0240_ _0286_ VDD VSS OAI22_X2
X_0843_ mem\[8\]\[2\] mem\[10\]\[2\] _0238_ _0287_ VDD VSS
+ MUX2_X1
X_0844_ mem\[9\]\[2\] mem\[11\]\[2\] _0238_ _0288_ VDD VSS
+ MUX2_X1
X_0845_ _0287_ _0288_ _0229_ _0289_ VDD VSS MUX2_X1
X_0846_ _0255_ _0239_ _0290_ VDD VSS NAND2_X2
X_0847_ _0231_ _0239_ _0291_ VDD VSS NAND2_X2
X_0848_ mem\[12\]\[2\] mem\[14\]\[2\] _0253_ _0292_ VDD VSS
+ MUX2_X1
X_0849_ mem\[13\]\[2\] mem\[15\]\[2\] _0253_ _0293_ VDD VSS
+ MUX2_X1
X_0850_ _0292_ _0293_ _0228_ _0294_ VDD VSS MUX2_X1
X_0851_ _0289_ _0290_ _0291_ _0294_ _0295_ VDD VSS OAI22_X1
X_0852_ _0286_ _0295_ _0296_ VDD VSS NOR2_X1
X_0853_ rd_data_reg\[2\] _0296_ _0225_ _0297_ VDD VSS MUX2_X1
X_0854_ _0261_ _0297_ _0134_ VDD VSS AND2_X1
X_0855_ mem\[2\]\[3\] mem\[6\]\[3\] _0278_ _0298_ VDD VSS
+ MUX2_X1
X_0856_ mem\[3\]\[3\] mem\[7\]\[3\] _0231_ _0299_ VDD VSS
+ MUX2_X1
X_0857_ _0298_ _0299_ _0229_ _0300_ VDD VSS MUX2_X1
X_0858_ mem\[0\]\[3\] mem\[4\]\[3\] _0243_ _0301_ VDD VSS
+ MUX2_X1
X_0859_ mem\[1\]\[3\] mem\[5\]\[3\] _0243_ _0302_ VDD VSS
+ MUX2_X1
X_0860_ _0301_ _0302_ _0284_ _0303_ VDD VSS MUX2_X1
X_0861_ _0242_ _0300_ _0303_ _0240_ _0304_ VDD VSS OAI22_X2
X_0862_ _0237_ _0305_ VDD VSS BUF_X4
X_0863_ mem\[12\]\[3\] mem\[14\]\[3\] _0305_ _0306_ VDD VSS
+ MUX2_X1
X_0864_ mem\[13\]\[3\] mem\[15\]\[3\] _0238_ _0307_ VDD VSS
+ MUX2_X1
X_0865_ _0306_ _0307_ _0284_ _0308_ VDD VSS MUX2_X1
X_0866_ mem\[8\]\[3\] mem\[10\]\[3\] _0253_ _0309_ VDD VSS
+ MUX2_X1
X_0867_ mem\[9\]\[3\] mem\[11\]\[3\] _0305_ _0310_ VDD VSS
+ MUX2_X1
X_0868_ _0309_ _0310_ _0228_ _0311_ VDD VSS MUX2_X1
X_0869_ _0291_ _0308_ _0311_ _0290_ _0312_ VDD VSS OAI22_X1
X_0870_ _0304_ _0312_ _0313_ VDD VSS NOR2_X1
X_0871_ rd_data_reg\[3\] _0313_ _0225_ _0314_ VDD VSS MUX2_X1
X_0872_ _0261_ _0314_ _0135_ VDD VSS AND2_X1
X_0873_ mem\[2\]\[4\] mem\[6\]\[4\] _0278_ _0315_ VDD VSS
+ MUX2_X1
X_0874_ mem\[3\]\[4\] mem\[7\]\[4\] _0278_ _0316_ VDD VSS
+ MUX2_X1
X_0875_ _0315_ _0316_ _0229_ _0317_ VDD VSS MUX2_X1
X_0876_ mem\[0\]\[4\] mem\[4\]\[4\] _0243_ _0318_ VDD VSS
+ MUX2_X1
X_0877_ mem\[1\]\[4\] mem\[5\]\[4\] _0243_ _0319_ VDD VSS
+ MUX2_X1
X_0878_ _0318_ _0319_ _0284_ _0320_ VDD VSS MUX2_X1
X_0879_ _0242_ _0317_ _0320_ _0240_ _0321_ VDD VSS OAI22_X2
X_0880_ mem\[12\]\[4\] mem\[14\]\[4\] _0305_ _0322_ VDD VSS
+ MUX2_X1
X_0881_ mem\[13\]\[4\] mem\[15\]\[4\] _0238_ _0323_ VDD VSS
+ MUX2_X1
X_0882_ _0322_ _0323_ _0284_ _0324_ VDD VSS MUX2_X1
X_0883_ mem\[8\]\[4\] mem\[10\]\[4\] _0253_ _0325_ VDD VSS
+ MUX2_X1
X_0884_ mem\[9\]\[4\] mem\[11\]\[4\] _0305_ _0326_ VDD VSS
+ MUX2_X1
X_0885_ _0325_ _0326_ _0228_ _0327_ VDD VSS MUX2_X1
X_0886_ _0291_ _0324_ _0327_ _0290_ _0328_ VDD VSS OAI22_X1
X_0887_ _0321_ _0328_ _0329_ VDD VSS NOR2_X1
X_0888_ rd_data_reg\[4\] _0329_ _0224_ _0330_ VDD VSS MUX2_X1
X_0889_ _0261_ _0330_ _0136_ VDD VSS AND2_X1
X_0890_ mem\[2\]\[5\] mem\[6\]\[5\] _0278_ _0331_ VDD VSS
+ MUX2_X1
X_0891_ mem\[3\]\[5\] mem\[7\]\[5\] _0278_ _0332_ VDD VSS
+ MUX2_X1
X_0892_ _0331_ _0332_ _0229_ _0333_ VDD VSS MUX2_X1
X_0893_ mem\[0\]\[5\] mem\[4\]\[5\] _0230_ _0334_ VDD VSS
+ MUX2_X1
X_0894_ mem\[1\]\[5\] mem\[5\]\[5\] _0243_ _0335_ VDD VSS
+ MUX2_X1
X_0895_ _0334_ _0335_ _0284_ _0336_ VDD VSS MUX2_X1
X_0896_ _0242_ _0333_ _0336_ _0240_ _0337_ VDD VSS OAI22_X1
X_0897_ mem\[12\]\[5\] mem\[14\]\[5\] _0305_ _0338_ VDD VSS
+ MUX2_X1
X_0898_ mem\[13\]\[5\] mem\[15\]\[5\] _0238_ _0339_ VDD VSS
+ MUX2_X1
X_0899_ _0338_ _0339_ _0284_ _0340_ VDD VSS MUX2_X1
X_0900_ mem\[8\]\[5\] mem\[10\]\[5\] _0253_ _0341_ VDD VSS
+ MUX2_X1
X_0901_ mem\[9\]\[5\] mem\[11\]\[5\] _0305_ _0342_ VDD VSS
+ MUX2_X1
X_0902_ _0341_ _0342_ _0228_ _0343_ VDD VSS MUX2_X1
X_0903_ _0291_ _0340_ _0343_ _0290_ _0344_ VDD VSS OAI22_X1
X_0904_ _0337_ _0344_ _0345_ VDD VSS NOR2_X1
X_0905_ rd_data_reg\[5\] _0345_ _0224_ _0346_ VDD VSS MUX2_X1
X_0906_ _0261_ _0346_ _0137_ VDD VSS AND2_X1
X_0907_ mem\[2\]\[6\] mem\[6\]\[6\] _0278_ _0347_ VDD VSS
+ MUX2_X1
X_0908_ mem\[3\]\[6\] mem\[7\]\[6\] _0278_ _0348_ VDD VSS
+ MUX2_X1
X_0909_ _0347_ _0348_ _0229_ _0349_ VDD VSS MUX2_X1
X_0910_ mem\[0\]\[6\] mem\[4\]\[6\] _0230_ _0350_ VDD VSS
+ MUX2_X1
X_0911_ mem\[1\]\[6\] mem\[5\]\[6\] _0243_ _0351_ VDD VSS
+ MUX2_X1
X_0912_ _0350_ _0351_ _0284_ _0352_ VDD VSS MUX2_X1
X_0913_ _0242_ _0349_ _0352_ _0240_ _0353_ VDD VSS OAI22_X2
X_0914_ mem\[12\]\[6\] mem\[14\]\[6\] _0305_ _0354_ VDD VSS
+ MUX2_X1
X_0915_ mem\[13\]\[6\] mem\[15\]\[6\] _0305_ _0355_ VDD VSS
+ MUX2_X1
X_0916_ _0354_ _0355_ _0228_ _0356_ VDD VSS MUX2_X1
X_0917_ mem\[8\]\[6\] mem\[10\]\[6\] _0253_ _0357_ VDD VSS
+ MUX2_X1
X_0918_ mem\[9\]\[6\] mem\[11\]\[6\] _0253_ _0358_ VDD VSS
+ MUX2_X1
X_0919_ _0357_ _0358_ _0228_ _0359_ VDD VSS MUX2_X1
X_0920_ _0291_ _0356_ _0359_ _0290_ _0360_ VDD VSS OAI22_X1
X_0921_ _0353_ _0360_ _0361_ VDD VSS NOR2_X1
X_0922_ rd_data_reg\[6\] _0361_ _0224_ _0362_ VDD VSS MUX2_X1
X_0923_ _0261_ _0362_ _0138_ VDD VSS AND2_X1
X_0924_ mem\[2\]\[7\] mem\[6\]\[7\] _0278_ _0363_ VDD VSS
+ MUX2_X1
X_0925_ mem\[3\]\[7\] mem\[7\]\[7\] _0278_ _0364_ VDD VSS
+ MUX2_X1
X_0926_ _0363_ _0364_ _0284_ _0365_ VDD VSS MUX2_X1
X_0927_ mem\[0\]\[7\] mem\[4\]\[7\] _0230_ _0366_ VDD VSS
+ MUX2_X1
X_0928_ mem\[1\]\[7\] mem\[5\]\[7\] _0243_ _0367_ VDD VSS
+ MUX2_X1
X_0929_ _0366_ _0367_ _0284_ _0368_ VDD VSS MUX2_X1
X_0930_ _0242_ _0365_ _0368_ _0240_ _0369_ VDD VSS OAI22_X2
X_0931_ mem\[12\]\[7\] mem\[14\]\[7\] _0305_ _0370_ VDD VSS
+ MUX2_X1
X_0932_ mem\[13\]\[7\] mem\[15\]\[7\] _0305_ _0371_ VDD VSS
+ MUX2_X1
X_0933_ _0370_ _0371_ _0228_ _0372_ VDD VSS MUX2_X1
X_0934_ mem\[8\]\[7\] mem\[10\]\[7\] _0253_ _0373_ VDD VSS
+ MUX2_X1
X_0935_ mem\[9\]\[7\] mem\[11\]\[7\] _0253_ _0374_ VDD VSS
+ MUX2_X1
X_0936_ _0373_ _0374_ _0228_ _0375_ VDD VSS MUX2_X1
X_0937_ _0291_ _0372_ _0375_ _0290_ _0376_ VDD VSS OAI22_X1
X_0938_ _0369_ _0376_ _0377_ VDD VSS NOR2_X1
X_0939_ rd_data_reg\[7\] _0377_ _0224_ _0378_ VDD VSS MUX2_X1
X_0940_ _0261_ _0378_ _0139_ VDD VSS AND2_X1
X_0941_ _0229_ _0000_ _0224_ _0379_ VDD VSS MUX2_X1
X_0942_ _0261_ _0379_ _0140_ VDD VSS AND2_X1
X_0943_ _0238_ _0001_ _0224_ _0380_ VDD VSS MUX2_X1
X_0944_ _0261_ _0380_ _0141_ VDD VSS AND2_X1
X_0945_ _0255_ _0559_ _0260_ _0225_ _0381_ VDD VSS NAND4_X1
X_0946_ _0231_ _0260_ _0382_ VDD VSS NAND2_X1
X_0947_ _0559_ _0225_ _0383_ VDD VSS AND2_X1
X_0948_ _0381_ _0382_ _0383_ _0142_ VDD VSS OAI21_X1
X_0949_ _0239_ _0219_ _0384_ VDD VSS NOR2_X1
X_0950_ _0241_ _0219_ _0385_ VDD VSS NOR2_X1
X_0951_ _0229_ _0238_ _0231_ _0225_ _0386_ VDD VSS NAND4_X1
X_0952_ _0384_ _0385_ _0386_ _0143_ VDD VSS MUX2_X1
X_0953_ rd_ptr\[4\] _0219_ _0387_ VDD VSS NOR2_X1
X_0954_ rd_ptr\[4\] _0260_ _0388_ VDD VSS AND2_X1
X_0955_ _0231_ _0239_ _0559_ _0225_ _0389_ VDD VSS NAND4_X1
X_0956_ _0387_ _0388_ _0389_ _0144_ VDD VSS MUX2_X1
X_0957_ _0261_ _0225_ _0145_ VDD VSS AND2_X1
X_0958_ _0002_ _0260_ _0390_ VDD VSS AND2_X1
X_0959_ wr_ptr\[0\] _0260_ _0391_ VDD VSS AND2_X1
X_0960_ _0176_ _0170_ _0392_ VDD VSS NAND2_X1
X_0961_ _0390_ _0391_ _0392_ _0146_ VDD VSS MUX2_X1
X_0962_ _0003_ _0260_ _0393_ VDD VSS AND2_X1
X_0963_ wr_ptr\[1\] _0260_ _0394_ VDD VSS AND2_X1
X_0964_ _0393_ _0394_ _0392_ _0147_ VDD VSS MUX2_X1
X_0965_ _0173_ _0219_ _0395_ VDD VSS NOR2_X1
X_0966_ _0174_ _0219_ _0396_ VDD VSS NOR2_X1
X_0967_ _0176_ _0199_ _0170_ _0397_ VDD VSS NAND3_X1
X_0968_ _0395_ _0396_ _0397_ _0148_ VDD VSS MUX2_X1
X_0969_ wr_ptr\[3\] _0219_ _0398_ VDD VSS NOR2_X1
X_0970_ wr_ptr\[3\] _0260_ _0399_ VDD VSS AND2_X1
X_0971_ _0173_ wr_ptr\[1\] wr_ptr\[0\] _0400_ VDD VSS AND3_X1
X_0972_ _0176_ _0170_ _0400_ _0401_ VDD VSS NAND3_X1
X_0973_ _0398_ _0399_ _0401_ _0149_ VDD VSS MUX2_X1
X_0974_ wr_ptr\[4\] _0260_ _0402_ VDD VSS AND2_X1
X_0975_ wr_ptr\[4\] _0219_ _0403_ VDD VSS NOR2_X1
X_0976_ _0402_ _0403_ _0209_ _0150_ VDD VSS MUX2_X1
X_0977_ net9 net7 net8 _0404_ VDD VSS AOI21_X1
X_0978_ _0155_ _0165_ _0404_ net3 VDD VSS AND3_X2
X_0979_ net8 net9 _0405_ VDD VSS NAND2_X1
X_0980_ _0155_ _0165_ _0405_ net4 VDD VSS OAI21_X2
X_0981_ rd_valid _0406_ VDD VSS CLKBUF_X3
X_0982_ rd_data_reg\[0\] _0406_ net12 VDD VSS AND2_X1
X_0983_ rd_data_reg\[1\] _0406_ net13 VDD VSS AND2_X1
X_0984_ rd_data_reg\[2\] _0406_ net14 VDD VSS AND2_X1
X_0985_ rd_data_reg\[3\] _0406_ net15 VDD VSS AND2_X1
X_0986_ rd_data_reg\[4\] _0406_ net16 VDD VSS AND2_X4
X_0987_ rd_data_reg\[5\] _0406_ net17 VDD VSS AND2_X1
X_0988_ rd_data_reg\[6\] _0406_ net18 VDD VSS AND2_X4
X_0989_ rd_data_reg\[7\] _0406_ net19 VDD VSS AND2_X4
X_0990_ _0548_ wr_ptr\[1\] _0549_ _0550_ net8 VDD VSS FA_X1
X_0991_ _0551_ wr_ptr\[3\] _0552_ _0553_ VDD VSS HA_X1
X_0992_ _0548_ wr_ptr\[1\] _0554_ _0555_ VDD VSS HA_X1
X_0993_ _0556_ wr_ptr\[2\] _0557_ _0558_ VDD VSS HA_X1
X_0994_ rd_ptr\[0\] rd_ptr\[1\] _0559_ _0001_ VDD VSS HA_X1
X_0995_ _0002_ _0560_ _0561_ _0003_ VDD VSS HA_X1
X_0996_ _0002_ wr_ptr\[1\] _0562_ _0563_ VDD VSS HA_X1
X_0997_ wr_ptr\[0\] _0560_ _0564_ _0565_ VDD VSS HA_X1
X_0998_ wr_ptr\[0\] wr_ptr\[1\] _0566_ _0567_ VDD VSS HA_X1
X_0999_ rd_ptr\[0\] _0002_ _0568_ _0569_ VDD VSS HA_X1
X_1000_ net7 net20 VDD VSS BUF_X1
X_1001_ net8 net21 VDD VSS BUF_X1
X_1002_ net9 net22 VDD VSS BUF_X1
X_1003_ net10 net23 VDD VSS BUF_X1
X_1004_ net11 net24 VDD VSS BUF_X1
Xmem\[0\]\[0\]$_DFFE_PP_ _0004_ clknet_4_8_0_clk mem\[0\]\[0\]
+ _0547_ VDD VSS DFF_X1
Xmem\[0\]\[1\]$_DFFE_PP_ _0005_ clknet_4_10_0_clk mem\[0\]\[1\]
+ _0546_ VDD VSS DFF_X1
Xmem\[0\]\[2\]$_DFFE_PP_ _0006_ clknet_4_8_0_clk mem\[0\]\[2\]
+ _0545_ VDD VSS DFF_X1
Xmem\[0\]\[3\]$_DFFE_PP_ _0007_ clknet_4_2_0_clk mem\[0\]\[3\]
+ _0544_ VDD VSS DFF_X1
Xmem\[0\]\[4\]$_DFFE_PP_ _0008_ clknet_4_2_0_clk mem\[0\]\[4\]
+ _0543_ VDD VSS DFF_X1
Xmem\[0\]\[5\]$_DFFE_PP_ _0009_ clknet_4_3_0_clk mem\[0\]\[5\]
+ _0542_ VDD VSS DFF_X1
Xmem\[0\]\[6\]$_DFFE_PP_ _0010_ clknet_4_3_0_clk mem\[0\]\[6\]
+ _0541_ VDD VSS DFF_X1
Xmem\[0\]\[7\]$_DFFE_PP_ _0011_ clknet_4_2_0_clk mem\[0\]\[7\]
+ _0540_ VDD VSS DFF_X1
Xmem\[10\]\[0\]$_DFFE_PP_ _0012_ clknet_4_12_0_clk mem\[10\]\[0\]
+ _0539_ VDD VSS DFF_X1
Xmem\[10\]\[1\]$_DFFE_PP_ _0013_ clknet_4_14_0_clk mem\[10\]\[1\]
+ _0538_ VDD VSS DFF_X1
Xmem\[10\]\[2\]$_DFFE_PP_ _0014_ clknet_4_9_0_clk mem\[10\]\[2\]
+ _0537_ VDD VSS DFF_X1
Xmem\[10\]\[3\]$_DFFE_PP_ _0015_ clknet_4_12_0_clk mem\[10\]\[3\]
+ _0536_ VDD VSS DFF_X1
Xmem\[10\]\[4\]$_DFFE_PP_ _0016_ clknet_4_6_0_clk mem\[10\]\[4\]
+ _0535_ VDD VSS DFF_X1
Xmem\[10\]\[5\]$_DFFE_PP_ _0017_ clknet_4_6_0_clk mem\[10\]\[5\]
+ _0534_ VDD VSS DFF_X1
Xmem\[10\]\[6\]$_DFFE_PP_ _0018_ clknet_4_4_0_clk mem\[10\]\[6\]
+ _0533_ VDD VSS DFF_X1
Xmem\[10\]\[7\]$_DFFE_PP_ _0019_ clknet_4_4_0_clk mem\[10\]\[7\]
+ _0532_ VDD VSS DFF_X1
Xmem\[11\]\[0\]$_DFFE_PP_ _0020_ clknet_4_14_0_clk mem\[11\]\[0\]
+ _0531_ VDD VSS DFF_X1
Xmem\[11\]\[1\]$_DFFE_PP_ _0021_ clknet_4_14_0_clk mem\[11\]\[1\]
+ _0530_ VDD VSS DFF_X1
Xmem\[11\]\[2\]$_DFFE_PP_ _0022_ clknet_4_12_0_clk mem\[11\]\[2\]
+ _0529_ VDD VSS DFF_X1
Xmem\[11\]\[3\]$_DFFE_PP_ _0023_ clknet_4_12_0_clk mem\[11\]\[3\]
+ _0528_ VDD VSS DFF_X1
Xmem\[11\]\[4\]$_DFFE_PP_ _0024_ clknet_4_6_0_clk mem\[11\]\[4\]
+ _0527_ VDD VSS DFF_X1
Xmem\[11\]\[5\]$_DFFE_PP_ _0025_ clknet_4_7_0_clk mem\[11\]\[5\]
+ _0526_ VDD VSS DFF_X1
Xmem\[11\]\[6\]$_DFFE_PP_ _0026_ clknet_4_5_0_clk mem\[11\]\[6\]
+ _0525_ VDD VSS DFF_X1
Xmem\[11\]\[7\]$_DFFE_PP_ _0027_ clknet_4_4_0_clk mem\[11\]\[7\]
+ _0524_ VDD VSS DFF_X1
Xmem\[12\]\[0\]$_DFFE_PP_ _0028_ clknet_4_13_0_clk mem\[12\]\[0\]
+ _0523_ VDD VSS DFF_X1
Xmem\[12\]\[1\]$_DFFE_PP_ _0029_ clknet_4_14_0_clk mem\[12\]\[1\]
+ _0522_ VDD VSS DFF_X1
Xmem\[12\]\[2\]$_DFFE_PP_ _0030_ clknet_4_12_0_clk mem\[12\]\[2\]
+ _0521_ VDD VSS DFF_X1
Xmem\[12\]\[3\]$_DFFE_PP_ _0031_ clknet_4_13_0_clk mem\[12\]\[3\]
+ _0520_ VDD VSS DFF_X1
Xmem\[12\]\[4\]$_DFFE_PP_ _0032_ clknet_4_7_0_clk mem\[12\]\[4\]
+ _0519_ VDD VSS DFF_X1
Xmem\[12\]\[5\]$_DFFE_PP_ _0033_ clknet_4_7_0_clk mem\[12\]\[5\]
+ _0518_ VDD VSS DFF_X1
Xmem\[12\]\[6\]$_DFFE_PP_ _0034_ clknet_4_5_0_clk mem\[12\]\[6\]
+ _0517_ VDD VSS DFF_X1
Xmem\[12\]\[7\]$_DFFE_PP_ _0035_ clknet_4_5_0_clk mem\[12\]\[7\]
+ _0516_ VDD VSS DFF_X1
Xmem\[13\]\[0\]$_DFFE_PP_ _0036_ clknet_4_12_0_clk mem\[13\]\[0\]
+ _0515_ VDD VSS DFF_X1
Xmem\[13\]\[1\]$_DFFE_PP_ _0037_ clknet_4_14_0_clk mem\[13\]\[1\]
+ _0514_ VDD VSS DFF_X1
Xmem\[13\]\[2\]$_DFFE_PP_ _0038_ clknet_4_12_0_clk mem\[13\]\[2\]
+ _0513_ VDD VSS DFF_X1
Xmem\[13\]\[3\]$_DFFE_PP_ _0039_ clknet_4_7_0_clk mem\[13\]\[3\]
+ _0512_ VDD VSS DFF_X1
Xmem\[13\]\[4\]$_DFFE_PP_ _0040_ clknet_4_7_0_clk mem\[13\]\[4\]
+ _0511_ VDD VSS DFF_X1
Xmem\[13\]\[5\]$_DFFE_PP_ _0041_ clknet_4_7_0_clk mem\[13\]\[5\]
+ _0510_ VDD VSS DFF_X1
Xmem\[13\]\[6\]$_DFFE_PP_ _0042_ clknet_4_5_0_clk mem\[13\]\[6\]
+ _0509_ VDD VSS DFF_X1
Xmem\[13\]\[7\]$_DFFE_PP_ _0043_ clknet_4_5_0_clk mem\[13\]\[7\]
+ _0508_ VDD VSS DFF_X1
Xmem\[14\]\[0\]$_DFFE_PP_ _0044_ clknet_4_13_0_clk mem\[14\]\[0\]
+ _0507_ VDD VSS DFF_X1
Xmem\[14\]\[1\]$_DFFE_PP_ _0045_ clknet_4_15_0_clk mem\[14\]\[1\]
+ _0506_ VDD VSS DFF_X1
Xmem\[14\]\[2\]$_DFFE_PP_ _0046_ clknet_4_7_0_clk mem\[14\]\[2\]
+ _0505_ VDD VSS DFF_X1
Xmem\[14\]\[3\]$_DFFE_PP_ _0047_ clknet_4_13_0_clk mem\[14\]\[3\]
+ _0504_ VDD VSS DFF_X1
Xmem\[14\]\[4\]$_DFFE_PP_ _0048_ clknet_4_7_0_clk mem\[14\]\[4\]
+ _0503_ VDD VSS DFF_X1
Xmem\[14\]\[5\]$_DFFE_PP_ _0049_ clknet_4_5_0_clk mem\[14\]\[5\]
+ _0502_ VDD VSS DFF_X1
Xmem\[14\]\[6\]$_DFFE_PP_ _0050_ clknet_4_5_0_clk mem\[14\]\[6\]
+ _0501_ VDD VSS DFF_X1
Xmem\[14\]\[7\]$_DFFE_PP_ _0051_ clknet_4_5_0_clk mem\[14\]\[7\]
+ _0500_ VDD VSS DFF_X1
Xmem\[15\]\[0\]$_DFFE_PP_ _0052_ clknet_4_13_0_clk mem\[15\]\[0\]
+ _0499_ VDD VSS DFF_X1
Xmem\[15\]\[1\]$_DFFE_PP_ _0053_ clknet_4_14_0_clk mem\[15\]\[1\]
+ _0498_ VDD VSS DFF_X1
Xmem\[15\]\[2\]$_DFFE_PP_ _0054_ clknet_4_12_0_clk mem\[15\]\[2\]
+ _0497_ VDD VSS DFF_X1
Xmem\[15\]\[3\]$_DFFE_PP_ _0055_ clknet_4_7_0_clk mem\[15\]\[3\]
+ _0496_ VDD VSS DFF_X1
Xmem\[15\]\[4\]$_DFFE_PP_ _0056_ clknet_4_7_0_clk mem\[15\]\[4\]
+ _0495_ VDD VSS DFF_X1
Xmem\[15\]\[5\]$_DFFE_PP_ _0057_ clknet_4_7_0_clk mem\[15\]\[5\]
+ _0494_ VDD VSS DFF_X1
Xmem\[15\]\[6\]$_DFFE_PP_ _0058_ clknet_4_5_0_clk mem\[15\]\[6\]
+ _0493_ VDD VSS DFF_X1
Xmem\[15\]\[7\]$_DFFE_PP_ _0059_ clknet_4_5_0_clk mem\[15\]\[7\]
+ _0492_ VDD VSS DFF_X1
Xmem\[1\]\[0\]$_DFFE_PP_ _0060_ clknet_4_9_0_clk mem\[1\]\[0\]
+ _0491_ VDD VSS DFF_X1
Xmem\[1\]\[1\]$_DFFE_PP_ _0061_ clknet_4_10_0_clk mem\[1\]\[1\]
+ _0490_ VDD VSS DFF_X1
Xmem\[1\]\[2\]$_DFFE_PP_ _0062_ clknet_4_8_0_clk mem\[1\]\[2\]
+ _0489_ VDD VSS DFF_X1
Xmem\[1\]\[3\]$_DFFE_PP_ _0063_ clknet_4_2_0_clk mem\[1\]\[3\]
+ _0488_ VDD VSS DFF_X1
Xmem\[1\]\[4\]$_DFFE_PP_ _0064_ clknet_4_2_0_clk mem\[1\]\[4\]
+ _0487_ VDD VSS DFF_X1
Xmem\[1\]\[5\]$_DFFE_PP_ _0065_ clknet_4_3_0_clk mem\[1\]\[5\]
+ _0486_ VDD VSS DFF_X1
Xmem\[1\]\[6\]$_DFFE_PP_ _0066_ clknet_4_3_0_clk mem\[1\]\[6\]
+ _0485_ VDD VSS DFF_X1
Xmem\[1\]\[7\]$_DFFE_PP_ _0067_ clknet_4_2_0_clk mem\[1\]\[7\]
+ _0484_ VDD VSS DFF_X1
Xmem\[2\]\[0\]$_DFFE_PP_ _0068_ clknet_4_10_0_clk mem\[2\]\[0\]
+ _0483_ VDD VSS DFF_X1
Xmem\[2\]\[1\]$_DFFE_PP_ _0069_ clknet_4_10_0_clk mem\[2\]\[1\]
+ _0482_ VDD VSS DFF_X1
Xmem\[2\]\[2\]$_DFFE_PP_ _0070_ clknet_4_8_0_clk mem\[2\]\[2\]
+ _0481_ VDD VSS DFF_X1
Xmem\[2\]\[3\]$_DFFE_PP_ _0071_ clknet_4_2_0_clk mem\[2\]\[3\]
+ _0480_ VDD VSS DFF_X1
Xmem\[2\]\[4\]$_DFFE_PP_ _0072_ clknet_4_0_0_clk mem\[2\]\[4\]
+ _0479_ VDD VSS DFF_X1
Xmem\[2\]\[5\]$_DFFE_PP_ _0073_ clknet_4_1_0_clk mem\[2\]\[5\]
+ _0478_ VDD VSS DFF_X1
Xmem\[2\]\[6\]$_DFFE_PP_ _0074_ clknet_4_1_0_clk mem\[2\]\[6\]
+ _0477_ VDD VSS DFF_X1
Xmem\[2\]\[7\]$_DFFE_PP_ _0075_ clknet_4_0_0_clk mem\[2\]\[7\]
+ _0476_ VDD VSS DFF_X1
Xmem\[3\]\[0\]$_DFFE_PP_ _0076_ clknet_4_11_0_clk mem\[3\]\[0\]
+ _0475_ VDD VSS DFF_X1
Xmem\[3\]\[1\]$_DFFE_PP_ _0077_ clknet_4_10_0_clk mem\[3\]\[1\]
+ _0474_ VDD VSS DFF_X1
Xmem\[3\]\[2\]$_DFFE_PP_ _0078_ clknet_4_9_0_clk mem\[3\]\[2\]
+ _0473_ VDD VSS DFF_X1
Xmem\[3\]\[3\]$_DFFE_PP_ _0079_ clknet_4_3_0_clk mem\[3\]\[3\]
+ _0472_ VDD VSS DFF_X1
Xmem\[3\]\[4\]$_DFFE_PP_ _0080_ clknet_4_0_0_clk mem\[3\]\[4\]
+ _0471_ VDD VSS DFF_X1
Xmem\[3\]\[5\]$_DFFE_PP_ _0081_ clknet_4_1_0_clk mem\[3\]\[5\]
+ _0470_ VDD VSS DFF_X1
Xmem\[3\]\[6\]$_DFFE_PP_ _0082_ clknet_4_1_0_clk mem\[3\]\[6\]
+ _0469_ VDD VSS DFF_X1
Xmem\[3\]\[7\]$_DFFE_PP_ _0083_ clknet_4_0_0_clk mem\[3\]\[7\]
+ _0468_ VDD VSS DFF_X1
Xmem\[4\]\[0\]$_DFFE_PP_ _0084_ clknet_4_9_0_clk mem\[4\]\[0\]
+ _0467_ VDD VSS DFF_X1
Xmem\[4\]\[1\]$_DFFE_PP_ _0085_ clknet_4_10_0_clk mem\[4\]\[1\]
+ _0466_ VDD VSS DFF_X1
Xmem\[4\]\[2\]$_DFFE_PP_ _0086_ clknet_4_8_0_clk mem\[4\]\[2\]
+ _0465_ VDD VSS DFF_X1
Xmem\[4\]\[3\]$_DFFE_PP_ _0087_ clknet_4_2_0_clk mem\[4\]\[3\]
+ _0464_ VDD VSS DFF_X1
Xmem\[4\]\[4\]$_DFFE_PP_ _0088_ clknet_4_2_0_clk mem\[4\]\[4\]
+ _0463_ VDD VSS DFF_X1
Xmem\[4\]\[5\]$_DFFE_PP_ _0089_ clknet_4_3_0_clk mem\[4\]\[5\]
+ _0462_ VDD VSS DFF_X1
Xmem\[4\]\[6\]$_DFFE_PP_ _0090_ clknet_4_1_0_clk mem\[4\]\[6\]
+ _0461_ VDD VSS DFF_X1
Xmem\[4\]\[7\]$_DFFE_PP_ _0091_ clknet_4_0_0_clk mem\[4\]\[7\]
+ _0460_ VDD VSS DFF_X1
Xmem\[5\]\[0\]$_DFFE_PP_ _0092_ clknet_4_11_0_clk mem\[5\]\[0\]
+ _0459_ VDD VSS DFF_X1
Xmem\[5\]\[1\]$_DFFE_PP_ _0093_ clknet_4_10_0_clk mem\[5\]\[1\]
+ _0458_ VDD VSS DFF_X1
Xmem\[5\]\[2\]$_DFFE_PP_ _0094_ clknet_4_10_0_clk mem\[5\]\[2\]
+ _0457_ VDD VSS DFF_X1
Xmem\[5\]\[3\]$_DFFE_PP_ _0095_ clknet_4_2_0_clk mem\[5\]\[3\]
+ _0456_ VDD VSS DFF_X1
Xmem\[5\]\[4\]$_DFFE_PP_ _0096_ clknet_4_2_0_clk mem\[5\]\[4\]
+ _0455_ VDD VSS DFF_X1
Xmem\[5\]\[5\]$_DFFE_PP_ _0097_ clknet_4_3_0_clk mem\[5\]\[5\]
+ _0454_ VDD VSS DFF_X1
Xmem\[5\]\[6\]$_DFFE_PP_ _0098_ clknet_4_2_0_clk mem\[5\]\[6\]
+ _0453_ VDD VSS DFF_X1
Xmem\[5\]\[7\]$_DFFE_PP_ _0099_ clknet_4_0_0_clk mem\[5\]\[7\]
+ _0452_ VDD VSS DFF_X1
Xmem\[6\]\[0\]$_DFFE_PP_ _0100_ clknet_4_8_0_clk mem\[6\]\[0\]
+ _0451_ VDD VSS DFF_X1
Xmem\[6\]\[1\]$_DFFE_PP_ _0101_ clknet_4_10_0_clk mem\[6\]\[1\]
+ _0450_ VDD VSS DFF_X1
Xmem\[6\]\[2\]$_DFFE_PP_ _0102_ clknet_4_8_0_clk mem\[6\]\[2\]
+ _0449_ VDD VSS DFF_X1
Xmem\[6\]\[3\]$_DFFE_PP_ _0103_ clknet_4_2_0_clk mem\[6\]\[3\]
+ _0448_ VDD VSS DFF_X1
Xmem\[6\]\[4\]$_DFFE_PP_ _0104_ clknet_4_0_0_clk mem\[6\]\[4\]
+ _0447_ VDD VSS DFF_X1
Xmem\[6\]\[5\]$_DFFE_PP_ _0105_ clknet_4_1_0_clk mem\[6\]\[5\]
+ _0446_ VDD VSS DFF_X1
Xmem\[6\]\[6\]$_DFFE_PP_ _0106_ clknet_4_1_0_clk mem\[6\]\[6\]
+ _0445_ VDD VSS DFF_X1
Xmem\[6\]\[7\]$_DFFE_PP_ _0107_ clknet_4_0_0_clk mem\[6\]\[7\]
+ _0444_ VDD VSS DFF_X1
Xmem\[7\]\[0\]$_DFFE_PP_ _0108_ clknet_4_11_0_clk mem\[7\]\[0\]
+ _0443_ VDD VSS DFF_X1
Xmem\[7\]\[1\]$_DFFE_PP_ _0109_ clknet_4_11_0_clk mem\[7\]\[1\]
+ _0442_ VDD VSS DFF_X1
Xmem\[7\]\[2\]$_DFFE_PP_ _0110_ clknet_4_9_0_clk mem\[7\]\[2\]
+ _0441_ VDD VSS DFF_X1
Xmem\[7\]\[3\]$_DFFE_PP_ _0111_ clknet_4_3_0_clk mem\[7\]\[3\]
+ _0440_ VDD VSS DFF_X1
Xmem\[7\]\[4\]$_DFFE_PP_ _0112_ clknet_4_0_0_clk mem\[7\]\[4\]
+ _0439_ VDD VSS DFF_X1
Xmem\[7\]\[5\]$_DFFE_PP_ _0113_ clknet_4_1_0_clk mem\[7\]\[5\]
+ _0438_ VDD VSS DFF_X1
Xmem\[7\]\[6\]$_DFFE_PP_ _0114_ clknet_4_1_0_clk mem\[7\]\[6\]
+ _0437_ VDD VSS DFF_X1
Xmem\[7\]\[7\]$_DFFE_PP_ _0115_ clknet_4_0_0_clk mem\[7\]\[7\]
+ _0436_ VDD VSS DFF_X1
Xmem\[8\]\[0\]$_DFFE_PP_ _0116_ clknet_4_9_0_clk mem\[8\]\[0\]
+ _0435_ VDD VSS DFF_X1
Xmem\[8\]\[1\]$_DFFE_PP_ _0117_ clknet_4_11_0_clk mem\[8\]\[1\]
+ _0434_ VDD VSS DFF_X1
Xmem\[8\]\[2\]$_DFFE_PP_ _0118_ clknet_4_9_0_clk mem\[8\]\[2\]
+ _0433_ VDD VSS DFF_X1
Xmem\[8\]\[3\]$_DFFE_PP_ _0119_ clknet_4_6_0_clk mem\[8\]\[3\]
+ _0432_ VDD VSS DFF_X1
Xmem\[8\]\[4\]$_DFFE_PP_ _0120_ clknet_4_6_0_clk mem\[8\]\[4\]
+ _0431_ VDD VSS DFF_X1
Xmem\[8\]\[5\]$_DFFE_PP_ _0121_ clknet_4_4_0_clk mem\[8\]\[5\]
+ _0430_ VDD VSS DFF_X1
Xmem\[8\]\[6\]$_DFFE_PP_ _0122_ clknet_4_4_0_clk mem\[8\]\[6\]
+ _0429_ VDD VSS DFF_X1
Xmem\[8\]\[7\]$_DFFE_PP_ _0123_ clknet_4_4_0_clk mem\[8\]\[7\]
+ _0428_ VDD VSS DFF_X1
Xmem\[9\]\[0\]$_DFFE_PP_ _0124_ clknet_4_14_0_clk mem\[9\]\[0\]
+ _0427_ VDD VSS DFF_X1
Xmem\[9\]\[1\]$_DFFE_PP_ _0125_ clknet_4_11_0_clk mem\[9\]\[1\]
+ _0426_ VDD VSS DFF_X1
Xmem\[9\]\[2\]$_DFFE_PP_ _0126_ clknet_4_9_0_clk mem\[9\]\[2\]
+ _0425_ VDD VSS DFF_X1
Xmem\[9\]\[3\]$_DFFE_PP_ _0127_ clknet_4_6_0_clk mem\[9\]\[3\]
+ _0424_ VDD VSS DFF_X1
Xmem\[9\]\[4\]$_DFFE_PP_ _0128_ clknet_4_6_0_clk mem\[9\]\[4\]
+ _0423_ VDD VSS DFF_X1
Xmem\[9\]\[5\]$_DFFE_PP_ _0129_ clknet_4_6_0_clk mem\[9\]\[5\]
+ _0422_ VDD VSS DFF_X1
Xmem\[9\]\[6\]$_DFFE_PP_ _0130_ clknet_4_4_0_clk mem\[9\]\[6\]
+ _0421_ VDD VSS DFF_X1
Xmem\[9\]\[7\]$_DFFE_PP_ _0131_ clknet_4_4_0_clk mem\[9\]\[7\]
+ _0420_ VDD VSS DFF_X1
Xrd_data_reg\[0\]$_SDFFE_PN0P_ _0132_ clknet_4_13_0_clk rd_data_reg\[0\]
+ _0419_ VDD VSS DFF_X1
Xrd_data_reg\[1\]$_SDFFE_PN0P_ _0133_ clknet_4_15_0_clk rd_data_reg\[1\]
+ _0418_ VDD VSS DFF_X1
Xrd_data_reg\[2\]$_SDFFE_PN0P_ _0134_ clknet_4_13_0_clk rd_data_reg\[2\]
+ _0417_ VDD VSS DFF_X1
Xrd_data_reg\[3\]$_SDFFE_PN0P_ _0135_ clknet_4_13_0_clk rd_data_reg\[3\]
+ _0416_ VDD VSS DFF_X1
Xrd_data_reg\[4\]$_SDFFE_PN0P_ _0136_ clknet_4_5_0_clk rd_data_reg\[4\]
+ _0415_ VDD VSS DFF_X1
Xrd_data_reg\[5\]$_SDFFE_PN0P_ _0137_ clknet_4_7_0_clk rd_data_reg\[5\]
+ _0414_ VDD VSS DFF_X1
Xrd_data_reg\[6\]$_SDFFE_PN0P_ _0138_ clknet_4_4_0_clk rd_data_reg\[6\]
+ _0413_ VDD VSS DFF_X1
Xrd_data_reg\[7\]$_SDFFE_PN0P_ _0139_ clknet_4_4_0_clk rd_data_reg\[7\]
+ _0412_ VDD VSS DFF_X1
Xrd_ptr\[0\]$_SDFFE_PN0P_ _0140_ clknet_4_15_0_clk rd_ptr\[0\]
+ _0000_ VDD VSS DFF_X2
Xrd_ptr\[1\]$_SDFFE_PN0P_ _0141_ clknet_4_15_0_clk rd_ptr\[1\]
+ _0548_ VDD VSS DFF_X1
Xrd_ptr\[2\]$_SDFFE_PN0P_ _0142_ clknet_4_15_0_clk rd_ptr\[2\]
+ _0556_ VDD VSS DFF_X2
Xrd_ptr\[3\]$_SDFFE_PN0P_ _0143_ clknet_4_15_0_clk rd_ptr\[3\]
+ _0551_ VDD VSS DFF_X1
Xrd_ptr\[4\]$_SDFFE_PN0P_ _0144_ clknet_4_15_0_clk rd_ptr\[4\]
+ _0411_ VDD VSS DFF_X1
Xrd_valid$_SDFF_PN0_ _0145_ clknet_4_13_0_clk rd_valid _0410_
+ VDD VSS DFF_X1
Xwr_ptr\[0\]$_SDFFE_PN0P_ _0146_ clknet_4_15_0_clk wr_ptr\[0\]
+ _0002_ VDD VSS DFF_X2
Xwr_ptr\[1\]$_SDFFE_PN0P_ _0147_ clknet_4_14_0_clk wr_ptr\[1\]
+ _0560_ VDD VSS DFF_X2
Xwr_ptr\[2\]$_SDFFE_PN0P_ _0148_ clknet_4_14_0_clk wr_ptr\[2\]
+ _0409_ VDD VSS DFF_X2
Xwr_ptr\[3\]$_SDFFE_PN0P_ _0149_ clknet_4_14_0_clk wr_ptr\[3\]
+ _0408_ VDD VSS DFF_X2
Xwr_ptr\[4\]$_SDFFE_PN0P_ _0150_ clknet_4_15_0_clk wr_ptr\[4\]
+ _0407_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Right_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Right_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Right_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Right_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Right_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Right_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Right_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Right_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Right_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Right_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Right_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Right_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Right_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Right_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Right_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Right_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Right_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Right_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Right_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Right_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Right_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Right_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Right_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Right_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Right_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Right_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Right_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Right_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Right_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Right_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Right_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Right_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Right_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Right_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Right_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Right_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Right_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Right_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Right_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Right_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Right_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Right_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Right_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Right_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Right_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Right_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Right_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Right_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Right_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Right_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Right_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Right_103 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Right_104 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Right_105 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Right_106 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Right_107 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Right_108 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Right_109 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Right_110 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Right_111 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Right_112 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Right_113 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Right_114 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Right_115 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Right_116 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Right_117 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Right_118 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Right_119 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Right_120 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Right_121 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Right_122 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Right_123 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Right_124 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Right_125 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Right_126 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Right_127 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Right_128 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Right_129 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Right_130 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Right_131 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Right_132 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Right_133 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Right_134 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Right_135 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Right_136 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Right_137 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Right_138 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Right_139 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Right_140 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Right_141 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Right_142 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Right_143 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Right_144 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Right_145 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Right_146 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Right_147 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Right_148 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Right_149 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Right_150 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Right_151 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Right_152 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Right_153 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Right_154 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Right_155 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Right_156 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Right_157 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Right_158 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Right_159 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Right_160 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Right_161 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Right_162 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Right_163 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_164_Right_164 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_165_Right_165 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_166_Right_166 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_167_Right_167 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_168_Right_168 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_169_Right_169 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_170_Right_170 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_171_Right_171 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_172_Right_172 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_173_Right_173 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_174_Right_174 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_175_Right_175 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_176_Right_176 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_177_Right_177 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_178_Right_178 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_179_Right_179 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_180_Right_180 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_181_Right_181 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_182_Right_182 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_183_Right_183 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_184_Right_184 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_185_Right_185 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_186_Right_186 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_187_Right_187 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_188_Right_188 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_189_Right_189 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_190_Right_190 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_191_Right_191 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_192_Right_192 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_193_Right_193 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_194_Right_194 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_195_Right_195 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_196_Right_196 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_197_Right_197 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_198_Right_198 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_199_Right_199 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_200_Right_200 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_201_Right_201 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_202_Right_202 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_203_Right_203 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_204_Right_204 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_205_Right_205 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_206_Right_206 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_207_Right_207 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_208_Right_208 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_209_Right_209 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_210_Right_210 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_211_Right_211 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_212_Right_212 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_213_Right_213 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_214_Right_214 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_215_Right_215 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_216_Right_216 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_217_Right_217 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_218_Right_218 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_219_Right_219 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_220_Right_220 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_221_Right_221 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_222_Right_222 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_223_Right_223 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_224_Right_224 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_225_Right_225 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_226_Right_226 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_227_Right_227 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_228_Right_228 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_229_Right_229 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_230_Right_230 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_231_Right_231 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_232_Right_232 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_233_Right_233 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_234_Right_234 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_235_Right_235 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_236_Right_236 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_237_Right_237 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_238_Right_238 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_239_Right_239 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_240_Right_240 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_241_Right_241 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_242_Right_242 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_243_Right_243 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_244_Right_244 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_245_Right_245 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_246_Right_246 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_247_Right_247 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_248_Right_248 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_249_Right_249 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_250_Right_250 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_251_Right_251 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_252_Right_252 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_253_Right_253 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_254_Right_254 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_255_Right_255 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_256_Right_256 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_257_Right_257 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_258_Right_258 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_259_Right_259 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_260_Right_260 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_261_Right_261 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_262_Right_262 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_263_Right_263 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_264_Right_264 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_265_Right_265 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_266_Right_266 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_267_Right_267 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_268_Right_268 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_269_Right_269 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_270_Right_270 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_271_Right_271 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_272_Right_272 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_273_Right_273 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_274_Right_274 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_275_Right_275 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_276_Right_276 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_277_Right_277 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_278_Right_278 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_279_Right_279 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_280_Right_280 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_281_Right_281 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_282_Right_282 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_283_Right_283 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_284_Right_284 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_285_Right_285 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_286_Right_286 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_287_Right_287 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_288_Right_288 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_289_Right_289 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_290_Right_290 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_291_Right_291 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_292_Right_292 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_293_Right_293 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_294_Right_294 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_295_Right_295 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_296_Right_296 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_297_Right_297 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_298_Right_298 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_299_Right_299 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_300_Right_300 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_301_Right_301 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_302_Right_302 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_303_Right_303 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_304_Right_304 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_305_Right_305 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_306_Right_306 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_307_Right_307 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_308_Right_308 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_309_Right_309 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_310_Right_310 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_311_Right_311 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_312_Right_312 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_313_Right_313 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_314_Right_314 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_315_Right_315 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_316_Right_316 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_317_Right_317 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_318_Right_318 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_319_Right_319 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_320_Right_320 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_321_Right_321 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_322_Right_322 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_323_Right_323 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_324_Right_324 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_325_Right_325 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_326_Right_326 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_327_Right_327 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_328_Right_328 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_329_Right_329 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_330_Right_330 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_331_Right_331 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_332_Right_332 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_333_Right_333 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_334_Right_334 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_335_Right_335 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_336_Right_336 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_337_Right_337 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_338_Right_338 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_339_Right_339 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_340_Right_340 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_341_Right_341 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_342_Right_342 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_343_Right_343 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_344_Right_344 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_345_Right_345 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_346_Right_346 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_347_Right_347 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_348_Right_348 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_349_Right_349 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_350_Right_350 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_351_Right_351 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_352_Right_352 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_353_Right_353 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_354_Right_354 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_355_Right_355 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_356_Right_356 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_357_Right_357 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_358 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_359 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_360 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_361 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_362 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_363 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_364 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_365 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_366 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_367 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_368 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_369 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_370 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_371 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_372 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_373 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_374 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_375 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_376 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_377 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_378 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_379 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_380 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_381 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_382 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_383 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_384 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_385 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_386 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_387 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_388 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_389 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_390 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_391 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_392 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_393 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_394 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_395 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_396 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_397 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_398 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_399 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_400 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_401 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_402 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_403 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_404 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_405 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_406 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_407 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_408 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_409 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Left_410 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Left_411 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Left_412 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Left_413 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Left_414 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Left_415 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Left_416 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Left_417 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Left_418 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Left_419 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Left_420 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Left_421 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Left_422 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Left_423 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Left_424 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Left_425 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Left_426 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Left_427 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Left_428 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Left_429 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Left_430 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Left_431 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Left_432 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Left_433 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Left_434 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Left_435 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Left_436 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Left_437 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Left_438 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Left_439 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Left_440 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Left_441 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Left_442 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Left_443 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Left_444 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Left_445 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Left_446 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Left_447 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Left_448 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Left_449 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Left_450 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Left_451 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Left_452 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Left_453 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Left_454 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Left_455 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Left_456 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Left_457 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Left_458 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Left_459 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Left_460 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Left_461 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Left_462 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Left_463 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Left_464 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Left_465 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Left_466 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Left_467 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Left_468 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Left_469 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Left_470 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Left_471 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Left_472 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Left_473 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Left_474 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Left_475 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Left_476 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Left_477 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Left_478 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Left_479 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Left_480 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Left_481 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Left_482 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Left_483 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Left_484 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Left_485 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Left_486 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Left_487 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Left_488 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Left_489 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Left_490 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Left_491 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Left_492 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Left_493 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Left_494 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Left_495 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Left_496 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Left_497 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Left_498 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Left_499 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Left_500 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Left_501 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Left_502 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Left_503 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Left_504 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Left_505 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Left_506 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Left_507 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Left_508 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Left_509 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Left_510 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Left_511 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Left_512 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Left_513 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Left_514 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Left_515 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Left_516 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Left_517 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Left_518 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Left_519 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Left_520 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Left_521 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_164_Left_522 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_165_Left_523 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_166_Left_524 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_167_Left_525 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_168_Left_526 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_169_Left_527 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_170_Left_528 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_171_Left_529 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_172_Left_530 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_173_Left_531 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_174_Left_532 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_175_Left_533 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_176_Left_534 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_177_Left_535 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_178_Left_536 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_179_Left_537 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_180_Left_538 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_181_Left_539 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_182_Left_540 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_183_Left_541 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_184_Left_542 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_185_Left_543 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_186_Left_544 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_187_Left_545 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_188_Left_546 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_189_Left_547 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_190_Left_548 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_191_Left_549 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_192_Left_550 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_193_Left_551 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_194_Left_552 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_195_Left_553 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_196_Left_554 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_197_Left_555 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_198_Left_556 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_199_Left_557 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_200_Left_558 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_201_Left_559 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_202_Left_560 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_203_Left_561 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_204_Left_562 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_205_Left_563 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_206_Left_564 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_207_Left_565 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_208_Left_566 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_209_Left_567 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_210_Left_568 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_211_Left_569 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_212_Left_570 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_213_Left_571 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_214_Left_572 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_215_Left_573 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_216_Left_574 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_217_Left_575 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_218_Left_576 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_219_Left_577 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_220_Left_578 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_221_Left_579 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_222_Left_580 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_223_Left_581 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_224_Left_582 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_225_Left_583 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_226_Left_584 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_227_Left_585 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_228_Left_586 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_229_Left_587 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_230_Left_588 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_231_Left_589 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_232_Left_590 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_233_Left_591 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_234_Left_592 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_235_Left_593 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_236_Left_594 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_237_Left_595 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_238_Left_596 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_239_Left_597 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_240_Left_598 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_241_Left_599 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_242_Left_600 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_243_Left_601 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_244_Left_602 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_245_Left_603 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_246_Left_604 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_247_Left_605 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_248_Left_606 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_249_Left_607 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_250_Left_608 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_251_Left_609 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_252_Left_610 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_253_Left_611 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_254_Left_612 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_255_Left_613 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_256_Left_614 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_257_Left_615 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_258_Left_616 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_259_Left_617 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_260_Left_618 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_261_Left_619 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_262_Left_620 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_263_Left_621 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_264_Left_622 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_265_Left_623 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_266_Left_624 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_267_Left_625 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_268_Left_626 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_269_Left_627 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_270_Left_628 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_271_Left_629 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_272_Left_630 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_273_Left_631 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_274_Left_632 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_275_Left_633 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_276_Left_634 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_277_Left_635 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_278_Left_636 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_279_Left_637 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_280_Left_638 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_281_Left_639 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_282_Left_640 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_283_Left_641 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_284_Left_642 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_285_Left_643 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_286_Left_644 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_287_Left_645 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_288_Left_646 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_289_Left_647 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_290_Left_648 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_291_Left_649 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_292_Left_650 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_293_Left_651 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_294_Left_652 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_295_Left_653 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_296_Left_654 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_297_Left_655 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_298_Left_656 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_299_Left_657 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_300_Left_658 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_301_Left_659 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_302_Left_660 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_303_Left_661 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_304_Left_662 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_305_Left_663 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_306_Left_664 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_307_Left_665 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_308_Left_666 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_309_Left_667 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_310_Left_668 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_311_Left_669 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_312_Left_670 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_313_Left_671 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_314_Left_672 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_315_Left_673 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_316_Left_674 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_317_Left_675 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_318_Left_676 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_319_Left_677 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_320_Left_678 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_321_Left_679 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_322_Left_680 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_323_Left_681 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_324_Left_682 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_325_Left_683 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_326_Left_684 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_327_Left_685 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_328_Left_686 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_329_Left_687 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_330_Left_688 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_331_Left_689 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_332_Left_690 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_333_Left_691 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_334_Left_692 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_335_Left_693 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_336_Left_694 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_337_Left_695 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_338_Left_696 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_339_Left_697 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_340_Left_698 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_341_Left_699 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_342_Left_700 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_343_Left_701 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_344_Left_702 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_345_Left_703 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_346_Left_704 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_347_Left_705 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_348_Left_706 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_349_Left_707 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_350_Left_708 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_351_Left_709 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_352_Left_710 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_353_Left_711 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_354_Left_712 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_355_Left_713 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_356_Left_714 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_357_Left_715 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_716 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_717 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_718 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_719 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_1_720 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_1_721 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_2_722 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_2_723 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_3_724 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_3_725 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_4_726 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_4_727 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_5_728 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_5_729 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_6_730 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_6_731 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_7_732 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_7_733 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_8_734 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_8_735 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_9_736 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_9_737 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_10_738 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_10_739 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_11_740 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_11_741 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_12_742 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_12_743 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_13_744 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_13_745 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_14_746 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_14_747 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_15_748 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_15_749 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_16_750 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_16_751 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_17_752 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_17_753 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_18_754 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_18_755 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_19_756 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_19_757 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_20_758 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_20_759 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_21_760 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_21_761 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_22_762 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_22_763 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_23_764 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_23_765 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_24_766 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_24_767 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_25_768 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_25_769 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_26_770 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_26_771 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_27_772 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_27_773 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_28_774 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_28_775 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_29_776 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_29_777 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_30_778 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_30_779 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_31_780 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_31_781 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_32_782 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_32_783 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_33_784 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_33_785 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_34_786 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_34_787 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_35_788 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_35_789 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_36_790 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_36_791 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_37_792 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_37_793 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_38_794 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_38_795 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_39_796 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_39_797 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_40_798 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_40_799 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_41_800 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_41_801 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_42_802 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_42_803 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_43_804 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_43_805 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_44_806 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_44_807 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_45_808 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_45_809 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_46_810 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_46_811 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_47_812 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_47_813 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_48_814 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_48_815 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_49_816 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_49_817 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_50_818 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_50_819 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_51_820 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_51_821 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_52_822 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_52_823 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_53_824 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_53_825 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_54_826 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_54_827 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_55_828 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_55_829 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_56_830 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_56_831 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_57_832 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_57_833 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_58_834 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_58_835 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_59_836 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_59_837 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_60_838 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_60_839 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_61_840 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_61_841 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_62_842 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_62_843 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_63_844 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_63_845 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_64_846 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_64_847 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_65_848 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_65_849 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_66_850 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_66_851 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_67_852 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_67_853 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_68_854 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_68_855 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_69_856 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_69_857 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_70_858 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_70_859 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_71_860 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_71_861 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_72_862 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_72_863 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_73_864 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_73_865 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_74_866 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_74_867 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_75_868 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_75_869 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_76_870 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_76_871 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_77_872 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_77_873 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_78_874 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_78_875 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_79_876 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_79_877 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_80_878 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_80_879 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_81_880 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_81_881 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_82_882 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_82_883 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_83_884 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_83_885 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_84_886 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_84_887 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_85_888 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_85_889 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_86_890 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_86_891 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_87_892 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_87_893 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_88_894 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_88_895 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_89_896 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_89_897 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_90_898 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_90_899 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_91_900 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_91_901 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_92_902 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_92_903 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_93_904 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_93_905 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_94_906 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_94_907 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_95_908 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_95_909 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_96_910 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_96_911 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_97_912 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_97_913 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_98_914 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_98_915 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_99_916 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_99_917 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_100_918 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_100_919 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_101_920 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_101_921 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_102_922 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_102_923 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_103_924 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_103_925 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_104_926 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_104_927 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_105_928 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_105_929 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_106_930 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_106_931 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_107_932 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_107_933 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_108_934 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_108_935 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_109_936 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_109_937 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_110_938 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_110_939 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_111_940 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_111_941 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_112_942 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_112_943 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_113_944 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_113_945 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_114_946 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_114_947 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_115_948 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_115_949 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_116_950 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_116_951 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_117_952 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_117_953 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_118_954 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_118_955 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_119_956 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_119_957 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_120_958 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_120_959 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_121_960 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_121_961 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_122_962 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_122_963 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_123_964 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_123_965 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_124_966 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_124_967 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_125_968 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_125_969 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_126_970 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_126_971 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_127_972 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_127_973 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_128_974 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_128_975 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_129_976 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_129_977 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_130_978 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_130_979 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_131_980 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_131_981 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_132_982 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_132_983 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_133_984 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_133_985 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_134_986 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_134_987 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_135_988 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_135_989 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_136_990 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_136_991 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_137_992 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_137_993 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_138_994 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_138_995 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_139_996 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_139_997 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_140_998 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_140_999 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_141_1000 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_141_1001 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_142_1002 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_142_1003 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_143_1004 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_143_1005 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_144_1006 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_144_1007 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_145_1008 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_145_1009 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_146_1010 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_146_1011 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_147_1012 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_147_1013 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_148_1014 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_148_1015 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_149_1016 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_149_1017 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_150_1018 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_150_1019 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_151_1020 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_151_1021 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_152_1022 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_152_1023 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_153_1024 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_153_1025 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_154_1026 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_154_1027 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_155_1028 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_155_1029 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_156_1030 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_156_1031 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_157_1032 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_157_1033 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_158_1034 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_158_1035 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_159_1036 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_159_1037 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_160_1038 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_160_1039 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_161_1040 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_161_1041 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_162_1042 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_162_1043 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_163_1044 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_163_1045 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_164_1046 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_164_1047 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_165_1048 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_165_1049 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_166_1050 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_166_1051 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_167_1052 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_167_1053 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_168_1054 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_168_1055 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_169_1056 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_169_1057 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_170_1058 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_170_1059 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_171_1060 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_171_1061 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_172_1062 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_172_1063 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_173_1064 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_173_1065 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_174_1066 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_174_1067 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_175_1068 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_175_1069 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_176_1070 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_176_1071 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_177_1072 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_177_1073 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_178_1074 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_178_1075 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_179_1076 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_179_1077 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_180_1078 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_180_1079 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_181_1080 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_181_1081 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_182_1082 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_182_1083 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_183_1084 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_183_1085 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_184_1086 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_184_1087 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_185_1088 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_185_1089 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_186_1090 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_186_1091 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_187_1092 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_187_1093 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_188_1094 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_188_1095 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_189_1096 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_189_1097 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_190_1098 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_190_1099 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_191_1100 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_191_1101 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_192_1102 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_192_1103 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_193_1104 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_193_1105 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_194_1106 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_194_1107 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_195_1108 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_195_1109 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_196_1110 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_196_1111 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_197_1112 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_197_1113 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_198_1114 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_198_1115 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_199_1116 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_199_1117 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_200_1118 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_200_1119 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_201_1120 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_201_1121 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_202_1122 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_202_1123 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_203_1124 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_203_1125 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_204_1126 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_204_1127 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_205_1128 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_205_1129 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_206_1130 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_206_1131 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_207_1132 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_207_1133 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_208_1134 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_208_1135 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_209_1136 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_209_1137 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_210_1138 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_210_1139 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_211_1140 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_211_1141 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_212_1142 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_212_1143 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_213_1144 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_213_1145 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_214_1146 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_214_1147 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_215_1148 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_215_1149 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_216_1150 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_216_1151 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_217_1152 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_217_1153 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_218_1154 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_218_1155 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_219_1156 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_219_1157 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_220_1158 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_220_1159 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_221_1160 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_221_1161 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_222_1162 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_222_1163 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_223_1164 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_223_1165 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_224_1166 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_224_1167 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_225_1168 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_225_1169 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_226_1170 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_226_1171 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_227_1172 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_227_1173 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_228_1174 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_228_1175 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_229_1176 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_229_1177 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_230_1178 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_230_1179 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_231_1180 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_231_1181 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_232_1182 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_232_1183 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_233_1184 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_233_1185 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_234_1186 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_234_1187 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_235_1188 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_235_1189 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_236_1190 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_236_1191 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_237_1192 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_237_1193 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_238_1194 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_238_1195 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_239_1196 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_239_1197 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_240_1198 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_240_1199 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_241_1200 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_241_1201 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_242_1202 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_242_1203 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_243_1204 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_243_1205 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_244_1206 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_244_1207 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_245_1208 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_245_1209 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_246_1210 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_246_1211 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_247_1212 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_247_1213 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_248_1214 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_248_1215 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_249_1216 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_249_1217 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_250_1218 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_250_1219 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_251_1220 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_251_1221 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_252_1222 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_252_1223 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_253_1224 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_253_1225 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_254_1226 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_254_1227 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_255_1228 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_255_1229 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_256_1230 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_256_1231 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_257_1232 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_257_1233 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_258_1234 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_258_1235 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_259_1236 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_259_1237 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_260_1238 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_260_1239 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_261_1240 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_261_1241 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_262_1242 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_262_1243 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_263_1244 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_263_1245 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_264_1246 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_264_1247 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_265_1248 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_265_1249 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_266_1250 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_266_1251 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_267_1252 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_267_1253 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_268_1254 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_268_1255 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_269_1256 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_269_1257 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_270_1258 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_270_1259 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_271_1260 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_271_1261 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_272_1262 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_272_1263 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_273_1264 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_273_1265 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_274_1266 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_274_1267 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_275_1268 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_275_1269 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_276_1270 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_276_1271 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_277_1272 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_277_1273 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_278_1274 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_278_1275 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_279_1276 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_279_1277 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_280_1278 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_280_1279 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_281_1280 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_281_1281 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_282_1282 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_282_1283 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_283_1284 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_283_1285 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_284_1286 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_284_1287 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_285_1288 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_285_1289 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_286_1290 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_286_1291 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_287_1292 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_287_1293 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_288_1294 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_288_1295 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_289_1296 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_289_1297 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_290_1298 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_290_1299 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_291_1300 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_291_1301 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_292_1302 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_292_1303 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_293_1304 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_293_1305 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_294_1306 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_294_1307 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_295_1308 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_295_1309 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_296_1310 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_296_1311 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_297_1312 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_297_1313 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_298_1314 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_298_1315 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_299_1316 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_299_1317 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_300_1318 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_300_1319 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_301_1320 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_301_1321 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_302_1322 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_302_1323 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_303_1324 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_303_1325 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_304_1326 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_304_1327 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_305_1328 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_305_1329 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_306_1330 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_306_1331 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_307_1332 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_307_1333 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_308_1334 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_308_1335 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_309_1336 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_309_1337 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_310_1338 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_310_1339 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_311_1340 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_311_1341 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_312_1342 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_312_1343 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_313_1344 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_313_1345 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_314_1346 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_314_1347 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_315_1348 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_315_1349 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_316_1350 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_316_1351 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_317_1352 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_317_1353 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_318_1354 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_318_1355 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_319_1356 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_319_1357 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_320_1358 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_320_1359 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_321_1360 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_321_1361 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_322_1362 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_322_1363 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_323_1364 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_323_1365 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_324_1366 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_324_1367 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_325_1368 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_325_1369 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_326_1370 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_326_1371 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_327_1372 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_327_1373 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_328_1374 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_328_1375 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_329_1376 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_329_1377 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_330_1378 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_330_1379 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_331_1380 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_331_1381 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_332_1382 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_332_1383 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_333_1384 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_333_1385 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_334_1386 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_334_1387 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_335_1388 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_335_1389 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_336_1390 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_336_1391 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_337_1392 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_337_1393 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_338_1394 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_338_1395 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_339_1396 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_339_1397 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_340_1398 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_340_1399 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_341_1400 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_341_1401 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_342_1402 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_342_1403 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_343_1404 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_343_1405 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_344_1406 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_344_1407 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_345_1408 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_345_1409 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_346_1410 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_346_1411 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_347_1412 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_347_1413 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_348_1414 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_348_1415 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_349_1416 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_349_1417 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_350_1418 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_350_1419 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_351_1420 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_351_1421 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_352_1422 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_352_1423 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_353_1424 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_353_1425 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_354_1426 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_354_1427 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_355_1428 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_355_1429 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_356_1430 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_356_1431 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_357_1432 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_357_1433 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_357_1434 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_357_1435 VDD VSS TAPCELL_X1
Xinput1 rd_en net1 VDD VSS BUF_X2
Xinput2 rst_n net2 VDD VSS BUF_X4
Xoutput3 net3 almost_empty VDD VSS BUF_X1
Xoutput4 net4 almost_full VDD VSS BUF_X1
Xoutput5 net5 empty VDD VSS BUF_X1
Xoutput6 net6 full VDD VSS BUF_X1
Xoutput7 net7 rd_count[0] VDD VSS BUF_X1
Xoutput8 net8 rd_count[1] VDD VSS BUF_X1
Xoutput9 net9 rd_count[2] VDD VSS BUF_X1
Xoutput10 net10 rd_count[3] VDD VSS BUF_X1
Xoutput11 net11 rd_count[4] VDD VSS BUF_X1
Xoutput12 net12 rd_data[0] VDD VSS BUF_X1
Xoutput13 net13 rd_data[1] VDD VSS BUF_X1
Xoutput14 net14 rd_data[2] VDD VSS BUF_X1
Xoutput15 net15 rd_data[3] VDD VSS BUF_X1
Xoutput16 net16 rd_data[4] VDD VSS BUF_X1
Xoutput17 net17 rd_data[5] VDD VSS BUF_X1
Xoutput18 net18 rd_data[6] VDD VSS BUF_X1
Xoutput19 net19 rd_data[7] VDD VSS BUF_X1
Xoutput20 net20 wr_count[0] VDD VSS BUF_X1
Xoutput21 net21 wr_count[1] VDD VSS BUF_X1
Xoutput22 net22 wr_count[2] VDD VSS BUF_X1
Xoutput23 net23 wr_count[3] VDD VSS BUF_X1
Xoutput24 net24 wr_count[4] VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_0_0_clk clknet_0_clk clknet_4_0_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_1_0_clk clknet_0_clk clknet_4_1_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_2_0_clk clknet_0_clk clknet_4_2_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_3_0_clk clknet_0_clk clknet_4_3_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_4_0_clk clknet_0_clk clknet_4_4_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_5_0_clk clknet_0_clk clknet_4_5_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_6_0_clk clknet_0_clk clknet_4_6_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_7_0_clk clknet_0_clk clknet_4_7_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_8_0_clk clknet_0_clk clknet_4_8_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_9_0_clk clknet_0_clk clknet_4_9_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_10_0_clk clknet_0_clk clknet_4_10_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_11_0_clk clknet_0_clk clknet_4_11_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_12_0_clk clknet_0_clk clknet_4_12_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_13_0_clk clknet_0_clk clknet_4_13_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_14_0_clk clknet_0_clk clknet_4_14_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_15_0_clk clknet_0_clk clknet_4_15_0_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_4_0_0_clk _unconnected_0 VDD VSS INV_X2
Xclkload1 clknet_4_1_0_clk _unconnected_1 VDD VSS INV_X2
Xclkload2 clknet_4_3_0_clk _unconnected_2 VDD VSS INV_X2
Xclkload3 clknet_4_4_0_clk _unconnected_3 VDD VSS INV_X2
Xclkload4 clknet_4_5_0_clk _unconnected_4 VDD VSS INV_X1
Xclkload5 clknet_4_6_0_clk _unconnected_5 VDD VSS INV_X2
Xclkload6 clknet_4_7_0_clk _unconnected_6 VDD VSS CLKBUF_X1
Xclkload7 clknet_4_8_0_clk _unconnected_7 VDD VSS INV_X4
Xclkload8 clknet_4_9_0_clk _unconnected_8 VDD VSS INV_X2
Xclkload9 clknet_4_10_0_clk _unconnected_9 VDD VSS INV_X2
Xclkload10 clknet_4_11_0_clk _unconnected_10 VDD VSS INV_X4
Xclkload11 clknet_4_12_0_clk _unconnected_11 VDD VSS INV_X2
Xclkload12 clknet_4_13_0_clk _unconnected_12 VDD VSS INV_X2
Xclkload13 clknet_4_14_0_clk _unconnected_13 VDD VSS INV_X2
Xclkload14 clknet_4_15_0_clk _unconnected_14 VDD VSS INV_X2
.ENDS sync_fifo
