* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT bist_controller bist_done bist_pass bist_start clk
+ error_addr[0] error_addr[1] error_addr[2] error_addr[3] error_addr[4]
+ error_count[0] error_count[10] error_count[11] error_count[12]
+ error_count[13] error_count[14] error_count[15] error_count[16]
+ error_count[17] error_count[18] error_count[19] error_count[1]
+ error_count[20] error_count[21] error_count[22] error_count[23]
+ error_count[24] error_count[25] error_count[26] error_count[27]
+ error_count[28] error_count[29] error_count[2] error_count[30]
+ error_count[31] error_count[3] error_count[4] error_count[5]
+ error_count[6] error_count[7] error_count[8] error_count[9]
+ mem_addr[0] mem_addr[1] mem_addr[2] mem_addr[3] mem_addr[4]
+ mem_enable mem_rdata[0] mem_rdata[10] mem_rdata[11] mem_rdata[12]
+ mem_rdata[13] mem_rdata[14] mem_rdata[15] mem_rdata[16] mem_rdata[17]
+ mem_rdata[18] mem_rdata[19] mem_rdata[1] mem_rdata[20] mem_rdata[21]
+ mem_rdata[22] mem_rdata[23] mem_rdata[24] mem_rdata[25] mem_rdata[26]
+ mem_rdata[27] mem_rdata[28] mem_rdata[29] mem_rdata[2] mem_rdata[30]
+ mem_rdata[31] mem_rdata[3] mem_rdata[4] mem_rdata[5] mem_rdata[6]
+ mem_rdata[7] mem_rdata[8] mem_rdata[9] mem_wdata[0] mem_wdata[10]
+ mem_wdata[11] mem_wdata[12] mem_wdata[13] mem_wdata[14] mem_wdata[15]
+ mem_wdata[16] mem_wdata[17] mem_wdata[18] mem_wdata[19] mem_wdata[1]
+ mem_wdata[20] mem_wdata[21] mem_wdata[22] mem_wdata[23] mem_wdata[24]
+ mem_wdata[25] mem_wdata[26] mem_wdata[27] mem_wdata[28] mem_wdata[29]
+ mem_wdata[2] mem_wdata[30] mem_wdata[31] mem_wdata[3] mem_wdata[4]
+ mem_wdata[5] mem_wdata[6] mem_wdata[7] mem_wdata[8] mem_wdata[9]
+ mem_write rst_n
X_0538_ net74 _0054_ VDD VSS BUF_X2
X_0539_ net75 _0054_ _0529_ _0532_ VDD VSS NAND3_X2
X_0540_ _0532_ _0535_ VDD VSS INV_X1
X_0541_ rst_n _0055_ VDD VSS BUF_X4
X_0542_ _0055_ _0056_ VDD VSS INV_X1
X_0543_ _0056_ _0057_ VDD VSS CLKBUF_X3
X_0544_ _0057_ _0058_ VDD VSS CLKBUF_X3
X_0545_ net72 _0059_ VDD VSS BUF_X1
X_0546_ state\[0\] _0060_ VDD VSS CLKBUF_X3
X_0547_ _0060_ _0061_ VDD VSS BUF_X4
X_0548_ state\[3\] _0062_ VDD VSS CLKBUF_X2
X_0549_ _0062_ _0063_ VDD VSS INV_X2
X_0550_ _0061_ _0063_ _0064_ VDD VSS NAND2_X1
X_0551_ state\[2\] _0065_ VDD VSS BUF_X4
X_0552_ _0001_ _0066_ VDD VSS CLKBUF_X2
X_0553_ _0065_ _0066_ _0067_ VDD VSS NAND2_X1
X_0554_ state\[1\] _0068_ VDD VSS CLKBUF_X3
X_0555_ _0068_ _0069_ VDD VSS BUF_X4
X_0556_ _0000_ _0070_ VDD VSS CLKBUF_X2
X_0557_ _0070_ _0071_ VDD VSS INV_X1
X_0558_ _0062_ _0072_ VDD VSS BUF_X4
X_0559_ _0072_ _0073_ VDD VSS CLKBUF_X3
X_0560_ _0065_ _0074_ VDD VSS INV_X2
X_0561_ phase_complete _0075_ VDD VSS BUF_X2
X_0562_ read_phase _0076_ VDD VSS CLKBUF_X3
X_0563_ _0075_ _0076_ _0077_ VDD VSS OR2_X1
X_0564_ _0073_ _0074_ _0077_ _0078_ VDD VSS NOR3_X1
X_0565_ _0069_ _0071_ _0078_ _0079_ VDD VSS OAI21_X1
X_0566_ _0064_ _0067_ _0079_ _0080_ VDD VSS AOI21_X2
X_0567_ bist_start _0081_ VDD VSS CLKBUF_X2
X_0568_ _0061_ _0069_ _0065_ _0081_ _0082_ VDD VSS NOR4_X2
X_0569_ _0072_ _0082_ _0083_ VDD VSS NOR2_X2
X_0570_ _0068_ _0084_ VDD VSS INV_X2
X_0571_ _0084_ _0072_ _0085_ VDD VSS NOR2_X1
X_0572_ _0065_ _0086_ VDD VSS BUF_X4
X_0573_ _0067_ _0075_ _0086_ _0087_ VDD VSS OAI21_X1
X_0574_ _0060_ _0068_ _0088_ VDD VSS NOR2_X4
X_0575_ _0063_ _0065_ _0088_ _0089_ VDD VSS AND3_X2
X_0576_ net110 _0090_ VDD VSS CLKBUF_X2
X_0577_ _0090_ _0091_ VDD VSS INV_X1
X_0578_ _0077_ _0066_ _0091_ _0092_ VDD VSS AOI21_X1
X_0579_ _0085_ _0087_ _0089_ _0092_ _0093_ VDD VSS AOI22_X2
X_0580_ _0065_ _0069_ _0061_ _0094_ VDD VSS AOI21_X2
X_0581_ _0072_ _0094_ _0095_ VDD VSS NOR2_X2
X_0582_ _0065_ _0076_ _0091_ _0096_ VDD VSS AOI21_X1
X_0583_ _0061_ _0069_ _0097_ VDD VSS NAND2_X2
X_0584_ _0066_ _0098_ VDD VSS INV_X1
X_0585_ _0091_ _0098_ _0099_ VDD VSS NAND2_X1
X_0586_ _0095_ _0096_ _0097_ _0076_ _0099_ _0100_ VDD VSS
+ OAI221_X2
X_0587_ _0083_ _0093_ _0100_ _0101_ VDD VSS NAND3_X1
X_0588_ _0059_ _0080_ _0101_ _0102_ VDD VSS OAI21_X1
X_0589_ _0064_ _0103_ VDD VSS INV_X1
X_0590_ _0074_ _0098_ _0104_ VDD VSS NOR2_X1
X_0591_ _0072_ _0074_ _0077_ _0105_ VDD VSS OR3_X1
X_0592_ _0084_ _0070_ _0105_ _0106_ VDD VSS AOI21_X1
X_0593_ _0103_ _0104_ _0106_ _0107_ VDD VSS OAI21_X2
X_0594_ _0083_ _0093_ _0100_ _0108_ VDD VSS AND3_X2
X_0595_ _0069_ _0086_ _0109_ VDD VSS NOR2_X1
X_0596_ _0073_ _0109_ _0110_ VDD VSS OR2_X1
X_0597_ _0072_ _0074_ _0088_ _0111_ VDD VSS NOR3_X2
X_0598_ _0527_ _0112_ VDD VSS INV_X1
X_0599_ net75 _0054_ _0112_ _0113_ VDD VSS OR3_X2
X_0600_ _0531_ _0114_ VDD VSS INV_X1
X_0601_ _0111_ _0113_ _0114_ _0115_ VDD VSS OAI21_X4
X_0602_ _0084_ _0072_ _0086_ _0116_ VDD VSS NOR3_X4
X_0603_ _0536_ _0117_ VDD VSS INV_X1
X_0604_ _0089_ _0116_ _0117_ _0118_ VDD VSS AOI21_X2
X_0605_ _0536_ _0088_ _0119_ VDD VSS NAND2_X1
X_0606_ _0110_ _0115_ _0118_ _0119_ _0059_ _0120_ VDD VSS
+ AOI221_X1
X_0607_ _0107_ _0108_ _0120_ _0121_ VDD VSS NAND3_X1
X_0608_ _0058_ _0102_ _0121_ _0003_ VDD VSS AOI21_X1
X_0609_ net73 _0107_ _0108_ _0122_ VDD VSS AOI21_X1
X_0610_ _0536_ _0089_ _0123_ VDD VSS NAND2_X1
X_0611_ _0115_ _0118_ _0528_ _0124_ VDD VSS MUX2_X1
X_0612_ _0107_ _0108_ _0123_ _0124_ _0125_ VDD VSS AND4_X1
X_0613_ _0058_ _0122_ _0125_ _0004_ VDD VSS NOR3_X1
X_0614_ _0054_ _0527_ _0115_ _0118_ _0529_ _0126_ VDD VSS
+ OAI221_X1
X_0615_ _0529_ _0127_ VDD VSS INV_X1
X_0616_ _0112_ _0115_ _0118_ _0127_ _0128_ VDD VSS OAI22_X1
X_0617_ _0126_ _0128_ _0054_ _0129_ VDD VSS OAI21_X1
X_0618_ _0107_ _0108_ _0123_ _0130_ VDD VSS AND3_X1
X_0619_ _0107_ _0108_ _0131_ VDD VSS NAND2_X1
X_0620_ _0054_ _0132_ VDD VSS INV_X1
X_0621_ _0057_ _0129_ _0130_ _0131_ _0132_ _0005_ VDD VSS
+ AOI221_X1
X_0622_ net75 _0107_ _0108_ _0133_ VDD VSS AOI21_X1
X_0623_ _0054_ _0059_ net73 _0134_ VDD VSS NOR3_X1
X_0624_ _0002_ _0134_ _0135_ VDD VSS XOR2_X1
X_0625_ _0054_ _0059_ net73 _0136_ VDD VSS NAND3_X1
X_0626_ _0002_ _0136_ _0137_ VDD VSS XOR2_X1
X_0627_ _0536_ _0137_ _0138_ VDD VSS NOR2_X1
X_0628_ _0115_ _0135_ _0138_ _0118_ _0139_ VDD VSS OAI22_X1
X_0629_ _0080_ _0101_ _0139_ _0140_ VDD VSS NOR3_X1
X_0630_ _0058_ _0133_ _0140_ _0006_ VDD VSS NOR3_X1
X_0631_ net76 _0107_ _0108_ _0141_ VDD VSS AOI21_X1
X_0632_ _0534_ _0116_ _0142_ VDD VSS NAND2_X1
X_0633_ _0533_ _0143_ VDD VSS INV_X1
X_0634_ _0531_ _0088_ _0144_ VDD VSS NOR2_X1
X_0635_ _0143_ _0088_ _0113_ _0144_ _0145_ VDD VSS AOI22_X1
X_0636_ _0063_ _0086_ _0146_ VDD VSS NAND2_X1
X_0637_ _0142_ _0145_ _0146_ _0147_ VDD VSS OAI21_X1
X_0638_ _0080_ _0101_ _0147_ _0148_ VDD VSS NOR3_X1
X_0639_ _0058_ _0141_ _0148_ _0007_ VDD VSS NOR3_X1
X_0640_ _0061_ _0069_ _0065_ _0149_ VDD VSS NOR3_X2
X_0641_ _0073_ _0149_ _0150_ VDD VSS NAND2_X1
X_0642_ _0081_ _0149_ _0151_ VDD VSS NAND2_X1
X_0643_ net33 _0151_ _0152_ VDD VSS NAND2_X1
X_0644_ _0058_ _0150_ _0152_ _0008_ VDD VSS AOI21_X1
X_0645_ _0521_ _0153_ VDD VSS INV_X1
X_0646_ net58 net63 net64 _0153_ _0154_ VDD VSS NOR4_X1
X_0647_ net60 _0155_ VDD VSS BUF_X1
X_0648_ net49 net59 _0155_ net61 _0156_ VDD VSS NOR4_X1
X_0649_ net56 _0157_ VDD VSS BUF_X1
X_0650_ net57 _0158_ VDD VSS BUF_X1
X_0651_ net54 net55 _0157_ _0158_ _0159_ VDD VSS NOR4_X1
X_0652_ net50 _0160_ VDD VSS BUF_X1
X_0653_ net53 _0161_ VDD VSS BUF_X1
X_0654_ _0160_ net52 _0161_ _0162_ VDD VSS NOR3_X1
X_0655_ _0154_ _0156_ _0159_ _0162_ _0163_ VDD VSS NAND4_X1
X_0656_ net68 _0164_ VDD VSS BUF_X2
X_0657_ net69 _0165_ VDD VSS BUF_X4
X_0658_ net70 _0166_ VDD VSS BUF_X1
X_0659_ net71 _0167_ VDD VSS CLKBUF_X2
X_0660_ _0164_ _0165_ _0166_ _0167_ _0168_ VDD VSS NOR4_X1
X_0661_ net62 _0169_ VDD VSS CLKBUF_X2
X_0662_ net65 _0170_ VDD VSS CLKBUF_X2
X_0663_ net66 _0171_ VDD VSS CLKBUF_X2
X_0664_ net67 _0172_ VDD VSS CLKBUF_X2
X_0665_ _0169_ _0170_ _0171_ _0172_ _0173_ VDD VSS NOR4_X1
X_0666_ net41 _0174_ VDD VSS BUF_X4
X_0667_ _0174_ net45 net46 net47 _0175_ VDD VSS NOR4_X1
X_0668_ net43 _0176_ VDD VSS BUF_X1
X_0669_ net48 _0177_ VDD VSS CLKBUF_X2
X_0670_ net42 _0176_ net44 _0177_ _0178_ VDD VSS NOR4_X1
X_0671_ _0168_ _0173_ _0175_ _0178_ _0179_ VDD VSS NAND4_X1
X_0672_ _0150_ _0163_ _0179_ _0180_ VDD VSS NOR3_X1
X_0673_ _0149_ _0081_ _0073_ _0181_ VDD VSS OAI21_X1
X_0674_ _0180_ _0181_ net34 _0182_ VDD VSS AOI21_X1
X_0675_ _0058_ _0182_ _0009_ VDD VSS NOR2_X1
X_0676_ _0055_ _0183_ VDD VSS BUF_X2
X_0677_ net35 _0183_ _0184_ VDD VSS AND2_X1
X_0678_ _0059_ _0183_ _0185_ VDD VSS AND2_X1
X_0679_ _0072_ _0094_ _0186_ VDD VSS OR2_X2
X_0680_ _0060_ _0068_ state\[2\] _0187_ VDD VSS NAND3_X2
X_0681_ _0072_ _0075_ _0076_ _0187_ _0188_ VDD VSS NOR4_X2
X_0682_ _0060_ _0068_ _0189_ VDD VSS AND2_X1
X_0683_ _0074_ _0189_ _0190_ VDD VSS XNOR2_X1
X_0684_ _0072_ _0076_ _0090_ _0098_ _0191_ VDD VSS NOR4_X2
X_0685_ _0188_ _0190_ _0191_ _0192_ VDD VSS AOI21_X2
X_0686_ net9 net13 net16 net15 _0193_ VDD VSS NAND4_X1
X_0687_ net8 net11 net10 net14 _0194_ VDD VSS NAND4_X1
X_0688_ net18 net21 net25 net24 _0195_ VDD VSS NAND4_X1
X_0689_ net17 net20 net19 net22 _0196_ VDD VSS NAND4_X1
X_0690_ _0193_ _0194_ _0195_ _0196_ _0197_ VDD VSS NOR4_X1
X_0691_ net28 net27 net30 net6 _0198_ VDD VSS NAND4_X1
X_0692_ net12 net1 net26 net23 _0199_ VDD VSS NAND4_X1
X_0693_ net29 net5 net4 net7 _0200_ VDD VSS NAND4_X1
X_0694_ net32 net31 net3 net2 _0201_ VDD VSS NAND4_X1
X_0695_ _0198_ _0199_ _0200_ _0201_ _0202_ VDD VSS NOR4_X1
X_0696_ _0070_ _0197_ _0202_ _0203_ VDD VSS AOI21_X1
X_0697_ _0076_ _0090_ _0098_ _0204_ VDD VSS NOR3_X1
X_0698_ _0060_ _0062_ _0205_ VDD VSS NOR2_X2
X_0699_ _0065_ _0205_ _0206_ VDD VSS NAND2_X1
X_0700_ _0204_ _0206_ _0207_ VDD VSS OR2_X1
X_0701_ _0192_ _0203_ _0207_ _0208_ VDD VSS OAI21_X2
X_0702_ _0076_ _0209_ VDD VSS INV_X1
X_0703_ net18 net17 net20 net24 _0210_ VDD VSS NOR4_X1
X_0704_ net19 net22 net21 net25 _0211_ VDD VSS NOR4_X1
X_0705_ _0210_ _0211_ _0212_ VDD VSS NAND2_X1
X_0706_ net9 net8 net11 net15 _0213_ VDD VSS NOR4_X1
X_0707_ net10 net14 net13 net16 _0214_ VDD VSS NOR4_X1
X_0708_ _0213_ _0214_ _0215_ VDD VSS NAND2_X1
X_0709_ net28 net27 net30 net6 _0216_ VDD VSS NOR4_X1
X_0710_ net12 net1 net26 net23 _0217_ VDD VSS NOR4_X1
X_0711_ _0216_ _0217_ _0218_ VDD VSS NAND2_X1
X_0712_ net29 net5 net4 net7 _0219_ VDD VSS NOR4_X1
X_0713_ net32 net31 net3 net2 _0220_ VDD VSS NOR4_X1
X_0714_ _0219_ _0220_ _0221_ VDD VSS NAND2_X1
X_0715_ _0212_ _0215_ _0218_ _0221_ _0222_ VDD VSS OR4_X1
X_0716_ _0071_ _0209_ _0222_ _0223_ VDD VSS OAI21_X1
X_0717_ _0186_ _0208_ _0223_ _0206_ _0224_ VDD VSS AOI211_X2
X_0718_ _0184_ _0185_ _0224_ _0010_ VDD VSS MUX2_X1
X_0719_ net36 _0183_ _0225_ VDD VSS AND2_X1
X_0720_ net73 _0183_ _0226_ VDD VSS AND2_X1
X_0721_ _0225_ _0226_ _0224_ _0011_ VDD VSS MUX2_X1
X_0722_ net37 _0183_ _0227_ VDD VSS AND2_X1
X_0723_ _0132_ _0057_ _0228_ VDD VSS NOR2_X1
X_0724_ _0227_ _0228_ _0224_ _0012_ VDD VSS MUX2_X1
X_0725_ net38 _0183_ _0229_ VDD VSS AND2_X1
X_0726_ net75 _0183_ _0230_ VDD VSS AND2_X1
X_0727_ _0229_ _0230_ _0224_ _0013_ VDD VSS MUX2_X1
X_0728_ net39 _0183_ _0231_ VDD VSS AND2_X1
X_0729_ net76 _0183_ _0232_ VDD VSS AND2_X1
X_0730_ _0231_ _0232_ _0224_ _0014_ VDD VSS MUX2_X1
X_0731_ _0055_ _0151_ _0073_ _0233_ VDD VSS OAI21_X2
X_0732_ _0233_ _0234_ VDD VSS CLKBUF_X3
X_0733_ _0208_ _0235_ VDD VSS BUF_X4
X_0734_ _0235_ _0236_ VDD VSS CLKBUF_X3
X_0735_ _0070_ _0094_ _0237_ VDD VSS NOR2_X1
X_0736_ _0065_ _0081_ _0084_ _0238_ VDD VSS AOI21_X1
X_0737_ _0061_ _0238_ _0239_ VDD VSS NOR2_X1
X_0738_ _0061_ _0069_ _0086_ _0240_ VDD VSS OAI21_X1
X_0739_ _0063_ _0237_ _0239_ _0240_ _0222_ _0241_ VDD VSS
+ OAI221_X2
X_0740_ _0241_ _0242_ VDD VSS CLKBUF_X3
X_0741_ _0242_ _0243_ VDD VSS CLKBUF_X3
X_0742_ net40 _0236_ _0243_ _0244_ VDD VSS OAI21_X1
X_0743_ _0242_ _0245_ VDD VSS BUF_X4
X_0744_ net40 _0235_ _0245_ _0246_ VDD VSS OR3_X1
X_0745_ _0234_ _0244_ _0246_ _0015_ VDD VSS AOI21_X1
X_0746_ _0186_ _0208_ _0241_ _0247_ VDD VSS OR3_X2
X_0747_ _0247_ _0248_ VDD VSS CLKBUF_X3
X_0748_ _0164_ _0249_ VDD VSS INV_X1
X_0749_ _0165_ _0250_ VDD VSS INV_X1
X_0750_ _0523_ _0169_ _0170_ _0251_ VDD VSS NAND3_X2
X_0751_ _0171_ _0172_ _0252_ VDD VSS NAND2_X2
X_0752_ _0249_ _0250_ _0251_ _0252_ _0253_ VDD VSS NOR4_X4
X_0753_ _0166_ _0254_ VDD VSS INV_X1
X_0754_ _0167_ _0255_ VDD VSS INV_X1
X_0755_ _0254_ _0255_ _0256_ VDD VSS NOR2_X1
X_0756_ _0174_ _0057_ _0257_ VDD VSS NOR2_X1
X_0757_ _0253_ _0256_ _0257_ _0258_ VDD VSS NAND3_X1
X_0758_ _0055_ _0259_ VDD VSS CLKBUF_X3
X_0759_ _0174_ _0259_ _0260_ VDD VSS NAND2_X1
X_0760_ _0235_ _0261_ VDD VSS BUF_X4
X_0761_ _0242_ _0262_ VDD VSS BUF_X4
X_0762_ _0186_ _0263_ VDD VSS BUF_X4
X_0763_ _0263_ _0253_ _0256_ _0264_ VDD VSS AOI21_X1
X_0764_ _0261_ _0262_ _0264_ _0265_ VDD VSS NOR3_X1
X_0765_ _0248_ _0258_ _0260_ _0265_ _0016_ VDD VSS OAI22_X1
X_0766_ _0073_ _0151_ _0266_ VDD VSS NOR2_X1
X_0767_ _0056_ _0266_ _0267_ VDD VSS NOR2_X1
X_0768_ _0267_ _0268_ VDD VSS BUF_X2
X_0769_ net42 _0268_ _0269_ VDD VSS AND2_X1
X_0770_ net42 _0234_ _0270_ VDD VSS NOR2_X1
X_0771_ _0235_ _0271_ VDD VSS CLKBUF_X3
X_0772_ net40 net51 _0272_ VDD VSS NAND2_X2
X_0773_ _0169_ _0170_ _0171_ _0172_ _0273_ VDD VSS NAND4_X1
X_0774_ _0272_ _0273_ _0274_ VDD VSS NOR2_X1
X_0775_ _0164_ _0165_ _0166_ _0274_ _0275_ VDD VSS AND4_X1
X_0776_ _0167_ _0174_ _0275_ _0276_ VDD VSS NAND3_X1
X_0777_ _0271_ _0245_ _0276_ _0277_ VDD VSS NOR3_X1
X_0778_ _0269_ _0270_ _0277_ _0017_ VDD VSS MUX2_X1
X_0779_ _0166_ _0167_ _0278_ VDD VSS NAND2_X1
X_0780_ _0164_ _0165_ _0174_ net42 _0279_ VDD VSS NAND4_X2
X_0781_ _0251_ _0252_ _0278_ _0279_ _0280_ VDD VSS OR4_X4
X_0782_ _0095_ _0280_ _0281_ VDD VSS AND2_X1
X_0783_ _0236_ _0243_ _0281_ _0282_ VDD VSS NOR3_X1
X_0784_ _0183_ _0283_ VDD VSS BUF_X4
X_0785_ _0176_ _0283_ _0284_ VDD VSS NAND2_X1
X_0786_ _0176_ _0057_ _0280_ _0285_ VDD VSS OR3_X1
X_0787_ _0282_ _0284_ _0285_ _0248_ _0018_ VDD VSS OAI22_X1
X_0788_ _0278_ _0279_ _0286_ VDD VSS NOR2_X1
X_0789_ _0176_ _0274_ _0286_ _0287_ VDD VSS NAND3_X1
X_0790_ _0095_ _0287_ _0288_ VDD VSS AND2_X1
X_0791_ _0236_ _0243_ _0288_ _0289_ VDD VSS NOR3_X1
X_0792_ net44 _0283_ _0290_ VDD VSS NAND2_X1
X_0793_ net44 _0057_ _0287_ _0291_ VDD VSS OR3_X1
X_0794_ _0289_ _0290_ _0291_ _0248_ _0019_ VDD VSS OAI22_X1
X_0795_ _0263_ _0292_ VDD VSS CLKBUF_X3
X_0796_ _0176_ net44 _0293_ VDD VSS NAND2_X2
X_0797_ _0280_ _0293_ _0294_ VDD VSS NOR2_X1
X_0798_ _0292_ _0294_ _0295_ VDD VSS NOR2_X1
X_0799_ _0236_ _0243_ _0295_ _0296_ VDD VSS NOR3_X1
X_0800_ net45 _0283_ _0297_ VDD VSS NAND2_X1
X_0801_ net45 _0298_ VDD VSS INV_X1
X_0802_ _0298_ _0259_ _0294_ _0299_ VDD VSS NAND3_X1
X_0803_ _0296_ _0297_ _0299_ _0248_ _0020_ VDD VSS OAI22_X1
X_0804_ _0298_ _0293_ _0300_ VDD VSS NOR2_X1
X_0805_ _0274_ _0286_ _0300_ _0301_ VDD VSS AND3_X1
X_0806_ _0292_ _0301_ _0302_ VDD VSS NOR2_X1
X_0807_ _0236_ _0243_ _0302_ _0303_ VDD VSS NOR3_X1
X_0808_ net46 _0283_ _0304_ VDD VSS NAND2_X1
X_0809_ net46 _0305_ VDD VSS INV_X1
X_0810_ _0055_ _0306_ VDD VSS CLKBUF_X3
X_0811_ _0305_ _0306_ _0301_ _0307_ VDD VSS NAND3_X1
X_0812_ _0303_ _0304_ _0307_ _0248_ _0021_ VDD VSS OAI22_X1
X_0813_ net45 net46 _0308_ VDD VSS NAND2_X1
X_0814_ _0280_ _0293_ _0308_ _0309_ VDD VSS NOR3_X1
X_0815_ _0292_ _0309_ _0310_ VDD VSS NOR2_X1
X_0816_ _0236_ _0243_ _0310_ _0311_ VDD VSS NOR3_X1
X_0817_ net47 _0283_ _0312_ VDD VSS NAND2_X1
X_0818_ net47 _0313_ VDD VSS INV_X1
X_0819_ _0313_ _0306_ _0309_ _0314_ VDD VSS NAND3_X1
X_0820_ _0311_ _0312_ _0314_ _0248_ _0022_ VDD VSS OAI22_X1
X_0821_ _0235_ _0242_ _0315_ VDD VSS NOR2_X1
X_0822_ _0305_ _0313_ _0316_ VDD VSS NOR2_X1
X_0823_ _0274_ _0286_ _0300_ _0316_ _0317_ VDD VSS AND4_X1
X_0824_ _0317_ _0318_ VDD VSS BUF_X2
X_0825_ _0177_ _0186_ _0318_ _0319_ VDD VSS OAI21_X1
X_0826_ _0319_ _0320_ VDD VSS INV_X1
X_0827_ _0301_ _0316_ _0321_ VDD VSS NAND2_X1
X_0828_ _0186_ _0208_ _0241_ _0321_ _0322_ VDD VSS OR4_X1
X_0829_ _0177_ _0323_ VDD VSS INV_X1
X_0830_ _0057_ _0315_ _0320_ _0322_ _0323_ _0023_ VDD VSS
+ AOI221_X1
X_0831_ net49 _0324_ VDD VSS INV_X1
X_0832_ _0313_ _0280_ _0293_ _0308_ _0325_ VDD VSS NOR4_X4
X_0833_ _0177_ _0324_ _0055_ _0325_ _0326_ VDD VSS NAND4_X1
X_0834_ _0292_ _0235_ _0242_ _0326_ _0327_ VDD VSS OR4_X1
X_0835_ net49 _0283_ _0328_ VDD VSS NAND2_X1
X_0836_ _0263_ _0325_ _0177_ _0329_ VDD VSS AOI21_X1
X_0837_ _0261_ _0262_ _0329_ _0330_ VDD VSS NOR3_X1
X_0838_ _0327_ _0328_ _0330_ _0024_ VDD VSS OAI21_X1
X_0839_ _0323_ _0324_ _0331_ VDD VSS NOR2_X1
X_0840_ _0160_ _0057_ _0332_ VDD VSS NOR2_X1
X_0841_ _0318_ _0331_ _0332_ _0333_ VDD VSS NAND3_X1
X_0842_ _0292_ _0235_ _0242_ _0333_ _0334_ VDD VSS OR4_X1
X_0843_ _0160_ _0283_ _0335_ VDD VSS NAND2_X1
X_0844_ _0263_ _0318_ _0331_ _0336_ VDD VSS AOI21_X1
X_0845_ _0261_ _0262_ _0336_ _0337_ VDD VSS NOR3_X1
X_0846_ _0334_ _0335_ _0337_ _0025_ VDD VSS OAI21_X1
X_0847_ net51 _0236_ _0243_ _0338_ VDD VSS OAI21_X1
X_0848_ _0522_ _0095_ _0339_ VDD VSS NAND2_X1
X_0849_ _0261_ _0262_ _0339_ _0340_ VDD VSS OR3_X1
X_0850_ _0058_ _0338_ _0340_ _0026_ VDD VSS AOI21_X1
X_0851_ _0160_ _0331_ _0341_ VDD VSS AND2_X1
X_0852_ net52 _0056_ _0342_ VDD VSS NOR2_X1
X_0853_ _0325_ _0341_ _0342_ _0343_ VDD VSS NAND3_X1
X_0854_ _0292_ _0235_ _0242_ _0343_ _0344_ VDD VSS OR4_X1
X_0855_ net52 _0283_ _0345_ VDD VSS NAND2_X1
X_0856_ _0263_ _0325_ _0341_ _0346_ VDD VSS AOI21_X1
X_0857_ _0261_ _0262_ _0346_ _0347_ VDD VSS NOR3_X1
X_0858_ _0344_ _0345_ _0347_ _0027_ VDD VSS OAI21_X1
X_0859_ _0161_ _0268_ _0348_ VDD VSS AND2_X1
X_0860_ _0161_ _0234_ _0349_ VDD VSS NOR2_X1
X_0861_ _0177_ net49 _0160_ net52 _0350_ VDD VSS AND4_X1
X_0862_ _0318_ _0350_ _0351_ VDD VSS NAND2_X1
X_0863_ _0271_ _0245_ _0351_ _0352_ VDD VSS NOR3_X1
X_0864_ _0348_ _0349_ _0352_ _0028_ VDD VSS MUX2_X1
X_0865_ net54 _0268_ _0353_ VDD VSS AND2_X1
X_0866_ net54 _0234_ _0354_ VDD VSS NOR2_X1
X_0867_ _0161_ _0325_ _0350_ _0355_ VDD VSS NAND3_X1
X_0868_ _0271_ _0245_ _0355_ _0356_ VDD VSS NOR3_X1
X_0869_ _0353_ _0354_ _0356_ _0029_ VDD VSS MUX2_X1
X_0870_ net55 _0268_ _0357_ VDD VSS AND2_X1
X_0871_ net55 _0234_ _0358_ VDD VSS NOR2_X1
X_0872_ _0161_ net54 _0350_ _0359_ VDD VSS AND3_X1
X_0873_ _0318_ _0359_ _0360_ VDD VSS NAND2_X1
X_0874_ _0271_ _0245_ _0360_ _0361_ VDD VSS NOR3_X1
X_0875_ _0357_ _0358_ _0361_ _0030_ VDD VSS MUX2_X1
X_0876_ _0157_ _0268_ _0362_ VDD VSS AND2_X1
X_0877_ _0157_ _0234_ _0363_ VDD VSS NOR2_X1
X_0878_ net55 _0359_ _0364_ VDD VSS AND2_X1
X_0879_ _0364_ _0365_ VDD VSS BUF_X2
X_0880_ _0325_ _0365_ _0366_ VDD VSS NAND2_X1
X_0881_ _0271_ _0245_ _0366_ _0367_ VDD VSS NOR3_X1
X_0882_ _0362_ _0363_ _0367_ _0031_ VDD VSS MUX2_X1
X_0883_ _0158_ _0268_ _0368_ VDD VSS AND2_X1
X_0884_ _0158_ _0234_ _0369_ VDD VSS NOR2_X1
X_0885_ _0157_ _0318_ _0365_ _0370_ VDD VSS NAND3_X1
X_0886_ _0271_ _0245_ _0370_ _0371_ VDD VSS NOR3_X1
X_0887_ _0368_ _0369_ _0371_ _0032_ VDD VSS MUX2_X1
X_0888_ net58 _0268_ _0372_ VDD VSS AND2_X1
X_0889_ net58 _0234_ _0373_ VDD VSS NOR2_X1
X_0890_ _0157_ _0158_ _0325_ _0365_ _0374_ VDD VSS NAND4_X1
X_0891_ _0271_ _0245_ _0374_ _0375_ VDD VSS NOR3_X1
X_0892_ _0372_ _0373_ _0375_ _0033_ VDD VSS MUX2_X1
X_0893_ net59 _0268_ _0376_ VDD VSS AND2_X1
X_0894_ net59 _0234_ _0377_ VDD VSS NOR2_X1
X_0895_ _0157_ _0158_ net58 _0378_ VDD VSS AND3_X1
X_0896_ _0318_ _0365_ _0378_ _0379_ VDD VSS NAND3_X1
X_0897_ _0271_ _0245_ _0379_ _0380_ VDD VSS NOR3_X1
X_0898_ _0376_ _0377_ _0380_ _0034_ VDD VSS MUX2_X1
X_0899_ _0155_ _0268_ _0381_ VDD VSS AND2_X1
X_0900_ _0155_ _0234_ _0382_ VDD VSS NOR2_X1
X_0901_ net59 _0378_ _0383_ VDD VSS AND2_X1
X_0902_ _0325_ _0365_ _0383_ _0384_ VDD VSS NAND3_X1
X_0903_ _0271_ _0245_ _0384_ _0385_ VDD VSS NOR3_X1
X_0904_ _0381_ _0382_ _0385_ _0035_ VDD VSS MUX2_X1
X_0905_ net61 _0268_ _0386_ VDD VSS AND2_X1
X_0906_ net61 _0233_ _0387_ VDD VSS NOR2_X1
X_0907_ _0155_ _0318_ _0365_ _0383_ _0388_ VDD VSS NAND4_X1
X_0908_ _0271_ _0242_ _0388_ _0389_ VDD VSS NOR3_X1
X_0909_ _0386_ _0387_ _0389_ _0036_ VDD VSS MUX2_X1
X_0910_ _0523_ _0263_ _0390_ VDD VSS NOR2_X1
X_0911_ _0236_ _0243_ _0390_ _0391_ VDD VSS NOR3_X1
X_0912_ _0169_ _0259_ _0392_ VDD VSS NAND2_X1
X_0913_ _0169_ _0393_ VDD VSS INV_X1
X_0914_ _0523_ _0393_ _0306_ _0394_ VDD VSS NAND3_X1
X_0915_ _0391_ _0392_ _0394_ _0248_ _0037_ VDD VSS OAI22_X1
X_0916_ net63 _0267_ _0395_ VDD VSS AND2_X1
X_0917_ net63 _0233_ _0396_ VDD VSS NOR2_X1
X_0918_ _0155_ net61 _0383_ _0397_ VDD VSS AND3_X1
X_0919_ _0325_ _0365_ _0397_ _0398_ VDD VSS NAND3_X1
X_0920_ _0235_ _0242_ _0398_ _0399_ VDD VSS NOR3_X1
X_0921_ _0395_ _0396_ _0399_ _0038_ VDD VSS MUX2_X1
X_0922_ net64 _0267_ _0400_ VDD VSS AND2_X1
X_0923_ net64 _0233_ _0401_ VDD VSS NOR2_X1
X_0924_ _0155_ net61 net63 _0383_ _0402_ VDD VSS AND4_X1
X_0925_ _0318_ _0365_ _0402_ _0403_ VDD VSS NAND3_X1
X_0926_ _0235_ _0242_ _0403_ _0404_ VDD VSS NOR3_X1
X_0927_ _0400_ _0401_ _0404_ _0039_ VDD VSS MUX2_X1
X_0928_ _0393_ _0272_ _0405_ VDD VSS NOR2_X1
X_0929_ _0292_ _0405_ _0406_ VDD VSS NOR2_X1
X_0930_ _0236_ _0243_ _0406_ _0407_ VDD VSS NOR3_X1
X_0931_ _0170_ _0259_ _0408_ VDD VSS NAND2_X1
X_0932_ _0170_ _0409_ VDD VSS INV_X1
X_0933_ _0409_ _0306_ _0405_ _0410_ VDD VSS NAND3_X1
X_0934_ _0407_ _0408_ _0410_ _0248_ _0040_ VDD VSS OAI22_X1
X_0935_ _0523_ _0169_ _0170_ _0411_ VDD VSS AND3_X1
X_0936_ _0292_ _0411_ _0412_ VDD VSS NOR2_X1
X_0937_ _0236_ _0243_ _0412_ _0413_ VDD VSS NOR3_X1
X_0938_ _0171_ _0259_ _0414_ VDD VSS NAND2_X1
X_0939_ _0171_ _0415_ VDD VSS INV_X1
X_0940_ _0415_ _0306_ _0411_ _0416_ VDD VSS NAND3_X1
X_0941_ _0413_ _0414_ _0416_ _0248_ _0041_ VDD VSS OAI22_X1
X_0942_ _0393_ _0409_ _0415_ _0272_ _0417_ VDD VSS NOR4_X2
X_0943_ _0292_ _0417_ _0418_ VDD VSS NOR2_X1
X_0944_ _0261_ _0262_ _0418_ _0419_ VDD VSS NOR3_X1
X_0945_ _0172_ _0259_ _0420_ VDD VSS NAND2_X1
X_0946_ _0172_ _0421_ VDD VSS INV_X1
X_0947_ _0421_ _0306_ _0417_ _0422_ VDD VSS NAND3_X1
X_0948_ _0419_ _0420_ _0422_ _0248_ _0042_ VDD VSS OAI22_X1
X_0949_ _0251_ _0252_ _0423_ VDD VSS NOR2_X1
X_0950_ _0292_ _0423_ _0424_ VDD VSS NOR2_X1
X_0951_ _0261_ _0262_ _0424_ _0425_ VDD VSS NOR3_X1
X_0952_ _0164_ _0259_ _0426_ VDD VSS NAND2_X1
X_0953_ _0249_ _0306_ _0423_ _0427_ VDD VSS NAND3_X1
X_0954_ _0425_ _0426_ _0427_ _0247_ _0043_ VDD VSS OAI22_X1
X_0955_ _0249_ _0272_ _0273_ _0428_ VDD VSS NOR3_X1
X_0956_ _0263_ _0428_ _0429_ VDD VSS NOR2_X1
X_0957_ _0261_ _0262_ _0429_ _0430_ VDD VSS NOR3_X1
X_0958_ _0165_ _0259_ _0431_ VDD VSS NAND2_X1
X_0959_ _0250_ _0306_ _0428_ _0432_ VDD VSS NAND3_X1
X_0960_ _0430_ _0431_ _0432_ _0247_ _0044_ VDD VSS OAI22_X1
X_0961_ _0263_ _0253_ _0433_ VDD VSS NOR2_X1
X_0962_ _0261_ _0262_ _0433_ _0434_ VDD VSS NOR3_X1
X_0963_ _0166_ _0259_ _0435_ VDD VSS NAND2_X1
X_0964_ _0254_ _0306_ _0253_ _0436_ VDD VSS NAND3_X1
X_0965_ _0434_ _0435_ _0436_ _0247_ _0045_ VDD VSS OAI22_X1
X_0966_ _0263_ _0275_ _0437_ VDD VSS NOR2_X1
X_0967_ _0261_ _0262_ _0437_ _0438_ VDD VSS NOR3_X1
X_0968_ _0167_ _0259_ _0439_ VDD VSS NAND2_X1
X_0969_ _0255_ _0306_ _0275_ _0440_ VDD VSS NAND3_X1
X_0970_ _0438_ _0439_ _0440_ _0247_ _0046_ VDD VSS OAI22_X1
X_0971_ _0076_ _0091_ _0066_ _0441_ VDD VSS AOI21_X1
X_0972_ _0077_ _0441_ _0187_ _0442_ VDD VSS MUX2_X1
X_0973_ _0083_ _0263_ _0442_ _0443_ VDD VSS OAI21_X1
X_0974_ _0086_ _0090_ _0097_ _0444_ VDD VSS NAND3_X1
X_0975_ _0070_ _0091_ _0074_ _0445_ VDD VSS MUX2_X1
X_0976_ _0444_ _0445_ _0097_ _0446_ VDD VSS OAI21_X1
X_0977_ _0061_ _0075_ _0447_ VDD VSS NOR2_X1
X_0978_ _0063_ _0446_ _0447_ _0116_ _0448_ VDD VSS AOI22_X1
X_0979_ _0443_ _0448_ _0449_ VDD VSS OR2_X1
X_0980_ _0075_ _0443_ _0450_ VDD VSS NAND2_X1
X_0981_ _0058_ _0449_ _0450_ _0047_ VDD VSS AOI21_X1
X_0982_ _0061_ _0451_ VDD VSS INV_X1
X_0983_ _0073_ _0238_ _0451_ _0452_ VDD VSS AOI21_X1
X_0984_ _0209_ _0452_ _0453_ VDD VSS OR2_X1
X_0985_ _0058_ _0192_ _0453_ _0048_ VDD VSS AOI21_X1
X_0986_ _0066_ _0117_ _0089_ _0116_ _0454_ VDD VSS OAI22_X2
X_0987_ _0073_ _0081_ _0149_ _0455_ VDD VSS NAND3_X1
X_0988_ _0067_ _0088_ _0456_ VDD VSS NOR2_X1
X_0989_ _0063_ _0082_ _0456_ _0457_ VDD VSS OAI21_X1
X_0990_ _0115_ _0454_ _0455_ _0457_ _0458_ VDD VSS NAND4_X2
X_0991_ _0205_ _0061_ _0458_ _0459_ VDD VSS MUX2_X1
X_0992_ _0283_ _0459_ _0049_ VDD VSS AND2_X1
X_0993_ _0069_ _0205_ _0458_ _0460_ VDD VSS OAI21_X1
X_0994_ _0069_ _0064_ _0458_ _0461_ VDD VSS OR3_X1
X_0995_ _0058_ _0460_ _0461_ _0050_ VDD VSS AOI21_X1
X_0996_ _0063_ _0074_ _0189_ _0462_ VDD VSS NAND3_X1
X_0997_ _0462_ _0074_ _0458_ _0463_ VDD VSS MUX2_X1
X_0998_ _0063_ _0086_ _0097_ _0464_ VDD VSS NAND3_X1
X_0999_ _0057_ _0463_ _0464_ _0051_ VDD VSS AOI21_X1
X_1000_ _0073_ _0187_ _0458_ _0465_ VDD VSS OR3_X1
X_1001_ _0057_ _0455_ _0465_ _0052_ VDD VSS AOI21_X1
X_1002_ _0084_ _0189_ _0074_ _0466_ VDD VSS MUX2_X1
X_1003_ _0071_ _0466_ _0467_ VDD VSS NAND2_X1
X_1004_ _0074_ _0070_ _0468_ VDD VSS NOR2_X1
X_1005_ _0084_ _0086_ _0075_ _0469_ VDD VSS NOR3_X1
X_1006_ _0451_ _0468_ _0469_ _0470_ VDD VSS OAI21_X1
X_1007_ _0073_ _0467_ _0470_ _0471_ VDD VSS AOI21_X1
X_1008_ _0189_ _0204_ _0472_ VDD VSS NAND2_X1
X_1009_ _0086_ _0189_ _0204_ _0473_ VDD VSS OAI21_X1
X_1010_ _0083_ _0472_ _0473_ _0474_ VDD VSS NAND3_X1
X_1011_ _0471_ _0090_ _0474_ _0475_ VDD VSS MUX2_X1
X_1012_ _0283_ _0475_ _0053_ VDD VSS AND2_X1
X_1013_ _0109_ _0063_ _0451_ net77 VDD VSS OAI21_X1
X_1014_ _0205_ _0086_ _0069_ net102 VDD VSS OAI21_X4
X_1015_ _0519_ _0520_ _0521_ _0522_ VDD VSS HA_X1
X_1016_ net40 net51 _0523_ _0524_ VDD VSS HA_X1
X_1017_ _0525_ _0526_ _0527_ _0528_ VDD VSS HA_X1
X_1018_ net72 net73 _0529_ _0530_ VDD VSS HA_X1
X_1019_ _0531_ _0532_ _0533_ _0534_ VDD VSS HA_X1
X_1020_ net76 _0535_ _0536_ _0537_ VDD VSS HA_X1
X_1021_ net102 net78 VDD VSS BUF_X1
X_1022_ net102 net89 VDD VSS BUF_X1
X_1023_ net102 net100 VDD VSS BUF_X1
X_1024_ net102 net103 VDD VSS BUF_X1
X_1025_ net102 net104 VDD VSS BUF_X1
X_1026_ net102 net105 VDD VSS BUF_X1
X_1027_ net102 net106 VDD VSS BUF_X1
X_1028_ net102 net107 VDD VSS BUF_X1
X_1029_ net102 net108 VDD VSS BUF_X1
X_1030_ net102 net109 VDD VSS BUF_X1
X_1031_ net102 net79 VDD VSS BUF_X1
X_1032_ net102 net80 VDD VSS BUF_X1
X_1033_ net102 net81 VDD VSS BUF_X1
X_1034_ net102 net82 VDD VSS BUF_X1
X_1035_ net102 net83 VDD VSS BUF_X1
X_1036_ net102 net84 VDD VSS BUF_X1
X_1037_ net102 net85 VDD VSS BUF_X1
X_1038_ net102 net86 VDD VSS BUF_X1
X_1039_ net102 net87 VDD VSS BUF_X1
X_1040_ net102 net88 VDD VSS BUF_X1
X_1041_ net102 net90 VDD VSS BUF_X1
X_1042_ net102 net91 VDD VSS BUF_X1
X_1043_ net102 net92 VDD VSS BUF_X1
X_1044_ net102 net93 VDD VSS BUF_X1
X_1045_ net102 net94 VDD VSS BUF_X1
X_1046_ net102 net95 VDD VSS BUF_X1
X_1047_ net102 net96 VDD VSS BUF_X1
X_1048_ net102 net97 VDD VSS BUF_X1
X_1049_ net102 net98 VDD VSS BUF_X1
X_1050_ net102 net99 VDD VSS BUF_X1
X_1051_ net102 net101 VDD VSS BUF_X1
Xaddr_counter\[0\]$_SDFFE_PN0P_ _0003_ clknet_2_0__leaf_clk
+ net72 _0525_ VDD VSS DFF_X1
Xaddr_counter\[1\]$_SDFFE_PN0P_ _0004_ clknet_2_0__leaf_clk
+ net73 _0526_ VDD VSS DFF_X2
Xaddr_counter\[2\]$_SDFFE_PN0P_ _0005_ clknet_2_0__leaf_clk
+ net74 _0518_ VDD VSS DFF_X1
Xaddr_counter\[3\]$_SDFFE_PN0P_ _0006_ clknet_2_0__leaf_clk
+ net75 _0002_ VDD VSS DFF_X2
Xaddr_counter\[4\]$_SDFFE_PN0P_ _0007_ clknet_2_0__leaf_clk
+ net76 _0531_ VDD VSS DFF_X2
Xbist_done$_SDFFE_PN0P_ _0008_ clknet_2_0__leaf_clk net33
+ _0517_ VDD VSS DFF_X1
Xbist_pass$_SDFFE_PN0P_ _0009_ clknet_2_0__leaf_clk net34
+ _0516_ VDD VSS DFF_X1
Xerror_addr\[0\]$_SDFFE_PN0P_ _0010_ clknet_2_0__leaf_clk
+ net35 _0515_ VDD VSS DFF_X1
Xerror_addr\[1\]$_SDFFE_PN0P_ _0011_ clknet_2_2__leaf_clk
+ net36 _0514_ VDD VSS DFF_X1
Xerror_addr\[2\]$_SDFFE_PN0P_ _0012_ clknet_2_0__leaf_clk
+ net37 _0513_ VDD VSS DFF_X1
Xerror_addr\[3\]$_SDFFE_PN0P_ _0013_ clknet_2_0__leaf_clk
+ net38 _0512_ VDD VSS DFF_X1
Xerror_addr\[4\]$_SDFFE_PN0P_ _0014_ clknet_2_0__leaf_clk
+ net39 _0511_ VDD VSS DFF_X1
Xerror_count\[0\]$_SDFFE_PN0P_ _0015_ clknet_2_3__leaf_clk
+ net40 _0519_ VDD VSS DFF_X2
Xerror_count\[10\]$_SDFFE_PN0P_ _0016_ clknet_2_3__leaf_clk
+ net41 _0510_ VDD VSS DFF_X1
Xerror_count\[11\]$_SDFFE_PN0P_ _0017_ clknet_2_3__leaf_clk
+ net42 _0509_ VDD VSS DFF_X2
Xerror_count\[12\]$_SDFFE_PN0P_ _0018_ clknet_2_1__leaf_clk
+ net43 _0508_ VDD VSS DFF_X1
Xerror_count\[13\]$_SDFFE_PN0P_ _0019_ clknet_2_1__leaf_clk
+ net44 _0507_ VDD VSS DFF_X2
Xerror_count\[14\]$_SDFFE_PN0P_ _0020_ clknet_2_1__leaf_clk
+ net45 _0506_ VDD VSS DFF_X1
Xerror_count\[15\]$_SDFFE_PN0P_ _0021_ clknet_2_1__leaf_clk
+ net46 _0505_ VDD VSS DFF_X2
Xerror_count\[16\]$_SDFFE_PN0P_ _0022_ clknet_2_1__leaf_clk
+ net47 _0504_ VDD VSS DFF_X1
Xerror_count\[17\]$_SDFFE_PN0P_ _0023_ clknet_2_2__leaf_clk
+ net48 _0503_ VDD VSS DFF_X1
Xerror_count\[18\]$_SDFFE_PN0P_ _0024_ clknet_2_3__leaf_clk
+ net49 _0502_ VDD VSS DFF_X2
Xerror_count\[19\]$_SDFFE_PN0P_ _0025_ clknet_2_2__leaf_clk
+ net50 _0501_ VDD VSS DFF_X1
Xerror_count\[1\]$_SDFFE_PN0P_ _0026_ clknet_2_3__leaf_clk
+ net51 _0520_ VDD VSS DFF_X2
Xerror_count\[20\]$_SDFFE_PN0P_ _0027_ clknet_2_2__leaf_clk
+ net52 _0500_ VDD VSS DFF_X1
Xerror_count\[21\]$_SDFFE_PN0P_ _0028_ clknet_2_2__leaf_clk
+ net53 _0499_ VDD VSS DFF_X1
Xerror_count\[22\]$_SDFFE_PN0P_ _0029_ clknet_2_2__leaf_clk
+ net54 _0498_ VDD VSS DFF_X1
Xerror_count\[23\]$_SDFFE_PN0P_ _0030_ clknet_2_2__leaf_clk
+ net55 _0497_ VDD VSS DFF_X1
Xerror_count\[24\]$_SDFFE_PN0P_ _0031_ clknet_2_2__leaf_clk
+ net56 _0496_ VDD VSS DFF_X1
Xerror_count\[25\]$_SDFFE_PN0P_ _0032_ clknet_2_2__leaf_clk
+ net57 _0495_ VDD VSS DFF_X1
Xerror_count\[26\]$_SDFFE_PN0P_ _0033_ clknet_2_2__leaf_clk
+ net58 _0494_ VDD VSS DFF_X1
Xerror_count\[27\]$_SDFFE_PN0P_ _0034_ clknet_2_2__leaf_clk
+ net59 _0493_ VDD VSS DFF_X1
Xerror_count\[28\]$_SDFFE_PN0P_ _0035_ clknet_2_2__leaf_clk
+ net60 _0492_ VDD VSS DFF_X1
Xerror_count\[29\]$_SDFFE_PN0P_ _0036_ clknet_2_2__leaf_clk
+ net61 _0491_ VDD VSS DFF_X1
Xerror_count\[2\]$_SDFFE_PN0P_ _0037_ clknet_2_3__leaf_clk
+ net62 _0490_ VDD VSS DFF_X1
Xerror_count\[30\]$_SDFFE_PN0P_ _0038_ clknet_2_2__leaf_clk
+ net63 _0489_ VDD VSS DFF_X1
Xerror_count\[31\]$_SDFFE_PN0P_ _0039_ clknet_2_2__leaf_clk
+ net64 _0488_ VDD VSS DFF_X1
Xerror_count\[3\]$_SDFFE_PN0P_ _0040_ clknet_2_3__leaf_clk
+ net65 _0487_ VDD VSS DFF_X1
Xerror_count\[4\]$_SDFFE_PN0P_ _0041_ clknet_2_3__leaf_clk
+ net66 _0486_ VDD VSS DFF_X1
Xerror_count\[5\]$_SDFFE_PN0P_ _0042_ clknet_2_3__leaf_clk
+ net67 _0485_ VDD VSS DFF_X1
Xerror_count\[6\]$_SDFFE_PN0P_ _0043_ clknet_2_3__leaf_clk
+ net68 _0484_ VDD VSS DFF_X1
Xerror_count\[7\]$_SDFFE_PN0P_ _0044_ clknet_2_3__leaf_clk
+ net69 _0483_ VDD VSS DFF_X1
Xerror_count\[8\]$_SDFFE_PN0P_ _0045_ clknet_2_3__leaf_clk
+ net70 _0482_ VDD VSS DFF_X1
Xerror_count\[9\]$_SDFFE_PN0P_ _0046_ clknet_2_3__leaf_clk
+ net71 _0481_ VDD VSS DFF_X1
Xphase_complete$_SDFFE_PN0P_ _0047_ clknet_2_0__leaf_clk phase_complete
+ _0001_ VDD VSS DFF_X1
Xread_phase$_SDFFE_PN0P_ _0048_ clknet_2_1__leaf_clk read_phase
+ _0000_ VDD VSS DFF_X1
Xstate\[0\]$_SDFFE_PN0P_ _0049_ clknet_2_1__leaf_clk state\[0\]
+ _0480_ VDD VSS DFF_X1
Xstate\[1\]$_SDFFE_PN0P_ _0050_ clknet_2_1__leaf_clk state\[1\]
+ _0479_ VDD VSS DFF_X1
Xstate\[2\]$_SDFFE_PN0P_ _0051_ clknet_2_1__leaf_clk state\[2\]
+ _0478_ VDD VSS DFF_X1
Xstate\[3\]$_SDFFE_PN0P_ _0052_ clknet_2_0__leaf_clk state\[3\]
+ _0477_ VDD VSS DFF_X1
Xwrite_phase$_SDFFE_PN0P_ _0053_ clknet_2_0__leaf_clk net110
+ _0476_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_55 VDD VSS TAPCELL_X1
Xinput1 mem_rdata[0] net1 VDD VSS BUF_X1
Xinput2 mem_rdata[10] net2 VDD VSS BUF_X1
Xinput3 mem_rdata[11] net3 VDD VSS BUF_X1
Xinput4 mem_rdata[12] net4 VDD VSS BUF_X1
Xinput5 mem_rdata[13] net5 VDD VSS BUF_X1
Xinput6 mem_rdata[14] net6 VDD VSS BUF_X1
Xinput7 mem_rdata[15] net7 VDD VSS BUF_X1
Xinput8 mem_rdata[16] net8 VDD VSS BUF_X1
Xinput9 mem_rdata[17] net9 VDD VSS BUF_X1
Xinput10 mem_rdata[18] net10 VDD VSS BUF_X1
Xinput11 mem_rdata[19] net11 VDD VSS BUF_X1
Xinput12 mem_rdata[1] net12 VDD VSS BUF_X1
Xinput13 mem_rdata[20] net13 VDD VSS BUF_X1
Xinput14 mem_rdata[21] net14 VDD VSS BUF_X1
Xinput15 mem_rdata[22] net15 VDD VSS BUF_X1
Xinput16 mem_rdata[23] net16 VDD VSS BUF_X1
Xinput17 mem_rdata[24] net17 VDD VSS BUF_X1
Xinput18 mem_rdata[25] net18 VDD VSS BUF_X1
Xinput19 mem_rdata[26] net19 VDD VSS BUF_X1
Xinput20 mem_rdata[27] net20 VDD VSS BUF_X1
Xinput21 mem_rdata[28] net21 VDD VSS BUF_X1
Xinput22 mem_rdata[29] net22 VDD VSS BUF_X1
Xinput23 mem_rdata[2] net23 VDD VSS BUF_X1
Xinput24 mem_rdata[30] net24 VDD VSS BUF_X1
Xinput25 mem_rdata[31] net25 VDD VSS BUF_X1
Xinput26 mem_rdata[3] net26 VDD VSS BUF_X1
Xinput27 mem_rdata[4] net27 VDD VSS BUF_X1
Xinput28 mem_rdata[5] net28 VDD VSS BUF_X1
Xinput29 mem_rdata[6] net29 VDD VSS BUF_X1
Xinput30 mem_rdata[7] net30 VDD VSS BUF_X1
Xinput31 mem_rdata[8] net31 VDD VSS BUF_X1
Xinput32 mem_rdata[9] net32 VDD VSS BUF_X1
Xoutput33 net33 bist_done VDD VSS BUF_X1
Xoutput34 net34 bist_pass VDD VSS BUF_X1
Xoutput35 net35 error_addr[0] VDD VSS BUF_X1
Xoutput36 net36 error_addr[1] VDD VSS BUF_X1
Xoutput37 net37 error_addr[2] VDD VSS BUF_X1
Xoutput38 net38 error_addr[3] VDD VSS BUF_X1
Xoutput39 net39 error_addr[4] VDD VSS BUF_X1
Xoutput40 net40 error_count[0] VDD VSS BUF_X1
Xoutput41 net41 error_count[10] VDD VSS BUF_X1
Xoutput42 net42 error_count[11] VDD VSS BUF_X1
Xoutput43 net43 error_count[12] VDD VSS BUF_X1
Xoutput44 net44 error_count[13] VDD VSS BUF_X1
Xoutput45 net45 error_count[14] VDD VSS BUF_X1
Xoutput46 net46 error_count[15] VDD VSS BUF_X1
Xoutput47 net47 error_count[16] VDD VSS BUF_X1
Xoutput48 net48 error_count[17] VDD VSS BUF_X1
Xoutput49 net49 error_count[18] VDD VSS BUF_X1
Xoutput50 net50 error_count[19] VDD VSS BUF_X1
Xoutput51 net51 error_count[1] VDD VSS BUF_X1
Xoutput52 net52 error_count[20] VDD VSS BUF_X1
Xoutput53 net53 error_count[21] VDD VSS BUF_X1
Xoutput54 net54 error_count[22] VDD VSS BUF_X1
Xoutput55 net55 error_count[23] VDD VSS BUF_X1
Xoutput56 net56 error_count[24] VDD VSS BUF_X1
Xoutput57 net57 error_count[25] VDD VSS BUF_X1
Xoutput58 net58 error_count[26] VDD VSS BUF_X1
Xoutput59 net59 error_count[27] VDD VSS BUF_X1
Xoutput60 net60 error_count[28] VDD VSS BUF_X1
Xoutput61 net61 error_count[29] VDD VSS BUF_X1
Xoutput62 net62 error_count[2] VDD VSS BUF_X1
Xoutput63 net63 error_count[30] VDD VSS BUF_X1
Xoutput64 net64 error_count[31] VDD VSS BUF_X1
Xoutput65 net65 error_count[3] VDD VSS BUF_X1
Xoutput66 net66 error_count[4] VDD VSS BUF_X1
Xoutput67 net67 error_count[5] VDD VSS BUF_X1
Xoutput68 net68 error_count[6] VDD VSS BUF_X1
Xoutput69 net69 error_count[7] VDD VSS BUF_X1
Xoutput70 net70 error_count[8] VDD VSS BUF_X1
Xoutput71 net71 error_count[9] VDD VSS BUF_X1
Xoutput72 net72 mem_addr[0] VDD VSS BUF_X1
Xoutput73 net73 mem_addr[1] VDD VSS BUF_X1
Xoutput74 net74 mem_addr[2] VDD VSS BUF_X1
Xoutput75 net75 mem_addr[3] VDD VSS BUF_X1
Xoutput76 net76 mem_addr[4] VDD VSS BUF_X1
Xoutput77 net77 mem_enable VDD VSS BUF_X1
Xoutput78 net78 mem_wdata[0] VDD VSS BUF_X1
Xoutput79 net79 mem_wdata[10] VDD VSS BUF_X1
Xoutput80 net80 mem_wdata[11] VDD VSS BUF_X1
Xoutput81 net81 mem_wdata[12] VDD VSS BUF_X1
Xoutput82 net82 mem_wdata[13] VDD VSS BUF_X1
Xoutput83 net83 mem_wdata[14] VDD VSS BUF_X1
Xoutput84 net84 mem_wdata[15] VDD VSS BUF_X1
Xoutput85 net85 mem_wdata[16] VDD VSS BUF_X1
Xoutput86 net86 mem_wdata[17] VDD VSS BUF_X1
Xoutput87 net87 mem_wdata[18] VDD VSS BUF_X1
Xoutput88 net88 mem_wdata[19] VDD VSS BUF_X1
Xoutput89 net89 mem_wdata[1] VDD VSS BUF_X1
Xoutput90 net90 mem_wdata[20] VDD VSS BUF_X1
Xoutput91 net91 mem_wdata[21] VDD VSS BUF_X1
Xoutput92 net92 mem_wdata[22] VDD VSS BUF_X1
Xoutput93 net93 mem_wdata[23] VDD VSS BUF_X1
Xoutput94 net94 mem_wdata[24] VDD VSS BUF_X1
Xoutput95 net95 mem_wdata[25] VDD VSS BUF_X1
Xoutput96 net96 mem_wdata[26] VDD VSS BUF_X1
Xoutput97 net97 mem_wdata[27] VDD VSS BUF_X1
Xoutput98 net98 mem_wdata[28] VDD VSS BUF_X1
Xoutput99 net99 mem_wdata[29] VDD VSS BUF_X1
Xoutput100 net100 mem_wdata[2] VDD VSS BUF_X1
Xoutput101 net101 mem_wdata[30] VDD VSS BUF_X1
Xoutput102 net102 mem_wdata[31] VDD VSS BUF_X1
Xoutput103 net103 mem_wdata[3] VDD VSS BUF_X1
Xoutput104 net104 mem_wdata[4] VDD VSS BUF_X1
Xoutput105 net105 mem_wdata[5] VDD VSS BUF_X1
Xoutput106 net106 mem_wdata[6] VDD VSS BUF_X1
Xoutput107 net107 mem_wdata[7] VDD VSS BUF_X1
Xoutput108 net108 mem_wdata[8] VDD VSS BUF_X1
Xoutput109 net109 mem_wdata[9] VDD VSS BUF_X1
Xoutput110 net110 mem_write VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_2_0__f_clk clknet_0_clk clknet_2_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_2_1__f_clk clknet_0_clk clknet_2_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_2_2__f_clk clknet_0_clk clknet_2_2__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_2_3__f_clk clknet_0_clk clknet_2_3__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_2_0__leaf_clk _unconnected_0 VDD VSS CLKBUF_X1
Xclkload1 clknet_2_1__leaf_clk _unconnected_1 VDD VSS INV_X4
Xclkload2 clknet_2_3__leaf_clk _unconnected_2 VDD VSS INV_X1
.ENDS bist_controller
