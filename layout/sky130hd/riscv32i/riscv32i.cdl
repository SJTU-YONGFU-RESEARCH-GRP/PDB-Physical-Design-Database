* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT riscv aluout[0] aluout[10] aluout[11] aluout[12] aluout[13]
+ aluout[14] aluout[15] aluout[16] aluout[17] aluout[18] aluout[19]
+ aluout[1] aluout[20] aluout[21] aluout[22] aluout[23] aluout[24]
+ aluout[25] aluout[26] aluout[27] aluout[28] aluout[29] aluout[2]
+ aluout[30] aluout[31] aluout[3] aluout[4] aluout[5] aluout[6]
+ aluout[7] aluout[8] aluout[9] clk instr[0] instr[10] instr[11]
+ instr[12] instr[13] instr[14] instr[15] instr[16] instr[17]
+ instr[18] instr[19] instr[1] instr[20] instr[21] instr[22]
+ instr[23] instr[24] instr[25] instr[26] instr[27] instr[28]
+ instr[29] instr[2] instr[30] instr[31] instr[3] instr[4] instr[5]
+ instr[6] instr[7] instr[8] instr[9] memread memwrite pc[0]
+ pc[10] pc[11] pc[12] pc[13] pc[14] pc[15] pc[16] pc[17] pc[18]
+ pc[19] pc[1] pc[20] pc[21] pc[22] pc[23] pc[24] pc[25] pc[26]
+ pc[27] pc[28] pc[29] pc[2] pc[30] pc[31] pc[3] pc[4] pc[5]
+ pc[6] pc[7] pc[8] pc[9] readdata[0] readdata[10] readdata[11]
+ readdata[12] readdata[13] readdata[14] readdata[15] readdata[16]
+ readdata[17] readdata[18] readdata[19] readdata[1] readdata[20]
+ readdata[21] readdata[22] readdata[23] readdata[24] readdata[25]
+ readdata[26] readdata[27] readdata[28] readdata[29] readdata[2]
+ readdata[30] readdata[31] readdata[3] readdata[4] readdata[5]
+ readdata[6] readdata[7] readdata[8] readdata[9] reset suspend
+ writedata[0] writedata[10] writedata[11] writedata[12] writedata[13]
+ writedata[14] writedata[15] writedata[16] writedata[17] writedata[18]
+ writedata[19] writedata[1] writedata[20] writedata[21] writedata[22]
+ writedata[23] writedata[24] writedata[25] writedata[26] writedata[27]
+ writedata[28] writedata[29] writedata[2] writedata[30] writedata[31]
+ writedata[3] writedata[4] writedata[5] writedata[6] writedata[7]
+ writedata[8] writedata[9]
XTAP_TAPCELL_ROW_26_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3654_ net29 VSS VSS VDD VDD _0035_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_26_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3656_ net27 net28 VSS VSS VDD VDD _0037_ sky130_fd_sc_hd__nand2b_2
XTAP_TAPCELL_ROW_26_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3660_ net26 net23 net1 net12 VSS VSS VDD VDD _0041_ sky130_fd_sc_hd__and4bb_4
X_3661_ _0037_ _0041_ VSS VSS VDD VDD _0042_ sky130_fd_sc_hd__nor2b_4
XTAP_TAPCELL_ROW_26_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3663_ _0035_ _0042_ VSS VSS VDD VDD net99 sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_26_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3666_ net17 net15 VSS VSS VDD VDD _0046_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_26_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3671_ dp.rf.rf\[1\]\[0\] net212 VSS VSS VDD VDD _0051_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3674_ net274 net16 VSS VSS VDD VDD _0054_ sky130_fd_sc_hd__nor2_8
X_3675_ _0051_ _0054_ VSS VSS VDD VDD _0055_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_25_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3677_ net274 VSS VSS VDD VDD _0057_ sky130_fd_sc_hd__clkinvlp_4
X_3678_ dp.rf.rf\[2\]\[0\] dp.rf.rf\[3\]\[0\] dp.rf.rf\[10\]\[0\]
+ dp.rf.rf\[11\]\[0\] net212 net16 VSS VSS VDD VDD _0058_ sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_25_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3680_ dp.rf.rf\[8\]\[0\] dp.rf.rf\[9\]\[0\] net212 VSS VSS
+ VDD VDD _0060_ sky130_fd_sc_hd__mux2i_1
X_3681_ net274 net16 VSS VSS VDD VDD _0061_ sky130_fd_sc_hd__nor2b_4
X_3682_ _0057_ _0058_ _0060_ _0061_ VSS VSS VDD VDD _0062_
+ sky130_fd_sc_hd__a2bb2oi_2
X_3683_ _0046_ _0055_ _0062_ VSS VSS VDD VDD _0063_ sky130_fd_sc_hd__and3_4
X_3684_ net17 net15 VSS VSS VDD VDD _0064_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_25_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3686_ net274 net16 VSS VSS VDD VDD _0066_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_25_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3691_ dp.rf.rf\[14\]\[0\] dp.rf.rf\[15\]\[0\] net212 VSS
+ VSS VDD VDD _0071_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_25_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3694_ dp.rf.rf\[12\]\[0\] dp.rf.rf\[13\]\[0\] net212 VSS
+ VSS VDD VDD _0074_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_25_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3696_ _0066_ _0071_ _0074_ _0061_ VSS VSS VDD VDD _0076_
+ sky130_fd_sc_hd__a22oi_1
X_3697_ dp.rf.rf\[4\]\[0\] dp.rf.rf\[5\]\[0\] net212 VSS VSS
+ VDD VDD _0077_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_25_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3700_ dp.rf.rf\[6\]\[0\] dp.rf.rf\[7\]\[0\] net212 VSS VSS
+ VDD VDD _0080_ sky130_fd_sc_hd__mux2i_1
X_3701_ net16 net274 VSS VSS VDD VDD _0081_ sky130_fd_sc_hd__nor2b_4
XTAP_TAPCELL_ROW_24_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3703_ _0054_ _0077_ _0080_ _0081_ VSS VSS VDD VDD _0083_
+ sky130_fd_sc_hd__a22oi_1
X_3704_ _0076_ _0083_ VSS VSS VDD VDD _0084_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_24_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3706_ net17 VSS VSS VDD VDD _0086_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_24_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3708_ _0086_ net15 VSS VSS VDD VDD _0088_ sky130_fd_sc_hd__nor2_4
X_3709_ dp.rf.rf\[26\]\[0\] dp.rf.rf\[27\]\[0\] net212 VSS
+ VSS VDD VDD _0089_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_24_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3712_ dp.rf.rf\[24\]\[0\] dp.rf.rf\[25\]\[0\] net212 VSS
+ VSS VDD VDD _0092_ sky130_fd_sc_hd__mux2i_1
X_3713_ _0066_ _0089_ _0092_ _0061_ VSS VSS VDD VDD _0093_
+ sky130_fd_sc_hd__a22oi_1
X_3714_ dp.rf.rf\[18\]\[0\] dp.rf.rf\[19\]\[0\] net212 VSS
+ VSS VDD VDD _0094_ sky130_fd_sc_hd__mux2i_1
X_3715_ dp.rf.rf\[16\]\[0\] dp.rf.rf\[17\]\[0\] net212 VSS
+ VSS VDD VDD _0095_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_24_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3717_ _0081_ _0094_ _0095_ _0054_ VSS VSS VDD VDD _0097_
+ sky130_fd_sc_hd__a22oi_1
X_3718_ _0088_ _0093_ _0097_ VSS VSS VDD VDD _0098_ sky130_fd_sc_hd__nand3_1
X_3719_ _0064_ _0084_ _0098_ VSS VSS VDD VDD _0099_ sky130_fd_sc_hd__o21ai_2
X_3720_ dp.rf.rf\[20\]\[0\] dp.rf.rf\[21\]\[0\] dp.rf.rf\[22\]\[0\]
+ dp.rf.rf\[23\]\[0\] net212 net274 VSS VSS VDD VDD _0100_ sky130_fd_sc_hd__mux4_2
X_3721_ net17 net15 VSS VSS VDD VDD _0101_ sky130_fd_sc_hd__nand2_2
X_3722_ net16 _0101_ VSS VSS VDD VDD _0102_ sky130_fd_sc_hd__nor2_4
X_3723_ net16 VSS VSS VDD VDD _0103_ sky130_fd_sc_hd__clkinv_16
X_3724_ _0103_ _0101_ VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__nor2_4
X_3725_ dp.rf.rf\[28\]\[0\] dp.rf.rf\[29\]\[0\] dp.rf.rf\[30\]\[0\]
+ dp.rf.rf\[31\]\[0\] net212 net274 VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__mux4_2
X_3726_ _0100_ _0102_ _0104_ _0105_ VSS VSS VDD VDD _0106_
+ sky130_fd_sc_hd__a22o_1
X_3727_ _0063_ _0099_ _0106_ VSS VSS VDD VDD net133 sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_24_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3729_ _0035_ _0041_ VSS VSS VDD VDD _0108_ sky130_fd_sc_hd__nand2_4
X_3730_ net4 net5 VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__nor2_2
X_3731_ net28 net24 _0109_ VSS VSS VDD VDD _0110_ sky130_fd_sc_hd__nand3_1
X_3732_ net28 net24 VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__nand2_1
X_3733_ net5 _0111_ VSS VSS VDD VDD _0112_ sky130_fd_sc_hd__nand2_1
X_3734_ _0108_ _0110_ _0112_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__o21ai_0
X_3735_ net5 _0108_ _0113_ net27 VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__a22oi_1
X_3736_ net1 net12 net23 VSS VSS VDD VDD _0115_ sky130_fd_sc_hd__and3_4
XTAP_TAPCELL_ROW_24_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3738_ net26 net29 net27 VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__nor3b_4
XTAP_TAPCELL_ROW_24_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3740_ _0115_ _0117_ VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__nand2_8
X_3741_ net29 _0042_ VSS VSS VDD VDD _0120_ sky130_fd_sc_hd__nand2_8
X_3742_ _0119_ _0120_ VSS VSS VDD VDD _0121_ sky130_fd_sc_hd__nand2_4
X_3743_ net6 _0114_ _0121_ VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_24_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3746_ net28 net29 _0037_ VSS VSS VDD VDD _0125_ sky130_fd_sc_hd__o21ai_2
X_3747_ net1 net12 net23 VSS VSS VDD VDD _0126_ sky130_fd_sc_hd__nand3_4
X_3748_ net28 net29 VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__nand2_1
X_3749_ net27 _0126_ _0127_ VSS VSS VDD VDD _0128_ sky130_fd_sc_hd__nor3_4
X_3750_ net26 net29 net27 VSS VSS VDD VDD _0129_ sky130_fd_sc_hd__or3b_4
X_3751_ _0126_ _0129_ VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__nor2_8
XTAP_TAPCELL_ROW_24_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3753_ _0041_ _0125_ net202 _0130_ VSS VSS VDD VDD _0132_
+ sky130_fd_sc_hd__a211oi_4
X_3754_ net26 _0128_ VSS VSS VDD VDD _0133_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_24_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3757_ net29 net30 VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__nor2b_1
X_3758_ net13 _0136_ _0042_ VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__mux2i_2
X_3759_ _0130_ _0133_ _0137_ VSS VSS VDD VDD _3530_ sky130_fd_sc_hd__nor3_4
X_3760_ _0041_ _0125_ net202 _0130_ VSS VSS VDD VDD _0138_
+ sky130_fd_sc_hd__a211o_4
X_3761_ _0106_ _0063_ _0138_ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__or3_4
X_3762_ net179 _3530_ _0139_ _0099_ VSS VSS VDD VDD _0140_
+ sky130_fd_sc_hd__o22a_4
XTAP_TAPCELL_ROW_23_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3766_ _0122_ _0140_ VSS VSS VDD VDD _3276_ sky130_fd_sc_hd__xnor2_1
X_3767_ _3276_ VSS VSS VDD VDD _3280_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_23_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3769_ net10 VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__inv_8
XTAP_TAPCELL_ROW_23_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3772_ net208 VSS VSS VDD VDD _0148_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_23_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3781_ dp.rf.rf\[16\]\[0\] dp.rf.rf\[17\]\[0\] dp.rf.rf\[18\]\[0\]
+ dp.rf.rf\[19\]\[0\] net209 net8 VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__mux4_1
X_3782_ _0148_ _0157_ VSS VSS VDD VDD _0158_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_22_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3787_ dp.rf.rf\[20\]\[0\] dp.rf.rf\[21\]\[0\] dp.rf.rf\[22\]\[0\]
+ dp.rf.rf\[23\]\[0\] net209 net8 VSS VSS VDD VDD _0163_ sky130_fd_sc_hd__mux4_1
X_3788_ net206 _0163_ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_22_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3790_ net11 _0119_ VSS VSS VDD VDD _0166_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_22_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3792_ _0145_ _0158_ _0164_ _0166_ VSS VSS VDD VDD _0168_
+ sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_22_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3794_ net211 net8 VSS VSS VDD VDD _0170_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_22_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3796_ _0119_ _0170_ dp.rf.rf\[24\]\[0\] VSS VSS VDD VDD
+ _0172_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_22_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3800_ _0126_ _0129_ net210 VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_21_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3805_ dp.rf.rf\[26\]\[0\] dp.rf.rf\[27\]\[0\] net209 VSS
+ VSS VDD VDD _0181_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_21_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3809_ net8 _0181_ net206 VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__a21oi_1
X_3810_ dp.rf.rf\[25\]\[0\] net8 _0176_ _0185_ VSS VSS VDD
+ VDD _0186_ sky130_fd_sc_hd__o31ai_1
XTAP_TAPCELL_ROW_21_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3814_ dp.rf.rf\[28\]\[0\] dp.rf.rf\[29\]\[0\] dp.rf.rf\[30\]\[0\]
+ dp.rf.rf\[31\]\[0\] net209 net8 VSS VSS VDD VDD _0190_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_21_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3816_ _0126_ _0129_ net10 VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_21_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3818_ net206 _0190_ net199 VSS VSS VDD VDD _0194_ sky130_fd_sc_hd__a21oi_1
X_3819_ _0172_ _0186_ _0194_ VSS VSS VDD VDD _0195_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_21_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3825_ dp.rf.rf\[2\]\[0\] dp.rf.rf\[3\]\[0\] dp.rf.rf\[6\]\[0\]
+ dp.rf.rf\[7\]\[0\] net209 net206 VSS VSS VDD VDD _0201_ sky130_fd_sc_hd__mux4_1
X_3826_ _0126_ _0129_ _0145_ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_20_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3829_ _0201_ net196 VSS VSS VDD VDD _0205_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_20_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3831_ dp.rf.rf\[0\]\[0\] dp.rf.rf\[1\]\[0\] dp.rf.rf\[4\]\[0\]
+ dp.rf.rf\[5\]\[0\] net209 net206 VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__mux4_1
X_3832_ net210 net8 net208 net10 VSS VSS VDD VDD _0208_ sky130_fd_sc_hd__nor4_2
X_3833_ _0115_ _0117_ _0208_ net11 VSS VSS VDD VDD _0209_
+ sky130_fd_sc_hd__a211oi_4
X_3834_ net8 net10 _0207_ net194 VSS VSS VDD VDD _0210_ sky130_fd_sc_hd__o31ai_2
X_3835_ net8 _0205_ _0210_ VSS VSS VDD VDD _0211_ sky130_fd_sc_hd__a21oi_2
X_3836_ _0126_ _0129_ net8 VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_20_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3841_ net209 dp.rf.rf\[14\]\[0\] VSS VSS VDD VDD _0217_
+ sky130_fd_sc_hd__nor2b_1
X_3842_ dp.rf.rf\[15\]\[0\] net209 _0148_ _0217_ VSS VSS VDD
+ VDD _0218_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_20_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3845_ _0115_ _0117_ _0148_ VSS VSS VDD VDD _0221_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_19_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3847_ net268 net209 _0176_ net269 _0221_ VSS VSS VDD VDD
+ _0223_ sky130_fd_sc_hd__a221oi_2
X_3848_ net8 VSS VSS VDD VDD _0224_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_19_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3852_ dp.rf.rf\[8\]\[0\] dp.rf.rf\[9\]\[0\] dp.rf.rf\[12\]\[0\]
+ dp.rf.rf\[13\]\[0\] net209 net206 VSS VSS VDD VDD _0228_ sky130_fd_sc_hd__mux4_1
X_3853_ net205 _0228_ net199 VSS VSS VDD VDD _0229_ sky130_fd_sc_hd__a21oi_1
X_3854_ _0212_ _0218_ _0223_ _0229_ VSS VSS VDD VDD _0230_
+ sky130_fd_sc_hd__o31ai_2
X_3855_ _0168_ _0195_ _0230_ _0211_ VSS VSS VDD VDD _3279_
+ sky130_fd_sc_hd__a22oi_4
X_3856_ net11 VSS VSS VDD VDD _0231_ sky130_fd_sc_hd__inv_6
X_3857_ _0115_ _0117_ _0231_ VSS VSS VDD VDD _0232_ sky130_fd_sc_hd__a21oi_4
X_3858_ _0119_ _0170_ dp.rf.rf\[24\]\[31\] VSS VSS VDD VDD
+ _0233_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_19_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3862_ dp.rf.rf\[26\]\[31\] dp.rf.rf\[27\]\[31\] net211 VSS
+ VSS VDD VDD _0237_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_19_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3865_ net8 _0237_ net207 VSS VSS VDD VDD _0240_ sky130_fd_sc_hd__a21oi_1
X_3866_ dp.rf.rf\[25\]\[31\] net8 net201 _0240_ VSS VSS VDD
+ VDD _0241_ sky130_fd_sc_hd__o31ai_1
X_3867_ dp.rf.rf\[28\]\[31\] dp.rf.rf\[29\]\[31\] dp.rf.rf\[30\]\[31\]
+ dp.rf.rf\[31\]\[31\] net211 net8 VSS VSS VDD VDD _0242_ sky130_fd_sc_hd__mux4_1
X_3868_ net207 _0242_ net198 VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__a21oi_1
X_3869_ _0233_ _0241_ _0243_ VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__o21ai_1
X_3870_ net211 VSS VSS VDD VDD _0245_ sky130_fd_sc_hd__clkinv_16
X_3871_ dp.rf.rf\[17\]\[31\] dp.rf.rf\[19\]\[31\] net8 VSS
+ VSS VDD VDD _0246_ sky130_fd_sc_hd__mux2_1
X_3872_ net211 net8 VSS VSS VDD VDD _0247_ sky130_fd_sc_hd__nand2b_4
X_3873_ _0245_ _0246_ _0247_ dp.rf.rf\[18\]\[31\] _0148_ VSS
+ VSS VDD VDD _0248_ sky130_fd_sc_hd__o221a_1
X_3874_ net196 _0248_ VSS VSS VDD VDD _0249_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_19_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3876_ _0245_ net205 _0145_ VSS VSS VDD VDD _0251_ sky130_fd_sc_hd__nand3_1
X_3877_ _0119_ _0251_ dp.rf.rf\[16\]\[31\] VSS VSS VDD VDD
+ _0252_ sky130_fd_sc_hd__a21oi_1
X_3878_ dp.rf.rf\[20\]\[31\] dp.rf.rf\[21\]\[31\] dp.rf.rf\[22\]\[31\]
+ dp.rf.rf\[23\]\[31\] net211 net8 VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__mux4_1
X_3879_ net190 _0253_ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__nand2_1
X_3880_ _0249_ _0252_ _0254_ VSS VSS VDD VDD _0255_ sky130_fd_sc_hd__o21ai_1
X_3881_ _0115_ _0117_ _0145_ VSS VSS VDD VDD _0256_ sky130_fd_sc_hd__a21oi_4
X_3882_ dp.rf.rf\[10\]\[31\] dp.rf.rf\[11\]\[31\] dp.rf.rf\[14\]\[31\]
+ dp.rf.rf\[15\]\[31\] net211 net207 VSS VSS VDD VDD _0257_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_19_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3884_ dp.rf.rf\[8\]\[31\] dp.rf.rf\[9\]\[31\] dp.rf.rf\[12\]\[31\]
+ dp.rf.rf\[13\]\[31\] net211 net207 VSS VSS VDD VDD _0259_
+ sky130_fd_sc_hd__mux4_1
X_3885_ _0257_ _0259_ _0224_ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__mux2i_2
X_3886_ dp.rf.rf\[2\]\[31\] dp.rf.rf\[3\]\[31\] dp.rf.rf\[6\]\[31\]
+ dp.rf.rf\[7\]\[31\] net211 net207 VSS VSS VDD VDD _0261_ sky130_fd_sc_hd__mux4_1
X_3887_ dp.rf.rf\[4\]\[31\] VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__inv_1
X_3888_ net211 net208 VSS VSS VDD VDD _0263_ sky130_fd_sc_hd__nor2b_4
XTAP_TAPCELL_ROW_19_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3891_ dp.rf.rf\[1\]\[31\] dp.rf.rf\[5\]\[31\] net207 VSS
+ VSS VDD VDD _0266_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_18_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3894_ _0262_ net203 _0266_ net211 net8 VSS VSS VDD VDD _0269_
+ sky130_fd_sc_hd__a221oi_1
X_3895_ net8 _0261_ _0269_ net196 VSS VSS VDD VDD _0270_ sky130_fd_sc_hd__a211oi_1
X_3896_ net11 _0130_ _0208_ VSS VSS VDD VDD _0271_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_18_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3898_ net185 _0260_ _0270_ _0271_ VSS VSS VDD VDD _0273_
+ sky130_fd_sc_hd__a211oi_2
X_3899_ net187 _0244_ _0255_ _0273_ VSS VSS VDD VDD _0274_
+ sky130_fd_sc_hd__a31oi_4
XTAP_TAPCELL_ROW_18_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3906_ dp.rf.rf\[24\]\[31\] dp.rf.rf\[25\]\[31\] dp.rf.rf\[26\]\[31\]
+ dp.rf.rf\[27\]\[31\] net213 net274 VSS VSS VDD VDD _0280_
+ sky130_fd_sc_hd__mux4_1
X_3907_ dp.rf.rf\[16\]\[31\] dp.rf.rf\[17\]\[31\] dp.rf.rf\[18\]\[31\]
+ dp.rf.rf\[19\]\[31\] net212 net274 VSS VSS VDD VDD _0281_
+ sky130_fd_sc_hd__mux4_1
X_3908_ dp.rf.rf\[28\]\[31\] dp.rf.rf\[29\]\[31\] dp.rf.rf\[30\]\[31\]
+ dp.rf.rf\[31\]\[31\] net213 net274 VSS VSS VDD VDD _0282_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_18_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3910_ dp.rf.rf\[20\]\[31\] dp.rf.rf\[21\]\[31\] dp.rf.rf\[22\]\[31\]
+ dp.rf.rf\[23\]\[31\] net213 net274 VSS VSS VDD VDD _0284_
+ sky130_fd_sc_hd__mux4_1
X_3911_ _0280_ _0281_ _0282_ _0284_ _0103_ net15 VSS VSS VDD
+ VDD _0285_ sky130_fd_sc_hd__mux4_1
X_3912_ net15 VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__clkinv_16
XTAP_TAPCELL_ROW_18_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3915_ net274 net212 net16 VSS VSS VDD VDD _0289_ sky130_fd_sc_hd__nor3_4
X_3916_ _0286_ _0289_ net17 VSS VSS VDD VDD _0290_ sky130_fd_sc_hd__a21oi_4
X_3917_ dp.rf.rf\[8\]\[31\] dp.rf.rf\[9\]\[31\] dp.rf.rf\[10\]\[31\]
+ dp.rf.rf\[11\]\[31\] net213 net274 VSS VSS VDD VDD _0291_
+ sky130_fd_sc_hd__mux4_1
X_3918_ dp.rf.rf\[0\]\[31\] dp.rf.rf\[1\]\[31\] dp.rf.rf\[2\]\[31\]
+ dp.rf.rf\[3\]\[31\] net213 net274 VSS VSS VDD VDD _0292_ sky130_fd_sc_hd__mux4_1
X_3919_ dp.rf.rf\[12\]\[31\] dp.rf.rf\[13\]\[31\] dp.rf.rf\[14\]\[31\]
+ dp.rf.rf\[15\]\[31\] net213 net274 VSS VSS VDD VDD _0293_
+ sky130_fd_sc_hd__mux4_1
X_3920_ dp.rf.rf\[4\]\[31\] dp.rf.rf\[5\]\[31\] dp.rf.rf\[6\]\[31\]
+ dp.rf.rf\[7\]\[31\] net213 net274 VSS VSS VDD VDD _0294_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_18_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3923_ _0291_ _0292_ _0293_ _0294_ _0103_ net15 VSS VSS VDD
+ VDD _0297_ sky130_fd_sc_hd__mux4_2
X_3924_ net17 _0285_ _0290_ _0297_ VSS VSS VDD VDD _0298_
+ sky130_fd_sc_hd__a22oi_4
X_3925_ net179 _0298_ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__nand2_1
X_3926_ net25 net179 _0299_ VSS VSS VDD VDD _0300_ sky130_fd_sc_hd__o21ai_1
X_3927_ _0122_ _0300_ VSS VSS VDD VDD _3283_ sky130_fd_sc_hd__xor2_1
X_3928_ _3283_ VSS VSS VDD VDD _3287_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_17_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3932_ net25 _0119_ VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_17_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3937_ net24 _0130_ VSS VSS VDD VDD _0309_ sky130_fd_sc_hd__nand2_1
X_3938_ _0304_ _0309_ VSS VSS VDD VDD _3649_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_17_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3940_ _0046_ _0289_ VSS VSS VDD VDD _0311_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_17_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3942_ dp.rf.rf\[24\]\[30\] dp.rf.rf\[25\]\[30\] dp.rf.rf\[26\]\[30\]
+ dp.rf.rf\[27\]\[30\] net212 net274 VSS VSS VDD VDD _0313_
+ sky130_fd_sc_hd__mux4_1
X_3943_ dp.rf.rf\[16\]\[30\] dp.rf.rf\[17\]\[30\] dp.rf.rf\[18\]\[30\]
+ dp.rf.rf\[19\]\[30\] net212 net274 VSS VSS VDD VDD _0314_
+ sky130_fd_sc_hd__mux4_1
X_3944_ dp.rf.rf\[28\]\[30\] dp.rf.rf\[29\]\[30\] dp.rf.rf\[30\]\[30\]
+ dp.rf.rf\[31\]\[30\] net212 net274 VSS VSS VDD VDD _0315_
+ sky130_fd_sc_hd__mux4_1
X_3945_ dp.rf.rf\[20\]\[30\] dp.rf.rf\[21\]\[30\] dp.rf.rf\[22\]\[30\]
+ dp.rf.rf\[23\]\[30\] net212 net274 VSS VSS VDD VDD _0316_
+ sky130_fd_sc_hd__mux4_1
X_3946_ _0313_ _0314_ _0315_ _0316_ _0103_ net15 VSS VSS VDD
+ VDD _0317_ sky130_fd_sc_hd__mux4_1
X_3947_ dp.rf.rf\[8\]\[30\] dp.rf.rf\[9\]\[30\] dp.rf.rf\[10\]\[30\]
+ dp.rf.rf\[11\]\[30\] net213 net274 VSS VSS VDD VDD _0318_
+ sky130_fd_sc_hd__mux4_1
X_3948_ dp.rf.rf\[0\]\[30\] dp.rf.rf\[1\]\[30\] dp.rf.rf\[2\]\[30\]
+ dp.rf.rf\[3\]\[30\] net213 net274 VSS VSS VDD VDD _0319_ sky130_fd_sc_hd__mux4_1
X_3949_ dp.rf.rf\[12\]\[30\] dp.rf.rf\[13\]\[30\] dp.rf.rf\[14\]\[30\]
+ dp.rf.rf\[15\]\[30\] net213 net274 VSS VSS VDD VDD _0320_
+ sky130_fd_sc_hd__mux4_1
X_3950_ dp.rf.rf\[4\]\[30\] dp.rf.rf\[5\]\[30\] dp.rf.rf\[6\]\[30\]
+ dp.rf.rf\[7\]\[30\] net213 net274 VSS VSS VDD VDD _0321_ sky130_fd_sc_hd__mux4_1
X_3951_ _0318_ _0319_ _0320_ _0321_ _0103_ net15 VSS VSS VDD
+ VDD _0322_ sky130_fd_sc_hd__mux4_1
X_3952_ _0317_ _0322_ _0086_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__mux2_1
X_3953_ _0311_ _0323_ VSS VSS VDD VDD _0324_ sky130_fd_sc_hd__nand2_4
X_3954_ _0138_ _0324_ VSS VSS VDD VDD _0325_ sky130_fd_sc_hd__nor2_1
X_3955_ _0138_ _3649_ _0325_ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__a21oi_1
X_3956_ _0122_ _0326_ VSS VSS VDD VDD _3292_ sky130_fd_sc_hd__xor2_1
X_3957_ _3292_ VSS VSS VDD VDD _3296_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_17_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3961_ dp.rf.rf\[10\]\[30\] dp.rf.rf\[11\]\[30\] dp.rf.rf\[14\]\[30\]
+ dp.rf.rf\[15\]\[30\] net209 net207 VSS VSS VDD VDD _0330_
+ sky130_fd_sc_hd__mux4_1
X_3962_ net8 _0330_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__nand2_1
X_3963_ dp.rf.rf\[8\]\[30\] dp.rf.rf\[9\]\[30\] dp.rf.rf\[12\]\[30\]
+ dp.rf.rf\[13\]\[30\] net209 net207 VSS VSS VDD VDD _0332_
+ sky130_fd_sc_hd__mux4_1
X_3964_ net205 _0332_ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__nand2_1
X_3965_ net185 _0331_ _0333_ VSS VSS VDD VDD _0334_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_16_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3967_ dp.rf.rf\[6\]\[30\] dp.rf.rf\[7\]\[30\] net209 VSS
+ VSS VDD VDD _0336_ sky130_fd_sc_hd__mux2_1
X_3968_ _0115_ _0117_ net205 VSS VSS VDD VDD _0337_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_16_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3970_ _0148_ _0336_ net182 VSS VSS VDD VDD _0339_ sky130_fd_sc_hd__o21ai_0
X_3971_ dp.rf.rf\[3\]\[30\] net209 net201 dp.rf.rf\[2\]\[30\]
+ net190 VSS VSS VDD VDD _0340_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_16_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3973_ dp.rf.rf\[4\]\[30\] VSS VSS VDD VDD _0342_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_16_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3975_ dp.rf.rf\[1\]\[30\] dp.rf.rf\[5\]\[30\] net207 VSS
+ VSS VDD VDD _0344_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_16_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3977_ _0342_ net203 _0344_ net209 net8 VSS VSS VDD VDD _0346_
+ sky130_fd_sc_hd__a221oi_1
X_3978_ net210 net208 VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__nor2_2
X_3979_ _0115_ _0117_ _0347_ _0145_ VSS VSS VDD VDD _0348_
+ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_16_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3981_ net196 _0346_ net181 dp.rf.rf\[0\]\[30\] VSS VSS VDD
+ VDD _0350_ sky130_fd_sc_hd__o22ai_1
X_3982_ _0339_ _0340_ _0350_ VSS VSS VDD VDD _0351_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_16_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3984_ dp.rf.rf\[26\]\[30\] dp.rf.rf\[27\]\[30\] dp.rf.rf\[30\]\[30\]
+ dp.rf.rf\[31\]\[30\] net209 net206 VSS VSS VDD VDD _0353_
+ sky130_fd_sc_hd__mux4_1
X_3985_ net8 _0353_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__nand2_1
X_3986_ dp.rf.rf\[24\]\[30\] dp.rf.rf\[25\]\[30\] dp.rf.rf\[28\]\[30\]
+ dp.rf.rf\[29\]\[30\] net209 net206 VSS VSS VDD VDD _0355_
+ sky130_fd_sc_hd__mux4_1
X_3987_ net205 _0355_ VSS VSS VDD VDD _0356_ sky130_fd_sc_hd__nand2_1
X_3988_ net10 _0354_ _0356_ _0166_ VSS VSS VDD VDD _0357_
+ sky130_fd_sc_hd__a31oi_2
X_3989_ dp.rf.rf\[22\]\[30\] dp.rf.rf\[23\]\[30\] net209 VSS
+ VSS VDD VDD _0358_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_16_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3991_ _0148_ _0358_ net182 VSS VSS VDD VDD _0360_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_16_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3995_ dp.rf.rf\[19\]\[30\] net209 net201 dp.rf.rf\[18\]\[30\]
+ net190 VSS VSS VDD VDD _0364_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_16_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_3997_ dp.rf.rf\[20\]\[30\] VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__inv_1
X_3998_ dp.rf.rf\[17\]\[30\] dp.rf.rf\[21\]\[30\] net206 VSS
+ VSS VDD VDD _0367_ sky130_fd_sc_hd__mux2i_1
X_3999_ _0366_ net203 _0367_ net209 net8 VSS VSS VDD VDD _0368_
+ sky130_fd_sc_hd__a221oi_1
X_4000_ dp.rf.rf\[16\]\[30\] net181 _0368_ net196 VSS VSS
+ VDD VDD _0369_ sky130_fd_sc_hd__o22ai_1
X_4001_ _0360_ _0364_ _0369_ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__o21ai_1
X_4002_ net194 _0334_ _0351_ _0357_ _0370_ VSS VSS VDD VDD
+ _0371_ sky130_fd_sc_hd__a32oi_4
XTAP_TAPCELL_ROW_16_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4004_ net22 _0130_ VSS VSS VDD VDD _0372_ sky130_fd_sc_hd__nand2_1
X_4005_ _0304_ _0372_ VSS VSS VDD VDD _3645_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4009_ dp.rf.rf\[28\]\[29\] dp.rf.rf\[29\]\[29\] dp.rf.rf\[30\]\[29\]
+ dp.rf.rf\[31\]\[29\] net213 net274 VSS VSS VDD VDD _0376_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_15_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4011_ dp.rf.rf\[20\]\[29\] dp.rf.rf\[21\]\[29\] dp.rf.rf\[22\]\[29\]
+ dp.rf.rf\[23\]\[29\] net215 net274 VSS VSS VDD VDD _0378_
+ sky130_fd_sc_hd__mux4_1
X_4012_ dp.rf.rf\[24\]\[29\] dp.rf.rf\[25\]\[29\] dp.rf.rf\[26\]\[29\]
+ dp.rf.rf\[27\]\[29\] net213 net274 VSS VSS VDD VDD _0379_
+ sky130_fd_sc_hd__mux4_1
X_4013_ dp.rf.rf\[16\]\[29\] dp.rf.rf\[17\]\[29\] dp.rf.rf\[18\]\[29\]
+ dp.rf.rf\[19\]\[29\] net215 net274 VSS VSS VDD VDD _0380_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_15_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4015_ _0376_ _0378_ _0379_ _0380_ _0103_ _0286_ VSS VSS
+ VDD VDD _0382_ sky130_fd_sc_hd__mux4_1
X_4016_ _0086_ _0382_ VSS VSS VDD VDD _0383_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_15_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4021_ dp.rf.rf\[12\]\[29\] dp.rf.rf\[13\]\[29\] dp.rf.rf\[14\]\[29\]
+ dp.rf.rf\[15\]\[29\] net215 net14 VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__mux4_1
X_4022_ _0286_ _0388_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_15_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4024_ dp.rf.rf\[8\]\[29\] dp.rf.rf\[9\]\[29\] dp.rf.rf\[10\]\[29\]
+ dp.rf.rf\[11\]\[29\] net215 net14 VSS VSS VDD VDD _0391_ sky130_fd_sc_hd__mux4_1
X_4025_ net15 _0391_ VSS VSS VDD VDD _0392_ sky130_fd_sc_hd__nor2_1
X_4026_ _0389_ _0392_ VSS VSS VDD VDD _0393_ sky130_fd_sc_hd__nor2_1
X_4027_ net17 net16 VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_15_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4030_ dp.rf.rf\[4\]\[29\] dp.rf.rf\[5\]\[29\] dp.rf.rf\[6\]\[29\]
+ dp.rf.rf\[7\]\[29\] net215 net14 VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__mux4_1
X_4031_ net15 _0397_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__nand2_1
X_4032_ dp.rf.rf\[0\]\[29\] dp.rf.rf\[1\]\[29\] dp.rf.rf\[2\]\[29\]
+ dp.rf.rf\[3\]\[29\] net215 net14 VSS VSS VDD VDD _0399_ sky130_fd_sc_hd__mux4_1
X_4033_ _0286_ _0399_ VSS VSS VDD VDD _0400_ sky130_fd_sc_hd__nand2_1
X_4034_ _0046_ _0289_ VSS VSS VDD VDD _0401_ sky130_fd_sc_hd__and2_4
X_4035_ _0394_ _0398_ _0400_ _0401_ VSS VSS VDD VDD _0402_
+ sky130_fd_sc_hd__a31oi_1
X_4036_ net17 _0103_ _0393_ _0402_ VSS VSS VDD VDD _0403_
+ sky130_fd_sc_hd__o31ai_2
X_4037_ _0383_ _0403_ VSS VSS VDD VDD _0404_ sky130_fd_sc_hd__nor2_4
X_4038_ _3645_ _0404_ net179 VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__mux2i_1
X_4039_ _0122_ _0405_ VSS VSS VDD VDD _3300_ sky130_fd_sc_hd__xor2_1
X_4040_ _3300_ VSS VSS VDD VDD _3304_ sky130_fd_sc_hd__inv_1
X_4041_ _0115_ _0117_ net205 _0231_ VSS VSS VDD VDD _0406_
+ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_15_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4045_ dp.rf.rf\[30\]\[29\] dp.rf.rf\[31\]\[29\] net211 VSS
+ VSS VDD VDD _0410_ sky130_fd_sc_hd__mux2i_1
X_4046_ net207 _0410_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__nand2_1
X_4047_ dp.rf.rf\[27\]\[29\] net211 net201 dp.rf.rf\[26\]\[29\]
+ net190 VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__a221o_1
X_4048_ dp.rf.rf\[24\]\[29\] dp.rf.rf\[28\]\[29\] net207 VSS
+ VSS VDD VDD _0413_ sky130_fd_sc_hd__mux2i_1
X_4049_ dp.rf.rf\[25\]\[29\] dp.rf.rf\[29\]\[29\] net207 VSS
+ VSS VDD VDD _0414_ sky130_fd_sc_hd__mux2i_1
X_4050_ net8 net209 VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__nand2b_4
X_4051_ _0170_ _0413_ _0414_ _0415_ net10 VSS VSS VDD VDD
+ _0416_ sky130_fd_sc_hd__o221ai_1
X_4052_ _0406_ _0411_ _0412_ _0416_ net188 VSS VSS VDD VDD
+ _0417_ sky130_fd_sc_hd__a32o_1
X_4053_ net211 dp.rf.rf\[22\]\[29\] VSS VSS VDD VDD _0418_
+ sky130_fd_sc_hd__nor2b_1
X_4054_ dp.rf.rf\[23\]\[29\] net211 _0148_ _0418_ VSS VSS
+ VDD VDD _0419_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_14_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4056_ dp.rf.rf\[19\]\[29\] net211 net201 dp.rf.rf\[18\]\[29\]
+ net190 VSS VSS VDD VDD _0421_ sky130_fd_sc_hd__a221oi_1
X_4057_ dp.rf.rf\[20\]\[29\] VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_14_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4059_ dp.rf.rf\[17\]\[29\] dp.rf.rf\[21\]\[29\] net207 VSS
+ VSS VDD VDD _0424_ sky130_fd_sc_hd__mux2i_1
X_4060_ _0422_ net203 _0424_ net211 net8 VSS VSS VDD VDD _0425_
+ sky130_fd_sc_hd__a221oi_1
X_4061_ dp.rf.rf\[16\]\[29\] net180 _0425_ net195 VSS VSS
+ VDD VDD _0426_ sky130_fd_sc_hd__o22ai_1
X_4062_ net192 _0419_ _0421_ _0426_ VSS VSS VDD VDD _0427_
+ sky130_fd_sc_hd__o31ai_2
X_4063_ dp.rf.rf\[2\]\[29\] dp.rf.rf\[3\]\[29\] dp.rf.rf\[6\]\[29\]
+ dp.rf.rf\[7\]\[29\] net211 net207 VSS VSS VDD VDD _0428_ sky130_fd_sc_hd__mux4_1
X_4064_ dp.rf.rf\[4\]\[29\] VSS VSS VDD VDD _0429_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_14_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4066_ dp.rf.rf\[1\]\[29\] dp.rf.rf\[5\]\[29\] net207 VSS
+ VSS VDD VDD _0431_ sky130_fd_sc_hd__mux2i_1
X_4067_ _0429_ net204 _0431_ net211 net8 VSS VSS VDD VDD _0432_
+ sky130_fd_sc_hd__a221oi_1
X_4068_ net8 _0428_ _0432_ net195 VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__a211oi_1
X_4069_ dp.rf.rf\[10\]\[29\] dp.rf.rf\[11\]\[29\] dp.rf.rf\[14\]\[29\]
+ dp.rf.rf\[15\]\[29\] net211 net207 VSS VSS VDD VDD _0434_
+ sky130_fd_sc_hd__mux4_1
X_4070_ dp.rf.rf\[8\]\[29\] dp.rf.rf\[9\]\[29\] dp.rf.rf\[12\]\[29\]
+ dp.rf.rf\[13\]\[29\] net211 net207 VSS VSS VDD VDD _0435_
+ sky130_fd_sc_hd__mux4_1
X_4071_ _0224_ _0435_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__and2_0
X_4072_ net182 _0434_ _0436_ net198 VSS VSS VDD VDD _0437_
+ sky130_fd_sc_hd__a211oi_1
X_4073_ _0271_ _0433_ _0437_ VSS VSS VDD VDD _0438_ sky130_fd_sc_hd__nor3_2
X_4074_ _0417_ _0427_ _0438_ VSS VSS VDD VDD _3303_ sky130_fd_sc_hd__a21oi_4
X_4075_ net21 _0130_ VSS VSS VDD VDD _0439_ sky130_fd_sc_hd__nand2_1
X_4076_ _0304_ _0439_ VSS VSS VDD VDD _3641_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4079_ dp.rf.rf\[4\]\[28\] dp.rf.rf\[5\]\[28\] dp.rf.rf\[6\]\[28\]
+ dp.rf.rf\[7\]\[28\] net215 net14 VSS VSS VDD VDD _0442_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_14_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4081_ dp.rf.rf\[0\]\[28\] dp.rf.rf\[1\]\[28\] dp.rf.rf\[2\]\[28\]
+ dp.rf.rf\[3\]\[28\] net215 net14 VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__mux4_1
X_4082_ _0442_ _0444_ _0286_ VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__mux2i_4
XTAP_TAPCELL_ROW_14_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4084_ dp.rf.rf\[8\]\[28\] dp.rf.rf\[9\]\[28\] dp.rf.rf\[10\]\[28\]
+ dp.rf.rf\[11\]\[28\] net215 net274 VSS VSS VDD VDD _0447_
+ sky130_fd_sc_hd__mux4_1
X_4085_ net16 _0046_ VSS VSS VDD VDD _0448_ sky130_fd_sc_hd__nand2_1
X_4086_ _0086_ net15 net16 VSS VSS VDD VDD _0449_ sky130_fd_sc_hd__nand3_1
X_4087_ dp.rf.rf\[12\]\[28\] dp.rf.rf\[13\]\[28\] dp.rf.rf\[14\]\[28\]
+ dp.rf.rf\[15\]\[28\] net215 net14 VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__mux4_1
X_4088_ _0447_ _0448_ _0449_ _0450_ _0311_ VSS VSS VDD VDD
+ _0451_ sky130_fd_sc_hd__o221ai_2
X_4089_ dp.rf.rf\[28\]\[28\] dp.rf.rf\[29\]\[28\] dp.rf.rf\[30\]\[28\]
+ dp.rf.rf\[31\]\[28\] net213 net277 VSS VSS VDD VDD _0452_
+ sky130_fd_sc_hd__mux4_1
X_4090_ dp.rf.rf\[20\]\[28\] dp.rf.rf\[21\]\[28\] dp.rf.rf\[22\]\[28\]
+ dp.rf.rf\[23\]\[28\] net213 net277 VSS VSS VDD VDD _0453_
+ sky130_fd_sc_hd__mux4_1
X_4091_ dp.rf.rf\[24\]\[28\] dp.rf.rf\[25\]\[28\] dp.rf.rf\[26\]\[28\]
+ dp.rf.rf\[27\]\[28\] net213 net277 VSS VSS VDD VDD _0454_
+ sky130_fd_sc_hd__mux4_1
X_4092_ dp.rf.rf\[16\]\[28\] dp.rf.rf\[17\]\[28\] dp.rf.rf\[18\]\[28\]
+ dp.rf.rf\[19\]\[28\] net213 net277 VSS VSS VDD VDD _0455_
+ sky130_fd_sc_hd__mux4_1
X_4093_ _0452_ _0453_ _0454_ _0455_ _0103_ _0286_ VSS VSS
+ VDD VDD _0456_ sky130_fd_sc_hd__mux4_2
X_4094_ _0086_ _0456_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__nor2_1
X_4095_ _0394_ _0445_ _0451_ _0457_ VSS VSS VDD VDD _0458_
+ sky130_fd_sc_hd__a211o_4
X_4096_ _0138_ _0458_ VSS VSS VDD VDD _0459_ sky130_fd_sc_hd__nor2_1
X_4097_ _0138_ _3641_ _0459_ VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__a21oi_1
X_4098_ _0122_ _0460_ VSS VSS VDD VDD _3308_ sky130_fd_sc_hd__xor2_1
X_4099_ _3308_ VSS VSS VDD VDD _3312_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_14_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4101_ dp.rf.rf\[18\]\[28\] dp.rf.rf\[19\]\[28\] dp.rf.rf\[22\]\[28\]
+ dp.rf.rf\[23\]\[28\] net209 net206 VSS VSS VDD VDD _0462_
+ sky130_fd_sc_hd__mux4_1
X_4102_ _0406_ _0462_ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__nand2_1
X_4103_ dp.rf.rf\[17\]\[28\] dp.rf.rf\[21\]\[28\] net206 VSS
+ VSS VDD VDD _0464_ sky130_fd_sc_hd__mux2i_1
X_4104_ dp.rf.rf\[20\]\[28\] net209 net206 VSS VSS VDD VDD
+ _0465_ sky130_fd_sc_hd__nor3b_1
X_4105_ dp.rf.rf\[16\]\[28\] net209 net206 VSS VSS VDD VDD
+ _0466_ sky130_fd_sc_hd__nor3_1
X_4106_ net209 _0464_ _0465_ _0466_ net8 VSS VSS VDD VDD _0467_
+ sky130_fd_sc_hd__a2111oi_0
X_4107_ net10 _0467_ net187 VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_14_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4109_ net1 net12 net23 dp.rf.rf\[26\]\[28\] VSS VSS VDD
+ VDD _0470_ sky130_fd_sc_hd__nand4_1
X_4110_ dp.rf.rf\[26\]\[28\] _0245_ _0129_ _0470_ VSS VSS
+ VDD VDD _0471_ sky130_fd_sc_hd__o2bb2ai_1
XTAP_TAPCELL_ROW_14_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4112_ dp.rf.rf\[27\]\[28\] net209 VSS VSS VDD VDD _0473_
+ sky130_fd_sc_hd__and2_0
XTAP_TAPCELL_ROW_14_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4114_ dp.rf.rf\[30\]\[28\] dp.rf.rf\[31\]\[28\] net209 VSS
+ VSS VDD VDD _0475_ sky130_fd_sc_hd__mux2i_1
X_4115_ net206 _0475_ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_13_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4117_ net190 _0471_ _0473_ _0476_ net182 VSS VSS VDD VDD
+ _0478_ sky130_fd_sc_hd__o311ai_4
X_4118_ dp.rf.rf\[24\]\[28\] dp.rf.rf\[25\]\[28\] dp.rf.rf\[28\]\[28\]
+ dp.rf.rf\[29\]\[28\] net209 net206 VSS VSS VDD VDD _0479_
+ sky130_fd_sc_hd__mux4_1
X_4119_ net205 _0479_ net198 VSS VSS VDD VDD _0480_ sky130_fd_sc_hd__a21oi_1
X_4120_ _0463_ _0468_ _0478_ _0480_ VSS VSS VDD VDD _0481_
+ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_13_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4122_ dp.rf.rf\[10\]\[28\] dp.rf.rf\[11\]\[28\] dp.rf.rf\[14\]\[28\]
+ dp.rf.rf\[15\]\[28\] net211 net207 VSS VSS VDD VDD _0483_
+ sky130_fd_sc_hd__mux4_1
X_4123_ dp.rf.rf\[8\]\[28\] dp.rf.rf\[9\]\[28\] dp.rf.rf\[12\]\[28\]
+ dp.rf.rf\[13\]\[28\] net211 net207 VSS VSS VDD VDD _0484_
+ sky130_fd_sc_hd__mux4_1
X_4124_ _0483_ _0484_ _0224_ VSS VSS VDD VDD _0485_ sky130_fd_sc_hd__mux2i_2
XTAP_TAPCELL_ROW_13_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4126_ dp.rf.rf\[2\]\[28\] dp.rf.rf\[3\]\[28\] dp.rf.rf\[6\]\[28\]
+ dp.rf.rf\[7\]\[28\] net211 net207 VSS VSS VDD VDD _0487_ sky130_fd_sc_hd__mux4_1
X_4127_ dp.rf.rf\[4\]\[28\] VSS VSS VDD VDD _0488_ sky130_fd_sc_hd__inv_1
X_4128_ dp.rf.rf\[1\]\[28\] dp.rf.rf\[5\]\[28\] net207 VSS
+ VSS VDD VDD _0489_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_13_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4130_ _0488_ net204 _0489_ net211 net8 VSS VSS VDD VDD _0491_
+ sky130_fd_sc_hd__a221oi_1
X_4131_ net8 _0487_ _0491_ VSS VSS VDD VDD _0492_ sky130_fd_sc_hd__a21oi_2
X_4132_ _0115_ _0117_ net10 VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_13_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4134_ net185 _0485_ _0492_ _0493_ _0271_ VSS VSS VDD VDD
+ _0495_ sky130_fd_sc_hd__a221oi_4
X_4135_ _0481_ _0495_ VSS VSS VDD VDD _3311_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_13_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4139_ dp.rf.rf\[24\]\[27\] dp.rf.rf\[25\]\[27\] dp.rf.rf\[26\]\[27\]
+ dp.rf.rf\[27\]\[27\] net213 net14 VSS VSS VDD VDD _0499_ sky130_fd_sc_hd__mux4_1
X_4140_ dp.rf.rf\[16\]\[27\] dp.rf.rf\[17\]\[27\] dp.rf.rf\[18\]\[27\]
+ dp.rf.rf\[19\]\[27\] net213 net14 VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__mux4_1
X_4141_ dp.rf.rf\[28\]\[27\] dp.rf.rf\[29\]\[27\] dp.rf.rf\[30\]\[27\]
+ dp.rf.rf\[31\]\[27\] net213 net14 VSS VSS VDD VDD _0501_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_13_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4143_ dp.rf.rf\[20\]\[27\] dp.rf.rf\[21\]\[27\] dp.rf.rf\[22\]\[27\]
+ dp.rf.rf\[23\]\[27\] net213 net14 VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_13_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4146_ _0499_ _0500_ _0501_ _0503_ _0103_ net15 VSS VSS VDD
+ VDD _0506_ sky130_fd_sc_hd__mux4_1
X_4147_ dp.rf.rf\[8\]\[27\] dp.rf.rf\[9\]\[27\] dp.rf.rf\[10\]\[27\]
+ dp.rf.rf\[11\]\[27\] net213 net14 VSS VSS VDD VDD _0507_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_13_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4149_ dp.rf.rf\[0\]\[27\] dp.rf.rf\[1\]\[27\] dp.rf.rf\[2\]\[27\]
+ dp.rf.rf\[3\]\[27\] net213 net14 VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__mux4_1
X_4150_ dp.rf.rf\[12\]\[27\] dp.rf.rf\[13\]\[27\] dp.rf.rf\[14\]\[27\]
+ dp.rf.rf\[15\]\[27\] net213 net14 VSS VSS VDD VDD _0510_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_13_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4153_ dp.rf.rf\[4\]\[27\] dp.rf.rf\[5\]\[27\] dp.rf.rf\[6\]\[27\]
+ dp.rf.rf\[7\]\[27\] net213 net14 VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__mux4_1
X_4154_ _0507_ _0509_ _0510_ _0513_ _0103_ net15 VSS VSS VDD
+ VDD _0514_ sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_12_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4156_ net17 _0506_ _0514_ _0290_ VSS VSS VDD VDD _0516_
+ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_12_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4158_ net20 _0130_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__nand2_1
X_4159_ _0304_ _0518_ VSS VSS VDD VDD _3637_ sky130_fd_sc_hd__nand2_1
X_4160_ net179 _3637_ VSS VSS VDD VDD _0519_ sky130_fd_sc_hd__nor2_1
X_4161_ net179 _0516_ _0519_ VSS VSS VDD VDD _0520_ sky130_fd_sc_hd__a21oi_1
X_4162_ _0122_ _0520_ VSS VSS VDD VDD _3316_ sky130_fd_sc_hd__xnor2_1
X_4163_ _3316_ VSS VSS VDD VDD _3320_ sky130_fd_sc_hd__inv_1
X_4164_ dp.rf.rf\[10\]\[27\] dp.rf.rf\[11\]\[27\] dp.rf.rf\[14\]\[27\]
+ dp.rf.rf\[15\]\[27\] net211 net207 VSS VSS VDD VDD _0521_
+ sky130_fd_sc_hd__mux4_1
X_4165_ net8 _0521_ VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__nand2_1
X_4166_ dp.rf.rf\[8\]\[27\] dp.rf.rf\[9\]\[27\] dp.rf.rf\[12\]\[27\]
+ dp.rf.rf\[13\]\[27\] net211 net207 VSS VSS VDD VDD _0523_
+ sky130_fd_sc_hd__mux4_1
X_4167_ _0224_ _0523_ VSS VSS VDD VDD _0524_ sky130_fd_sc_hd__nand2_1
X_4168_ net185 _0522_ _0524_ VSS VSS VDD VDD _0525_ sky130_fd_sc_hd__and3_1
X_4169_ dp.rf.rf\[2\]\[27\] dp.rf.rf\[3\]\[27\] dp.rf.rf\[6\]\[27\]
+ dp.rf.rf\[7\]\[27\] net211 net207 VSS VSS VDD VDD _0526_ sky130_fd_sc_hd__mux4_1
X_4170_ dp.rf.rf\[1\]\[27\] dp.rf.rf\[5\]\[27\] net207 VSS
+ VSS VDD VDD _0527_ sky130_fd_sc_hd__mux2i_1
X_4171_ net211 net207 VSS VSS VDD VDD _0528_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_12_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4173_ dp.rf.rf\[4\]\[27\] _0528_ VSS VSS VDD VDD _0530_
+ sky130_fd_sc_hd__nor2_1
X_4174_ net211 _0527_ _0530_ net8 VSS VSS VDD VDD _0531_ sky130_fd_sc_hd__a211oi_1
X_4175_ net8 _0526_ _0531_ net196 VSS VSS VDD VDD _0532_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_12_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4177_ dp.rf.rf\[30\]\[27\] dp.rf.rf\[31\]\[27\] net211 VSS
+ VSS VDD VDD _0534_ sky130_fd_sc_hd__mux2i_1
X_4178_ net207 _0534_ VSS VSS VDD VDD _0535_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4180_ dp.rf.rf\[27\]\[27\] net211 net201 dp.rf.rf\[26\]\[27\]
+ net190 VSS VSS VDD VDD _0537_ sky130_fd_sc_hd__a221o_1
X_4181_ dp.rf.rf\[24\]\[27\] dp.rf.rf\[25\]\[27\] dp.rf.rf\[28\]\[27\]
+ dp.rf.rf\[29\]\[27\] net211 net207 VSS VSS VDD VDD _0538_
+ sky130_fd_sc_hd__mux4_1
X_4182_ _0224_ _0538_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__nand2_1
X_4183_ net185 _0539_ VSS VSS VDD VDD _0540_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4185_ _0406_ _0535_ _0537_ _0540_ net187 VSS VSS VDD VDD
+ _0542_ sky130_fd_sc_hd__a32oi_2
XTAP_TAPCELL_ROW_12_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4188_ dp.rf.rf\[22\]\[27\] dp.rf.rf\[23\]\[27\] net211 VSS
+ VSS VDD VDD _0545_ sky130_fd_sc_hd__mux2i_1
X_4189_ net207 _0545_ net192 VSS VSS VDD VDD _0546_ sky130_fd_sc_hd__a21oi_1
X_4190_ dp.rf.rf\[19\]\[27\] net211 net201 dp.rf.rf\[18\]\[27\]
+ net190 VSS VSS VDD VDD _0547_ sky130_fd_sc_hd__a221o_1
X_4191_ dp.rf.rf\[20\]\[27\] VSS VSS VDD VDD _0548_ sky130_fd_sc_hd__inv_1
X_4192_ dp.rf.rf\[17\]\[27\] dp.rf.rf\[21\]\[27\] net207 VSS
+ VSS VDD VDD _0549_ sky130_fd_sc_hd__mux2i_1
X_4193_ _0548_ net203 _0549_ net211 net8 VSS VSS VDD VDD _0550_
+ sky130_fd_sc_hd__a221oi_1
X_4194_ dp.rf.rf\[16\]\[27\] net180 _0550_ net196 VSS VSS
+ VDD VDD _0551_ sky130_fd_sc_hd__o22a_1
X_4195_ _0546_ _0547_ _0551_ VSS VSS VDD VDD _0552_ sky130_fd_sc_hd__a21oi_1
X_4196_ _0271_ _0525_ _0532_ _0542_ _0552_ VSS VSS VDD VDD
+ _3315_ sky130_fd_sc_hd__o32ai_4
X_4197_ _3315_ VSS VSS VDD VDD _3319_ sky130_fd_sc_hd__inv_2
X_4198_ net19 _0130_ VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__nand2_1
X_4199_ _0304_ _0553_ VSS VSS VDD VDD _3633_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_12_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4203_ dp.rf.rf\[24\]\[26\] dp.rf.rf\[25\]\[26\] dp.rf.rf\[26\]\[26\]
+ dp.rf.rf\[27\]\[26\] net213 net278 VSS VSS VDD VDD _0557_
+ sky130_fd_sc_hd__mux4_1
X_4204_ dp.rf.rf\[16\]\[26\] dp.rf.rf\[17\]\[26\] dp.rf.rf\[18\]\[26\]
+ dp.rf.rf\[19\]\[26\] net213 net278 VSS VSS VDD VDD _0558_
+ sky130_fd_sc_hd__mux4_1
X_4205_ dp.rf.rf\[28\]\[26\] dp.rf.rf\[29\]\[26\] dp.rf.rf\[30\]\[26\]
+ dp.rf.rf\[31\]\[26\] net213 net278 VSS VSS VDD VDD _0559_
+ sky130_fd_sc_hd__mux4_1
X_4206_ dp.rf.rf\[20\]\[26\] dp.rf.rf\[21\]\[26\] dp.rf.rf\[22\]\[26\]
+ dp.rf.rf\[23\]\[26\] net213 net278 VSS VSS VDD VDD _0560_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_12_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4208_ _0557_ _0558_ _0559_ _0560_ _0103_ net15 VSS VSS VDD
+ VDD _0562_ sky130_fd_sc_hd__mux4_1
X_4209_ net17 _0562_ VSS VSS VDD VDD _0563_ sky130_fd_sc_hd__nand2_1
X_4210_ dp.rf.rf\[8\]\[26\] dp.rf.rf\[9\]\[26\] dp.rf.rf\[10\]\[26\]
+ dp.rf.rf\[11\]\[26\] net215 net14 VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__mux4_1
X_4211_ dp.rf.rf\[0\]\[26\] dp.rf.rf\[1\]\[26\] dp.rf.rf\[2\]\[26\]
+ dp.rf.rf\[3\]\[26\] net215 net14 VSS VSS VDD VDD _0565_ sky130_fd_sc_hd__mux4_1
X_4212_ dp.rf.rf\[12\]\[26\] dp.rf.rf\[13\]\[26\] dp.rf.rf\[14\]\[26\]
+ dp.rf.rf\[15\]\[26\] net215 net14 VSS VSS VDD VDD _0566_ sky130_fd_sc_hd__mux4_1
X_4213_ dp.rf.rf\[4\]\[26\] dp.rf.rf\[5\]\[26\] dp.rf.rf\[6\]\[26\]
+ dp.rf.rf\[7\]\[26\] net215 net14 VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__mux4_1
X_4214_ _0564_ _0565_ _0566_ _0567_ _0103_ net15 VSS VSS VDD
+ VDD _0568_ sky130_fd_sc_hd__mux4_1
X_4215_ _0086_ _0568_ VSS VSS VDD VDD _0569_ sky130_fd_sc_hd__nand2_1
X_4216_ _0563_ _0569_ VSS VSS VDD VDD _0570_ sky130_fd_sc_hd__nand2_1
X_4217_ _0311_ _0570_ VSS VSS VDD VDD _0571_ sky130_fd_sc_hd__nand2_4
X_4218_ _0138_ _0571_ VSS VSS VDD VDD _0572_ sky130_fd_sc_hd__nor2_1
X_4219_ _0138_ _3633_ _0572_ VSS VSS VDD VDD _0573_ sky130_fd_sc_hd__a21oi_1
X_4220_ _0122_ _0573_ VSS VSS VDD VDD _3324_ sky130_fd_sc_hd__xor2_1
X_4221_ _3324_ VSS VSS VDD VDD _3328_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_11_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4224_ dp.rf.rf\[26\]\[26\] dp.rf.rf\[27\]\[26\] net7 VSS
+ VSS VDD VDD _0576_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_11_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4226_ dp.rf.rf\[30\]\[26\] dp.rf.rf\[31\]\[26\] net7 VSS
+ VSS VDD VDD _0578_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_11_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4229_ net206 _0578_ _0224_ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__a21oi_1
X_4230_ net189 _0576_ _0581_ VSS VSS VDD VDD _0582_ sky130_fd_sc_hd__o21ai_0
X_4231_ dp.rf.rf\[24\]\[26\] dp.rf.rf\[25\]\[26\] dp.rf.rf\[28\]\[26\]
+ dp.rf.rf\[29\]\[26\] net7 net206 VSS VSS VDD VDD _0583_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_11_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4233_ _0224_ _0583_ net198 VSS VSS VDD VDD _0585_ sky130_fd_sc_hd__a21oi_1
X_4234_ _0582_ _0585_ VSS VSS VDD VDD _0586_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_11_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4238_ net7 dp.rf.rf\[22\]\[26\] VSS VSS VDD VDD _0590_ sky130_fd_sc_hd__nor2b_1
X_4239_ dp.rf.rf\[23\]\[26\] net7 _0148_ _0590_ VSS VSS VDD
+ VDD _0591_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_11_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4241_ dp.rf.rf\[19\]\[26\] net7 net201 dp.rf.rf\[18\]\[26\]
+ net189 VSS VSS VDD VDD _0593_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_11_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4243_ dp.rf.rf\[20\]\[26\] VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_11_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4246_ dp.rf.rf\[17\]\[26\] dp.rf.rf\[21\]\[26\] net206 VSS
+ VSS VDD VDD _0598_ sky130_fd_sc_hd__mux2i_1
X_4247_ _0595_ net204 _0598_ net7 net8 VSS VSS VDD VDD _0599_
+ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_10_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4249_ dp.rf.rf\[16\]\[26\] net180 _0599_ net195 VSS VSS
+ VDD VDD _0601_ sky130_fd_sc_hd__o22ai_1
X_4250_ net192 _0591_ _0593_ _0601_ VSS VSS VDD VDD _0602_
+ sky130_fd_sc_hd__o31ai_2
XTAP_TAPCELL_ROW_10_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4252_ dp.rf.rf\[2\]\[26\] dp.rf.rf\[3\]\[26\] dp.rf.rf\[6\]\[26\]
+ dp.rf.rf\[7\]\[26\] net211 net207 VSS VSS VDD VDD _0604_ sky130_fd_sc_hd__mux4_1
X_4253_ dp.rf.rf\[4\]\[26\] VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__inv_1
X_4254_ dp.rf.rf\[1\]\[26\] dp.rf.rf\[5\]\[26\] net207 VSS
+ VSS VDD VDD _0606_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_10_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4256_ _0605_ net204 _0606_ net211 net8 VSS VSS VDD VDD _0608_
+ sky130_fd_sc_hd__a221oi_1
X_4257_ net8 _0604_ _0608_ VSS VSS VDD VDD _0609_ sky130_fd_sc_hd__a21oi_1
X_4258_ _0493_ _0609_ _0271_ VSS VSS VDD VDD _0610_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_10_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4261_ net211 dp.rf.rf\[14\]\[26\] VSS VSS VDD VDD _0613_
+ sky130_fd_sc_hd__nor2b_1
X_4262_ dp.rf.rf\[15\]\[26\] net211 _0148_ _0613_ VSS VSS
+ VDD VDD _0614_ sky130_fd_sc_hd__a211oi_1
X_4263_ dp.rf.rf\[11\]\[26\] net211 net201 dp.rf.rf\[10\]\[26\]
+ net189 VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_10_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4266_ dp.rf.rf\[8\]\[26\] dp.rf.rf\[9\]\[26\] dp.rf.rf\[12\]\[26\]
+ dp.rf.rf\[13\]\[26\] net211 net207 VSS VSS VDD VDD _0618_
+ sky130_fd_sc_hd__mux4_1
X_4267_ _0224_ _0618_ net198 VSS VSS VDD VDD _0619_ sky130_fd_sc_hd__a21oi_1
X_4268_ net192 _0614_ _0615_ _0619_ VSS VSS VDD VDD _0620_
+ sky130_fd_sc_hd__o31ai_2
X_4269_ net188 _0586_ _0602_ _0610_ _0620_ VSS VSS VDD VDD
+ _0621_ sky130_fd_sc_hd__a32oi_4
XTAP_TAPCELL_ROW_10_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4271_ net18 _0130_ VSS VSS VDD VDD _0622_ sky130_fd_sc_hd__nand2_1
X_4272_ _0304_ _0622_ VSS VSS VDD VDD _3629_ sky130_fd_sc_hd__nand2_1
X_4273_ dp.rf.rf\[24\]\[25\] dp.rf.rf\[25\]\[25\] dp.rf.rf\[26\]\[25\]
+ dp.rf.rf\[27\]\[25\] net213 net277 VSS VSS VDD VDD _0623_
+ sky130_fd_sc_hd__mux4_1
X_4274_ dp.rf.rf\[16\]\[25\] dp.rf.rf\[17\]\[25\] dp.rf.rf\[18\]\[25\]
+ dp.rf.rf\[19\]\[25\] net213 net277 VSS VSS VDD VDD _0624_
+ sky130_fd_sc_hd__mux4_1
X_4275_ dp.rf.rf\[28\]\[25\] dp.rf.rf\[29\]\[25\] dp.rf.rf\[30\]\[25\]
+ dp.rf.rf\[31\]\[25\] net213 net277 VSS VSS VDD VDD _0625_
+ sky130_fd_sc_hd__mux4_1
X_4276_ dp.rf.rf\[20\]\[25\] dp.rf.rf\[21\]\[25\] dp.rf.rf\[22\]\[25\]
+ dp.rf.rf\[23\]\[25\] net213 net277 VSS VSS VDD VDD _0626_
+ sky130_fd_sc_hd__mux4_1
X_4277_ _0623_ _0624_ _0625_ _0626_ _0103_ net15 VSS VSS VDD
+ VDD _0627_ sky130_fd_sc_hd__mux4_1
X_4278_ net17 _0627_ VSS VSS VDD VDD _0628_ sky130_fd_sc_hd__nand2_1
X_4279_ dp.rf.rf\[8\]\[25\] dp.rf.rf\[9\]\[25\] dp.rf.rf\[10\]\[25\]
+ dp.rf.rf\[11\]\[25\] net213 net277 VSS VSS VDD VDD _0629_
+ sky130_fd_sc_hd__mux4_1
X_4280_ dp.rf.rf\[0\]\[25\] dp.rf.rf\[1\]\[25\] dp.rf.rf\[2\]\[25\]
+ dp.rf.rf\[3\]\[25\] net213 net277 VSS VSS VDD VDD _0630_ sky130_fd_sc_hd__mux4_1
X_4281_ dp.rf.rf\[12\]\[25\] dp.rf.rf\[13\]\[25\] dp.rf.rf\[14\]\[25\]
+ dp.rf.rf\[15\]\[25\] net213 net277 VSS VSS VDD VDD _0631_
+ sky130_fd_sc_hd__mux4_1
X_4282_ dp.rf.rf\[4\]\[25\] dp.rf.rf\[5\]\[25\] dp.rf.rf\[6\]\[25\]
+ dp.rf.rf\[7\]\[25\] net213 net277 VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__mux4_1
X_4283_ _0629_ _0630_ _0631_ _0632_ _0103_ net15 VSS VSS VDD
+ VDD _0633_ sky130_fd_sc_hd__mux4_1
X_4284_ _0086_ _0633_ VSS VSS VDD VDD _0634_ sky130_fd_sc_hd__nand2_1
X_4285_ _0628_ _0634_ VSS VSS VDD VDD _0635_ sky130_fd_sc_hd__nand2_1
X_4286_ _0311_ _0635_ VSS VSS VDD VDD _0636_ sky130_fd_sc_hd__nand2_2
X_4287_ _0138_ _0636_ VSS VSS VDD VDD _0637_ sky130_fd_sc_hd__nor2_1
X_4288_ _0138_ _3629_ _0637_ VSS VSS VDD VDD _0638_ sky130_fd_sc_hd__a21oi_1
X_4289_ _0122_ _0638_ VSS VSS VDD VDD _3332_ sky130_fd_sc_hd__xor2_1
X_4290_ _3332_ VSS VSS VDD VDD _3336_ sky130_fd_sc_hd__inv_1
X_4291_ dp.rf.rf\[22\]\[25\] dp.rf.rf\[23\]\[25\] net210 VSS
+ VSS VDD VDD _0639_ sky130_fd_sc_hd__mux2_1
X_4292_ _0148_ _0639_ _0337_ VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__o21ai_0
X_4293_ dp.rf.rf\[19\]\[25\] net210 net201 dp.rf.rf\[18\]\[25\]
+ net190 VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__a221oi_1
X_4294_ dp.rf.rf\[20\]\[25\] VSS VSS VDD VDD _0642_ sky130_fd_sc_hd__inv_1
X_4295_ dp.rf.rf\[17\]\[25\] dp.rf.rf\[21\]\[25\] net208 VSS
+ VSS VDD VDD _0643_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_10_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4297_ _0642_ net204 _0643_ net210 net8 VSS VSS VDD VDD _0645_
+ sky130_fd_sc_hd__a221oi_1
X_4298_ dp.rf.rf\[16\]\[25\] net181 _0645_ _0202_ VSS VSS
+ VDD VDD _0646_ sky130_fd_sc_hd__o22ai_1
X_4299_ _0640_ _0641_ _0646_ VSS VSS VDD VDD _0647_ sky130_fd_sc_hd__o21ai_1
X_4300_ dp.rf.rf\[30\]\[25\] dp.rf.rf\[31\]\[25\] net209 VSS
+ VSS VDD VDD _0648_ sky130_fd_sc_hd__mux2_1
X_4301_ _0148_ _0648_ net182 VSS VSS VDD VDD _0649_ sky130_fd_sc_hd__o21ai_0
X_4302_ dp.rf.rf\[27\]\[25\] net209 net201 dp.rf.rf\[26\]\[25\]
+ net190 VSS VSS VDD VDD _0650_ sky130_fd_sc_hd__a221oi_1
X_4303_ dp.rf.rf\[24\]\[25\] dp.rf.rf\[25\]\[25\] dp.rf.rf\[28\]\[25\]
+ dp.rf.rf\[29\]\[25\] net209 net208 VSS VSS VDD VDD _0651_
+ sky130_fd_sc_hd__mux4_1
X_4304_ net205 _0651_ net198 VSS VSS VDD VDD _0652_ sky130_fd_sc_hd__a21oi_1
X_4305_ _0649_ _0650_ _0652_ VSS VSS VDD VDD _0653_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_10_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4307_ dp.rf.rf\[2\]\[25\] dp.rf.rf\[3\]\[25\] dp.rf.rf\[6\]\[25\]
+ dp.rf.rf\[7\]\[25\] net209 net208 VSS VSS VDD VDD _0655_ sky130_fd_sc_hd__mux4_1
X_4308_ net8 _0655_ VSS VSS VDD VDD _0656_ sky130_fd_sc_hd__nand2_1
X_4309_ dp.rf.rf\[1\]\[25\] dp.rf.rf\[5\]\[25\] net208 VSS
+ VSS VDD VDD _0657_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_10_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4311_ dp.rf.rf\[4\]\[25\] _0528_ _0657_ _0245_ net205 VSS
+ VSS VDD VDD _0659_ sky130_fd_sc_hd__o221ai_1
X_4312_ _0493_ _0656_ _0659_ _0271_ VSS VSS VDD VDD _0660_
+ sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_10_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4315_ dp.rf.rf\[11\]\[25\] net209 net201 dp.rf.rf\[10\]\[25\]
+ net190 VSS VSS VDD VDD _0663_ sky130_fd_sc_hd__a221oi_1
X_4316_ dp.rf.rf\[14\]\[25\] dp.rf.rf\[15\]\[25\] net209 VSS
+ VSS VDD VDD _0664_ sky130_fd_sc_hd__mux2i_1
X_4317_ net208 _0664_ VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__nand2_1
X_4318_ net8 _0119_ _0665_ VSS VSS VDD VDD _0666_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_9_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4321_ dp.rf.rf\[8\]\[25\] dp.rf.rf\[9\]\[25\] dp.rf.rf\[12\]\[25\]
+ dp.rf.rf\[13\]\[25\] net209 net208 VSS VSS VDD VDD _0669_
+ sky130_fd_sc_hd__mux4_1
X_4322_ net205 _0669_ net198 VSS VSS VDD VDD _0670_ sky130_fd_sc_hd__a21oi_1
X_4323_ _0663_ _0666_ _0670_ VSS VSS VDD VDD _0671_ sky130_fd_sc_hd__o21ai_1
X_4324_ net188 _0647_ _0653_ _0660_ _0671_ VSS VSS VDD VDD
+ _3335_ sky130_fd_sc_hd__a32oi_4
XTAP_TAPCELL_ROW_9_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4326_ dp.rf.rf\[28\]\[24\] dp.rf.rf\[29\]\[24\] dp.rf.rf\[30\]\[24\]
+ dp.rf.rf\[31\]\[24\] net212 net274 VSS VSS VDD VDD _0673_
+ sky130_fd_sc_hd__mux4_1
X_4327_ net16 _0673_ VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_9_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4329_ dp.rf.rf\[20\]\[24\] dp.rf.rf\[21\]\[24\] dp.rf.rf\[22\]\[24\]
+ dp.rf.rf\[23\]\[24\] net212 net274 VSS VSS VDD VDD _0676_
+ sky130_fd_sc_hd__mux4_1
X_4330_ _0103_ _0676_ VSS VSS VDD VDD _0677_ sky130_fd_sc_hd__nand2_1
X_4331_ net15 _0674_ _0677_ VSS VSS VDD VDD _0678_ sky130_fd_sc_hd__nand3_1
X_4332_ dp.rf.rf\[24\]\[24\] dp.rf.rf\[25\]\[24\] dp.rf.rf\[26\]\[24\]
+ dp.rf.rf\[27\]\[24\] net212 net274 VSS VSS VDD VDD _0679_
+ sky130_fd_sc_hd__mux4_1
X_4333_ net16 _0679_ VSS VSS VDD VDD _0680_ sky130_fd_sc_hd__nand2_1
X_4334_ dp.rf.rf\[16\]\[24\] dp.rf.rf\[17\]\[24\] dp.rf.rf\[18\]\[24\]
+ dp.rf.rf\[19\]\[24\] net212 net274 VSS VSS VDD VDD _0681_
+ sky130_fd_sc_hd__mux4_1
X_4335_ _0103_ _0681_ VSS VSS VDD VDD _0682_ sky130_fd_sc_hd__nand2_1
X_4336_ _0286_ _0680_ _0682_ VSS VSS VDD VDD _0683_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_9_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4338_ dp.rf.rf\[12\]\[24\] dp.rf.rf\[13\]\[24\] dp.rf.rf\[14\]\[24\]
+ dp.rf.rf\[15\]\[24\] net215 net14 VSS VSS VDD VDD _0685_ sky130_fd_sc_hd__mux4_1
X_4339_ dp.rf.rf\[4\]\[24\] dp.rf.rf\[5\]\[24\] dp.rf.rf\[6\]\[24\]
+ dp.rf.rf\[7\]\[24\] net215 net14 VSS VSS VDD VDD _0686_ sky130_fd_sc_hd__mux4_1
X_4340_ _0685_ _0686_ _0103_ VSS VSS VDD VDD _0687_ sky130_fd_sc_hd__mux2i_2
X_4341_ dp.rf.rf\[8\]\[24\] dp.rf.rf\[9\]\[24\] dp.rf.rf\[10\]\[24\]
+ dp.rf.rf\[11\]\[24\] net215 net14 VSS VSS VDD VDD _0688_ sky130_fd_sc_hd__mux4_1
X_4342_ net16 _0688_ VSS VSS VDD VDD _0689_ sky130_fd_sc_hd__nand2_1
X_4343_ dp.rf.rf\[0\]\[24\] dp.rf.rf\[1\]\[24\] dp.rf.rf\[2\]\[24\]
+ dp.rf.rf\[3\]\[24\] net215 net14 VSS VSS VDD VDD _0690_ sky130_fd_sc_hd__mux4_1
X_4344_ _0103_ _0690_ VSS VSS VDD VDD _0691_ sky130_fd_sc_hd__nand2_1
X_4345_ _0286_ _0689_ _0691_ VSS VSS VDD VDD _0692_ sky130_fd_sc_hd__and3_1
X_4346_ net15 _0687_ _0692_ VSS VSS VDD VDD _0693_ sky130_fd_sc_hd__a21oi_4
X_4347_ net17 _0678_ _0683_ _0693_ _0290_ VSS VSS VDD VDD
+ _0694_ sky130_fd_sc_hd__a32oi_4
XTAP_TAPCELL_ROW_9_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4349_ _0086_ _0119_ _0304_ VSS VSS VDD VDD _3625_ sky130_fd_sc_hd__o21ai_1
X_4350_ net179 _3625_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__nor2_1
X_4351_ net179 _0694_ _0696_ VSS VSS VDD VDD _0697_ sky130_fd_sc_hd__a21oi_1
X_4352_ _0122_ _0697_ VSS VSS VDD VDD _3340_ sky130_fd_sc_hd__xnor2_1
X_4353_ _3340_ VSS VSS VDD VDD _3344_ sky130_fd_sc_hd__inv_1
X_4354_ dp.rf.rf\[24\]\[24\] dp.rf.rf\[28\]\[24\] net207 VSS
+ VSS VDD VDD _0698_ sky130_fd_sc_hd__mux2i_1
X_4355_ dp.rf.rf\[25\]\[24\] dp.rf.rf\[29\]\[24\] net207 VSS
+ VSS VDD VDD _0699_ sky130_fd_sc_hd__mux2i_1
X_4356_ _0170_ _0698_ _0699_ _0415_ VSS VSS VDD VDD _0700_
+ sky130_fd_sc_hd__o22ai_1
X_4357_ _0145_ _0700_ net187 VSS VSS VDD VDD _0701_ sky130_fd_sc_hd__o21ai_1
X_4358_ net1 net12 net23 dp.rf.rf\[26\]\[24\] VSS VSS VDD
+ VDD _0702_ sky130_fd_sc_hd__nand4_1
X_4359_ dp.rf.rf\[26\]\[24\] _0245_ _0129_ _0702_ VSS VSS
+ VDD VDD _0703_ sky130_fd_sc_hd__o2bb2ai_1
X_4360_ dp.rf.rf\[27\]\[24\] net209 VSS VSS VDD VDD _0704_
+ sky130_fd_sc_hd__and2_0
X_4361_ dp.rf.rf\[30\]\[24\] dp.rf.rf\[31\]\[24\] net209 VSS
+ VSS VDD VDD _0705_ sky130_fd_sc_hd__mux2i_1
X_4362_ net207 _0705_ VSS VSS VDD VDD _0706_ sky130_fd_sc_hd__nand2_1
X_4363_ net190 _0703_ _0704_ _0406_ _0706_ VSS VSS VDD VDD
+ _0707_ sky130_fd_sc_hd__o311ai_4
X_4364_ net1 net12 net23 dp.rf.rf\[18\]\[24\] VSS VSS VDD
+ VDD _0708_ sky130_fd_sc_hd__nand4_1
X_4365_ dp.rf.rf\[18\]\[24\] _0245_ _0129_ _0708_ VSS VSS
+ VDD VDD _0709_ sky130_fd_sc_hd__o2bb2ai_1
X_4366_ dp.rf.rf\[19\]\[24\] net209 VSS VSS VDD VDD _0710_
+ sky130_fd_sc_hd__and2_0
X_4367_ dp.rf.rf\[22\]\[24\] dp.rf.rf\[23\]\[24\] net209 VSS
+ VSS VDD VDD _0711_ sky130_fd_sc_hd__mux2i_1
X_4368_ net207 _0711_ VSS VSS VDD VDD _0712_ sky130_fd_sc_hd__nand2_1
X_4369_ net190 _0709_ _0710_ _0712_ net182 VSS VSS VDD VDD
+ _0713_ sky130_fd_sc_hd__o311ai_4
X_4370_ dp.rf.rf\[20\]\[24\] VSS VSS VDD VDD _0714_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_9_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4372_ dp.rf.rf\[17\]\[24\] dp.rf.rf\[21\]\[24\] net207 VSS
+ VSS VDD VDD _0716_ sky130_fd_sc_hd__mux2i_1
X_4373_ _0714_ net203 _0716_ net209 net8 VSS VSS VDD VDD _0717_
+ sky130_fd_sc_hd__a221oi_1
XTAP_TAPCELL_ROW_9_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4375_ dp.rf.rf\[16\]\[24\] net181 _0717_ net196 VSS VSS
+ VDD VDD _0719_ sky130_fd_sc_hd__o22ai_2
X_4376_ _0701_ _0707_ _0713_ _0719_ VSS VSS VDD VDD _0720_
+ sky130_fd_sc_hd__a22oi_4
X_4377_ net1 net12 net23 dp.rf.rf\[10\]\[24\] VSS VSS VDD
+ VDD _0721_ sky130_fd_sc_hd__nand4_1
X_4378_ dp.rf.rf\[10\]\[24\] _0245_ _0129_ _0721_ VSS VSS
+ VDD VDD _0722_ sky130_fd_sc_hd__o2bb2ai_1
X_4379_ dp.rf.rf\[11\]\[24\] net211 VSS VSS VDD VDD _0723_
+ sky130_fd_sc_hd__and2_0
X_4380_ dp.rf.rf\[14\]\[24\] dp.rf.rf\[15\]\[24\] net211 VSS
+ VSS VDD VDD _0724_ sky130_fd_sc_hd__mux2i_1
X_4381_ net207 _0724_ VSS VSS VDD VDD _0725_ sky130_fd_sc_hd__nand2_1
X_4382_ net190 _0722_ _0723_ _0725_ net182 VSS VSS VDD VDD
+ _0726_ sky130_fd_sc_hd__o311ai_2
X_4383_ dp.rf.rf\[8\]\[24\] dp.rf.rf\[9\]\[24\] dp.rf.rf\[12\]\[24\]
+ dp.rf.rf\[13\]\[24\] net211 net207 VSS VSS VDD VDD _0727_
+ sky130_fd_sc_hd__mux4_1
X_4384_ _0224_ _0727_ net198 VSS VSS VDD VDD _0728_ sky130_fd_sc_hd__a21oi_1
X_4385_ dp.rf.rf\[2\]\[24\] dp.rf.rf\[3\]\[24\] dp.rf.rf\[6\]\[24\]
+ dp.rf.rf\[7\]\[24\] net211 net207 VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__mux4_1
X_4386_ dp.rf.rf\[4\]\[24\] VSS VSS VDD VDD _0730_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_9_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4388_ dp.rf.rf\[1\]\[24\] dp.rf.rf\[5\]\[24\] net207 VSS
+ VSS VDD VDD _0732_ sky130_fd_sc_hd__mux2i_1
X_4389_ _0730_ net204 _0732_ net211 net8 VSS VSS VDD VDD _0733_
+ sky130_fd_sc_hd__a221oi_1
X_4390_ net8 _0729_ _0733_ net195 VSS VSS VDD VDD _0734_ sky130_fd_sc_hd__a211oi_2
X_4391_ _0726_ _0728_ _0734_ _0271_ VSS VSS VDD VDD _0735_
+ sky130_fd_sc_hd__a211oi_4
X_4392_ _0720_ _0735_ VSS VSS VDD VDD _3343_ sky130_fd_sc_hd__nor2_8
X_4393_ _0103_ _0119_ _0304_ VSS VSS VDD VDD _3621_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_9_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4395_ dp.rf.rf\[24\]\[23\] dp.rf.rf\[25\]\[23\] dp.rf.rf\[26\]\[23\]
+ dp.rf.rf\[27\]\[23\] net213 net274 VSS VSS VDD VDD _0737_
+ sky130_fd_sc_hd__mux4_1
X_4396_ dp.rf.rf\[16\]\[23\] dp.rf.rf\[17\]\[23\] dp.rf.rf\[18\]\[23\]
+ dp.rf.rf\[19\]\[23\] net215 net274 VSS VSS VDD VDD _0738_
+ sky130_fd_sc_hd__mux4_1
X_4397_ dp.rf.rf\[28\]\[23\] dp.rf.rf\[29\]\[23\] dp.rf.rf\[30\]\[23\]
+ dp.rf.rf\[31\]\[23\] net213 net274 VSS VSS VDD VDD _0739_
+ sky130_fd_sc_hd__mux4_1
X_4398_ dp.rf.rf\[20\]\[23\] dp.rf.rf\[21\]\[23\] dp.rf.rf\[22\]\[23\]
+ dp.rf.rf\[23\]\[23\] net215 net274 VSS VSS VDD VDD _0740_
+ sky130_fd_sc_hd__mux4_1
X_4399_ _0737_ _0738_ _0739_ _0740_ _0103_ net15 VSS VSS VDD
+ VDD _0741_ sky130_fd_sc_hd__mux4_1
X_4400_ dp.rf.rf\[8\]\[23\] dp.rf.rf\[9\]\[23\] dp.rf.rf\[10\]\[23\]
+ dp.rf.rf\[11\]\[23\] net215 net14 VSS VSS VDD VDD _0742_ sky130_fd_sc_hd__mux4_1
X_4401_ dp.rf.rf\[0\]\[23\] dp.rf.rf\[1\]\[23\] dp.rf.rf\[2\]\[23\]
+ dp.rf.rf\[3\]\[23\] net215 net14 VSS VSS VDD VDD _0743_ sky130_fd_sc_hd__mux4_1
X_4402_ dp.rf.rf\[12\]\[23\] dp.rf.rf\[13\]\[23\] dp.rf.rf\[14\]\[23\]
+ dp.rf.rf\[15\]\[23\] net215 net14 VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__mux4_1
X_4403_ dp.rf.rf\[4\]\[23\] dp.rf.rf\[5\]\[23\] dp.rf.rf\[6\]\[23\]
+ dp.rf.rf\[7\]\[23\] net215 net14 VSS VSS VDD VDD _0745_ sky130_fd_sc_hd__mux4_1
X_4404_ _0742_ _0743_ _0744_ _0745_ _0103_ net15 VSS VSS VDD
+ VDD _0746_ sky130_fd_sc_hd__mux4_2
X_4405_ _0741_ _0746_ _0086_ VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__mux2i_4
X_4406_ _0138_ _0401_ _0747_ VSS VSS VDD VDD _0748_ sky130_fd_sc_hd__nor3_1
X_4407_ _0138_ _3621_ _0748_ VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__a21oi_1
X_4408_ _0122_ _0749_ VSS VSS VDD VDD _3348_ sky130_fd_sc_hd__xor2_1
X_4409_ _3348_ VSS VSS VDD VDD _3352_ sky130_fd_sc_hd__inv_1
X_4410_ dp.rf.rf\[22\]\[23\] dp.rf.rf\[23\]\[23\] net211 VSS
+ VSS VDD VDD _0750_ sky130_fd_sc_hd__mux2_1
X_4411_ _0148_ _0750_ net182 VSS VSS VDD VDD _0751_ sky130_fd_sc_hd__o21ai_0
X_4412_ dp.rf.rf\[19\]\[23\] net211 net201 dp.rf.rf\[18\]\[23\]
+ net190 VSS VSS VDD VDD _0752_ sky130_fd_sc_hd__a221oi_1
X_4413_ dp.rf.rf\[20\]\[23\] VSS VSS VDD VDD _0753_ sky130_fd_sc_hd__inv_1
X_4414_ dp.rf.rf\[17\]\[23\] dp.rf.rf\[21\]\[23\] net207 VSS
+ VSS VDD VDD _0754_ sky130_fd_sc_hd__mux2i_1
X_4415_ _0753_ net203 _0754_ net211 net8 VSS VSS VDD VDD _0755_
+ sky130_fd_sc_hd__a221oi_1
X_4416_ dp.rf.rf\[16\]\[23\] net180 _0755_ net195 VSS VSS
+ VDD VDD _0756_ sky130_fd_sc_hd__o22ai_1
X_4417_ _0751_ _0752_ _0756_ VSS VSS VDD VDD _0757_ sky130_fd_sc_hd__o21ai_1
X_4418_ dp.rf.rf\[26\]\[23\] dp.rf.rf\[27\]\[23\] dp.rf.rf\[30\]\[23\]
+ dp.rf.rf\[31\]\[23\] net211 net207 VSS VSS VDD VDD _0758_
+ sky130_fd_sc_hd__mux4_1
X_4419_ dp.rf.rf\[25\]\[23\] dp.rf.rf\[29\]\[23\] net207 VSS
+ VSS VDD VDD _0759_ sky130_fd_sc_hd__mux2i_1
X_4420_ dp.rf.rf\[24\]\[23\] dp.rf.rf\[28\]\[23\] net207 VSS
+ VSS VDD VDD _0760_ sky130_fd_sc_hd__mux2i_1
X_4421_ _0415_ _0759_ _0760_ _0170_ VSS VSS VDD VDD _0761_
+ sky130_fd_sc_hd__o22ai_1
X_4422_ net8 _0758_ _0761_ net198 VSS VSS VDD VDD _0762_ sky130_fd_sc_hd__a211o_1
X_4423_ net211 dp.rf.rf\[14\]\[23\] VSS VSS VDD VDD _0763_
+ sky130_fd_sc_hd__nor2b_1
X_4424_ dp.rf.rf\[15\]\[23\] net211 _0148_ _0763_ VSS VSS
+ VDD VDD _0764_ sky130_fd_sc_hd__a211oi_1
X_4425_ dp.rf.rf\[11\]\[23\] net211 net201 dp.rf.rf\[10\]\[23\]
+ net190 VSS VSS VDD VDD _0765_ sky130_fd_sc_hd__a221oi_1
X_4426_ dp.rf.rf\[8\]\[23\] dp.rf.rf\[9\]\[23\] dp.rf.rf\[12\]\[23\]
+ dp.rf.rf\[13\]\[23\] net211 net207 VSS VSS VDD VDD _0766_
+ sky130_fd_sc_hd__mux4_1
X_4427_ _0224_ _0766_ net198 VSS VSS VDD VDD _0767_ sky130_fd_sc_hd__a21oi_1
X_4428_ net192 _0764_ _0765_ _0767_ VSS VSS VDD VDD _0768_
+ sky130_fd_sc_hd__o31ai_2
X_4429_ dp.rf.rf\[2\]\[23\] dp.rf.rf\[3\]\[23\] dp.rf.rf\[6\]\[23\]
+ dp.rf.rf\[7\]\[23\] net211 net207 VSS VSS VDD VDD _0769_ sky130_fd_sc_hd__mux4_1
X_4430_ dp.rf.rf\[4\]\[23\] VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__inv_1
X_4431_ dp.rf.rf\[1\]\[23\] dp.rf.rf\[5\]\[23\] net207 VSS
+ VSS VDD VDD _0771_ sky130_fd_sc_hd__mux2i_1
X_4432_ _0770_ net203 _0771_ net211 net8 VSS VSS VDD VDD _0772_
+ sky130_fd_sc_hd__a221oi_1
X_4433_ net8 _0769_ _0772_ net196 VSS VSS VDD VDD _0773_ sky130_fd_sc_hd__a211oi_1
X_4434_ _0271_ _0773_ VSS VSS VDD VDD _0774_ sky130_fd_sc_hd__nor2_1
X_4435_ net188 _0757_ _0762_ _0768_ _0774_ VSS VSS VDD VDD
+ _3351_ sky130_fd_sc_hd__a32oi_4
X_4436_ dp.rf.rf\[28\]\[22\] dp.rf.rf\[29\]\[22\] dp.rf.rf\[30\]\[22\]
+ dp.rf.rf\[31\]\[22\] net13 net277 VSS VSS VDD VDD _0775_ sky130_fd_sc_hd__mux4_1
X_4437_ net16 _0775_ VSS VSS VDD VDD _0776_ sky130_fd_sc_hd__nand2_1
X_4438_ dp.rf.rf\[20\]\[22\] dp.rf.rf\[21\]\[22\] dp.rf.rf\[22\]\[22\]
+ dp.rf.rf\[23\]\[22\] net13 net277 VSS VSS VDD VDD _0777_ sky130_fd_sc_hd__mux4_1
X_4439_ _0103_ _0777_ VSS VSS VDD VDD _0778_ sky130_fd_sc_hd__nand2_1
X_4440_ net15 _0776_ _0778_ VSS VSS VDD VDD _0779_ sky130_fd_sc_hd__nand3_1
X_4441_ dp.rf.rf\[24\]\[22\] dp.rf.rf\[25\]\[22\] dp.rf.rf\[26\]\[22\]
+ dp.rf.rf\[27\]\[22\] net13 net277 VSS VSS VDD VDD _0780_ sky130_fd_sc_hd__mux4_1
X_4442_ net16 _0780_ VSS VSS VDD VDD _0781_ sky130_fd_sc_hd__nand2_1
X_4443_ dp.rf.rf\[16\]\[22\] dp.rf.rf\[17\]\[22\] dp.rf.rf\[18\]\[22\]
+ dp.rf.rf\[19\]\[22\] net13 net277 VSS VSS VDD VDD _0782_ sky130_fd_sc_hd__mux4_1
X_4444_ _0103_ _0782_ VSS VSS VDD VDD _0783_ sky130_fd_sc_hd__nand2_1
X_4445_ _0286_ _0781_ _0783_ VSS VSS VDD VDD _0784_ sky130_fd_sc_hd__nand3_1
X_4446_ dp.rf.rf\[12\]\[22\] dp.rf.rf\[13\]\[22\] dp.rf.rf\[14\]\[22\]
+ dp.rf.rf\[15\]\[22\] net13 net277 VSS VSS VDD VDD _0785_ sky130_fd_sc_hd__mux4_1
X_4447_ dp.rf.rf\[4\]\[22\] dp.rf.rf\[5\]\[22\] dp.rf.rf\[6\]\[22\]
+ dp.rf.rf\[7\]\[22\] net13 net277 VSS VSS VDD VDD _0786_ sky130_fd_sc_hd__mux4_1
X_4448_ _0785_ _0786_ _0103_ VSS VSS VDD VDD _0787_ sky130_fd_sc_hd__mux2i_1
X_4449_ dp.rf.rf\[8\]\[22\] dp.rf.rf\[9\]\[22\] dp.rf.rf\[10\]\[22\]
+ dp.rf.rf\[11\]\[22\] net13 net277 VSS VSS VDD VDD _0788_ sky130_fd_sc_hd__mux4_1
X_4450_ net16 _0788_ VSS VSS VDD VDD _0789_ sky130_fd_sc_hd__nand2_1
X_4451_ dp.rf.rf\[0\]\[22\] dp.rf.rf\[1\]\[22\] dp.rf.rf\[2\]\[22\]
+ dp.rf.rf\[3\]\[22\] net13 net277 VSS VSS VDD VDD _0790_ sky130_fd_sc_hd__mux4_1
X_4452_ _0103_ _0790_ VSS VSS VDD VDD _0791_ sky130_fd_sc_hd__nand2_1
X_4453_ _0286_ _0789_ _0791_ VSS VSS VDD VDD _0792_ sky130_fd_sc_hd__and3_1
X_4454_ net15 _0787_ _0792_ VSS VSS VDD VDD _0793_ sky130_fd_sc_hd__a21oi_2
X_4455_ net17 _0779_ _0784_ _0793_ net184 VSS VSS VDD VDD
+ _0794_ sky130_fd_sc_hd__a32oi_4
X_4456_ _0286_ _0119_ _0304_ VSS VSS VDD VDD _3617_ sky130_fd_sc_hd__o21ai_1
X_4457_ net179 _3617_ VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__nor2_1
X_4458_ net179 _0794_ _0795_ VSS VSS VDD VDD _0796_ sky130_fd_sc_hd__a21oi_1
X_4459_ _0122_ _0796_ VSS VSS VDD VDD _3356_ sky130_fd_sc_hd__xnor2_1
X_4460_ _3356_ VSS VSS VDD VDD _3360_ sky130_fd_sc_hd__inv_1
X_4461_ dp.rf.rf\[10\]\[22\] dp.rf.rf\[11\]\[22\] dp.rf.rf\[14\]\[22\]
+ dp.rf.rf\[15\]\[22\] net209 net208 VSS VSS VDD VDD _0797_
+ sky130_fd_sc_hd__mux4_1
X_4462_ net8 _0797_ VSS VSS VDD VDD _0798_ sky130_fd_sc_hd__nand2_1
X_4463_ dp.rf.rf\[8\]\[22\] dp.rf.rf\[9\]\[22\] dp.rf.rf\[12\]\[22\]
+ dp.rf.rf\[13\]\[22\] net209 net208 VSS VSS VDD VDD _0799_
+ sky130_fd_sc_hd__mux4_1
X_4464_ net205 _0799_ VSS VSS VDD VDD _0800_ sky130_fd_sc_hd__nand2_1
X_4465_ net185 _0798_ _0800_ VSS VSS VDD VDD _0801_ sky130_fd_sc_hd__nand3_2
X_4466_ dp.rf.rf\[6\]\[22\] dp.rf.rf\[7\]\[22\] net209 VSS
+ VSS VDD VDD _0802_ sky130_fd_sc_hd__mux2_1
X_4467_ _0148_ _0802_ _0337_ VSS VSS VDD VDD _0803_ sky130_fd_sc_hd__o21ai_0
X_4468_ dp.rf.rf\[3\]\[22\] net209 net201 dp.rf.rf\[2\]\[22\]
+ net189 VSS VSS VDD VDD _0804_ sky130_fd_sc_hd__a221oi_1
X_4469_ dp.rf.rf\[4\]\[22\] VSS VSS VDD VDD _0805_ sky130_fd_sc_hd__inv_1
X_4470_ dp.rf.rf\[1\]\[22\] dp.rf.rf\[5\]\[22\] net208 VSS
+ VSS VDD VDD _0806_ sky130_fd_sc_hd__mux2i_1
X_4471_ _0805_ net204 _0806_ net209 net8 VSS VSS VDD VDD _0807_
+ sky130_fd_sc_hd__a221oi_1
X_4472_ dp.rf.rf\[0\]\[22\] net180 _0807_ net195 VSS VSS VDD
+ VDD _0808_ sky130_fd_sc_hd__o22ai_1
X_4473_ _0803_ _0804_ _0808_ VSS VSS VDD VDD _0809_ sky130_fd_sc_hd__o21ai_2
X_4474_ dp.rf.rf\[26\]\[22\] dp.rf.rf\[27\]\[22\] net210 VSS
+ VSS VDD VDD _0810_ sky130_fd_sc_hd__mux2_1
X_4475_ dp.rf.rf\[30\]\[22\] dp.rf.rf\[31\]\[22\] net210 VSS
+ VSS VDD VDD _0811_ sky130_fd_sc_hd__mux2i_1
X_4476_ net208 _0811_ net205 VSS VSS VDD VDD _0812_ sky130_fd_sc_hd__a21oi_1
X_4477_ net189 _0810_ _0812_ VSS VSS VDD VDD _0813_ sky130_fd_sc_hd__o21ai_0
X_4478_ dp.rf.rf\[24\]\[22\] dp.rf.rf\[25\]\[22\] dp.rf.rf\[28\]\[22\]
+ dp.rf.rf\[29\]\[22\] net210 net208 VSS VSS VDD VDD _0814_
+ sky130_fd_sc_hd__mux4_1
X_4479_ net205 _0814_ _0192_ VSS VSS VDD VDD _0815_ sky130_fd_sc_hd__a21oi_1
X_4480_ _0813_ _0815_ _0166_ VSS VSS VDD VDD _0816_ sky130_fd_sc_hd__a21oi_1
X_4481_ dp.rf.rf\[22\]\[22\] dp.rf.rf\[23\]\[22\] net210 VSS
+ VSS VDD VDD _0817_ sky130_fd_sc_hd__mux2_1
X_4482_ _0148_ _0817_ _0337_ VSS VSS VDD VDD _0818_ sky130_fd_sc_hd__o21ai_0
X_4483_ dp.rf.rf\[19\]\[22\] net210 net201 dp.rf.rf\[18\]\[22\]
+ net189 VSS VSS VDD VDD _0819_ sky130_fd_sc_hd__a221oi_1
X_4484_ dp.rf.rf\[20\]\[22\] VSS VSS VDD VDD _0820_ sky130_fd_sc_hd__inv_1
X_4485_ dp.rf.rf\[17\]\[22\] dp.rf.rf\[21\]\[22\] net208 VSS
+ VSS VDD VDD _0821_ sky130_fd_sc_hd__mux2i_1
X_4486_ _0820_ net204 _0821_ net210 net8 VSS VSS VDD VDD _0822_
+ sky130_fd_sc_hd__a221oi_1
X_4487_ dp.rf.rf\[16\]\[22\] net180 _0822_ net195 VSS VSS
+ VDD VDD _0823_ sky130_fd_sc_hd__o22ai_1
X_4488_ _0818_ _0819_ _0823_ VSS VSS VDD VDD _0824_ sky130_fd_sc_hd__o21ai_1
X_4489_ _0209_ _0801_ _0809_ _0816_ _0824_ VSS VSS VDD VDD
+ _3359_ sky130_fd_sc_hd__a32oi_4
X_4490_ _0057_ _0119_ _0304_ VSS VSS VDD VDD _3613_ sky130_fd_sc_hd__o21ai_1
X_4491_ dp.rf.rf\[24\]\[21\] dp.rf.rf\[25\]\[21\] dp.rf.rf\[26\]\[21\]
+ dp.rf.rf\[27\]\[21\] net213 net278 VSS VSS VDD VDD _0825_
+ sky130_fd_sc_hd__mux4_1
X_4492_ dp.rf.rf\[16\]\[21\] dp.rf.rf\[17\]\[21\] dp.rf.rf\[18\]\[21\]
+ dp.rf.rf\[19\]\[21\] net213 net278 VSS VSS VDD VDD _0826_
+ sky130_fd_sc_hd__mux4_1
X_4493_ dp.rf.rf\[28\]\[21\] dp.rf.rf\[29\]\[21\] dp.rf.rf\[30\]\[21\]
+ dp.rf.rf\[31\]\[21\] net213 net278 VSS VSS VDD VDD _0827_
+ sky130_fd_sc_hd__mux4_1
X_4494_ dp.rf.rf\[20\]\[21\] dp.rf.rf\[21\]\[21\] dp.rf.rf\[22\]\[21\]
+ dp.rf.rf\[23\]\[21\] net213 net278 VSS VSS VDD VDD _0828_
+ sky130_fd_sc_hd__mux4_1
X_4495_ _0825_ _0826_ _0827_ _0828_ _0103_ net15 VSS VSS VDD
+ VDD _0829_ sky130_fd_sc_hd__mux4_1
X_4496_ net17 _0829_ VSS VSS VDD VDD _0830_ sky130_fd_sc_hd__nand2_1
X_4497_ dp.rf.rf\[8\]\[21\] dp.rf.rf\[9\]\[21\] dp.rf.rf\[10\]\[21\]
+ dp.rf.rf\[11\]\[21\] net215 net14 VSS VSS VDD VDD _0831_ sky130_fd_sc_hd__mux4_1
X_4498_ dp.rf.rf\[0\]\[21\] dp.rf.rf\[1\]\[21\] dp.rf.rf\[2\]\[21\]
+ dp.rf.rf\[3\]\[21\] net215 net14 VSS VSS VDD VDD _0832_ sky130_fd_sc_hd__mux4_1
X_4499_ dp.rf.rf\[12\]\[21\] dp.rf.rf\[13\]\[21\] dp.rf.rf\[14\]\[21\]
+ dp.rf.rf\[15\]\[21\] net215 net14 VSS VSS VDD VDD _0833_ sky130_fd_sc_hd__mux4_1
X_4500_ dp.rf.rf\[4\]\[21\] dp.rf.rf\[5\]\[21\] dp.rf.rf\[6\]\[21\]
+ dp.rf.rf\[7\]\[21\] net215 net14 VSS VSS VDD VDD _0834_ sky130_fd_sc_hd__mux4_1
X_4501_ _0831_ _0832_ _0833_ _0834_ _0103_ net15 VSS VSS VDD
+ VDD _0835_ sky130_fd_sc_hd__mux4_1
X_4502_ _0086_ _0835_ VSS VSS VDD VDD _0836_ sky130_fd_sc_hd__nand2_1
X_4503_ _0830_ _0836_ VSS VSS VDD VDD _0837_ sky130_fd_sc_hd__nand2_2
X_4504_ _0311_ _0837_ VSS VSS VDD VDD _0838_ sky130_fd_sc_hd__nand2_4
X_4505_ _0138_ _0838_ VSS VSS VDD VDD _0839_ sky130_fd_sc_hd__nor2_1
X_4506_ _0138_ _3613_ _0839_ VSS VSS VDD VDD _0840_ sky130_fd_sc_hd__a21oi_1
X_4507_ _0122_ _0840_ VSS VSS VDD VDD _3364_ sky130_fd_sc_hd__xor2_1
X_4508_ _3364_ VSS VSS VDD VDD _3368_ sky130_fd_sc_hd__inv_1
X_4509_ dp.rf.rf\[26\]\[21\] dp.rf.rf\[27\]\[21\] dp.rf.rf\[30\]\[21\]
+ dp.rf.rf\[31\]\[21\] net7 net206 VSS VSS VDD VDD _0841_ sky130_fd_sc_hd__mux4_1
X_4510_ dp.rf.rf\[24\]\[21\] dp.rf.rf\[25\]\[21\] dp.rf.rf\[28\]\[21\]
+ dp.rf.rf\[29\]\[21\] net7 net206 VSS VSS VDD VDD _0842_ sky130_fd_sc_hd__mux4_1
X_4511_ _0337_ _0841_ _0842_ _0224_ net198 VSS VSS VDD VDD
+ _0843_ sky130_fd_sc_hd__a221o_1
X_4512_ dp.rf.rf\[22\]\[21\] dp.rf.rf\[23\]\[21\] net7 VSS
+ VSS VDD VDD _0844_ sky130_fd_sc_hd__mux2_1
X_4513_ _0148_ _0844_ _0337_ VSS VSS VDD VDD _0845_ sky130_fd_sc_hd__o21ai_0
X_4514_ dp.rf.rf\[19\]\[21\] net7 net201 dp.rf.rf\[18\]\[21\]
+ net189 VSS VSS VDD VDD _0846_ sky130_fd_sc_hd__a221oi_1
X_4515_ dp.rf.rf\[20\]\[21\] VSS VSS VDD VDD _0847_ sky130_fd_sc_hd__inv_1
X_4516_ dp.rf.rf\[17\]\[21\] dp.rf.rf\[21\]\[21\] net206 VSS
+ VSS VDD VDD _0848_ sky130_fd_sc_hd__mux2i_1
X_4517_ _0847_ net204 _0848_ net7 net8 VSS VSS VDD VDD _0849_
+ sky130_fd_sc_hd__a221oi_1
X_4518_ dp.rf.rf\[16\]\[21\] net180 _0849_ net195 VSS VSS
+ VDD VDD _0850_ sky130_fd_sc_hd__o22ai_1
X_4519_ _0845_ _0846_ _0850_ VSS VSS VDD VDD _0851_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_9_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4521_ dp.rf.rf\[10\]\[21\] dp.rf.rf\[11\]\[21\] dp.rf.rf\[14\]\[21\]
+ dp.rf.rf\[15\]\[21\] net211 net207 VSS VSS VDD VDD _0853_
+ sky130_fd_sc_hd__mux4_1
X_4522_ dp.rf.rf\[8\]\[21\] dp.rf.rf\[9\]\[21\] dp.rf.rf\[12\]\[21\]
+ dp.rf.rf\[13\]\[21\] net211 net207 VSS VSS VDD VDD _0854_
+ sky130_fd_sc_hd__mux4_1
X_4523_ _0853_ _0854_ _0224_ VSS VSS VDD VDD _0855_ sky130_fd_sc_hd__mux2i_1
X_4524_ dp.rf.rf\[2\]\[21\] dp.rf.rf\[3\]\[21\] dp.rf.rf\[6\]\[21\]
+ dp.rf.rf\[7\]\[21\] net211 net207 VSS VSS VDD VDD _0856_ sky130_fd_sc_hd__mux4_1
X_4525_ dp.rf.rf\[4\]\[21\] VSS VSS VDD VDD _0857_ sky130_fd_sc_hd__inv_1
X_4526_ dp.rf.rf\[1\]\[21\] dp.rf.rf\[5\]\[21\] net207 VSS
+ VSS VDD VDD _0858_ sky130_fd_sc_hd__mux2i_1
X_4527_ _0857_ net204 _0858_ net211 net8 VSS VSS VDD VDD _0859_
+ sky130_fd_sc_hd__a221oi_1
X_4528_ net8 _0856_ _0859_ net195 VSS VSS VDD VDD _0860_ sky130_fd_sc_hd__a211oi_1
X_4529_ net185 _0855_ _0860_ VSS VSS VDD VDD _0861_ sky130_fd_sc_hd__a21oi_2
X_4530_ net188 _0843_ _0851_ _0861_ _0209_ VSS VSS VDD VDD
+ _3367_ sky130_fd_sc_hd__a32oi_4
X_4531_ dp.rf.rf\[28\]\[20\] dp.rf.rf\[29\]\[20\] dp.rf.rf\[30\]\[20\]
+ dp.rf.rf\[31\]\[20\] net212 net274 VSS VSS VDD VDD _0862_
+ sky130_fd_sc_hd__mux4_1
X_4532_ net16 _0862_ VSS VSS VDD VDD _0863_ sky130_fd_sc_hd__nand2_1
X_4533_ dp.rf.rf\[20\]\[20\] dp.rf.rf\[21\]\[20\] dp.rf.rf\[22\]\[20\]
+ dp.rf.rf\[23\]\[20\] net213 net274 VSS VSS VDD VDD _0864_
+ sky130_fd_sc_hd__mux4_1
X_4534_ _0103_ _0864_ VSS VSS VDD VDD _0865_ sky130_fd_sc_hd__nand2_1
X_4535_ net15 _0863_ _0865_ VSS VSS VDD VDD _0866_ sky130_fd_sc_hd__nand3_1
X_4536_ dp.rf.rf\[24\]\[20\] dp.rf.rf\[25\]\[20\] dp.rf.rf\[26\]\[20\]
+ dp.rf.rf\[27\]\[20\] net212 net274 VSS VSS VDD VDD _0867_
+ sky130_fd_sc_hd__mux4_1
X_4537_ net16 _0867_ VSS VSS VDD VDD _0868_ sky130_fd_sc_hd__nand2_1
X_4538_ dp.rf.rf\[16\]\[20\] dp.rf.rf\[17\]\[20\] dp.rf.rf\[18\]\[20\]
+ dp.rf.rf\[19\]\[20\] net213 net274 VSS VSS VDD VDD _0869_
+ sky130_fd_sc_hd__mux4_1
X_4539_ _0103_ _0869_ VSS VSS VDD VDD _0870_ sky130_fd_sc_hd__nand2_1
X_4540_ _0286_ _0868_ _0870_ VSS VSS VDD VDD _0871_ sky130_fd_sc_hd__nand3_1
X_4541_ dp.rf.rf\[12\]\[20\] dp.rf.rf\[13\]\[20\] dp.rf.rf\[14\]\[20\]
+ dp.rf.rf\[15\]\[20\] net215 net14 VSS VSS VDD VDD _0872_ sky130_fd_sc_hd__mux4_1
X_4542_ dp.rf.rf\[4\]\[20\] dp.rf.rf\[5\]\[20\] dp.rf.rf\[6\]\[20\]
+ dp.rf.rf\[7\]\[20\] net215 net274 VSS VSS VDD VDD _0873_ sky130_fd_sc_hd__mux4_1
X_4543_ _0872_ _0873_ _0103_ VSS VSS VDD VDD _0874_ sky130_fd_sc_hd__mux2i_1
X_4544_ dp.rf.rf\[8\]\[20\] dp.rf.rf\[9\]\[20\] dp.rf.rf\[10\]\[20\]
+ dp.rf.rf\[11\]\[20\] net215 net14 VSS VSS VDD VDD _0875_ sky130_fd_sc_hd__mux4_1
X_4545_ net16 _0875_ VSS VSS VDD VDD _0876_ sky130_fd_sc_hd__nand2_1
X_4546_ dp.rf.rf\[0\]\[20\] dp.rf.rf\[1\]\[20\] dp.rf.rf\[2\]\[20\]
+ dp.rf.rf\[3\]\[20\] net215 net274 VSS VSS VDD VDD _0877_ sky130_fd_sc_hd__mux4_1
X_4547_ _0103_ _0877_ VSS VSS VDD VDD _0878_ sky130_fd_sc_hd__nand2_1
X_4548_ _0286_ _0876_ _0878_ VSS VSS VDD VDD _0879_ sky130_fd_sc_hd__and3_1
X_4549_ net15 _0874_ _0879_ VSS VSS VDD VDD _0880_ sky130_fd_sc_hd__a21oi_2
X_4550_ net17 _0866_ _0871_ _0880_ _0290_ VSS VSS VDD VDD
+ _0881_ sky130_fd_sc_hd__a32oi_4
XTAP_TAPCELL_ROW_9_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4553_ net213 _0130_ VSS VSS VDD VDD _0884_ sky130_fd_sc_hd__nand2_1
X_4554_ _0304_ _0884_ VSS VSS VDD VDD _3609_ sky130_fd_sc_hd__nand2_1
X_4555_ net179 _3609_ VSS VSS VDD VDD _0885_ sky130_fd_sc_hd__nor2_1
X_4556_ net179 _0881_ _0885_ VSS VSS VDD VDD _0886_ sky130_fd_sc_hd__a21oi_1
X_4557_ _0122_ _0886_ VSS VSS VDD VDD _3372_ sky130_fd_sc_hd__xnor2_1
X_4558_ _3372_ VSS VSS VDD VDD _3376_ sky130_fd_sc_hd__inv_1
X_4559_ dp.rf.rf\[22\]\[20\] dp.rf.rf\[23\]\[20\] net211 VSS
+ VSS VDD VDD _0887_ sky130_fd_sc_hd__mux2_1
X_4560_ _0148_ _0887_ net182 VSS VSS VDD VDD _0888_ sky130_fd_sc_hd__o21ai_0
X_4561_ dp.rf.rf\[19\]\[20\] net211 net201 dp.rf.rf\[18\]\[20\]
+ net190 VSS VSS VDD VDD _0889_ sky130_fd_sc_hd__a221oi_1
X_4562_ dp.rf.rf\[20\]\[20\] VSS VSS VDD VDD _0890_ sky130_fd_sc_hd__inv_1
X_4563_ dp.rf.rf\[17\]\[20\] dp.rf.rf\[21\]\[20\] net206 VSS
+ VSS VDD VDD _0891_ sky130_fd_sc_hd__mux2i_1
X_4564_ _0890_ net204 _0891_ net211 net8 VSS VSS VDD VDD _0892_
+ sky130_fd_sc_hd__a221oi_1
X_4565_ dp.rf.rf\[16\]\[20\] net180 _0892_ net195 VSS VSS
+ VDD VDD _0893_ sky130_fd_sc_hd__o22ai_1
X_4566_ _0888_ _0889_ _0893_ VSS VSS VDD VDD _0894_ sky130_fd_sc_hd__o21ai_1
X_4567_ dp.rf.rf\[26\]\[20\] dp.rf.rf\[27\]\[20\] dp.rf.rf\[30\]\[20\]
+ dp.rf.rf\[31\]\[20\] net211 net206 VSS VSS VDD VDD _0895_
+ sky130_fd_sc_hd__mux4_1
X_4568_ dp.rf.rf\[25\]\[20\] dp.rf.rf\[29\]\[20\] net206 VSS
+ VSS VDD VDD _0896_ sky130_fd_sc_hd__mux2i_1
X_4569_ dp.rf.rf\[24\]\[20\] dp.rf.rf\[28\]\[20\] net206 VSS
+ VSS VDD VDD _0897_ sky130_fd_sc_hd__mux2i_1
X_4570_ _0415_ _0896_ _0897_ _0170_ VSS VSS VDD VDD _0898_
+ sky130_fd_sc_hd__o22ai_1
X_4571_ net8 _0895_ _0898_ net198 VSS VSS VDD VDD _0899_ sky130_fd_sc_hd__a211o_1
X_4572_ dp.rf.rf\[9\]\[20\] dp.rf.rf\[11\]\[20\] dp.rf.rf\[13\]\[20\]
+ dp.rf.rf\[15\]\[20\] net8 net207 VSS VSS VDD VDD _0900_ sky130_fd_sc_hd__mux4_1
X_4573_ net211 _0900_ VSS VSS VDD VDD _0901_ sky130_fd_sc_hd__nand2_1
X_4574_ dp.rf.rf\[8\]\[20\] dp.rf.rf\[10\]\[20\] dp.rf.rf\[12\]\[20\]
+ dp.rf.rf\[14\]\[20\] net8 net207 VSS VSS VDD VDD _0902_ sky130_fd_sc_hd__mux4_1
X_4575_ _0245_ _0902_ VSS VSS VDD VDD _0903_ sky130_fd_sc_hd__nand2_1
X_4576_ net185 _0901_ _0903_ _0271_ VSS VSS VDD VDD _0904_
+ sky130_fd_sc_hd__a31oi_4
X_4577_ dp.rf.rf\[6\]\[20\] dp.rf.rf\[7\]\[20\] net211 VSS
+ VSS VDD VDD _0905_ sky130_fd_sc_hd__mux2_1
X_4578_ _0148_ _0905_ net182 VSS VSS VDD VDD _0906_ sky130_fd_sc_hd__o21ai_0
X_4579_ dp.rf.rf\[3\]\[20\] net211 net201 dp.rf.rf\[2\]\[20\]
+ net190 VSS VSS VDD VDD _0907_ sky130_fd_sc_hd__a221oi_1
X_4580_ dp.rf.rf\[4\]\[20\] VSS VSS VDD VDD _0908_ sky130_fd_sc_hd__inv_1
X_4581_ dp.rf.rf\[1\]\[20\] dp.rf.rf\[5\]\[20\] net207 VSS
+ VSS VDD VDD _0909_ sky130_fd_sc_hd__mux2i_1
X_4582_ _0908_ net204 _0909_ net211 net8 VSS VSS VDD VDD _0910_
+ sky130_fd_sc_hd__a221oi_1
X_4583_ dp.rf.rf\[0\]\[20\] net180 _0910_ net195 VSS VSS VDD
+ VDD _0911_ sky130_fd_sc_hd__o22ai_1
X_4584_ _0906_ _0907_ _0911_ VSS VSS VDD VDD _0912_ sky130_fd_sc_hd__o21ai_2
X_4585_ net188 _0894_ _0899_ _0904_ _0912_ VSS VSS VDD VDD
+ _3375_ sky130_fd_sc_hd__a32oi_4
X_4586_ net26 _0128_ VSS VSS VDD VDD _0913_ sky130_fd_sc_hd__nand2_4
X_4587_ net25 _0119_ _0913_ VSS VSS VDD VDD _0914_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_8_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4589_ net10 _0130_ _0133_ net11 _0914_ VSS VSS VDD VDD _0916_
+ sky130_fd_sc_hd__a221oi_2
X_4590_ _0120_ _0913_ VSS VSS VDD VDD _0917_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_8_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4592_ net25 _0119_ VSS VSS VDD VDD _0919_ sky130_fd_sc_hd__and2_0
X_4593_ net11 _0130_ _0919_ _0917_ VSS VSS VDD VDD _0920_
+ sky130_fd_sc_hd__a211oi_1
X_4594_ _0916_ _0917_ _0920_ VSS VSS VDD VDD _3605_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_8_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4597_ dp.rf.rf\[28\]\[19\] dp.rf.rf\[29\]\[19\] dp.rf.rf\[30\]\[19\]
+ dp.rf.rf\[31\]\[19\] net212 net274 VSS VSS VDD VDD _0923_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_8_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4602_ dp.rf.rf\[20\]\[19\] dp.rf.rf\[21\]\[19\] dp.rf.rf\[22\]\[19\]
+ dp.rf.rf\[23\]\[19\] net212 net274 VSS VSS VDD VDD _0928_
+ sky130_fd_sc_hd__mux4_1
X_4603_ _0104_ _0923_ _0928_ _0102_ VSS VSS VDD VDD _0929_
+ sky130_fd_sc_hd__a22oi_2
X_4604_ _0103_ _0064_ VSS VSS VDD VDD _0930_ sky130_fd_sc_hd__nor2_1
X_4605_ dp.rf.rf\[12\]\[19\] dp.rf.rf\[13\]\[19\] dp.rf.rf\[14\]\[19\]
+ dp.rf.rf\[15\]\[19\] net213 net274 VSS VSS VDD VDD _0931_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_8_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4608_ dp.rf.rf\[4\]\[19\] dp.rf.rf\[5\]\[19\] dp.rf.rf\[6\]\[19\]
+ dp.rf.rf\[7\]\[19\] net213 net274 VSS VSS VDD VDD _0934_ sky130_fd_sc_hd__mux4_1
X_4609_ net16 _0064_ VSS VSS VDD VDD _0935_ sky130_fd_sc_hd__nor2_2
X_4610_ _0930_ _0931_ _0934_ _0935_ VSS VSS VDD VDD _0936_
+ sky130_fd_sc_hd__a22oi_2
X_4611_ dp.rf.rf\[26\]\[19\] dp.rf.rf\[27\]\[19\] net212 VSS
+ VSS VDD VDD _0937_ sky130_fd_sc_hd__mux2i_1
X_4612_ dp.rf.rf\[24\]\[19\] dp.rf.rf\[25\]\[19\] net212 VSS
+ VSS VDD VDD _0938_ sky130_fd_sc_hd__mux2i_1
X_4613_ _0066_ _0937_ _0938_ _0061_ VSS VSS VDD VDD _0939_
+ sky130_fd_sc_hd__a22oi_1
X_4614_ dp.rf.rf\[18\]\[19\] dp.rf.rf\[19\]\[19\] net212 VSS
+ VSS VDD VDD _0940_ sky130_fd_sc_hd__mux2i_1
X_4615_ dp.rf.rf\[16\]\[19\] dp.rf.rf\[17\]\[19\] net212 VSS
+ VSS VDD VDD _0941_ sky130_fd_sc_hd__mux2i_1
X_4616_ _0081_ _0940_ _0941_ _0054_ VSS VSS VDD VDD _0942_
+ sky130_fd_sc_hd__a22oi_1
X_4617_ _0088_ _0939_ _0942_ VSS VSS VDD VDD _0943_ sky130_fd_sc_hd__nand3_1
X_4618_ net17 net15 _0103_ VSS VSS VDD VDD _0944_ sky130_fd_sc_hd__nor3_1
X_4619_ dp.rf.rf\[8\]\[19\] dp.rf.rf\[9\]\[19\] dp.rf.rf\[10\]\[19\]
+ dp.rf.rf\[11\]\[19\] net213 net274 VSS VSS VDD VDD _0945_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_8_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4621_ dp.rf.rf\[0\]\[19\] dp.rf.rf\[1\]\[19\] dp.rf.rf\[2\]\[19\]
+ dp.rf.rf\[3\]\[19\] net213 net274 VSS VSS VDD VDD _0947_ sky130_fd_sc_hd__mux4_1
X_4622_ net17 net15 net16 _0289_ VSS VSS VDD VDD _0948_ sky130_fd_sc_hd__nor4_4
X_4623_ _0944_ _0945_ _0947_ _0948_ VSS VSS VDD VDD _0949_
+ sky130_fd_sc_hd__a22oi_2
X_4624_ _0929_ _0936_ _0943_ _0949_ VSS VSS VDD VDD _0950_
+ sky130_fd_sc_hd__nand4_4
X_4625_ _3605_ _0950_ net179 VSS VSS VDD VDD _0951_ sky130_fd_sc_hd__mux2i_1
X_4626_ _0122_ _0951_ VSS VSS VDD VDD _3380_ sky130_fd_sc_hd__xor2_1
X_4627_ _3380_ VSS VSS VDD VDD _3384_ sky130_fd_sc_hd__inv_1
X_4628_ _0231_ net196 VSS VSS VDD VDD _0952_ sky130_fd_sc_hd__nor2_4
X_4629_ dp.rf.rf\[18\]\[19\] dp.rf.rf\[19\]\[19\] dp.rf.rf\[22\]\[19\]
+ dp.rf.rf\[23\]\[19\] net209 net206 VSS VSS VDD VDD _0953_
+ sky130_fd_sc_hd__mux4_1
X_4630_ net8 _0953_ VSS VSS VDD VDD _0954_ sky130_fd_sc_hd__nand2_1
X_4631_ net210 net208 VSS VSS VDD VDD _0955_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_8_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4633_ dp.rf.rf\[16\]\[19\] _0955_ VSS VSS VDD VDD _0957_
+ sky130_fd_sc_hd__nor2_1
X_4634_ dp.rf.rf\[16\]\[19\] _0119_ VSS VSS VDD VDD _0958_
+ sky130_fd_sc_hd__nor2_1
X_4635_ dp.rf.rf\[17\]\[19\] dp.rf.rf\[21\]\[19\] net206 VSS
+ VSS VDD VDD _0959_ sky130_fd_sc_hd__mux2_1
X_4636_ dp.rf.rf\[20\]\[19\] _0528_ _0959_ _0245_ net205 VSS
+ VSS VDD VDD _0960_ sky130_fd_sc_hd__o221ai_1
X_4637_ _0119_ _0954_ _0960_ VSS VSS VDD VDD _0961_ sky130_fd_sc_hd__and3_1
X_4638_ _0954_ _0957_ _0958_ _0961_ VSS VSS VDD VDD _0962_
+ sky130_fd_sc_hd__a211oi_2
X_4639_ net11 _0256_ VSS VSS VDD VDD _0963_ sky130_fd_sc_hd__nand2_4
X_4640_ dp.rf.rf\[26\]\[19\] dp.rf.rf\[27\]\[19\] dp.rf.rf\[30\]\[19\]
+ dp.rf.rf\[31\]\[19\] net209 net206 VSS VSS VDD VDD _0964_
+ sky130_fd_sc_hd__mux4_1
X_4641_ net205 _0964_ VSS VSS VDD VDD _0965_ sky130_fd_sc_hd__nor2_1
X_4642_ dp.rf.rf\[24\]\[19\] dp.rf.rf\[25\]\[19\] dp.rf.rf\[28\]\[19\]
+ dp.rf.rf\[29\]\[19\] net209 net206 VSS VSS VDD VDD _0966_
+ sky130_fd_sc_hd__mux4_1
X_4643_ net8 _0966_ VSS VSS VDD VDD _0967_ sky130_fd_sc_hd__nor2_1
X_4644_ _0963_ _0965_ _0967_ VSS VSS VDD VDD _0968_ sky130_fd_sc_hd__nor3_1
X_4645_ _0115_ _0117_ _0347_ VSS VSS VDD VDD _0969_ sky130_fd_sc_hd__a21oi_4
X_4646_ dp.rf.rf\[12\]\[19\] VSS VSS VDD VDD _0970_ sky130_fd_sc_hd__inv_1
X_4647_ dp.rf.rf\[9\]\[19\] dp.rf.rf\[13\]\[19\] net206 VSS
+ VSS VDD VDD _0971_ sky130_fd_sc_hd__mux2i_1
X_4648_ _0970_ net203 _0971_ net209 net8 VSS VSS VDD VDD _0972_
+ sky130_fd_sc_hd__a221oi_1
X_4649_ dp.rf.rf\[8\]\[19\] _0969_ _0972_ VSS VSS VDD VDD
+ _0973_ sky130_fd_sc_hd__o21ai_0
X_4650_ dp.rf.rf\[10\]\[19\] dp.rf.rf\[11\]\[19\] dp.rf.rf\[14\]\[19\]
+ dp.rf.rf\[15\]\[19\] net209 net206 VSS VSS VDD VDD _0974_
+ sky130_fd_sc_hd__mux4_1
X_4651_ net8 _0974_ net199 VSS VSS VDD VDD _0975_ sky130_fd_sc_hd__a21oi_1
X_4652_ dp.rf.rf\[2\]\[19\] dp.rf.rf\[3\]\[19\] dp.rf.rf\[6\]\[19\]
+ dp.rf.rf\[7\]\[19\] net209 net206 VSS VSS VDD VDD _0976_ sky130_fd_sc_hd__mux4_1
X_4653_ net8 _0976_ VSS VSS VDD VDD _0977_ sky130_fd_sc_hd__and2_0
X_4654_ dp.rf.rf\[4\]\[19\] VSS VSS VDD VDD _0978_ sky130_fd_sc_hd__inv_1
X_4655_ dp.rf.rf\[1\]\[19\] dp.rf.rf\[5\]\[19\] net206 VSS
+ VSS VDD VDD _0979_ sky130_fd_sc_hd__mux2i_1
X_4656_ _0978_ net203 _0979_ net209 net8 VSS VSS VDD VDD _0980_
+ sky130_fd_sc_hd__a221oi_1
X_4657_ net196 _0977_ _0980_ net194 VSS VSS VDD VDD _0981_
+ sky130_fd_sc_hd__o31ai_1
X_4658_ _0973_ _0975_ _0981_ VSS VSS VDD VDD _0982_ sky130_fd_sc_hd__a21oi_2
X_4659_ _0952_ _0962_ _0968_ _0982_ VSS VSS VDD VDD _3383_
+ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_8_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4662_ dp.rf.rf\[28\]\[18\] dp.rf.rf\[29\]\[18\] dp.rf.rf\[30\]\[18\]
+ dp.rf.rf\[31\]\[18\] net212 net274 VSS VSS VDD VDD _0985_
+ sky130_fd_sc_hd__mux4_1
X_4663_ dp.rf.rf\[20\]\[18\] dp.rf.rf\[21\]\[18\] dp.rf.rf\[22\]\[18\]
+ dp.rf.rf\[23\]\[18\] net212 net274 VSS VSS VDD VDD _0986_
+ sky130_fd_sc_hd__mux4_1
X_4664_ _0104_ _0985_ _0986_ _0102_ VSS VSS VDD VDD _0987_
+ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_7_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4666_ dp.rf.rf\[12\]\[18\] dp.rf.rf\[13\]\[18\] dp.rf.rf\[14\]\[18\]
+ dp.rf.rf\[15\]\[18\] net212 net274 VSS VSS VDD VDD _0989_
+ sky130_fd_sc_hd__mux4_1
X_4667_ dp.rf.rf\[4\]\[18\] dp.rf.rf\[5\]\[18\] dp.rf.rf\[6\]\[18\]
+ dp.rf.rf\[7\]\[18\] net212 net274 VSS VSS VDD VDD _0990_ sky130_fd_sc_hd__mux4_1
X_4668_ _0930_ _0989_ _0990_ _0935_ VSS VSS VDD VDD _0991_
+ sky130_fd_sc_hd__a22oi_1
X_4669_ dp.rf.rf\[26\]\[18\] dp.rf.rf\[27\]\[18\] net212 VSS
+ VSS VDD VDD _0992_ sky130_fd_sc_hd__mux2i_1
X_4670_ dp.rf.rf\[24\]\[18\] dp.rf.rf\[25\]\[18\] net212 VSS
+ VSS VDD VDD _0993_ sky130_fd_sc_hd__mux2i_1
X_4671_ _0066_ _0992_ _0993_ _0061_ VSS VSS VDD VDD _0994_
+ sky130_fd_sc_hd__a22oi_1
X_4672_ dp.rf.rf\[18\]\[18\] dp.rf.rf\[19\]\[18\] net212 VSS
+ VSS VDD VDD _0995_ sky130_fd_sc_hd__mux2i_1
X_4673_ dp.rf.rf\[16\]\[18\] dp.rf.rf\[17\]\[18\] net212 VSS
+ VSS VDD VDD _0996_ sky130_fd_sc_hd__mux2i_1
X_4674_ _0081_ _0995_ _0996_ _0054_ VSS VSS VDD VDD _0997_
+ sky130_fd_sc_hd__a22oi_1
X_4675_ _0088_ _0994_ _0997_ VSS VSS VDD VDD _0998_ sky130_fd_sc_hd__nand3_1
X_4676_ dp.rf.rf\[8\]\[18\] dp.rf.rf\[9\]\[18\] dp.rf.rf\[10\]\[18\]
+ dp.rf.rf\[11\]\[18\] net212 net274 VSS VSS VDD VDD _0999_
+ sky130_fd_sc_hd__mux4_1
X_4677_ dp.rf.rf\[0\]\[18\] dp.rf.rf\[1\]\[18\] dp.rf.rf\[2\]\[18\]
+ dp.rf.rf\[3\]\[18\] net212 net274 VSS VSS VDD VDD _1000_ sky130_fd_sc_hd__mux4_1
X_4678_ _0944_ _0999_ _1000_ _0948_ VSS VSS VDD VDD _1001_
+ sky130_fd_sc_hd__a22oi_1
X_4679_ _0987_ _0991_ _0998_ _1001_ VSS VSS VDD VDD _1002_
+ sky130_fd_sc_hd__and4_2
X_4680_ net208 _0130_ _0133_ net10 _0914_ VSS VSS VDD VDD
+ _1003_ sky130_fd_sc_hd__a221oi_2
X_4681_ _0916_ _1003_ _0917_ VSS VSS VDD VDD _3601_ sky130_fd_sc_hd__mux2i_2
X_4682_ net179 _3601_ VSS VSS VDD VDD _1004_ sky130_fd_sc_hd__nor2_1
X_4683_ net179 _1002_ _1004_ VSS VSS VDD VDD _1005_ sky130_fd_sc_hd__a21oi_1
X_4684_ _0122_ _1005_ VSS VSS VDD VDD _3388_ sky130_fd_sc_hd__xnor2_1
X_4685_ _3388_ VSS VSS VDD VDD _3392_ sky130_fd_sc_hd__inv_1
X_4686_ dp.rf.rf\[28\]\[18\] VSS VSS VDD VDD _1006_ sky130_fd_sc_hd__inv_1
X_4687_ dp.rf.rf\[25\]\[18\] dp.rf.rf\[29\]\[18\] net206 VSS
+ VSS VDD VDD _1007_ sky130_fd_sc_hd__mux2i_1
X_4688_ _1006_ net203 _1007_ net209 net8 VSS VSS VDD VDD _1008_
+ sky130_fd_sc_hd__a221oi_1
X_4689_ dp.rf.rf\[24\]\[18\] _0969_ _1008_ _0130_ VSS VSS
+ VDD VDD _1009_ sky130_fd_sc_hd__o22ai_2
X_4690_ dp.rf.rf\[26\]\[18\] dp.rf.rf\[27\]\[18\] dp.rf.rf\[30\]\[18\]
+ dp.rf.rf\[31\]\[18\] net209 net206 VSS VSS VDD VDD _1010_
+ sky130_fd_sc_hd__mux4_1
X_4691_ net182 _1010_ VSS VSS VDD VDD _1011_ sky130_fd_sc_hd__nand2_1
X_4692_ dp.rf.rf\[20\]\[18\] VSS VSS VDD VDD _1012_ sky130_fd_sc_hd__inv_1
X_4693_ dp.rf.rf\[17\]\[18\] dp.rf.rf\[21\]\[18\] net206 VSS
+ VSS VDD VDD _1013_ sky130_fd_sc_hd__mux2i_1
X_4694_ _1012_ net203 _1013_ net209 net8 VSS VSS VDD VDD _1014_
+ sky130_fd_sc_hd__a221oi_1
X_4695_ dp.rf.rf\[16\]\[18\] _0955_ _1014_ _0130_ VSS VSS
+ VDD VDD _1015_ sky130_fd_sc_hd__o22ai_2
X_4696_ dp.rf.rf\[18\]\[18\] dp.rf.rf\[19\]\[18\] dp.rf.rf\[22\]\[18\]
+ dp.rf.rf\[23\]\[18\] net209 net206 VSS VSS VDD VDD _1016_
+ sky130_fd_sc_hd__mux4_1
X_4697_ net8 _1016_ net10 VSS VSS VDD VDD _1017_ sky130_fd_sc_hd__a21oi_1
X_4698_ net10 _1009_ _1011_ _1015_ _1017_ VSS VSS VDD VDD
+ _1018_ sky130_fd_sc_hd__a32oi_4
X_4699_ dp.rf.rf\[12\]\[18\] VSS VSS VDD VDD _1019_ sky130_fd_sc_hd__inv_1
X_4700_ dp.rf.rf\[9\]\[18\] dp.rf.rf\[13\]\[18\] net206 VSS
+ VSS VDD VDD _1020_ sky130_fd_sc_hd__mux2i_1
X_4701_ _1019_ net203 _1020_ net209 net8 VSS VSS VDD VDD _1021_
+ sky130_fd_sc_hd__a221oi_1
X_4702_ dp.rf.rf\[8\]\[18\] _0969_ _1021_ VSS VSS VDD VDD
+ _1022_ sky130_fd_sc_hd__o21ai_1
X_4703_ dp.rf.rf\[10\]\[18\] dp.rf.rf\[11\]\[18\] dp.rf.rf\[14\]\[18\]
+ dp.rf.rf\[15\]\[18\] net209 net206 VSS VSS VDD VDD _1023_
+ sky130_fd_sc_hd__mux4_1
X_4704_ net8 _1023_ net199 VSS VSS VDD VDD _1024_ sky130_fd_sc_hd__a21oi_1
X_4705_ dp.rf.rf\[2\]\[18\] dp.rf.rf\[3\]\[18\] dp.rf.rf\[6\]\[18\]
+ dp.rf.rf\[7\]\[18\] net209 net206 VSS VSS VDD VDD _1025_ sky130_fd_sc_hd__mux4_1
X_4706_ dp.rf.rf\[4\]\[18\] VSS VSS VDD VDD _1026_ sky130_fd_sc_hd__inv_1
X_4707_ dp.rf.rf\[1\]\[18\] dp.rf.rf\[5\]\[18\] net206 VSS
+ VSS VDD VDD _1027_ sky130_fd_sc_hd__mux2i_1
X_4708_ _1026_ net203 _1027_ net209 net8 VSS VSS VDD VDD _1028_
+ sky130_fd_sc_hd__a221oi_1
X_4709_ net8 _1025_ _1028_ net196 VSS VSS VDD VDD _1029_ sky130_fd_sc_hd__a211oi_1
X_4710_ _1022_ _1024_ _1029_ VSS VSS VDD VDD _1030_ sky130_fd_sc_hd__a21oi_2
X_4711_ net187 _1018_ _1030_ net194 VSS VSS VDD VDD _1031_
+ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_7_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4713_ dp.rf.rf\[26\]\[17\] dp.rf.rf\[27\]\[17\] net212 VSS
+ VSS VDD VDD _1032_ sky130_fd_sc_hd__mux2i_1
X_4714_ dp.rf.rf\[24\]\[17\] dp.rf.rf\[25\]\[17\] net212 VSS
+ VSS VDD VDD _1033_ sky130_fd_sc_hd__mux2i_1
X_4715_ _0066_ _1032_ _1033_ _0061_ VSS VSS VDD VDD _1034_
+ sky130_fd_sc_hd__a22oi_1
X_4716_ dp.rf.rf\[18\]\[17\] dp.rf.rf\[19\]\[17\] net212 VSS
+ VSS VDD VDD _1035_ sky130_fd_sc_hd__mux2i_1
X_4717_ dp.rf.rf\[16\]\[17\] dp.rf.rf\[17\]\[17\] net212 VSS
+ VSS VDD VDD _1036_ sky130_fd_sc_hd__mux2i_1
X_4718_ _0081_ _1035_ _1036_ _0054_ VSS VSS VDD VDD _1037_
+ sky130_fd_sc_hd__a22oi_1
X_4719_ _0088_ _1034_ _1037_ VSS VSS VDD VDD _1038_ sky130_fd_sc_hd__nand3_1
X_4720_ dp.rf.rf\[4\]\[17\] VSS VSS VDD VDD _1039_ sky130_fd_sc_hd__inv_1
X_4721_ net212 dp.rf.rf\[5\]\[17\] VSS VSS VDD VDD _1040_
+ sky130_fd_sc_hd__nand2_1
X_4722_ net212 _1039_ _0054_ _1040_ VSS VSS VDD VDD _1041_
+ sky130_fd_sc_hd__o211ai_1
X_4723_ dp.rf.rf\[6\]\[17\] dp.rf.rf\[7\]\[17\] net212 VSS
+ VSS VDD VDD _1042_ sky130_fd_sc_hd__mux2i_1
X_4724_ dp.rf.rf\[12\]\[17\] dp.rf.rf\[13\]\[17\] net212 VSS
+ VSS VDD VDD _1043_ sky130_fd_sc_hd__mux2i_1
X_4725_ _0081_ _1042_ _1043_ _0061_ VSS VSS VDD VDD _1044_
+ sky130_fd_sc_hd__a22oi_1
X_4726_ dp.rf.rf\[14\]\[17\] dp.rf.rf\[15\]\[17\] net212 VSS
+ VSS VDD VDD _1045_ sky130_fd_sc_hd__mux2i_1
X_4727_ _0066_ _1045_ _0064_ VSS VSS VDD VDD _1046_ sky130_fd_sc_hd__a21oi_1
X_4728_ _1041_ _1044_ _1046_ VSS VSS VDD VDD _1047_ sky130_fd_sc_hd__nand3_1
X_4729_ dp.rf.rf\[8\]\[17\] dp.rf.rf\[9\]\[17\] net212 VSS
+ VSS VDD VDD _1048_ sky130_fd_sc_hd__mux2i_1
X_4730_ dp.rf.rf\[10\]\[17\] dp.rf.rf\[11\]\[17\] net212 VSS
+ VSS VDD VDD _1049_ sky130_fd_sc_hd__mux2i_2
X_4731_ _0061_ _1048_ _1049_ _0066_ VSS VSS VDD VDD _1050_
+ sky130_fd_sc_hd__a22oi_1
X_4732_ dp.rf.rf\[2\]\[17\] dp.rf.rf\[3\]\[17\] net212 VSS
+ VSS VDD VDD _1051_ sky130_fd_sc_hd__mux2i_1
X_4733_ _0081_ _1051_ VSS VSS VDD VDD _1052_ sky130_fd_sc_hd__nand2_1
X_4734_ net212 dp.rf.rf\[1\]\[17\] VSS VSS VDD VDD _1053_
+ sky130_fd_sc_hd__nand2_1
X_4735_ _0054_ _1053_ VSS VSS VDD VDD _1054_ sky130_fd_sc_hd__nand2_1
X_4736_ _0046_ _1050_ _1052_ _1054_ VSS VSS VDD VDD _1055_
+ sky130_fd_sc_hd__nand4_1
X_4737_ dp.rf.rf\[28\]\[17\] dp.rf.rf\[29\]\[17\] dp.rf.rf\[30\]\[17\]
+ dp.rf.rf\[31\]\[17\] net212 net274 VSS VSS VDD VDD _1056_
+ sky130_fd_sc_hd__mux4_1
X_4738_ dp.rf.rf\[20\]\[17\] dp.rf.rf\[21\]\[17\] dp.rf.rf\[22\]\[17\]
+ dp.rf.rf\[23\]\[17\] net212 net274 VSS VSS VDD VDD _1057_
+ sky130_fd_sc_hd__mux4_1
X_4739_ _0104_ _1056_ _1057_ _0102_ VSS VSS VDD VDD _1058_
+ sky130_fd_sc_hd__a22oi_2
X_4740_ _1038_ _1047_ _1055_ _1058_ VSS VSS VDD VDD _1059_
+ sky130_fd_sc_hd__nand4_4
X_4741_ _1059_ VSS VSS VDD VDD _1060_ sky130_fd_sc_hd__clkinvlp_4
X_4742_ net25 _0119_ _0913_ VSS VSS VDD VDD _1061_ sky130_fd_sc_hd__nand3_1
X_4743_ net8 _0130_ _0133_ net208 VSS VSS VDD VDD _1062_ sky130_fd_sc_hd__a22oi_1
X_4744_ _1061_ _0917_ _1062_ VSS VSS VDD VDD _1063_ sky130_fd_sc_hd__and3_1
X_4745_ _0120_ _0913_ _1003_ _1063_ VSS VSS VDD VDD _3597_
+ sky130_fd_sc_hd__a31oi_2
X_4746_ net179 _3597_ VSS VSS VDD VDD _1064_ sky130_fd_sc_hd__nor2_1
X_4747_ net179 _1060_ _1064_ VSS VSS VDD VDD _1065_ sky130_fd_sc_hd__a21oi_1
X_4748_ _0122_ _1065_ VSS VSS VDD VDD _3396_ sky130_fd_sc_hd__xnor2_1
X_4749_ _3396_ VSS VSS VDD VDD _3400_ sky130_fd_sc_hd__inv_1
X_4750_ dp.rf.rf\[18\]\[17\] dp.rf.rf\[22\]\[17\] net206 VSS
+ VSS VDD VDD _1066_ sky130_fd_sc_hd__mux2i_1
X_4751_ net205 _1066_ _0148_ _0245_ VSS VSS VDD VDD _1067_
+ sky130_fd_sc_hd__o211ai_1
X_4752_ _0119_ _1067_ dp.rf.rf\[16\]\[17\] VSS VSS VDD VDD
+ _1068_ sky130_fd_sc_hd__a21oi_1
X_4753_ dp.rf.rf\[19\]\[17\] dp.rf.rf\[23\]\[17\] net206 VSS
+ VSS VDD VDD _1069_ sky130_fd_sc_hd__mux2i_1
X_4754_ net209 net8 VSS VSS VDD VDD _1070_ sky130_fd_sc_hd__nand2_2
X_4755_ _0247_ _1066_ _1069_ _1070_ VSS VSS VDD VDD _1071_
+ sky130_fd_sc_hd__o22ai_1
X_4756_ dp.rf.rf\[20\]\[17\] VSS VSS VDD VDD _1072_ sky130_fd_sc_hd__inv_1
X_4757_ dp.rf.rf\[17\]\[17\] dp.rf.rf\[21\]\[17\] net206 VSS
+ VSS VDD VDD _1073_ sky130_fd_sc_hd__mux2i_1
X_4758_ _1072_ net203 _1073_ net209 net8 VSS VSS VDD VDD _1074_
+ sky130_fd_sc_hd__a221oi_1
X_4759_ _0130_ _1071_ _1074_ VSS VSS VDD VDD _1075_ sky130_fd_sc_hd__nor3_1
X_4760_ _0231_ net196 _1068_ _1075_ VSS VSS VDD VDD _1076_
+ sky130_fd_sc_hd__nor4_1
X_4761_ dp.rf.rf\[26\]\[17\] dp.rf.rf\[27\]\[17\] dp.rf.rf\[30\]\[17\]
+ dp.rf.rf\[31\]\[17\] net209 net206 VSS VSS VDD VDD _1077_
+ sky130_fd_sc_hd__mux4_1
X_4762_ net8 _1077_ VSS VSS VDD VDD _1078_ sky130_fd_sc_hd__nand2_1
X_4763_ dp.rf.rf\[28\]\[17\] VSS VSS VDD VDD _1079_ sky130_fd_sc_hd__inv_1
X_4764_ dp.rf.rf\[25\]\[17\] dp.rf.rf\[29\]\[17\] net206 VSS
+ VSS VDD VDD _1080_ sky130_fd_sc_hd__mux2i_1
X_4765_ _1079_ net203 _1080_ net209 net8 VSS VSS VDD VDD _1081_
+ sky130_fd_sc_hd__a221oi_1
X_4766_ dp.rf.rf\[24\]\[17\] _0955_ _1081_ _0130_ VSS VSS
+ VDD VDD _1082_ sky130_fd_sc_hd__o22ai_1
X_4767_ _1078_ _1082_ _0963_ VSS VSS VDD VDD _1083_ sky130_fd_sc_hd__a21oi_1
X_4768_ dp.rf.rf\[9\]\[17\] dp.rf.rf\[13\]\[17\] net206 VSS
+ VSS VDD VDD _1084_ sky130_fd_sc_hd__mux2i_1
X_4769_ net209 _1084_ VSS VSS VDD VDD _1085_ sky130_fd_sc_hd__nand2_1
X_4770_ dp.rf.rf\[12\]\[17\] _0528_ _0955_ dp.rf.rf\[8\]\[17\]
+ VSS VSS VDD VDD _1086_ sky130_fd_sc_hd__o22a_1
X_4771_ dp.rf.rf\[11\]\[17\] dp.rf.rf\[15\]\[17\] net206 VSS
+ VSS VDD VDD _1087_ sky130_fd_sc_hd__mux2i_1
X_4772_ dp.rf.rf\[10\]\[17\] dp.rf.rf\[14\]\[17\] net206 VSS
+ VSS VDD VDD _1088_ sky130_fd_sc_hd__mux2i_1
X_4773_ _1070_ _1087_ _1088_ _0247_ VSS VSS VDD VDD _1089_
+ sky130_fd_sc_hd__o22ai_1
X_4774_ net205 _1085_ _1086_ _1089_ VSS VSS VDD VDD _1090_
+ sky130_fd_sc_hd__a31oi_1
X_4775_ dp.rf.rf\[2\]\[17\] dp.rf.rf\[3\]\[17\] dp.rf.rf\[6\]\[17\]
+ dp.rf.rf\[7\]\[17\] net209 net206 VSS VSS VDD VDD _1091_ sky130_fd_sc_hd__mux4_1
X_4776_ net8 _1091_ VSS VSS VDD VDD _1092_ sky130_fd_sc_hd__and2_0
X_4777_ dp.rf.rf\[1\]\[17\] dp.rf.rf\[5\]\[17\] net206 VSS
+ VSS VDD VDD _1093_ sky130_fd_sc_hd__mux2i_1
X_4778_ _1039_ net203 _1093_ net209 net8 VSS VSS VDD VDD _1094_
+ sky130_fd_sc_hd__a221oi_1
X_4779_ net210 net8 net208 VSS VSS VDD VDD _1095_ sky130_fd_sc_hd__nor3_1
X_4780_ _0115_ _0117_ _1095_ net11 net10 VSS VSS VDD VDD _1096_
+ sky130_fd_sc_hd__a2111oi_4
X_4781_ _1092_ _1094_ _1096_ VSS VSS VDD VDD _1097_ sky130_fd_sc_hd__o21ai_0
X_4782_ net11 net199 _1090_ _1097_ VSS VSS VDD VDD _1098_
+ sky130_fd_sc_hd__o31ai_1
X_4783_ _1076_ _1083_ _1098_ VSS VSS VDD VDD _3395_ sky130_fd_sc_hd__or3_4
X_4784_ _3395_ VSS VSS VDD VDD _3399_ sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_7_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4786_ dp.rf.rf\[26\]\[16\] dp.rf.rf\[27\]\[16\] net212 VSS
+ VSS VDD VDD _1100_ sky130_fd_sc_hd__mux2i_2
X_4787_ dp.rf.rf\[24\]\[16\] dp.rf.rf\[25\]\[16\] net212 VSS
+ VSS VDD VDD _1101_ sky130_fd_sc_hd__mux2i_1
X_4788_ _0066_ _1100_ _1101_ _0061_ VSS VSS VDD VDD _1102_
+ sky130_fd_sc_hd__a22oi_1
X_4789_ dp.rf.rf\[18\]\[16\] dp.rf.rf\[19\]\[16\] net212 VSS
+ VSS VDD VDD _1103_ sky130_fd_sc_hd__mux2i_1
X_4790_ dp.rf.rf\[16\]\[16\] dp.rf.rf\[17\]\[16\] net212 VSS
+ VSS VDD VDD _1104_ sky130_fd_sc_hd__mux2i_1
X_4791_ _0081_ _1103_ _1104_ _0054_ VSS VSS VDD VDD _1105_
+ sky130_fd_sc_hd__a22oi_1
X_4792_ _0088_ _1102_ _1105_ VSS VSS VDD VDD _1106_ sky130_fd_sc_hd__nand3_1
X_4793_ dp.rf.rf\[4\]\[16\] VSS VSS VDD VDD _1107_ sky130_fd_sc_hd__inv_1
X_4794_ net212 dp.rf.rf\[5\]\[16\] VSS VSS VDD VDD _1108_
+ sky130_fd_sc_hd__nand2_1
X_4795_ net212 _1107_ _0054_ _1108_ VSS VSS VDD VDD _1109_
+ sky130_fd_sc_hd__o211ai_1
X_4796_ dp.rf.rf\[6\]\[16\] dp.rf.rf\[7\]\[16\] net212 VSS
+ VSS VDD VDD _1110_ sky130_fd_sc_hd__mux2i_1
X_4797_ dp.rf.rf\[12\]\[16\] dp.rf.rf\[13\]\[16\] net212 VSS
+ VSS VDD VDD _1111_ sky130_fd_sc_hd__mux2i_1
X_4798_ _0081_ _1110_ _1111_ _0061_ VSS VSS VDD VDD _1112_
+ sky130_fd_sc_hd__a22oi_1
X_4799_ dp.rf.rf\[14\]\[16\] dp.rf.rf\[15\]\[16\] net212 VSS
+ VSS VDD VDD _1113_ sky130_fd_sc_hd__mux2i_1
X_4800_ _0066_ _1113_ _0064_ VSS VSS VDD VDD _1114_ sky130_fd_sc_hd__a21oi_1
X_4801_ _1109_ _1112_ _1114_ VSS VSS VDD VDD _1115_ sky130_fd_sc_hd__nand3_1
X_4802_ dp.rf.rf\[8\]\[16\] dp.rf.rf\[9\]\[16\] net212 VSS
+ VSS VDD VDD _1116_ sky130_fd_sc_hd__mux2i_1
X_4803_ dp.rf.rf\[10\]\[16\] dp.rf.rf\[11\]\[16\] net212 VSS
+ VSS VDD VDD _1117_ sky130_fd_sc_hd__mux2i_1
X_4804_ _0061_ _1116_ _1117_ _0066_ VSS VSS VDD VDD _1118_
+ sky130_fd_sc_hd__a22oi_1
X_4805_ dp.rf.rf\[2\]\[16\] dp.rf.rf\[3\]\[16\] net212 VSS
+ VSS VDD VDD _1119_ sky130_fd_sc_hd__mux2i_1
X_4806_ _0081_ _1119_ VSS VSS VDD VDD _1120_ sky130_fd_sc_hd__nand2_1
X_4807_ net212 dp.rf.rf\[1\]\[16\] VSS VSS VDD VDD _1121_
+ sky130_fd_sc_hd__nand2_1
X_4808_ _0054_ _1121_ VSS VSS VDD VDD _1122_ sky130_fd_sc_hd__nand2_1
X_4809_ _0046_ _1118_ _1120_ _1122_ VSS VSS VDD VDD _1123_
+ sky130_fd_sc_hd__nand4_1
X_4810_ dp.rf.rf\[28\]\[16\] dp.rf.rf\[29\]\[16\] dp.rf.rf\[30\]\[16\]
+ dp.rf.rf\[31\]\[16\] net212 net274 VSS VSS VDD VDD _1124_
+ sky130_fd_sc_hd__mux4_1
X_4811_ dp.rf.rf\[20\]\[16\] dp.rf.rf\[21\]\[16\] dp.rf.rf\[22\]\[16\]
+ dp.rf.rf\[23\]\[16\] net212 net274 VSS VSS VDD VDD _1125_
+ sky130_fd_sc_hd__mux4_1
X_4812_ _0104_ _1124_ _1125_ _0102_ VSS VSS VDD VDD _1126_
+ sky130_fd_sc_hd__a22oi_1
X_4813_ _1106_ _1115_ _1123_ _1126_ VSS VSS VDD VDD _1127_
+ sky130_fd_sc_hd__and4_2
X_4814_ net210 _0130_ _0133_ net8 _0914_ VSS VSS VDD VDD _1128_
+ sky130_fd_sc_hd__a221oi_4
X_4815_ _0914_ _0917_ _1062_ VSS VSS VDD VDD _1129_ sky130_fd_sc_hd__nor3b_1
X_4816_ _0917_ _1128_ _1129_ VSS VSS VDD VDD _3593_ sky130_fd_sc_hd__a21oi_1
X_4817_ net178 _3593_ VSS VSS VDD VDD _1130_ sky130_fd_sc_hd__nor2_1
X_4818_ net178 _1127_ _1130_ VSS VSS VDD VDD _1131_ sky130_fd_sc_hd__a21oi_1
X_4819_ _0122_ _1131_ VSS VSS VDD VDD _3404_ sky130_fd_sc_hd__xnor2_1
X_4820_ _3404_ VSS VSS VDD VDD _3408_ sky130_fd_sc_hd__inv_1
X_4821_ dp.rf.rf\[9\]\[16\] dp.rf.rf\[13\]\[16\] net206 VSS
+ VSS VDD VDD _1132_ sky130_fd_sc_hd__mux2i_1
X_4822_ net209 _1132_ VSS VSS VDD VDD _1133_ sky130_fd_sc_hd__nand2_1
X_4823_ dp.rf.rf\[12\]\[16\] _0528_ _0955_ dp.rf.rf\[8\]\[16\]
+ VSS VSS VDD VDD _1134_ sky130_fd_sc_hd__o22a_1
X_4824_ dp.rf.rf\[11\]\[16\] dp.rf.rf\[15\]\[16\] net206 VSS
+ VSS VDD VDD _1135_ sky130_fd_sc_hd__mux2i_1
X_4825_ dp.rf.rf\[10\]\[16\] dp.rf.rf\[14\]\[16\] net206 VSS
+ VSS VDD VDD _1136_ sky130_fd_sc_hd__mux2i_1
X_4826_ _1070_ _1135_ _1136_ _0247_ VSS VSS VDD VDD _1137_
+ sky130_fd_sc_hd__o22ai_1
X_4827_ net205 _1133_ _1134_ _1137_ VSS VSS VDD VDD _1138_
+ sky130_fd_sc_hd__a31oi_2
X_4828_ dp.rf.rf\[2\]\[16\] dp.rf.rf\[3\]\[16\] dp.rf.rf\[6\]\[16\]
+ dp.rf.rf\[7\]\[16\] net209 net206 VSS VSS VDD VDD _1139_ sky130_fd_sc_hd__mux4_1
X_4829_ net8 _1139_ VSS VSS VDD VDD _1140_ sky130_fd_sc_hd__and2_0
X_4830_ dp.rf.rf\[1\]\[16\] dp.rf.rf\[5\]\[16\] net206 VSS
+ VSS VDD VDD _1141_ sky130_fd_sc_hd__mux2i_1
X_4831_ _1107_ net203 _1141_ net209 net8 VSS VSS VDD VDD _1142_
+ sky130_fd_sc_hd__a221oi_1
X_4832_ _1140_ _1142_ _1096_ VSS VSS VDD VDD _1143_ sky130_fd_sc_hd__o21ai_1
X_4833_ net11 net199 _1138_ _1143_ VSS VSS VDD VDD _1144_
+ sky130_fd_sc_hd__o31ai_4
X_4834_ dp.rf.rf\[28\]\[16\] VSS VSS VDD VDD _1145_ sky130_fd_sc_hd__inv_1
X_4835_ dp.rf.rf\[25\]\[16\] dp.rf.rf\[29\]\[16\] net206 VSS
+ VSS VDD VDD _1146_ sky130_fd_sc_hd__mux2i_1
X_4836_ _1145_ net203 _1146_ net209 net8 VSS VSS VDD VDD _1147_
+ sky130_fd_sc_hd__a221oi_2
X_4837_ dp.rf.rf\[24\]\[16\] _0969_ _1147_ _0130_ VSS VSS
+ VDD VDD _1148_ sky130_fd_sc_hd__o22ai_2
X_4838_ dp.rf.rf\[26\]\[16\] dp.rf.rf\[27\]\[16\] dp.rf.rf\[30\]\[16\]
+ dp.rf.rf\[31\]\[16\] net209 net206 VSS VSS VDD VDD _1149_
+ sky130_fd_sc_hd__mux4_1
X_4839_ net182 _1149_ VSS VSS VDD VDD _1150_ sky130_fd_sc_hd__nand2_1
X_4840_ dp.rf.rf\[18\]\[16\] dp.rf.rf\[22\]\[16\] net206 VSS
+ VSS VDD VDD _1151_ sky130_fd_sc_hd__mux2i_1
X_4841_ dp.rf.rf\[19\]\[16\] dp.rf.rf\[23\]\[16\] net206 VSS
+ VSS VDD VDD _1152_ sky130_fd_sc_hd__mux2i_1
X_4842_ _0247_ _1151_ _1152_ _1070_ _0145_ VSS VSS VDD VDD
+ _1153_ sky130_fd_sc_hd__o221ai_1
X_4843_ dp.rf.rf\[17\]\[16\] dp.rf.rf\[21\]\[16\] net206 VSS
+ VSS VDD VDD _1154_ sky130_fd_sc_hd__mux2i_1
X_4844_ dp.rf.rf\[20\]\[16\] net209 net206 VSS VSS VDD VDD
+ _1155_ sky130_fd_sc_hd__nor3b_1
X_4845_ dp.rf.rf\[16\]\[16\] net209 net206 VSS VSS VDD VDD
+ _1156_ sky130_fd_sc_hd__nor3_1
X_4846_ net209 _1154_ _1155_ _1156_ net8 VSS VSS VDD VDD _1157_
+ sky130_fd_sc_hd__a2111oi_1
X_4847_ _1153_ _1157_ net187 VSS VSS VDD VDD _1158_ sky130_fd_sc_hd__o21ai_1
X_4848_ net10 _1148_ _1150_ _1158_ VSS VSS VDD VDD _1159_
+ sky130_fd_sc_hd__a31oi_4
X_4849_ _1144_ _1159_ VSS VSS VDD VDD _3403_ sky130_fd_sc_hd__or2_4
X_4850_ _3403_ VSS VSS VDD VDD _3407_ sky130_fd_sc_hd__clkinv_2
X_4851_ dp.rf.rf\[24\]\[15\] dp.rf.rf\[25\]\[15\] dp.rf.rf\[26\]\[15\]
+ dp.rf.rf\[27\]\[15\] net213 net278 VSS VSS VDD VDD _1160_
+ sky130_fd_sc_hd__mux4_1
X_4852_ dp.rf.rf\[16\]\[15\] dp.rf.rf\[17\]\[15\] dp.rf.rf\[18\]\[15\]
+ dp.rf.rf\[19\]\[15\] net213 net278 VSS VSS VDD VDD _1161_
+ sky130_fd_sc_hd__mux4_1
X_4853_ dp.rf.rf\[28\]\[15\] dp.rf.rf\[29\]\[15\] dp.rf.rf\[30\]\[15\]
+ dp.rf.rf\[31\]\[15\] net213 net278 VSS VSS VDD VDD _1162_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_7_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4855_ dp.rf.rf\[20\]\[15\] dp.rf.rf\[21\]\[15\] dp.rf.rf\[22\]\[15\]
+ dp.rf.rf\[23\]\[15\] net213 net278 VSS VSS VDD VDD _1164_
+ sky130_fd_sc_hd__mux4_1
X_4856_ _1160_ _1161_ _1162_ _1164_ _0103_ net15 VSS VSS VDD
+ VDD _1165_ sky130_fd_sc_hd__mux4_1
X_4857_ net17 _1165_ VSS VSS VDD VDD _1166_ sky130_fd_sc_hd__nand2_1
X_4858_ dp.rf.rf\[8\]\[15\] dp.rf.rf\[9\]\[15\] dp.rf.rf\[10\]\[15\]
+ dp.rf.rf\[11\]\[15\] net215 net14 VSS VSS VDD VDD _1167_ sky130_fd_sc_hd__mux4_1
X_4859_ dp.rf.rf\[0\]\[15\] dp.rf.rf\[1\]\[15\] dp.rf.rf\[2\]\[15\]
+ dp.rf.rf\[3\]\[15\] net215 net14 VSS VSS VDD VDD _1168_ sky130_fd_sc_hd__mux4_1
X_4860_ dp.rf.rf\[12\]\[15\] dp.rf.rf\[13\]\[15\] dp.rf.rf\[14\]\[15\]
+ dp.rf.rf\[15\]\[15\] net215 net14 VSS VSS VDD VDD _1169_ sky130_fd_sc_hd__mux4_1
X_4861_ dp.rf.rf\[4\]\[15\] dp.rf.rf\[5\]\[15\] dp.rf.rf\[6\]\[15\]
+ dp.rf.rf\[7\]\[15\] net215 net14 VSS VSS VDD VDD _1170_ sky130_fd_sc_hd__mux4_1
X_4862_ _1167_ _1168_ _1169_ _1170_ _0103_ net15 VSS VSS VDD
+ VDD _1171_ sky130_fd_sc_hd__mux4_1
X_4863_ _0086_ _1171_ VSS VSS VDD VDD _1172_ sky130_fd_sc_hd__nand2_1
X_4864_ _1166_ _1172_ VSS VSS VDD VDD _1173_ sky130_fd_sc_hd__nand2_1
X_4865_ _0311_ _1173_ VSS VSS VDD VDD _1174_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_7_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4867_ net6 _0130_ _0133_ net210 _0914_ VSS VSS VDD VDD _1176_
+ sky130_fd_sc_hd__a221oi_4
X_4868_ _1128_ _1176_ _0917_ VSS VSS VDD VDD _3589_ sky130_fd_sc_hd__mux2i_4
X_4869_ _0138_ _3589_ VSS VSS VDD VDD _1177_ sky130_fd_sc_hd__nand2_1
X_4870_ _0138_ _1174_ _1177_ VSS VSS VDD VDD _1178_ sky130_fd_sc_hd__o21ai_0
X_4871_ _0122_ _1178_ VSS VSS VDD VDD _3412_ sky130_fd_sc_hd__xnor2_1
X_4872_ _3412_ VSS VSS VDD VDD _3416_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_7_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4874_ dp.rf.rf\[26\]\[15\] dp.rf.rf\[27\]\[15\] dp.rf.rf\[30\]\[15\]
+ dp.rf.rf\[31\]\[15\] net7 net206 VSS VSS VDD VDD _1180_ sky130_fd_sc_hd__mux4_1
X_4875_ dp.rf.rf\[24\]\[15\] dp.rf.rf\[25\]\[15\] dp.rf.rf\[28\]\[15\]
+ dp.rf.rf\[29\]\[15\] net7 net206 VSS VSS VDD VDD _1181_ sky130_fd_sc_hd__mux4_1
X_4876_ _0337_ _1180_ _1181_ _0224_ net198 VSS VSS VDD VDD
+ _1182_ sky130_fd_sc_hd__a221oi_1
X_4877_ _0166_ _1182_ VSS VSS VDD VDD _1183_ sky130_fd_sc_hd__nor2_1
X_4878_ dp.rf.rf\[22\]\[15\] dp.rf.rf\[23\]\[15\] net7 VSS
+ VSS VDD VDD _1184_ sky130_fd_sc_hd__mux2_1
X_4879_ _0148_ _1184_ _0337_ VSS VSS VDD VDD _1185_ sky130_fd_sc_hd__o21ai_0
X_4880_ dp.rf.rf\[19\]\[15\] net7 net200 dp.rf.rf\[18\]\[15\]
+ net189 VSS VSS VDD VDD _1186_ sky130_fd_sc_hd__a221oi_1
X_4881_ dp.rf.rf\[20\]\[15\] VSS VSS VDD VDD _1187_ sky130_fd_sc_hd__inv_1
X_4882_ dp.rf.rf\[17\]\[15\] dp.rf.rf\[21\]\[15\] net206 VSS
+ VSS VDD VDD _1188_ sky130_fd_sc_hd__mux2i_1
X_4883_ _1187_ net204 _1188_ net7 net8 VSS VSS VDD VDD _1189_
+ sky130_fd_sc_hd__a221oi_1
X_4884_ dp.rf.rf\[16\]\[15\] net180 _1189_ _0202_ VSS VSS
+ VDD VDD _1190_ sky130_fd_sc_hd__o22ai_1
X_4885_ _1185_ _1186_ _1190_ VSS VSS VDD VDD _1191_ sky130_fd_sc_hd__o21ai_1
X_4886_ dp.rf.rf\[2\]\[15\] dp.rf.rf\[3\]\[15\] dp.rf.rf\[6\]\[15\]
+ dp.rf.rf\[7\]\[15\] net211 net207 VSS VSS VDD VDD _1192_ sky130_fd_sc_hd__mux4_1
X_4887_ net8 _1192_ VSS VSS VDD VDD _1193_ sky130_fd_sc_hd__nand2_1
X_4888_ dp.rf.rf\[1\]\[15\] dp.rf.rf\[5\]\[15\] net207 VSS
+ VSS VDD VDD _1194_ sky130_fd_sc_hd__mux2_1
X_4889_ dp.rf.rf\[4\]\[15\] _0528_ _1194_ _0245_ _0224_ VSS
+ VSS VDD VDD _1195_ sky130_fd_sc_hd__o221ai_1
X_4890_ _0493_ _1193_ _1195_ _0271_ VSS VSS VDD VDD _1196_
+ sky130_fd_sc_hd__a31o_1
X_4891_ dp.rf.rf\[14\]\[15\] dp.rf.rf\[15\]\[15\] net211 VSS
+ VSS VDD VDD _1197_ sky130_fd_sc_hd__mux2i_1
X_4892_ net207 _1197_ VSS VSS VDD VDD _1198_ sky130_fd_sc_hd__nand2_1
X_4893_ dp.rf.rf\[11\]\[15\] net211 net200 dp.rf.rf\[10\]\[15\]
+ net189 VSS VSS VDD VDD _1199_ sky130_fd_sc_hd__a221o_1
X_4894_ dp.rf.rf\[8\]\[15\] dp.rf.rf\[9\]\[15\] dp.rf.rf\[12\]\[15\]
+ dp.rf.rf\[13\]\[15\] net211 net207 VSS VSS VDD VDD _1200_
+ sky130_fd_sc_hd__mux4_1
X_4895_ _0224_ _1200_ VSS VSS VDD VDD _1201_ sky130_fd_sc_hd__nand2_1
X_4896_ net185 _1201_ VSS VSS VDD VDD _1202_ sky130_fd_sc_hd__nand2_1
X_4897_ _0337_ _1198_ _1199_ _1202_ VSS VSS VDD VDD _1203_
+ sky130_fd_sc_hd__a31oi_4
X_4898_ _1183_ _1191_ _1196_ _1203_ VSS VSS VDD VDD _3411_
+ sky130_fd_sc_hd__o2bb2ai_4
X_4899_ _3411_ VSS VSS VDD VDD _3415_ sky130_fd_sc_hd__clkinv_2
XTAP_TAPCELL_ROW_7_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4901_ net5 _0130_ _0133_ net6 VSS VSS VDD VDD _1205_ sky130_fd_sc_hd__a22oi_1
X_4902_ _1061_ _0917_ _1205_ VSS VSS VDD VDD _1206_ sky130_fd_sc_hd__and3_1
X_4903_ _0120_ _0913_ _1176_ _1206_ VSS VSS VDD VDD _3585_
+ sky130_fd_sc_hd__a31oi_4
X_4904_ _0132_ _3585_ VSS VSS VDD VDD _1207_ sky130_fd_sc_hd__nor2_1
X_4905_ dp.rf.rf\[24\]\[14\] dp.rf.rf\[25\]\[14\] dp.rf.rf\[26\]\[14\]
+ dp.rf.rf\[27\]\[14\] net214 net278 VSS VSS VDD VDD _1208_
+ sky130_fd_sc_hd__mux4_1
X_4906_ dp.rf.rf\[16\]\[14\] dp.rf.rf\[17\]\[14\] dp.rf.rf\[18\]\[14\]
+ dp.rf.rf\[19\]\[14\] net214 net277 VSS VSS VDD VDD _1209_
+ sky130_fd_sc_hd__mux4_1
X_4907_ dp.rf.rf\[28\]\[14\] dp.rf.rf\[29\]\[14\] dp.rf.rf\[30\]\[14\]
+ dp.rf.rf\[31\]\[14\] net214 net278 VSS VSS VDD VDD _1210_
+ sky130_fd_sc_hd__mux4_1
X_4908_ dp.rf.rf\[20\]\[14\] dp.rf.rf\[21\]\[14\] dp.rf.rf\[22\]\[14\]
+ dp.rf.rf\[23\]\[14\] net214 net278 VSS VSS VDD VDD _1211_
+ sky130_fd_sc_hd__mux4_1
X_4909_ _1208_ _1209_ _1210_ _1211_ _0103_ net15 VSS VSS VDD
+ VDD _1212_ sky130_fd_sc_hd__mux4_1
X_4910_ dp.rf.rf\[8\]\[14\] dp.rf.rf\[9\]\[14\] dp.rf.rf\[10\]\[14\]
+ dp.rf.rf\[11\]\[14\] net214 net278 VSS VSS VDD VDD _1213_
+ sky130_fd_sc_hd__mux4_1
X_4911_ dp.rf.rf\[0\]\[14\] dp.rf.rf\[1\]\[14\] dp.rf.rf\[2\]\[14\]
+ dp.rf.rf\[3\]\[14\] net214 net278 VSS VSS VDD VDD _1214_ sky130_fd_sc_hd__mux4_1
X_4912_ dp.rf.rf\[12\]\[14\] dp.rf.rf\[13\]\[14\] dp.rf.rf\[14\]\[14\]
+ dp.rf.rf\[15\]\[14\] net214 net278 VSS VSS VDD VDD _1215_
+ sky130_fd_sc_hd__mux4_1
X_4913_ dp.rf.rf\[4\]\[14\] dp.rf.rf\[5\]\[14\] dp.rf.rf\[6\]\[14\]
+ dp.rf.rf\[7\]\[14\] net214 net278 VSS VSS VDD VDD _1216_ sky130_fd_sc_hd__mux4_1
X_4914_ _1213_ _1214_ _1215_ _1216_ _0103_ net15 VSS VSS VDD
+ VDD _1217_ sky130_fd_sc_hd__mux4_1
X_4915_ net17 _1212_ _1217_ net184 VSS VSS VDD VDD _1218_
+ sky130_fd_sc_hd__a22o_2
X_4916_ _0138_ _1218_ VSS VSS VDD VDD _1219_ sky130_fd_sc_hd__nor2_1
X_4917_ _1207_ _1219_ VSS VSS VDD VDD _1220_ sky130_fd_sc_hd__nor2_1
X_4918_ _0122_ _1220_ VSS VSS VDD VDD _3420_ sky130_fd_sc_hd__xnor2_1
X_4919_ _3420_ VSS VSS VDD VDD _3424_ sky130_fd_sc_hd__inv_1
X_4920_ dp.rf.rf\[10\]\[14\] dp.rf.rf\[11\]\[14\] dp.rf.rf\[14\]\[14\]
+ dp.rf.rf\[15\]\[14\] net7 net9 VSS VSS VDD VDD _1221_ sky130_fd_sc_hd__mux4_1
X_4921_ net8 _1221_ VSS VSS VDD VDD _1222_ sky130_fd_sc_hd__nand2_1
X_4922_ dp.rf.rf\[8\]\[14\] dp.rf.rf\[9\]\[14\] dp.rf.rf\[12\]\[14\]
+ dp.rf.rf\[13\]\[14\] net7 net9 VSS VSS VDD VDD _1223_ sky130_fd_sc_hd__mux4_1
X_4923_ net205 _1223_ VSS VSS VDD VDD _1224_ sky130_fd_sc_hd__nand2_1
X_4924_ net186 _1222_ _1224_ VSS VSS VDD VDD _1225_ sky130_fd_sc_hd__nand3_1
X_4925_ dp.rf.rf\[6\]\[14\] dp.rf.rf\[7\]\[14\] net7 VSS VSS
+ VDD VDD _1226_ sky130_fd_sc_hd__mux2_1
X_4926_ _0148_ _1226_ net183 VSS VSS VDD VDD _1227_ sky130_fd_sc_hd__o21ai_0
X_4927_ dp.rf.rf\[3\]\[14\] net7 _0176_ dp.rf.rf\[2\]\[14\]
+ net191 VSS VSS VDD VDD _1228_ sky130_fd_sc_hd__a221oi_1
X_4928_ dp.rf.rf\[4\]\[14\] VSS VSS VDD VDD _1229_ sky130_fd_sc_hd__inv_1
X_4929_ dp.rf.rf\[1\]\[14\] dp.rf.rf\[5\]\[14\] net9 VSS VSS
+ VDD VDD _1230_ sky130_fd_sc_hd__mux2i_1
X_4930_ _1229_ _0263_ _1230_ net7 net8 VSS VSS VDD VDD _1231_
+ sky130_fd_sc_hd__a221oi_1
X_4931_ dp.rf.rf\[0\]\[14\] _0348_ _1231_ net197 VSS VSS VDD
+ VDD _1232_ sky130_fd_sc_hd__o22ai_1
X_4932_ _1227_ _1228_ _1232_ VSS VSS VDD VDD _1233_ sky130_fd_sc_hd__o21ai_0
X_4933_ dp.rf.rf\[26\]\[14\] dp.rf.rf\[27\]\[14\] dp.rf.rf\[30\]\[14\]
+ dp.rf.rf\[31\]\[14\] net7 net9 VSS VSS VDD VDD _1234_ sky130_fd_sc_hd__mux4_1
X_4934_ net8 _1234_ VSS VSS VDD VDD _1235_ sky130_fd_sc_hd__nand2_1
X_4935_ dp.rf.rf\[24\]\[14\] dp.rf.rf\[25\]\[14\] dp.rf.rf\[28\]\[14\]
+ dp.rf.rf\[29\]\[14\] net7 net9 VSS VSS VDD VDD _1236_ sky130_fd_sc_hd__mux4_1
X_4936_ net205 _1236_ VSS VSS VDD VDD _1237_ sky130_fd_sc_hd__nand2_1
X_4937_ net10 _1235_ _1237_ _0166_ VSS VSS VDD VDD _1238_
+ sky130_fd_sc_hd__a31oi_1
X_4938_ dp.rf.rf\[22\]\[14\] dp.rf.rf\[23\]\[14\] net7 VSS
+ VSS VDD VDD _1239_ sky130_fd_sc_hd__mux2_1
X_4939_ _0148_ _1239_ net183 VSS VSS VDD VDD _1240_ sky130_fd_sc_hd__o21ai_0
X_4940_ dp.rf.rf\[19\]\[14\] net7 _0176_ dp.rf.rf\[18\]\[14\]
+ net191 VSS VSS VDD VDD _1241_ sky130_fd_sc_hd__a221oi_1
X_4941_ dp.rf.rf\[20\]\[14\] VSS VSS VDD VDD _1242_ sky130_fd_sc_hd__inv_1
X_4942_ dp.rf.rf\[17\]\[14\] dp.rf.rf\[21\]\[14\] net9 VSS
+ VSS VDD VDD _1243_ sky130_fd_sc_hd__mux2i_1
X_4943_ _1242_ _0263_ _1243_ net7 net8 VSS VSS VDD VDD _1244_
+ sky130_fd_sc_hd__a221oi_1
X_4944_ dp.rf.rf\[16\]\[14\] _0348_ _1244_ net197 VSS VSS
+ VDD VDD _1245_ sky130_fd_sc_hd__o22ai_1
X_4945_ _1240_ _1241_ _1245_ VSS VSS VDD VDD _1246_ sky130_fd_sc_hd__o21ai_0
X_4946_ net193 _1225_ _1233_ _1238_ _1246_ VSS VSS VDD VDD
+ _3419_ sky130_fd_sc_hd__a32o_4
X_4947_ _3419_ VSS VSS VDD VDD _3423_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_7_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4950_ net4 _0130_ _0133_ net5 _0914_ VSS VSS VDD VDD _1249_
+ sky130_fd_sc_hd__a221oi_1
X_4951_ _0914_ _0917_ _1205_ VSS VSS VDD VDD _1250_ sky130_fd_sc_hd__nor3b_1
X_4952_ _0917_ _1249_ _1250_ VSS VSS VDD VDD _3581_ sky130_fd_sc_hd__a21oi_2
X_4953_ _0132_ _3581_ VSS VSS VDD VDD _1251_ sky130_fd_sc_hd__nor2_1
X_4954_ dp.rf.rf\[24\]\[13\] dp.rf.rf\[25\]\[13\] dp.rf.rf\[26\]\[13\]
+ dp.rf.rf\[27\]\[13\] net214 net278 VSS VSS VDD VDD _1252_
+ sky130_fd_sc_hd__mux4_1
X_4955_ dp.rf.rf\[16\]\[13\] dp.rf.rf\[17\]\[13\] dp.rf.rf\[18\]\[13\]
+ dp.rf.rf\[19\]\[13\] net214 net277 VSS VSS VDD VDD _1253_
+ sky130_fd_sc_hd__mux4_1
X_4956_ dp.rf.rf\[28\]\[13\] dp.rf.rf\[29\]\[13\] dp.rf.rf\[30\]\[13\]
+ dp.rf.rf\[31\]\[13\] net214 net278 VSS VSS VDD VDD _1254_
+ sky130_fd_sc_hd__mux4_1
X_4957_ dp.rf.rf\[20\]\[13\] dp.rf.rf\[21\]\[13\] dp.rf.rf\[22\]\[13\]
+ dp.rf.rf\[23\]\[13\] net214 net277 VSS VSS VDD VDD _1255_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_7_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4959_ _1252_ _1253_ _1254_ _1255_ _0103_ net15 VSS VSS VDD
+ VDD _1257_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_7_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_4961_ dp.rf.rf\[8\]\[13\] dp.rf.rf\[9\]\[13\] dp.rf.rf\[10\]\[13\]
+ dp.rf.rf\[11\]\[13\] net214 net278 VSS VSS VDD VDD _1259_
+ sky130_fd_sc_hd__mux4_1
X_4962_ dp.rf.rf\[0\]\[13\] dp.rf.rf\[1\]\[13\] dp.rf.rf\[2\]\[13\]
+ dp.rf.rf\[3\]\[13\] net214 net278 VSS VSS VDD VDD _1260_ sky130_fd_sc_hd__mux4_1
X_4963_ dp.rf.rf\[12\]\[13\] dp.rf.rf\[13\]\[13\] dp.rf.rf\[14\]\[13\]
+ dp.rf.rf\[15\]\[13\] net214 net278 VSS VSS VDD VDD _1261_
+ sky130_fd_sc_hd__mux4_1
X_4964_ dp.rf.rf\[4\]\[13\] dp.rf.rf\[5\]\[13\] dp.rf.rf\[6\]\[13\]
+ dp.rf.rf\[7\]\[13\] net214 net278 VSS VSS VDD VDD _1262_ sky130_fd_sc_hd__mux4_1
X_4965_ _1259_ _1260_ _1261_ _1262_ _0103_ net15 VSS VSS VDD
+ VDD _1263_ sky130_fd_sc_hd__mux4_1
X_4966_ net17 _1257_ _1263_ net184 VSS VSS VDD VDD _1264_
+ sky130_fd_sc_hd__a22o_2
X_4967_ _0138_ _1264_ VSS VSS VDD VDD _1265_ sky130_fd_sc_hd__nor2_1
X_4968_ _1251_ _1265_ VSS VSS VDD VDD _1266_ sky130_fd_sc_hd__nor2_1
X_4969_ _0122_ _1266_ VSS VSS VDD VDD _3428_ sky130_fd_sc_hd__xnor2_1
X_4970_ _3428_ VSS VSS VDD VDD _3432_ sky130_fd_sc_hd__inv_1
X_4971_ dp.rf.rf\[26\]\[13\] dp.rf.rf\[27\]\[13\] dp.rf.rf\[30\]\[13\]
+ dp.rf.rf\[31\]\[13\] net7 net9 VSS VSS VDD VDD _1267_ sky130_fd_sc_hd__mux4_1
X_4972_ dp.rf.rf\[24\]\[13\] dp.rf.rf\[25\]\[13\] dp.rf.rf\[28\]\[13\]
+ dp.rf.rf\[29\]\[13\] net7 net9 VSS VSS VDD VDD _1268_ sky130_fd_sc_hd__mux4_1
X_4973_ net183 _1267_ _1268_ net205 net199 VSS VSS VDD VDD
+ _1269_ sky130_fd_sc_hd__a221oi_1
X_4974_ _0166_ _1269_ VSS VSS VDD VDD _1270_ sky130_fd_sc_hd__nor2_1
X_4975_ dp.rf.rf\[22\]\[13\] dp.rf.rf\[23\]\[13\] net7 VSS
+ VSS VDD VDD _1271_ sky130_fd_sc_hd__mux2_1
X_4976_ _0148_ _1271_ net183 VSS VSS VDD VDD _1272_ sky130_fd_sc_hd__o21ai_0
X_4977_ dp.rf.rf\[19\]\[13\] net7 _0176_ dp.rf.rf\[18\]\[13\]
+ net191 VSS VSS VDD VDD _1273_ sky130_fd_sc_hd__a221oi_1
X_4978_ dp.rf.rf\[20\]\[13\] VSS VSS VDD VDD _1274_ sky130_fd_sc_hd__inv_1
X_4979_ dp.rf.rf\[17\]\[13\] dp.rf.rf\[21\]\[13\] net9 VSS
+ VSS VDD VDD _1275_ sky130_fd_sc_hd__mux2i_1
X_4980_ _1274_ _0263_ _1275_ net7 net8 VSS VSS VDD VDD _1276_
+ sky130_fd_sc_hd__a221oi_1
X_4981_ dp.rf.rf\[16\]\[13\] _0348_ _1276_ net197 VSS VSS
+ VDD VDD _1277_ sky130_fd_sc_hd__o22ai_1
X_4982_ _1272_ _1273_ _1277_ VSS VSS VDD VDD _1278_ sky130_fd_sc_hd__o21ai_0
X_4983_ dp.rf.rf\[10\]\[13\] dp.rf.rf\[11\]\[13\] dp.rf.rf\[14\]\[13\]
+ dp.rf.rf\[15\]\[13\] net7 net9 VSS VSS VDD VDD _1279_ sky130_fd_sc_hd__mux4_1
X_4984_ dp.rf.rf\[8\]\[13\] dp.rf.rf\[9\]\[13\] dp.rf.rf\[12\]\[13\]
+ dp.rf.rf\[13\]\[13\] net7 net9 VSS VSS VDD VDD _1280_ sky130_fd_sc_hd__mux4_1
X_4985_ _1279_ _1280_ net205 VSS VSS VDD VDD _1281_ sky130_fd_sc_hd__mux2i_2
X_4986_ dp.rf.rf\[2\]\[13\] dp.rf.rf\[3\]\[13\] dp.rf.rf\[6\]\[13\]
+ dp.rf.rf\[7\]\[13\] net7 net9 VSS VSS VDD VDD _1282_ sky130_fd_sc_hd__mux4_1
X_4987_ dp.rf.rf\[4\]\[13\] VSS VSS VDD VDD _1283_ sky130_fd_sc_hd__inv_1
X_4988_ dp.rf.rf\[1\]\[13\] dp.rf.rf\[5\]\[13\] net9 VSS VSS
+ VDD VDD _1284_ sky130_fd_sc_hd__mux2i_1
X_4989_ _1283_ _0263_ _1284_ net7 net8 VSS VSS VDD VDD _1285_
+ sky130_fd_sc_hd__a221oi_1
X_4990_ net8 _1282_ _1285_ net197 VSS VSS VDD VDD _1286_ sky130_fd_sc_hd__a211oi_1
X_4991_ net186 _1281_ _1286_ _0271_ VSS VSS VDD VDD _1287_
+ sky130_fd_sc_hd__a211oi_2
X_4992_ _1270_ _1278_ _1287_ VSS VSS VDD VDD _3427_ sky130_fd_sc_hd__a21o_4
X_4993_ _3427_ VSS VSS VDD VDD _3431_ sky130_fd_sc_hd__inv_2
X_4994_ _0130_ _0133_ net4 VSS VSS VDD VDD _1288_ sky130_fd_sc_hd__o21ai_0
X_4995_ _1061_ _1288_ VSS VSS VDD VDD _3577_ sky130_fd_sc_hd__nand2_2
X_4996_ dp.rf.rf\[24\]\[12\] dp.rf.rf\[25\]\[12\] dp.rf.rf\[26\]\[12\]
+ dp.rf.rf\[27\]\[12\] net214 net277 VSS VSS VDD VDD _1289_
+ sky130_fd_sc_hd__mux4_1
X_4997_ dp.rf.rf\[16\]\[12\] dp.rf.rf\[17\]\[12\] dp.rf.rf\[18\]\[12\]
+ dp.rf.rf\[19\]\[12\] net214 net277 VSS VSS VDD VDD _1290_
+ sky130_fd_sc_hd__mux4_1
X_4998_ dp.rf.rf\[28\]\[12\] dp.rf.rf\[29\]\[12\] dp.rf.rf\[30\]\[12\]
+ dp.rf.rf\[31\]\[12\] net214 net277 VSS VSS VDD VDD _1291_
+ sky130_fd_sc_hd__mux4_1
X_4999_ dp.rf.rf\[20\]\[12\] dp.rf.rf\[21\]\[12\] dp.rf.rf\[22\]\[12\]
+ dp.rf.rf\[23\]\[12\] net214 net277 VSS VSS VDD VDD _1292_
+ sky130_fd_sc_hd__mux4_1
X_5000_ _1289_ _1290_ _1291_ _1292_ _0103_ net15 VSS VSS VDD
+ VDD _1293_ sky130_fd_sc_hd__mux4_1
X_5001_ dp.rf.rf\[8\]\[12\] dp.rf.rf\[9\]\[12\] dp.rf.rf\[10\]\[12\]
+ dp.rf.rf\[11\]\[12\] net214 net277 VSS VSS VDD VDD _1294_
+ sky130_fd_sc_hd__mux4_1
X_5002_ dp.rf.rf\[0\]\[12\] dp.rf.rf\[1\]\[12\] dp.rf.rf\[2\]\[12\]
+ dp.rf.rf\[3\]\[12\] net214 net277 VSS VSS VDD VDD _1295_ sky130_fd_sc_hd__mux4_1
X_5003_ dp.rf.rf\[12\]\[12\] dp.rf.rf\[13\]\[12\] dp.rf.rf\[14\]\[12\]
+ dp.rf.rf\[15\]\[12\] net214 net277 VSS VSS VDD VDD _1296_
+ sky130_fd_sc_hd__mux4_1
X_5004_ dp.rf.rf\[4\]\[12\] dp.rf.rf\[5\]\[12\] dp.rf.rf\[6\]\[12\]
+ dp.rf.rf\[7\]\[12\] net214 net277 VSS VSS VDD VDD _1297_ sky130_fd_sc_hd__mux4_1
X_5005_ _1294_ _1295_ _1296_ _1297_ _0103_ net15 VSS VSS VDD
+ VDD _1298_ sky130_fd_sc_hd__mux4_2
X_5006_ net17 _1293_ _1298_ net184 VSS VSS VDD VDD _1299_
+ sky130_fd_sc_hd__a22oi_4
X_5007_ _0132_ _1299_ VSS VSS VDD VDD _1300_ sky130_fd_sc_hd__nand2_1
X_5008_ _0132_ _3577_ _1300_ VSS VSS VDD VDD _1301_ sky130_fd_sc_hd__o21ai_0
X_5009_ _0122_ _1301_ VSS VSS VDD VDD _3436_ sky130_fd_sc_hd__xor2_1
X_5010_ _3436_ VSS VSS VDD VDD _3440_ sky130_fd_sc_hd__inv_1
X_5011_ dp.rf.rf\[22\]\[12\] dp.rf.rf\[23\]\[12\] net210 VSS
+ VSS VDD VDD _1302_ sky130_fd_sc_hd__mux2_1
X_5012_ _0148_ _1302_ net183 VSS VSS VDD VDD _1303_ sky130_fd_sc_hd__o21ai_0
X_5013_ dp.rf.rf\[19\]\[12\] net210 _0176_ dp.rf.rf\[18\]\[12\]
+ net191 VSS VSS VDD VDD _1304_ sky130_fd_sc_hd__a221oi_1
X_5014_ dp.rf.rf\[20\]\[12\] VSS VSS VDD VDD _1305_ sky130_fd_sc_hd__inv_1
X_5015_ dp.rf.rf\[17\]\[12\] dp.rf.rf\[21\]\[12\] net208 VSS
+ VSS VDD VDD _1306_ sky130_fd_sc_hd__mux2i_1
X_5016_ _1305_ _0263_ _1306_ net210 net8 VSS VSS VDD VDD _1307_
+ sky130_fd_sc_hd__a221oi_1
X_5017_ dp.rf.rf\[16\]\[12\] _0348_ _1307_ net197 VSS VSS
+ VDD VDD _1308_ sky130_fd_sc_hd__o22ai_1
X_5018_ _1303_ _1304_ _1308_ VSS VSS VDD VDD _1309_ sky130_fd_sc_hd__o21ai_1
X_5019_ dp.rf.rf\[30\]\[12\] dp.rf.rf\[31\]\[12\] net210 VSS
+ VSS VDD VDD _1310_ sky130_fd_sc_hd__mux2_1
X_5020_ _0148_ _1310_ net183 VSS VSS VDD VDD _1311_ sky130_fd_sc_hd__o21ai_0
X_5021_ dp.rf.rf\[27\]\[12\] net210 net200 dp.rf.rf\[26\]\[12\]
+ net191 VSS VSS VDD VDD _1312_ sky130_fd_sc_hd__a221oi_1
X_5022_ dp.rf.rf\[25\]\[12\] dp.rf.rf\[29\]\[12\] net208 VSS
+ VSS VDD VDD _1313_ sky130_fd_sc_hd__mux2i_1
X_5023_ net210 _1313_ VSS VSS VDD VDD _1314_ sky130_fd_sc_hd__nand2_1
X_5024_ dp.rf.rf\[28\]\[12\] _0528_ _0955_ dp.rf.rf\[24\]\[12\]
+ _1314_ VSS VSS VDD VDD _1315_ sky130_fd_sc_hd__o221ai_1
X_5025_ _1311_ _1312_ _1315_ net8 net186 VSS VSS VDD VDD _1316_
+ sky130_fd_sc_hd__o221ai_1
X_5026_ dp.rf.rf\[8\]\[12\] dp.rf.rf\[9\]\[12\] dp.rf.rf\[12\]\[12\]
+ dp.rf.rf\[13\]\[12\] net210 net208 VSS VSS VDD VDD _1317_
+ sky130_fd_sc_hd__mux4_1
X_5027_ net205 _1317_ VSS VSS VDD VDD _1318_ sky130_fd_sc_hd__nand2_1
X_5028_ dp.rf.rf\[10\]\[12\] dp.rf.rf\[11\]\[12\] dp.rf.rf\[14\]\[12\]
+ dp.rf.rf\[15\]\[12\] net210 net208 VSS VSS VDD VDD _1319_
+ sky130_fd_sc_hd__mux4_1
X_5029_ net8 _1319_ VSS VSS VDD VDD _1320_ sky130_fd_sc_hd__nand2_1
X_5030_ net186 _1318_ _1320_ _0271_ VSS VSS VDD VDD _1321_
+ sky130_fd_sc_hd__a31oi_2
X_5031_ dp.rf.rf\[6\]\[12\] dp.rf.rf\[7\]\[12\] net210 VSS
+ VSS VDD VDD _1322_ sky130_fd_sc_hd__mux2_1
X_5032_ _0148_ _1322_ net183 VSS VSS VDD VDD _1323_ sky130_fd_sc_hd__o21ai_0
X_5033_ dp.rf.rf\[3\]\[12\] net210 net200 dp.rf.rf\[2\]\[12\]
+ net189 VSS VSS VDD VDD _1324_ sky130_fd_sc_hd__a221oi_1
X_5034_ dp.rf.rf\[4\]\[12\] VSS VSS VDD VDD _1325_ sky130_fd_sc_hd__inv_1
X_5035_ dp.rf.rf\[1\]\[12\] dp.rf.rf\[5\]\[12\] net208 VSS
+ VSS VDD VDD _1326_ sky130_fd_sc_hd__mux2i_1
X_5036_ _1325_ net204 _1326_ net210 net8 VSS VSS VDD VDD _1327_
+ sky130_fd_sc_hd__a221oi_1
X_5037_ dp.rf.rf\[0\]\[12\] net180 _1327_ _0202_ VSS VSS VDD
+ VDD _1328_ sky130_fd_sc_hd__o22ai_1
X_5038_ _1323_ _1324_ _1328_ VSS VSS VDD VDD _1329_ sky130_fd_sc_hd__o21ai_1
X_5039_ _0232_ _1309_ _1316_ _1321_ _1329_ VSS VSS VDD VDD
+ _3435_ sky130_fd_sc_hd__a32o_4
X_5040_ _3435_ VSS VSS VDD VDD _3439_ sky130_fd_sc_hd__clkinv_2
X_5041_ dp.rf.rf\[24\]\[11\] dp.rf.rf\[25\]\[11\] dp.rf.rf\[26\]\[11\]
+ dp.rf.rf\[27\]\[11\] net214 net278 VSS VSS VDD VDD _1330_
+ sky130_fd_sc_hd__mux4_1
X_5042_ dp.rf.rf\[16\]\[11\] dp.rf.rf\[17\]\[11\] dp.rf.rf\[18\]\[11\]
+ dp.rf.rf\[19\]\[11\] net214 net278 VSS VSS VDD VDD _1331_
+ sky130_fd_sc_hd__mux4_1
X_5043_ dp.rf.rf\[28\]\[11\] dp.rf.rf\[29\]\[11\] dp.rf.rf\[30\]\[11\]
+ dp.rf.rf\[31\]\[11\] net214 net278 VSS VSS VDD VDD _1332_
+ sky130_fd_sc_hd__mux4_1
X_5044_ dp.rf.rf\[20\]\[11\] dp.rf.rf\[21\]\[11\] dp.rf.rf\[22\]\[11\]
+ dp.rf.rf\[23\]\[11\] net214 net278 VSS VSS VDD VDD _1333_
+ sky130_fd_sc_hd__mux4_1
X_5045_ _1330_ _1331_ _1332_ _1333_ _0103_ net15 VSS VSS VDD
+ VDD _1334_ sky130_fd_sc_hd__mux4_1
X_5046_ dp.rf.rf\[8\]\[11\] dp.rf.rf\[9\]\[11\] dp.rf.rf\[10\]\[11\]
+ dp.rf.rf\[11\]\[11\] net214 net278 VSS VSS VDD VDD _1335_
+ sky130_fd_sc_hd__mux4_1
X_5047_ dp.rf.rf\[0\]\[11\] dp.rf.rf\[1\]\[11\] dp.rf.rf\[2\]\[11\]
+ dp.rf.rf\[3\]\[11\] net13 net277 VSS VSS VDD VDD _1336_ sky130_fd_sc_hd__mux4_1
X_5048_ dp.rf.rf\[12\]\[11\] dp.rf.rf\[13\]\[11\] dp.rf.rf\[14\]\[11\]
+ dp.rf.rf\[15\]\[11\] net214 net278 VSS VSS VDD VDD _1337_
+ sky130_fd_sc_hd__mux4_1
X_5049_ dp.rf.rf\[4\]\[11\] dp.rf.rf\[5\]\[11\] dp.rf.rf\[6\]\[11\]
+ dp.rf.rf\[7\]\[11\] net13 net278 VSS VSS VDD VDD _1338_ sky130_fd_sc_hd__mux4_1
X_5050_ _1335_ _1336_ _1337_ _1338_ _0103_ net15 VSS VSS VDD
+ VDD _1339_ sky130_fd_sc_hd__mux4_2
X_5051_ _1334_ _1339_ _0086_ VSS VSS VDD VDD _1340_ sky130_fd_sc_hd__mux2i_4
X_5052_ net29 _0042_ VSS VSS VDD VDD _1341_ sky130_fd_sc_hd__and2_0
X_5053_ net30 _1341_ _0133_ net13 VSS VSS VDD VDD _1342_ sky130_fd_sc_hd__a22oi_2
X_5054_ _0304_ _0917_ _1342_ VSS VSS VDD VDD _3573_ sky130_fd_sc_hd__o21ai_4
X_5055_ _0138_ _3573_ VSS VSS VDD VDD _1343_ sky130_fd_sc_hd__nand2_1
X_5056_ _0138_ _0401_ _1340_ _1343_ VSS VSS VDD VDD _1344_
+ sky130_fd_sc_hd__o31ai_1
X_5057_ _0122_ _1344_ VSS VSS VDD VDD _3444_ sky130_fd_sc_hd__xnor2_1
X_5058_ _3444_ VSS VSS VDD VDD _3448_ sky130_fd_sc_hd__inv_1
X_5059_ dp.rf.rf\[2\]\[11\] dp.rf.rf\[3\]\[11\] dp.rf.rf\[6\]\[11\]
+ dp.rf.rf\[7\]\[11\] net210 net9 VSS VSS VDD VDD _1345_ sky130_fd_sc_hd__mux4_1
X_5060_ net8 _1345_ VSS VSS VDD VDD _1346_ sky130_fd_sc_hd__nand2_1
X_5061_ dp.rf.rf\[1\]\[11\] dp.rf.rf\[5\]\[11\] net9 VSS VSS
+ VDD VDD _1347_ sky130_fd_sc_hd__mux2_1
X_5062_ dp.rf.rf\[4\]\[11\] _0528_ _1347_ _0245_ net205 VSS
+ VSS VDD VDD _1348_ sky130_fd_sc_hd__o221ai_1
X_5063_ _0493_ _1346_ _1348_ VSS VSS VDD VDD _1349_ sky130_fd_sc_hd__nand3_1
X_5064_ dp.rf.rf\[10\]\[11\] dp.rf.rf\[11\]\[11\] dp.rf.rf\[14\]\[11\]
+ dp.rf.rf\[15\]\[11\] net7 net9 VSS VSS VDD VDD _1350_ sky130_fd_sc_hd__mux4_1
X_5065_ net8 _1350_ VSS VSS VDD VDD _1351_ sky130_fd_sc_hd__nand2_1
X_5066_ dp.rf.rf\[8\]\[11\] dp.rf.rf\[9\]\[11\] dp.rf.rf\[12\]\[11\]
+ dp.rf.rf\[13\]\[11\] net7 net9 VSS VSS VDD VDD _1352_ sky130_fd_sc_hd__mux4_1
X_5067_ net205 _1352_ VSS VSS VDD VDD _1353_ sky130_fd_sc_hd__nand2_1
X_5068_ net186 _1351_ _1353_ VSS VSS VDD VDD _1354_ sky130_fd_sc_hd__nand3_1
X_5069_ dp.rf.rf\[26\]\[11\] dp.rf.rf\[27\]\[11\] dp.rf.rf\[30\]\[11\]
+ dp.rf.rf\[31\]\[11\] net7 net9 VSS VSS VDD VDD _1355_ sky130_fd_sc_hd__mux4_1
X_5070_ net8 _1355_ VSS VSS VDD VDD _1356_ sky130_fd_sc_hd__nand2_1
X_5071_ dp.rf.rf\[24\]\[11\] dp.rf.rf\[25\]\[11\] dp.rf.rf\[28\]\[11\]
+ dp.rf.rf\[29\]\[11\] net7 net9 VSS VSS VDD VDD _1357_ sky130_fd_sc_hd__mux4_1
X_5072_ net205 _1357_ VSS VSS VDD VDD _1358_ sky130_fd_sc_hd__nand2_1
X_5073_ net10 _1356_ _1358_ _0166_ VSS VSS VDD VDD _1359_
+ sky130_fd_sc_hd__a31oi_1
X_5074_ dp.rf.rf\[22\]\[11\] dp.rf.rf\[23\]\[11\] net7 VSS
+ VSS VDD VDD _1360_ sky130_fd_sc_hd__mux2_1
X_5075_ _0148_ _1360_ net183 VSS VSS VDD VDD _1361_ sky130_fd_sc_hd__o21ai_0
X_5076_ dp.rf.rf\[19\]\[11\] net7 net200 dp.rf.rf\[18\]\[11\]
+ net191 VSS VSS VDD VDD _1362_ sky130_fd_sc_hd__a221oi_1
X_5077_ dp.rf.rf\[20\]\[11\] VSS VSS VDD VDD _1363_ sky130_fd_sc_hd__inv_1
X_5078_ dp.rf.rf\[17\]\[11\] dp.rf.rf\[21\]\[11\] net9 VSS
+ VSS VDD VDD _1364_ sky130_fd_sc_hd__mux2i_1
X_5079_ _1363_ _0263_ _1364_ net7 net8 VSS VSS VDD VDD _1365_
+ sky130_fd_sc_hd__a221oi_1
X_5080_ dp.rf.rf\[16\]\[11\] net180 _1365_ _0202_ VSS VSS
+ VDD VDD _1366_ sky130_fd_sc_hd__o22ai_1
X_5081_ _1361_ _1362_ _1366_ VSS VSS VDD VDD _1367_ sky130_fd_sc_hd__o21ai_0
X_5082_ net193 _1349_ _1354_ _1359_ _1367_ VSS VSS VDD VDD
+ _3443_ sky130_fd_sc_hd__a32o_4
X_5083_ _3443_ VSS VSS VDD VDD _3447_ sky130_fd_sc_hd__clkinv_2
X_5084_ net24 _0119_ VSS VSS VDD VDD _3569_ sky130_fd_sc_hd__and2_1
X_5085_ dp.rf.rf\[24\]\[10\] dp.rf.rf\[25\]\[10\] dp.rf.rf\[26\]\[10\]
+ dp.rf.rf\[27\]\[10\] net214 net278 VSS VSS VDD VDD _1368_
+ sky130_fd_sc_hd__mux4_1
X_5086_ dp.rf.rf\[16\]\[10\] dp.rf.rf\[17\]\[10\] dp.rf.rf\[18\]\[10\]
+ dp.rf.rf\[19\]\[10\] net214 net278 VSS VSS VDD VDD _1369_
+ sky130_fd_sc_hd__mux4_1
X_5087_ dp.rf.rf\[28\]\[10\] dp.rf.rf\[29\]\[10\] dp.rf.rf\[30\]\[10\]
+ dp.rf.rf\[31\]\[10\] net214 net278 VSS VSS VDD VDD _1370_
+ sky130_fd_sc_hd__mux4_1
X_5088_ dp.rf.rf\[20\]\[10\] dp.rf.rf\[21\]\[10\] dp.rf.rf\[22\]\[10\]
+ dp.rf.rf\[23\]\[10\] net214 net278 VSS VSS VDD VDD _1371_
+ sky130_fd_sc_hd__mux4_1
X_5089_ _1368_ _1369_ _1370_ _1371_ _0103_ net15 VSS VSS VDD
+ VDD _1372_ sky130_fd_sc_hd__mux4_1
X_5090_ dp.rf.rf\[8\]\[10\] dp.rf.rf\[9\]\[10\] dp.rf.rf\[10\]\[10\]
+ dp.rf.rf\[11\]\[10\] net214 net278 VSS VSS VDD VDD _1373_
+ sky130_fd_sc_hd__mux4_1
X_5091_ dp.rf.rf\[0\]\[10\] dp.rf.rf\[1\]\[10\] dp.rf.rf\[2\]\[10\]
+ dp.rf.rf\[3\]\[10\] net214 net278 VSS VSS VDD VDD _1374_ sky130_fd_sc_hd__mux4_1
X_5092_ dp.rf.rf\[12\]\[10\] dp.rf.rf\[13\]\[10\] dp.rf.rf\[14\]\[10\]
+ dp.rf.rf\[15\]\[10\] net214 net278 VSS VSS VDD VDD _1375_
+ sky130_fd_sc_hd__mux4_1
X_5093_ dp.rf.rf\[4\]\[10\] dp.rf.rf\[5\]\[10\] dp.rf.rf\[6\]\[10\]
+ dp.rf.rf\[7\]\[10\] net214 net278 VSS VSS VDD VDD _1376_ sky130_fd_sc_hd__mux4_1
X_5094_ _1373_ _1374_ _1375_ _1376_ _0103_ net15 VSS VSS VDD
+ VDD _1377_ sky130_fd_sc_hd__mux4_1
X_5095_ net17 _1372_ _1377_ net184 VSS VSS VDD VDD _1378_
+ sky130_fd_sc_hd__a22o_2
X_5096_ _3569_ _1378_ _0132_ VSS VSS VDD VDD _1379_ sky130_fd_sc_hd__mux2_1
X_5097_ _0122_ _1379_ VSS VSS VDD VDD _3452_ sky130_fd_sc_hd__xnor2_1
X_5098_ _3452_ VSS VSS VDD VDD _3456_ sky130_fd_sc_hd__inv_1
X_5099_ dp.rf.rf\[10\]\[10\] dp.rf.rf\[11\]\[10\] dp.rf.rf\[14\]\[10\]
+ dp.rf.rf\[15\]\[10\] net7 net9 VSS VSS VDD VDD _1380_ sky130_fd_sc_hd__mux4_1
X_5100_ net8 _1380_ VSS VSS VDD VDD _1381_ sky130_fd_sc_hd__nand2_1
X_5101_ dp.rf.rf\[8\]\[10\] dp.rf.rf\[9\]\[10\] dp.rf.rf\[12\]\[10\]
+ dp.rf.rf\[13\]\[10\] net7 net9 VSS VSS VDD VDD _1382_ sky130_fd_sc_hd__mux4_1
X_5102_ net205 _1382_ VSS VSS VDD VDD _1383_ sky130_fd_sc_hd__nand2_1
X_5103_ net186 _1381_ _1383_ VSS VSS VDD VDD _1384_ sky130_fd_sc_hd__nand3_1
X_5104_ dp.rf.rf\[6\]\[10\] dp.rf.rf\[7\]\[10\] net7 VSS VSS
+ VDD VDD _1385_ sky130_fd_sc_hd__mux2_1
X_5105_ _0148_ _1385_ net183 VSS VSS VDD VDD _1386_ sky130_fd_sc_hd__o21ai_0
X_5106_ dp.rf.rf\[3\]\[10\] net7 net200 dp.rf.rf\[2\]\[10\]
+ net191 VSS VSS VDD VDD _1387_ sky130_fd_sc_hd__a221oi_1
X_5107_ dp.rf.rf\[4\]\[10\] VSS VSS VDD VDD _1388_ sky130_fd_sc_hd__inv_1
X_5108_ dp.rf.rf\[1\]\[10\] dp.rf.rf\[5\]\[10\] net9 VSS VSS
+ VDD VDD _1389_ sky130_fd_sc_hd__mux2i_1
X_5109_ _1388_ _0263_ _1389_ net7 net8 VSS VSS VDD VDD _1390_
+ sky130_fd_sc_hd__a221oi_1
X_5110_ dp.rf.rf\[0\]\[10\] _0348_ _1390_ net197 VSS VSS VDD
+ VDD _1391_ sky130_fd_sc_hd__o22ai_1
X_5111_ _1386_ _1387_ _1391_ VSS VSS VDD VDD _1392_ sky130_fd_sc_hd__o21ai_1
X_5112_ dp.rf.rf\[26\]\[10\] dp.rf.rf\[27\]\[10\] dp.rf.rf\[30\]\[10\]
+ dp.rf.rf\[31\]\[10\] net7 net9 VSS VSS VDD VDD _1393_ sky130_fd_sc_hd__mux4_1
X_5113_ net8 _1393_ VSS VSS VDD VDD _1394_ sky130_fd_sc_hd__nand2_1
X_5114_ dp.rf.rf\[24\]\[10\] dp.rf.rf\[25\]\[10\] dp.rf.rf\[28\]\[10\]
+ dp.rf.rf\[29\]\[10\] net7 net9 VSS VSS VDD VDD _1395_ sky130_fd_sc_hd__mux4_1
X_5115_ net205 _1395_ VSS VSS VDD VDD _1396_ sky130_fd_sc_hd__nand2_1
X_5116_ net10 _1394_ _1396_ _0166_ VSS VSS VDD VDD _1397_
+ sky130_fd_sc_hd__a31oi_1
X_5117_ dp.rf.rf\[22\]\[10\] dp.rf.rf\[23\]\[10\] net7 VSS
+ VSS VDD VDD _1398_ sky130_fd_sc_hd__mux2_1
X_5118_ _0148_ _1398_ net183 VSS VSS VDD VDD _1399_ sky130_fd_sc_hd__o21ai_0
X_5119_ dp.rf.rf\[19\]\[10\] net7 net200 dp.rf.rf\[18\]\[10\]
+ net191 VSS VSS VDD VDD _1400_ sky130_fd_sc_hd__a221oi_1
X_5120_ dp.rf.rf\[20\]\[10\] VSS VSS VDD VDD _1401_ sky130_fd_sc_hd__inv_1
X_5121_ dp.rf.rf\[17\]\[10\] dp.rf.rf\[21\]\[10\] net9 VSS
+ VSS VDD VDD _1402_ sky130_fd_sc_hd__mux2i_1
X_5122_ _1401_ _0263_ _1402_ net7 net8 VSS VSS VDD VDD _1403_
+ sky130_fd_sc_hd__a221oi_1
X_5123_ dp.rf.rf\[16\]\[10\] _0348_ _1403_ net197 VSS VSS
+ VDD VDD _1404_ sky130_fd_sc_hd__o22ai_1
X_5124_ _1399_ _1400_ _1404_ VSS VSS VDD VDD _1405_ sky130_fd_sc_hd__o21ai_0
X_5125_ net193 _1384_ _1392_ _1397_ _1405_ VSS VSS VDD VDD
+ _3451_ sky130_fd_sc_hd__a32o_4
X_5126_ _3451_ VSS VSS VDD VDD _3455_ sky130_fd_sc_hd__clkinv_4
X_5127_ net22 _0119_ VSS VSS VDD VDD _3565_ sky130_fd_sc_hd__and2_1
X_5128_ dp.rf.rf\[24\]\[9\] dp.rf.rf\[25\]\[9\] dp.rf.rf\[26\]\[9\]
+ dp.rf.rf\[27\]\[9\] net13 net278 VSS VSS VDD VDD _1406_ sky130_fd_sc_hd__mux4_1
X_5129_ dp.rf.rf\[16\]\[9\] dp.rf.rf\[17\]\[9\] dp.rf.rf\[18\]\[9\]
+ dp.rf.rf\[19\]\[9\] net13 net278 VSS VSS VDD VDD _1407_ sky130_fd_sc_hd__mux4_1
X_5130_ dp.rf.rf\[28\]\[9\] dp.rf.rf\[29\]\[9\] dp.rf.rf\[30\]\[9\]
+ dp.rf.rf\[31\]\[9\] net13 net278 VSS VSS VDD VDD _1408_ sky130_fd_sc_hd__mux4_1
X_5131_ dp.rf.rf\[20\]\[9\] dp.rf.rf\[21\]\[9\] dp.rf.rf\[22\]\[9\]
+ dp.rf.rf\[23\]\[9\] net13 net278 VSS VSS VDD VDD _1409_ sky130_fd_sc_hd__mux4_1
X_5132_ _1406_ _1407_ _1408_ _1409_ _0103_ net15 VSS VSS VDD
+ VDD _1410_ sky130_fd_sc_hd__mux4_1
X_5133_ net17 _1410_ VSS VSS VDD VDD _1411_ sky130_fd_sc_hd__nand2_1
X_5134_ dp.rf.rf\[8\]\[9\] dp.rf.rf\[9\]\[9\] dp.rf.rf\[10\]\[9\]
+ dp.rf.rf\[11\]\[9\] net13 net14 VSS VSS VDD VDD _1412_ sky130_fd_sc_hd__mux4_1
X_5135_ dp.rf.rf\[0\]\[9\] dp.rf.rf\[1\]\[9\] dp.rf.rf\[2\]\[9\]
+ dp.rf.rf\[3\]\[9\] net215 net14 VSS VSS VDD VDD _1413_ sky130_fd_sc_hd__mux4_1
X_5136_ dp.rf.rf\[12\]\[9\] dp.rf.rf\[13\]\[9\] dp.rf.rf\[14\]\[9\]
+ dp.rf.rf\[15\]\[9\] net215 net14 VSS VSS VDD VDD _1414_ sky130_fd_sc_hd__mux4_1
X_5137_ dp.rf.rf\[4\]\[9\] dp.rf.rf\[5\]\[9\] dp.rf.rf\[6\]\[9\]
+ dp.rf.rf\[7\]\[9\] net215 net14 VSS VSS VDD VDD _1415_ sky130_fd_sc_hd__mux4_1
X_5138_ _1412_ _1413_ _1414_ _1415_ _0103_ net15 VSS VSS VDD
+ VDD _1416_ sky130_fd_sc_hd__mux4_2
X_5139_ _0086_ _1416_ VSS VSS VDD VDD _1417_ sky130_fd_sc_hd__nand2_1
X_5140_ _1411_ _1417_ VSS VSS VDD VDD _1418_ sky130_fd_sc_hd__nand2_1
X_5141_ _0311_ _1418_ VSS VSS VDD VDD _1419_ sky130_fd_sc_hd__nand2_4
X_5142_ _0138_ _1419_ VSS VSS VDD VDD _1420_ sky130_fd_sc_hd__nor2_1
X_5143_ _0138_ _3565_ _1420_ VSS VSS VDD VDD _1421_ sky130_fd_sc_hd__a21oi_1
X_5144_ _0122_ _1421_ VSS VSS VDD VDD _3460_ sky130_fd_sc_hd__xor2_1
X_5145_ _3460_ VSS VSS VDD VDD _3464_ sky130_fd_sc_hd__inv_1
X_5146_ dp.rf.rf\[1\]\[9\] dp.rf.rf\[5\]\[9\] net208 VSS VSS
+ VDD VDD _1422_ sky130_fd_sc_hd__mux2_1
X_5147_ dp.rf.rf\[4\]\[9\] _0528_ _1422_ _0245_ VSS VSS VDD
+ VDD _1423_ sky130_fd_sc_hd__o22ai_1
X_5148_ dp.rf.rf\[2\]\[9\] dp.rf.rf\[3\]\[9\] dp.rf.rf\[6\]\[9\]
+ dp.rf.rf\[7\]\[9\] net211 net207 VSS VSS VDD VDD _1424_ sky130_fd_sc_hd__mux4_1
X_5149_ net8 _1424_ VSS VSS VDD VDD _1425_ sky130_fd_sc_hd__nand2_1
X_5150_ net8 _1423_ _1425_ _0493_ VSS VSS VDD VDD _1426_ sky130_fd_sc_hd__o211ai_2
X_5151_ dp.rf.rf\[10\]\[9\] dp.rf.rf\[11\]\[9\] dp.rf.rf\[14\]\[9\]
+ dp.rf.rf\[15\]\[9\] net7 net9 VSS VSS VDD VDD _1427_ sky130_fd_sc_hd__mux4_1
X_5152_ net8 _1427_ VSS VSS VDD VDD _1428_ sky130_fd_sc_hd__nand2_1
X_5153_ dp.rf.rf\[8\]\[9\] dp.rf.rf\[9\]\[9\] dp.rf.rf\[12\]\[9\]
+ dp.rf.rf\[13\]\[9\] net7 net9 VSS VSS VDD VDD _1429_ sky130_fd_sc_hd__mux4_1
X_5154_ _0224_ _1429_ VSS VSS VDD VDD _1430_ sky130_fd_sc_hd__nand2_1
X_5155_ net186 _1428_ _1430_ VSS VSS VDD VDD _1431_ sky130_fd_sc_hd__nand3_2
X_5156_ dp.rf.rf\[26\]\[9\] dp.rf.rf\[27\]\[9\] dp.rf.rf\[30\]\[9\]
+ dp.rf.rf\[31\]\[9\] net7 net9 VSS VSS VDD VDD _1432_ sky130_fd_sc_hd__mux4_1
X_5157_ net8 _1432_ VSS VSS VDD VDD _1433_ sky130_fd_sc_hd__nand2_1
X_5158_ dp.rf.rf\[24\]\[9\] dp.rf.rf\[25\]\[9\] dp.rf.rf\[28\]\[9\]
+ dp.rf.rf\[29\]\[9\] net7 net9 VSS VSS VDD VDD _1434_ sky130_fd_sc_hd__mux4_1
X_5159_ net205 _1434_ VSS VSS VDD VDD _1435_ sky130_fd_sc_hd__nand2_1
X_5160_ net10 _1433_ _1435_ _0166_ VSS VSS VDD VDD _1436_
+ sky130_fd_sc_hd__a31oi_2
X_5161_ dp.rf.rf\[22\]\[9\] dp.rf.rf\[23\]\[9\] net7 VSS VSS
+ VDD VDD _1437_ sky130_fd_sc_hd__mux2_1
X_5162_ _0148_ _1437_ net183 VSS VSS VDD VDD _1438_ sky130_fd_sc_hd__o21ai_0
X_5163_ dp.rf.rf\[19\]\[9\] net7 net200 dp.rf.rf\[18\]\[9\]
+ net189 VSS VSS VDD VDD _1439_ sky130_fd_sc_hd__a221oi_1
X_5164_ dp.rf.rf\[20\]\[9\] VSS VSS VDD VDD _1440_ sky130_fd_sc_hd__inv_1
X_5165_ dp.rf.rf\[17\]\[9\] dp.rf.rf\[21\]\[9\] net9 VSS VSS
+ VDD VDD _1441_ sky130_fd_sc_hd__mux2i_1
X_5166_ _1440_ _0263_ _1441_ net7 net8 VSS VSS VDD VDD _1442_
+ sky130_fd_sc_hd__a221oi_1
X_5167_ dp.rf.rf\[16\]\[9\] net180 _1442_ _0202_ VSS VSS VDD
+ VDD _1443_ sky130_fd_sc_hd__o22ai_1
X_5168_ _1438_ _1439_ _1443_ VSS VSS VDD VDD _1444_ sky130_fd_sc_hd__o21ai_1
X_5169_ net193 _1431_ _1426_ _1436_ _1444_ VSS VSS VDD VDD
+ _3463_ sky130_fd_sc_hd__a32oi_4
X_5170_ dp.rf.rf\[24\]\[8\] dp.rf.rf\[25\]\[8\] dp.rf.rf\[26\]\[8\]
+ dp.rf.rf\[27\]\[8\] net214 net277 VSS VSS VDD VDD _1445_ sky130_fd_sc_hd__mux4_1
X_5171_ dp.rf.rf\[16\]\[8\] dp.rf.rf\[17\]\[8\] dp.rf.rf\[18\]\[8\]
+ dp.rf.rf\[19\]\[8\] net214 net277 VSS VSS VDD VDD _1446_ sky130_fd_sc_hd__mux4_1
X_5172_ dp.rf.rf\[28\]\[8\] dp.rf.rf\[29\]\[8\] dp.rf.rf\[30\]\[8\]
+ dp.rf.rf\[31\]\[8\] net214 net277 VSS VSS VDD VDD _1447_ sky130_fd_sc_hd__mux4_1
X_5173_ dp.rf.rf\[20\]\[8\] dp.rf.rf\[21\]\[8\] dp.rf.rf\[22\]\[8\]
+ dp.rf.rf\[23\]\[8\] net214 net278 VSS VSS VDD VDD _1448_ sky130_fd_sc_hd__mux4_1
X_5174_ _1445_ _1446_ _1447_ _1448_ _0103_ net15 VSS VSS VDD
+ VDD _1449_ sky130_fd_sc_hd__mux4_1
X_5175_ dp.rf.rf\[8\]\[8\] dp.rf.rf\[9\]\[8\] dp.rf.rf\[10\]\[8\]
+ dp.rf.rf\[11\]\[8\] net214 net278 VSS VSS VDD VDD _1450_ sky130_fd_sc_hd__mux4_1
X_5176_ dp.rf.rf\[0\]\[8\] dp.rf.rf\[1\]\[8\] dp.rf.rf\[2\]\[8\]
+ dp.rf.rf\[3\]\[8\] net214 net278 VSS VSS VDD VDD _1451_ sky130_fd_sc_hd__mux4_1
X_5177_ dp.rf.rf\[12\]\[8\] dp.rf.rf\[13\]\[8\] dp.rf.rf\[14\]\[8\]
+ dp.rf.rf\[15\]\[8\] net214 net278 VSS VSS VDD VDD _1452_ sky130_fd_sc_hd__mux4_1
X_5178_ dp.rf.rf\[4\]\[8\] dp.rf.rf\[5\]\[8\] dp.rf.rf\[6\]\[8\]
+ dp.rf.rf\[7\]\[8\] net214 net278 VSS VSS VDD VDD _1453_ sky130_fd_sc_hd__mux4_1
X_5179_ _1450_ _1451_ _1452_ _1453_ _0103_ net15 VSS VSS VDD
+ VDD _1454_ sky130_fd_sc_hd__mux4_2
X_5180_ net17 _1449_ _1454_ net184 VSS VSS VDD VDD _1455_
+ sky130_fd_sc_hd__a22oi_4
X_5181_ net21 _0119_ VSS VSS VDD VDD _3561_ sky130_fd_sc_hd__and2_1
X_5182_ _0132_ _3561_ VSS VSS VDD VDD _1456_ sky130_fd_sc_hd__nor2_1
X_5183_ _0132_ _1455_ _1456_ VSS VSS VDD VDD _1457_ sky130_fd_sc_hd__a21oi_1
X_5184_ _0122_ _1457_ VSS VSS VDD VDD _3468_ sky130_fd_sc_hd__xnor2_1
X_5185_ _3468_ VSS VSS VDD VDD _3472_ sky130_fd_sc_hd__inv_1
X_5186_ dp.rf.rf\[24\]\[8\] dp.rf.rf\[25\]\[8\] dp.rf.rf\[28\]\[8\]
+ dp.rf.rf\[29\]\[8\] net210 net208 VSS VSS VDD VDD _1458_ sky130_fd_sc_hd__mux4_1
X_5187_ net205 _1458_ net199 VSS VSS VDD VDD _1459_ sky130_fd_sc_hd__a21oi_1
X_5188_ dp.rf.rf\[26\]\[8\] dp.rf.rf\[27\]\[8\] dp.rf.rf\[30\]\[8\]
+ dp.rf.rf\[31\]\[8\] net210 net208 VSS VSS VDD VDD _1460_ sky130_fd_sc_hd__mux4_1
X_5189_ _0406_ _1460_ VSS VSS VDD VDD _1461_ sky130_fd_sc_hd__nand2_1
X_5190_ _0166_ _1459_ _1461_ VSS VSS VDD VDD _1462_ sky130_fd_sc_hd__o21ai_2
X_5191_ dp.rf.rf\[18\]\[8\] dp.rf.rf\[19\]\[8\] dp.rf.rf\[22\]\[8\]
+ dp.rf.rf\[23\]\[8\] net210 net208 VSS VSS VDD VDD _1463_ sky130_fd_sc_hd__mux4_1
X_5192_ net183 _1463_ VSS VSS VDD VDD _1464_ sky130_fd_sc_hd__nand2_1
X_5193_ dp.rf.rf\[20\]\[8\] VSS VSS VDD VDD _1465_ sky130_fd_sc_hd__inv_1
X_5194_ dp.rf.rf\[17\]\[8\] dp.rf.rf\[21\]\[8\] net208 VSS
+ VSS VDD VDD _1466_ sky130_fd_sc_hd__mux2i_1
X_5195_ _1465_ _0263_ _1466_ net210 net8 VSS VSS VDD VDD _1467_
+ sky130_fd_sc_hd__a221oi_1
X_5196_ dp.rf.rf\[16\]\[8\] _0348_ _1467_ net197 VSS VSS VDD
+ VDD _1468_ sky130_fd_sc_hd__o22ai_1
X_5197_ _1464_ _1468_ VSS VSS VDD VDD _1469_ sky130_fd_sc_hd__nand2_1
X_5198_ dp.rf.rf\[9\]\[8\] dp.rf.rf\[11\]\[8\] dp.rf.rf\[13\]\[8\]
+ dp.rf.rf\[15\]\[8\] net8 net9 VSS VSS VDD VDD _1470_ sky130_fd_sc_hd__mux4_1
X_5199_ net7 _1470_ VSS VSS VDD VDD _1471_ sky130_fd_sc_hd__nand2_1
X_5200_ dp.rf.rf\[8\]\[8\] dp.rf.rf\[10\]\[8\] dp.rf.rf\[12\]\[8\]
+ dp.rf.rf\[14\]\[8\] net8 net9 VSS VSS VDD VDD _1472_ sky130_fd_sc_hd__mux4_1
X_5201_ _0245_ _1472_ VSS VSS VDD VDD _1473_ sky130_fd_sc_hd__nand2_1
X_5202_ net186 _1471_ _1473_ _0271_ VSS VSS VDD VDD _1474_
+ sky130_fd_sc_hd__a31oi_4
X_5203_ dp.rf.rf\[6\]\[8\] dp.rf.rf\[7\]\[8\] net7 VSS VSS
+ VDD VDD _1475_ sky130_fd_sc_hd__mux2_1
X_5204_ _0148_ _1475_ net183 VSS VSS VDD VDD _1476_ sky130_fd_sc_hd__o21ai_0
X_5205_ dp.rf.rf\[3\]\[8\] net7 _0176_ dp.rf.rf\[2\]\[8\]
+ net191 VSS VSS VDD VDD _1477_ sky130_fd_sc_hd__a221oi_1
X_5206_ dp.rf.rf\[4\]\[8\] VSS VSS VDD VDD _1478_ sky130_fd_sc_hd__inv_1
X_5207_ dp.rf.rf\[1\]\[8\] dp.rf.rf\[5\]\[8\] net9 VSS VSS
+ VDD VDD _1479_ sky130_fd_sc_hd__mux2i_1
X_5208_ _1478_ _0263_ _1479_ net7 net8 VSS VSS VDD VDD _1480_
+ sky130_fd_sc_hd__a221oi_1
X_5209_ dp.rf.rf\[0\]\[8\] _0348_ _1480_ net197 VSS VSS VDD
+ VDD _1481_ sky130_fd_sc_hd__o22ai_1
X_5210_ _1476_ _1477_ _1481_ VSS VSS VDD VDD _1482_ sky130_fd_sc_hd__o21ai_2
X_5211_ _1462_ _1469_ _1474_ _1482_ VSS VSS VDD VDD _3471_
+ sky130_fd_sc_hd__a22oi_4
X_5212_ dp.rf.rf\[12\]\[7\] dp.rf.rf\[13\]\[7\] dp.rf.rf\[14\]\[7\]
+ dp.rf.rf\[15\]\[7\] net13 net277 VSS VSS VDD VDD _1483_ sky130_fd_sc_hd__mux4_1
X_5213_ net16 _1483_ VSS VSS VDD VDD _1484_ sky130_fd_sc_hd__nand2_1
X_5214_ dp.rf.rf\[4\]\[7\] dp.rf.rf\[5\]\[7\] dp.rf.rf\[6\]\[7\]
+ dp.rf.rf\[7\]\[7\] net13 net277 VSS VSS VDD VDD _1485_ sky130_fd_sc_hd__mux4_1
X_5215_ _0103_ _1485_ VSS VSS VDD VDD _1486_ sky130_fd_sc_hd__nand2_1
X_5216_ net15 _1484_ _1486_ VSS VSS VDD VDD _1487_ sky130_fd_sc_hd__nand3_1
X_5217_ dp.rf.rf\[8\]\[7\] dp.rf.rf\[9\]\[7\] dp.rf.rf\[10\]\[7\]
+ dp.rf.rf\[11\]\[7\] net13 net277 VSS VSS VDD VDD _1488_ sky130_fd_sc_hd__mux4_1
X_5218_ net16 _1488_ VSS VSS VDD VDD _1489_ sky130_fd_sc_hd__nand2_1
X_5219_ dp.rf.rf\[0\]\[7\] dp.rf.rf\[1\]\[7\] dp.rf.rf\[2\]\[7\]
+ dp.rf.rf\[3\]\[7\] net13 net277 VSS VSS VDD VDD _1490_ sky130_fd_sc_hd__mux4_1
X_5220_ _0103_ _1490_ VSS VSS VDD VDD _1491_ sky130_fd_sc_hd__nand2_1
X_5221_ _0286_ _1489_ _1491_ VSS VSS VDD VDD _1492_ sky130_fd_sc_hd__nand3_1
X_5222_ dp.rf.rf\[28\]\[7\] dp.rf.rf\[29\]\[7\] dp.rf.rf\[30\]\[7\]
+ dp.rf.rf\[31\]\[7\] net214 net277 VSS VSS VDD VDD _1493_ sky130_fd_sc_hd__mux4_1
X_5223_ dp.rf.rf\[20\]\[7\] dp.rf.rf\[21\]\[7\] dp.rf.rf\[22\]\[7\]
+ dp.rf.rf\[23\]\[7\] net13 net277 VSS VSS VDD VDD _1494_ sky130_fd_sc_hd__mux4_1
X_5224_ _1493_ _1494_ _0103_ VSS VSS VDD VDD _1495_ sky130_fd_sc_hd__mux2i_1
X_5225_ dp.rf.rf\[24\]\[7\] dp.rf.rf\[25\]\[7\] dp.rf.rf\[26\]\[7\]
+ dp.rf.rf\[27\]\[7\] net214 net277 VSS VSS VDD VDD _1496_ sky130_fd_sc_hd__mux4_1
X_5226_ net16 _1496_ VSS VSS VDD VDD _1497_ sky130_fd_sc_hd__nand2_1
X_5227_ dp.rf.rf\[16\]\[7\] dp.rf.rf\[17\]\[7\] dp.rf.rf\[18\]\[7\]
+ dp.rf.rf\[19\]\[7\] net13 net277 VSS VSS VDD VDD _1498_ sky130_fd_sc_hd__mux4_1
X_5228_ _0103_ _1498_ VSS VSS VDD VDD _1499_ sky130_fd_sc_hd__nand2_1
X_5229_ _0286_ _1497_ _1499_ VSS VSS VDD VDD _1500_ sky130_fd_sc_hd__and3_1
X_5230_ net15 _1495_ _1500_ VSS VSS VDD VDD _1501_ sky130_fd_sc_hd__a21oi_1
X_5231_ net184 _1487_ _1492_ _1501_ net17 VSS VSS VDD VDD
+ _1502_ sky130_fd_sc_hd__a32oi_4
X_5232_ _1502_ VSS VSS VDD VDD net162 sky130_fd_sc_hd__inv_1
X_5233_ net20 _0119_ VSS VSS VDD VDD _3557_ sky130_fd_sc_hd__and2_1
X_5234_ _0138_ _3557_ VSS VSS VDD VDD _1503_ sky130_fd_sc_hd__nand2_1
X_5235_ _0138_ _1502_ _1503_ VSS VSS VDD VDD _1504_ sky130_fd_sc_hd__o21ai_0
X_5236_ _0122_ _1504_ VSS VSS VDD VDD _3476_ sky130_fd_sc_hd__xnor2_1
X_5237_ _3476_ VSS VSS VDD VDD _3480_ sky130_fd_sc_hd__inv_1
X_5238_ dp.rf.rf\[8\]\[7\] dp.rf.rf\[9\]\[7\] dp.rf.rf\[12\]\[7\]
+ dp.rf.rf\[13\]\[7\] net210 net208 VSS VSS VDD VDD _1505_ sky130_fd_sc_hd__mux4_1
X_5239_ net205 _1505_ VSS VSS VDD VDD _1506_ sky130_fd_sc_hd__nand2_1
X_5240_ dp.rf.rf\[10\]\[7\] dp.rf.rf\[11\]\[7\] dp.rf.rf\[14\]\[7\]
+ dp.rf.rf\[15\]\[7\] net210 net208 VSS VSS VDD VDD _1507_ sky130_fd_sc_hd__mux4_1
X_5241_ net183 _1507_ _0192_ VSS VSS VDD VDD _1508_ sky130_fd_sc_hd__a21oi_1
X_5242_ _1506_ _1508_ VSS VSS VDD VDD _1509_ sky130_fd_sc_hd__nand2_1
X_5243_ dp.rf.rf\[6\]\[7\] dp.rf.rf\[7\]\[7\] net210 VSS VSS
+ VDD VDD _1510_ sky130_fd_sc_hd__mux2_1
X_5244_ _0148_ _1510_ net183 VSS VSS VDD VDD _1511_ sky130_fd_sc_hd__o21ai_0
X_5245_ dp.rf.rf\[3\]\[7\] net209 net200 dp.rf.rf\[2\]\[7\]
+ net189 VSS VSS VDD VDD _1512_ sky130_fd_sc_hd__a221oi_1
X_5246_ dp.rf.rf\[4\]\[7\] VSS VSS VDD VDD _1513_ sky130_fd_sc_hd__inv_1
X_5247_ dp.rf.rf\[1\]\[7\] dp.rf.rf\[5\]\[7\] net208 VSS VSS
+ VDD VDD _1514_ sky130_fd_sc_hd__mux2i_1
X_5248_ _1513_ net204 _1514_ net210 net8 VSS VSS VDD VDD _1515_
+ sky130_fd_sc_hd__a221oi_1
X_5249_ dp.rf.rf\[0\]\[7\] net180 _1515_ _0202_ VSS VSS VDD
+ VDD _1516_ sky130_fd_sc_hd__o22ai_1
X_5250_ _1511_ _1512_ _1516_ VSS VSS VDD VDD _1517_ sky130_fd_sc_hd__o21ai_2
X_5251_ dp.rf.rf\[24\]\[7\] dp.rf.rf\[25\]\[7\] dp.rf.rf\[28\]\[7\]
+ dp.rf.rf\[29\]\[7\] net210 net208 VSS VSS VDD VDD _1518_ sky130_fd_sc_hd__mux4_1
X_5252_ net205 _1518_ VSS VSS VDD VDD _1519_ sky130_fd_sc_hd__nand2_1
X_5253_ dp.rf.rf\[26\]\[7\] dp.rf.rf\[27\]\[7\] dp.rf.rf\[30\]\[7\]
+ dp.rf.rf\[31\]\[7\] net210 net208 VSS VSS VDD VDD _1520_ sky130_fd_sc_hd__mux4_1
X_5254_ net8 _1520_ VSS VSS VDD VDD _1521_ sky130_fd_sc_hd__nand2_1
X_5255_ net10 _1519_ _1521_ _0166_ VSS VSS VDD VDD _1522_
+ sky130_fd_sc_hd__a31oi_2
X_5256_ dp.rf.rf\[22\]\[7\] dp.rf.rf\[23\]\[7\] net210 VSS
+ VSS VDD VDD _1523_ sky130_fd_sc_hd__mux2_1
X_5257_ _0148_ _1523_ net183 VSS VSS VDD VDD _1524_ sky130_fd_sc_hd__o21ai_0
X_5258_ dp.rf.rf\[19\]\[7\] net210 net200 dp.rf.rf\[18\]\[7\]
+ net189 VSS VSS VDD VDD _1525_ sky130_fd_sc_hd__a221oi_1
X_5259_ dp.rf.rf\[20\]\[7\] VSS VSS VDD VDD _1526_ sky130_fd_sc_hd__inv_1
X_5260_ dp.rf.rf\[17\]\[7\] dp.rf.rf\[21\]\[7\] net208 VSS
+ VSS VDD VDD _1527_ sky130_fd_sc_hd__mux2i_1
X_5261_ _1526_ net204 _1527_ net210 net8 VSS VSS VDD VDD _1528_
+ sky130_fd_sc_hd__a221oi_1
X_5262_ dp.rf.rf\[16\]\[7\] net180 _1528_ _0202_ VSS VSS VDD
+ VDD _1529_ sky130_fd_sc_hd__o22ai_1
X_5263_ _1524_ _1525_ _1529_ VSS VSS VDD VDD _1530_ sky130_fd_sc_hd__o21ai_1
X_5264_ _1509_ net193 _1517_ _1522_ _1530_ VSS VSS VDD VDD
+ _3479_ sky130_fd_sc_hd__a32oi_4
X_5265_ dp.rf.rf\[24\]\[6\] dp.rf.rf\[25\]\[6\] dp.rf.rf\[26\]\[6\]
+ dp.rf.rf\[27\]\[6\] net213 net278 VSS VSS VDD VDD _1531_ sky130_fd_sc_hd__mux4_1
X_5266_ dp.rf.rf\[16\]\[6\] dp.rf.rf\[17\]\[6\] dp.rf.rf\[18\]\[6\]
+ dp.rf.rf\[19\]\[6\] net213 net278 VSS VSS VDD VDD _1532_ sky130_fd_sc_hd__mux4_1
X_5267_ dp.rf.rf\[28\]\[6\] dp.rf.rf\[29\]\[6\] dp.rf.rf\[30\]\[6\]
+ dp.rf.rf\[31\]\[6\] net213 net278 VSS VSS VDD VDD _1533_ sky130_fd_sc_hd__mux4_1
X_5268_ dp.rf.rf\[20\]\[6\] dp.rf.rf\[21\]\[6\] dp.rf.rf\[22\]\[6\]
+ dp.rf.rf\[23\]\[6\] net213 net278 VSS VSS VDD VDD _1534_ sky130_fd_sc_hd__mux4_1
X_5269_ _1531_ _1532_ _1533_ _1534_ _0103_ net15 VSS VSS VDD
+ VDD _1535_ sky130_fd_sc_hd__mux4_1
X_5270_ dp.rf.rf\[8\]\[6\] dp.rf.rf\[9\]\[6\] dp.rf.rf\[10\]\[6\]
+ dp.rf.rf\[11\]\[6\] net215 net14 VSS VSS VDD VDD _1536_ sky130_fd_sc_hd__mux4_1
X_5271_ dp.rf.rf\[0\]\[6\] dp.rf.rf\[1\]\[6\] dp.rf.rf\[2\]\[6\]
+ dp.rf.rf\[3\]\[6\] net215 net14 VSS VSS VDD VDD _1537_ sky130_fd_sc_hd__mux4_1
X_5272_ dp.rf.rf\[12\]\[6\] dp.rf.rf\[13\]\[6\] dp.rf.rf\[14\]\[6\]
+ dp.rf.rf\[15\]\[6\] net215 net14 VSS VSS VDD VDD _1538_ sky130_fd_sc_hd__mux4_1
X_5273_ dp.rf.rf\[4\]\[6\] dp.rf.rf\[5\]\[6\] dp.rf.rf\[6\]\[6\]
+ dp.rf.rf\[7\]\[6\] net215 net14 VSS VSS VDD VDD _1539_ sky130_fd_sc_hd__mux4_1
X_5274_ _1536_ _1537_ _1538_ _1539_ _0103_ net15 VSS VSS VDD
+ VDD _1540_ sky130_fd_sc_hd__mux4_1
X_5275_ net17 _1535_ _1540_ net184 VSS VSS VDD VDD net161
+ sky130_fd_sc_hd__a22o_4
X_5276_ net19 _0119_ VSS VSS VDD VDD _3553_ sky130_fd_sc_hd__and2_1
X_5277_ net161 _3553_ _0138_ VSS VSS VDD VDD _1541_ sky130_fd_sc_hd__mux2_1
X_5278_ _0122_ _1541_ VSS VSS VDD VDD _3484_ sky130_fd_sc_hd__xnor2_1
X_5279_ _3484_ VSS VSS VDD VDD _3488_ sky130_fd_sc_hd__inv_1
X_5280_ dp.rf.rf\[10\]\[6\] dp.rf.rf\[11\]\[6\] dp.rf.rf\[14\]\[6\]
+ dp.rf.rf\[15\]\[6\] net211 net207 VSS VSS VDD VDD _1542_ sky130_fd_sc_hd__mux4_1
X_5281_ net8 _1542_ VSS VSS VDD VDD _1543_ sky130_fd_sc_hd__nand2_1
X_5282_ dp.rf.rf\[8\]\[6\] dp.rf.rf\[9\]\[6\] dp.rf.rf\[12\]\[6\]
+ dp.rf.rf\[13\]\[6\] net211 net207 VSS VSS VDD VDD _1544_ sky130_fd_sc_hd__mux4_1
X_5283_ _0224_ _1544_ VSS VSS VDD VDD _1545_ sky130_fd_sc_hd__nand2_1
X_5284_ net185 _1543_ _1545_ VSS VSS VDD VDD _1546_ sky130_fd_sc_hd__nand3_2
X_5285_ dp.rf.rf\[6\]\[6\] dp.rf.rf\[7\]\[6\] net211 VSS VSS
+ VDD VDD _1547_ sky130_fd_sc_hd__mux2_1
X_5286_ _0148_ _1547_ _0337_ VSS VSS VDD VDD _1548_ sky130_fd_sc_hd__o21ai_0
X_5287_ dp.rf.rf\[3\]\[6\] net211 net200 dp.rf.rf\[2\]\[6\]
+ net189 VSS VSS VDD VDD _1549_ sky130_fd_sc_hd__a221oi_1
X_5288_ dp.rf.rf\[4\]\[6\] VSS VSS VDD VDD _1550_ sky130_fd_sc_hd__inv_1
X_5289_ dp.rf.rf\[1\]\[6\] dp.rf.rf\[5\]\[6\] net207 VSS VSS
+ VDD VDD _1551_ sky130_fd_sc_hd__mux2i_1
X_5290_ _1550_ net204 _1551_ net211 net8 VSS VSS VDD VDD _1552_
+ sky130_fd_sc_hd__a221oi_1
X_5291_ dp.rf.rf\[0\]\[6\] net180 _1552_ _0202_ VSS VSS VDD
+ VDD _1553_ sky130_fd_sc_hd__o22ai_1
X_5292_ _1548_ _1549_ _1553_ VSS VSS VDD VDD _1554_ sky130_fd_sc_hd__o21ai_2
X_5293_ dp.rf.rf\[26\]\[6\] dp.rf.rf\[27\]\[6\] dp.rf.rf\[30\]\[6\]
+ dp.rf.rf\[31\]\[6\] net7 net208 VSS VSS VDD VDD _1555_ sky130_fd_sc_hd__mux4_1
X_5294_ net8 _1555_ VSS VSS VDD VDD _1556_ sky130_fd_sc_hd__nand2_1
X_5295_ dp.rf.rf\[24\]\[6\] dp.rf.rf\[25\]\[6\] dp.rf.rf\[28\]\[6\]
+ dp.rf.rf\[29\]\[6\] net7 net208 VSS VSS VDD VDD _1557_ sky130_fd_sc_hd__mux4_1
X_5296_ _0224_ _1557_ VSS VSS VDD VDD _1558_ sky130_fd_sc_hd__nand2_1
X_5297_ net10 _1556_ _1558_ _0166_ VSS VSS VDD VDD _1559_
+ sky130_fd_sc_hd__a31oi_2
X_5298_ dp.rf.rf\[22\]\[6\] dp.rf.rf\[23\]\[6\] net7 VSS VSS
+ VDD VDD _1560_ sky130_fd_sc_hd__mux2_1
X_5299_ _0148_ _1560_ _0337_ VSS VSS VDD VDD _1561_ sky130_fd_sc_hd__o21ai_0
X_5300_ dp.rf.rf\[19\]\[6\] net7 net200 dp.rf.rf\[18\]\[6\]
+ net189 VSS VSS VDD VDD _1562_ sky130_fd_sc_hd__a221oi_1
X_5301_ dp.rf.rf\[20\]\[6\] VSS VSS VDD VDD _1563_ sky130_fd_sc_hd__inv_1
X_5302_ dp.rf.rf\[17\]\[6\] dp.rf.rf\[21\]\[6\] net206 VSS
+ VSS VDD VDD _1564_ sky130_fd_sc_hd__mux2i_1
X_5303_ _1563_ net204 _1564_ net7 net8 VSS VSS VDD VDD _1565_
+ sky130_fd_sc_hd__a221oi_1
X_5304_ dp.rf.rf\[16\]\[6\] net180 _1565_ _0202_ VSS VSS VDD
+ VDD _1566_ sky130_fd_sc_hd__o22ai_1
X_5305_ _1561_ _1562_ _1566_ VSS VSS VDD VDD _1567_ sky130_fd_sc_hd__o21ai_1
X_5306_ _1546_ net193 _1554_ _1567_ _1559_ VSS VSS VDD VDD
+ _3487_ sky130_fd_sc_hd__a32oi_4
X_5307_ dp.rf.rf\[24\]\[5\] dp.rf.rf\[25\]\[5\] dp.rf.rf\[26\]\[5\]
+ dp.rf.rf\[27\]\[5\] net214 net277 VSS VSS VDD VDD _1568_ sky130_fd_sc_hd__mux4_1
X_5308_ dp.rf.rf\[16\]\[5\] dp.rf.rf\[17\]\[5\] dp.rf.rf\[18\]\[5\]
+ dp.rf.rf\[19\]\[5\] net214 net277 VSS VSS VDD VDD _1569_ sky130_fd_sc_hd__mux4_1
X_5309_ dp.rf.rf\[28\]\[5\] dp.rf.rf\[29\]\[5\] dp.rf.rf\[30\]\[5\]
+ dp.rf.rf\[31\]\[5\] net214 net277 VSS VSS VDD VDD _1570_ sky130_fd_sc_hd__mux4_1
X_5310_ dp.rf.rf\[20\]\[5\] dp.rf.rf\[21\]\[5\] dp.rf.rf\[22\]\[5\]
+ dp.rf.rf\[23\]\[5\] net214 net277 VSS VSS VDD VDD _1571_ sky130_fd_sc_hd__mux4_1
X_5311_ _1568_ _1569_ _1570_ _1571_ _0103_ net15 VSS VSS VDD
+ VDD _1572_ sky130_fd_sc_hd__mux4_2
X_5312_ dp.rf.rf\[8\]\[5\] dp.rf.rf\[9\]\[5\] dp.rf.rf\[10\]\[5\]
+ dp.rf.rf\[11\]\[5\] net214 net277 VSS VSS VDD VDD _1573_ sky130_fd_sc_hd__mux4_1
X_5313_ dp.rf.rf\[0\]\[5\] dp.rf.rf\[1\]\[5\] dp.rf.rf\[2\]\[5\]
+ dp.rf.rf\[3\]\[5\] net214 net277 VSS VSS VDD VDD _1574_ sky130_fd_sc_hd__mux4_1
X_5314_ dp.rf.rf\[12\]\[5\] dp.rf.rf\[13\]\[5\] dp.rf.rf\[14\]\[5\]
+ dp.rf.rf\[15\]\[5\] net214 net277 VSS VSS VDD VDD _1575_ sky130_fd_sc_hd__mux4_1
X_5315_ dp.rf.rf\[4\]\[5\] dp.rf.rf\[5\]\[5\] dp.rf.rf\[6\]\[5\]
+ dp.rf.rf\[7\]\[5\] net214 net277 VSS VSS VDD VDD _1576_ sky130_fd_sc_hd__mux4_1
X_5316_ _1573_ _1574_ _1575_ _1576_ _0103_ net15 VSS VSS VDD
+ VDD _1577_ sky130_fd_sc_hd__mux4_1
X_5317_ _1572_ _1577_ _0086_ VSS VSS VDD VDD _1578_ sky130_fd_sc_hd__mux2i_4
X_5318_ _0401_ _1578_ VSS VSS VDD VDD net160 sky130_fd_sc_hd__nor2_2
X_5319_ net18 _0119_ VSS VSS VDD VDD _3549_ sky130_fd_sc_hd__and2_1
X_5320_ _0138_ _0401_ _1578_ VSS VSS VDD VDD _1579_ sky130_fd_sc_hd__nor3_1
X_5321_ _0138_ _3549_ _1579_ VSS VSS VDD VDD _1580_ sky130_fd_sc_hd__a21oi_1
X_5322_ _0122_ _1580_ VSS VSS VDD VDD _3492_ sky130_fd_sc_hd__xor2_1
X_5323_ _3492_ VSS VSS VDD VDD _3496_ sky130_fd_sc_hd__inv_1
X_5324_ dp.rf.rf\[26\]\[5\] dp.rf.rf\[27\]\[5\] net7 VSS VSS
+ VDD VDD _1581_ sky130_fd_sc_hd__mux2_1
X_5325_ dp.rf.rf\[30\]\[5\] dp.rf.rf\[31\]\[5\] net7 VSS VSS
+ VDD VDD _1582_ sky130_fd_sc_hd__mux2_1
X_5326_ net191 _1581_ _1582_ _0148_ net8 VSS VSS VDD VDD _1583_
+ sky130_fd_sc_hd__o221ai_1
X_5327_ dp.rf.rf\[24\]\[5\] dp.rf.rf\[25\]\[5\] dp.rf.rf\[28\]\[5\]
+ dp.rf.rf\[29\]\[5\] net7 net9 VSS VSS VDD VDD _1584_ sky130_fd_sc_hd__mux4_1
X_5328_ net205 _1584_ VSS VSS VDD VDD _1585_ sky130_fd_sc_hd__nand2_1
X_5329_ net186 _1583_ _1585_ VSS VSS VDD VDD _1586_ sky130_fd_sc_hd__nand3_1
X_5330_ net7 dp.rf.rf\[22\]\[5\] VSS VSS VDD VDD _1587_ sky130_fd_sc_hd__nor2b_1
X_5331_ dp.rf.rf\[23\]\[5\] net7 _0148_ _1587_ VSS VSS VDD
+ VDD _1588_ sky130_fd_sc_hd__a211oi_1
X_5332_ dp.rf.rf\[19\]\[5\] net7 _0176_ dp.rf.rf\[18\]\[5\]
+ net191 VSS VSS VDD VDD _1589_ sky130_fd_sc_hd__a221oi_1
X_5333_ dp.rf.rf\[20\]\[5\] VSS VSS VDD VDD _1590_ sky130_fd_sc_hd__inv_1
X_5334_ dp.rf.rf\[17\]\[5\] dp.rf.rf\[21\]\[5\] net208 VSS
+ VSS VDD VDD _1591_ sky130_fd_sc_hd__mux2i_1
X_5335_ _1590_ _0263_ _1591_ net7 net8 VSS VSS VDD VDD _1592_
+ sky130_fd_sc_hd__a221oi_1
X_5336_ dp.rf.rf\[16\]\[5\] _0348_ _1592_ net197 VSS VSS VDD
+ VDD _1593_ sky130_fd_sc_hd__o22ai_1
X_5337_ net192 _1588_ _1589_ _1593_ VSS VSS VDD VDD _1594_
+ sky130_fd_sc_hd__o31ai_2
X_5338_ dp.rf.rf\[10\]\[5\] dp.rf.rf\[11\]\[5\] dp.rf.rf\[14\]\[5\]
+ dp.rf.rf\[15\]\[5\] net210 net208 VSS VSS VDD VDD _1595_ sky130_fd_sc_hd__mux4_1
X_5339_ dp.rf.rf\[8\]\[5\] dp.rf.rf\[9\]\[5\] dp.rf.rf\[12\]\[5\]
+ dp.rf.rf\[13\]\[5\] net210 net208 VSS VSS VDD VDD _1596_ sky130_fd_sc_hd__mux4_1
X_5340_ _1595_ _1596_ net205 VSS VSS VDD VDD _1597_ sky130_fd_sc_hd__mux2i_1
X_5341_ dp.rf.rf\[2\]\[5\] dp.rf.rf\[3\]\[5\] dp.rf.rf\[6\]\[5\]
+ dp.rf.rf\[7\]\[5\] net210 net208 VSS VSS VDD VDD _1598_ sky130_fd_sc_hd__mux4_1
X_5342_ dp.rf.rf\[4\]\[5\] VSS VSS VDD VDD _1599_ sky130_fd_sc_hd__inv_1
X_5343_ dp.rf.rf\[1\]\[5\] dp.rf.rf\[5\]\[5\] net208 VSS VSS
+ VDD VDD _1600_ sky130_fd_sc_hd__mux2i_1
X_5344_ _1599_ _0263_ _1600_ net210 net8 VSS VSS VDD VDD _1601_
+ sky130_fd_sc_hd__a221oi_1
X_5345_ net8 _1598_ _1601_ net197 VSS VSS VDD VDD _1602_ sky130_fd_sc_hd__a211oi_1
X_5346_ net186 _1597_ _1602_ _0271_ VSS VSS VDD VDD _1603_
+ sky130_fd_sc_hd__a211oi_2
X_5347_ _0232_ _1586_ _1594_ _1603_ VSS VSS VDD VDD _3495_
+ sky130_fd_sc_hd__a31oi_4
X_5348_ _0042_ _0130_ VSS VSS VDD VDD _1604_ sky130_fd_sc_hd__nor2_2
X_5349_ net3 _0042_ _1604_ net17 VSS VSS VDD VDD _1605_ sky130_fd_sc_hd__a22oi_4
X_5350_ _1605_ VSS VSS VDD VDD _3545_ sky130_fd_sc_hd__inv_1
X_5351_ dp.rf.rf\[4\]\[4\] dp.rf.rf\[5\]\[4\] dp.rf.rf\[6\]\[4\]
+ dp.rf.rf\[7\]\[4\] net215 net14 VSS VSS VDD VDD _1606_ sky130_fd_sc_hd__mux4_1
X_5352_ dp.rf.rf\[0\]\[4\] dp.rf.rf\[1\]\[4\] dp.rf.rf\[2\]\[4\]
+ dp.rf.rf\[3\]\[4\] net215 net14 VSS VSS VDD VDD _1607_ sky130_fd_sc_hd__mux4_1
X_5353_ _1606_ _1607_ _0286_ VSS VSS VDD VDD _1608_ sky130_fd_sc_hd__mux2i_2
X_5354_ dp.rf.rf\[28\]\[4\] dp.rf.rf\[29\]\[4\] dp.rf.rf\[30\]\[4\]
+ dp.rf.rf\[31\]\[4\] net213 net278 VSS VSS VDD VDD _1609_ sky130_fd_sc_hd__mux4_1
X_5355_ dp.rf.rf\[20\]\[4\] dp.rf.rf\[21\]\[4\] dp.rf.rf\[22\]\[4\]
+ dp.rf.rf\[23\]\[4\] net213 net278 VSS VSS VDD VDD _1610_ sky130_fd_sc_hd__mux4_1
X_5356_ dp.rf.rf\[24\]\[4\] dp.rf.rf\[25\]\[4\] dp.rf.rf\[26\]\[4\]
+ dp.rf.rf\[27\]\[4\] net213 net278 VSS VSS VDD VDD _1611_ sky130_fd_sc_hd__mux4_1
X_5357_ dp.rf.rf\[16\]\[4\] dp.rf.rf\[17\]\[4\] dp.rf.rf\[18\]\[4\]
+ dp.rf.rf\[19\]\[4\] net213 net278 VSS VSS VDD VDD _1612_ sky130_fd_sc_hd__mux4_1
X_5358_ _1609_ _1610_ _1611_ _1612_ _0103_ _0286_ VSS VSS
+ VDD VDD _1613_ sky130_fd_sc_hd__mux4_1
X_5359_ _0086_ _1613_ VSS VSS VDD VDD _1614_ sky130_fd_sc_hd__nor2_1
X_5360_ dp.rf.rf\[12\]\[4\] dp.rf.rf\[13\]\[4\] dp.rf.rf\[14\]\[4\]
+ dp.rf.rf\[15\]\[4\] net215 net14 VSS VSS VDD VDD _1615_ sky130_fd_sc_hd__mux4_1
X_5361_ dp.rf.rf\[8\]\[4\] dp.rf.rf\[9\]\[4\] dp.rf.rf\[10\]\[4\]
+ dp.rf.rf\[11\]\[4\] net215 net14 VSS VSS VDD VDD _1616_ sky130_fd_sc_hd__mux4_1
X_5362_ _0449_ _1615_ _1616_ _0448_ VSS VSS VDD VDD _1617_
+ sky130_fd_sc_hd__o22ai_1
X_5363_ _0394_ _1608_ _1617_ _0401_ _1614_ VSS VSS VDD VDD
+ _1618_ sky130_fd_sc_hd__a2111o_4
X_5364_ net428 VSS VSS VDD VDD net159 sky130_fd_sc_hd__inv_1
X_5365_ _1605_ _1618_ net178 VSS VSS VDD VDD _1619_ sky130_fd_sc_hd__mux2i_4
XTAP_TAPCELL_ROW_7_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5368_ _0122_ _1619_ VSS VSS VDD VDD _3500_ sky130_fd_sc_hd__xnor2_1
X_5369_ _3500_ VSS VSS VDD VDD _3504_ sky130_fd_sc_hd__inv_1
X_5370_ dp.rf.rf\[9\]\[4\] dp.rf.rf\[11\]\[4\] dp.rf.rf\[13\]\[4\]
+ dp.rf.rf\[15\]\[4\] net8 net207 VSS VSS VDD VDD _1622_ sky130_fd_sc_hd__mux4_1
X_5371_ net211 _1622_ VSS VSS VDD VDD _1623_ sky130_fd_sc_hd__nand2_1
X_5372_ dp.rf.rf\[8\]\[4\] dp.rf.rf\[10\]\[4\] dp.rf.rf\[12\]\[4\]
+ dp.rf.rf\[14\]\[4\] net8 net207 VSS VSS VDD VDD _1624_ sky130_fd_sc_hd__mux4_1
X_5373_ _0245_ _1624_ VSS VSS VDD VDD _1625_ sky130_fd_sc_hd__nand2_1
X_5374_ net185 _1623_ _1625_ VSS VSS VDD VDD _1626_ sky130_fd_sc_hd__nand3_1
X_5375_ dp.rf.rf\[1\]\[4\] dp.rf.rf\[5\]\[4\] net207 VSS VSS
+ VDD VDD _1627_ sky130_fd_sc_hd__mux2_1
X_5376_ dp.rf.rf\[4\]\[4\] _0528_ _1627_ _0245_ VSS VSS VDD
+ VDD _1628_ sky130_fd_sc_hd__o22ai_1
X_5377_ dp.rf.rf\[2\]\[4\] dp.rf.rf\[3\]\[4\] dp.rf.rf\[6\]\[4\]
+ dp.rf.rf\[7\]\[4\] net211 net207 VSS VSS VDD VDD _1629_ sky130_fd_sc_hd__mux4_1
X_5378_ net8 _1629_ VSS VSS VDD VDD _1630_ sky130_fd_sc_hd__nand2_1
X_5379_ net8 _1628_ _1630_ _0493_ VSS VSS VDD VDD _1631_ sky130_fd_sc_hd__o211ai_2
X_5380_ dp.rf.rf\[24\]\[4\] dp.rf.rf\[25\]\[4\] dp.rf.rf\[28\]\[4\]
+ dp.rf.rf\[29\]\[4\] net7 net206 VSS VSS VDD VDD _1632_ sky130_fd_sc_hd__mux4_1
X_5381_ net205 _1632_ VSS VSS VDD VDD _1633_ sky130_fd_sc_hd__nand2_1
X_5382_ dp.rf.rf\[26\]\[4\] dp.rf.rf\[27\]\[4\] dp.rf.rf\[30\]\[4\]
+ dp.rf.rf\[31\]\[4\] net7 net206 VSS VSS VDD VDD _1634_ sky130_fd_sc_hd__mux4_1
X_5383_ net8 _1634_ VSS VSS VDD VDD _1635_ sky130_fd_sc_hd__nand2_1
X_5384_ net185 _1633_ _1635_ VSS VSS VDD VDD _1636_ sky130_fd_sc_hd__nand3_1
X_5385_ dp.rf.rf\[16\]\[4\] dp.rf.rf\[20\]\[4\] net206 VSS
+ VSS VDD VDD _1637_ sky130_fd_sc_hd__mux2i_1
X_5386_ dp.rf.rf\[17\]\[4\] dp.rf.rf\[21\]\[4\] net206 VSS
+ VSS VDD VDD _1638_ sky130_fd_sc_hd__mux2i_1
X_5387_ _0170_ _1637_ _1638_ _0415_ _0145_ VSS VSS VDD VDD
+ _1639_ sky130_fd_sc_hd__o221ai_1
X_5388_ dp.rf.rf\[18\]\[4\] dp.rf.rf\[19\]\[4\] dp.rf.rf\[22\]\[4\]
+ dp.rf.rf\[23\]\[4\] net7 net206 VSS VSS VDD VDD _1640_ sky130_fd_sc_hd__mux4_1
X_5389_ net188 _1639_ _1640_ _0406_ VSS VSS VDD VDD _1641_
+ sky130_fd_sc_hd__a22o_1
X_5390_ _0209_ _1626_ _1631_ _1636_ _1641_ VSS VSS VDD VDD
+ _3499_ sky130_fd_sc_hd__a32o_4
X_5391_ _3499_ VSS VSS VDD VDD _3503_ sky130_fd_sc_hd__clkinv_2
X_5392_ net2 _0042_ _1604_ net16 VSS VSS VDD VDD _3539_ sky130_fd_sc_hd__a22o_2
X_5393_ dp.rf.rf\[24\]\[3\] dp.rf.rf\[25\]\[3\] dp.rf.rf\[26\]\[3\]
+ dp.rf.rf\[27\]\[3\] net13 net277 VSS VSS VDD VDD _1642_ sky130_fd_sc_hd__mux4_1
X_5394_ dp.rf.rf\[16\]\[3\] dp.rf.rf\[17\]\[3\] dp.rf.rf\[18\]\[3\]
+ dp.rf.rf\[19\]\[3\] net13 net277 VSS VSS VDD VDD _1643_ sky130_fd_sc_hd__mux4_1
X_5395_ dp.rf.rf\[28\]\[3\] dp.rf.rf\[29\]\[3\] dp.rf.rf\[30\]\[3\]
+ dp.rf.rf\[31\]\[3\] net13 net277 VSS VSS VDD VDD _1644_ sky130_fd_sc_hd__mux4_1
X_5396_ dp.rf.rf\[20\]\[3\] dp.rf.rf\[21\]\[3\] dp.rf.rf\[22\]\[3\]
+ dp.rf.rf\[23\]\[3\] net13 net277 VSS VSS VDD VDD _1645_ sky130_fd_sc_hd__mux4_1
X_5397_ _1642_ _1643_ _1644_ _1645_ _0103_ net15 VSS VSS VDD
+ VDD _1646_ sky130_fd_sc_hd__mux4_1
X_5398_ dp.rf.rf\[8\]\[3\] dp.rf.rf\[9\]\[3\] dp.rf.rf\[10\]\[3\]
+ dp.rf.rf\[11\]\[3\] net13 net277 VSS VSS VDD VDD _1647_ sky130_fd_sc_hd__mux4_1
X_5399_ dp.rf.rf\[0\]\[3\] dp.rf.rf\[1\]\[3\] dp.rf.rf\[2\]\[3\]
+ dp.rf.rf\[3\]\[3\] net13 net277 VSS VSS VDD VDD _1648_ sky130_fd_sc_hd__mux4_1
X_5400_ dp.rf.rf\[12\]\[3\] dp.rf.rf\[13\]\[3\] dp.rf.rf\[14\]\[3\]
+ dp.rf.rf\[15\]\[3\] net13 net277 VSS VSS VDD VDD _1649_ sky130_fd_sc_hd__mux4_1
X_5401_ dp.rf.rf\[4\]\[3\] dp.rf.rf\[5\]\[3\] dp.rf.rf\[6\]\[3\]
+ dp.rf.rf\[7\]\[3\] net13 net277 VSS VSS VDD VDD _1650_ sky130_fd_sc_hd__mux4_1
X_5402_ _1647_ _1648_ _1649_ _1650_ _0103_ net15 VSS VSS VDD
+ VDD _1651_ sky130_fd_sc_hd__mux4_1
X_5403_ net17 _1646_ _1651_ net184 VSS VSS VDD VDD net158
+ sky130_fd_sc_hd__a22o_4
X_5404_ _3539_ net158 net178 VSS VSS VDD VDD _1652_ sky130_fd_sc_hd__mux2_8
XTAP_TAPCELL_ROW_6_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5408_ _0122_ _1652_ VSS VSS VDD VDD _3508_ sky130_fd_sc_hd__xnor2_1
X_5409_ _3508_ VSS VSS VDD VDD _3512_ sky130_fd_sc_hd__inv_1
X_5410_ dp.rf.rf\[19\]\[3\] net210 _0176_ dp.rf.rf\[18\]\[3\]
+ net191 VSS VSS VDD VDD _1656_ sky130_fd_sc_hd__a221o_1
X_5411_ dp.rf.rf\[22\]\[3\] dp.rf.rf\[23\]\[3\] net210 VSS
+ VSS VDD VDD _1657_ sky130_fd_sc_hd__mux2i_1
X_5412_ net208 _1657_ _0130_ net205 VSS VSS VDD VDD _1658_
+ sky130_fd_sc_hd__a211oi_1
X_5413_ dp.rf.rf\[16\]\[3\] dp.rf.rf\[17\]\[3\] dp.rf.rf\[20\]\[3\]
+ dp.rf.rf\[21\]\[3\] net210 net208 VSS VSS VDD VDD _1659_ sky130_fd_sc_hd__mux4_1
X_5414_ net205 _1659_ VSS VSS VDD VDD _1660_ sky130_fd_sc_hd__nand2_1
X_5415_ _0232_ _1660_ VSS VSS VDD VDD _1661_ sky130_fd_sc_hd__nand2_1
X_5416_ _1656_ _1658_ _1661_ VSS VSS VDD VDD _1662_ sky130_fd_sc_hd__a21oi_1
X_5417_ _0231_ _1095_ net197 VSS VSS VDD VDD _1663_ sky130_fd_sc_hd__a21o_1
X_5418_ dp.rf.rf\[4\]\[3\] VSS VSS VDD VDD _1664_ sky130_fd_sc_hd__inv_1
X_5419_ dp.rf.rf\[1\]\[3\] dp.rf.rf\[5\]\[3\] net208 VSS VSS
+ VDD VDD _1665_ sky130_fd_sc_hd__mux2i_1
X_5420_ _1664_ net204 _1665_ net210 net8 VSS VSS VDD VDD _1666_
+ sky130_fd_sc_hd__a221oi_1
X_5421_ net11 _0130_ _1666_ VSS VSS VDD VDD _1667_ sky130_fd_sc_hd__nor3_1
X_5422_ _0231_ _0347_ VSS VSS VDD VDD _1668_ sky130_fd_sc_hd__nand2_1
X_5423_ _0119_ _1668_ dp.rf.rf\[0\]\[3\] VSS VSS VDD VDD _1669_
+ sky130_fd_sc_hd__a21oi_1
X_5424_ dp.rf.rf\[6\]\[3\] dp.rf.rf\[7\]\[3\] net210 VSS VSS
+ VDD VDD _1670_ sky130_fd_sc_hd__mux2i_1
X_5425_ net208 _1670_ net192 VSS VSS VDD VDD _1671_ sky130_fd_sc_hd__a21oi_1
X_5426_ dp.rf.rf\[3\]\[3\] net210 _0176_ dp.rf.rf\[2\]\[3\]
+ _0221_ VSS VSS VDD VDD _1672_ sky130_fd_sc_hd__a221o_1
X_5427_ _1667_ _1669_ _1671_ _1672_ VSS VSS VDD VDD _1673_
+ sky130_fd_sc_hd__a2bb2oi_1
X_5428_ dp.rf.rf\[26\]\[3\] dp.rf.rf\[30\]\[3\] net208 VSS
+ VSS VDD VDD _1674_ sky130_fd_sc_hd__mux2_1
X_5429_ net210 net208 VSS VSS VDD VDD _1675_ sky130_fd_sc_hd__nand2_1
X_5430_ net210 _1674_ _1675_ dp.rf.rf\[31\]\[3\] net8 VSS
+ VSS VDD VDD _1676_ sky130_fd_sc_hd__o221ai_1
X_5431_ _0115_ _0117_ dp.rf.rf\[27\]\[3\] _0245_ net208 VSS
+ VSS VDD VDD _1677_ sky130_fd_sc_hd__a2111oi_0
X_5432_ dp.rf.rf\[24\]\[3\] dp.rf.rf\[25\]\[3\] dp.rf.rf\[28\]\[3\]
+ dp.rf.rf\[29\]\[3\] net210 net208 VSS VSS VDD VDD _1678_ sky130_fd_sc_hd__mux4_1
X_5433_ net205 _1678_ VSS VSS VDD VDD _1679_ sky130_fd_sc_hd__nand2_1
X_5434_ _1676_ _1677_ _1679_ _0119_ net11 VSS VSS VDD VDD
+ _1680_ sky130_fd_sc_hd__o2111ai_1
X_5435_ net186 _1680_ VSS VSS VDD VDD _1681_ sky130_fd_sc_hd__nand2_1
X_5436_ dp.rf.rf\[11\]\[3\] net210 net200 dp.rf.rf\[10\]\[3\]
+ net189 VSS VSS VDD VDD _1682_ sky130_fd_sc_hd__a221o_1
X_5437_ dp.rf.rf\[14\]\[3\] dp.rf.rf\[15\]\[3\] net210 VSS
+ VSS VDD VDD _1683_ sky130_fd_sc_hd__mux2i_1
X_5438_ net208 _1683_ net192 VSS VSS VDD VDD _1684_ sky130_fd_sc_hd__a21oi_1
X_5439_ dp.rf.rf\[8\]\[3\] dp.rf.rf\[9\]\[3\] dp.rf.rf\[12\]\[3\]
+ dp.rf.rf\[13\]\[3\] net210 net208 VSS VSS VDD VDD _1685_ sky130_fd_sc_hd__mux4_1
X_5440_ net205 _1685_ VSS VSS VDD VDD _1686_ sky130_fd_sc_hd__nand2_1
X_5441_ _0231_ _1686_ VSS VSS VDD VDD _1687_ sky130_fd_sc_hd__nand2_1
X_5442_ _1682_ _1684_ _1687_ VSS VSS VDD VDD _1688_ sky130_fd_sc_hd__a21oi_1
X_5443_ _1662_ _1663_ _1673_ _1681_ _1688_ VSS VSS VDD VDD
+ _1689_ sky130_fd_sc_hd__o32a_4
XTAP_TAPCELL_ROW_6_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5445_ net32 _0042_ _1604_ net15 VSS VSS VDD VDD _3535_ sky130_fd_sc_hd__a22o_2
X_5446_ dp.rf.rf\[24\]\[2\] dp.rf.rf\[25\]\[2\] dp.rf.rf\[26\]\[2\]
+ dp.rf.rf\[27\]\[2\] net213 net277 VSS VSS VDD VDD _1690_ sky130_fd_sc_hd__mux4_1
X_5447_ dp.rf.rf\[16\]\[2\] dp.rf.rf\[17\]\[2\] dp.rf.rf\[18\]\[2\]
+ dp.rf.rf\[19\]\[2\] net213 net277 VSS VSS VDD VDD _1691_ sky130_fd_sc_hd__mux4_1
X_5448_ dp.rf.rf\[28\]\[2\] dp.rf.rf\[29\]\[2\] dp.rf.rf\[30\]\[2\]
+ dp.rf.rf\[31\]\[2\] net213 net277 VSS VSS VDD VDD _1692_ sky130_fd_sc_hd__mux4_2
X_5449_ dp.rf.rf\[20\]\[2\] dp.rf.rf\[21\]\[2\] dp.rf.rf\[22\]\[2\]
+ dp.rf.rf\[23\]\[2\] net213 net277 VSS VSS VDD VDD _1693_ sky130_fd_sc_hd__mux4_1
X_5450_ _1690_ _1691_ _1692_ _1693_ _0103_ net15 VSS VSS VDD
+ VDD _1694_ sky130_fd_sc_hd__mux4_2
X_5451_ dp.rf.rf\[8\]\[2\] dp.rf.rf\[9\]\[2\] dp.rf.rf\[10\]\[2\]
+ dp.rf.rf\[11\]\[2\] net13 net277 VSS VSS VDD VDD _1695_ sky130_fd_sc_hd__mux4_1
X_5452_ dp.rf.rf\[0\]\[2\] dp.rf.rf\[1\]\[2\] dp.rf.rf\[2\]\[2\]
+ dp.rf.rf\[3\]\[2\] net13 net277 VSS VSS VDD VDD _1696_ sky130_fd_sc_hd__mux4_1
X_5453_ dp.rf.rf\[12\]\[2\] dp.rf.rf\[13\]\[2\] dp.rf.rf\[14\]\[2\]
+ dp.rf.rf\[15\]\[2\] net13 net277 VSS VSS VDD VDD _1697_ sky130_fd_sc_hd__mux4_1
X_5454_ dp.rf.rf\[4\]\[2\] dp.rf.rf\[5\]\[2\] dp.rf.rf\[6\]\[2\]
+ dp.rf.rf\[7\]\[2\] net13 net277 VSS VSS VDD VDD _1698_ sky130_fd_sc_hd__mux4_1
X_5455_ _1695_ _1696_ _1697_ _1698_ _0103_ net15 VSS VSS VDD
+ VDD _1699_ sky130_fd_sc_hd__mux4_2
X_5456_ _1694_ net17 _1699_ net184 VSS VSS VDD VDD _1700_
+ sky130_fd_sc_hd__a22oi_4
X_5457_ _1700_ VSS VSS VDD VDD net155 sky130_fd_sc_hd__inv_1
X_5458_ _1700_ net178 VSS VSS VDD VDD _1701_ sky130_fd_sc_hd__nand2_4
X_5459_ net178 _3535_ _1701_ VSS VSS VDD VDD _1702_ sky130_fd_sc_hd__o21a_4
XTAP_TAPCELL_ROW_6_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5462_ _0122_ _1702_ VSS VSS VDD VDD _3516_ sky130_fd_sc_hd__xnor2_1
X_5463_ _3516_ VSS VSS VDD VDD _3520_ sky130_fd_sc_hd__inv_1
X_5464_ net208 dp.rf.rf\[17\]\[2\] VSS VSS VDD VDD _1705_
+ sky130_fd_sc_hd__nor2b_1
X_5465_ net434 net208 _1705_ _0245_ VSS VSS VDD VDD _1706_
+ sky130_fd_sc_hd__a211oi_2
X_5466_ net436 _0528_ _0955_ dp.rf.rf\[16\]\[2\] net205 VSS
+ VSS VDD VDD _1707_ sky130_fd_sc_hd__o221ai_2
X_5467_ dp.rf.rf\[19\]\[2\] net210 _0176_ dp.rf.rf\[18\]\[2\]
+ _0221_ VSS VSS VDD VDD _1708_ sky130_fd_sc_hd__a221oi_2
X_5468_ dp.rf.rf\[22\]\[2\] dp.rf.rf\[23\]\[2\] net210 VSS
+ VSS VDD VDD _1709_ sky130_fd_sc_hd__mux2_1
X_5469_ _0148_ _1709_ net8 VSS VSS VDD VDD _1710_ sky130_fd_sc_hd__o21ai_1
X_5470_ _1706_ _1707_ _1708_ _1710_ VSS VSS VDD VDD _1711_
+ sky130_fd_sc_hd__o22ai_4
X_5471_ net210 dp.rf.rf\[30\]\[2\] VSS VSS VDD VDD _1712_
+ sky130_fd_sc_hd__nor2b_1
X_5472_ dp.rf.rf\[31\]\[2\] net210 _0148_ _1712_ VSS VSS VDD
+ VDD _1713_ sky130_fd_sc_hd__a211oi_1
X_5473_ dp.rf.rf\[27\]\[2\] net210 _0176_ dp.rf.rf\[26\]\[2\]
+ _0221_ VSS VSS VDD VDD _1714_ sky130_fd_sc_hd__a221oi_1
X_5474_ _0212_ _0963_ _1713_ _1714_ VSS VSS VDD VDD _1715_
+ sky130_fd_sc_hd__nor4_1
X_5475_ net208 dp.rf.rf\[25\]\[2\] VSS VSS VDD VDD _1716_
+ sky130_fd_sc_hd__nor2b_1
X_5476_ dp.rf.rf\[29\]\[2\] net208 _1716_ _0245_ VSS VSS VDD
+ VDD _1717_ sky130_fd_sc_hd__a211oi_1
X_5477_ dp.rf.rf\[28\]\[2\] _0528_ _0955_ dp.rf.rf\[24\]\[2\]
+ VSS VSS VDD VDD _1718_ sky130_fd_sc_hd__o22ai_1
X_5478_ net8 _0963_ _1717_ _1718_ VSS VSS VDD VDD _1719_ sky130_fd_sc_hd__nor4_1
X_5479_ _0952_ _1711_ _1715_ _1719_ VSS VSS VDD VDD _1720_
+ sky130_fd_sc_hd__a211oi_4
X_5480_ dp.rf.rf\[10\]\[2\] dp.rf.rf\[11\]\[2\] dp.rf.rf\[14\]\[2\]
+ dp.rf.rf\[15\]\[2\] net210 net208 VSS VSS VDD VDD _1721_ sky130_fd_sc_hd__mux4_1
X_5481_ dp.rf.rf\[8\]\[2\] dp.rf.rf\[9\]\[2\] dp.rf.rf\[12\]\[2\]
+ dp.rf.rf\[13\]\[2\] net210 net208 VSS VSS VDD VDD _1722_ sky130_fd_sc_hd__mux4_1
X_5482_ _1721_ _1722_ net205 VSS VSS VDD VDD _1723_ sky130_fd_sc_hd__mux2i_2
X_5483_ dp.rf.rf\[6\]\[2\] dp.rf.rf\[7\]\[2\] net210 VSS VSS
+ VDD VDD _1724_ sky130_fd_sc_hd__mux2i_1
X_5484_ dp.rf.rf\[3\]\[2\] net210 _0176_ dp.rf.rf\[2\]\[2\]
+ net191 VSS VSS VDD VDD _1725_ sky130_fd_sc_hd__a221oi_1
X_5485_ net208 _1724_ _1725_ net192 VSS VSS VDD VDD _1726_
+ sky130_fd_sc_hd__a211o_1
X_5486_ dp.rf.rf\[1\]\[2\] dp.rf.rf\[5\]\[2\] net208 VSS VSS
+ VDD VDD _1727_ sky130_fd_sc_hd__mux2i_1
X_5487_ dp.rf.rf\[4\]\[2\] _0528_ VSS VSS VDD VDD _1728_ sky130_fd_sc_hd__nor2_1
X_5488_ net210 _1727_ _1728_ net8 VSS VSS VDD VDD _1729_ sky130_fd_sc_hd__a211oi_1
X_5489_ dp.rf.rf\[0\]\[2\] _0348_ _1729_ net197 VSS VSS VDD
+ VDD _1730_ sky130_fd_sc_hd__o22ai_1
X_5490_ net186 _1723_ _1726_ _1730_ _0271_ VSS VSS VDD VDD
+ _1731_ sky130_fd_sc_hd__a221o_4
X_5491_ _1720_ _1731_ VSS VSS VDD VDD _3515_ sky130_fd_sc_hd__nand2_4
X_5492_ _3515_ VSS VSS VDD VDD _3519_ sky130_fd_sc_hd__inv_1
X_5493_ net31 _0042_ _1604_ net277 VSS VSS VDD VDD _3272_
+ sky130_fd_sc_hd__a22o_1
X_5494_ net16 dp.rf.rf\[8\]\[1\] _0081_ dp.rf.rf\[0\]\[1\]
+ net15 VSS VSS VDD VDD _1732_ sky130_fd_sc_hd__a221oi_1
X_5495_ dp.rf.rf\[4\]\[1\] VSS VSS VDD VDD _1733_ sky130_fd_sc_hd__inv_1
X_5496_ net16 dp.rf.rf\[12\]\[1\] VSS VSS VDD VDD _1734_ sky130_fd_sc_hd__nand2_1
X_5497_ net16 _1733_ _1734_ net15 VSS VSS VDD VDD _1735_ sky130_fd_sc_hd__o211a_1
X_5498_ dp.rf.rf\[1\]\[1\] dp.rf.rf\[5\]\[1\] dp.rf.rf\[9\]\[1\]
+ dp.rf.rf\[13\]\[1\] net15 net16 VSS VSS VDD VDD _1736_ sky130_fd_sc_hd__mux4_1
X_5499_ net212 _1736_ VSS VSS VDD VDD _1737_ sky130_fd_sc_hd__nand2_1
X_5500_ net212 _1732_ _1735_ _1737_ VSS VSS VDD VDD _1738_
+ sky130_fd_sc_hd__o31a_1
X_5501_ dp.rf.rf\[18\]\[1\] dp.rf.rf\[19\]\[1\] net212 VSS
+ VSS VDD VDD _1739_ sky130_fd_sc_hd__mux2i_1
X_5502_ dp.rf.rf\[24\]\[1\] dp.rf.rf\[25\]\[1\] net212 VSS
+ VSS VDD VDD _1740_ sky130_fd_sc_hd__mux2i_1
X_5503_ _0081_ _1739_ _1740_ _0061_ VSS VSS VDD VDD _1741_
+ sky130_fd_sc_hd__a22oi_1
X_5504_ dp.rf.rf\[26\]\[1\] dp.rf.rf\[27\]\[1\] net212 VSS
+ VSS VDD VDD _1742_ sky130_fd_sc_hd__mux2i_1
X_5505_ dp.rf.rf\[16\]\[1\] dp.rf.rf\[17\]\[1\] net212 VSS
+ VSS VDD VDD _1743_ sky130_fd_sc_hd__mux2i_1
X_5506_ _0066_ _1742_ _1743_ _0054_ VSS VSS VDD VDD _1744_
+ sky130_fd_sc_hd__a22oi_1
X_5507_ _0088_ _1741_ _1744_ VSS VSS VDD VDD _1745_ sky130_fd_sc_hd__nand3_1
X_5508_ dp.rf.rf\[6\]\[1\] dp.rf.rf\[7\]\[1\] dp.rf.rf\[14\]\[1\]
+ dp.rf.rf\[15\]\[1\] net212 net16 VSS VSS VDD VDD _1746_ sky130_fd_sc_hd__mux4_1
X_5509_ dp.rf.rf\[2\]\[1\] dp.rf.rf\[3\]\[1\] dp.rf.rf\[10\]\[1\]
+ dp.rf.rf\[11\]\[1\] net212 net16 VSS VSS VDD VDD _1747_ sky130_fd_sc_hd__mux4_1
X_5510_ _1746_ _1747_ _0286_ VSS VSS VDD VDD _1748_ sky130_fd_sc_hd__mux2i_1
X_5511_ dp.rf.rf\[28\]\[1\] dp.rf.rf\[29\]\[1\] dp.rf.rf\[30\]\[1\]
+ dp.rf.rf\[31\]\[1\] net212 net274 VSS VSS VDD VDD _1749_ sky130_fd_sc_hd__mux4_1
X_5512_ dp.rf.rf\[20\]\[1\] dp.rf.rf\[21\]\[1\] dp.rf.rf\[22\]\[1\]
+ dp.rf.rf\[23\]\[1\] net212 net274 VSS VSS VDD VDD _1750_ sky130_fd_sc_hd__mux4_1
X_5513_ _1749_ _1750_ _0103_ VSS VSS VDD VDD _1751_ sky130_fd_sc_hd__mux2i_1
X_5514_ net17 _0057_ _1748_ _1751_ _0101_ VSS VSS VDD VDD
+ _1752_ sky130_fd_sc_hd__o32a_1
X_5515_ _1738_ net274 net17 _1745_ _1752_ VSS VSS VDD VDD
+ net144 sky130_fd_sc_hd__o311ai_4
X_5516_ net31 _0042_ _1604_ net277 net178 VSS VSS VDD VDD
+ _1753_ sky130_fd_sc_hd__a221o_2
X_5517_ net409 _0138_ _1753_ VSS VSS VDD VDD _1754_ sky130_fd_sc_hd__o21a_4
XTAP_TAPCELL_ROW_6_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5522_ _0122_ _1754_ VSS VSS VDD VDD _3267_ sky130_fd_sc_hd__xnor2_2
X_5523_ _3267_ VSS VSS VDD VDD _3526_ sky130_fd_sc_hd__inv_1
X_5524_ dp.rf.rf\[24\]\[1\] dp.rf.rf\[28\]\[1\] net206 VSS
+ VSS VDD VDD _1759_ sky130_fd_sc_hd__mux2i_1
X_5525_ dp.rf.rf\[25\]\[1\] dp.rf.rf\[29\]\[1\] net206 VSS
+ VSS VDD VDD _1760_ sky130_fd_sc_hd__mux2i_1
X_5526_ _0170_ _1759_ _1760_ _0415_ VSS VSS VDD VDD _1761_
+ sky130_fd_sc_hd__o22ai_1
X_5527_ net198 _1761_ net187 VSS VSS VDD VDD _1762_ sky130_fd_sc_hd__o21ai_2
X_5528_ dp.rf.rf\[26\]\[1\] net1 net12 net23 VSS VSS VDD VDD
+ _1763_ sky130_fd_sc_hd__nand4_1
X_5529_ dp.rf.rf\[26\]\[1\] _0245_ _0129_ _1763_ VSS VSS VDD
+ VDD _1764_ sky130_fd_sc_hd__o2bb2ai_1
X_5530_ dp.rf.rf\[27\]\[1\] net209 VSS VSS VDD VDD _1765_
+ sky130_fd_sc_hd__and2_0
X_5531_ dp.rf.rf\[30\]\[1\] dp.rf.rf\[31\]\[1\] net209 VSS
+ VSS VDD VDD _1766_ sky130_fd_sc_hd__mux2i_1
X_5532_ net206 _1766_ _0231_ VSS VSS VDD VDD _1767_ sky130_fd_sc_hd__a21oi_1
X_5533_ _0221_ _1764_ _1765_ _1767_ net182 VSS VSS VDD VDD
+ _1768_ sky130_fd_sc_hd__o311ai_4
X_5534_ dp.rf.rf\[18\]\[1\] net1 net12 net23 VSS VSS VDD VDD
+ _1769_ sky130_fd_sc_hd__nand4_1
X_5535_ dp.rf.rf\[18\]\[1\] _0245_ _0129_ _1769_ VSS VSS VDD
+ VDD _1770_ sky130_fd_sc_hd__o2bb2ai_1
X_5536_ dp.rf.rf\[19\]\[1\] net209 VSS VSS VDD VDD _1771_
+ sky130_fd_sc_hd__and2_0
X_5537_ dp.rf.rf\[22\]\[1\] dp.rf.rf\[23\]\[1\] net209 VSS
+ VSS VDD VDD _1772_ sky130_fd_sc_hd__mux2i_1
X_5538_ net206 _1772_ VSS VSS VDD VDD _1773_ sky130_fd_sc_hd__nand2_1
X_5539_ _0221_ _1770_ _1771_ _1773_ net182 VSS VSS VDD VDD
+ _1774_ sky130_fd_sc_hd__o311ai_2
X_5540_ dp.rf.rf\[20\]\[1\] VSS VSS VDD VDD _1775_ sky130_fd_sc_hd__inv_1
X_5541_ dp.rf.rf\[17\]\[1\] dp.rf.rf\[21\]\[1\] net206 VSS
+ VSS VDD VDD _1776_ sky130_fd_sc_hd__mux2i_1
X_5542_ _1775_ net203 _1776_ net209 net8 VSS VSS VDD VDD _1777_
+ sky130_fd_sc_hd__a221oi_1
X_5543_ dp.rf.rf\[16\]\[1\] net181 _1777_ net196 VSS VSS VDD
+ VDD _1778_ sky130_fd_sc_hd__o22ai_2
X_5544_ _1762_ _1768_ _1774_ _1778_ VSS VSS VDD VDD _1779_
+ sky130_fd_sc_hd__a22oi_4
X_5545_ dp.rf.rf\[10\]\[1\] net1 net12 net23 VSS VSS VDD VDD
+ _1780_ sky130_fd_sc_hd__nand4_1
X_5546_ dp.rf.rf\[10\]\[1\] _0245_ _0129_ _1780_ VSS VSS VDD
+ VDD _1781_ sky130_fd_sc_hd__o2bb2ai_1
X_5547_ dp.rf.rf\[11\]\[1\] net209 VSS VSS VDD VDD _1782_
+ sky130_fd_sc_hd__and2_0
X_5548_ dp.rf.rf\[14\]\[1\] dp.rf.rf\[15\]\[1\] net209 VSS
+ VSS VDD VDD _1783_ sky130_fd_sc_hd__mux2i_1
X_5549_ net206 _1783_ VSS VSS VDD VDD _1784_ sky130_fd_sc_hd__nand2_1
X_5550_ _0221_ _1781_ _1782_ _1784_ net182 VSS VSS VDD VDD
+ _1785_ sky130_fd_sc_hd__o311ai_4
X_5551_ dp.rf.rf\[8\]\[1\] dp.rf.rf\[9\]\[1\] dp.rf.rf\[12\]\[1\]
+ dp.rf.rf\[13\]\[1\] net209 net206 VSS VSS VDD VDD _1786_ sky130_fd_sc_hd__mux4_1
X_5552_ net205 _1786_ net199 VSS VSS VDD VDD _1787_ sky130_fd_sc_hd__a21oi_1
X_5553_ dp.rf.rf\[2\]\[1\] dp.rf.rf\[3\]\[1\] dp.rf.rf\[6\]\[1\]
+ dp.rf.rf\[7\]\[1\] net209 net206 VSS VSS VDD VDD _1788_ sky130_fd_sc_hd__mux4_1
X_5554_ dp.rf.rf\[1\]\[1\] dp.rf.rf\[5\]\[1\] net206 VSS VSS
+ VDD VDD _1789_ sky130_fd_sc_hd__mux2i_1
X_5555_ _1733_ net203 _1789_ net209 net8 VSS VSS VDD VDD _1790_
+ sky130_fd_sc_hd__a221oi_1
X_5556_ net8 _1788_ _1790_ net196 VSS VSS VDD VDD _1791_ sky130_fd_sc_hd__a211oi_2
X_5557_ _1785_ _1787_ _1791_ _0271_ VSS VSS VDD VDD _1792_
+ sky130_fd_sc_hd__a211oi_4
X_5558_ _1779_ _1792_ VSS VSS VDD VDD _3525_ sky130_fd_sc_hd__nor2_4
X_5559_ net497 VSS VSS VDD VDD _3275_ sky130_fd_sc_hd__inv_1
X_5560_ net27 _0111_ _0108_ VSS VSS VDD VDD _1793_ sky130_fd_sc_hd__a21oi_4
X_5561_ _0121_ _1793_ VSS VSS VDD VDD _1794_ sky130_fd_sc_hd__nor2_2
X_5562_ net4 net5 _1794_ net6 VSS VSS VDD VDD _1795_ sky130_fd_sc_hd__nand4b_4
XTAP_TAPCELL_ROW_6_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5564_ net27 _0108_ VSS VSS VDD VDD _1797_ sky130_fd_sc_hd__or2_2
X_5565_ net5 _1797_ VSS VSS VDD VDD _1798_ sky130_fd_sc_hd__nand2_2
X_5566_ net6 net4 VSS VSS VDD VDD _1799_ sky130_fd_sc_hd__nor2_1
X_5567_ net6 net4 _1793_ VSS VSS VDD VDD _1800_ sky130_fd_sc_hd__a21oi_1
X_5568_ net6 net4 VSS VSS VDD VDD _1801_ sky130_fd_sc_hd__nand2_2
X_5569_ _1797_ _1801_ net5 VSS VSS VDD VDD _1802_ sky130_fd_sc_hd__a21oi_1
X_5570_ _1798_ _1799_ _0121_ _1800_ _1802_ VSS VSS VDD VDD
+ _1803_ sky130_fd_sc_hd__a2111oi_4
XTAP_TAPCELL_ROW_6_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5572_ net27 _0108_ VSS VSS VDD VDD _1805_ sky130_fd_sc_hd__nor2_8
X_5573_ net5 net4 VSS VSS VDD VDD _1806_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_5_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5575_ net6 net24 VSS VSS VDD VDD _1808_ sky130_fd_sc_hd__nor2b_1
X_5576_ _0130_ _1805_ _1806_ _1808_ VSS VSS VDD VDD _1809_
+ sky130_fd_sc_hd__nor4_4
XTAP_TAPCELL_ROW_5_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5578_ _3277_ net174 net176 VSS VSS VDD VDD _1811_ sky130_fd_sc_hd__a21oi_1
X_5579_ _3281_ _1795_ _1811_ VSS VSS VDD VDD _1812_ sky130_fd_sc_hd__o21ai_0
X_5580_ net6 VSS VSS VDD VDD _1813_ sky130_fd_sc_hd__inv_2
X_5581_ _1813_ _1797_ _1793_ VSS VSS VDD VDD _1814_ sky130_fd_sc_hd__and3_1
X_5582_ net5 _1814_ net4 VSS VSS VDD VDD _1815_ sky130_fd_sc_hd__o21ai_2
X_5583_ net4 _1805_ VSS VSS VDD VDD _1816_ sky130_fd_sc_hd__nor2_1
X_5584_ net5 _1816_ net6 VSS VSS VDD VDD _1817_ sky130_fd_sc_hd__o21ai_2
X_5585_ _1798_ _1815_ _1817_ _0121_ VSS VSS VDD VDD _1818_
+ sky130_fd_sc_hd__a31o_4
XTAP_TAPCELL_ROW_5_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5587_ net6 _0109_ _1794_ VSS VSS VDD VDD _1820_ sky130_fd_sc_hd__and3_4
XTAP_TAPCELL_ROW_5_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5590_ _0122_ _1818_ _1820_ VSS VSS VDD VDD _1823_ sky130_fd_sc_hd__a21oi_1
X_5591_ _1798_ _1815_ _1817_ _0121_ VSS VSS VDD VDD _1824_
+ sky130_fd_sc_hd__a31oi_4
XTAP_TAPCELL_ROW_5_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5593_ _0122_ _1824_ VSS VSS VDD VDD _1826_ sky130_fd_sc_hd__nor2_1
X_5594_ _3278_ _1826_ VSS VSS VDD VDD _1827_ sky130_fd_sc_hd__nor2_1
X_5595_ _3278_ _1823_ _1827_ VSS VSS VDD VDD _1828_ sky130_fd_sc_hd__a21oi_1
X_5596_ net6 net5 VSS VSS VDD VDD _1829_ sky130_fd_sc_hd__nor2b_1
X_5597_ net4 _1829_ VSS VSS VDD VDD _1830_ sky130_fd_sc_hd__nand2_1
X_5598_ _0274_ _0300_ VSS VSS VDD VDD _1831_ sky130_fd_sc_hd__xor2_1
X_5599_ _1793_ _1830_ _1831_ VSS VSS VDD VDD _1832_ sky130_fd_sc_hd__o21ai_0
X_5600_ _0122_ _1832_ VSS VSS VDD VDD _1833_ sky130_fd_sc_hd__xnor2_1
X_5601_ _3286_ _3285_ _1833_ VSS VSS VDD VDD _1834_ sky130_fd_sc_hd__or3_1
X_5602_ _3285_ _1833_ VSS VSS VDD VDD _1835_ sky130_fd_sc_hd__nand2_1
X_5603_ _1794_ _1829_ VSS VSS VDD VDD _1836_ sky130_fd_sc_hd__nand2_1
X_5604_ _1834_ _1835_ _1836_ VSS VSS VDD VDD _1837_ sky130_fd_sc_hd__a21oi_1
X_5605_ _1812_ _1828_ _1837_ VSS VSS VDD VDD _1838_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_5_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5607_ _3357_ _3373_ _3365_ VSS VSS VDD VDD _1840_ sky130_fd_sc_hd__nor3_1
X_5608_ _3494_ _3493_ _3486_ VSS VSS VDD VDD _1841_ sky130_fd_sc_hd__o21a_1
X_5609_ _3485_ _1841_ VSS VSS VDD VDD _1842_ sky130_fd_sc_hd__nor2_1
X_5610_ _3518_ _3268_ _3517_ VSS VSS VDD VDD _1843_ sky130_fd_sc_hd__a21o_1
X_5611_ _1843_ _3510_ _3509_ VSS VSS VDD VDD _1844_ sky130_fd_sc_hd__a21o_1
X_5612_ _3502_ _1844_ _3493_ _3485_ _3501_ VSS VSS VDD VDD
+ _1845_ sky130_fd_sc_hd__a2111oi_4
X_5613_ _3438_ _3446_ _3454_ _3462_ VSS VSS VDD VDD _1846_
+ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_5_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5615_ _3470_ _3478_ VSS VSS VDD VDD _1848_ sky130_fd_sc_hd__nand2_1
X_5616_ _1842_ _1845_ _1846_ _1848_ VSS VSS VDD VDD _1849_
+ sky130_fd_sc_hd__nor4_4
X_5617_ _3470_ _3477_ _3469_ VSS VSS VDD VDD _1850_ sky130_fd_sc_hd__a21o_1
X_5618_ _3462_ _1850_ _3461_ VSS VSS VDD VDD _1851_ sky130_fd_sc_hd__a21o_1
X_5619_ _3454_ _1851_ _3445_ _3437_ _3453_ VSS VSS VDD VDD
+ _1852_ sky130_fd_sc_hd__a2111oi_1
X_5620_ _3437_ _3446_ _3445_ VSS VSS VDD VDD _1853_ sky130_fd_sc_hd__or3_1
X_5621_ _3437_ _3438_ _1853_ VSS VSS VDD VDD _1854_ sky130_fd_sc_hd__o21ai_1
X_5622_ _3421_ _3429_ VSS VSS VDD VDD _1855_ sky130_fd_sc_hd__nor2_1
X_5623_ _1852_ _1854_ _1855_ VSS VSS VDD VDD _1856_ sky130_fd_sc_hd__o21ai_1
X_5624_ _3397_ VSS VSS VDD VDD _1857_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_5_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5626_ _3405_ _3406_ _3398_ VSS VSS VDD VDD _1859_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_5_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5628_ _3390_ _3382_ VSS VSS VDD VDD _1861_ sky130_fd_sc_hd__nand2_1
X_5629_ _1857_ _1859_ _1861_ VSS VSS VDD VDD _1862_ sky130_fd_sc_hd__a21oi_1
X_5630_ _3430_ _3429_ _3422_ VSS VSS VDD VDD _1863_ sky130_fd_sc_hd__o21ai_0
X_5631_ _3421_ _1863_ VSS VSS VDD VDD _1864_ sky130_fd_sc_hd__nand2b_1
X_5632_ _3414_ _1862_ _1864_ VSS VSS VDD VDD _1865_ sky130_fd_sc_hd__and3_1
X_5633_ _1849_ _1856_ _1865_ VSS VSS VDD VDD _1866_ sky130_fd_sc_hd__o21ai_2
X_5634_ _3382_ VSS VSS VDD VDD _1867_ sky130_fd_sc_hd__inv_1
X_5635_ _3405_ _3398_ VSS VSS VDD VDD _1868_ sky130_fd_sc_hd__nand2_1
X_5636_ _1857_ _1868_ VSS VSS VDD VDD _1869_ sky130_fd_sc_hd__nand2_1
X_5637_ _3390_ _1869_ _3389_ VSS VSS VDD VDD _1870_ sky130_fd_sc_hd__a21oi_1
X_5638_ _1867_ _1870_ VSS VSS VDD VDD _1871_ sky130_fd_sc_hd__nor2_1
X_5639_ _3413_ _1862_ _1871_ _3381_ VSS VSS VDD VDD _1872_
+ sky130_fd_sc_hd__a211oi_1
X_5640_ _1840_ _1866_ _1872_ VSS VSS VDD VDD _1873_ sky130_fd_sc_hd__nand3_2
X_5641_ _3374_ VSS VSS VDD VDD _1874_ sky130_fd_sc_hd__inv_1
X_5642_ _3366_ _3365_ _3358_ VSS VSS VDD VDD _1875_ sky130_fd_sc_hd__o21a_1
X_5643_ _3357_ _1875_ _3350_ VSS VSS VDD VDD _1876_ sky130_fd_sc_hd__o21ai_0
X_5644_ _1874_ _1840_ _1876_ VSS VSS VDD VDD _1877_ sky130_fd_sc_hd__a21oi_1
X_5645_ _1873_ _1877_ _3341_ _3333_ _3349_ VSS VSS VDD VDD
+ _1878_ sky130_fd_sc_hd__a2111oi_4
X_5646_ _3341_ _3342_ VSS VSS VDD VDD _1879_ sky130_fd_sc_hd__or2_0
X_5647_ _3334_ _1879_ _3333_ VSS VSS VDD VDD _1880_ sky130_fd_sc_hd__a21oi_1
X_5648_ _3318_ _3326_ VSS VSS VDD VDD _1881_ sky130_fd_sc_hd__nand2_1
X_5649_ _3318_ _3325_ _3317_ VSS VSS VDD VDD _1882_ sky130_fd_sc_hd__a21oi_1
X_5650_ _1878_ _1880_ _1881_ _1882_ VSS VSS VDD VDD _1883_
+ sky130_fd_sc_hd__o31ai_2
X_5651_ _3302_ _3310_ VSS VSS VDD VDD _1884_ sky130_fd_sc_hd__and2_0
X_5652_ _3302_ _3309_ _1883_ _1884_ _3301_ VSS VSS VDD VDD
+ _1885_ sky130_fd_sc_hd__a221o_1
X_5653_ _3294_ _1885_ _3293_ VSS VSS VDD VDD _1886_ sky130_fd_sc_hd__a21oi_2
X_5654_ _1836_ _1886_ _1833_ _3286_ VSS VSS VDD VDD _1887_
+ sky130_fd_sc_hd__or4bb_1
X_5655_ _3285_ _1836_ _1833_ VSS VSS VDD VDD _1888_ sky130_fd_sc_hd__nor3_1
X_5656_ _1886_ _1888_ VSS VSS VDD VDD _1889_ sky130_fd_sc_hd__nand2_2
X_5657_ _3539_ net158 net178 VSS VSS VDD VDD _1890_ sky130_fd_sc_hd__mux2i_4
XTAP_TAPCELL_ROW_5_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5660_ net179 _3530_ _0099_ net606 VSS VSS VDD VDD _1893_
+ sky130_fd_sc_hd__o22ai_4
XTAP_TAPCELL_ROW_5_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5663_ _3495_ VSS VSS VDD VDD _3491_ sky130_fd_sc_hd__inv_1
X_5664_ net409 _0138_ _1753_ VSS VSS VDD VDD _1896_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_4_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5668_ _3479_ net407 VSS VSS VDD VDD _1900_ sky130_fd_sc_hd__nor2_1
X_5669_ _3491_ net708 _1900_ VSS VSS VDD VDD _1901_ sky130_fd_sc_hd__a21oi_1
X_5670_ net515 VSS VSS VDD VDD _3483_ sky130_fd_sc_hd__inv_1
X_5671_ _3503_ net709 VSS VSS VDD VDD _1902_ sky130_fd_sc_hd__nand2_1
X_5672_ _3483_ net407 _1902_ net276 VSS VSS VDD VDD _1903_
+ sky130_fd_sc_hd__o211ai_1
X_5673_ net257 _1901_ _1903_ VSS VSS VDD VDD _1904_ sky130_fd_sc_hd__o21ai_1
X_5674_ _1689_ VSS VSS VDD VDD _3507_ sky130_fd_sc_hd__inv_1
X_5675_ net265 _3525_ VSS VSS VDD VDD _1905_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_4_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5678_ _3507_ net265 _1905_ net276 VSS VSS VDD VDD _1908_
+ sky130_fd_sc_hd__a211oi_1
X_5679_ net497 net265 VSS VSS VDD VDD _1909_ sky130_fd_sc_hd__nor2_1
X_5680_ _3515_ net265 _1909_ _0140_ VSS VSS VDD VDD _1910_
+ sky130_fd_sc_hd__a211oi_1
X_5681_ _1702_ _1908_ _1910_ VSS VSS VDD VDD _1911_ sky130_fd_sc_hd__nor3_1
X_5682_ net267 _1904_ _1911_ VSS VSS VDD VDD _1912_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_4_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5685_ _3423_ _3439_ net708 VSS VSS VDD VDD _1915_ sky130_fd_sc_hd__mux2i_2
X_5686_ _3415_ _3431_ net708 VSS VSS VDD VDD _1916_ sky130_fd_sc_hd__mux2i_2
X_5687_ _1915_ _1916_ _0140_ VSS VSS VDD VDD _1917_ sky130_fd_sc_hd__mux2i_1
X_5688_ _3447_ net855 net708 VSS VSS VDD VDD _1918_ sky130_fd_sc_hd__mux2i_2
X_5689_ _3455_ _3471_ net708 VSS VSS VDD VDD _1919_ sky130_fd_sc_hd__mux2i_2
X_5690_ _1918_ _1919_ net257 VSS VSS VDD VDD _1920_ sky130_fd_sc_hd__mux2i_2
X_5691_ net178 _3535_ net432 VSS VSS VDD VDD _1921_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_4_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5694_ _1917_ _1920_ _1921_ VSS VSS VDD VDD _1924_ sky130_fd_sc_hd__mux2i_1
X_5695_ net171 _1924_ VSS VSS VDD VDD _1925_ sky130_fd_sc_hd__nor2_1
X_5696_ _1890_ _1912_ _1925_ net266 VSS VSS VDD VDD _1926_
+ sky130_fd_sc_hd__a211oi_1
X_5697_ _1605_ net429 net178 VSS VSS VDD VDD _1927_ sky130_fd_sc_hd__mux2_8
XTAP_TAPCELL_ROW_4_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5700_ _0371_ _3311_ net167 VSS VSS VDD VDD _1930_ sky130_fd_sc_hd__mux2i_4
X_5701_ _0274_ _3303_ net167 VSS VSS VDD VDD _1931_ sky130_fd_sc_hd__mux2i_4
X_5702_ _1930_ _1931_ _0140_ VSS VSS VDD VDD _1932_ sky130_fd_sc_hd__mux2_1
X_5703_ _0621_ _3343_ net167 VSS VSS VDD VDD _1933_ sky130_fd_sc_hd__mux2i_2
X_5704_ _3319_ _3335_ net167 VSS VSS VDD VDD _1934_ sky130_fd_sc_hd__mux2i_2
X_5705_ _1933_ _1934_ _0140_ VSS VSS VDD VDD _1935_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_4_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5707_ _1932_ _1935_ net165 VSS VSS VDD VDD _1937_ sky130_fd_sc_hd__mux2_1
X_5708_ _3359_ _3375_ net167 VSS VSS VDD VDD _1938_ sky130_fd_sc_hd__mux2i_4
X_5709_ _3351_ _3367_ net167 VSS VSS VDD VDD _1939_ sky130_fd_sc_hd__mux2i_2
XTAP_TAPCELL_ROW_3_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5711_ _1938_ _1939_ _0140_ VSS VSS VDD VDD _1941_ sky130_fd_sc_hd__mux2i_1
X_5712_ _1031_ _3407_ net167 VSS VSS VDD VDD _1942_ sky130_fd_sc_hd__mux2i_2
X_5713_ _3383_ _3399_ net167 VSS VSS VDD VDD _1943_ sky130_fd_sc_hd__mux2i_1
X_5714_ _1942_ _1943_ _0140_ VSS VSS VDD VDD _1944_ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_3_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5716_ _1941_ _1944_ net165 VSS VSS VDD VDD _1946_ sky130_fd_sc_hd__mux2i_1
X_5717_ _1937_ _1946_ _1890_ VSS VSS VDD VDD _1947_ sky130_fd_sc_hd__mux2i_1
X_5718_ _1927_ _1947_ VSS VSS VDD VDD _1948_ sky130_fd_sc_hd__nor2_1
X_5719_ net5 _1805_ _1801_ VSS VSS VDD VDD _1949_ sky130_fd_sc_hd__nor3_4
XTAP_TAPCELL_ROW_3_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5722_ _1926_ _1948_ _1949_ VSS VSS VDD VDD _1952_ sky130_fd_sc_hd__o21ai_2
X_5723_ _0140_ net497 net265 VSS VSS VDD VDD _1953_ sky130_fd_sc_hd__nor3_2
X_5724_ _1652_ net421 VSS VSS VDD VDD _1954_ sky130_fd_sc_hd__nor2_4
X_5725_ net438 _1949_ VSS VSS VDD VDD _1955_ sky130_fd_sc_hd__nor2_8
X_5726_ _0130_ _1805_ _1806_ _1808_ VSS VSS VDD VDD _1956_
+ sky130_fd_sc_hd__or4_4
XTAP_TAPCELL_ROW_3_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5729_ _1953_ _1954_ _1955_ _1956_ VSS VSS VDD VDD _1959_
+ sky130_fd_sc_hd__a31oi_4
X_5730_ _1838_ _1887_ _1889_ _1952_ _1959_ VSS VSS VDD VDD
+ net66 sky130_fd_sc_hd__a32oi_4
X_5731_ net27 net28 _0108_ VSS VSS VDD VDD _1960_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_3_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5733_ _1960_ VSS VSS VDD VDD net98 sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_3_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5736_ _3525_ VSS VSS VDD VDD _3266_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_3_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5739_ _3311_ _0621_ net167 VSS VSS VDD VDD _1966_ sky130_fd_sc_hd__mux2i_2
X_5740_ _1934_ _1966_ _0140_ VSS VSS VDD VDD _1967_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_3_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5742_ net253 _0371_ net265 VSS VSS VDD VDD _1969_ sky130_fd_sc_hd__nor3_1
X_5743_ net255 _1931_ _1969_ VSS VSS VDD VDD _1970_ sky130_fd_sc_hd__a21o_2
X_5744_ _1967_ _1970_ net425 VSS VSS VDD VDD _1971_ sky130_fd_sc_hd__mux2_1
X_5745_ _1971_ VSS VSS VDD VDD _1972_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_3_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5747_ _0371_ _3303_ net252 VSS VSS VDD VDD _1974_ sky130_fd_sc_hd__mux2i_2
X_5748_ _0274_ net167 VSS VSS VDD VDD _1975_ sky130_fd_sc_hd__nor2_1
X_5749_ net167 _1974_ _1975_ VSS VSS VDD VDD _1976_ sky130_fd_sc_hd__a21o_2
X_5750_ _1967_ _1976_ net423 VSS VSS VDD VDD _1977_ sky130_fd_sc_hd__mux2i_4
X_5751_ _1972_ _1977_ net24 VSS VSS VDD VDD _1978_ sky130_fd_sc_hd__mux2i_2
X_5752_ _0140_ _1939_ VSS VSS VDD VDD _1979_ sky130_fd_sc_hd__nor2_1
X_5753_ _3343_ _3359_ net167 VSS VSS VDD VDD _1980_ sky130_fd_sc_hd__mux2i_2
X_5754_ net261 _1980_ VSS VSS VDD VDD _1981_ sky130_fd_sc_hd__nor2_1
X_5755_ _1979_ _1981_ VSS VSS VDD VDD _1982_ sky130_fd_sc_hd__nor2_2
X_5756_ _3375_ _1031_ net167 VSS VSS VDD VDD _1983_ sky130_fd_sc_hd__mux2i_1
X_5757_ _0140_ _1983_ VSS VSS VDD VDD _1984_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_2_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5759_ net169 _1943_ VSS VSS VDD VDD _1986_ sky130_fd_sc_hd__nand2_1
X_5760_ _1984_ _1986_ VSS VSS VDD VDD _1987_ sky130_fd_sc_hd__nand2_2
X_5761_ _1982_ _1987_ net166 VSS VSS VDD VDD _1988_ sky130_fd_sc_hd__mux2i_2
X_5762_ net171 _1988_ VSS VSS VDD VDD _1989_ sky130_fd_sc_hd__nand2_1
X_5763_ net5 _1805_ _1801_ VSS VSS VDD VDD _1990_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_2_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5766_ _1927_ _1990_ VSS VSS VDD VDD _1993_ sky130_fd_sc_hd__nor2_2
X_5767_ net171 _1978_ _1989_ _1993_ VSS VSS VDD VDD _1994_
+ sky130_fd_sc_hd__o211ai_2
X_5768_ net437 _1990_ VSS VSS VDD VDD _1995_ sky130_fd_sc_hd__nor2_2
X_5769_ _3407_ _3423_ net707 VSS VSS VDD VDD _1996_ sky130_fd_sc_hd__mux2i_2
X_5770_ _0140_ _1996_ VSS VSS VDD VDD _1997_ sky130_fd_sc_hd__nand2_1
X_5771_ net257 _1916_ VSS VSS VDD VDD _1998_ sky130_fd_sc_hd__nand2_1
X_5772_ _1997_ _1998_ VSS VSS VDD VDD _1999_ sky130_fd_sc_hd__nand2_1
X_5773_ _0140_ _1918_ VSS VSS VDD VDD _2000_ sky130_fd_sc_hd__nor2_1
X_5774_ _3439_ _3455_ net708 VSS VSS VDD VDD _2001_ sky130_fd_sc_hd__mux2i_1
X_5775_ net257 _2001_ VSS VSS VDD VDD _2002_ sky130_fd_sc_hd__nor2_1
X_5776_ _2000_ _2002_ VSS VSS VDD VDD _2003_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_2_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5778_ _1999_ _2003_ net932 VSS VSS VDD VDD _2005_ sky130_fd_sc_hd__mux2i_2
XTAP_TAPCELL_ROW_2_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5781_ _3471_ net517 net407 VSS VSS VDD VDD _2008_ sky130_fd_sc_hd__mux2i_1
X_5782_ _0140_ _2008_ VSS VSS VDD VDD _2009_ sky130_fd_sc_hd__nand2_1
X_5783_ _0140_ _1901_ _2009_ VSS VSS VDD VDD _2010_ sky130_fd_sc_hd__o21ai_1
X_5784_ _3503_ _1689_ net257 VSS VSS VDD VDD _2011_ sky130_fd_sc_hd__mux2i_1
X_5785_ net265 _2011_ VSS VSS VDD VDD _2012_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_2_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5787_ net257 _3525_ VSS VSS VDD VDD _2014_ sky130_fd_sc_hd__nand2_1
X_5788_ net257 _3515_ net407 _2014_ VSS VSS VDD VDD _2015_
+ sky130_fd_sc_hd__o211ai_1
X_5789_ net932 _2012_ _2015_ VSS VSS VDD VDD _2016_ sky130_fd_sc_hd__nand3_1
X_5790_ net932 _2010_ _2016_ net171 VSS VSS VDD VDD _2017_
+ sky130_fd_sc_hd__o211ai_1
X_5791_ net171 _2005_ _2017_ VSS VSS VDD VDD _2018_ sky130_fd_sc_hd__o21ai_0
X_5792_ _1954_ _1955_ VSS VSS VDD VDD _2019_ sky130_fd_sc_hd__nand2_1
X_5793_ _0140_ net497 VSS VSS VDD VDD _2020_ sky130_fd_sc_hd__nand2_1
X_5794_ net709 _2014_ _2020_ VSS VSS VDD VDD _2021_ sky130_fd_sc_hd__nand3_2
X_5795_ _2019_ _2021_ net177 VSS VSS VDD VDD _2022_ sky130_fd_sc_hd__o21ai_0
X_5796_ _1995_ _2018_ _2022_ VSS VSS VDD VDD _2023_ sky130_fd_sc_hd__a21oi_1
X_5797_ _3269_ _1824_ VSS VSS VDD VDD _2024_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_2_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5799_ _3524_ _1820_ VSS VSS VDD VDD _2026_ sky130_fd_sc_hd__nand2_1
X_5800_ _3527_ _1795_ _2026_ VSS VSS VDD VDD _2027_ sky130_fd_sc_hd__o21ai_0
X_5801_ _3523_ net172 _2024_ _2027_ net177 VSS VSS VDD VDD
+ _2028_ sky130_fd_sc_hd__a2111oi_1
X_5802_ _1994_ _2023_ _2028_ VSS VSS VDD VDD net77 sky130_fd_sc_hd__a21oi_2
X_5803_ _3399_ _3415_ net707 VSS VSS VDD VDD _2029_ sky130_fd_sc_hd__mux2i_4
X_5804_ _1996_ _2029_ _0140_ VSS VSS VDD VDD _2030_ sky130_fd_sc_hd__mux2i_2
X_5805_ _3431_ _3447_ net708 VSS VSS VDD VDD _2031_ sky130_fd_sc_hd__mux2i_2
X_5806_ _2001_ _2031_ _0140_ VSS VSS VDD VDD _2032_ sky130_fd_sc_hd__mux2i_1
X_5807_ _2030_ _2032_ _1921_ VSS VSS VDD VDD _2033_ sky130_fd_sc_hd__mux2i_1
X_5808_ net856 _3479_ net407 VSS VSS VDD VDD _2034_ sky130_fd_sc_hd__mux2i_2
X_5809_ _2008_ _2034_ _0140_ VSS VSS VDD VDD _2035_ sky130_fd_sc_hd__mux2i_1
X_5810_ _1689_ net407 VSS VSS VDD VDD _2036_ sky130_fd_sc_hd__nand2_1
X_5811_ _3491_ net407 _2036_ VSS VSS VDD VDD _2037_ sky130_fd_sc_hd__o21ai_0
X_5812_ _1720_ _1731_ net466 VSS VSS VDD VDD _2038_ sky130_fd_sc_hd__a21oi_4
X_5813_ _3499_ net265 _2038_ _0140_ VSS VSS VDD VDD _2039_
+ sky130_fd_sc_hd__a211oi_1
X_5814_ _0140_ _2037_ _2039_ VSS VSS VDD VDD _2040_ sky130_fd_sc_hd__a21oi_1
X_5815_ net932 _2040_ VSS VSS VDD VDD _2041_ sky130_fd_sc_hd__nand2_1
X_5816_ net932 _2035_ _2041_ net171 VSS VSS VDD VDD _2042_
+ sky130_fd_sc_hd__o211ai_1
X_5817_ net171 _2033_ _2042_ VSS VSS VDD VDD _2043_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_2_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5819_ _3335_ _3351_ net167 VSS VSS VDD VDD _2045_ sky130_fd_sc_hd__mux2i_4
X_5820_ _1980_ _2045_ _0140_ VSS VSS VDD VDD _2046_ sky130_fd_sc_hd__mux2i_4
XTAP_TAPCELL_ROW_2_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5822_ _3367_ _3383_ net167 VSS VSS VDD VDD _2048_ sky130_fd_sc_hd__mux2i_2
X_5823_ _1983_ _2048_ _0140_ VSS VSS VDD VDD _2049_ sky130_fd_sc_hd__mux2_1
X_5824_ net165 _2049_ VSS VSS VDD VDD _2050_ sky130_fd_sc_hd__nand2_1
X_5825_ net165 _2046_ _2050_ VSS VSS VDD VDD _2051_ sky130_fd_sc_hd__o21ai_2
X_5826_ _3303_ _3319_ net167 VSS VSS VDD VDD _2052_ sky130_fd_sc_hd__mux2i_4
X_5827_ _1966_ _2052_ _0140_ VSS VSS VDD VDD _2053_ sky130_fd_sc_hd__mux2i_4
X_5828_ _0274_ _0371_ net253 VSS VSS VDD VDD _2054_ sky130_fd_sc_hd__mux2i_1
X_5829_ net167 _2054_ net165 VSS VSS VDD VDD _2055_ sky130_fd_sc_hd__a21oi_1
X_5830_ net165 _2053_ _2055_ VSS VSS VDD VDD _2056_ sky130_fd_sc_hd__a21oi_4
X_5831_ net167 _2054_ VSS VSS VDD VDD _2057_ sky130_fd_sc_hd__nand2_2
X_5832_ net165 _1975_ VSS VSS VDD VDD _2058_ sky130_fd_sc_hd__nor2_1
X_5833_ net165 _2053_ _2057_ _2058_ VSS VSS VDD VDD _2059_
+ sky130_fd_sc_hd__a22oi_4
X_5834_ _2056_ _2059_ net24 VSS VSS VDD VDD _2060_ sky130_fd_sc_hd__mux2i_1
X_5835_ net465 _2060_ VSS VSS VDD VDD _2061_ sky130_fd_sc_hd__nand2_1
X_5836_ net431 _2051_ _2061_ net437 VSS VSS VDD VDD _2062_
+ sky130_fd_sc_hd__o211ai_1
X_5837_ net266 _2043_ _2062_ VSS VSS VDD VDD _2063_ sky130_fd_sc_hd__o21a_1
X_5838_ net499 _1896_ VSS VSS VDD VDD _2064_ sky130_fd_sc_hd__nor2_2
X_5839_ net466 _3525_ _0140_ VSS VSS VDD VDD _2065_ sky130_fd_sc_hd__o21ai_1
X_5840_ _0140_ _2038_ _2064_ _2065_ VSS VSS VDD VDD _2066_
+ sky130_fd_sc_hd__o31ai_4
X_5841_ _2019_ _2066_ VSS VSS VDD VDD _2067_ sky130_fd_sc_hd__nor2_1
X_5842_ _1956_ _2067_ VSS VSS VDD VDD _2068_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_2_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5845_ net605 net271 VSS VSS VDD VDD _2071_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_2_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5847_ _3518_ _1820_ VSS VSS VDD VDD _2073_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5849_ _3521_ _1795_ _2073_ _1956_ VSS VSS VDD VDD _2075_
+ sky130_fd_sc_hd__o211ai_1
X_5850_ _3517_ net172 _1818_ _2071_ _2075_ VSS VSS VDD VDD
+ _2076_ sky130_fd_sc_hd__a221oi_2
X_5851_ _1990_ _2063_ _2068_ _2076_ VSS VSS VDD VDD net88
+ sky130_fd_sc_hd__o22ai_2
X_5852_ _0122_ net168 VSS VSS VDD VDD _2077_ sky130_fd_sc_hd__nand2_4
X_5853_ _2077_ _2020_ VSS VSS VDD VDD _3265_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_1_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5855_ _1930_ _2052_ net253 VSS VSS VDD VDD _2079_ sky130_fd_sc_hd__mux2i_4
X_5856_ _0140_ _0274_ net265 VSS VSS VDD VDD _2080_ sky130_fd_sc_hd__nor3_2
X_5857_ net422 _2080_ VSS VSS VDD VDD _2081_ sky130_fd_sc_hd__nand2_1
X_5858_ net267 _2079_ _2081_ VSS VSS VDD VDD _2082_ sky130_fd_sc_hd__o21ai_2
X_5859_ _0274_ VSS VSS VDD VDD _3284_ sky130_fd_sc_hd__inv_2
X_5860_ _3284_ net165 VSS VSS VDD VDD _2083_ sky130_fd_sc_hd__nor2_1
X_5861_ net165 _2079_ _2083_ VSS VSS VDD VDD _2084_ sky130_fd_sc_hd__a21oi_1
X_5862_ _2082_ _2084_ net24 VSS VSS VDD VDD _2085_ sky130_fd_sc_hd__mux2i_1
X_5863_ _1933_ _2045_ net248 VSS VSS VDD VDD _2086_ sky130_fd_sc_hd__mux2i_4
X_5864_ _1938_ _2048_ net261 VSS VSS VDD VDD _2087_ sky130_fd_sc_hd__mux2i_4
X_5865_ _2086_ _2087_ net166 VSS VSS VDD VDD _2088_ sky130_fd_sc_hd__mux2i_4
X_5866_ net171 _2088_ VSS VSS VDD VDD _2089_ sky130_fd_sc_hd__nand2_1
X_5867_ net171 _2085_ _2089_ VSS VSS VDD VDD _2090_ sky130_fd_sc_hd__o21ai_0
X_5868_ _1993_ _2090_ VSS VSS VDD VDD _2091_ sky130_fd_sc_hd__nand2_1
X_5869_ net257 net518 VSS VSS VDD VDD _2092_ sky130_fd_sc_hd__nor2_1
X_5870_ net257 _3491_ _2092_ VSS VSS VDD VDD _2093_ sky130_fd_sc_hd__a21oi_1
X_5871_ net407 _2011_ VSS VSS VDD VDD _2094_ sky130_fd_sc_hd__nand2_1
X_5872_ net407 _2093_ _2094_ VSS VSS VDD VDD _2095_ sky130_fd_sc_hd__o21ai_0
X_5873_ _1919_ _2034_ net257 VSS VSS VDD VDD _2096_ sky130_fd_sc_hd__mux2i_2
X_5874_ net932 _2096_ VSS VSS VDD VDD _2097_ sky130_fd_sc_hd__nor2_1
X_5875_ net932 _2095_ _2097_ VSS VSS VDD VDD _2098_ sky130_fd_sc_hd__a21oi_1
X_5876_ _1942_ _2029_ net261 VSS VSS VDD VDD _2099_ sky130_fd_sc_hd__mux2i_4
X_5877_ _1915_ _2031_ net257 VSS VSS VDD VDD _2100_ sky130_fd_sc_hd__mux2i_2
X_5878_ _2099_ _2100_ _1921_ VSS VSS VDD VDD _2101_ sky130_fd_sc_hd__mux2i_2
X_5879_ net431 _2101_ VSS VSS VDD VDD _2102_ sky130_fd_sc_hd__nand2_1
X_5880_ net431 _2098_ _2102_ VSS VSS VDD VDD _2103_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_1_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5882_ _0138_ net411 _1779_ _1792_ _1753_ VSS VSS VDD VDD
+ _2105_ sky130_fd_sc_hd__o221ai_1
X_5883_ _1689_ net265 _2105_ net261 VSS VSS VDD VDD _2106_
+ sky130_fd_sc_hd__o211ai_2
X_5884_ net261 _2038_ _2064_ _2106_ VSS VSS VDD VDD _2107_
+ sky130_fd_sc_hd__o31ai_4
XTAP_TAPCELL_ROW_1_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5886_ _2019_ _2107_ net177 VSS VSS VDD VDD _2109_ sky130_fd_sc_hd__o21ai_0
X_5887_ _1995_ _2103_ _2109_ VSS VSS VDD VDD _2110_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_1_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5890_ _3524_ _2077_ _2020_ VSS VSS VDD VDD _2113_ sky130_fd_sc_hd__and3_1
X_5891_ _3523_ _2113_ net270 VSS VSS VDD VDD _2114_ sky130_fd_sc_hd__o21a_1
X_5892_ _3517_ _2114_ VSS VSS VDD VDD _2115_ sky130_fd_sc_hd__nor2_1
X_5893_ net435 _2115_ VSS VSS VDD VDD _2116_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_1_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_5896_ net435 _1820_ VSS VSS VDD VDD _2119_ sky130_fd_sc_hd__nand2_1
X_5897_ _3513_ _1795_ _2119_ _1956_ VSS VSS VDD VDD _2120_
+ sky130_fd_sc_hd__o211ai_1
X_5898_ _3509_ net172 _1818_ _2116_ _2120_ VSS VSS VDD VDD
+ _2121_ sky130_fd_sc_hd__a221oi_2
X_5899_ _2091_ _2110_ _2121_ VSS VSS VDD VDD net91 sky130_fd_sc_hd__a21oi_1
X_5900_ _1927_ net177 VSS VSS VDD VDD _2122_ sky130_fd_sc_hd__nand2_1
X_5901_ _3515_ net407 _1902_ net257 VSS VSS VDD VDD _2123_
+ sky130_fd_sc_hd__o211ai_2
X_5902_ net407 _3266_ _2036_ _0140_ VSS VSS VDD VDD _2124_
+ sky130_fd_sc_hd__o211ai_2
X_5903_ net166 _1953_ VSS VSS VDD VDD _2125_ sky130_fd_sc_hd__nor2_1
X_5904_ net166 _2123_ _2124_ _2125_ VSS VSS VDD VDD _2126_
+ sky130_fd_sc_hd__a31oi_2
X_5905_ _1949_ _2126_ VSS VSS VDD VDD _2127_ sky130_fd_sc_hd__nor2_1
X_5906_ _1921_ _1920_ VSS VSS VDD VDD _2128_ sky130_fd_sc_hd__nor2_1
X_5907_ net932 _1904_ _2128_ _1990_ VSS VSS VDD VDD _2129_
+ sky130_fd_sc_hd__a211oi_1
X_5908_ net431 _2127_ _2129_ VSS VSS VDD VDD _2130_ sky130_fd_sc_hd__nor3_1
X_5909_ net165 _1944_ VSS VSS VDD VDD _2131_ sky130_fd_sc_hd__nor2_1
X_5910_ net267 _1917_ VSS VSS VDD VDD _2132_ sky130_fd_sc_hd__nor2_1
X_5911_ _2131_ _2132_ VSS VSS VDD VDD _2133_ sky130_fd_sc_hd__nor2_1
X_5912_ net171 _1990_ _2133_ VSS VSS VDD VDD _2134_ sky130_fd_sc_hd__nor3_1
X_5913_ _2122_ _2130_ _2134_ VSS VSS VDD VDD _2135_ sky130_fd_sc_hd__or3_1
X_5914_ _1818_ net279 VSS VSS VDD VDD _2136_ sky130_fd_sc_hd__nand2_1
X_5915_ _1824_ _1844_ VSS VSS VDD VDD _2137_ sky130_fd_sc_hd__nor2_1
X_5916_ _1820_ _2137_ _3502_ VSS VSS VDD VDD _2138_ sky130_fd_sc_hd__o21ai_0
X_5917_ _3505_ _1795_ _1956_ VSS VSS VDD VDD _2139_ sky130_fd_sc_hd__o21ai_0
X_5918_ _3501_ net172 _2139_ VSS VSS VDD VDD _2140_ sky130_fd_sc_hd__a21oi_1
X_5919_ _3502_ _2136_ _2138_ _2140_ VSS VSS VDD VDD _2141_
+ sky130_fd_sc_hd__o211ai_1
X_5920_ net431 _1935_ VSS VSS VDD VDD _2142_ sky130_fd_sc_hd__nor2_1
X_5921_ net24 _1949_ VSS VSS VDD VDD _2143_ sky130_fd_sc_hd__and2_2
X_5922_ _3284_ _2143_ VSS VSS VDD VDD _2144_ sky130_fd_sc_hd__nand2_2
X_5923_ _1930_ _1931_ _0140_ VSS VSS VDD VDD _2145_ sky130_fd_sc_hd__mux2i_4
X_5924_ _1652_ net166 VSS VSS VDD VDD _2146_ sky130_fd_sc_hd__nand2_2
X_5925_ _1938_ _1939_ _0140_ VSS VSS VDD VDD _2147_ sky130_fd_sc_hd__mux2_1
X_5926_ _1935_ _2147_ net165 VSS VSS VDD VDD _2148_ sky130_fd_sc_hd__mux2i_2
X_5927_ _2145_ _2146_ _2148_ net465 VSS VSS VDD VDD _2149_
+ sky130_fd_sc_hd__o22ai_1
X_5928_ _1949_ _2149_ VSS VSS VDD VDD _2150_ sky130_fd_sc_hd__nand2_1
X_5929_ _1927_ _1956_ VSS VSS VDD VDD _2151_ sky130_fd_sc_hd__nor2_2
X_5930_ net166 _2142_ _2144_ _2150_ _2151_ VSS VSS VDD VDD
+ _2152_ sky130_fd_sc_hd__o311ai_1
X_5931_ _2135_ _2141_ _2152_ VSS VSS VDD VDD net92 sky130_fd_sc_hd__and3_1
X_5932_ _3497_ _1795_ VSS VSS VDD VDD _2153_ sky130_fd_sc_hd__nor2_1
X_5933_ _3493_ net172 _1820_ _3494_ _2153_ VSS VSS VDD VDD
+ _2154_ sky130_fd_sc_hd__a221o_1
X_5934_ _3523_ net270 _3517_ VSS VSS VDD VDD _2155_ sky130_fd_sc_hd__a21oi_1
X_5935_ _2155_ _3510_ VSS VSS VDD VDD _2156_ sky130_fd_sc_hd__nor2b_1
X_5936_ _3509_ _2156_ _3502_ VSS VSS VDD VDD _2157_ sky130_fd_sc_hd__o21ai_1
X_5937_ _3501_ _2157_ VSS VSS VDD VDD _2158_ sky130_fd_sc_hd__nand2b_1
X_5938_ _3502_ _3510_ _3518_ _2113_ _2158_ VSS VSS VDD VDD
+ _2159_ sky130_fd_sc_hd__a41oi_1
X_5939_ _3494_ _2159_ VSS VSS VDD VDD _2160_ sky130_fd_sc_hd__xor2_1
X_5940_ _1824_ _2160_ VSS VSS VDD VDD _2161_ sky130_fd_sc_hd__nor2_1
X_5941_ net519 _1689_ _1754_ VSS VSS VDD VDD _2162_ sky130_fd_sc_hd__mux2i_2
X_5942_ _3515_ net709 _1902_ _0140_ VSS VSS VDD VDD _2163_
+ sky130_fd_sc_hd__o211a_1
X_5943_ net276 _2162_ _2163_ VSS VSS VDD VDD _2164_ sky130_fd_sc_hd__a21oi_2
X_5944_ _2021_ _2164_ _1921_ VSS VSS VDD VDD _2165_ sky130_fd_sc_hd__mux2i_4
X_5945_ net932 _2003_ VSS VSS VDD VDD _2166_ sky130_fd_sc_hd__nor2_1
X_5946_ net267 _2010_ VSS VSS VDD VDD _2167_ sky130_fd_sc_hd__nor2_1
X_5947_ _2166_ _2167_ _1949_ VSS VSS VDD VDD _2168_ sky130_fd_sc_hd__o21ai_0
X_5948_ _1949_ _2165_ _2168_ net171 VSS VSS VDD VDD _2169_
+ sky130_fd_sc_hd__o211ai_1
X_5949_ net171 _1990_ VSS VSS VDD VDD _2170_ sky130_fd_sc_hd__nor2_1
X_5950_ _1921_ _1987_ VSS VSS VDD VDD _2171_ sky130_fd_sc_hd__nor2_1
X_5951_ _1921_ _1997_ _1998_ _2171_ VSS VSS VDD VDD _2172_
+ sky130_fd_sc_hd__a31oi_2
X_5952_ _2170_ _2172_ VSS VSS VDD VDD _2173_ sky130_fd_sc_hd__nand2_1
X_5953_ _2169_ _2173_ net266 VSS VSS VDD VDD _2174_ sky130_fd_sc_hd__a21oi_1
X_5954_ _1982_ _1967_ net426 VSS VSS VDD VDD _2175_ sky130_fd_sc_hd__mux2i_2
X_5955_ net431 _2175_ VSS VSS VDD VDD _2176_ sky130_fd_sc_hd__nor2_1
X_5956_ _0274_ net424 net170 VSS VSS VDD VDD _2177_ sky130_fd_sc_hd__a21oi_1
X_5957_ net267 _1976_ _2177_ VSS VSS VDD VDD _2178_ sky130_fd_sc_hd__o21ai_2
X_5958_ net171 net426 VSS VSS VDD VDD _2179_ sky130_fd_sc_hd__nor2_2
X_5959_ _1970_ _2179_ net24 VSS VSS VDD VDD _2180_ sky130_fd_sc_hd__a21oi_1
X_5960_ net24 _2178_ _2180_ VSS VSS VDD VDD _2181_ sky130_fd_sc_hd__a21oi_1
X_5961_ _2176_ _2181_ _1993_ VSS VSS VDD VDD _2182_ sky130_fd_sc_hd__o21ai_1
X_5962_ net177 _2182_ VSS VSS VDD VDD _2183_ sky130_fd_sc_hd__nand2_1
X_5963_ net177 _2154_ _2161_ _2174_ _2183_ VSS VSS VDD VDD
+ net93 sky130_fd_sc_hd__o32a_1
X_5964_ _2046_ _2053_ net426 VSS VSS VDD VDD _2184_ sky130_fd_sc_hd__mux2i_2
X_5965_ net171 _2184_ VSS VSS VDD VDD _2185_ sky130_fd_sc_hd__nand2_1
X_5966_ _2057_ _2146_ _2185_ VSS VSS VDD VDD _2186_ sky130_fd_sc_hd__o21ai_0
X_5967_ _1949_ _2186_ VSS VSS VDD VDD _2187_ sky130_fd_sc_hd__nand2_1
X_5968_ net24 _1949_ VSS VSS VDD VDD _2188_ sky130_fd_sc_hd__nand2_4
X_5969_ _0274_ _2188_ VSS VSS VDD VDD _2189_ sky130_fd_sc_hd__nor2_4
X_5970_ net166 net407 net171 VSS VSS VDD VDD _2190_ sky130_fd_sc_hd__a21oi_1
X_5971_ _2189_ _2190_ VSS VSS VDD VDD _2191_ sky130_fd_sc_hd__nand2_1
X_5972_ _3502_ net279 _3501_ VSS VSS VDD VDD _2192_ sky130_fd_sc_hd__a21o_1
X_5973_ _2192_ _3494_ _3493_ VSS VSS VDD VDD _2193_ sky130_fd_sc_hd__a21oi_2
X_5974_ _2193_ _3486_ VSS VSS VDD VDD _2194_ sky130_fd_sc_hd__xnor2_2
X_5975_ _3486_ _1820_ VSS VSS VDD VDD _2195_ sky130_fd_sc_hd__nand2_1
X_5976_ _3489_ _1795_ _2195_ _1956_ VSS VSS VDD VDD _2196_
+ sky130_fd_sc_hd__o211ai_2
X_5977_ _3485_ net172 _2194_ _1818_ _2196_ VSS VSS VDD VDD
+ _2197_ sky130_fd_sc_hd__a221oi_4
X_5978_ net517 _3503_ _1754_ VSS VSS VDD VDD _2198_ sky130_fd_sc_hd__mux2i_4
X_5979_ _2162_ _2198_ net168 VSS VSS VDD VDD _2199_ sky130_fd_sc_hd__mux2i_1
X_5980_ _2066_ _2199_ net166 VSS VSS VDD VDD _2200_ sky130_fd_sc_hd__mux2_1
X_5981_ net267 _2032_ VSS VSS VDD VDD _2201_ sky130_fd_sc_hd__nand2_1
X_5982_ net932 _2035_ VSS VSS VDD VDD _2202_ sky130_fd_sc_hd__nand2_1
X_5983_ _1949_ _2201_ _2202_ VSS VSS VDD VDD _2203_ sky130_fd_sc_hd__nand3_1
X_5984_ _1949_ _2200_ _2203_ VSS VSS VDD VDD _2204_ sky130_fd_sc_hd__o21ai_0
X_5985_ net267 _2049_ VSS VSS VDD VDD _2205_ sky130_fd_sc_hd__nand2_1
X_5986_ _1702_ _2030_ _2205_ VSS VSS VDD VDD _2206_ sky130_fd_sc_hd__o21ai_1
X_5987_ net171 _2204_ _2206_ _2170_ _2122_ VSS VSS VDD VDD
+ _2207_ sky130_fd_sc_hd__a221oi_2
X_5988_ _2151_ _2187_ _2191_ _2197_ _2207_ VSS VSS VDD VDD
+ net94 sky130_fd_sc_hd__a311oi_4
X_5989_ _3479_ VSS VSS VDD VDD _3475_ sky130_fd_sc_hd__inv_1
X_5990_ _2086_ _2079_ net267 VSS VSS VDD VDD _2208_ sky130_fd_sc_hd__mux2i_4
X_5991_ net254 net165 net167 net24 VSS VSS VDD VDD _2209_
+ sky130_fd_sc_hd__a31oi_1
X_5992_ _0274_ _2209_ net465 VSS VSS VDD VDD _2210_ sky130_fd_sc_hd__o21ai_1
X_5993_ net431 _2208_ _2210_ _1949_ VSS VSS VDD VDD _2211_
+ sky130_fd_sc_hd__o211ai_4
X_5994_ net166 _2107_ VSS VSS VDD VDD _2212_ sky130_fd_sc_hd__nor2_1
X_5995_ _3479_ net520 net265 VSS VSS VDD VDD _2213_ sky130_fd_sc_hd__mux2i_4
X_5996_ _2198_ _2213_ net276 VSS VSS VDD VDD _2214_ sky130_fd_sc_hd__mux2i_4
X_5997_ net427 _2214_ VSS VSS VDD VDD _2215_ sky130_fd_sc_hd__nor2_1
X_5998_ _2212_ _2215_ VSS VSS VDD VDD _2216_ sky130_fd_sc_hd__nor2_1
X_5999_ net267 _2100_ VSS VSS VDD VDD _2217_ sky130_fd_sc_hd__nand2_1
X_6000_ net932 _2096_ VSS VSS VDD VDD _2218_ sky130_fd_sc_hd__nand2_1
X_6001_ _1949_ _2217_ _2218_ VSS VSS VDD VDD _2219_ sky130_fd_sc_hd__nand3_1
X_6002_ _1949_ _2216_ _2219_ VSS VSS VDD VDD _2220_ sky130_fd_sc_hd__o21ai_0
X_6003_ _2087_ _2099_ net166 VSS VSS VDD VDD _2221_ sky130_fd_sc_hd__mux2i_2
X_6004_ net171 _2220_ _2221_ _2170_ _2122_ VSS VSS VDD VDD
+ _2222_ sky130_fd_sc_hd__a221oi_2
X_6005_ _3494_ _3502_ _3510_ _3518_ VSS VSS VDD VDD _2223_
+ sky130_fd_sc_hd__and4_1
X_6006_ _3524_ _2223_ VSS VSS VDD VDD _2224_ sky130_fd_sc_hd__nand2_1
X_6007_ net168 net501 _2224_ VSS VSS VDD VDD _2225_ sky130_fd_sc_hd__nor3_1
X_6008_ _3494_ _2158_ _3493_ VSS VSS VDD VDD _2226_ sky130_fd_sc_hd__a21oi_2
X_6009_ _0122_ _0140_ _2224_ _2226_ VSS VSS VDD VDD _2227_
+ sky130_fd_sc_hd__o31ai_2
X_6010_ _2225_ _2227_ _3486_ VSS VSS VDD VDD _2228_ sky130_fd_sc_hd__o21a_1
X_6011_ _3485_ _2228_ VSS VSS VDD VDD _2229_ sky130_fd_sc_hd__nor2_1
X_6012_ _3478_ _2229_ VSS VSS VDD VDD _2230_ sky130_fd_sc_hd__xnor2_1
X_6013_ _3478_ _1820_ VSS VSS VDD VDD _2231_ sky130_fd_sc_hd__nand2_1
X_6014_ _3481_ _1795_ _2231_ _1956_ VSS VSS VDD VDD _2232_
+ sky130_fd_sc_hd__o211ai_2
X_6015_ _3477_ net172 _1818_ _2230_ _2232_ VSS VSS VDD VDD
+ _2233_ sky130_fd_sc_hd__a221oi_4
X_6016_ _2151_ _2211_ _2233_ _2222_ VSS VSS VDD VDD net95
+ sky130_fd_sc_hd__a211oi_4
X_6017_ _3471_ VSS VSS VDD VDD _3467_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_1_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6019_ _3471_ net517 net466 VSS VSS VDD VDD _2235_ sky130_fd_sc_hd__mux2i_1
X_6020_ _2213_ _2235_ net276 VSS VSS VDD VDD _2236_ sky130_fd_sc_hd__mux2i_2
X_6021_ net166 _2236_ VSS VSS VDD VDD _2237_ sky130_fd_sc_hd__nand2_1
X_6022_ net426 _2123_ _2124_ VSS VSS VDD VDD _2238_ sky130_fd_sc_hd__nand3_1
X_6023_ net171 _2237_ _2238_ _1953_ _2179_ VSS VSS VDD VDD
+ _2239_ sky130_fd_sc_hd__a32oi_2
X_6024_ _1924_ _1946_ net465 VSS VSS VDD VDD _2240_ sky130_fd_sc_hd__mux2i_1
X_6025_ _2239_ _2240_ _1949_ VSS VSS VDD VDD _2241_ sky130_fd_sc_hd__mux2i_1
X_6026_ net24 _3284_ VSS VSS VDD VDD _2242_ sky130_fd_sc_hd__nand2_1
X_6027_ net170 _2242_ VSS VSS VDD VDD _2243_ sky130_fd_sc_hd__nor2_1
X_6028_ _1890_ _1937_ _2243_ VSS VSS VDD VDD _2244_ sky130_fd_sc_hd__a21oi_1
X_6029_ _1990_ _2244_ net266 VSS VSS VDD VDD _2245_ sky130_fd_sc_hd__o21ai_0
X_6030_ net266 _2241_ _2245_ VSS VSS VDD VDD _2246_ sky130_fd_sc_hd__o21ai_2
X_6031_ _1842_ net288 _3478_ VSS VSS VDD VDD _2247_ sky130_fd_sc_hd__nor3b_2
X_6032_ _3477_ _2247_ _3470_ VSS VSS VDD VDD _2248_ sky130_fd_sc_hd__o21a_1
X_6033_ _3470_ _3477_ _2247_ _1818_ VSS VSS VDD VDD _2249_
+ sky130_fd_sc_hd__o31ai_1
X_6034_ _3473_ _1795_ VSS VSS VDD VDD _2250_ sky130_fd_sc_hd__nor2_1
X_6035_ _3469_ net175 _1820_ _3470_ _2250_ VSS VSS VDD VDD
+ _2251_ sky130_fd_sc_hd__a221oi_1
X_6036_ _2248_ _2249_ _1956_ _2251_ VSS VSS VDD VDD _2252_
+ sky130_fd_sc_hd__o211a_1
X_6037_ _1809_ _2246_ _2252_ VSS VSS VDD VDD net96 sky130_fd_sc_hd__a21oi_4
X_6038_ net852 VSS VSS VDD VDD _3459_ sky130_fd_sc_hd__inv_1
X_6039_ _1927_ _1990_ VSS VSS VDD VDD _2253_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_1_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6041_ net855 _3479_ _1754_ VSS VSS VDD VDD _2255_ sky130_fd_sc_hd__mux2i_1
X_6042_ _2235_ _2255_ net168 VSS VSS VDD VDD _2256_ sky130_fd_sc_hd__mux2_1
X_6043_ net166 _2256_ VSS VSS VDD VDD _2257_ sky130_fd_sc_hd__nand2_1
X_6044_ net166 _2164_ _2257_ VSS VSS VDD VDD _2258_ sky130_fd_sc_hd__o21ai_2
X_6045_ net171 _2258_ _2146_ _2021_ VSS VSS VDD VDD _2259_
+ sky130_fd_sc_hd__o2bb2ai_1
X_6046_ _1988_ _2005_ net171 VSS VSS VDD VDD _2260_ sky130_fd_sc_hd__mux2i_2
X_6047_ _1927_ _1949_ VSS VSS VDD VDD _2261_ sky130_fd_sc_hd__nand2_2
X_6048_ _0274_ _1977_ net170 VSS VSS VDD VDD _2262_ sky130_fd_sc_hd__mux2_1
X_6049_ net24 _1652_ _1990_ VSS VSS VDD VDD _2263_ sky130_fd_sc_hd__nor3_4
X_6050_ _2263_ VSS VSS VDD VDD _2264_ sky130_fd_sc_hd__inv_1
X_6051_ _2188_ _2262_ _2264_ _1972_ net440 VSS VSS VDD VDD
+ _2265_ sky130_fd_sc_hd__o221ai_4
X_6052_ _2253_ _2259_ _2260_ _2261_ _2265_ VSS VSS VDD VDD
+ _2266_ sky130_fd_sc_hd__o221ai_4
X_6053_ _3470_ _3478_ _3486_ VSS VSS VDD VDD _2267_ sky130_fd_sc_hd__and3_1
X_6054_ _2227_ _2225_ _2267_ VSS VSS VDD VDD _2268_ sky130_fd_sc_hd__o21ai_2
X_6055_ _3485_ _3478_ _3477_ VSS VSS VDD VDD _2269_ sky130_fd_sc_hd__a21o_1
X_6056_ _3470_ _2269_ _3469_ VSS VSS VDD VDD _2270_ sky130_fd_sc_hd__a21oi_1
X_6057_ net305 _2270_ VSS VSS VDD VDD _2271_ sky130_fd_sc_hd__nand2_2
X_6058_ _3462_ _2271_ VSS VSS VDD VDD _2272_ sky130_fd_sc_hd__xor2_1
X_6059_ _3461_ net175 _1820_ _3462_ VSS VSS VDD VDD _2273_
+ sky130_fd_sc_hd__a22oi_1
X_6060_ _3465_ _1795_ _2273_ VSS VSS VDD VDD _2274_ sky130_fd_sc_hd__o21ai_0
X_6061_ _2272_ _1818_ _2274_ _1809_ VSS VSS VDD VDD _2275_
+ sky130_fd_sc_hd__a211oi_2
X_6062_ _1809_ _2266_ _2275_ VSS VSS VDD VDD net97 sky130_fd_sc_hd__a21oi_2
X_6063_ _3455_ _3471_ _1754_ VSS VSS VDD VDD _2276_ sky130_fd_sc_hd__mux2i_1
X_6064_ _2255_ _2276_ net168 VSS VSS VDD VDD _2277_ sky130_fd_sc_hd__mux2_1
X_6065_ net166 _2199_ VSS VSS VDD VDD _2278_ sky130_fd_sc_hd__nor2_1
X_6066_ net166 _2277_ _2278_ VSS VSS VDD VDD _2279_ sky130_fd_sc_hd__a21oi_1
X_6067_ _2066_ _2146_ _2279_ _1652_ VSS VSS VDD VDD _2280_
+ sky130_fd_sc_hd__o22a_1
X_6068_ _2033_ net171 VSS VSS VDD VDD _2281_ sky130_fd_sc_hd__nand2b_1
X_6069_ net170 _2051_ _2281_ _1949_ VSS VSS VDD VDD _2282_
+ sky130_fd_sc_hd__o211ai_1
X_6070_ _1949_ _2280_ _2282_ VSS VSS VDD VDD _2283_ sky130_fd_sc_hd__o21ai_1
X_6071_ _1652_ net265 VSS VSS VDD VDD _2284_ sky130_fd_sc_hd__nor2_1
X_6072_ _1652_ _2055_ _2284_ _0274_ VSS VSS VDD VDD _2285_
+ sky130_fd_sc_hd__o22ai_2
X_6073_ _1954_ _2053_ _2188_ VSS VSS VDD VDD _2286_ sky130_fd_sc_hd__a21oi_1
X_6074_ _2056_ _2263_ _2285_ _2286_ VSS VSS VDD VDD _2287_
+ sky130_fd_sc_hd__a22oi_4
X_6075_ net266 _2287_ VSS VSS VDD VDD _2288_ sky130_fd_sc_hd__nand2_1
X_6076_ net266 _2283_ _2288_ VSS VSS VDD VDD _2289_ sky130_fd_sc_hd__o21ai_4
X_6077_ _3469_ _2248_ _3462_ VSS VSS VDD VDD _2290_ sky130_fd_sc_hd__o21a_1
X_6078_ _3454_ _3461_ _2290_ VSS VSS VDD VDD _2291_ sky130_fd_sc_hd__nor3_1
X_6079_ _3461_ _2290_ _3454_ VSS VSS VDD VDD _2292_ sky130_fd_sc_hd__o21ai_1
X_6080_ _1824_ _2291_ _2292_ VSS VSS VDD VDD _2293_ sky130_fd_sc_hd__nor3b_2
X_6081_ _3454_ _1820_ VSS VSS VDD VDD _2294_ sky130_fd_sc_hd__nand2_1
X_6082_ _3457_ _1795_ _2294_ VSS VSS VDD VDD _2295_ sky130_fd_sc_hd__o21ai_0
X_6083_ _3453_ net175 _2295_ _2293_ _1809_ VSS VSS VDD VDD
+ _2296_ sky130_fd_sc_hd__a2111oi_4
X_6084_ _1809_ _2289_ _2296_ VSS VSS VDD VDD net67 sky130_fd_sc_hd__a21oi_4
X_6085_ _3462_ _2271_ _3461_ VSS VSS VDD VDD _2297_ sky130_fd_sc_hd__a21o_1
X_6086_ _3454_ _2297_ _3453_ VSS VSS VDD VDD _2298_ sky130_fd_sc_hd__a21oi_2
X_6087_ _2298_ _3446_ VSS VSS VDD VDD _2299_ sky130_fd_sc_hd__xnor2_1
X_6088_ _3446_ _1820_ VSS VSS VDD VDD _2300_ sky130_fd_sc_hd__nand2_1
X_6089_ _3449_ _1795_ _2300_ VSS VSS VDD VDD _2301_ sky130_fd_sc_hd__o21ai_1
X_6090_ _3445_ net175 _2299_ _1818_ _2301_ VSS VSS VDD VDD
+ _2302_ sky130_fd_sc_hd__a221oi_4
X_6091_ net170 net165 VSS VSS VDD VDD _2303_ sky130_fd_sc_hd__nand2_1
X_6092_ _0274_ _2303_ _2188_ VSS VSS VDD VDD _2304_ sky130_fd_sc_hd__a21oi_1
X_6093_ _1954_ _2079_ VSS VSS VDD VDD _2305_ sky130_fd_sc_hd__nand2_1
X_6094_ _2082_ _2263_ _2304_ _2305_ _1927_ VSS VSS VDD VDD
+ _2306_ sky130_fd_sc_hd__a221o_1
X_6095_ _3447_ net855 _1754_ VSS VSS VDD VDD _2307_ sky130_fd_sc_hd__mux2i_2
X_6096_ _2276_ _2307_ net168 VSS VSS VDD VDD _2308_ sky130_fd_sc_hd__mux2_1
X_6097_ net165 _2308_ VSS VSS VDD VDD _2309_ sky130_fd_sc_hd__nand2_1
X_6098_ net165 _2214_ _2309_ VSS VSS VDD VDD _2310_ sky130_fd_sc_hd__o21ai_2
X_6099_ net171 _2310_ VSS VSS VDD VDD _2311_ sky130_fd_sc_hd__nand2_1
X_6100_ _2107_ _2179_ VSS VSS VDD VDD _2312_ sky130_fd_sc_hd__nand2b_1
X_6101_ _2088_ _2101_ net171 VSS VSS VDD VDD _2313_ sky130_fd_sc_hd__mux2i_1
X_6102_ _1955_ _2311_ _2312_ _1995_ _2313_ VSS VSS VDD VDD
+ _2314_ sky130_fd_sc_hd__a32oi_1
X_6103_ _2306_ _2314_ _1956_ VSS VSS VDD VDD _2315_ sky130_fd_sc_hd__a21oi_2
X_6104_ _2302_ _1956_ _2315_ VSS VSS VDD VDD net68 sky130_fd_sc_hd__a21oi_2
X_6105_ net170 _2148_ VSS VSS VDD VDD _2316_ sky130_fd_sc_hd__nor2_1
X_6106_ net431 _2133_ VSS VSS VDD VDD _2317_ sky130_fd_sc_hd__nor2_1
X_6107_ _3439_ _3455_ net466 VSS VSS VDD VDD _2318_ sky130_fd_sc_hd__mux2i_2
X_6108_ _2307_ _2318_ net276 VSS VSS VDD VDD _2319_ sky130_fd_sc_hd__mux2i_2
X_6109_ _2236_ _2319_ _1921_ VSS VSS VDD VDD _2320_ sky130_fd_sc_hd__mux2i_4
X_6110_ _2126_ _2320_ net170 VSS VSS VDD VDD _2321_ sky130_fd_sc_hd__mux2i_2
X_6111_ _1990_ _2321_ VSS VSS VDD VDD _2322_ sky130_fd_sc_hd__nand2_1
X_6112_ _1990_ _2316_ _2317_ _2322_ _1927_ VSS VSS VDD VDD
+ _2323_ sky130_fd_sc_hd__o311ai_4
X_6113_ _1932_ _1954_ VSS VSS VDD VDD _2324_ sky130_fd_sc_hd__nand2_1
X_6114_ _1954_ _2242_ _2324_ VSS VSS VDD VDD _2325_ sky130_fd_sc_hd__o21ai_1
X_6115_ _1993_ _2325_ _1956_ VSS VSS VDD VDD _2326_ sky130_fd_sc_hd__a21oi_2
X_6116_ _3453_ _2292_ VSS VSS VDD VDD _2327_ sky130_fd_sc_hd__nand2b_1
X_6117_ _3446_ _2327_ _3445_ VSS VSS VDD VDD _2328_ sky130_fd_sc_hd__a21oi_1
X_6118_ _3438_ _2328_ VSS VSS VDD VDD _2329_ sky130_fd_sc_hd__xnor2_1
X_6119_ _3438_ _1820_ VSS VSS VDD VDD _2330_ sky130_fd_sc_hd__nand2_1
X_6120_ _3441_ _1795_ _2330_ _1956_ VSS VSS VDD VDD _2331_
+ sky130_fd_sc_hd__o211ai_2
X_6121_ _3437_ net175 _2329_ _1818_ _2331_ VSS VSS VDD VDD
+ _2332_ sky130_fd_sc_hd__a221oi_4
X_6122_ _2323_ _2326_ _2332_ VSS VSS VDD VDD net69 sky130_fd_sc_hd__a21oi_4
X_6123_ _3454_ _3461_ _3453_ VSS VSS VDD VDD _2333_ sky130_fd_sc_hd__a21o_1
X_6124_ _3446_ _2333_ _3445_ VSS VSS VDD VDD _2334_ sky130_fd_sc_hd__a21o_1
X_6125_ _3438_ _2334_ _3437_ VSS VSS VDD VDD _2335_ sky130_fd_sc_hd__a21oi_4
X_6126_ _2270_ _2268_ _1846_ VSS VSS VDD VDD _2336_ sky130_fd_sc_hd__a21o_2
X_6127_ _2335_ net304 VSS VSS VDD VDD _2337_ sky130_fd_sc_hd__and2_1
X_6128_ _3430_ _2337_ VSS VSS VDD VDD _2338_ sky130_fd_sc_hd__xnor2_1
X_6129_ _1818_ _2338_ VSS VSS VDD VDD _2339_ sky130_fd_sc_hd__nand2_1
X_6130_ _3433_ _1795_ VSS VSS VDD VDD _2340_ sky130_fd_sc_hd__nor2_1
X_6131_ _3430_ _1820_ _2340_ VSS VSS VDD VDD _2341_ sky130_fd_sc_hd__a21oi_1
X_6132_ _3429_ net175 _1809_ VSS VSS VDD VDD _2342_ sky130_fd_sc_hd__a21oi_1
X_6133_ _2303_ _1976_ _2304_ VSS VSS VDD VDD _2343_ sky130_fd_sc_hd__o21ai_2
X_6134_ net166 _1970_ _2263_ VSS VSS VDD VDD _2344_ sky130_fd_sc_hd__nand3_1
X_6135_ net171 _2175_ VSS VSS VDD VDD _2345_ sky130_fd_sc_hd__nor2_1
X_6136_ net171 _2172_ _2345_ _2261_ VSS VSS VDD VDD _2346_
+ sky130_fd_sc_hd__a211oi_1
X_6137_ _3435_ _3451_ net466 VSS VSS VDD VDD _2347_ sky130_fd_sc_hd__mux2i_2
X_6138_ _3427_ _3443_ _1754_ VSS VSS VDD VDD _2348_ sky130_fd_sc_hd__mux2i_4
X_6139_ _2347_ _2348_ net259 VSS VSS VDD VDD _2349_ sky130_fd_sc_hd__mux2i_4
X_6140_ _2256_ _2349_ net166 VSS VSS VDD VDD _2350_ sky130_fd_sc_hd__mux2i_2
X_6141_ net171 _2350_ VSS VSS VDD VDD _2351_ sky130_fd_sc_hd__nand2_1
X_6142_ net171 _2165_ _2351_ VSS VSS VDD VDD _2352_ sky130_fd_sc_hd__o21a_1
X_6143_ _2253_ _2352_ VSS VSS VDD VDD _2353_ sky130_fd_sc_hd__nor2_1
X_6144_ net266 _2343_ _2344_ _2346_ _2353_ VSS VSS VDD VDD
+ _2354_ sky130_fd_sc_hd__a311o_4
X_6145_ _2339_ _2341_ _2342_ _2354_ _1809_ VSS VSS VDD VDD
+ net70 sky130_fd_sc_hd__a32oi_4
X_6146_ net431 _2184_ VSS VSS VDD VDD _2355_ sky130_fd_sc_hd__nand2_1
X_6147_ net171 _2206_ VSS VSS VDD VDD _2356_ sky130_fd_sc_hd__nand2_1
X_6148_ _1995_ _2355_ _2356_ VSS VSS VDD VDD _2357_ sky130_fd_sc_hd__and3_1
X_6149_ _0140_ net265 _2303_ VSS VSS VDD VDD _2358_ sky130_fd_sc_hd__nor3_1
X_6150_ _0371_ _2358_ VSS VSS VDD VDD _2359_ sky130_fd_sc_hd__nand2_1
X_6151_ _3284_ _2358_ _2359_ _2143_ VSS VSS VDD VDD _2360_
+ sky130_fd_sc_hd__o211ai_1
X_6152_ net421 _2057_ _2264_ _2360_ net266 VSS VSS VDD VDD
+ _2361_ sky130_fd_sc_hd__o311a_1
X_6153_ _3419_ _3435_ _1754_ VSS VSS VDD VDD _2362_ sky130_fd_sc_hd__mux2i_4
X_6154_ _2348_ _2362_ net258 VSS VSS VDD VDD _2363_ sky130_fd_sc_hd__mux2i_4
X_6155_ _2277_ _2363_ net166 VSS VSS VDD VDD _2364_ sky130_fd_sc_hd__mux2i_2
X_6156_ _2200_ _2364_ net171 VSS VSS VDD VDD _2365_ sky130_fd_sc_hd__mux2i_2
X_6157_ _2253_ _2365_ VSS VSS VDD VDD _2366_ sky130_fd_sc_hd__nor2_1
X_6158_ _1852_ _1854_ VSS VSS VDD VDD _2367_ sky130_fd_sc_hd__nor2_1
X_6159_ _1849_ _2367_ _3430_ VSS VSS VDD VDD _2368_ sky130_fd_sc_hd__o21ai_0
X_6160_ _3429_ _2368_ VSS VSS VDD VDD _2369_ sky130_fd_sc_hd__nand2b_1
X_6161_ _3422_ _2369_ VSS VSS VDD VDD _2370_ sky130_fd_sc_hd__xnor2_1
X_6162_ _3421_ net175 _1820_ _3422_ VSS VSS VDD VDD _2371_
+ sky130_fd_sc_hd__a22oi_1
X_6163_ _3425_ _1795_ _1824_ _2370_ _2371_ VSS VSS VDD VDD
+ _2372_ sky130_fd_sc_hd__o221ai_1
X_6164_ _1956_ _2372_ VSS VSS VDD VDD _2373_ sky130_fd_sc_hd__nand2_2
X_6165_ _1956_ _2357_ _2361_ _2366_ _2373_ VSS VSS VDD VDD
+ net71 sky130_fd_sc_hd__o41ai_4
X_6166_ _3414_ VSS VSS VDD VDD _2374_ sky130_fd_sc_hd__inv_1
X_6167_ _3422_ _3430_ VSS VSS VDD VDD _2375_ sky130_fd_sc_hd__nand2_1
X_6168_ _3422_ _3429_ _3421_ VSS VSS VDD VDD _2376_ sky130_fd_sc_hd__a21oi_1
X_6169_ _2337_ _2375_ _2376_ VSS VSS VDD VDD _2377_ sky130_fd_sc_hd__o21ai_0
X_6170_ _2374_ _2377_ VSS VSS VDD VDD _2378_ sky130_fd_sc_hd__xnor2_1
X_6171_ _1818_ _2378_ VSS VSS VDD VDD _2379_ sky130_fd_sc_hd__nand2_1
X_6172_ _3417_ _1795_ VSS VSS VDD VDD _2380_ sky130_fd_sc_hd__nor2_1
X_6173_ _3414_ _1820_ _2380_ VSS VSS VDD VDD _2381_ sky130_fd_sc_hd__a21oi_1
X_6174_ _3413_ net175 _1809_ VSS VSS VDD VDD _2382_ sky130_fd_sc_hd__a21oi_1
X_6175_ net431 _2208_ VSS VSS VDD VDD _2383_ sky130_fd_sc_hd__nand2_1
X_6176_ net170 _2221_ VSS VSS VDD VDD _2384_ sky130_fd_sc_hd__nand2_1
X_6177_ _2261_ _2144_ VSS VSS VDD VDD _2385_ sky130_fd_sc_hd__nand2_1
X_6178_ net166 _2080_ _2263_ _2385_ VSS VSS VDD VDD _2386_
+ sky130_fd_sc_hd__a31oi_1
X_6179_ _1927_ _2383_ _2384_ _2386_ VSS VSS VDD VDD _2387_
+ sky130_fd_sc_hd__a31oi_1
X_6180_ _2107_ _2214_ net165 VSS VSS VDD VDD _2388_ sky130_fd_sc_hd__mux2i_2
X_6181_ _3411_ _3427_ net466 VSS VSS VDD VDD _2389_ sky130_fd_sc_hd__mux2i_4
X_6182_ _2362_ _2389_ net258 VSS VSS VDD VDD _2390_ sky130_fd_sc_hd__mux2i_4
X_6183_ _2308_ _2390_ net165 VSS VSS VDD VDD _2391_ sky130_fd_sc_hd__mux2_1
X_6184_ _2388_ _2391_ net170 VSS VSS VDD VDD _2392_ sky130_fd_sc_hd__mux2i_4
X_6185_ _2253_ _2392_ net176 VSS VSS VDD VDD _2393_ sky130_fd_sc_hd__o21ai_0
X_6186_ _2387_ _2393_ VSS VSS VDD VDD _2394_ sky130_fd_sc_hd__nor2_2
X_6187_ _2379_ _2381_ _2382_ _2394_ VSS VSS VDD VDD net72
+ sky130_fd_sc_hd__a31oi_4
X_6188_ _3409_ _1795_ VSS VSS VDD VDD _2395_ sky130_fd_sc_hd__nor2_1
X_6189_ _3406_ _1820_ _2395_ VSS VSS VDD VDD _2396_ sky130_fd_sc_hd__a21oi_1
X_6190_ _3405_ _1803_ net177 VSS VSS VDD VDD _2397_ sky130_fd_sc_hd__a21oi_1
X_6191_ _1849_ _1856_ _1864_ VSS VSS VDD VDD _2398_ sky130_fd_sc_hd__o21a_1
X_6192_ _2398_ _3414_ _3413_ VSS VSS VDD VDD _2399_ sky130_fd_sc_hd__a21oi_2
X_6193_ _2399_ _3406_ VSS VSS VDD VDD _2400_ sky130_fd_sc_hd__xnor2_1
X_6194_ _1818_ _2400_ VSS VSS VDD VDD _2401_ sky130_fd_sc_hd__nand2_1
X_6195_ _2307_ _2318_ net168 VSS VSS VDD VDD _2402_ sky130_fd_sc_hd__mux2_1
X_6196_ _3403_ _3419_ net466 VSS VSS VDD VDD _2403_ sky130_fd_sc_hd__mux2i_4
X_6197_ _2389_ _2403_ net169 VSS VSS VDD VDD _2404_ sky130_fd_sc_hd__mux2i_1
X_6198_ _2402_ _2404_ _1921_ VSS VSS VDD VDD _2405_ sky130_fd_sc_hd__mux2i_1
X_6199_ net431 _2405_ VSS VSS VDD VDD _2406_ sky130_fd_sc_hd__nor2_1
X_6200_ net465 _2237_ _2238_ _2406_ VSS VSS VDD VDD _2407_
+ sky130_fd_sc_hd__a31o_1
X_6201_ _1927_ _1949_ VSS VSS VDD VDD _2408_ sky130_fd_sc_hd__nor2_4
X_6202_ _1953_ _1954_ _2408_ VSS VSS VDD VDD _2409_ sky130_fd_sc_hd__and3_1
X_6203_ _1995_ _2189_ VSS VSS VDD VDD _2410_ sky130_fd_sc_hd__nor2_2
X_6204_ _1927_ _1947_ _2410_ VSS VSS VDD VDD _2411_ sky130_fd_sc_hd__a21oi_1
X_6205_ _1955_ _2407_ _2409_ _2411_ _1956_ VSS VSS VDD VDD
+ _2412_ sky130_fd_sc_hd__a2111oi_2
X_6206_ _2396_ _2401_ _2397_ _2412_ VSS VSS VDD VDD net73
+ sky130_fd_sc_hd__a31oi_4
X_6207_ _3395_ _3411_ net466 VSS VSS VDD VDD _2413_ sky130_fd_sc_hd__mux2i_4
X_6208_ _2403_ _2413_ net261 VSS VSS VDD VDD _2414_ sky130_fd_sc_hd__mux2i_4
X_6209_ _2349_ _2414_ net166 VSS VSS VDD VDD _2415_ sky130_fd_sc_hd__mux2i_1
X_6210_ net170 _2415_ VSS VSS VDD VDD _2416_ sky130_fd_sc_hd__nand2_1
X_6211_ net170 _2258_ _2416_ _1955_ VSS VSS VDD VDD _2417_
+ sky130_fd_sc_hd__o211ai_2
X_6212_ _0274_ net440 _2188_ VSS VSS VDD VDD _2418_ sky130_fd_sc_hd__a21oi_4
X_6213_ net170 _1977_ _1927_ VSS VSS VDD VDD _2419_ sky130_fd_sc_hd__o21ai_0
X_6214_ _1954_ _2408_ VSS VSS VDD VDD _2420_ sky130_fd_sc_hd__nand2_1
X_6215_ _2021_ _2420_ net177 VSS VSS VDD VDD _2421_ sky130_fd_sc_hd__o21ai_0
X_6216_ _2418_ _2419_ _2421_ VSS VSS VDD VDD _2422_ sky130_fd_sc_hd__a21oi_1
X_6217_ net24 net437 _1990_ VSS VSS VDD VDD _2423_ sky130_fd_sc_hd__nor3_2
X_6218_ net465 _1988_ _2410_ VSS VSS VDD VDD _2424_ sky130_fd_sc_hd__nor3_1
X_6219_ net431 _1971_ _2423_ _2424_ VSS VSS VDD VDD _2425_
+ sky130_fd_sc_hd__a31oi_2
X_6220_ _3470_ _2269_ VSS VSS VDD VDD _2426_ sky130_fd_sc_hd__nand2_1
X_6221_ _3406_ _3414_ _3422_ _3430_ VSS VSS VDD VDD _2427_
+ sky130_fd_sc_hd__nand4_4
X_6222_ _1846_ _2427_ VSS VSS VDD VDD _2428_ sky130_fd_sc_hd__nor2_1
X_6223_ _2268_ _2426_ _2428_ VSS VSS VDD VDD _2429_ sky130_fd_sc_hd__a21boi_2
X_6224_ _3469_ _2428_ VSS VSS VDD VDD _2430_ sky130_fd_sc_hd__nand2_1
X_6225_ _2335_ _2427_ _2430_ VSS VSS VDD VDD _2431_ sky130_fd_sc_hd__o21ai_0
X_6226_ _2374_ _2376_ _3413_ VSS VSS VDD VDD _2432_ sky130_fd_sc_hd__o21bai_1
X_6227_ _3406_ _2432_ _3405_ VSS VSS VDD VDD _2433_ sky130_fd_sc_hd__a21oi_2
X_6228_ _2431_ _2429_ _2433_ VSS VSS VDD VDD _2434_ sky130_fd_sc_hd__nor3b_2
X_6229_ _3398_ _2434_ VSS VSS VDD VDD _2435_ sky130_fd_sc_hd__xnor2_1
X_6230_ _3398_ _1820_ VSS VSS VDD VDD _2436_ sky130_fd_sc_hd__nand2_1
X_6231_ _3401_ _1795_ _2436_ _1956_ VSS VSS VDD VDD _2437_
+ sky130_fd_sc_hd__o211ai_2
X_6232_ _3397_ _1803_ _2435_ _1818_ _2437_ VSS VSS VDD VDD
+ _2438_ sky130_fd_sc_hd__a221oi_4
X_6233_ _2417_ _2422_ _2425_ _2438_ VSS VSS VDD VDD net74
+ sky130_fd_sc_hd__a31oi_4
X_6234_ _1031_ VSS VSS VDD VDD _3387_ sky130_fd_sc_hd__inv_1
X_6235_ net431 _2059_ VSS VSS VDD VDD _2439_ sky130_fd_sc_hd__and2_0
X_6236_ net266 _2439_ _2418_ VSS VSS VDD VDD _2440_ sky130_fd_sc_hd__o21ai_1
X_6237_ net465 _2410_ VSS VSS VDD VDD _2441_ sky130_fd_sc_hd__nor2_2
X_6238_ net431 _2056_ _2423_ VSS VSS VDD VDD _2442_ sky130_fd_sc_hd__nand3_1
X_6239_ _2066_ _2420_ _2442_ net177 VSS VSS VDD VDD _2443_
+ sky130_fd_sc_hd__o211ai_1
X_6240_ _2051_ _2441_ _2443_ VSS VSS VDD VDD _2444_ sky130_fd_sc_hd__a21oi_1
X_6241_ net431 _2279_ VSS VSS VDD VDD _2445_ sky130_fd_sc_hd__nand2_1
X_6242_ _1031_ _3407_ net466 VSS VSS VDD VDD _2446_ sky130_fd_sc_hd__mux2_1
X_6243_ _2413_ _2446_ net169 VSS VSS VDD VDD _2447_ sky130_fd_sc_hd__mux2i_2
X_6244_ _2363_ _2447_ net165 VSS VSS VDD VDD _2448_ sky130_fd_sc_hd__mux2i_1
X_6245_ net170 _2448_ VSS VSS VDD VDD _2449_ sky130_fd_sc_hd__nand2_1
X_6246_ _1955_ _2445_ _2449_ VSS VSS VDD VDD _2450_ sky130_fd_sc_hd__nand3_1
X_6247_ _3406_ VSS VSS VDD VDD _2451_ sky130_fd_sc_hd__inv_1
X_6248_ _2451_ _2399_ _3405_ VSS VSS VDD VDD _2452_ sky130_fd_sc_hd__o21bai_1
X_6249_ _2452_ _3398_ _3397_ VSS VSS VDD VDD _2453_ sky130_fd_sc_hd__a21oi_1
X_6250_ _3390_ _2453_ VSS VSS VDD VDD _2454_ sky130_fd_sc_hd__xnor2_1
X_6251_ _3390_ _1820_ VSS VSS VDD VDD _2455_ sky130_fd_sc_hd__nand2_1
X_6252_ _3393_ _1795_ _2455_ _1956_ VSS VSS VDD VDD _2456_
+ sky130_fd_sc_hd__o211ai_2
X_6253_ _3389_ net174 _2454_ _1818_ _2456_ VSS VSS VDD VDD
+ _2457_ sky130_fd_sc_hd__a221oi_4
X_6254_ _2440_ _2444_ _2450_ _2457_ VSS VSS VDD VDD net75
+ sky130_fd_sc_hd__a31oi_4
X_6255_ _3383_ VSS VSS VDD VDD _3379_ sky130_fd_sc_hd__inv_1
X_6256_ _3390_ _3398_ VSS VSS VDD VDD _2458_ sky130_fd_sc_hd__nand2_1
X_6257_ _3390_ _3397_ _3389_ VSS VSS VDD VDD _2459_ sky130_fd_sc_hd__a21oi_1
X_6258_ _2458_ _2434_ _2459_ VSS VSS VDD VDD _2460_ sky130_fd_sc_hd__o21ai_1
X_6259_ _1867_ _2460_ VSS VSS VDD VDD _2461_ sky130_fd_sc_hd__xnor2_1
X_6260_ _3382_ _1820_ VSS VSS VDD VDD _2462_ sky130_fd_sc_hd__nand2_1
X_6261_ _3385_ _1795_ _2462_ _1956_ VSS VSS VDD VDD _2463_
+ sky130_fd_sc_hd__o211ai_2
X_6262_ _3381_ net174 _2461_ _1818_ _2463_ VSS VSS VDD VDD
+ _2464_ sky130_fd_sc_hd__a221oi_4
X_6263_ _1031_ _3407_ net265 VSS VSS VDD VDD _2465_ sky130_fd_sc_hd__mux2i_1
X_6264_ _3383_ _3399_ net466 VSS VSS VDD VDD _2466_ sky130_fd_sc_hd__mux2i_1
X_6265_ _2465_ _2466_ net261 VSS VSS VDD VDD _2467_ sky130_fd_sc_hd__mux2i_2
X_6266_ net267 _2390_ VSS VSS VDD VDD _2468_ sky130_fd_sc_hd__nand2_1
X_6267_ net267 _2467_ _2468_ VSS VSS VDD VDD _2469_ sky130_fd_sc_hd__o21ai_2
X_6268_ _2310_ _2469_ net170 VSS VSS VDD VDD _2470_ sky130_fd_sc_hd__mux2i_1
X_6269_ _2084_ _2418_ _2423_ _2082_ _2441_ VSS VSS VDD VDD
+ _2471_ sky130_fd_sc_hd__a221oi_1
X_6270_ net431 _2088_ VSS VSS VDD VDD _2472_ sky130_fd_sc_hd__nor2_1
X_6271_ net439 _2189_ _1956_ VSS VSS VDD VDD _2473_ sky130_fd_sc_hd__a21oi_4
X_6272_ _2107_ _2420_ _2473_ VSS VSS VDD VDD _2474_ sky130_fd_sc_hd__o21a_1
X_6273_ _2253_ _2470_ _2471_ _2472_ _2474_ VSS VSS VDD VDD
+ _2475_ sky130_fd_sc_hd__o221a_1
X_6274_ _2464_ _2475_ VSS VSS VDD VDD net76 sky130_fd_sc_hd__nor2_1
X_6275_ _3375_ VSS VSS VDD VDD _3371_ sky130_fd_sc_hd__inv_1
X_6276_ _3375_ _1031_ net466 VSS VSS VDD VDD _2476_ sky130_fd_sc_hd__mux2i_2
X_6277_ _2466_ _2476_ net169 VSS VSS VDD VDD _2477_ sky130_fd_sc_hd__mux2_1
X_6278_ net421 _2477_ VSS VSS VDD VDD _2478_ sky130_fd_sc_hd__nor2_1
X_6279_ _1921_ _2404_ VSS VSS VDD VDD _2479_ sky130_fd_sc_hd__nor2_1
X_6280_ _2253_ _2478_ _2479_ VSS VSS VDD VDD _2480_ sky130_fd_sc_hd__nor3_1
X_6281_ _2126_ _2408_ VSS VSS VDD VDD _2481_ sky130_fd_sc_hd__nand2_1
X_6282_ _2148_ _2410_ _2481_ VSS VSS VDD VDD _2482_ sky130_fd_sc_hd__o21ai_0
X_6283_ _2480_ _2482_ net170 VSS VSS VDD VDD _2483_ sky130_fd_sc_hd__o21ai_0
X_6284_ net267 _1935_ VSS VSS VDD VDD _2484_ sky130_fd_sc_hd__nand2_1
X_6285_ net267 _1932_ net465 VSS VSS VDD VDD _2485_ sky130_fd_sc_hd__o21ai_0
X_6286_ _2484_ _2485_ _2144_ VSS VSS VDD VDD _2486_ sky130_fd_sc_hd__a21oi_1
X_6287_ _2145_ _2261_ _2146_ _2473_ VSS VSS VDD VDD _2487_
+ sky130_fd_sc_hd__o31ai_1
X_6288_ net431 _1955_ _2320_ _2486_ _2487_ VSS VSS VDD VDD
+ _2488_ sky130_fd_sc_hd__a311oi_1
X_6289_ _1866_ _1872_ VSS VSS VDD VDD _2489_ sky130_fd_sc_hd__nand2_1
X_6290_ _1874_ _2489_ VSS VSS VDD VDD _2490_ sky130_fd_sc_hd__xnor2_2
X_6291_ _3374_ _1820_ VSS VSS VDD VDD _2491_ sky130_fd_sc_hd__nand2_1
X_6292_ _3377_ _1795_ _2491_ _1956_ VSS VSS VDD VDD _2492_
+ sky130_fd_sc_hd__o211ai_2
X_6293_ _3373_ net174 _2490_ _1818_ _2492_ VSS VSS VDD VDD
+ _2493_ sky130_fd_sc_hd__a221oi_4
X_6294_ _2483_ _2488_ _2493_ VSS VSS VDD VDD net78 sky130_fd_sc_hd__a21oi_4
X_6295_ _3367_ VSS VSS VDD VDD _3363_ sky130_fd_sc_hd__inv_1
X_6296_ _2175_ _2441_ VSS VSS VDD VDD _2494_ sky130_fd_sc_hd__nand2b_1
X_6297_ net166 _2423_ VSS VSS VDD VDD _2495_ sky130_fd_sc_hd__nand2_1
X_6298_ _2495_ _1970_ VSS VSS VDD VDD _2496_ sky130_fd_sc_hd__nor2b_1
X_6299_ _2253_ _2350_ VSS VSS VDD VDD _2497_ sky130_fd_sc_hd__nor2_1
X_6300_ _2496_ _2497_ net431 VSS VSS VDD VDD _2498_ sky130_fd_sc_hd__o21ai_0
X_6301_ _2178_ _2418_ VSS VSS VDD VDD _2499_ sky130_fd_sc_hd__nand2b_1
X_6302_ _2473_ _2498_ _2499_ VSS VSS VDD VDD _2500_ sky130_fd_sc_hd__and3_1
X_6303_ _3367_ _3383_ _1754_ VSS VSS VDD VDD _2501_ sky130_fd_sc_hd__mux2i_2
X_6304_ _2476_ _2501_ net251 VSS VSS VDD VDD _2502_ sky130_fd_sc_hd__mux2i_4
X_6305_ net166 _2414_ VSS VSS VDD VDD _2503_ sky130_fd_sc_hd__nor2_1
X_6306_ net166 _2502_ _2503_ _2253_ VSS VSS VDD VDD _2504_
+ sky130_fd_sc_hd__a211oi_2
X_6307_ _2165_ _2408_ _2504_ VSS VSS VDD VDD _2505_ sky130_fd_sc_hd__a21o_1
X_6308_ net171 _2505_ VSS VSS VDD VDD _2506_ sky130_fd_sc_hd__nand2_1
X_6309_ _3366_ _1820_ VSS VSS VDD VDD _2507_ sky130_fd_sc_hd__nand2_1
X_6310_ _3369_ _1795_ _2507_ _1956_ VSS VSS VDD VDD _2508_
+ sky130_fd_sc_hd__o211ai_2
X_6311_ _3365_ net173 _2508_ VSS VSS VDD VDD _2509_ sky130_fd_sc_hd__a21oi_4
X_6312_ _3390_ _3374_ _3382_ _3398_ VSS VSS VDD VDD _2510_
+ sky130_fd_sc_hd__nand4_1
X_6313_ _1867_ _2459_ _3381_ VSS VSS VDD VDD _2511_ sky130_fd_sc_hd__o21bai_1
X_6314_ _3374_ _2511_ _3373_ VSS VSS VDD VDD _2512_ sky130_fd_sc_hd__a21oi_1
X_6315_ _2433_ _2510_ _2512_ VSS VSS VDD VDD _2513_ sky130_fd_sc_hd__o21ai_1
X_6316_ _2336_ _2335_ _2427_ _2510_ VSS VSS VDD VDD _2514_
+ sky130_fd_sc_hd__a211oi_2
X_6317_ _3366_ _2513_ _2514_ VSS VSS VDD VDD _2515_ sky130_fd_sc_hd__nor3_1
X_6318_ _2513_ _2514_ _3366_ VSS VSS VDD VDD _2516_ sky130_fd_sc_hd__o21ai_0
X_6319_ _1824_ _2515_ _2516_ VSS VSS VDD VDD _2517_ sky130_fd_sc_hd__or3b_4
X_6320_ _2494_ _2500_ _2506_ _2517_ _2509_ VSS VSS VDD VDD
+ net79 sky130_fd_sc_hd__a32oi_4
X_6321_ _3359_ VSS VSS VDD VDD _3355_ sky130_fd_sc_hd__inv_1
X_6322_ _1927_ net166 net407 _2144_ VSS VSS VDD VDD _2518_
+ sky130_fd_sc_hd__a31oi_1
X_6323_ _2441_ _2518_ _2184_ VSS VSS VDD VDD _2519_ sky130_fd_sc_hd__o21ai_1
X_6324_ net437 _2190_ _2189_ VSS VSS VDD VDD _2520_ sky130_fd_sc_hd__o21ai_0
X_6325_ _2057_ _2146_ _2520_ VSS VSS VDD VDD _2521_ sky130_fd_sc_hd__o21ai_0
X_6326_ net171 _2253_ _2364_ VSS VSS VDD VDD _2522_ sky130_fd_sc_hd__nor3_1
X_6327_ _2385_ _2521_ _2522_ VSS VSS VDD VDD _2523_ sky130_fd_sc_hd__a21oi_1
X_6328_ net165 _2447_ VSS VSS VDD VDD _2524_ sky130_fd_sc_hd__nor2_1
X_6329_ _3359_ _3375_ _1754_ VSS VSS VDD VDD _2525_ sky130_fd_sc_hd__mux2i_1
X_6330_ _2501_ _2525_ net169 VSS VSS VDD VDD _2526_ sky130_fd_sc_hd__mux2_1
X_6331_ net421 _2526_ VSS VSS VDD VDD _2527_ sky130_fd_sc_hd__nor2_1
X_6332_ net441 _2524_ _2527_ VSS VSS VDD VDD _2528_ sky130_fd_sc_hd__nor3_2
X_6333_ _1927_ _2200_ VSS VSS VDD VDD _2529_ sky130_fd_sc_hd__nor2_1
X_6334_ _2528_ _2529_ net171 _1990_ VSS VSS VDD VDD _2530_
+ sky130_fd_sc_hd__o211ai_2
X_6335_ _2489_ _3374_ _3373_ VSS VSS VDD VDD _2531_ sky130_fd_sc_hd__a21oi_1
X_6336_ _2531_ _3366_ VSS VSS VDD VDD _2532_ sky130_fd_sc_hd__nor2b_1
X_6337_ _3365_ _2532_ VSS VSS VDD VDD _2533_ sky130_fd_sc_hd__nor2_1
X_6338_ _2533_ _3358_ VSS VSS VDD VDD _2534_ sky130_fd_sc_hd__xnor2_1
X_6339_ _3358_ _1820_ VSS VSS VDD VDD _2535_ sky130_fd_sc_hd__nand2_1
X_6340_ _3361_ _1795_ _2535_ _1956_ VSS VSS VDD VDD _2536_
+ sky130_fd_sc_hd__o211ai_2
X_6341_ _3357_ net173 _2534_ _1818_ _2536_ VSS VSS VDD VDD
+ _2537_ sky130_fd_sc_hd__a221oi_4
X_6342_ net177 _2519_ _2523_ _2530_ _2537_ VSS VSS VDD VDD
+ net80 sky130_fd_sc_hd__a41oi_4
X_6343_ _3351_ VSS VSS VDD VDD _3347_ sky130_fd_sc_hd__inv_1
X_6344_ _3353_ _1795_ VSS VSS VDD VDD _2538_ sky130_fd_sc_hd__nor2_1
X_6345_ _3350_ _1820_ _2538_ VSS VSS VDD VDD _2539_ sky130_fd_sc_hd__a21oi_1
X_6346_ _3349_ net174 net176 VSS VSS VDD VDD _2540_ sky130_fd_sc_hd__a21oi_1
X_6347_ _3366_ _2513_ _3365_ VSS VSS VDD VDD _2541_ sky130_fd_sc_hd__a21o_1
X_6348_ _3358_ _2541_ _3357_ VSS VSS VDD VDD _2542_ sky130_fd_sc_hd__a21oi_2
X_6349_ _3358_ _3366_ VSS VSS VDD VDD _2543_ sky130_fd_sc_hd__nand2_1
X_6350_ _2336_ _2335_ _2427_ _2510_ _2543_ VSS VSS VDD VDD
+ _2544_ sky130_fd_sc_hd__a2111o_1
X_6351_ _2542_ _2544_ _3350_ VSS VSS VDD VDD _2545_ sky130_fd_sc_hd__a21oi_1
X_6352_ _3350_ _2542_ _2544_ VSS VSS VDD VDD _2546_ sky130_fd_sc_hd__and3_1
X_6353_ _2545_ _2546_ _1818_ VSS VSS VDD VDD _2547_ sky130_fd_sc_hd__o21ai_1
X_6354_ net166 _2080_ _2423_ net170 VSS VSS VDD VDD _2548_
+ sky130_fd_sc_hd__a31oi_1
X_6355_ _2261_ _2548_ _2144_ VSS VSS VDD VDD _2549_ sky130_fd_sc_hd__o21ai_0
X_6356_ net431 _2208_ _2549_ VSS VSS VDD VDD _2550_ sky130_fd_sc_hd__o21a_1
X_6357_ _3351_ _3367_ net265 VSS VSS VDD VDD _2551_ sky130_fd_sc_hd__mux2i_2
X_6358_ _2525_ _2551_ net250 VSS VSS VDD VDD _2552_ sky130_fd_sc_hd__mux2i_2
X_6359_ _2467_ _2552_ net165 VSS VSS VDD VDD _2553_ sky130_fd_sc_hd__mux2i_2
X_6360_ _2391_ _2553_ net170 VSS VSS VDD VDD _2554_ sky130_fd_sc_hd__mux2i_1
X_6361_ net170 _2408_ VSS VSS VDD VDD _2555_ sky130_fd_sc_hd__nand2_1
X_6362_ _2253_ _2554_ _2555_ _2216_ _2473_ VSS VSS VDD VDD
+ _2556_ sky130_fd_sc_hd__o221ai_1
X_6363_ _2550_ _2556_ VSS VSS VDD VDD _2557_ sky130_fd_sc_hd__nor2_1
X_6364_ _2539_ _2547_ _2540_ _2557_ VSS VSS VDD VDD net81
+ sky130_fd_sc_hd__a31oi_4
X_6365_ _3343_ VSS VSS VDD VDD _3339_ sky130_fd_sc_hd__inv_1
X_6366_ _1890_ _2405_ VSS VSS VDD VDD _2558_ sky130_fd_sc_hd__nor2_1
X_6367_ _3343_ _3359_ net466 VSS VSS VDD VDD _2559_ sky130_fd_sc_hd__mux2i_2
X_6368_ _2551_ _2559_ net263 VSS VSS VDD VDD _2560_ sky130_fd_sc_hd__mux2i_2
X_6369_ net165 _2477_ VSS VSS VDD VDD _2561_ sky130_fd_sc_hd__nor2_1
X_6370_ net165 _2560_ _2561_ _1652_ VSS VSS VDD VDD _2562_
+ sky130_fd_sc_hd__a211oi_1
X_6371_ _2558_ _2562_ _1990_ VSS VSS VDD VDD _2563_ sky130_fd_sc_hd__o21ai_0
X_6372_ _1990_ _2244_ _2563_ VSS VSS VDD VDD _2564_ sky130_fd_sc_hd__o21ai_0
X_6373_ _1949_ _2239_ net266 VSS VSS VDD VDD _2565_ sky130_fd_sc_hd__o21ai_0
X_6374_ net266 _2564_ _2565_ VSS VSS VDD VDD _2566_ sky130_fd_sc_hd__o21ai_2
X_6375_ _1873_ _1877_ _3349_ VSS VSS VDD VDD _2567_ sky130_fd_sc_hd__a21oi_1
X_6376_ _3342_ _2567_ VSS VSS VDD VDD _2568_ sky130_fd_sc_hd__xnor2_1
X_6377_ _3341_ net173 VSS VSS VDD VDD _2569_ sky130_fd_sc_hd__nand2_1
X_6378_ _3345_ _1795_ _2569_ _1956_ VSS VSS VDD VDD _2570_
+ sky130_fd_sc_hd__o211ai_2
X_6379_ _3342_ _1820_ _1818_ _2568_ _2570_ VSS VSS VDD VDD
+ _2571_ sky130_fd_sc_hd__a221oi_4
X_6380_ _2473_ _2566_ _2571_ VSS VSS VDD VDD net82 sky130_fd_sc_hd__a21oi_4
X_6381_ _3335_ VSS VSS VDD VDD _3331_ sky130_fd_sc_hd__inv_1
X_6382_ _2259_ _2408_ VSS VSS VDD VDD _2572_ sky130_fd_sc_hd__nand2_1
X_6383_ _1927_ net170 _0274_ VSS VSS VDD VDD _2573_ sky130_fd_sc_hd__a21oi_1
X_6384_ net443 net465 _1977_ VSS VSS VDD VDD _2574_ sky130_fd_sc_hd__nor3_1
X_6385_ _2573_ _2574_ _2143_ VSS VSS VDD VDD _2575_ sky130_fd_sc_hd__o21ai_1
X_6386_ net267 _2502_ VSS VSS VDD VDD _2576_ sky130_fd_sc_hd__nand2_1
X_6387_ _3335_ _3351_ _1754_ VSS VSS VDD VDD _2577_ sky130_fd_sc_hd__mux2i_1
X_6388_ _2559_ _2577_ net249 VSS VSS VDD VDD _2578_ sky130_fd_sc_hd__mux2i_2
X_6389_ net165 _2578_ VSS VSS VDD VDD _2579_ sky130_fd_sc_hd__nand2_1
X_6390_ net170 _2415_ VSS VSS VDD VDD _2580_ sky130_fd_sc_hd__nor2_1
X_6391_ net170 _2576_ _2579_ _2580_ VSS VSS VDD VDD _2581_
+ sky130_fd_sc_hd__a31oi_1
X_6392_ _1972_ _2264_ _2581_ _1949_ VSS VSS VDD VDD _2582_
+ sky130_fd_sc_hd__o22ai_1
X_6393_ _1927_ _2582_ VSS VSS VDD VDD _2583_ sky130_fd_sc_hd__nand2_1
X_6394_ _3334_ VSS VSS VDD VDD _2584_ sky130_fd_sc_hd__inv_1
X_6395_ _3342_ _3350_ VSS VSS VDD VDD _2585_ sky130_fd_sc_hd__nand2_1
X_6396_ _2543_ _2585_ VSS VSS VDD VDD _2586_ sky130_fd_sc_hd__nor2_1
X_6397_ _2513_ _2514_ _2586_ VSS VSS VDD VDD _2587_ sky130_fd_sc_hd__o21ai_1
X_6398_ _3358_ _3365_ _3357_ VSS VSS VDD VDD _2588_ sky130_fd_sc_hd__a21o_1
X_6399_ _3350_ _2588_ _3349_ VSS VSS VDD VDD _2589_ sky130_fd_sc_hd__a21o_1
X_6400_ _3342_ _2589_ _3341_ VSS VSS VDD VDD _2590_ sky130_fd_sc_hd__a21oi_1
X_6401_ _2584_ _2587_ _2590_ VSS VSS VDD VDD _2591_ sky130_fd_sc_hd__nand3_1
X_6402_ _2587_ _2590_ _2584_ VSS VSS VDD VDD _2592_ sky130_fd_sc_hd__a21o_1
X_6403_ _3334_ _1820_ VSS VSS VDD VDD _2593_ sky130_fd_sc_hd__nand2_1
X_6404_ _3333_ net173 net176 VSS VSS VDD VDD _2594_ sky130_fd_sc_hd__a21oi_1
X_6405_ _3337_ _1795_ _2593_ _2594_ VSS VSS VDD VDD _2595_
+ sky130_fd_sc_hd__o211ai_2
X_6406_ _1818_ _2591_ _2592_ _2595_ VSS VSS VDD VDD _2596_
+ sky130_fd_sc_hd__a31oi_4
X_6407_ net177 _2572_ _2575_ _2583_ _2596_ VSS VSS VDD VDD
+ net83 sky130_fd_sc_hd__a41oi_4
X_6408_ _0621_ VSS VSS VDD VDD _3323_ sky130_fd_sc_hd__inv_1
X_6409_ _0621_ _3343_ _1754_ VSS VSS VDD VDD _2597_ sky130_fd_sc_hd__mux2i_1
X_6410_ _2577_ _2597_ net247 VSS VSS VDD VDD _2598_ sky130_fd_sc_hd__mux2_1
X_6411_ _2526_ _2598_ net165 VSS VSS VDD VDD _2599_ sky130_fd_sc_hd__mux2i_1
X_6412_ _2448_ _2599_ net170 VSS VSS VDD VDD _2600_ sky130_fd_sc_hd__mux2_1
X_6413_ _1949_ _2600_ _2287_ VSS VSS VDD VDD _2601_ sky130_fd_sc_hd__o21ai_0
X_6414_ _1927_ _2601_ VSS VSS VDD VDD _2602_ sky130_fd_sc_hd__nand2_1
X_6415_ _2280_ _2408_ VSS VSS VDD VDD _2603_ sky130_fd_sc_hd__nand2b_1
X_6416_ _3326_ _1878_ _1880_ VSS VSS VDD VDD _2604_ sky130_fd_sc_hd__nor3_1
X_6417_ _1878_ _1880_ _3326_ VSS VSS VDD VDD _2605_ sky130_fd_sc_hd__o21ai_0
X_6418_ _2604_ _2605_ VSS VSS VDD VDD _2606_ sky130_fd_sc_hd__nand2b_4
X_6419_ _3326_ _1820_ VSS VSS VDD VDD _2607_ sky130_fd_sc_hd__nand2_1
X_6420_ _3329_ _1795_ _2607_ _1956_ VSS VSS VDD VDD _2608_
+ sky130_fd_sc_hd__o211ai_2
X_6421_ _3325_ net174 _2606_ _1818_ _2608_ VSS VSS VDD VDD
+ _2609_ sky130_fd_sc_hd__a221oi_4
X_6422_ _2473_ _2602_ _2603_ _2609_ VSS VSS VDD VDD net84
+ sky130_fd_sc_hd__a31oi_4
X_6423_ _3318_ _1820_ VSS VSS VDD VDD _2610_ sky130_fd_sc_hd__nand2_1
X_6424_ _3317_ net173 net176 VSS VSS VDD VDD _2611_ sky130_fd_sc_hd__a21oi_1
X_6425_ _3321_ _1795_ _2610_ _2611_ VSS VSS VDD VDD _2612_
+ sky130_fd_sc_hd__o211ai_1
X_6426_ _3342_ _3349_ _3341_ VSS VSS VDD VDD _2613_ sky130_fd_sc_hd__a21oi_1
X_6427_ _2584_ _2613_ VSS VSS VDD VDD _2614_ sky130_fd_sc_hd__nor2_1
X_6428_ _3342_ _3334_ _3350_ VSS VSS VDD VDD _2615_ sky130_fd_sc_hd__nand3_1
X_6429_ _2542_ _2544_ _2615_ VSS VSS VDD VDD _2616_ sky130_fd_sc_hd__a21oi_1
X_6430_ _3333_ _2614_ _2616_ _3326_ VSS VSS VDD VDD _2617_
+ sky130_fd_sc_hd__o31ai_1
X_6431_ _3318_ _3325_ VSS VSS VDD VDD _2618_ sky130_fd_sc_hd__nor2_1
X_6432_ _2544_ _2542_ _2615_ _1881_ VSS VSS VDD VDD _2619_
+ sky130_fd_sc_hd__a211oi_4
X_6433_ _3333_ _2614_ VSS VSS VDD VDD _2620_ sky130_fd_sc_hd__nor2_1
X_6434_ _3318_ _3325_ VSS VSS VDD VDD _2621_ sky130_fd_sc_hd__nand2_1
X_6435_ _1881_ _2620_ _2621_ VSS VSS VDD VDD _2622_ sky130_fd_sc_hd__o21ai_1
X_6436_ _1824_ _2619_ _2622_ VSS VSS VDD VDD _2623_ sky130_fd_sc_hd__or3_1
X_6437_ _2617_ _2618_ _2623_ VSS VSS VDD VDD _2624_ sky130_fd_sc_hd__a21oi_2
X_6438_ _3319_ _3335_ net265 VSS VSS VDD VDD _2625_ sky130_fd_sc_hd__mux2i_1
X_6439_ _2597_ _2625_ net263 VSS VSS VDD VDD _2626_ sky130_fd_sc_hd__mux2i_1
X_6440_ net165 _2626_ VSS VSS VDD VDD _2627_ sky130_fd_sc_hd__nand2_1
X_6441_ net267 _2552_ VSS VSS VDD VDD _2628_ sky130_fd_sc_hd__nand2_1
X_6442_ net170 _2627_ _2628_ VSS VSS VDD VDD _2629_ sky130_fd_sc_hd__and3_1
X_6443_ net465 _2469_ _2629_ VSS VSS VDD VDD _2630_ sky130_fd_sc_hd__a21oi_1
X_6444_ net170 _2308_ VSS VSS VDD VDD _2631_ sky130_fd_sc_hd__nand2_1
X_6445_ net170 _2107_ _2631_ VSS VSS VDD VDD _2632_ sky130_fd_sc_hd__o21ai_0
X_6446_ _2214_ _2555_ VSS VSS VDD VDD _2633_ sky130_fd_sc_hd__nor2_1
X_6447_ _1927_ _2080_ _2263_ _2633_ VSS VSS VDD VDD _2634_
+ sky130_fd_sc_hd__a31oi_1
X_6448_ net165 _2634_ VSS VSS VDD VDD _2635_ sky130_fd_sc_hd__nor2_1
X_6449_ net165 _2408_ _2632_ _2635_ VSS VSS VDD VDD _2636_
+ sky130_fd_sc_hd__a31oi_2
X_6450_ _1927_ _1954_ VSS VSS VDD VDD _2637_ sky130_fd_sc_hd__nand2_1
X_6451_ _1990_ _2079_ _2637_ VSS VSS VDD VDD _2638_ sky130_fd_sc_hd__nor3_1
X_6452_ _2189_ _2637_ _2638_ VSS VSS VDD VDD _2639_ sky130_fd_sc_hd__a21oi_1
X_6453_ _2253_ _2630_ _2636_ _2639_ net176 VSS VSS VDD VDD
+ _2640_ sky130_fd_sc_hd__o2111ai_4
X_6454_ _2612_ _2624_ _2640_ VSS VSS VDD VDD net85 sky130_fd_sc_hd__o21a_4
X_6455_ _3311_ VSS VSS VDD VDD _3307_ sky130_fd_sc_hd__inv_1
X_6456_ _3313_ _1795_ VSS VSS VDD VDD _2641_ sky130_fd_sc_hd__nor2_1
X_6457_ _3310_ _1820_ _2641_ VSS VSS VDD VDD _2642_ sky130_fd_sc_hd__a21oi_1
X_6458_ _3309_ net173 net176 VSS VSS VDD VDD _2643_ sky130_fd_sc_hd__a21oi_1
X_6459_ _3310_ _1883_ VSS VSS VDD VDD _2644_ sky130_fd_sc_hd__xor2_1
X_6460_ _1818_ _2644_ VSS VSS VDD VDD _2645_ sky130_fd_sc_hd__nand2_1
X_6461_ _3311_ _0621_ net265 VSS VSS VDD VDD _2646_ sky130_fd_sc_hd__mux2i_1
X_6462_ _0140_ _2646_ VSS VSS VDD VDD _2647_ sky130_fd_sc_hd__nor2_1
X_6463_ net263 _2625_ VSS VSS VDD VDD _2648_ sky130_fd_sc_hd__nor2_1
X_6464_ _2647_ _2648_ VSS VSS VDD VDD _2649_ sky130_fd_sc_hd__nor2_1
X_6465_ net165 _2560_ VSS VSS VDD VDD _2650_ sky130_fd_sc_hd__nor2_1
X_6466_ net165 _2649_ _2650_ VSS VSS VDD VDD _2651_ sky130_fd_sc_hd__a21oi_1
X_6467_ _2145_ _2495_ _2651_ _2253_ VSS VSS VDD VDD _2652_
+ sky130_fd_sc_hd__o22ai_2
X_6468_ net442 _1990_ VSS VSS VDD VDD _2653_ sky130_fd_sc_hd__nand2_1
X_6469_ _2321_ _2653_ VSS VSS VDD VDD _2654_ sky130_fd_sc_hd__nor2_1
X_6470_ _2145_ _0274_ _2637_ VSS VSS VDD VDD _2655_ sky130_fd_sc_hd__mux2i_1
X_6471_ net465 _2480_ _2655_ _2143_ _1956_ VSS VSS VDD VDD
+ _2656_ sky130_fd_sc_hd__a221o_1
X_6472_ net170 _2652_ _2654_ _2656_ VSS VSS VDD VDD _2657_
+ sky130_fd_sc_hd__a211oi_4
X_6473_ _2642_ _2645_ _2643_ _2657_ VSS VSS VDD VDD net86
+ sky130_fd_sc_hd__a31oi_4
X_6474_ _3303_ VSS VSS VDD VDD _3299_ sky130_fd_sc_hd__inv_1
X_6475_ _3302_ _3310_ _1818_ VSS VSS VDD VDD _2658_ sky130_fd_sc_hd__nand3b_1
X_6476_ _3309_ _1818_ _3302_ VSS VSS VDD VDD _2659_ sky130_fd_sc_hd__nand3b_1
X_6477_ _3317_ _2619_ _2622_ VSS VSS VDD VDD _2660_ sky130_fd_sc_hd__nor3_2
X_6478_ _2658_ _2659_ _2660_ VSS VSS VDD VDD _2661_ sky130_fd_sc_hd__mux2i_2
X_6479_ _3310_ _3309_ VSS VSS VDD VDD _2662_ sky130_fd_sc_hd__nor2_1
X_6480_ _3309_ _2662_ _3302_ VSS VSS VDD VDD _2663_ sky130_fd_sc_hd__mux2i_1
X_6481_ _3301_ net173 net176 VSS VSS VDD VDD _2664_ sky130_fd_sc_hd__a21oi_1
X_6482_ _3305_ _1795_ VSS VSS VDD VDD _2665_ sky130_fd_sc_hd__nor2_1
X_6483_ _3302_ _1820_ _2665_ VSS VSS VDD VDD _2666_ sky130_fd_sc_hd__a21oi_1
X_6484_ _1824_ _2663_ _2664_ _2666_ VSS VSS VDD VDD _2667_
+ sky130_fd_sc_hd__o211ai_2
X_6485_ _2496_ _2504_ net431 VSS VSS VDD VDD _2668_ sky130_fd_sc_hd__mux2i_1
X_6486_ net265 _2637_ _0274_ VSS VSS VDD VDD _2669_ sky130_fd_sc_hd__o21ai_0
X_6487_ net265 _1974_ _2637_ _2669_ _2143_ VSS VSS VDD VDD
+ _2670_ sky130_fd_sc_hd__o311ai_0
X_6488_ net267 _2578_ VSS VSS VDD VDD _2671_ sky130_fd_sc_hd__nand2_1
X_6489_ _3303_ _3319_ net265 VSS VSS VDD VDD _2672_ sky130_fd_sc_hd__mux2i_1
X_6490_ net252 _2672_ VSS VSS VDD VDD _2673_ sky130_fd_sc_hd__nand2_1
X_6491_ _0140_ _2646_ VSS VSS VDD VDD _2674_ sky130_fd_sc_hd__nand2_1
X_6492_ net165 _2673_ _2674_ VSS VSS VDD VDD _2675_ sky130_fd_sc_hd__nand3_1
X_6493_ net170 _1955_ _2671_ _2675_ VSS VSS VDD VDD _2676_
+ sky130_fd_sc_hd__nand4_1
X_6494_ net176 _2670_ _2676_ VSS VSS VDD VDD _2677_ sky130_fd_sc_hd__nand3_1
X_6495_ _2352_ _2408_ _2677_ VSS VSS VDD VDD _2678_ sky130_fd_sc_hd__a21oi_1
X_6496_ _2668_ _2678_ VSS VSS VDD VDD _2679_ sky130_fd_sc_hd__nand2_2
X_6497_ _2667_ _2661_ _2679_ VSS VSS VDD VDD _2680_ sky130_fd_sc_hd__o21ai_4
X_6498_ _2680_ VSS VSS VDD VDD net87 sky130_fd_sc_hd__inv_1
X_6499_ _0371_ VSS VSS VDD VDD _3291_ sky130_fd_sc_hd__inv_1
X_6500_ _1990_ _2365_ _2418_ VSS VSS VDD VDD _2681_ sky130_fd_sc_hd__a21oi_1
X_6501_ _1927_ _2360_ _2681_ VSS VSS VDD VDD _2682_ sky130_fd_sc_hd__a21oi_1
X_6502_ _2524_ _2527_ VSS VSS VDD VDD _2683_ sky130_fd_sc_hd__nor2_1
X_6503_ _1652_ _2683_ VSS VSS VDD VDD _2684_ sky130_fd_sc_hd__nand2_1
X_6504_ _0140_ _2672_ VSS VSS VDD VDD _2685_ sky130_fd_sc_hd__nand2_1
X_6505_ _0371_ _3311_ net265 VSS VSS VDD VDD _2686_ sky130_fd_sc_hd__mux2i_1
X_6506_ net263 _2686_ VSS VSS VDD VDD _2687_ sky130_fd_sc_hd__nand2_1
X_6507_ net165 _2598_ VSS VSS VDD VDD _2688_ sky130_fd_sc_hd__nor2_1
X_6508_ net165 _2685_ _2687_ _2688_ _1652_ VSS VSS VDD VDD
+ _2689_ sky130_fd_sc_hd__a311o_1
X_6509_ _2684_ _2689_ _2253_ VSS VSS VDD VDD _2690_ sky130_fd_sc_hd__a21oi_1
X_6510_ net431 _2057_ _2495_ VSS VSS VDD VDD _2691_ sky130_fd_sc_hd__nor3_1
X_6511_ _1956_ _2682_ _2690_ _2691_ VSS VSS VDD VDD _2692_
+ sky130_fd_sc_hd__or4_2
X_6512_ _1885_ _3294_ VSS VSS VDD VDD _2693_ sky130_fd_sc_hd__xnor2_1
X_6513_ _3294_ _1820_ VSS VSS VDD VDD _2694_ sky130_fd_sc_hd__nand2_1
X_6514_ _3297_ _1795_ _2694_ VSS VSS VDD VDD _2695_ sky130_fd_sc_hd__o21ai_0
X_6515_ _3293_ net174 _2695_ net176 VSS VSS VDD VDD _2696_
+ sky130_fd_sc_hd__a211oi_1
X_6516_ _1824_ _2693_ _2696_ VSS VSS VDD VDD _2697_ sky130_fd_sc_hd__o21ai_1
X_6517_ _2692_ _2697_ VSS VSS VDD VDD net89 sky130_fd_sc_hd__and2_4
X_6518_ _3310_ _3317_ _3309_ VSS VSS VDD VDD _2698_ sky130_fd_sc_hd__a21o_1
X_6519_ _3302_ _2698_ _3301_ VSS VSS VDD VDD _2699_ sky130_fd_sc_hd__a21oi_1
X_6520_ _3293_ _2699_ _3286_ VSS VSS VDD VDD _2700_ sky130_fd_sc_hd__nand3b_1
X_6521_ _2619_ _2622_ _2700_ VSS VSS VDD VDD _2701_ sky130_fd_sc_hd__nor3_2
X_6522_ _3302_ _3310_ VSS VSS VDD VDD _2702_ sky130_fd_sc_hd__nand2_1
X_6523_ _2702_ _2699_ VSS VSS VDD VDD _2703_ sky130_fd_sc_hd__nand2_1
X_6524_ _3294_ _2703_ _3293_ VSS VSS VDD VDD _2704_ sky130_fd_sc_hd__a21o_1
X_6525_ _2699_ _3294_ VSS VSS VDD VDD _2705_ sky130_fd_sc_hd__nor2b_1
X_6526_ _3286_ _3293_ _2705_ VSS VSS VDD VDD _2706_ sky130_fd_sc_hd__nor3_1
X_6527_ _3286_ _2704_ _2706_ VSS VSS VDD VDD _2707_ sky130_fd_sc_hd__a21oi_1
X_6528_ _2702_ _3286_ _3294_ VSS VSS VDD VDD _2708_ sky130_fd_sc_hd__nor3b_1
X_6529_ _2619_ _2622_ _2708_ VSS VSS VDD VDD _2709_ sky130_fd_sc_hd__o21a_1
X_6530_ _2701_ _2707_ _2709_ VSS VSS VDD VDD _2710_ sky130_fd_sc_hd__nor3_1
X_6531_ _1824_ _2710_ VSS VSS VDD VDD _2711_ sky130_fd_sc_hd__nor2_1
X_6532_ _3286_ _1820_ VSS VSS VDD VDD _2712_ sky130_fd_sc_hd__nand2_1
X_6533_ _3285_ net174 net176 VSS VSS VDD VDD _2713_ sky130_fd_sc_hd__a21oi_1
X_6534_ _3289_ _1795_ _2712_ _2713_ VSS VSS VDD VDD _2714_
+ sky130_fd_sc_hd__o211ai_1
X_6535_ _0274_ _3303_ net265 VSS VSS VDD VDD _2715_ sky130_fd_sc_hd__mux2i_1
X_6536_ _2686_ _2715_ net256 VSS VSS VDD VDD _2716_ sky130_fd_sc_hd__mux2i_1
X_6537_ _2626_ _2716_ net165 VSS VSS VDD VDD _2717_ sky130_fd_sc_hd__mux2i_1
X_6538_ _2553_ _2717_ net170 VSS VSS VDD VDD _2718_ sky130_fd_sc_hd__mux2i_2
X_6539_ _0140_ _1652_ net265 _2495_ _2188_ VSS VSS VDD VDD
+ _2719_ sky130_fd_sc_hd__o41ai_1
X_6540_ _3284_ _2719_ _1956_ VSS VSS VDD VDD _2720_ sky130_fd_sc_hd__a21oi_1
X_6541_ _2392_ _2653_ _2718_ _2253_ _2720_ VSS VSS VDD VDD
+ _2721_ sky130_fd_sc_hd__o221ai_4
X_6542_ _2714_ _2711_ _2721_ VSS VSS VDD VDD net90 sky130_fd_sc_hd__o21a_2
X_6543_ net31 net30 VSS VSS VDD VDD _2722_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_1_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6545_ _0035_ _0037_ _0041_ _0130_ net202 VSS VSS VDD VDD
+ _2724_ sky130_fd_sc_hd__a311oi_4
X_6546_ _2724_ net32 VSS VSS VDD VDD _2725_ sky130_fd_sc_hd__nor2b_4
X_6547_ net2 _2725_ net3 VSS VSS VDD VDD _2726_ sky130_fd_sc_hd__nand3b_4
X_6548_ _2722_ _2726_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__nor2_8
X_6549_ net30 net31 VSS VSS VDD VDD _2727_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_1_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6551_ net32 _2724_ VSS VSS VDD VDD _2729_ sky130_fd_sc_hd__nor2_4
X_6552_ net3 net2 VSS VSS VDD VDD _2730_ sky130_fd_sc_hd__nor2_2
X_6553_ _2729_ _2730_ VSS VSS VDD VDD _2731_ sky130_fd_sc_hd__nand2_4
X_6554_ _2727_ _2731_ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__nor2_8
X_6555_ net31 net30 VSS VSS VDD VDD _2732_ sky130_fd_sc_hd__nand2_8
X_6556_ net3 net2 _2729_ VSS VSS VDD VDD _2733_ sky130_fd_sc_hd__nand3b_4
X_6557_ _2732_ _2733_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__nor2_8
X_6558_ _2727_ _2733_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__nor2_8
X_6559_ net31 net30 VSS VSS VDD VDD _2734_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_1_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6561_ _2733_ _2734_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__nor2_8
X_6562_ net2 _2729_ net3 VSS VSS VDD VDD _2736_ sky130_fd_sc_hd__nand3b_4
X_6563_ _2732_ _2736_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__nor2_8
X_6564_ _2722_ _2733_ VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__nor2_8
X_6565_ _2727_ _2736_ VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__nor2_8
X_6566_ _2734_ _2736_ VSS VSS VDD VDD _0007_ sky130_fd_sc_hd__nor2_8
X_6567_ _2725_ _2730_ VSS VSS VDD VDD _2737_ sky130_fd_sc_hd__nand2_8
X_6568_ _2732_ _2737_ VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__nor2_8
X_6569_ _2722_ _2736_ VSS VSS VDD VDD _0006_ sky130_fd_sc_hd__nor2_8
X_6570_ _2727_ _2737_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__nor2_8
X_6571_ _2734_ _2737_ VSS VSS VDD VDD _0026_ sky130_fd_sc_hd__nor2_8
X_6572_ net3 net2 _2725_ VSS VSS VDD VDD _2738_ sky130_fd_sc_hd__nand3b_4
X_6573_ _2732_ _2738_ VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__nor2_8
X_6574_ _2722_ _2737_ VSS VSS VDD VDD _0025_ sky130_fd_sc_hd__nor2_8
X_6575_ _2727_ _2738_ VSS VSS VDD VDD _0004_ sky130_fd_sc_hd__nor2_8
X_6576_ _2734_ _2738_ VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__nor2_8
X_6577_ _2731_ _2732_ VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__nor2_8
X_6578_ _2722_ _2738_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__nor2_8
X_6579_ _2731_ _2734_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__nor2_8
X_6580_ net3 net2 _2725_ VSS VSS VDD VDD _2739_ sky130_fd_sc_hd__nand3_4
X_6581_ _2732_ _2739_ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__nor2_8
X_6582_ _2727_ _2739_ VSS VSS VDD VDD _0022_ sky130_fd_sc_hd__nor2_8
X_6583_ _2734_ _2739_ VSS VSS VDD VDD _0020_ sky130_fd_sc_hd__nor2_8
X_6584_ net3 net2 _2729_ VSS VSS VDD VDD _2740_ sky130_fd_sc_hd__nand3_4
X_6585_ _2734_ _2740_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__nor2_8
X_6586_ _2722_ _2739_ VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__nor2_8
X_6587_ _2727_ _2740_ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__nor2_8
X_6588_ _2732_ _2740_ VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__nor2_8
X_6589_ _2722_ _2740_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__nor2_8
X_6590_ _2726_ _2732_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__nor2_8
X_6591_ _2726_ _2734_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__nor2_8
X_6592_ _2726_ _2727_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__nor2_8
X_6593_ net65 VSS VSS VDD VDD _0031_ sky130_fd_sc_hd__clkinv_16
X_6594_ net28 _0126_ _0129_ VSS VSS VDD VDD _2741_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_0_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6596_ _0120_ _0913_ _2741_ VSS VSS VDD VDD _2743_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_0_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6599_ net100 _2743_ VSS VSS VDD VDD _2746_ sky130_fd_sc_hd__nand2_1
X_6600_ net502 _2743_ _2746_ VSS VSS VDD VDD _3529_ sky130_fd_sc_hd__o21ai_0
X_6601_ net111 _2743_ VSS VSS VDD VDD _2747_ sky130_fd_sc_hd__nand2_1
X_6602_ _3525_ _2743_ _2747_ VSS VSS VDD VDD _3271_ sky130_fd_sc_hd__o21ai_1
X_6603_ net122 _2743_ VSS VSS VDD VDD _2748_ sky130_fd_sc_hd__nand2_1
X_6604_ _3519_ _2743_ _2748_ VSS VSS VDD VDD _3534_ sky130_fd_sc_hd__o21ai_0
X_6605_ net125 _2743_ VSS VSS VDD VDD _2749_ sky130_fd_sc_hd__nand2_1
X_6606_ _1689_ _2743_ _2749_ VSS VSS VDD VDD _3538_ sky130_fd_sc_hd__o21ai_0
X_6607_ net126 _2743_ VSS VSS VDD VDD _2750_ sky130_fd_sc_hd__nand2_1
X_6608_ _3503_ _2743_ _2750_ VSS VSS VDD VDD _3544_ sky130_fd_sc_hd__o21ai_0
X_6609_ net127 _2743_ VSS VSS VDD VDD _2751_ sky130_fd_sc_hd__nand2_1
X_6610_ _3495_ _2743_ _2751_ VSS VSS VDD VDD _3548_ sky130_fd_sc_hd__o21ai_0
X_6611_ net128 _2743_ VSS VSS VDD VDD _2752_ sky130_fd_sc_hd__nand2_1
X_6612_ net516 _2743_ _2752_ VSS VSS VDD VDD _3552_ sky130_fd_sc_hd__o21ai_0
X_6613_ net129 _2743_ VSS VSS VDD VDD _2753_ sky130_fd_sc_hd__nand2_1
X_6614_ _3479_ _2743_ _2753_ VSS VSS VDD VDD _3556_ sky130_fd_sc_hd__o21ai_0
X_6615_ net130 _2743_ VSS VSS VDD VDD _2754_ sky130_fd_sc_hd__nand2_1
X_6616_ _3471_ _2743_ _2754_ VSS VSS VDD VDD _3560_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6618_ net131 _2743_ VSS VSS VDD VDD _2756_ sky130_fd_sc_hd__nand2_1
X_6619_ net854 _2743_ _2756_ VSS VSS VDD VDD _3564_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6621_ net101 _2743_ VSS VSS VDD VDD _2758_ sky130_fd_sc_hd__nand2_1
X_6622_ _3455_ _2743_ _2758_ VSS VSS VDD VDD _3568_ sky130_fd_sc_hd__o21ai_0
X_6623_ net102 _2743_ VSS VSS VDD VDD _2759_ sky130_fd_sc_hd__nand2_1
X_6624_ _3447_ _2743_ _2759_ VSS VSS VDD VDD _3572_ sky130_fd_sc_hd__o21ai_0
X_6625_ net103 _2743_ VSS VSS VDD VDD _2760_ sky130_fd_sc_hd__nand2_1
X_6626_ _3439_ _2743_ _2760_ VSS VSS VDD VDD _3576_ sky130_fd_sc_hd__o21ai_0
X_6627_ net104 _2743_ VSS VSS VDD VDD _2761_ sky130_fd_sc_hd__nand2_1
X_6628_ _3431_ _2743_ _2761_ VSS VSS VDD VDD _3580_ sky130_fd_sc_hd__o21ai_0
X_6629_ net105 _2743_ VSS VSS VDD VDD _2762_ sky130_fd_sc_hd__nand2_1
X_6630_ _3423_ _2743_ _2762_ VSS VSS VDD VDD _3584_ sky130_fd_sc_hd__o21ai_0
X_6631_ net106 _2743_ VSS VSS VDD VDD _2763_ sky130_fd_sc_hd__nand2_1
X_6632_ _3415_ _2743_ _2763_ VSS VSS VDD VDD _3588_ sky130_fd_sc_hd__o21ai_0
X_6633_ net107 _2743_ VSS VSS VDD VDD _2764_ sky130_fd_sc_hd__nand2_1
X_6634_ _3407_ _2743_ _2764_ VSS VSS VDD VDD _3592_ sky130_fd_sc_hd__o21ai_0
X_6635_ net108 _2743_ VSS VSS VDD VDD _2765_ sky130_fd_sc_hd__nand2_1
X_6636_ _3399_ _2743_ _2765_ VSS VSS VDD VDD _3596_ sky130_fd_sc_hd__o21ai_0
X_6637_ net109 _2743_ VSS VSS VDD VDD _2766_ sky130_fd_sc_hd__nand2_1
X_6638_ _1031_ _2743_ _2766_ VSS VSS VDD VDD _3600_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6640_ net110 _2743_ VSS VSS VDD VDD _2768_ sky130_fd_sc_hd__nand2_1
X_6641_ _3383_ _2743_ _2768_ VSS VSS VDD VDD _3604_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6643_ net112 _2743_ VSS VSS VDD VDD _2770_ sky130_fd_sc_hd__nand2_1
X_6644_ _3375_ _2743_ _2770_ VSS VSS VDD VDD _3608_ sky130_fd_sc_hd__o21ai_0
X_6645_ net113 _2743_ VSS VSS VDD VDD _2771_ sky130_fd_sc_hd__nand2_1
X_6646_ _3367_ _2743_ _2771_ VSS VSS VDD VDD _3612_ sky130_fd_sc_hd__o21ai_0
X_6647_ net114 _2743_ VSS VSS VDD VDD _2772_ sky130_fd_sc_hd__nand2_1
X_6648_ _3359_ _2743_ _2772_ VSS VSS VDD VDD _3616_ sky130_fd_sc_hd__o21ai_0
X_6649_ net115 _2743_ VSS VSS VDD VDD _2773_ sky130_fd_sc_hd__nand2_1
X_6650_ _3351_ _2743_ _2773_ VSS VSS VDD VDD _3620_ sky130_fd_sc_hd__o21ai_0
X_6651_ net116 _2743_ VSS VSS VDD VDD _2774_ sky130_fd_sc_hd__nand2_1
X_6652_ _3343_ _2743_ _2774_ VSS VSS VDD VDD _3624_ sky130_fd_sc_hd__o21ai_0
X_6653_ net117 _2743_ VSS VSS VDD VDD _2775_ sky130_fd_sc_hd__nand2_1
X_6654_ _3335_ _2743_ _2775_ VSS VSS VDD VDD _3628_ sky130_fd_sc_hd__o21ai_0
X_6655_ net118 _2743_ VSS VSS VDD VDD _2776_ sky130_fd_sc_hd__nand2_1
X_6656_ _0621_ _2743_ _2776_ VSS VSS VDD VDD _3632_ sky130_fd_sc_hd__o21ai_0
X_6657_ net119 _2743_ VSS VSS VDD VDD _2777_ sky130_fd_sc_hd__nand2_1
X_6658_ _3319_ _2743_ _2777_ VSS VSS VDD VDD _3636_ sky130_fd_sc_hd__o21ai_0
X_6659_ net120 _2743_ VSS VSS VDD VDD _2778_ sky130_fd_sc_hd__nand2_1
X_6660_ _3311_ _2743_ _2778_ VSS VSS VDD VDD _3640_ sky130_fd_sc_hd__o21ai_0
X_6661_ net121 _2743_ VSS VSS VDD VDD _2779_ sky130_fd_sc_hd__nand2_1
X_6662_ _3303_ _2743_ _2779_ VSS VSS VDD VDD _3644_ sky130_fd_sc_hd__o21ai_0
X_6663_ net123 _2743_ VSS VSS VDD VDD _2780_ sky130_fd_sc_hd__nand2_1
X_6664_ _0371_ _2743_ _2780_ VSS VSS VDD VDD _3648_ sky130_fd_sc_hd__o21ai_0
X_6665_ net27 _0126_ _0127_ VSS VSS VDD VDD _2781_ sky130_fd_sc_hd__or3_4
X_6666_ net6 net4 net5 _0120_ VSS VSS VDD VDD _2782_ sky130_fd_sc_hd__nor4_1
X_6667_ net6 net5 _0120_ net4 VSS VSS VDD VDD _2783_ sky130_fd_sc_hd__nor4b_1
X_6668_ _0950_ _3383_ VSS VSS VDD VDD _2784_ sky130_fd_sc_hd__nand2_1
X_6669_ _0401_ _0747_ VSS VSS VDD VDD _2785_ sky130_fd_sc_hd__nor2_1
X_6670_ _0794_ _3359_ VSS VSS VDD VDD _2786_ sky130_fd_sc_hd__nor2b_1
X_6671_ _2785_ _3351_ _2786_ VSS VSS VDD VDD _2787_ sky130_fd_sc_hd__maj3_1
X_6672_ _0838_ VSS VSS VDD VDD _2788_ sky130_fd_sc_hd__inv_1
X_6673_ _0881_ _3375_ VSS VSS VDD VDD _2789_ sky130_fd_sc_hd__nor2b_1
X_6674_ _2788_ _3367_ _2789_ VSS VSS VDD VDD _2790_ sky130_fd_sc_hd__maj3_1
X_6675_ _2787_ _2790_ VSS VSS VDD VDD _2791_ sky130_fd_sc_hd__nor2_1
X_6676_ _1002_ VSS VSS VDD VDD _2792_ sky130_fd_sc_hd__inv_1
X_6677_ _1127_ _1144_ _1159_ VSS VSS VDD VDD _2793_ sky130_fd_sc_hd__nor3_1
X_6678_ _1059_ _3399_ _2793_ VSS VSS VDD VDD _2794_ sky130_fd_sc_hd__maj3_1
X_6679_ _2792_ _1031_ _2794_ VSS VSS VDD VDD _2795_ sky130_fd_sc_hd__maj3_1
X_6680_ _0950_ _3383_ _2795_ VSS VSS VDD VDD _2796_ sky130_fd_sc_hd__o21ai_1
X_6681_ _3375_ _0881_ VSS VSS VDD VDD _2797_ sky130_fd_sc_hd__nand2b_1
X_6682_ _2788_ _3367_ _2797_ VSS VSS VDD VDD _2798_ sky130_fd_sc_hd__maj3_1
X_6683_ _3359_ _0794_ VSS VSS VDD VDD _2799_ sky130_fd_sc_hd__nand2b_1
X_6684_ _2785_ _3351_ _2799_ VSS VSS VDD VDD _2800_ sky130_fd_sc_hd__maj3_1
X_6685_ _2787_ _2798_ _2800_ VSS VSS VDD VDD _2801_ sky130_fd_sc_hd__o21ai_1
X_6686_ _2784_ _2791_ _2796_ _2801_ VSS VSS VDD VDD _2802_
+ sky130_fd_sc_hd__a31oi_1
X_6687_ _0628_ _0634_ _0401_ VSS VSS VDD VDD _2803_ sky130_fd_sc_hd__a21oi_2
X_6688_ _2803_ _3335_ VSS VSS VDD VDD _2804_ sky130_fd_sc_hd__nand2_1
X_6689_ _2803_ _3335_ VSS VSS VDD VDD _2805_ sky130_fd_sc_hd__nor2_1
X_6690_ _0694_ _3339_ _2804_ _2805_ VSS VSS VDD VDD _2806_
+ sky130_fd_sc_hd__a31oi_1
X_6691_ _0516_ _3315_ _0571_ VSS VSS VDD VDD _2807_ sky130_fd_sc_hd__a21oi_1
X_6692_ _0621_ _2806_ _2807_ VSS VSS VDD VDD _2808_ sky130_fd_sc_hd__o21ai_0
X_6693_ _0516_ _3315_ VSS VSS VDD VDD _2809_ sky130_fd_sc_hd__nand2_1
X_6694_ _0516_ _3315_ VSS VSS VDD VDD _2810_ sky130_fd_sc_hd__nor2_1
X_6695_ _0621_ _2809_ _2806_ _2810_ VSS VSS VDD VDD _2811_
+ sky130_fd_sc_hd__a31oi_1
X_6696_ net5 _1341_ VSS VSS VDD VDD _2812_ sky130_fd_sc_hd__nand2_2
X_6697_ _0274_ _0298_ VSS VSS VDD VDD _2813_ sky130_fd_sc_hd__nor2b_1
X_6698_ _0274_ _0298_ VSS VSS VDD VDD _2814_ sky130_fd_sc_hd__xnor2_1
X_6699_ _0324_ VSS VSS VDD VDD _2815_ sky130_fd_sc_hd__inv_2
X_6700_ _2815_ _0371_ VSS VSS VDD VDD _2816_ sky130_fd_sc_hd__and2_0
X_6701_ _0298_ _2812_ _0274_ VSS VSS VDD VDD _2817_ sky130_fd_sc_hd__nor3b_1
X_6702_ _2812_ _2813_ _2814_ _2816_ _2817_ VSS VSS VDD VDD
+ _2818_ sky130_fd_sc_hd__a221oi_2
X_6703_ _0481_ _0495_ _0458_ VSS VSS VDD VDD _2819_ sky130_fd_sc_hd__o21ai_0
X_6704_ _0404_ _3303_ _2819_ VSS VSS VDD VDD _2820_ sky130_fd_sc_hd__maj3_1
X_6705_ _2815_ _0371_ _2814_ _2820_ VSS VSS VDD VDD _2821_
+ sky130_fd_sc_hd__o211ai_1
X_6706_ _2818_ _2821_ VSS VSS VDD VDD _2822_ sky130_fd_sc_hd__and2_2
X_6707_ _2808_ _2811_ _2822_ VSS VSS VDD VDD _2823_ sky130_fd_sc_hd__a21oi_1
X_6708_ _0694_ _0720_ _0735_ VSS VSS VDD VDD _2824_ sky130_fd_sc_hd__nor3_1
X_6709_ _2803_ _3335_ _2824_ VSS VSS VDD VDD _2825_ sky130_fd_sc_hd__maj3_1
X_6710_ _0621_ _2809_ _2807_ VSS VSS VDD VDD _2826_ sky130_fd_sc_hd__a21o_1
X_6711_ _0621_ _2807_ _2825_ _2826_ _2810_ VSS VSS VDD VDD
+ _2827_ sky130_fd_sc_hd__a221oi_1
X_6712_ _2822_ _2827_ VSS VSS VDD VDD _2828_ sky130_fd_sc_hd__nor2_1
X_6713_ _0458_ _0481_ _0495_ VSS VSS VDD VDD _2829_ sky130_fd_sc_hd__nor3_1
X_6714_ _0404_ _3303_ _2829_ VSS VSS VDD VDD _2830_ sky130_fd_sc_hd__maj3_1
X_6715_ _2815_ _0371_ _2814_ _2830_ VSS VSS VDD VDD _2831_
+ sky130_fd_sc_hd__o211ai_1
X_6716_ _2818_ _2831_ VSS VSS VDD VDD _2832_ sky130_fd_sc_hd__nand2_1
X_6717_ _2802_ _2823_ _2828_ _2832_ VSS VSS VDD VDD _2833_
+ sky130_fd_sc_hd__a211o_2
X_6718_ _2808_ _2811_ VSS VSS VDD VDD _2834_ sky130_fd_sc_hd__nand2_1
X_6719_ _1144_ _1159_ _1127_ VSS VSS VDD VDD _2835_ sky130_fd_sc_hd__o21ai_0
X_6720_ _1059_ _3399_ _2835_ VSS VSS VDD VDD _2836_ sky130_fd_sc_hd__maj3_1
X_6721_ _1031_ _2836_ _2792_ VSS VSS VDD VDD _2837_ sky130_fd_sc_hd__a21oi_1
X_6722_ _1031_ _2836_ _2784_ VSS VSS VDD VDD _2838_ sky130_fd_sc_hd__nor3b_1
X_6723_ _0950_ _3383_ VSS VSS VDD VDD _2839_ sky130_fd_sc_hd__nor2_1
X_6724_ _2784_ _2837_ _2838_ _2839_ VSS VSS VDD VDD _2840_
+ sky130_fd_sc_hd__a211o_1
X_6725_ _2791_ _2840_ _2801_ VSS VSS VDD VDD _2841_ sky130_fd_sc_hd__a21oi_1
X_6726_ _2818_ _2831_ _2827_ VSS VSS VDD VDD _2842_ sky130_fd_sc_hd__nand3_1
X_6727_ _1218_ _3423_ VSS VSS VDD VDD _2843_ sky130_fd_sc_hd__nand2_1
X_6728_ _1174_ _3411_ _2843_ VSS VSS VDD VDD _2844_ sky130_fd_sc_hd__maj3_1
X_6729_ _1299_ _3435_ VSS VSS VDD VDD _2845_ sky130_fd_sc_hd__nand2_1
X_6730_ _3431_ _2845_ _1264_ VSS VSS VDD VDD _2846_ sky130_fd_sc_hd__o21ai_0
X_6731_ _3431_ _2845_ VSS VSS VDD VDD _2847_ sky130_fd_sc_hd__nand2_1
X_6732_ _1218_ _3423_ VSS VSS VDD VDD _2848_ sky130_fd_sc_hd__nor2_1
X_6733_ _1174_ _3411_ _2848_ VSS VSS VDD VDD _2849_ sky130_fd_sc_hd__maj3_1
X_6734_ _2846_ _2847_ _2849_ VSS VSS VDD VDD _2850_ sky130_fd_sc_hd__a21o_1
X_6735_ _2844_ _2850_ _2822_ VSS VSS VDD VDD _2851_ sky130_fd_sc_hd__a21oi_4
X_6736_ _2832_ _2834_ _2841_ _2842_ _2851_ VSS VSS VDD VDD
+ _2852_ sky130_fd_sc_hd__o221ai_4
X_6737_ _1299_ _3435_ VSS VSS VDD VDD _2853_ sky130_fd_sc_hd__nor2_1
X_6738_ _3431_ _2853_ VSS VSS VDD VDD _2854_ sky130_fd_sc_hd__nor2_1
X_6739_ _3431_ _2853_ _1264_ VSS VSS VDD VDD _2855_ sky130_fd_sc_hd__a21oi_1
X_6740_ _0401_ _1340_ _3443_ VSS VSS VDD VDD _2856_ sky130_fd_sc_hd__nor3_1
X_6741_ _1411_ _1417_ _0401_ VSS VSS VDD VDD _2857_ sky130_fd_sc_hd__a21oi_4
X_6742_ _1462_ _1469_ _1474_ _1482_ _1455_ VSS VSS VDD VDD
+ _2858_ sky130_fd_sc_hd__a221oi_1
X_6743_ _2857_ net852 _2858_ VSS VSS VDD VDD _2859_ sky130_fd_sc_hd__maj3_1
X_6744_ _1378_ _3455_ _2859_ VSS VSS VDD VDD _2860_ sky130_fd_sc_hd__maj3_1
X_6745_ _0401_ _1340_ _3443_ VSS VSS VDD VDD _2861_ sky130_fd_sc_hd__o21ai_1
X_6746_ _2856_ _2860_ _2861_ VSS VSS VDD VDD _2862_ sky130_fd_sc_hd__o21ai_1
X_6747_ _2849_ _2854_ _2855_ _2862_ _2844_ VSS VSS VDD VDD
+ _2863_ sky130_fd_sc_hd__o311a_1
X_6748_ _3471_ _1455_ VSS VSS VDD VDD _2864_ sky130_fd_sc_hd__nand2b_1
X_6749_ _2857_ net852 _2864_ VSS VSS VDD VDD _2865_ sky130_fd_sc_hd__maj3_1
X_6750_ _1378_ _3455_ _2865_ VSS VSS VDD VDD _2866_ sky130_fd_sc_hd__maj3_1
X_6751_ _2856_ _2866_ _2861_ VSS VSS VDD VDD _2867_ sky130_fd_sc_hd__o21ai_2
X_6752_ _1502_ _3475_ VSS VSS VDD VDD _2868_ sky130_fd_sc_hd__nor2_1
X_6753_ _1618_ _3499_ VSS VSS VDD VDD _2869_ sky130_fd_sc_hd__nor2_1
X_6754_ net160 net521 _2869_ VSS VSS VDD VDD _2870_ sky130_fd_sc_hd__maj3_1
X_6755_ net161 net515 _2870_ VSS VSS VDD VDD _2871_ sky130_fd_sc_hd__maj3_1
X_6756_ _1502_ _3475_ VSS VSS VDD VDD _2872_ sky130_fd_sc_hd__nand2_1
X_6757_ _2868_ _2871_ _2872_ VSS VSS VDD VDD _2873_ sky130_fd_sc_hd__o21a_1
X_6758_ net412 _3525_ VSS VSS VDD VDD _2874_ sky130_fd_sc_hd__nor2_1
X_6759_ net412 _3525_ VSS VSS VDD VDD _2875_ sky130_fd_sc_hd__nand2_1
X_6760_ _2874_ _2875_ VSS VSS VDD VDD _2876_ sky130_fd_sc_hd__nor2b_1
X_6761_ _2872_ _2876_ VSS VSS VDD VDD _2877_ sky130_fd_sc_hd__nand2_1
X_6762_ net158 _1689_ VSS VSS VDD VDD _2878_ sky130_fd_sc_hd__nor2_1
X_6763_ net158 _1689_ VSS VSS VDD VDD _2879_ sky130_fd_sc_hd__nand2_1
X_6764_ _1720_ _1731_ net155 VSS VSS VDD VDD _2880_ sky130_fd_sc_hd__a21oi_1
X_6765_ _1700_ _3515_ VSS VSS VDD VDD _2881_ sky130_fd_sc_hd__nor2_1
X_6766_ net133 net500 VSS VSS VDD VDD _2882_ sky130_fd_sc_hd__xnor2_1
X_6767_ _2880_ _2881_ _2882_ VSS VSS VDD VDD _2883_ sky130_fd_sc_hd__nor3_1
X_6768_ _2877_ _2878_ _2879_ _2883_ VSS VSS VDD VDD _2884_
+ sky130_fd_sc_hd__or4bb_1
X_6769_ _1618_ _3499_ VSS VSS VDD VDD _2885_ sky130_fd_sc_hd__nand2_1
X_6770_ net160 net522 _2885_ VSS VSS VDD VDD _2886_ sky130_fd_sc_hd__maj3_1
X_6771_ net161 net515 _2886_ VSS VSS VDD VDD _2887_ sky130_fd_sc_hd__maj3_1
X_6772_ _2868_ _2887_ VSS VSS VDD VDD _2888_ sky130_fd_sc_hd__nor2_1
X_6773_ _2867_ _2873_ _2884_ _2888_ VSS VSS VDD VDD _2889_
+ sky130_fd_sc_hd__nor4_1
X_6774_ _2833_ _2852_ _2863_ _2889_ VSS VSS VDD VDD _2890_
+ sky130_fd_sc_hd__nand4bb_1
X_6775_ _2782_ _2783_ _2890_ VSS VSS VDD VDD _2891_ sky130_fd_sc_hd__mux2i_2
X_6776_ _0120_ _1801_ VSS VSS VDD VDD _2892_ sky130_fd_sc_hd__nor2_1
X_6777_ _1813_ net4 _0120_ VSS VSS VDD VDD _2893_ sky130_fd_sc_hd__nor3_1
X_6778_ net133 net500 VSS VSS VDD VDD _2894_ sky130_fd_sc_hd__nand2_1
X_6779_ _2874_ _2894_ _2875_ _3515_ VSS VSS VDD VDD _2895_
+ sky130_fd_sc_hd__o211a_1
X_6780_ _2874_ _2894_ _2875_ _1700_ VSS VSS VDD VDD _2896_
+ sky130_fd_sc_hd__o211a_1
X_6781_ _2878_ _2895_ _2880_ _2896_ _2879_ VSS VSS VDD VDD
+ _2897_ sky130_fd_sc_hd__o41ai_1
X_6782_ _2872_ _2887_ _2897_ _2873_ VSS VSS VDD VDD _2898_
+ sky130_fd_sc_hd__a31oi_1
X_6783_ _2867_ _2898_ _2863_ VSS VSS VDD VDD _2899_ sky130_fd_sc_hd__o21a_1
X_6784_ _2852_ _2899_ _2833_ VSS VSS VDD VDD _2900_ sky130_fd_sc_hd__o21bai_1
X_6785_ _2892_ _2893_ _2900_ VSS VSS VDD VDD _2901_ sky130_fd_sc_hd__mux2i_2
X_6786_ _2781_ _2891_ _2901_ VSS VSS VDD VDD _2902_ sky130_fd_sc_hd__nand3_4
X_6787_ net100 _3531_ _2902_ VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__mux2_1
X_6788_ net111 VSS VSS VDD VDD _2903_ sky130_fd_sc_hd__inv_1
XTAP_TAPCELL_ROW_0_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6790_ _2903_ _3274_ _2902_ VSS VSS VDD VDD _0033_ sky130_fd_sc_hd__mux2i_1
X_6791_ net129 VSS VSS VDD VDD _2905_ sky130_fd_sc_hd__inv_1
X_6792_ net126 net127 net128 VSS VSS VDD VDD _2906_ sky130_fd_sc_hd__nand3_1
X_6793_ _2905_ _2906_ VSS VSS VDD VDD _2907_ sky130_fd_sc_hd__nor2_1
X_6794_ _3542_ net130 net131 _2907_ VSS VSS VDD VDD _2908_
+ sky130_fd_sc_hd__nand4_1
X_6795_ net101 _2908_ VSS VSS VDD VDD _2909_ sky130_fd_sc_hd__xor2_2
X_6796_ _3563_ _3558_ _3562_ VSS VSS VDD VDD _2910_ sky130_fd_sc_hd__a21o_1
X_6797_ _3567_ _2910_ _3566_ VSS VSS VDD VDD _2911_ sky130_fd_sc_hd__a21oi_4
X_6798_ _3547_ VSS VSS VDD VDD _2912_ sky130_fd_sc_hd__clkinvlp_4
X_6799_ _3273_ _3537_ _3536_ VSS VSS VDD VDD _2913_ sky130_fd_sc_hd__a21o_1
X_6800_ _2913_ _3541_ _3540_ VSS VSS VDD VDD _2914_ sky130_fd_sc_hd__a21oi_4
X_6801_ _3546_ _3550_ _3554_ VSS VSS VDD VDD _2915_ sky130_fd_sc_hd__nor3_2
X_6802_ _2912_ _2914_ _2915_ VSS VSS VDD VDD _2916_ sky130_fd_sc_hd__o21ai_2
X_6803_ _3551_ _3550_ _3555_ VSS VSS VDD VDD _2917_ sky130_fd_sc_hd__o21a_1
X_6804_ _3554_ _2917_ _3559_ VSS VSS VDD VDD _2918_ sky130_fd_sc_hd__o21a_1
X_6805_ _3563_ _3567_ _2918_ VSS VSS VDD VDD _2919_ sky130_fd_sc_hd__and3_1
X_6806_ _2916_ _2919_ VSS VSS VDD VDD _2920_ sky130_fd_sc_hd__nand2_1
X_6807_ _2911_ _2920_ VSS VSS VDD VDD _2921_ sky130_fd_sc_hd__nand2_1
X_6808_ _3571_ _2921_ VSS VSS VDD VDD _2922_ sky130_fd_sc_hd__xnor2_1
X_6809_ _2909_ _2922_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[10\]
+ sky130_fd_sc_hd__mux2i_1
X_6810_ net122 net125 VSS VSS VDD VDD _2923_ sky130_fd_sc_hd__nand2_1
X_6811_ _2905_ _2906_ _2923_ VSS VSS VDD VDD _2924_ sky130_fd_sc_hd__nor3_2
X_6812_ net130 net131 net101 _2924_ VSS VSS VDD VDD _2925_
+ sky130_fd_sc_hd__nand4_1
X_6813_ net102 _2925_ VSS VSS VDD VDD _2926_ sky130_fd_sc_hd__xor2_1
X_6814_ _3270_ _3533_ _3532_ VSS VSS VDD VDD _2927_ sky130_fd_sc_hd__a21o_1
X_6815_ _3537_ _2927_ _3536_ VSS VSS VDD VDD _2928_ sky130_fd_sc_hd__a21o_1
X_6816_ _3541_ _2928_ _3540_ VSS VSS VDD VDD _2929_ sky130_fd_sc_hd__a21oi_2
X_6817_ _2912_ _2929_ VSS VSS VDD VDD _2930_ sky130_fd_sc_hd__nor2_1
X_6818_ _2930_ _2915_ VSS VSS VDD VDD _2931_ sky130_fd_sc_hd__nor2b_1
X_6819_ _2931_ VSS VSS VDD VDD _2932_ sky130_fd_sc_hd__inv_1
X_6820_ _2919_ _2932_ VSS VSS VDD VDD _2933_ sky130_fd_sc_hd__nand2_1
X_6821_ _2911_ _2933_ VSS VSS VDD VDD _2934_ sky130_fd_sc_hd__nand2_1
X_6822_ _3571_ _2934_ _3570_ VSS VSS VDD VDD _2935_ sky130_fd_sc_hd__a21oi_1
X_6823_ _3575_ _2935_ VSS VSS VDD VDD _2936_ sky130_fd_sc_hd__xor2_1
X_6824_ _2926_ _2936_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[11\]
+ sky130_fd_sc_hd__mux2i_1
X_6825_ _3542_ _2907_ VSS VSS VDD VDD _2937_ sky130_fd_sc_hd__nand2_2
X_6826_ net130 net131 net101 net102 VSS VSS VDD VDD _2938_
+ sky130_fd_sc_hd__nand4_1
X_6827_ _2937_ _2938_ VSS VSS VDD VDD _2939_ sky130_fd_sc_hd__nor2_1
X_6828_ net103 _2939_ VSS VSS VDD VDD _2940_ sky130_fd_sc_hd__xnor2_4
X_6829_ _3574_ VSS VSS VDD VDD _2941_ sky130_fd_sc_hd__inv_1
X_6830_ _3571_ _3570_ _3575_ VSS VSS VDD VDD _2942_ sky130_fd_sc_hd__o21ai_1
X_6831_ _3570_ _3574_ VSS VSS VDD VDD _2943_ sky130_fd_sc_hd__nor2_1
X_6832_ _2911_ _2943_ VSS VSS VDD VDD _2944_ sky130_fd_sc_hd__nand2_1
X_6833_ _2919_ _2916_ _2944_ VSS VSS VDD VDD _2945_ sky130_fd_sc_hd__a21oi_4
X_6834_ _2941_ _2942_ _2945_ VSS VSS VDD VDD _2946_ sky130_fd_sc_hd__a21oi_1
X_6835_ _3579_ _2946_ VSS VSS VDD VDD _2947_ sky130_fd_sc_hd__xnor2_2
X_6836_ _2940_ _2947_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[12\]
+ sky130_fd_sc_hd__mux2i_1
X_6837_ net103 VSS VSS VDD VDD _2948_ sky130_fd_sc_hd__inv_1
X_6838_ _2948_ _2938_ VSS VSS VDD VDD _2949_ sky130_fd_sc_hd__nor2_1
X_6839_ _2924_ _2949_ VSS VSS VDD VDD _2950_ sky130_fd_sc_hd__nand2_1
X_6840_ net104 _2950_ VSS VSS VDD VDD _2951_ sky130_fd_sc_hd__xor2_1
X_6841_ _2941_ _2942_ _3579_ VSS VSS VDD VDD _2952_ sky130_fd_sc_hd__a21boi_2
X_6842_ _2919_ _2944_ VSS VSS VDD VDD _2953_ sky130_fd_sc_hd__or2_1
X_6843_ _2912_ _2929_ _2943_ _2911_ _2915_ VSS VSS VDD VDD
+ _2954_ sky130_fd_sc_hd__o2111ai_4
X_6844_ _2952_ _2953_ _2954_ _3578_ VSS VSS VDD VDD _2955_
+ sky130_fd_sc_hd__a31oi_2
X_6845_ _3583_ _2955_ VSS VSS VDD VDD _2956_ sky130_fd_sc_hd__xor2_2
X_6846_ _2951_ _2956_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[13\]
+ sky130_fd_sc_hd__mux2i_1
X_6847_ _3542_ net104 _2907_ _2949_ VSS VSS VDD VDD _2957_
+ sky130_fd_sc_hd__nand4_1
X_6848_ net105 _2957_ VSS VSS VDD VDD _2958_ sky130_fd_sc_hd__xor2_1
X_6849_ _2952_ VSS VSS VDD VDD _2959_ sky130_fd_sc_hd__inv_1
X_6850_ _2945_ _2959_ _3578_ VSS VSS VDD VDD _2960_ sky130_fd_sc_hd__o21bai_1
X_6851_ _3583_ _2960_ _3582_ VSS VSS VDD VDD _2961_ sky130_fd_sc_hd__a21oi_2
X_6852_ _3587_ _2961_ VSS VSS VDD VDD _2962_ sky130_fd_sc_hd__xor2_4
X_6853_ _2958_ _2962_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[14\]
+ sky130_fd_sc_hd__mux2i_1
X_6854_ net104 net105 _2924_ _2949_ VSS VSS VDD VDD _2963_
+ sky130_fd_sc_hd__nand4_1
X_6855_ net106 _2963_ VSS VSS VDD VDD _2964_ sky130_fd_sc_hd__xor2_1
X_6856_ _3587_ _3586_ _2952_ _3583_ VSS VSS VDD VDD _2965_
+ sky130_fd_sc_hd__o211a_1
X_6857_ _3583_ _3578_ _3582_ VSS VSS VDD VDD _2966_ sky130_fd_sc_hd__a21o_1
X_6858_ _3587_ _2966_ _3586_ VSS VSS VDD VDD _2967_ sky130_fd_sc_hd__a21o_1
X_6859_ _2953_ _2954_ _2965_ _2967_ VSS VSS VDD VDD _2968_
+ sky130_fd_sc_hd__a31oi_4
X_6860_ _3591_ _2968_ VSS VSS VDD VDD _2969_ sky130_fd_sc_hd__xor2_1
X_6861_ _2964_ _2969_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[15\]
+ sky130_fd_sc_hd__mux2i_1
X_6862_ net104 net105 net106 _2949_ VSS VSS VDD VDD _2970_
+ sky130_fd_sc_hd__and4_1
X_6863_ _2937_ _2970_ VSS VSS VDD VDD _2971_ sky130_fd_sc_hd__nor2b_4
X_6864_ net107 _2971_ VSS VSS VDD VDD _2972_ sky130_fd_sc_hd__xnor2_1
X_6865_ _3583_ _3587_ _3591_ _2952_ VSS VSS VDD VDD _2973_
+ sky130_fd_sc_hd__nand4_1
X_6866_ _3591_ _2967_ _3590_ VSS VSS VDD VDD _2974_ sky130_fd_sc_hd__a21oi_1
X_6867_ _2945_ _2973_ _2974_ VSS VSS VDD VDD _2975_ sky130_fd_sc_hd__o21ai_4
X_6868_ _3595_ _2975_ VSS VSS VDD VDD _2976_ sky130_fd_sc_hd__xnor2_2
X_6869_ _2972_ _2976_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[16\]
+ sky130_fd_sc_hd__mux2i_1
X_6870_ net107 _2924_ _2970_ VSS VSS VDD VDD _2977_ sky130_fd_sc_hd__and3_4
XTAP_TAPCELL_ROW_0_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6872_ net108 _2977_ VSS VSS VDD VDD _2979_ sky130_fd_sc_hd__xnor2_1
X_6873_ _3591_ _3595_ VSS VSS VDD VDD _2980_ sky130_fd_sc_hd__nand2_1
X_6874_ _3595_ _3590_ _3594_ VSS VSS VDD VDD _2981_ sky130_fd_sc_hd__a21oi_1
X_6875_ _2968_ _2980_ _2981_ VSS VSS VDD VDD _2982_ sky130_fd_sc_hd__o21ai_4
X_6876_ _3599_ _2982_ VSS VSS VDD VDD _2983_ sky130_fd_sc_hd__xnor2_4
X_6877_ _2979_ _2983_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[17\]
+ sky130_fd_sc_hd__mux2i_1
X_6878_ net107 net108 _2971_ VSS VSS VDD VDD _2984_ sky130_fd_sc_hd__nand3_1
X_6879_ net109 _2984_ VSS VSS VDD VDD _2985_ sky130_fd_sc_hd__xor2_1
X_6880_ _3595_ _2975_ _3594_ VSS VSS VDD VDD _2986_ sky130_fd_sc_hd__a21o_1
X_6881_ _3599_ _2986_ _3598_ VSS VSS VDD VDD _2987_ sky130_fd_sc_hd__a21oi_2
X_6882_ _3603_ _2987_ VSS VSS VDD VDD _2988_ sky130_fd_sc_hd__xor2_4
X_6883_ _2985_ _2988_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[18\]
+ sky130_fd_sc_hd__mux2i_1
X_6884_ net108 net109 _2977_ VSS VSS VDD VDD _2989_ sky130_fd_sc_hd__nand3_1
X_6885_ net110 _2989_ VSS VSS VDD VDD _2990_ sky130_fd_sc_hd__xor2_1
X_6886_ _3602_ VSS VSS VDD VDD _2991_ sky130_fd_sc_hd__inv_1
X_6887_ _3599_ _3598_ _3603_ VSS VSS VDD VDD _2992_ sky130_fd_sc_hd__o21ai_1
X_6888_ _2991_ _2992_ VSS VSS VDD VDD _2993_ sky130_fd_sc_hd__nand2_1
X_6889_ _3598_ _3602_ _2982_ _2993_ VSS VSS VDD VDD _2994_
+ sky130_fd_sc_hd__o31a_2
X_6890_ _3607_ _2994_ VSS VSS VDD VDD _2995_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_0_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6892_ _2990_ _2995_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[19\]
+ sky130_fd_sc_hd__mux2i_1
X_6893_ net107 _2971_ VSS VSS VDD VDD _2997_ sky130_fd_sc_hd__nand2_1
X_6894_ net108 net109 net110 VSS VSS VDD VDD _2998_ sky130_fd_sc_hd__nand3_1
X_6895_ _2997_ _2998_ VSS VSS VDD VDD _2999_ sky130_fd_sc_hd__nor2_1
X_6896_ net112 _2999_ VSS VSS VDD VDD _3000_ sky130_fd_sc_hd__xnor2_2
X_6897_ _2975_ _3595_ _3598_ _3594_ VSS VSS VDD VDD _3001_
+ sky130_fd_sc_hd__a211oi_4
X_6898_ _3001_ _2992_ _2991_ VSS VSS VDD VDD _3002_ sky130_fd_sc_hd__o21ai_0
X_6899_ _3607_ _3002_ _3606_ VSS VSS VDD VDD _3003_ sky130_fd_sc_hd__a21oi_1
X_6900_ _3611_ _3003_ VSS VSS VDD VDD _3004_ sky130_fd_sc_hd__xor2_2
X_6901_ _3000_ _3004_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[20\]
+ sky130_fd_sc_hd__mux2i_1
X_6902_ net112 VSS VSS VDD VDD _3005_ sky130_fd_sc_hd__inv_1
X_6903_ _3005_ _2998_ VSS VSS VDD VDD _3006_ sky130_fd_sc_hd__nor2_1
X_6904_ _2977_ _3006_ VSS VSS VDD VDD _3007_ sky130_fd_sc_hd__nand2_1
X_6905_ net113 _3007_ VSS VSS VDD VDD _3008_ sky130_fd_sc_hd__xor2_1
X_6906_ _3607_ _2994_ _3606_ VSS VSS VDD VDD _3009_ sky130_fd_sc_hd__a21o_1
X_6907_ _3611_ _3009_ _3610_ VSS VSS VDD VDD _3010_ sky130_fd_sc_hd__a21oi_1
X_6908_ _3615_ _3010_ VSS VSS VDD VDD _3011_ sky130_fd_sc_hd__xor2_2
X_6909_ _3008_ _3011_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[21\]
+ sky130_fd_sc_hd__mux2i_1
X_6910_ net107 net113 _2971_ _3006_ VSS VSS VDD VDD _3012_
+ sky130_fd_sc_hd__nand4_1
X_6911_ net114 _3012_ VSS VSS VDD VDD _3013_ sky130_fd_sc_hd__xor2_1
X_6912_ _3602_ _3606_ _3610_ VSS VSS VDD VDD _3014_ sky130_fd_sc_hd__nor3_1
X_6913_ _3001_ _2992_ _3014_ VSS VSS VDD VDD _3015_ sky130_fd_sc_hd__o21ai_2
X_6914_ _3607_ _3606_ _3610_ VSS VSS VDD VDD _3016_ sky130_fd_sc_hd__nor3_1
X_6915_ _3611_ _3610_ VSS VSS VDD VDD _3017_ sky130_fd_sc_hd__nor2_1
X_6916_ _3016_ _3017_ VSS VSS VDD VDD _3018_ sky130_fd_sc_hd__nor2_1
X_6917_ _3615_ _3015_ _3018_ _3614_ VSS VSS VDD VDD _3019_
+ sky130_fd_sc_hd__a31oi_2
X_6918_ _3619_ _3019_ VSS VSS VDD VDD _3020_ sky130_fd_sc_hd__xor2_2
X_6919_ _3013_ _3020_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[22\]
+ sky130_fd_sc_hd__mux2i_1
X_6920_ net113 net114 _3006_ VSS VSS VDD VDD _3021_ sky130_fd_sc_hd__and3_1
X_6921_ _2977_ _3021_ VSS VSS VDD VDD _3022_ sky130_fd_sc_hd__nand2_1
X_6922_ net115 _3022_ VSS VSS VDD VDD _3023_ sky130_fd_sc_hd__xor2_1
X_6923_ _3607_ _3611_ _3615_ VSS VSS VDD VDD _3024_ sky130_fd_sc_hd__and3_1
X_6924_ _3598_ _3602_ _2982_ _2993_ _3024_ VSS VSS VDD VDD
+ _3025_ sky130_fd_sc_hd__o311ai_4
X_6925_ _3611_ _3615_ _3606_ VSS VSS VDD VDD _3026_ sky130_fd_sc_hd__and3_1
X_6926_ _3615_ _3610_ _3026_ VSS VSS VDD VDD _3027_ sky130_fd_sc_hd__a21oi_1
X_6927_ _3025_ _3027_ VSS VSS VDD VDD _3028_ sky130_fd_sc_hd__nand2_1
X_6928_ _3614_ _3028_ _3619_ VSS VSS VDD VDD _3029_ sky130_fd_sc_hd__o21ai_0
X_6929_ _3618_ _3029_ VSS VSS VDD VDD _3030_ sky130_fd_sc_hd__nand2b_1
X_6930_ _3623_ _3030_ VSS VSS VDD VDD _3031_ sky130_fd_sc_hd__xnor2_1
X_6931_ _3023_ _3031_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[23\]
+ sky130_fd_sc_hd__mux2i_1
X_6932_ net107 net115 _2971_ _3021_ VSS VSS VDD VDD _3032_
+ sky130_fd_sc_hd__nand4_1
X_6933_ net116 _3032_ VSS VSS VDD VDD _3033_ sky130_fd_sc_hd__xor2_1
X_6934_ _3615_ _3619_ _3623_ VSS VSS VDD VDD _3034_ sky130_fd_sc_hd__and3_1
X_6935_ _3015_ _3018_ _3034_ VSS VSS VDD VDD _3035_ sky130_fd_sc_hd__nand3_1
X_6936_ _3619_ _3623_ _3614_ VSS VSS VDD VDD _3036_ sky130_fd_sc_hd__and3_1
X_6937_ _3623_ _3618_ _3036_ VSS VSS VDD VDD _3037_ sky130_fd_sc_hd__a21oi_1
X_6938_ _3035_ _3037_ VSS VSS VDD VDD _3038_ sky130_fd_sc_hd__and2_1
X_6939_ _3622_ _3038_ VSS VSS VDD VDD _3039_ sky130_fd_sc_hd__nand2b_1
X_6940_ _3627_ _3039_ VSS VSS VDD VDD _3040_ sky130_fd_sc_hd__xor2_1
X_6941_ _3040_ VSS VSS VDD VDD _3041_ sky130_fd_sc_hd__inv_1
X_6942_ _3033_ _3041_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[24\]
+ sky130_fd_sc_hd__mux2i_1
X_6943_ net115 net116 _3021_ VSS VSS VDD VDD _3042_ sky130_fd_sc_hd__and3_1
X_6944_ _2977_ _3042_ VSS VSS VDD VDD _3043_ sky130_fd_sc_hd__nand2_1
X_6945_ net117 _3043_ VSS VSS VDD VDD _3044_ sky130_fd_sc_hd__xor2_1
X_6946_ _3614_ _3618_ _3622_ VSS VSS VDD VDD _3045_ sky130_fd_sc_hd__nor3_1
X_6947_ _3619_ _3618_ VSS VSS VDD VDD _3046_ sky130_fd_sc_hd__or2_0
X_6948_ _3623_ _3046_ _3622_ VSS VSS VDD VDD _3047_ sky130_fd_sc_hd__a21oi_1
X_6949_ _3025_ _3027_ _3045_ _3047_ VSS VSS VDD VDD _3048_
+ sky130_fd_sc_hd__a31oi_2
X_6950_ _3627_ _3048_ _3626_ VSS VSS VDD VDD _3049_ sky130_fd_sc_hd__a21oi_1
X_6951_ _3631_ _3049_ VSS VSS VDD VDD _3050_ sky130_fd_sc_hd__xor2_1
X_6952_ _3044_ _3050_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[25\]
+ sky130_fd_sc_hd__mux2i_1
X_6953_ net117 _3042_ VSS VSS VDD VDD _3051_ sky130_fd_sc_hd__nand2_1
X_6954_ _2997_ _3051_ VSS VSS VDD VDD _3052_ sky130_fd_sc_hd__nor2_1
X_6955_ net118 _3052_ VSS VSS VDD VDD _3053_ sky130_fd_sc_hd__xnor2_1
X_6956_ _3622_ _3626_ _3630_ VSS VSS VDD VDD _3054_ sky130_fd_sc_hd__nor3_1
X_6957_ _3627_ _3626_ VSS VSS VDD VDD _3055_ sky130_fd_sc_hd__or2_0
X_6958_ _3631_ _3055_ _3630_ VSS VSS VDD VDD _3056_ sky130_fd_sc_hd__a21oi_1
X_6959_ _3038_ _3054_ _3056_ VSS VSS VDD VDD _3057_ sky130_fd_sc_hd__a21oi_1
X_6960_ _3635_ _3057_ VSS VSS VDD VDD _3058_ sky130_fd_sc_hd__xnor2_2
X_6961_ _3053_ _3058_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[26\]
+ sky130_fd_sc_hd__mux2i_1
X_6962_ net117 net118 _2977_ _3042_ VSS VSS VDD VDD _3059_
+ sky130_fd_sc_hd__and4_1
X_6963_ net119 _3059_ VSS VSS VDD VDD _3060_ sky130_fd_sc_hd__xnor2_1
X_6964_ _3635_ _3630_ VSS VSS VDD VDD _3061_ sky130_fd_sc_hd__nand2_1
X_6965_ _3631_ _3635_ _3626_ VSS VSS VDD VDD _3062_ sky130_fd_sc_hd__nand3_1
X_6966_ _3061_ _3062_ VSS VSS VDD VDD _3063_ sky130_fd_sc_hd__nand2_1
X_6967_ _3627_ _3631_ _3635_ _3048_ _3063_ VSS VSS VDD VDD
+ _3064_ sky130_fd_sc_hd__a41oi_2
X_6968_ _3634_ _3064_ VSS VSS VDD VDD _3065_ sky130_fd_sc_hd__nor2b_1
X_6969_ _3639_ _3065_ VSS VSS VDD VDD _3066_ sky130_fd_sc_hd__xor2_1
X_6970_ _3060_ _3066_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[27\]
+ sky130_fd_sc_hd__mux2i_1
X_6971_ net118 net119 _3052_ VSS VSS VDD VDD _3067_ sky130_fd_sc_hd__nand3_1
X_6972_ net120 _3067_ VSS VSS VDD VDD _3068_ sky130_fd_sc_hd__xor2_2
X_6973_ _3635_ VSS VSS VDD VDD _3069_ sky130_fd_sc_hd__inv_1
X_6974_ _3035_ _3037_ _3054_ _3056_ _3069_ VSS VSS VDD VDD
+ _3070_ sky130_fd_sc_hd__a311oi_1
X_6975_ _3634_ _3070_ _3639_ VSS VSS VDD VDD _3071_ sky130_fd_sc_hd__o21ai_1
X_6976_ _3643_ _3638_ VSS VSS VDD VDD _3072_ sky130_fd_sc_hd__nor2_1
X_6977_ _3638_ VSS VSS VDD VDD _3073_ sky130_fd_sc_hd__inv_1
X_6978_ _3073_ _3071_ _3643_ VSS VSS VDD VDD _3074_ sky130_fd_sc_hd__a21boi_1
X_6979_ _3071_ _3072_ _3074_ VSS VSS VDD VDD _3075_ sky130_fd_sc_hd__a21o_1
X_6980_ _3068_ _3075_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[28\]
+ sky130_fd_sc_hd__mux2i_1
X_6981_ net119 net120 _3059_ VSS VSS VDD VDD _3076_ sky130_fd_sc_hd__nand3_1
X_6982_ net121 _3076_ VSS VSS VDD VDD _3077_ sky130_fd_sc_hd__xor2_1
X_6983_ _3634_ _3638_ _3642_ VSS VSS VDD VDD _3078_ sky130_fd_sc_hd__nor3_1
X_6984_ _3639_ _3638_ VSS VSS VDD VDD _3079_ sky130_fd_sc_hd__or2_0
X_6985_ _3643_ _3079_ _3642_ VSS VSS VDD VDD _3080_ sky130_fd_sc_hd__a21oi_1
X_6986_ _3064_ _3078_ _3080_ VSS VSS VDD VDD _3081_ sky130_fd_sc_hd__a21oi_1
X_6987_ _3647_ _3081_ VSS VSS VDD VDD _3082_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_0_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_6989_ _3077_ _3082_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[29\]
+ sky130_fd_sc_hd__mux2i_1
X_6990_ _3273_ _3537_ VSS VSS VDD VDD _3084_ sky130_fd_sc_hd__xnor2_1
X_6991_ net122 _3084_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[2\]
+ sky130_fd_sc_hd__mux2i_1
X_6992_ net119 net120 net121 VSS VSS VDD VDD _3085_ sky130_fd_sc_hd__and3_1
X_6993_ net118 _3052_ _3085_ VSS VSS VDD VDD _3086_ sky130_fd_sc_hd__nand3_1
X_6994_ net123 _3086_ VSS VSS VDD VDD _3087_ sky130_fd_sc_hd__xor2_2
X_6995_ _3642_ _3646_ _3651_ VSS VSS VDD VDD _3088_ sky130_fd_sc_hd__nor3b_1
X_6996_ _3651_ _3647_ VSS VSS VDD VDD _3089_ sky130_fd_sc_hd__nor2b_1
X_6997_ _3088_ _3089_ _3074_ VSS VSS VDD VDD _3090_ sky130_fd_sc_hd__mux2_1
X_6998_ _3646_ VSS VSS VDD VDD _3091_ sky130_fd_sc_hd__inv_1
X_6999_ _3647_ _3646_ _3651_ VSS VSS VDD VDD _3092_ sky130_fd_sc_hd__nor3b_1
X_7000_ _3642_ _3089_ _3092_ VSS VSS VDD VDD _3093_ sky130_fd_sc_hd__a21oi_1
X_7001_ _3651_ _3091_ _3093_ VSS VSS VDD VDD _3094_ sky130_fd_sc_hd__o21ai_0
X_7002_ _3090_ _3094_ VSS VSS VDD VDD _3095_ sky130_fd_sc_hd__nor2_1
X_7003_ _3087_ _3095_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[30\]
+ sky130_fd_sc_hd__mux2i_1
X_7004_ net123 _3059_ _3085_ VSS VSS VDD VDD _3096_ sky130_fd_sc_hd__nand3_1
X_7005_ net124 _3096_ VSS VSS VDD VDD _3097_ sky130_fd_sc_hd__xor2_2
X_7006_ net124 _2743_ VSS VSS VDD VDD _3098_ sky130_fd_sc_hd__nand2_1
X_7007_ _0274_ _2743_ _3098_ VSS VSS VDD VDD _3099_ sky130_fd_sc_hd__o21ai_0
X_7008_ net25 _3099_ VSS VSS VDD VDD _3100_ sky130_fd_sc_hd__xnor2_1
X_7009_ _3647_ _3081_ _3646_ VSS VSS VDD VDD _3101_ sky130_fd_sc_hd__a21o_1
X_7010_ _3651_ _3101_ _3650_ VSS VSS VDD VDD _3102_ sky130_fd_sc_hd__a21oi_2
X_7011_ _3102_ _3100_ VSS VSS VDD VDD _3103_ sky130_fd_sc_hd__xnor2_2
X_7012_ _3097_ _3103_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[31\]
+ sky130_fd_sc_hd__mux2i_1
X_7013_ _3541_ _2928_ VSS VSS VDD VDD _3104_ sky130_fd_sc_hd__xor2_1
X_7014_ _3543_ _3104_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[3\]
+ sky130_fd_sc_hd__mux2_1
X_7015_ net126 _3542_ VSS VSS VDD VDD _3105_ sky130_fd_sc_hd__xnor2_1
X_7016_ _2912_ _2914_ VSS VSS VDD VDD _3106_ sky130_fd_sc_hd__xnor2_1
X_7017_ _3105_ _3106_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[4\]
+ sky130_fd_sc_hd__mux2i_1
X_7018_ net122 net125 net126 VSS VSS VDD VDD _3107_ sky130_fd_sc_hd__nand3_1
X_7019_ net127 _3107_ VSS VSS VDD VDD _3108_ sky130_fd_sc_hd__xor2_1
X_7020_ _3546_ _2930_ VSS VSS VDD VDD _3109_ sky130_fd_sc_hd__nor2_1
X_7021_ _3551_ _3109_ VSS VSS VDD VDD _3110_ sky130_fd_sc_hd__xor2_1
X_7022_ _3108_ _3110_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[5\]
+ sky130_fd_sc_hd__mux2i_1
X_7023_ net126 _3542_ net127 VSS VSS VDD VDD _3111_ sky130_fd_sc_hd__nand3_1
X_7024_ net128 _3111_ VSS VSS VDD VDD _3112_ sky130_fd_sc_hd__xor2_1
X_7025_ _2912_ _2914_ _3546_ VSS VSS VDD VDD _3113_ sky130_fd_sc_hd__o21bai_1
X_7026_ _3551_ _3113_ _3550_ VSS VSS VDD VDD _3114_ sky130_fd_sc_hd__a21oi_1
X_7027_ _3555_ _3114_ VSS VSS VDD VDD _3115_ sky130_fd_sc_hd__xor2_1
X_7028_ _3112_ _3115_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[6\]
+ sky130_fd_sc_hd__mux2i_1
X_7029_ _2906_ _2923_ VSS VSS VDD VDD _3116_ sky130_fd_sc_hd__nor2_1
X_7030_ net129 _3116_ VSS VSS VDD VDD _3117_ sky130_fd_sc_hd__xnor2_2
X_7031_ _3554_ _2917_ VSS VSS VDD VDD _3118_ sky130_fd_sc_hd__nor2_1
X_7032_ _3118_ _2931_ VSS VSS VDD VDD _3119_ sky130_fd_sc_hd__nor2_1
X_7033_ _3559_ _3119_ VSS VSS VDD VDD _3120_ sky130_fd_sc_hd__xnor2_2
X_7034_ _3117_ _3120_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[7\]
+ sky130_fd_sc_hd__mux2i_1
X_7035_ net130 _2937_ VSS VSS VDD VDD _3121_ sky130_fd_sc_hd__xor2_1
X_7036_ _2916_ _2918_ _3558_ VSS VSS VDD VDD _3122_ sky130_fd_sc_hd__a21oi_1
X_7037_ _3563_ _3122_ VSS VSS VDD VDD _3123_ sky130_fd_sc_hd__xor2_2
X_7038_ _3121_ _3123_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[8\]
+ sky130_fd_sc_hd__mux2i_1
X_7039_ net130 _2924_ VSS VSS VDD VDD _3124_ sky130_fd_sc_hd__nand2_1
X_7040_ net131 _3124_ VSS VSS VDD VDD _3125_ sky130_fd_sc_hd__xor2_1
X_7041_ _2918_ _2932_ _3558_ VSS VSS VDD VDD _3126_ sky130_fd_sc_hd__a21o_1
X_7042_ _3563_ _3126_ _3562_ VSS VSS VDD VDD _3127_ sky130_fd_sc_hd__a21oi_1
X_7043_ _3567_ _3127_ VSS VSS VDD VDD _3128_ sky130_fd_sc_hd__xor2_2
X_7044_ _3125_ _3128_ _2902_ VSS VSS VDD VDD dp.ISRmux.d0\[9\]
+ sky130_fd_sc_hd__mux2i_1
XTAP_TAPCELL_ROW_0_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7046_ net66 _1960_ VSS VSS VDD VDD _3130_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7048_ _2781_ _2741_ VSS VSS VDD VDD _3132_ sky130_fd_sc_hd__nand2_8
X_7049_ net33 net98 _3132_ VSS VSS VDD VDD _3133_ sky130_fd_sc_hd__a21oi_1
X_7050_ net100 _2781_ _2741_ _3531_ VSS VSS VDD VDD _3134_
+ sky130_fd_sc_hd__o22ai_2
X_7051_ _3130_ _3133_ _3134_ VSS VSS VDD VDD dp.result2\[0\]
+ sky130_fd_sc_hd__a21oi_4
X_7052_ net28 _0119_ VSS VSS VDD VDD _3135_ sky130_fd_sc_hd__nor2_8
X_7053_ _0128_ _3135_ VSS VSS VDD VDD _3136_ sky130_fd_sc_hd__nor2_8
X_7054_ _1960_ _3136_ VSS VSS VDD VDD _3137_ sky130_fd_sc_hd__nand2_8
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7056_ net99 _0109_ _1805_ VSS VSS VDD VDD _3139_ sky130_fd_sc_hd__nand3b_4
X_7057_ net4 net5 net99 _1797_ VSS VSS VDD VDD _3140_ sky130_fd_sc_hd__nor4_4
X_7058_ _1813_ net62 net273 _1960_ VSS VSS VDD VDD _3141_
+ sky130_fd_sc_hd__a31o_4
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7060_ net34 _3139_ _3141_ VSS VSS VDD VDD _3143_ sky130_fd_sc_hd__a21oi_2
X_7061_ net202 _2909_ _2922_ _3135_ _3143_ VSS VSS VDD VDD
+ _3144_ sky130_fd_sc_hd__a221oi_4
X_7062_ net67 _3137_ _3144_ VSS VSS VDD VDD dp.result2\[10\]
+ sky130_fd_sc_hd__o21a_4
X_7063_ net35 _3139_ _3141_ VSS VSS VDD VDD _3145_ sky130_fd_sc_hd__a21oi_1
X_7064_ net202 _2926_ _2936_ _3135_ _3145_ VSS VSS VDD VDD
+ _3146_ sky130_fd_sc_hd__a221oi_1
X_7065_ net68 _3137_ _3146_ VSS VSS VDD VDD dp.result2\[11\]
+ sky130_fd_sc_hd__o21a_4
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7068_ net36 _3139_ _3141_ VSS VSS VDD VDD _3149_ sky130_fd_sc_hd__a21oi_1
X_7069_ _3132_ _3149_ VSS VSS VDD VDD _3150_ sky130_fd_sc_hd__nor2_1
X_7070_ net98 net69 _3150_ VSS VSS VDD VDD _3151_ sky130_fd_sc_hd__o21ai_4
X_7071_ _2781_ _2940_ _2947_ _2741_ _3151_ VSS VSS VDD VDD
+ dp.result2\[12\] sky130_fd_sc_hd__o221ai_4
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7073_ _3135_ _2956_ VSS VSS VDD VDD _3153_ sky130_fd_sc_hd__nand2_1
X_7074_ net37 _3139_ _3141_ VSS VSS VDD VDD _3154_ sky130_fd_sc_hd__a21oi_1
X_7075_ net202 _2951_ _3154_ VSS VSS VDD VDD _3155_ sky130_fd_sc_hd__a21oi_1
X_7076_ net70 _3137_ _3153_ _3155_ VSS VSS VDD VDD dp.result2\[13\]
+ sky130_fd_sc_hd__o211a_4
X_7077_ net38 _3139_ _3141_ VSS VSS VDD VDD _3156_ sky130_fd_sc_hd__a21oi_1
X_7078_ _3132_ _3156_ VSS VSS VDD VDD _3157_ sky130_fd_sc_hd__nor2_1
X_7079_ net98 net71 _3157_ VSS VSS VDD VDD _3158_ sky130_fd_sc_hd__o21ai_2
X_7080_ _2781_ _2958_ _2962_ _2741_ _3158_ VSS VSS VDD VDD
+ dp.result2\[14\] sky130_fd_sc_hd__o221ai_4
X_7081_ net39 _3139_ _3141_ VSS VSS VDD VDD _3159_ sky130_fd_sc_hd__a21oi_1
X_7082_ net202 _2964_ _2969_ _3135_ _3159_ VSS VSS VDD VDD
+ _3160_ sky130_fd_sc_hd__a221oi_1
X_7083_ net72 _3137_ _3160_ VSS VSS VDD VDD dp.result2\[15\]
+ sky130_fd_sc_hd__o21a_4
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7085_ _1806_ _1960_ VSS VSS VDD VDD _3162_ sky130_fd_sc_hd__nor2_1
X_7086_ _1813_ net39 _3162_ VSS VSS VDD VDD _3163_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7089_ _1806_ _1960_ net40 VSS VSS VDD VDD _3166_ sky130_fd_sc_hd__o21ai_0
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7091_ _3163_ _3166_ net273 VSS VSS VDD VDD _3168_ sky130_fd_sc_hd__a21oi_1
X_7092_ net202 _2972_ VSS VSS VDD VDD _3169_ sky130_fd_sc_hd__nand2_1
X_7093_ _3141_ _3168_ _3169_ VSS VSS VDD VDD _3170_ sky130_fd_sc_hd__o21ai_1
X_7094_ net73 _3137_ VSS VSS VDD VDD _3171_ sky130_fd_sc_hd__nor2_1
X_7095_ _3135_ _2976_ _3170_ _3171_ VSS VSS VDD VDD dp.result2\[16\]
+ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7097_ _1806_ _1960_ net41 VSS VSS VDD VDD _3173_ sky130_fd_sc_hd__o21ai_0
X_7098_ _3163_ _3173_ net273 VSS VSS VDD VDD _3174_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7100_ net98 net74 _3141_ _3174_ _3136_ VSS VSS VDD VDD _3176_
+ sky130_fd_sc_hd__o221ai_4
X_7101_ _2781_ _2979_ _2983_ _2741_ _3176_ VSS VSS VDD VDD
+ dp.result2\[17\] sky130_fd_sc_hd__o221ai_4
X_7102_ _1806_ _1960_ net42 VSS VSS VDD VDD _3177_ sky130_fd_sc_hd__o21ai_0
X_7103_ _3163_ _3177_ net273 VSS VSS VDD VDD _3178_ sky130_fd_sc_hd__a21oi_1
X_7104_ net98 net321 _3141_ _3178_ _3136_ VSS VSS VDD VDD
+ _3179_ sky130_fd_sc_hd__o221ai_4
X_7105_ _2781_ _2985_ _2988_ _2741_ net663 VSS VSS VDD VDD
+ dp.result2\[18\] sky130_fd_sc_hd__o221ai_4
X_7106_ _1806_ _1960_ net43 VSS VSS VDD VDD _3180_ sky130_fd_sc_hd__o21ai_0
X_7107_ _3163_ _3180_ net273 VSS VSS VDD VDD _3181_ sky130_fd_sc_hd__a21oi_1
X_7108_ _3141_ _3181_ VSS VSS VDD VDD _3182_ sky130_fd_sc_hd__nor2_1
X_7109_ _3132_ _3182_ VSS VSS VDD VDD _3183_ sky130_fd_sc_hd__nor2_1
X_7110_ _2464_ _2475_ _1960_ VSS VSS VDD VDD _3184_ sky130_fd_sc_hd__o21ai_1
X_7111_ _2781_ _2990_ _2995_ _2741_ VSS VSS VDD VDD _3185_
+ sky130_fd_sc_hd__o22ai_1
X_7112_ _3183_ _3184_ _3185_ VSS VSS VDD VDD dp.result2\[19\]
+ sky130_fd_sc_hd__a21o_4
X_7113_ net98 _3132_ VSS VSS VDD VDD _3186_ sky130_fd_sc_hd__nor2_1
X_7114_ _2903_ _2781_ _2741_ _3274_ VSS VSS VDD VDD _3187_
+ sky130_fd_sc_hd__o22ai_1
X_7115_ net44 net98 net77 _3186_ _3187_ VSS VSS VDD VDD dp.result2\[1\]
+ sky130_fd_sc_hd__a221o_4
X_7116_ _1806_ _1960_ net45 VSS VSS VDD VDD _3188_ sky130_fd_sc_hd__o21ai_0
X_7117_ _3163_ _3188_ net273 VSS VSS VDD VDD _3189_ sky130_fd_sc_hd__a21oi_1
X_7118_ net78 net98 _3141_ _3189_ _3136_ VSS VSS VDD VDD _3190_
+ sky130_fd_sc_hd__o221ai_4
X_7119_ _2781_ _3000_ _3004_ _2741_ net851 VSS VSS VDD VDD
+ dp.result2\[20\] sky130_fd_sc_hd__o221ai_4
X_7120_ _1806_ _1960_ net46 VSS VSS VDD VDD _3191_ sky130_fd_sc_hd__o21ai_0
X_7121_ _3163_ _3191_ net273 VSS VSS VDD VDD _3192_ sky130_fd_sc_hd__a21oi_1
X_7122_ net98 net609 _3141_ _3192_ _3136_ VSS VSS VDD VDD
+ _3193_ sky130_fd_sc_hd__o221ai_4
X_7123_ _2781_ _3008_ _3011_ _2741_ net814 VSS VSS VDD VDD
+ dp.result2\[21\] sky130_fd_sc_hd__o221ai_4
X_7124_ _1806_ _1960_ net47 VSS VSS VDD VDD _3194_ sky130_fd_sc_hd__o21ai_0
X_7125_ _3163_ _3194_ net273 VSS VSS VDD VDD _3195_ sky130_fd_sc_hd__a21oi_1
X_7126_ net80 net98 _3141_ _3195_ _3136_ VSS VSS VDD VDD _3196_
+ sky130_fd_sc_hd__o221ai_4
X_7127_ _2781_ _3013_ _3020_ _2741_ net660 VSS VSS VDD VDD
+ dp.result2\[22\] sky130_fd_sc_hd__o221ai_4
X_7128_ _1806_ _1960_ net48 VSS VSS VDD VDD _3197_ sky130_fd_sc_hd__o21ai_0
X_7129_ _3163_ _3197_ net273 VSS VSS VDD VDD _3198_ sky130_fd_sc_hd__a21oi_1
X_7130_ net625 net98 _3141_ _3198_ VSS VSS VDD VDD _3199_
+ sky130_fd_sc_hd__o22ai_4
X_7131_ _0128_ _3023_ _3031_ _3135_ VSS VSS VDD VDD _3200_
+ sky130_fd_sc_hd__a22oi_2
X_7132_ _3136_ net711 _3200_ VSS VSS VDD VDD dp.result2\[23\]
+ sky130_fd_sc_hd__a21boi_4
X_7133_ _2781_ _3033_ VSS VSS VDD VDD _3201_ sky130_fd_sc_hd__nor2_1
X_7134_ _3040_ _3135_ _3201_ VSS VSS VDD VDD _3202_ sky130_fd_sc_hd__a21oi_4
X_7135_ _3202_ _1960_ VSS VSS VDD VDD _3203_ sky130_fd_sc_hd__nand2_4
X_7136_ _1806_ _1960_ net49 VSS VSS VDD VDD _3204_ sky130_fd_sc_hd__o21ai_0
X_7137_ _3163_ _3204_ _3140_ VSS VSS VDD VDD _3205_ sky130_fd_sc_hd__a21oi_1
X_7138_ _3141_ _3205_ _3136_ VSS VSS VDD VDD _3206_ sky130_fd_sc_hd__o21ai_1
X_7139_ net301 _3203_ _3206_ _3202_ VSS VSS VDD VDD dp.result2\[24\]
+ sky130_fd_sc_hd__a2bb2oi_4
X_7140_ _1806_ _1960_ net50 VSS VSS VDD VDD _3207_ sky130_fd_sc_hd__o21ai_1
X_7141_ _3163_ _3207_ net273 VSS VSS VDD VDD _3208_ sky130_fd_sc_hd__a21oi_4
X_7142_ _3141_ _3208_ VSS VSS VDD VDD _3209_ sky130_fd_sc_hd__nor2_1
X_7143_ _0128_ _3044_ _3050_ _3135_ _3209_ VSS VSS VDD VDD
+ _3210_ sky130_fd_sc_hd__a221oi_1
X_7144_ _3137_ net617 _3210_ VSS VSS VDD VDD dp.result2\[25\]
+ sky130_fd_sc_hd__o21a_4
X_7145_ _1806_ _1960_ net51 VSS VSS VDD VDD _3211_ sky130_fd_sc_hd__o21ai_4
X_7146_ _3163_ _3211_ _3140_ VSS VSS VDD VDD _3212_ sky130_fd_sc_hd__a21oi_1
X_7147_ _0128_ _3053_ VSS VSS VDD VDD _3213_ sky130_fd_sc_hd__nand2_1
X_7148_ _3137_ net284 _3141_ _3212_ _3213_ VSS VSS VDD VDD
+ _3214_ sky130_fd_sc_hd__o221ai_4
X_7149_ _3135_ _3058_ net607 VSS VSS VDD VDD dp.result2\[26\]
+ sky130_fd_sc_hd__a21oi_4
X_7150_ _2781_ _3060_ _3066_ _2741_ VSS VSS VDD VDD _3215_
+ sky130_fd_sc_hd__o22ai_2
X_7151_ _1806_ _1960_ net52 VSS VSS VDD VDD _3216_ sky130_fd_sc_hd__o21ai_0
X_7152_ _3163_ _3216_ _3140_ VSS VSS VDD VDD _3217_ sky130_fd_sc_hd__a21oi_1
X_7153_ _3141_ _3217_ _3136_ VSS VSS VDD VDD _3218_ sky130_fd_sc_hd__o21ai_0
X_7154_ _3215_ _3218_ VSS VSS VDD VDD _3219_ sky130_fd_sc_hd__nand2b_1
X_7155_ net98 _3215_ net85 _3219_ VSS VSS VDD VDD dp.result2\[27\]
+ sky130_fd_sc_hd__o31a_4
X_7156_ _1806_ _1960_ net53 VSS VSS VDD VDD _3220_ sky130_fd_sc_hd__o21ai_0
X_7157_ _3163_ _3220_ _3140_ VSS VSS VDD VDD _3221_ sky130_fd_sc_hd__a21oi_1
X_7158_ net98 net280 _3141_ _3221_ _3136_ VSS VSS VDD VDD
+ _3222_ sky130_fd_sc_hd__o221ai_4
X_7159_ _2781_ _3068_ _3075_ _2741_ _3222_ VSS VSS VDD VDD
+ dp.result2\[28\] sky130_fd_sc_hd__o221ai_4
X_7160_ _1806_ _1960_ net54 VSS VSS VDD VDD _3223_ sky130_fd_sc_hd__o21ai_0
X_7161_ _3163_ _3223_ _3140_ VSS VSS VDD VDD _3224_ sky130_fd_sc_hd__a21oi_1
X_7162_ _3141_ _3224_ _3136_ VSS VSS VDD VDD _3225_ sky130_fd_sc_hd__o21ai_2
X_7163_ _2741_ _3082_ VSS VSS VDD VDD _3226_ sky130_fd_sc_hd__nor2_1
X_7164_ _2781_ _3077_ _3225_ _1960_ VSS VSS VDD VDD _3227_
+ sky130_fd_sc_hd__o22ai_1
X_7165_ _3226_ _3227_ VSS VSS VDD VDD _3228_ sky130_fd_sc_hd__nor2_4
X_7166_ net420 _3225_ _3228_ VSS VSS VDD VDD dp.result2\[29\]
+ sky130_fd_sc_hd__o21ai_4
X_7167_ net122 net202 _3135_ _3084_ VSS VSS VDD VDD _3229_
+ sky130_fd_sc_hd__a22oi_1
X_7168_ net55 _1960_ net88 _3137_ _3229_ VSS VSS VDD VDD dp.result2\[2\]
+ sky130_fd_sc_hd__o221a_4
X_7169_ _1806_ _1960_ net56 VSS VSS VDD VDD _3230_ sky130_fd_sc_hd__o21ai_1
X_7170_ _3163_ _3230_ net273 VSS VSS VDD VDD _3231_ sky130_fd_sc_hd__a21oi_4
X_7171_ _3141_ _3231_ _3136_ VSS VSS VDD VDD _3232_ sky130_fd_sc_hd__o21ai_2
X_7172_ net275 _2692_ net98 VSS VSS VDD VDD _3233_ sky130_fd_sc_hd__a21oi_4
X_7173_ _3090_ _3094_ _3135_ VSS VSS VDD VDD _3234_ sky130_fd_sc_hd__o21ai_4
X_7174_ _2781_ _3087_ _3232_ net530 _3234_ VSS VSS VDD VDD
+ dp.result2\[30\] sky130_fd_sc_hd__o221ai_4
X_7175_ _1806_ _1960_ net57 VSS VSS VDD VDD _3235_ sky130_fd_sc_hd__o21ai_0
X_7176_ _3163_ _3235_ net273 VSS VSS VDD VDD _3236_ sky130_fd_sc_hd__a21oi_1
X_7177_ _3141_ _3236_ VSS VSS VDD VDD _3237_ sky130_fd_sc_hd__or2_2
X_7178_ _1818_ _2721_ _3237_ VSS VSS VDD VDD _3238_ sky130_fd_sc_hd__and3_1
X_7179_ _2701_ _2707_ _2709_ _3238_ VSS VSS VDD VDD _3239_
+ sky130_fd_sc_hd__o31ai_1
X_7180_ _2714_ _2721_ _3237_ VSS VSS VDD VDD _3240_ sky130_fd_sc_hd__and3_1
X_7181_ net98 _3237_ _3240_ VSS VSS VDD VDD _3241_ sky130_fd_sc_hd__a21oi_1
X_7182_ _3136_ _3241_ _3239_ VSS VSS VDD VDD _3242_ sky130_fd_sc_hd__and3_4
X_7183_ _0128_ _3097_ _3103_ _3135_ _3242_ VSS VSS VDD VDD
+ dp.result2\[31\] sky130_fd_sc_hd__a221oi_4
X_7184_ _1960_ net91 VSS VSS VDD VDD _3243_ sky130_fd_sc_hd__nand2_1
X_7185_ net58 net98 _3132_ VSS VSS VDD VDD _3244_ sky130_fd_sc_hd__a21oi_1
X_7186_ _3543_ _2781_ _2741_ _3104_ VSS VSS VDD VDD _3245_
+ sky130_fd_sc_hd__o22ai_2
X_7187_ _3243_ _3244_ _3245_ VSS VSS VDD VDD dp.result2\[3\]
+ sky130_fd_sc_hd__a21oi_4
X_7188_ net59 net92 _1960_ VSS VSS VDD VDD _3246_ sky130_fd_sc_hd__mux2_1
X_7189_ _2781_ _3105_ _3106_ _2741_ VSS VSS VDD VDD _3247_
+ sky130_fd_sc_hd__o22ai_2
X_7190_ _3136_ _3246_ _3247_ VSS VSS VDD VDD dp.result2\[4\]
+ sky130_fd_sc_hd__a21o_4
X_7191_ net202 _3108_ _3110_ _3135_ VSS VSS VDD VDD _3248_
+ sky130_fd_sc_hd__a22oi_2
X_7192_ net60 _1960_ net93 _3137_ _3248_ VSS VSS VDD VDD dp.result2\[5\]
+ sky130_fd_sc_hd__o221a_4
X_7193_ net61 net613 _1960_ VSS VSS VDD VDD _3249_ sky130_fd_sc_hd__mux2i_4
X_7194_ net202 _3112_ _3115_ _3135_ VSS VSS VDD VDD _3250_
+ sky130_fd_sc_hd__a22oi_1
X_7195_ _3249_ _3136_ _3250_ VSS VSS VDD VDD dp.result2\[6\]
+ sky130_fd_sc_hd__a21boi_4
X_7196_ net62 net98 VSS VSS VDD VDD _3251_ sky130_fd_sc_hd__and2_0
X_7197_ _1960_ net493 _3132_ _3251_ VSS VSS VDD VDD _3252_
+ sky130_fd_sc_hd__a211oi_4
X_7198_ net202 _3117_ _3120_ _3135_ _3252_ VSS VSS VDD VDD
+ dp.result2\[7\] sky130_fd_sc_hd__a221oi_4
X_7199_ net63 _3139_ _3141_ VSS VSS VDD VDD _3253_ sky130_fd_sc_hd__a21oi_1
X_7200_ _3132_ _3253_ VSS VSS VDD VDD _3254_ sky130_fd_sc_hd__nor2_1
X_7201_ net98 net96 _3254_ VSS VSS VDD VDD _3255_ sky130_fd_sc_hd__o21ai_2
X_7202_ _2781_ _3121_ _3123_ _2741_ _3255_ VSS VSS VDD VDD
+ dp.result2\[8\] sky130_fd_sc_hd__o221ai_4
X_7203_ net64 _3139_ _3141_ VSS VSS VDD VDD _3256_ sky130_fd_sc_hd__a21oi_1
X_7204_ _3132_ _3256_ VSS VSS VDD VDD _3257_ sky130_fd_sc_hd__nor2_1
X_7205_ net98 net97 _3257_ VSS VSS VDD VDD _3258_ sky130_fd_sc_hd__o21ai_2
X_7206_ _2781_ _3125_ _3128_ _2741_ _3258_ VSS VSS VDD VDD
+ dp.result2\[9\] sky130_fd_sc_hd__o221ai_4
X_7207_ net27 net28 net29 _0041_ VSS VSS VDD VDD net132 sky130_fd_sc_hd__and4_1
X_7208_ net99 _0109_ _1805_ VSS VSS VDD VDD _3259_ sky130_fd_sc_hd__nand3_2
X_7209_ _1378_ _3259_ VSS VSS VDD VDD net134 sky130_fd_sc_hd__and2_0
X_7210_ net99 _0109_ _1805_ VSS VSS VDD VDD _3260_ sky130_fd_sc_hd__and3_2
X_7211_ _0401_ _1340_ _3260_ VSS VSS VDD VDD net135 sky130_fd_sc_hd__nor3_2
X_7212_ _1299_ _3260_ VSS VSS VDD VDD net136 sky130_fd_sc_hd__nor2_2
X_7213_ _1264_ _3259_ VSS VSS VDD VDD net137 sky130_fd_sc_hd__and2_0
X_7214_ _1218_ _3259_ VSS VSS VDD VDD net138 sky130_fd_sc_hd__and2_0
X_7215_ _1174_ _3260_ VSS VSS VDD VDD net139 sky130_fd_sc_hd__nor2_2
X_7216_ net5 net99 VSS VSS VDD VDD _3261_ sky130_fd_sc_hd__nor2b_4
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_7219_ _1127_ _3261_ VSS VSS VDD VDD net140 sky130_fd_sc_hd__nor2_1
X_7220_ _1060_ _3261_ VSS VSS VDD VDD net141 sky130_fd_sc_hd__nor2_1
X_7221_ _1002_ _3261_ VSS VSS VDD VDD net142 sky130_fd_sc_hd__nor2_1
X_7222_ _0950_ VSS VSS VDD VDD _3264_ sky130_fd_sc_hd__inv_1
X_7223_ _3264_ _3261_ VSS VSS VDD VDD net143 sky130_fd_sc_hd__nor2_1
X_7224_ _0881_ _3261_ VSS VSS VDD VDD net145 sky130_fd_sc_hd__nor2_2
X_7225_ _0838_ _3261_ VSS VSS VDD VDD net146 sky130_fd_sc_hd__nor2_2
X_7226_ _0794_ _3261_ VSS VSS VDD VDD net147 sky130_fd_sc_hd__nor2_2
X_7227_ _0401_ _0747_ _3261_ VSS VSS VDD VDD net148 sky130_fd_sc_hd__nor3_2
X_7228_ _0694_ _3261_ VSS VSS VDD VDD net149 sky130_fd_sc_hd__nor2_2
X_7229_ _0636_ _3261_ VSS VSS VDD VDD net150 sky130_fd_sc_hd__nor2_2
X_7230_ _0571_ _3261_ VSS VSS VDD VDD net151 sky130_fd_sc_hd__nor2_2
X_7231_ _0516_ _3261_ VSS VSS VDD VDD net152 sky130_fd_sc_hd__nor2_2
X_7232_ _0458_ _3261_ VSS VSS VDD VDD net153 sky130_fd_sc_hd__nor2_2
X_7233_ _0383_ _0403_ _3261_ VSS VSS VDD VDD net154 sky130_fd_sc_hd__nor3_2
X_7234_ _0324_ _3261_ VSS VSS VDD VDD net156 sky130_fd_sc_hd__nor2_1
X_7235_ _0298_ _3261_ VSS VSS VDD VDD net157 sky130_fd_sc_hd__nor2_2
X_7236_ _1455_ _3260_ VSS VSS VDD VDD net163 sky130_fd_sc_hd__nor2_1
X_7237_ _1419_ _3260_ VSS VSS VDD VDD net164 sky130_fd_sc_hd__nor2_1
X_7238_ _3266_ _3265_ _3267_ VSS VSS VDD VDD _3268_ _3269_
+ sky130_fd_sc_hd__fa_2
X_7239_ _3270_ _3271_ _3272_ VSS VSS VDD VDD _3273_ _3274_
+ sky130_fd_sc_hd__fa_2
X_7240_ _3275_ _3276_ VSS VSS VDD VDD _3277_ _3278_ sky130_fd_sc_hd__ha_1
X_7241_ net498 _3280_ VSS VSS VDD VDD _3281_ _3282_ sky130_fd_sc_hd__ha_1
X_7242_ _3283_ _3284_ VSS VSS VDD VDD _3285_ _3286_ sky130_fd_sc_hd__ha_1
X_7243_ _3287_ _0274_ VSS VSS VDD VDD _3289_ _3290_ sky130_fd_sc_hd__ha_1
X_7244_ _3291_ _3292_ VSS VSS VDD VDD _3293_ _3294_ sky130_fd_sc_hd__ha_1
X_7245_ _0371_ _3296_ VSS VSS VDD VDD _3297_ _3298_ sky130_fd_sc_hd__ha_1
X_7246_ _3299_ _3300_ VSS VSS VDD VDD _3301_ _3302_ sky130_fd_sc_hd__ha_2
X_7247_ _3303_ _3304_ VSS VSS VDD VDD _3305_ _3306_ sky130_fd_sc_hd__ha_1
X_7248_ _3307_ _3308_ VSS VSS VDD VDD _3309_ _3310_ sky130_fd_sc_hd__ha_2
X_7249_ _3311_ _3312_ VSS VSS VDD VDD _3313_ _3314_ sky130_fd_sc_hd__ha_1
X_7250_ _3315_ _3316_ VSS VSS VDD VDD _3317_ _3318_ sky130_fd_sc_hd__ha_1
X_7251_ _3319_ _3320_ VSS VSS VDD VDD _3321_ _3322_ sky130_fd_sc_hd__ha_1
X_7252_ _3323_ _3324_ VSS VSS VDD VDD _3325_ _3326_ sky130_fd_sc_hd__ha_1
X_7253_ _0621_ _3328_ VSS VSS VDD VDD _3329_ _3330_ sky130_fd_sc_hd__ha_1
X_7254_ _3331_ _3332_ VSS VSS VDD VDD _3333_ _3334_ sky130_fd_sc_hd__ha_1
X_7255_ _3335_ _3336_ VSS VSS VDD VDD _3337_ _3338_ sky130_fd_sc_hd__ha_1
X_7256_ _3339_ _3340_ VSS VSS VDD VDD _3341_ _3342_ sky130_fd_sc_hd__ha_2
X_7257_ _3343_ _3344_ VSS VSS VDD VDD _3345_ _3346_ sky130_fd_sc_hd__ha_1
X_7258_ _3347_ _3348_ VSS VSS VDD VDD _3349_ _3350_ sky130_fd_sc_hd__ha_1
X_7259_ _3351_ _3352_ VSS VSS VDD VDD _3353_ _3354_ sky130_fd_sc_hd__ha_1
X_7260_ _3355_ _3356_ VSS VSS VDD VDD _3357_ _3358_ sky130_fd_sc_hd__ha_2
X_7261_ _3359_ _3360_ VSS VSS VDD VDD _3361_ _3362_ sky130_fd_sc_hd__ha_1
X_7262_ _3363_ _3364_ VSS VSS VDD VDD _3365_ _3366_ sky130_fd_sc_hd__ha_2
X_7263_ _3367_ _3368_ VSS VSS VDD VDD _3369_ _3370_ sky130_fd_sc_hd__ha_1
X_7264_ _3371_ _3372_ VSS VSS VDD VDD _3373_ _3374_ sky130_fd_sc_hd__ha_1
X_7265_ _3375_ _3376_ VSS VSS VDD VDD _3377_ _3378_ sky130_fd_sc_hd__ha_1
X_7266_ _3379_ _3380_ VSS VSS VDD VDD _3381_ _3382_ sky130_fd_sc_hd__ha_1
X_7267_ _3383_ _3384_ VSS VSS VDD VDD _3385_ _3386_ sky130_fd_sc_hd__ha_1
X_7268_ _3387_ _3388_ VSS VSS VDD VDD _3389_ _3390_ sky130_fd_sc_hd__ha_2
X_7269_ _1031_ _3392_ VSS VSS VDD VDD _3393_ _3394_ sky130_fd_sc_hd__ha_1
X_7270_ _3395_ _3396_ VSS VSS VDD VDD _3397_ _3398_ sky130_fd_sc_hd__ha_2
X_7271_ _3399_ _3400_ VSS VSS VDD VDD _3401_ _3402_ sky130_fd_sc_hd__ha_1
X_7272_ _3403_ _3404_ VSS VSS VDD VDD _3405_ _3406_ sky130_fd_sc_hd__ha_2
X_7273_ _3407_ _3408_ VSS VSS VDD VDD _3409_ _3410_ sky130_fd_sc_hd__ha_1
X_7274_ _3411_ _3412_ VSS VSS VDD VDD _3413_ _3414_ sky130_fd_sc_hd__ha_2
X_7275_ _3415_ _3416_ VSS VSS VDD VDD _3417_ _3418_ sky130_fd_sc_hd__ha_1
X_7276_ _3419_ _3420_ VSS VSS VDD VDD _3421_ _3422_ sky130_fd_sc_hd__ha_2
X_7277_ _3423_ _3424_ VSS VSS VDD VDD _3425_ _3426_ sky130_fd_sc_hd__ha_1
X_7278_ _3427_ _3428_ VSS VSS VDD VDD _3429_ _3430_ sky130_fd_sc_hd__ha_2
X_7279_ _3431_ _3432_ VSS VSS VDD VDD _3433_ _3434_ sky130_fd_sc_hd__ha_1
X_7280_ _3435_ _3436_ VSS VSS VDD VDD _3437_ _3438_ sky130_fd_sc_hd__ha_2
X_7281_ _3439_ _3440_ VSS VSS VDD VDD _3441_ _3442_ sky130_fd_sc_hd__ha_1
X_7282_ _3443_ _3444_ VSS VSS VDD VDD _3445_ _3446_ sky130_fd_sc_hd__ha_2
X_7283_ _3447_ _3448_ VSS VSS VDD VDD _3449_ _3450_ sky130_fd_sc_hd__ha_1
X_7284_ _3451_ _3452_ VSS VSS VDD VDD _3453_ _3454_ sky130_fd_sc_hd__ha_2
X_7285_ _3455_ _3456_ VSS VSS VDD VDD _3457_ _3458_ sky130_fd_sc_hd__ha_1
X_7286_ _3459_ _3460_ VSS VSS VDD VDD _3461_ _3462_ sky130_fd_sc_hd__ha_2
X_7287_ net852 _3464_ VSS VSS VDD VDD _3465_ _3466_ sky130_fd_sc_hd__ha_1
X_7288_ _3467_ _3468_ VSS VSS VDD VDD _3469_ _3470_ sky130_fd_sc_hd__ha_2
X_7289_ _3471_ _3472_ VSS VSS VDD VDD _3473_ _3474_ sky130_fd_sc_hd__ha_1
X_7290_ _3475_ _3476_ VSS VSS VDD VDD _3477_ _3478_ sky130_fd_sc_hd__ha_2
X_7291_ _3479_ _3480_ VSS VSS VDD VDD _3481_ _3482_ sky130_fd_sc_hd__ha_1
X_7292_ _3483_ _3484_ VSS VSS VDD VDD _3485_ _3486_ sky130_fd_sc_hd__ha_2
X_7293_ net515 _3488_ VSS VSS VDD VDD _3489_ _3490_ sky130_fd_sc_hd__ha_1
X_7294_ _3491_ _3492_ VSS VSS VDD VDD _3493_ _3494_ sky130_fd_sc_hd__ha_1
X_7295_ _3495_ _3496_ VSS VSS VDD VDD _3497_ _3498_ sky130_fd_sc_hd__ha_1
X_7296_ _3499_ _3500_ VSS VSS VDD VDD _3501_ _3502_ sky130_fd_sc_hd__ha_2
X_7297_ _3503_ _3504_ VSS VSS VDD VDD _3505_ _3506_ sky130_fd_sc_hd__ha_1
X_7298_ _3508_ _3507_ VSS VSS VDD VDD _3509_ _3510_ sky130_fd_sc_hd__ha_1
X_7299_ _1689_ _3512_ VSS VSS VDD VDD _3513_ _3514_ sky130_fd_sc_hd__ha_1
X_7300_ _3516_ _3515_ VSS VSS VDD VDD _3517_ _3518_ sky130_fd_sc_hd__ha_1
X_7301_ _3519_ _3520_ VSS VSS VDD VDD _3521_ _3522_ sky130_fd_sc_hd__ha_1
X_7302_ _3266_ _3267_ VSS VSS VDD VDD _3523_ _3524_ sky130_fd_sc_hd__ha_1
X_7303_ _3525_ _3526_ VSS VSS VDD VDD _3527_ _3528_ sky130_fd_sc_hd__ha_1
X_7304_ _3529_ _3530_ VSS VSS VDD VDD _3270_ _3531_ sky130_fd_sc_hd__ha_2
X_7305_ _3271_ _3272_ VSS VSS VDD VDD _3532_ _3533_ sky130_fd_sc_hd__ha_1
X_7306_ _3534_ _3535_ VSS VSS VDD VDD _3536_ _3537_ sky130_fd_sc_hd__ha_1
X_7307_ _3538_ _3539_ VSS VSS VDD VDD _3540_ _3541_ sky130_fd_sc_hd__ha_1
X_7308_ net122 net125 VSS VSS VDD VDD _3542_ _3543_ sky130_fd_sc_hd__ha_2
X_7309_ _3544_ _3545_ VSS VSS VDD VDD _3546_ _3547_ sky130_fd_sc_hd__ha_1
X_7310_ _3548_ _3549_ VSS VSS VDD VDD _3550_ _3551_ sky130_fd_sc_hd__ha_1
X_7311_ _3552_ _3553_ VSS VSS VDD VDD _3554_ _3555_ sky130_fd_sc_hd__ha_1
X_7312_ _3556_ _3557_ VSS VSS VDD VDD _3558_ _3559_ sky130_fd_sc_hd__ha_1
X_7313_ _3560_ _3561_ VSS VSS VDD VDD _3562_ _3563_ sky130_fd_sc_hd__ha_1
X_7314_ _3564_ _3565_ VSS VSS VDD VDD _3566_ _3567_ sky130_fd_sc_hd__ha_1
X_7315_ _3568_ _3569_ VSS VSS VDD VDD _3570_ _3571_ sky130_fd_sc_hd__ha_1
X_7316_ _3572_ _3573_ VSS VSS VDD VDD _3574_ _3575_ sky130_fd_sc_hd__ha_1
X_7317_ _3576_ _3577_ VSS VSS VDD VDD _3578_ _3579_ sky130_fd_sc_hd__ha_1
X_7318_ _3580_ _3581_ VSS VSS VDD VDD _3582_ _3583_ sky130_fd_sc_hd__ha_2
X_7319_ _3584_ _3585_ VSS VSS VDD VDD _3586_ _3587_ sky130_fd_sc_hd__ha_2
X_7320_ _3588_ _3589_ VSS VSS VDD VDD _3590_ _3591_ sky130_fd_sc_hd__ha_1
X_7321_ _3592_ _3593_ VSS VSS VDD VDD _3594_ _3595_ sky130_fd_sc_hd__ha_2
X_7322_ _3596_ _3597_ VSS VSS VDD VDD _3598_ _3599_ sky130_fd_sc_hd__ha_2
X_7323_ _3600_ _3601_ VSS VSS VDD VDD _3602_ _3603_ sky130_fd_sc_hd__ha_2
X_7324_ _3604_ _3605_ VSS VSS VDD VDD _3606_ _3607_ sky130_fd_sc_hd__ha_2
X_7325_ _3608_ _3609_ VSS VSS VDD VDD _3610_ _3611_ sky130_fd_sc_hd__ha_1
X_7326_ _3612_ _3613_ VSS VSS VDD VDD _3614_ _3615_ sky130_fd_sc_hd__ha_2
X_7327_ _3616_ _3617_ VSS VSS VDD VDD _3618_ _3619_ sky130_fd_sc_hd__ha_1
X_7328_ _3620_ _3621_ VSS VSS VDD VDD _3622_ _3623_ sky130_fd_sc_hd__ha_1
X_7329_ _3624_ _3625_ VSS VSS VDD VDD _3626_ _3627_ sky130_fd_sc_hd__ha_1
X_7330_ _3628_ _3629_ VSS VSS VDD VDD _3630_ _3631_ sky130_fd_sc_hd__ha_1
X_7331_ _3632_ _3633_ VSS VSS VDD VDD _3634_ _3635_ sky130_fd_sc_hd__ha_2
X_7332_ _3636_ _3637_ VSS VSS VDD VDD _3638_ _3639_ sky130_fd_sc_hd__ha_1
X_7333_ _3640_ _3641_ VSS VSS VDD VDD _3642_ _3643_ sky130_fd_sc_hd__ha_1
X_7334_ _3644_ _3645_ VSS VSS VDD VDD _3646_ _3647_ sky130_fd_sc_hd__ha_1
X_7335_ _3648_ _3649_ VSS VSS VDD VDD _3650_ _3651_ sky130_fd_sc_hd__ha_1
Xclkbuf_leaf_0_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xdp.pcreg.q\[0\]$_DFFE_PP0P_ clknet_leaf_63_clk _0032_ _0031_
+ VSS VSS VDD VDD net100 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[10\]$_DFF_PP0_ clknet_leaf_68_clk dp.ISRmux.d0\[10\]
+ _0031_ VSS VSS VDD VDD net101 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[11\]$_DFF_PP0_ clknet_leaf_69_clk dp.ISRmux.d0\[11\]
+ _0031_ VSS VSS VDD VDD net102 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[12\]$_DFF_PP0_ clknet_leaf_67_clk dp.ISRmux.d0\[12\]
+ _0031_ VSS VSS VDD VDD net103 sky130_fd_sc_hd__dfrtp_2
Xdp.pcreg.q\[13\]$_DFF_PP0_ clknet_leaf_69_clk dp.ISRmux.d0\[13\]
+ _0031_ VSS VSS VDD VDD net104 sky130_fd_sc_hd__dfrtp_2
Xdp.pcreg.q\[14\]$_DFF_PP0_ clknet_leaf_69_clk dp.ISRmux.d0\[14\]
+ _0031_ VSS VSS VDD VDD net105 sky130_fd_sc_hd__dfrtp_2
Xdp.pcreg.q\[15\]$_DFF_PP0_ clknet_leaf_66_clk dp.ISRmux.d0\[15\]
+ _0031_ VSS VSS VDD VDD net106 sky130_fd_sc_hd__dfrtp_2
Xdp.pcreg.q\[16\]$_DFF_PP0_ clknet_leaf_66_clk dp.ISRmux.d0\[16\]
+ _0031_ VSS VSS VDD VDD net107 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[17\]$_DFF_PP0_ clknet_leaf_63_clk dp.ISRmux.d0\[17\]
+ _0031_ VSS VSS VDD VDD net108 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[18\]$_DFF_PP0_ clknet_leaf_63_clk dp.ISRmux.d0\[18\]
+ _0031_ VSS VSS VDD VDD net109 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[19\]$_DFF_PP0_ clknet_leaf_63_clk dp.ISRmux.d0\[19\]
+ _0031_ VSS VSS VDD VDD net110 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[1\]$_DFFE_PP0P_ clknet_leaf_66_clk _0033_ _0031_
+ VSS VSS VDD VDD net111 sky130_fd_sc_hd__dfrtp_1
Xdp.pcreg.q\[20\]$_DFF_PP0_ clknet_leaf_64_clk dp.ISRmux.d0\[20\]
+ _0031_ VSS VSS VDD VDD net112 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[21\]$_DFF_PP0_ clknet_leaf_65_clk dp.ISRmux.d0\[21\]
+ _0031_ VSS VSS VDD VDD net113 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[22\]$_DFF_PP0_ clknet_leaf_65_clk dp.ISRmux.d0\[22\]
+ _0031_ VSS VSS VDD VDD net114 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[23\]$_DFF_PP0_ clknet_leaf_65_clk dp.ISRmux.d0\[23\]
+ _0031_ VSS VSS VDD VDD net115 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[24\]$_DFF_PP0_ clknet_leaf_47_clk dp.ISRmux.d0\[24\]
+ _0031_ VSS VSS VDD VDD net116 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[25\]$_DFF_PP0_ clknet_leaf_65_clk dp.ISRmux.d0\[25\]
+ _0031_ VSS VSS VDD VDD net117 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[26\]$_DFF_PP0_ clknet_leaf_47_clk dp.ISRmux.d0\[26\]
+ _0031_ VSS VSS VDD VDD net118 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[27\]$_DFF_PP0_ clknet_leaf_47_clk dp.ISRmux.d0\[27\]
+ _0031_ VSS VSS VDD VDD net119 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[28\]$_DFF_PP0_ clknet_leaf_47_clk dp.ISRmux.d0\[28\]
+ _0031_ VSS VSS VDD VDD net120 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[29\]$_DFF_PP0_ clknet_leaf_48_clk dp.ISRmux.d0\[29\]
+ _0031_ VSS VSS VDD VDD net121 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[2\]$_DFF_PP0_ clknet_leaf_66_clk dp.ISRmux.d0\[2\]
+ _0031_ VSS VSS VDD VDD net122 sky130_fd_sc_hd__dfrtp_2
Xdp.pcreg.q\[30\]$_DFF_PP0_ clknet_leaf_47_clk dp.ISRmux.d0\[30\]
+ _0031_ VSS VSS VDD VDD net123 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[31\]$_DFF_PP0_ clknet_leaf_47_clk dp.ISRmux.d0\[31\]
+ _0031_ VSS VSS VDD VDD net124 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[3\]$_DFF_PP0_ clknet_leaf_66_clk dp.ISRmux.d0\[3\]
+ _0031_ VSS VSS VDD VDD net125 sky130_fd_sc_hd__dfrtp_2
Xdp.pcreg.q\[4\]$_DFF_PP0_ clknet_leaf_67_clk dp.ISRmux.d0\[4\]
+ _0031_ VSS VSS VDD VDD net126 sky130_fd_sc_hd__dfrtp_2
Xdp.pcreg.q\[5\]$_DFF_PP0_ clknet_leaf_67_clk dp.ISRmux.d0\[5\]
+ _0031_ VSS VSS VDD VDD net127 sky130_fd_sc_hd__dfrtp_2
Xdp.pcreg.q\[6\]$_DFF_PP0_ clknet_leaf_67_clk dp.ISRmux.d0\[6\]
+ _0031_ VSS VSS VDD VDD net128 sky130_fd_sc_hd__dfrtp_1
Xdp.pcreg.q\[7\]$_DFF_PP0_ clknet_leaf_68_clk dp.ISRmux.d0\[7\]
+ _0031_ VSS VSS VDD VDD net129 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[8\]$_DFF_PP0_ clknet_leaf_69_clk dp.ISRmux.d0\[8\]
+ _0031_ VSS VSS VDD VDD net130 sky130_fd_sc_hd__dfrtp_4
Xdp.pcreg.q\[9\]$_DFF_PP0_ clknet_leaf_68_clk dp.ISRmux.d0\[9\]
+ _0031_ VSS VSS VDD VDD net131 sky130_fd_sc_hd__dfrtp_4
Xdp.rf.rf\[0\]\[0\]$_DFFE_PP_ clknet_leaf_50_clk net309 net216
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[10\]$_DFFE_PP_ clknet_leaf_92_clk dp.result2\[10\]
+ net217 VSS VSS VDD VDD dp.rf.rf\[0\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[11\]$_DFFE_PP_ clknet_leaf_97_clk dp.result2\[11\]
+ net218 VSS VSS VDD VDD dp.rf.rf\[0\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[12\]$_DFFE_PP_ clknet_leaf_87_clk net638 net219
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[13\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[13\]
+ net220 VSS VSS VDD VDD dp.rf.rf\[0\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[14\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[14\]
+ net221 VSS VSS VDD VDD dp.rf.rf\[0\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ net222 VSS VSS VDD VDD dp.rf.rf\[0\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[18\]$_DFFE_PP_ clknet_leaf_55_clk net661 net223
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ net224 VSS VSS VDD VDD dp.rf.rf\[0\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[1\]$_DFFE_PP_ clknet_leaf_51_clk dp.result2\[1\]
+ net225 VSS VSS VDD VDD dp.rf.rf\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk net850 net226
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk net742 net227
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net649 net228
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[23\]$_DFFE_PP_ clknet_leaf_31_clk net614 net229
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[24\]$_DFFE_PP_ clknet_leaf_26_clk net678 net230
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[25\]$_DFFE_PP_ clknet_leaf_14_clk net931 net231
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[26\]$_DFFE_PP_ clknet_leaf_5_clk net608 net232
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ net233 VSS VSS VDD VDD dp.rf.rf\[0\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[28\]$_DFFE_PP_ clknet_leaf_25_clk dp.result2\[28\]
+ net234 VSS VSS VDD VDD dp.rf.rf\[0\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[29\]$_DFFE_PP_ clknet_leaf_25_clk net734 net235
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[2\]$_DFFE_PP_ clknet_leaf_82_clk dp.result2\[2\]
+ net236 VSS VSS VDD VDD dp.rf.rf\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net474 net237
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[31\]$_DFFE_PP_ clknet_leaf_38_clk net524 net238
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[3\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[3\]
+ net239 VSS VSS VDD VDD dp.rf.rf\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ net240 VSS VSS VDD VDD dp.rf.rf\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ net241 VSS VSS VDD VDD dp.rf.rf\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[6\]$_DFFE_PP_ clknet_leaf_0_clk dp.result2\[6\]
+ net242 VSS VSS VDD VDD dp.rf.rf\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[7\]$_DFFE_PP_ clknet_leaf_89_clk net272 net243
+ VSS VSS VDD VDD dp.rf.rf\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[8\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[8\]
+ net244 VSS VSS VDD VDD dp.rf.rf\[0\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[0\]\[9\]$_DFFE_PP_ clknet_leaf_103_clk dp.result2\[9\]
+ net245 VSS VSS VDD VDD dp.rf.rf\[0\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[0\]$_DFFE_PP_ clknet_leaf_49_clk dp.result2\[0\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[10\]$_DFFE_PP_ clknet_leaf_94_clk dp.result2\[10\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[12\]$_DFFE_PP_ clknet_leaf_91_clk dp.result2\[12\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[13\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[13\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[14\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[14\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[16\]$_DFFE_PP_ clknet_leaf_60_clk net933
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[17\]$_DFFE_PP_ clknet_leaf_56_clk net934
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[18\]$_DFFE_PP_ clknet_leaf_54_clk net736
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[19\]$_DFFE_PP_ clknet_leaf_54_clk dp.result2\[19\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[1\]$_DFFE_PP_ clknet_leaf_46_clk dp.result2\[1\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[20\]$_DFFE_PP_ clknet_leaf_22_clk dp.result2\[20\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk dp.result2\[21\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[22\]$_DFFE_PP_ clknet_leaf_88_clk net650
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[23\]$_DFFE_PP_ clknet_leaf_29_clk net614
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[24\]$_DFFE_PP_ clknet_leaf_27_clk net735
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[25\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[25\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk dp.result2\[26\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[27\]$_DFFE_PP_ clknet_leaf_36_clk dp.result2\[27\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[28\]$_DFFE_PP_ clknet_leaf_22_clk net635
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[29\]$_DFFE_PP_ clknet_leaf_25_clk net734
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[2\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[2\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net475
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[31\]$_DFFE_PP_ clknet_leaf_37_clk net688
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[3\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[3\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[4\]$_DFFE_PP_ clknet_leaf_6_clk dp.result2\[4\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[5\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[5\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[6\]$_DFFE_PP_ clknet_leaf_103_clk dp.result2\[6\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[7\]$_DFFE_PP_ clknet_leaf_97_clk net272 _0000_
+ VSS VSS VDD VDD dp.rf.rf\[10\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[8\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[8\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[10\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0000_ VSS VSS VDD VDD dp.rf.rf\[10\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[0\]$_DFFE_PP_ clknet_leaf_49_clk dp.result2\[0\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[10\]$_DFFE_PP_ clknet_leaf_94_clk dp.result2\[10\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[11\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[11\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[12\]$_DFFE_PP_ clknet_leaf_91_clk dp.result2\[12\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[13\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[13\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[16\]$_DFFE_PP_ clknet_leaf_60_clk net933
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[17\]$_DFFE_PP_ clknet_leaf_60_clk net934
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[18\]$_DFFE_PP_ clknet_leaf_54_clk net736
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[1\]$_DFFE_PP_ clknet_leaf_46_clk dp.result2\[1\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[20\]$_DFFE_PP_ clknet_leaf_25_clk dp.result2\[20\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk dp.result2\[21\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[22\]$_DFFE_PP_ clknet_leaf_89_clk dp.result2\[22\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[23\]$_DFFE_PP_ clknet_leaf_29_clk net614
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[24\]$_DFFE_PP_ clknet_leaf_29_clk net733
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[25\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[25\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk dp.result2\[26\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[28\]$_DFFE_PP_ clknet_leaf_22_clk net635
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[2\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[2\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net475
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[31\]$_DFFE_PP_ clknet_leaf_37_clk net688
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[6\]$_DFFE_PP_ clknet_leaf_103_clk dp.result2\[6\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[7\]$_DFFE_PP_ clknet_leaf_97_clk net272 _0001_
+ VSS VSS VDD VDD dp.rf.rf\[11\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[8\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[8\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[11\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0001_ VSS VSS VDD VDD dp.rf.rf\[11\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[0\]$_DFFE_PP_ clknet_leaf_64_clk net358 _0002_
+ VSS VSS VDD VDD dp.rf.rf\[12\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[10\]$_DFFE_PP_ clknet_leaf_94_clk dp.result2\[10\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[12\]$_DFFE_PP_ clknet_leaf_79_clk net638
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[13\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[13\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[14\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[14\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[15\]$_DFFE_PP_ clknet_leaf_0_clk dp.result2\[15\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[16\]$_DFFE_PP_ clknet_leaf_56_clk net849
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[17\]$_DFFE_PP_ clknet_leaf_56_clk dp.result2\[17\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[18\]$_DFFE_PP_ clknet_leaf_56_clk net661
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[19\]$_DFFE_PP_ clknet_leaf_54_clk dp.result2\[19\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[1\]$_DFFE_PP_ clknet_leaf_48_clk dp.result2\[1\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[20\]$_DFFE_PP_ clknet_leaf_25_clk dp.result2\[20\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[21\]$_DFFE_PP_ clknet_leaf_7_clk net737 _0002_
+ VSS VSS VDD VDD dp.rf.rf\[12\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[22\]$_DFFE_PP_ clknet_leaf_10_clk net658
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[23\]$_DFFE_PP_ clknet_leaf_33_clk net614
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[24\]$_DFFE_PP_ clknet_leaf_29_clk net733
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk net931
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk net588 _0002_
+ VSS VSS VDD VDD dp.rf.rf\[12\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[28\]$_DFFE_PP_ clknet_leaf_22_clk dp.result2\[28\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[2\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[2\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[30\]$_DFFE_PP_ clknet_leaf_39_clk net531
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[31\]$_DFFE_PP_ clknet_leaf_36_clk net514
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[6\]$_DFFE_PP_ clknet_leaf_0_clk dp.result2\[6\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[7\]$_DFFE_PP_ clknet_leaf_98_clk net272 _0002_
+ VSS VSS VDD VDD dp.rf.rf\[12\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[8\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[8\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[12\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0002_ VSS VSS VDD VDD dp.rf.rf\[12\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[0\]$_DFFE_PP_ clknet_leaf_64_clk net358 _0003_
+ VSS VSS VDD VDD dp.rf.rf\[13\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[10\]$_DFFE_PP_ clknet_leaf_94_clk dp.result2\[10\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[12\]$_DFFE_PP_ clknet_leaf_92_clk net648
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[13\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[13\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[14\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[14\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[15\]$_DFFE_PP_ clknet_leaf_0_clk dp.result2\[15\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[16\]$_DFFE_PP_ clknet_leaf_56_clk net849
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[17\]$_DFFE_PP_ clknet_leaf_56_clk net934
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[18\]$_DFFE_PP_ clknet_leaf_54_clk net661
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[19\]$_DFFE_PP_ clknet_leaf_54_clk dp.result2\[19\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[1\]$_DFFE_PP_ clknet_leaf_48_clk dp.result2\[1\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[20\]$_DFFE_PP_ clknet_leaf_24_clk dp.result2\[20\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk dp.result2\[21\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[22\]$_DFFE_PP_ clknet_leaf_10_clk net658
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[23\]$_DFFE_PP_ clknet_leaf_31_clk net614
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[24\]$_DFFE_PP_ clknet_leaf_29_clk net733
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk net931
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk net588 _0003_
+ VSS VSS VDD VDD dp.rf.rf\[13\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[28\]$_DFFE_PP_ clknet_leaf_22_clk dp.result2\[28\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net734
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[2\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[2\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net475
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[31\]$_DFFE_PP_ clknet_leaf_37_clk net688
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[6\]$_DFFE_PP_ clknet_leaf_103_clk dp.result2\[6\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[7\]$_DFFE_PP_ clknet_leaf_98_clk net272 _0003_
+ VSS VSS VDD VDD dp.rf.rf\[13\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[8\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[8\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[13\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0003_ VSS VSS VDD VDD dp.rf.rf\[13\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[0\]$_DFFE_PP_ clknet_leaf_50_clk net308 _0004_
+ VSS VSS VDD VDD dp.rf.rf\[14\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[10\]$_DFFE_PP_ clknet_leaf_94_clk dp.result2\[10\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[12\]$_DFFE_PP_ clknet_leaf_90_clk net639
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[13\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[13\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[14\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[14\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[16\]$_DFFE_PP_ clknet_leaf_60_clk net933
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[17\]$_DFFE_PP_ clknet_leaf_56_clk net934
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[18\]$_DFFE_PP_ clknet_leaf_54_clk dp.result2\[18\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[1\]$_DFFE_PP_ clknet_leaf_46_clk dp.result2\[1\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[20\]$_DFFE_PP_ clknet_leaf_25_clk dp.result2\[20\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk dp.result2\[21\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[22\]$_DFFE_PP_ clknet_leaf_10_clk net649
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[23\]$_DFFE_PP_ clknet_leaf_30_clk net614
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[24\]$_DFFE_PP_ clknet_leaf_29_clk net733
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk dp.result2\[25\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk net588 _0004_
+ VSS VSS VDD VDD dp.rf.rf\[14\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[28\]$_DFFE_PP_ clknet_leaf_22_clk net635
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[2\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[2\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net475
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[31\]$_DFFE_PP_ clknet_leaf_37_clk net688
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[6\]$_DFFE_PP_ clknet_leaf_103_clk dp.result2\[6\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[7\]$_DFFE_PP_ clknet_leaf_98_clk net272 _0004_
+ VSS VSS VDD VDD dp.rf.rf\[14\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[8\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[8\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[14\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0004_ VSS VSS VDD VDD dp.rf.rf\[14\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[0\]$_DFFE_PP_ clknet_leaf_50_clk net309 _0005_
+ VSS VSS VDD VDD dp.rf.rf\[15\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[10\]$_DFFE_PP_ clknet_leaf_94_clk dp.result2\[10\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[11\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[11\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[12\]$_DFFE_PP_ clknet_leaf_92_clk net648
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[13\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[13\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[14\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[14\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[16\]$_DFFE_PP_ clknet_leaf_60_clk net933
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[17\]$_DFFE_PP_ clknet_leaf_60_clk net934
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[18\]$_DFFE_PP_ clknet_leaf_54_clk net736
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[19\]$_DFFE_PP_ clknet_leaf_54_clk dp.result2\[19\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk dp.result2\[1\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[20\]$_DFFE_PP_ clknet_leaf_25_clk dp.result2\[20\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk dp.result2\[21\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[22\]$_DFFE_PP_ clknet_leaf_10_clk net649
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[23\]$_DFFE_PP_ clknet_leaf_30_clk net614
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[24\]$_DFFE_PP_ clknet_leaf_29_clk net733
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk net931
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk dp.result2\[26\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[28\]$_DFFE_PP_ clknet_leaf_22_clk net635
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[2\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[2\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net475
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[31\]$_DFFE_PP_ clknet_leaf_37_clk net688
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[6\]$_DFFE_PP_ clknet_leaf_103_clk dp.result2\[6\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[7\]$_DFFE_PP_ clknet_leaf_98_clk net272 _0005_
+ VSS VSS VDD VDD dp.rf.rf\[15\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[8\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[8\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[15\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0005_ VSS VSS VDD VDD dp.rf.rf\[15\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[0\]$_DFFE_PP_ clknet_leaf_58_clk net358 _0006_
+ VSS VSS VDD VDD dp.rf.rf\[16\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[10\]$_DFFE_PP_ clknet_leaf_92_clk dp.result2\[10\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[12\]$_DFFE_PP_ clknet_leaf_82_clk net639
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[13\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[13\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[15\]$_DFFE_PP_ clknet_leaf_89_clk dp.result2\[15\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[16\]$_DFFE_PP_ clknet_leaf_59_clk net933
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[17\]$_DFFE_PP_ clknet_leaf_50_clk dp.result2\[17\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[18\]$_DFFE_PP_ clknet_leaf_50_clk dp.result2\[18\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[19\]$_DFFE_PP_ clknet_leaf_52_clk dp.result2\[19\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[1\]$_DFFE_PP_ clknet_leaf_48_clk dp.result2\[1\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk net850
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[21\]$_DFFE_PP_ clknet_leaf_8_clk net737 _0006_
+ VSS VSS VDD VDD dp.rf.rf\[16\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[22\]$_DFFE_PP_ clknet_leaf_13_clk net658
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[23\]$_DFFE_PP_ clknet_leaf_28_clk net906
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[24\]$_DFFE_PP_ clknet_leaf_18_clk net735
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[25\]$_DFFE_PP_ clknet_leaf_14_clk net931
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk net608 _0006_
+ VSS VSS VDD VDD dp.rf.rf\[16\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[27\]$_DFFE_PP_ clknet_leaf_34_clk dp.result2\[27\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[28\]$_DFFE_PP_ clknet_leaf_46_clk dp.result2\[28\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[29\]$_DFFE_PP_ clknet_leaf_20_clk net712
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[2\]$_DFFE_PP_ clknet_leaf_65_clk dp.result2\[2\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[30\]$_DFFE_PP_ clknet_leaf_41_clk net474
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk net687
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[3\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[3\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[4\]$_DFFE_PP_ clknet_leaf_16_clk dp.result2\[4\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[5\]$_DFFE_PP_ clknet_leaf_67_clk dp.result2\[5\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[6\]$_DFFE_PP_ clknet_leaf_1_clk dp.result2\[6\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[7\]$_DFFE_PP_ clknet_leaf_89_clk net272 _0006_
+ VSS VSS VDD VDD dp.rf.rf\[16\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[8\]$_DFFE_PP_ clknet_leaf_80_clk dp.result2\[8\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[16\]\[9\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[9\]
+ _0006_ VSS VSS VDD VDD dp.rf.rf\[16\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[0\]$_DFFE_PP_ clknet_leaf_58_clk net358 _0007_
+ VSS VSS VDD VDD dp.rf.rf\[17\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[11\]$_DFFE_PP_ clknet_leaf_97_clk dp.result2\[11\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[12\]$_DFFE_PP_ clknet_leaf_81_clk net639
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[13\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[13\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[15\]$_DFFE_PP_ clknet_leaf_2_clk dp.result2\[15\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[16\]$_DFFE_PP_ clknet_leaf_62_clk net848
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[17\]$_DFFE_PP_ clknet_leaf_50_clk dp.result2\[17\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[18\]$_DFFE_PP_ clknet_leaf_51_clk net661
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[19\]$_DFFE_PP_ clknet_leaf_52_clk dp.result2\[19\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[1\]$_DFFE_PP_ clknet_leaf_51_clk dp.result2\[1\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk net850
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[21\]$_DFFE_PP_ clknet_leaf_8_clk net737 _0007_
+ VSS VSS VDD VDD dp.rf.rf\[17\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net649
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[23\]$_DFFE_PP_ clknet_leaf_28_clk net906
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[24\]$_DFFE_PP_ clknet_leaf_43_clk net733
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[25\]$_DFFE_PP_ clknet_leaf_14_clk net931
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk net608 _0007_
+ VSS VSS VDD VDD dp.rf.rf\[17\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[27\]$_DFFE_PP_ clknet_leaf_34_clk dp.result2\[27\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[28\]$_DFFE_PP_ clknet_leaf_16_clk net634
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[2\]$_DFFE_PP_ clknet_leaf_14_clk dp.result2\[2\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[30\]$_DFFE_PP_ clknet_leaf_42_clk dp.result2\[30\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk net687
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[3\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[3\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[4\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[4\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[6\]$_DFFE_PP_ clknet_leaf_1_clk net936 _0007_
+ VSS VSS VDD VDD dp.rf.rf\[17\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[7\]$_DFFE_PP_ clknet_leaf_90_clk net272 _0007_
+ VSS VSS VDD VDD dp.rf.rf\[17\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[8\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[8\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[17\]\[9\]$_DFFE_PP_ clknet_leaf_99_clk dp.result2\[9\]
+ _0007_ VSS VSS VDD VDD dp.rf.rf\[17\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[0\]$_DFFE_PP_ clknet_leaf_58_clk net358 _0008_
+ VSS VSS VDD VDD dp.rf.rf\[18\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[12\]$_DFFE_PP_ clknet_leaf_82_clk net639
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[13\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[13\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[15\]$_DFFE_PP_ clknet_leaf_2_clk dp.result2\[15\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[16\]$_DFFE_PP_ clknet_leaf_59_clk net848
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[17\]$_DFFE_PP_ clknet_leaf_57_clk dp.result2\[17\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[18\]$_DFFE_PP_ clknet_leaf_52_clk net662
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[19\]$_DFFE_PP_ clknet_leaf_41_clk dp.result2\[19\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk dp.result2\[1\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk net850
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net737 _0008_
+ VSS VSS VDD VDD dp.rf.rf\[18\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[22\]$_DFFE_PP_ clknet_leaf_14_clk net658
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[23\]$_DFFE_PP_ clknet_leaf_28_clk net906
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[24\]$_DFFE_PP_ clknet_leaf_19_clk net678
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk net931
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk net587 _0008_
+ VSS VSS VDD VDD dp.rf.rf\[18\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[28\]$_DFFE_PP_ clknet_leaf_16_clk net634
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[2\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[2\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[30\]$_DFFE_PP_ clknet_leaf_42_clk dp.result2\[30\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk net687
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[3\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[3\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[4\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[4\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[6\]$_DFFE_PP_ clknet_leaf_1_clk dp.result2\[6\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[7\]$_DFFE_PP_ clknet_leaf_88_clk net272 _0008_
+ VSS VSS VDD VDD dp.rf.rf\[18\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[8\]$_DFFE_PP_ clknet_leaf_80_clk dp.result2\[8\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[18\]\[9\]$_DFFE_PP_ clknet_leaf_99_clk dp.result2\[9\]
+ _0008_ VSS VSS VDD VDD dp.rf.rf\[18\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[0\]$_DFFE_PP_ clknet_leaf_58_clk net358 _0009_
+ VSS VSS VDD VDD dp.rf.rf\[19\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[10\]$_DFFE_PP_ clknet_leaf_79_clk dp.result2\[10\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[11\]$_DFFE_PP_ clknet_leaf_97_clk dp.result2\[11\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[12\]$_DFFE_PP_ clknet_leaf_81_clk net639
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[13\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[13\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[15\]$_DFFE_PP_ clknet_leaf_2_clk dp.result2\[15\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[16\]$_DFFE_PP_ clknet_leaf_58_clk net849
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[17\]$_DFFE_PP_ clknet_leaf_57_clk dp.result2\[17\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[18\]$_DFFE_PP_ clknet_leaf_51_clk net662
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[19\]$_DFFE_PP_ clknet_leaf_40_clk dp.result2\[19\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk dp.result2\[1\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[20\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[20\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net737 _0009_
+ VSS VSS VDD VDD dp.rf.rf\[19\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[22\]$_DFFE_PP_ clknet_leaf_13_clk net658
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[23\]$_DFFE_PP_ clknet_leaf_28_clk net906
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[24\]$_DFFE_PP_ clknet_leaf_43_clk net678
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk net931
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk net587 _0009_
+ VSS VSS VDD VDD dp.rf.rf\[19\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[28\]$_DFFE_PP_ clknet_leaf_16_clk net634
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[2\]$_DFFE_PP_ clknet_leaf_14_clk dp.result2\[2\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[30\]$_DFFE_PP_ clknet_leaf_41_clk net474
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk net687
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[3\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[3\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[4\]$_DFFE_PP_ clknet_leaf_21_clk dp.result2\[4\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[6\]$_DFFE_PP_ clknet_leaf_1_clk dp.result2\[6\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[7\]$_DFFE_PP_ clknet_leaf_90_clk net272 _0009_
+ VSS VSS VDD VDD dp.rf.rf\[19\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[8\]$_DFFE_PP_ clknet_leaf_80_clk dp.result2\[8\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[19\]\[9\]$_DFFE_PP_ clknet_leaf_99_clk dp.result2\[9\]
+ _0009_ VSS VSS VDD VDD dp.rf.rf\[19\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[0\]$_DFFE_PP_ clknet_leaf_50_clk net309 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[10\]$_DFFE_PP_ clknet_leaf_92_clk dp.result2\[10\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[11\]$_DFFE_PP_ clknet_leaf_97_clk dp.result2\[11\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[12\]$_DFFE_PP_ clknet_leaf_87_clk net638 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[13\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[13\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[14\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[14\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[15\]$_DFFE_PP_ clknet_leaf_4_clk dp.result2\[15\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[16\]$_DFFE_PP_ clknet_leaf_58_clk net849 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[17\]$_DFFE_PP_ clknet_leaf_57_clk dp.result2\[17\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[18\]$_DFFE_PP_ clknet_leaf_57_clk net661 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[1\]$_DFFE_PP_ clknet_leaf_49_clk dp.result2\[1\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk dp.result2\[20\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk net742 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net649 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[23\]$_DFFE_PP_ clknet_leaf_31_clk net614 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[24\]$_DFFE_PP_ clknet_leaf_30_clk net733 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk net931 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[26\]$_DFFE_PP_ clknet_leaf_5_clk net608 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[27\]$_DFFE_PP_ clknet_leaf_36_clk dp.result2\[27\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net635 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[29\]$_DFFE_PP_ clknet_leaf_25_clk net734 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[2\]$_DFFE_PP_ clknet_leaf_82_clk dp.result2\[2\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net474 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[31\]$_DFFE_PP_ clknet_leaf_36_clk net688 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[3\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[3\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[4\]$_DFFE_PP_ clknet_leaf_24_clk dp.result2\[4\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[5\]$_DFFE_PP_ clknet_leaf_81_clk dp.result2\[5\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[6\]$_DFFE_PP_ clknet_leaf_0_clk net936 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[7\]$_DFFE_PP_ clknet_leaf_89_clk net272 _0010_
+ VSS VSS VDD VDD dp.rf.rf\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[8\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[8\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[1\]\[9\]$_DFFE_PP_ clknet_leaf_103_clk dp.result2\[9\]
+ _0010_ VSS VSS VDD VDD dp.rf.rf\[1\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk dp.result2\[0\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[10\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[10\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[12\]$_DFFE_PP_ clknet_leaf_80_clk net648
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[13\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[13\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[15\]$_DFFE_PP_ clknet_leaf_98_clk dp.result2\[15\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[16\]$_DFFE_PP_ clknet_leaf_61_clk net933
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[17\]$_DFFE_PP_ clknet_leaf_59_clk dp.result2\[17\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[18\]$_DFFE_PP_ clknet_leaf_50_clk dp.result2\[18\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[19\]$_DFFE_PP_ clknet_leaf_41_clk dp.result2\[19\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[1\]$_DFFE_PP_ clknet_leaf_41_clk dp.result2\[1\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk net850
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[21\]$_DFFE_PP_ clknet_leaf_8_clk net737 _0011_
+ VSS VSS VDD VDD dp.rf.rf\[20\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net650
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[23\]$_DFFE_PP_ clknet_leaf_28_clk net906
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[24\]$_DFFE_PP_ clknet_leaf_43_clk net733
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[25\]$_DFFE_PP_ clknet_leaf_14_clk net931
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[26\]$_DFFE_PP_ clknet_leaf_21_clk net587
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[27\]$_DFFE_PP_ clknet_leaf_34_clk dp.result2\[27\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[28\]$_DFFE_PP_ clknet_leaf_46_clk dp.result2\[28\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[29\]$_DFFE_PP_ clknet_leaf_28_clk net712
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[2\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[2\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[30\]$_DFFE_PP_ clknet_leaf_42_clk net474
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk net687
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[3\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[3\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[4\]$_DFFE_PP_ clknet_leaf_16_clk dp.result2\[4\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[5\]$_DFFE_PP_ clknet_leaf_68_clk dp.result2\[5\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[6\]$_DFFE_PP_ clknet_leaf_1_clk net936 _0011_
+ VSS VSS VDD VDD dp.rf.rf\[20\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[7\]$_DFFE_PP_ clknet_leaf_90_clk net272 _0011_
+ VSS VSS VDD VDD dp.rf.rf\[20\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[8\]$_DFFE_PP_ clknet_leaf_80_clk dp.result2\[8\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[20\]\[9\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[9\]
+ _0011_ VSS VSS VDD VDD dp.rf.rf\[20\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk net308 _0012_
+ VSS VSS VDD VDD dp.rf.rf\[21\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[10\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[10\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[12\]$_DFFE_PP_ clknet_leaf_80_clk net648
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[13\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[13\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[15\]$_DFFE_PP_ clknet_leaf_1_clk dp.result2\[15\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[16\]$_DFFE_PP_ clknet_leaf_62_clk net848
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[17\]$_DFFE_PP_ clknet_leaf_50_clk dp.result2\[17\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[18\]$_DFFE_PP_ clknet_leaf_51_clk net662
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[19\]$_DFFE_PP_ clknet_leaf_52_clk dp.result2\[19\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[1\]$_DFFE_PP_ clknet_leaf_51_clk dp.result2\[1\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk net850
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[21\]$_DFFE_PP_ clknet_leaf_8_clk net737 _0012_
+ VSS VSS VDD VDD dp.rf.rf\[21\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net650
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[23\]$_DFFE_PP_ clknet_leaf_28_clk net906
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[24\]$_DFFE_PP_ clknet_leaf_43_clk net733
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[25\]$_DFFE_PP_ clknet_leaf_14_clk net931
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[26\]$_DFFE_PP_ clknet_leaf_21_clk net587
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[27\]$_DFFE_PP_ clknet_leaf_34_clk dp.result2\[27\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[28\]$_DFFE_PP_ clknet_leaf_16_clk net634
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[2\]$_DFFE_PP_ clknet_leaf_14_clk dp.result2\[2\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[30\]$_DFFE_PP_ clknet_leaf_42_clk dp.result2\[30\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[31\]$_DFFE_PP_ clknet_leaf_34_clk net687
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[3\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[3\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[4\]$_DFFE_PP_ clknet_leaf_18_clk dp.result2\[4\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[6\]$_DFFE_PP_ clknet_leaf_2_clk net936 _0012_
+ VSS VSS VDD VDD dp.rf.rf\[21\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[7\]$_DFFE_PP_ clknet_leaf_90_clk net272 _0012_
+ VSS VSS VDD VDD dp.rf.rf\[21\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[8\]$_DFFE_PP_ clknet_leaf_80_clk dp.result2\[8\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[21\]\[9\]$_DFFE_PP_ clknet_leaf_101_clk dp.result2\[9\]
+ _0012_ VSS VSS VDD VDD dp.rf.rf\[21\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk net309 _0013_
+ VSS VSS VDD VDD dp.rf.rf\[22\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[12\]$_DFFE_PP_ clknet_leaf_80_clk net648
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[13\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[13\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[15\]$_DFFE_PP_ clknet_leaf_1_clk dp.result2\[15\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[16\]$_DFFE_PP_ clknet_leaf_58_clk net848
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[17\]$_DFFE_PP_ clknet_leaf_51_clk net935
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[18\]$_DFFE_PP_ clknet_leaf_51_clk net662
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[19\]$_DFFE_PP_ clknet_leaf_41_clk dp.result2\[19\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[1\]$_DFFE_PP_ clknet_leaf_41_clk dp.result2\[1\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk net850
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[21\]$_DFFE_PP_ clknet_leaf_8_clk net737 _0013_
+ VSS VSS VDD VDD dp.rf.rf\[22\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[22\]$_DFFE_PP_ clknet_leaf_88_clk net650
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[23\]$_DFFE_PP_ clknet_leaf_28_clk net906
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[24\]$_DFFE_PP_ clknet_leaf_43_clk net678
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk net931
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[26\]$_DFFE_PP_ clknet_leaf_21_clk net587
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[28\]$_DFFE_PP_ clknet_leaf_16_clk net634
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[2\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[2\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[30\]$_DFFE_PP_ clknet_leaf_42_clk dp.result2\[30\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[31\]$_DFFE_PP_ clknet_leaf_34_clk net687
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[3\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[3\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[4\]$_DFFE_PP_ clknet_leaf_21_clk dp.result2\[4\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[5\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[5\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[6\]$_DFFE_PP_ clknet_leaf_1_clk net936 _0013_
+ VSS VSS VDD VDD dp.rf.rf\[22\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[7\]$_DFFE_PP_ clknet_leaf_89_clk net272 _0013_
+ VSS VSS VDD VDD dp.rf.rf\[22\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[8\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[8\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[22\]\[9\]$_DFFE_PP_ clknet_leaf_99_clk dp.result2\[9\]
+ _0013_ VSS VSS VDD VDD dp.rf.rf\[22\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk net309 _0014_
+ VSS VSS VDD VDD dp.rf.rf\[23\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[12\]$_DFFE_PP_ clknet_leaf_80_clk net648
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[13\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[13\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[15\]$_DFFE_PP_ clknet_leaf_1_clk dp.result2\[15\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[16\]$_DFFE_PP_ clknet_leaf_59_clk net933
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[17\]$_DFFE_PP_ clknet_leaf_58_clk dp.result2\[17\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[18\]$_DFFE_PP_ clknet_leaf_51_clk net662
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[19\]$_DFFE_PP_ clknet_leaf_41_clk dp.result2\[19\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[1\]$_DFFE_PP_ clknet_leaf_52_clk dp.result2\[1\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk net850
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[21\]$_DFFE_PP_ clknet_leaf_10_clk net737
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[22\]$_DFFE_PP_ clknet_leaf_88_clk net650
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[23\]$_DFFE_PP_ clknet_leaf_28_clk net906
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[24\]$_DFFE_PP_ clknet_leaf_43_clk net678
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk net931
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[26\]$_DFFE_PP_ clknet_leaf_21_clk dp.result2\[26\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[28\]$_DFFE_PP_ clknet_leaf_16_clk net637
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[29\]$_DFFE_PP_ clknet_leaf_28_clk net712
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[2\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[2\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[30\]$_DFFE_PP_ clknet_leaf_42_clk dp.result2\[30\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[31\]$_DFFE_PP_ clknet_leaf_34_clk net687
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[3\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[3\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[4\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[4\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[5\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[5\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[6\]$_DFFE_PP_ clknet_leaf_1_clk net936 _0014_
+ VSS VSS VDD VDD dp.rf.rf\[23\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[7\]$_DFFE_PP_ clknet_leaf_89_clk net272 _0014_
+ VSS VSS VDD VDD dp.rf.rf\[23\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[8\]$_DFFE_PP_ clknet_leaf_80_clk dp.result2\[8\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[23\]\[9\]$_DFFE_PP_ clknet_leaf_101_clk dp.result2\[9\]
+ _0014_ VSS VSS VDD VDD dp.rf.rf\[23\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk net309 _0015_
+ VSS VSS VDD VDD dp.rf.rf\[24\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[10\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[10\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[11\]$_DFFE_PP_ clknet_leaf_94_clk dp.result2\[11\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[12\]$_DFFE_PP_ clknet_leaf_79_clk net638
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[13\]$_DFFE_PP_ clknet_leaf_69_clk dp.result2\[13\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[14\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[14\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[15\]$_DFFE_PP_ clknet_leaf_10_clk dp.result2\[15\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[16\]$_DFFE_PP_ clknet_leaf_59_clk net933
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[17\]$_DFFE_PP_ clknet_leaf_59_clk net935
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[18\]$_DFFE_PP_ clknet_leaf_51_clk net661
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[19\]$_DFFE_PP_ clknet_leaf_53_clk dp.result2\[19\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[1\]$_DFFE_PP_ clknet_leaf_41_clk dp.result2\[1\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk net850
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[21\]$_DFFE_PP_ clknet_leaf_10_clk net737
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[22\]$_DFFE_PP_ clknet_leaf_87_clk dp.result2\[22\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[23\]$_DFFE_PP_ clknet_leaf_43_clk net710
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[24\]$_DFFE_PP_ clknet_leaf_46_clk net733
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[25\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk net587
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[27\]$_DFFE_PP_ clknet_leaf_34_clk dp.result2\[27\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[28\]$_DFFE_PP_ clknet_leaf_46_clk dp.result2\[28\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[29\]$_DFFE_PP_ clknet_leaf_19_clk net712
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[2\]$_DFFE_PP_ clknet_leaf_65_clk dp.result2\[2\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[30\]$_DFFE_PP_ clknet_leaf_40_clk net531
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[31\]$_DFFE_PP_ clknet_leaf_35_clk net526
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[3\]$_DFFE_PP_ clknet_leaf_82_clk dp.result2\[3\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[4\]$_DFFE_PP_ clknet_leaf_21_clk dp.result2\[4\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[5\]$_DFFE_PP_ clknet_leaf_68_clk dp.result2\[5\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[6\]$_DFFE_PP_ clknet_leaf_99_clk net936 _0015_
+ VSS VSS VDD VDD dp.rf.rf\[24\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[7\]$_DFFE_PP_ clknet_leaf_97_clk net272 _0015_
+ VSS VSS VDD VDD dp.rf.rf\[24\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[8\]$_DFFE_PP_ clknet_leaf_79_clk dp.result2\[8\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[24\]\[9\]$_DFFE_PP_ clknet_leaf_101_clk dp.result2\[9\]
+ _0015_ VSS VSS VDD VDD dp.rf.rf\[24\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk dp.result2\[0\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[10\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[10\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[12\]$_DFFE_PP_ clknet_leaf_79_clk net648
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[13\]$_DFFE_PP_ clknet_leaf_69_clk dp.result2\[13\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[14\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[14\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[15\]$_DFFE_PP_ clknet_leaf_10_clk dp.result2\[15\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[16\]$_DFFE_PP_ clknet_leaf_61_clk net640
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[17\]$_DFFE_PP_ clknet_leaf_59_clk net935
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[18\]$_DFFE_PP_ clknet_leaf_55_clk net736
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[19\]$_DFFE_PP_ clknet_leaf_53_clk dp.result2\[19\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[1\]$_DFFE_PP_ clknet_leaf_41_clk dp.result2\[1\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk net850
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[21\]$_DFFE_PP_ clknet_leaf_10_clk net737
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[22\]$_DFFE_PP_ clknet_leaf_88_clk net650
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[23\]$_DFFE_PP_ clknet_leaf_34_clk net710
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[24\]$_DFFE_PP_ clknet_leaf_44_clk net735
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[25\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk net587
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[28\]$_DFFE_PP_ clknet_leaf_44_clk net637
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[29\]$_DFFE_PP_ clknet_leaf_18_clk net712
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[2\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[2\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[30\]$_DFFE_PP_ clknet_leaf_40_clk net531
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[31\]$_DFFE_PP_ clknet_leaf_35_clk net526
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[3\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[3\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[4\]$_DFFE_PP_ clknet_leaf_8_clk dp.result2\[4\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[5\]$_DFFE_PP_ clknet_leaf_68_clk dp.result2\[5\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[6\]$_DFFE_PP_ clknet_leaf_98_clk net936 _0016_
+ VSS VSS VDD VDD dp.rf.rf\[25\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[7\]$_DFFE_PP_ clknet_leaf_92_clk net272 _0016_
+ VSS VSS VDD VDD dp.rf.rf\[25\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[8\]$_DFFE_PP_ clknet_leaf_79_clk dp.result2\[8\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[25\]\[9\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[9\]
+ _0016_ VSS VSS VDD VDD dp.rf.rf\[25\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk net308 _0017_
+ VSS VSS VDD VDD dp.rf.rf\[26\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[12\]$_DFFE_PP_ clknet_leaf_91_clk dp.result2\[12\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[13\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[13\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[15\]$_DFFE_PP_ clknet_leaf_9_clk dp.result2\[15\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[16\]$_DFFE_PP_ clknet_leaf_61_clk net933
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[17\]$_DFFE_PP_ clknet_leaf_59_clk net934
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[18\]$_DFFE_PP_ clknet_leaf_52_clk net662
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[19\]$_DFFE_PP_ clknet_leaf_52_clk dp.result2\[19\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[1\]$_DFFE_PP_ clknet_leaf_48_clk dp.result2\[1\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk net850
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[21\]$_DFFE_PP_ clknet_leaf_10_clk net737
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[22\]$_DFFE_PP_ clknet_leaf_88_clk dp.result2\[22\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[23\]$_DFFE_PP_ clknet_leaf_34_clk net710
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[24\]$_DFFE_PP_ clknet_leaf_44_clk net735
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[25\]$_DFFE_PP_ clknet_leaf_16_clk dp.result2\[25\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk net587
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[27\]$_DFFE_PP_ clknet_leaf_35_clk dp.result2\[27\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[28\]$_DFFE_PP_ clknet_leaf_16_clk net637
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[29\]$_DFFE_PP_ clknet_leaf_19_clk net734
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[2\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[2\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[30\]$_DFFE_PP_ clknet_leaf_40_clk net531
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[31\]$_DFFE_PP_ clknet_leaf_35_clk net525
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[3\]$_DFFE_PP_ clknet_leaf_66_clk dp.result2\[3\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[4\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[4\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[5\]$_DFFE_PP_ clknet_leaf_68_clk dp.result2\[5\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[6\]$_DFFE_PP_ clknet_leaf_99_clk net936 _0017_
+ VSS VSS VDD VDD dp.rf.rf\[26\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[7\]$_DFFE_PP_ clknet_leaf_97_clk net272 _0017_
+ VSS VSS VDD VDD dp.rf.rf\[26\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[8\]$_DFFE_PP_ clknet_leaf_79_clk dp.result2\[8\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[26\]\[9\]$_DFFE_PP_ clknet_leaf_101_clk dp.result2\[9\]
+ _0017_ VSS VSS VDD VDD dp.rf.rf\[26\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk net308 _0018_
+ VSS VSS VDD VDD dp.rf.rf\[27\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[12\]$_DFFE_PP_ clknet_leaf_91_clk dp.result2\[12\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[13\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[13\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[14\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[14\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[15\]$_DFFE_PP_ clknet_leaf_2_clk dp.result2\[15\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[16\]$_DFFE_PP_ clknet_leaf_61_clk net933
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[17\]$_DFFE_PP_ clknet_leaf_61_clk net935
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[18\]$_DFFE_PP_ clknet_leaf_51_clk net662
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[19\]$_DFFE_PP_ clknet_leaf_52_clk dp.result2\[19\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[1\]$_DFFE_PP_ clknet_leaf_48_clk dp.result2\[1\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk net850
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net742 _0018_
+ VSS VSS VDD VDD dp.rf.rf\[27\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[22\]$_DFFE_PP_ clknet_leaf_88_clk dp.result2\[22\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[23\]$_DFFE_PP_ clknet_leaf_34_clk net710
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[24\]$_DFFE_PP_ clknet_leaf_44_clk net735
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[25\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk net608
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[27\]$_DFFE_PP_ clknet_leaf_35_clk dp.result2\[27\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[28\]$_DFFE_PP_ clknet_leaf_16_clk net637
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[29\]$_DFFE_PP_ clknet_leaf_19_clk net712
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[2\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[2\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[30\]$_DFFE_PP_ clknet_leaf_42_clk dp.result2\[30\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[31\]$_DFFE_PP_ clknet_leaf_35_clk net525
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[3\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[3\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[4\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[4\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[5\]$_DFFE_PP_ clknet_leaf_69_clk dp.result2\[5\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[6\]$_DFFE_PP_ clknet_leaf_99_clk net936 _0018_
+ VSS VSS VDD VDD dp.rf.rf\[27\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[7\]$_DFFE_PP_ clknet_leaf_97_clk net272 _0018_
+ VSS VSS VDD VDD dp.rf.rf\[27\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[8\]$_DFFE_PP_ clknet_leaf_79_clk dp.result2\[8\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[27\]\[9\]$_DFFE_PP_ clknet_leaf_101_clk dp.result2\[9\]
+ _0018_ VSS VSS VDD VDD dp.rf.rf\[27\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk net308 _0019_
+ VSS VSS VDD VDD dp.rf.rf\[28\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[10\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[10\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[12\]$_DFFE_PP_ clknet_leaf_83_clk net639
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[13\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[13\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[14\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[14\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[15\]$_DFFE_PP_ clknet_leaf_2_clk dp.result2\[15\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[16\]$_DFFE_PP_ clknet_leaf_61_clk net933
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[17\]$_DFFE_PP_ clknet_leaf_60_clk net934
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[18\]$_DFFE_PP_ clknet_leaf_53_clk dp.result2\[18\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[19\]$_DFFE_PP_ clknet_leaf_53_clk dp.result2\[19\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk dp.result2\[1\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk net850
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net737 _0019_
+ VSS VSS VDD VDD dp.rf.rf\[28\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[22\]$_DFFE_PP_ clknet_leaf_87_clk dp.result2\[22\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[23\]$_DFFE_PP_ clknet_leaf_19_clk net710
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[24\]$_DFFE_PP_ clknet_leaf_44_clk net735
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[25\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[25\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[26\]$_DFFE_PP_ clknet_leaf_8_clk net608 _0019_
+ VSS VSS VDD VDD dp.rf.rf\[28\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[27\]$_DFFE_PP_ clknet_leaf_36_clk dp.result2\[27\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[28\]$_DFFE_PP_ clknet_leaf_44_clk net637
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[29\]$_DFFE_PP_ clknet_leaf_19_clk net734
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[2\]$_DFFE_PP_ clknet_leaf_47_clk dp.result2\[2\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[30\]$_DFFE_PP_ clknet_leaf_40_clk net531
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[31\]$_DFFE_PP_ clknet_leaf_35_clk net514
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[3\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[3\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[4\]$_DFFE_PP_ clknet_leaf_8_clk dp.result2\[4\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[5\]$_DFFE_PP_ clknet_leaf_68_clk dp.result2\[5\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[6\]$_DFFE_PP_ clknet_leaf_99_clk net936 _0019_
+ VSS VSS VDD VDD dp.rf.rf\[28\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[7\]$_DFFE_PP_ clknet_leaf_90_clk net272 _0019_
+ VSS VSS VDD VDD dp.rf.rf\[28\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[8\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[8\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[28\]\[9\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[9\]
+ _0019_ VSS VSS VDD VDD dp.rf.rf\[28\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[0\]$_DFFE_PP_ clknet_leaf_61_clk net358 _0020_
+ VSS VSS VDD VDD dp.rf.rf\[29\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[12\]$_DFFE_PP_ clknet_leaf_82_clk net639
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[13\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[13\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[14\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[14\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[15\]$_DFFE_PP_ clknet_leaf_2_clk dp.result2\[15\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[16\]$_DFFE_PP_ clknet_leaf_61_clk net933
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[17\]$_DFFE_PP_ clknet_leaf_60_clk net934
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[18\]$_DFFE_PP_ clknet_leaf_53_clk dp.result2\[18\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[19\]$_DFFE_PP_ clknet_leaf_53_clk dp.result2\[19\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk dp.result2\[1\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk net850
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net742 _0020_
+ VSS VSS VDD VDD dp.rf.rf\[29\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[22\]$_DFFE_PP_ clknet_leaf_87_clk dp.result2\[22\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[23\]$_DFFE_PP_ clknet_leaf_19_clk net710
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[24\]$_DFFE_PP_ clknet_leaf_44_clk net735
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[25\]$_DFFE_PP_ clknet_leaf_16_clk dp.result2\[25\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk dp.result2\[26\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[28\]$_DFFE_PP_ clknet_leaf_46_clk dp.result2\[28\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[29\]$_DFFE_PP_ clknet_leaf_19_clk net734
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[2\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[2\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[30\]$_DFFE_PP_ clknet_leaf_40_clk net531
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[31\]$_DFFE_PP_ clknet_leaf_35_clk net514
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[3\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[3\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[4\]$_DFFE_PP_ clknet_leaf_8_clk dp.result2\[4\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[5\]$_DFFE_PP_ clknet_leaf_68_clk dp.result2\[5\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[6\]$_DFFE_PP_ clknet_leaf_1_clk dp.result2\[6\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[7\]$_DFFE_PP_ clknet_leaf_90_clk net272 _0020_
+ VSS VSS VDD VDD dp.rf.rf\[29\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[8\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[8\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[29\]\[9\]$_DFFE_PP_ clknet_leaf_101_clk dp.result2\[9\]
+ _0020_ VSS VSS VDD VDD dp.rf.rf\[29\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[0\]$_DFFE_PP_ clknet_leaf_49_clk dp.result2\[0\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[10\]$_DFFE_PP_ clknet_leaf_92_clk dp.result2\[10\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[11\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[11\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[12\]$_DFFE_PP_ clknet_leaf_87_clk net638 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[13\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[13\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[14\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[14\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[16\]$_DFFE_PP_ clknet_leaf_56_clk net849 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[17\]$_DFFE_PP_ clknet_leaf_55_clk dp.result2\[17\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[18\]$_DFFE_PP_ clknet_leaf_55_clk net736 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[1\]$_DFFE_PP_ clknet_leaf_47_clk dp.result2\[1\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[20\]$_DFFE_PP_ clknet_leaf_22_clk dp.result2\[20\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk net742 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net649 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[23\]$_DFFE_PP_ clknet_leaf_31_clk net614 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[24\]$_DFFE_PP_ clknet_leaf_30_clk net733 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk dp.result2\[25\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[26\]$_DFFE_PP_ clknet_leaf_5_clk net608 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net634 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net734 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[2\]$_DFFE_PP_ clknet_leaf_82_clk dp.result2\[2\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[30\]$_DFFE_PP_ clknet_leaf_42_clk dp.result2\[30\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[31\]$_DFFE_PP_ clknet_leaf_36_clk net514 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[3\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[3\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[5\]$_DFFE_PP_ clknet_leaf_81_clk dp.result2\[5\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[6\]$_DFFE_PP_ clknet_leaf_0_clk dp.result2\[6\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[7\]$_DFFE_PP_ clknet_leaf_88_clk net272 _0021_
+ VSS VSS VDD VDD dp.rf.rf\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[8\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[8\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[2\]\[9\]$_DFFE_PP_ clknet_leaf_103_clk dp.result2\[9\]
+ _0021_ VSS VSS VDD VDD dp.rf.rf\[2\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[0\]$_DFFE_PP_ clknet_leaf_62_clk net308 _0022_
+ VSS VSS VDD VDD dp.rf.rf\[30\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[12\]$_DFFE_PP_ clknet_leaf_87_clk net638
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[13\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[13\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[15\]$_DFFE_PP_ clknet_leaf_2_clk dp.result2\[15\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[16\]$_DFFE_PP_ clknet_leaf_61_clk net933
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[17\]$_DFFE_PP_ clknet_leaf_59_clk net935
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[18\]$_DFFE_PP_ clknet_leaf_53_clk dp.result2\[18\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[19\]$_DFFE_PP_ clknet_leaf_40_clk dp.result2\[19\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk dp.result2\[1\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk net850
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net742 _0022_
+ VSS VSS VDD VDD dp.rf.rf\[30\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[22\]$_DFFE_PP_ clknet_leaf_88_clk dp.result2\[22\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[23\]$_DFFE_PP_ clknet_leaf_19_clk net710
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[24\]$_DFFE_PP_ clknet_leaf_44_clk net735
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[25\]$_DFFE_PP_ clknet_leaf_16_clk dp.result2\[25\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk dp.result2\[26\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[28\]$_DFFE_PP_ clknet_leaf_18_clk net637
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[29\]$_DFFE_PP_ clknet_leaf_19_clk net734
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[2\]$_DFFE_PP_ clknet_leaf_47_clk dp.result2\[2\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[30\]$_DFFE_PP_ clknet_leaf_40_clk net531
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[31\]$_DFFE_PP_ clknet_leaf_35_clk net514
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[3\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[3\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[4\]$_DFFE_PP_ clknet_leaf_21_clk dp.result2\[4\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[5\]$_DFFE_PP_ clknet_leaf_67_clk dp.result2\[5\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[6\]$_DFFE_PP_ clknet_leaf_99_clk net936 _0022_
+ VSS VSS VDD VDD dp.rf.rf\[30\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[7\]$_DFFE_PP_ clknet_leaf_90_clk net272 _0022_
+ VSS VSS VDD VDD dp.rf.rf\[30\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[8\]$_DFFE_PP_ clknet_leaf_79_clk dp.result2\[8\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[30\]\[9\]$_DFFE_PP_ clknet_leaf_101_clk dp.result2\[9\]
+ _0022_ VSS VSS VDD VDD dp.rf.rf\[30\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[0\]$_DFFE_PP_ clknet_leaf_63_clk net308 _0023_
+ VSS VSS VDD VDD dp.rf.rf\[31\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[10\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[10\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[11\]$_DFFE_PP_ clknet_leaf_95_clk dp.result2\[11\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[12\]$_DFFE_PP_ clknet_leaf_91_clk dp.result2\[12\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[13\]$_DFFE_PP_ clknet_leaf_70_clk dp.result2\[13\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[14\]$_DFFE_PP_ clknet_leaf_71_clk dp.result2\[14\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[15\]$_DFFE_PP_ clknet_leaf_2_clk dp.result2\[15\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[16\]$_DFFE_PP_ clknet_leaf_61_clk net933
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[17\]$_DFFE_PP_ clknet_leaf_59_clk net935
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[18\]$_DFFE_PP_ clknet_leaf_52_clk net662
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[19\]$_DFFE_PP_ clknet_leaf_40_clk dp.result2\[19\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk dp.result2\[1\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[20\]$_DFFE_PP_ clknet_leaf_44_clk net850
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net742 _0023_
+ VSS VSS VDD VDD dp.rf.rf\[31\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[22\]$_DFFE_PP_ clknet_leaf_88_clk dp.result2\[22\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[23\]$_DFFE_PP_ clknet_leaf_34_clk net710
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[24\]$_DFFE_PP_ clknet_leaf_42_clk net678
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[25\]$_DFFE_PP_ clknet_leaf_17_clk dp.result2\[25\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk dp.result2\[26\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[28\]$_DFFE_PP_ clknet_leaf_44_clk net637
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[29\]$_DFFE_PP_ clknet_leaf_19_clk net734
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[2\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[2\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[30\]$_DFFE_PP_ clknet_leaf_42_clk dp.result2\[30\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[31\]$_DFFE_PP_ clknet_leaf_35_clk net514
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[3\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[3\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[4\]$_DFFE_PP_ clknet_leaf_21_clk dp.result2\[4\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[5\]$_DFFE_PP_ clknet_leaf_68_clk dp.result2\[5\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[6\]$_DFFE_PP_ clknet_leaf_99_clk net936 _0023_
+ VSS VSS VDD VDD dp.rf.rf\[31\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[7\]$_DFFE_PP_ clknet_leaf_97_clk net272 _0023_
+ VSS VSS VDD VDD dp.rf.rf\[31\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[8\]$_DFFE_PP_ clknet_leaf_79_clk dp.result2\[8\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[31\]\[9\]$_DFFE_PP_ clknet_leaf_101_clk dp.result2\[9\]
+ _0023_ VSS VSS VDD VDD dp.rf.rf\[31\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[0\]$_DFFE_PP_ clknet_leaf_49_clk dp.result2\[0\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[10\]$_DFFE_PP_ clknet_leaf_92_clk dp.result2\[10\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[11\]$_DFFE_PP_ clknet_leaf_99_clk dp.result2\[11\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[12\]$_DFFE_PP_ clknet_leaf_87_clk net638 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[13\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[13\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[14\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[14\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[16\]$_DFFE_PP_ clknet_leaf_57_clk net849 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[17\]$_DFFE_PP_ clknet_leaf_55_clk dp.result2\[17\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[18\]$_DFFE_PP_ clknet_leaf_54_clk net736 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[1\]$_DFFE_PP_ clknet_leaf_46_clk dp.result2\[1\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[20\]$_DFFE_PP_ clknet_leaf_22_clk dp.result2\[20\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk dp.result2\[21\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net649 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[23\]$_DFFE_PP_ clknet_leaf_31_clk net614 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[24\]$_DFFE_PP_ clknet_leaf_26_clk net678 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk dp.result2\[25\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[26\]$_DFFE_PP_ clknet_leaf_5_clk net608 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net634 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net734 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[2\]$_DFFE_PP_ clknet_leaf_82_clk dp.result2\[2\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[30\]$_DFFE_PP_ clknet_leaf_40_clk net531 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[31\]$_DFFE_PP_ clknet_leaf_36_clk net524 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[3\]$_DFFE_PP_ clknet_leaf_84_clk dp.result2\[3\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[5\]$_DFFE_PP_ clknet_leaf_81_clk dp.result2\[5\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[6\]$_DFFE_PP_ clknet_leaf_0_clk dp.result2\[6\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[7\]$_DFFE_PP_ clknet_leaf_88_clk net272 _0024_
+ VSS VSS VDD VDD dp.rf.rf\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[8\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[8\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[3\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0024_ VSS VSS VDD VDD dp.rf.rf\[3\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[0\]$_DFFE_PP_ clknet_leaf_50_clk net309 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[12\]$_DFFE_PP_ clknet_leaf_91_clk dp.result2\[12\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[13\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[13\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[14\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[14\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[15\]$_DFFE_PP_ clknet_leaf_2_clk dp.result2\[15\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[16\]$_DFFE_PP_ clknet_leaf_58_clk net849 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[17\]$_DFFE_PP_ clknet_leaf_57_clk net935 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[18\]$_DFFE_PP_ clknet_leaf_55_clk net736 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[1\]$_DFFE_PP_ clknet_leaf_48_clk dp.result2\[1\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk dp.result2\[20\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk net737 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net650 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[23\]$_DFFE_PP_ clknet_leaf_33_clk net614 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[24\]$_DFFE_PP_ clknet_leaf_30_clk net733 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk net931 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[26\]$_DFFE_PP_ clknet_leaf_5_clk net588 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net635 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net734 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[2\]$_DFFE_PP_ clknet_leaf_82_clk dp.result2\[2\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[30\]$_DFFE_PP_ clknet_leaf_37_clk net474 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[31\]$_DFFE_PP_ clknet_leaf_37_clk net688 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[3\]$_DFFE_PP_ clknet_leaf_14_clk dp.result2\[3\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[5\]$_DFFE_PP_ clknet_leaf_81_clk dp.result2\[5\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[6\]$_DFFE_PP_ clknet_leaf_0_clk net936 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[7\]$_DFFE_PP_ clknet_leaf_98_clk net272 _0025_
+ VSS VSS VDD VDD dp.rf.rf\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[8\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[8\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[4\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0025_ VSS VSS VDD VDD dp.rf.rf\[4\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[0\]$_DFFE_PP_ clknet_leaf_50_clk net309 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[10\]$_DFFE_PP_ clknet_leaf_92_clk dp.result2\[10\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[11\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[11\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[12\]$_DFFE_PP_ clknet_leaf_91_clk net639 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[13\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[13\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[14\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[14\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[16\]$_DFFE_PP_ clknet_leaf_57_clk net849 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[17\]$_DFFE_PP_ clknet_leaf_57_clk dp.result2\[17\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[18\]$_DFFE_PP_ clknet_leaf_53_clk dp.result2\[18\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[1\]$_DFFE_PP_ clknet_leaf_48_clk dp.result2\[1\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk dp.result2\[20\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk net737 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[22\]$_DFFE_PP_ clknet_leaf_10_clk net658 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[23\]$_DFFE_PP_ clknet_leaf_31_clk net614 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[24\]$_DFFE_PP_ clknet_leaf_30_clk net733 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk dp.result2\[25\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[26\]$_DFFE_PP_ clknet_leaf_5_clk net588 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net634 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net734 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[2\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[2\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[30\]$_DFFE_PP_ clknet_leaf_37_clk net474 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[31\]$_DFFE_PP_ clknet_leaf_36_clk net524 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[4\]$_DFFE_PP_ clknet_leaf_5_clk dp.result2\[4\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[5\]$_DFFE_PP_ clknet_leaf_81_clk dp.result2\[5\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[6\]$_DFFE_PP_ clknet_leaf_0_clk net936 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[7\]$_DFFE_PP_ clknet_leaf_89_clk net272 _0026_
+ VSS VSS VDD VDD dp.rf.rf\[5\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[8\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[8\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[5\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0026_ VSS VSS VDD VDD dp.rf.rf\[5\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[0\]$_DFFE_PP_ clknet_leaf_49_clk dp.result2\[0\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[10\]$_DFFE_PP_ clknet_leaf_94_clk dp.result2\[10\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[11\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[11\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[12\]$_DFFE_PP_ clknet_leaf_91_clk dp.result2\[12\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[13\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[13\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[14\]$_DFFE_PP_ clknet_leaf_74_clk dp.result2\[14\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[16\]$_DFFE_PP_ clknet_leaf_57_clk net849 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[17\]$_DFFE_PP_ clknet_leaf_55_clk dp.result2\[17\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[18\]$_DFFE_PP_ clknet_leaf_53_clk dp.result2\[18\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk dp.result2\[1\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[20\]$_DFFE_PP_ clknet_leaf_27_clk dp.result2\[20\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk dp.result2\[21\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[22\]$_DFFE_PP_ clknet_leaf_10_clk net658 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[23\]$_DFFE_PP_ clknet_leaf_31_clk net614 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[24\]$_DFFE_PP_ clknet_leaf_30_clk net733 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[25\]$_DFFE_PP_ clknet_leaf_11_clk net931 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[26\]$_DFFE_PP_ clknet_leaf_5_clk net588 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[27\]$_DFFE_PP_ clknet_leaf_33_clk dp.result2\[27\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net635 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net734 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[2\]$_DFFE_PP_ clknet_leaf_82_clk dp.result2\[2\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net475 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[31\]$_DFFE_PP_ clknet_leaf_36_clk net524 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[5\]$_DFFE_PP_ clknet_leaf_81_clk dp.result2\[5\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[6\]$_DFFE_PP_ clknet_leaf_0_clk dp.result2\[6\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[7\]$_DFFE_PP_ clknet_leaf_89_clk net272 _0027_
+ VSS VSS VDD VDD dp.rf.rf\[6\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[8\]$_DFFE_PP_ clknet_leaf_78_clk dp.result2\[8\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[6\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0027_ VSS VSS VDD VDD dp.rf.rf\[6\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[0\]$_DFFE_PP_ clknet_leaf_49_clk dp.result2\[0\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[10\]$_DFFE_PP_ clknet_leaf_92_clk dp.result2\[10\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[11\]$_DFFE_PP_ clknet_leaf_100_clk dp.result2\[11\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[12\]$_DFFE_PP_ clknet_leaf_91_clk dp.result2\[12\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[13\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[13\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[14\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[14\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[16\]$_DFFE_PP_ clknet_leaf_57_clk net849 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[17\]$_DFFE_PP_ clknet_leaf_55_clk dp.result2\[17\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[18\]$_DFFE_PP_ clknet_leaf_55_clk net736 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[19\]$_DFFE_PP_ clknet_leaf_40_clk dp.result2\[19\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk dp.result2\[1\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[20\]$_DFFE_PP_ clknet_leaf_27_clk dp.result2\[20\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk net737 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[22\]$_DFFE_PP_ clknet_leaf_10_clk net649 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[23\]$_DFFE_PP_ clknet_leaf_31_clk net614 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[24\]$_DFFE_PP_ clknet_leaf_30_clk net733 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk dp.result2\[25\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[26\]$_DFFE_PP_ clknet_leaf_5_clk net588 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net635 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net734 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[2\]$_DFFE_PP_ clknet_leaf_83_clk dp.result2\[2\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net475 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[31\]$_DFFE_PP_ clknet_leaf_36_clk net524 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[4\]$_DFFE_PP_ clknet_leaf_23_clk dp.result2\[4\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[5\]$_DFFE_PP_ clknet_leaf_81_clk dp.result2\[5\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[6\]$_DFFE_PP_ clknet_leaf_0_clk dp.result2\[6\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[7\]$_DFFE_PP_ clknet_leaf_98_clk net272 _0028_
+ VSS VSS VDD VDD dp.rf.rf\[7\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[8\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[8\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[7\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0028_ VSS VSS VDD VDD dp.rf.rf\[7\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[0\]$_DFFE_PP_ clknet_leaf_64_clk net308 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[10\]$_DFFE_PP_ clknet_leaf_93_clk dp.result2\[10\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[12\]$_DFFE_PP_ clknet_leaf_79_clk net638 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[13\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[13\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[14\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[14\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[15\]$_DFFE_PP_ clknet_leaf_3_clk dp.result2\[15\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[16\]$_DFFE_PP_ clknet_leaf_57_clk net849 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[17\]$_DFFE_PP_ clknet_leaf_56_clk dp.result2\[17\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[18\]$_DFFE_PP_ clknet_leaf_55_clk net661 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[19\]$_DFFE_PP_ clknet_leaf_54_clk dp.result2\[19\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[1\]$_DFFE_PP_ clknet_leaf_49_clk dp.result2\[1\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[20\]$_DFFE_PP_ clknet_leaf_25_clk dp.result2\[20\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net742 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[22\]$_DFFE_PP_ clknet_leaf_88_clk net650 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[23\]$_DFFE_PP_ clknet_leaf_29_clk net614 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[24\]$_DFFE_PP_ clknet_leaf_28_clk net678 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk dp.result2\[25\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk dp.result2\[26\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[27\]$_DFFE_PP_ clknet_leaf_36_clk dp.result2\[27\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[28\]$_DFFE_PP_ clknet_leaf_21_clk net637 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net712 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[2\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[2\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[30\]$_DFFE_PP_ clknet_leaf_38_clk net475 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[31\]$_DFFE_PP_ clknet_leaf_38_clk net524 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[4\]$_DFFE_PP_ clknet_leaf_6_clk dp.result2\[4\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[5\]$_DFFE_PP_ clknet_leaf_72_clk dp.result2\[5\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[6\]$_DFFE_PP_ clknet_leaf_99_clk net936 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[7\]$_DFFE_PP_ clknet_leaf_98_clk net272 _0029_
+ VSS VSS VDD VDD dp.rf.rf\[8\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[8\]$_DFFE_PP_ clknet_leaf_76_clk dp.result2\[8\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[8\]\[9\]$_DFFE_PP_ clknet_leaf_101_clk dp.result2\[9\]
+ _0029_ VSS VSS VDD VDD dp.rf.rf\[8\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[0\]$_DFFE_PP_ clknet_leaf_64_clk net358 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[10\]$_DFFE_PP_ clknet_leaf_94_clk dp.result2\[10\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[11\]$_DFFE_PP_ clknet_leaf_96_clk dp.result2\[11\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[12\]$_DFFE_PP_ clknet_leaf_92_clk net648 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[13\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[13\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[14\]$_DFFE_PP_ clknet_leaf_75_clk dp.result2\[14\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[15\]$_DFFE_PP_ clknet_leaf_0_clk dp.result2\[15\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[16\]$_DFFE_PP_ clknet_leaf_56_clk net849 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[17\]$_DFFE_PP_ clknet_leaf_56_clk dp.result2\[17\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[18\]$_DFFE_PP_ clknet_leaf_54_clk net661 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[19\]$_DFFE_PP_ clknet_leaf_39_clk dp.result2\[19\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[1\]$_DFFE_PP_ clknet_leaf_48_clk dp.result2\[1\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[20\]$_DFFE_PP_ clknet_leaf_24_clk dp.result2\[20\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[21\]$_DFFE_PP_ clknet_leaf_4_clk dp.result2\[21\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[22\]$_DFFE_PP_ clknet_leaf_10_clk net658 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[23\]$_DFFE_PP_ clknet_leaf_29_clk net614 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[24\]$_DFFE_PP_ clknet_leaf_29_clk net733 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk net931 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk net588 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[27\]$_DFFE_PP_ clknet_leaf_32_clk dp.result2\[27\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[28\]$_DFFE_PP_ clknet_leaf_22_clk dp.result2\[28\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net734 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[2\]$_DFFE_PP_ clknet_leaf_86_clk dp.result2\[2\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[30\]$_DFFE_PP_ clknet_leaf_39_clk net474 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[31\]$_DFFE_PP_ clknet_leaf_37_clk net688 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[3\]$_DFFE_PP_ clknet_leaf_85_clk dp.result2\[3\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[4\]$_DFFE_PP_ clknet_leaf_21_clk dp.result2\[4\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[5\]$_DFFE_PP_ clknet_leaf_73_clk dp.result2\[5\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[6\]$_DFFE_PP_ clknet_leaf_103_clk dp.result2\[6\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[7\]$_DFFE_PP_ clknet_leaf_98_clk net272 _0030_
+ VSS VSS VDD VDD dp.rf.rf\[9\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[8\]$_DFFE_PP_ clknet_leaf_77_clk dp.result2\[8\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xdp.rf.rf\[9\]\[9\]$_DFFE_PP_ clknet_leaf_102_clk dp.result2\[9\]
+ _0030_ VSS VSS VDD VDD dp.rf.rf\[9\]\[9\] sky130_fd_sc_hd__edfxtp_1
XTAP_TAPCELL_ROW_27_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 instr[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_6
Xinput2 instr[10] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_8
Xinput3 instr[11] VSS VSS VDD VDD net3 sky130_fd_sc_hd__buf_6
Xinput4 instr[12] VSS VSS VDD VDD net4 sky130_fd_sc_hd__buf_6
Xinput5 instr[13] VSS VSS VDD VDD net5 sky130_fd_sc_hd__buf_16
Xinput6 instr[14] VSS VSS VDD VDD net6 sky130_fd_sc_hd__buf_8
Xinput7 instr[15] VSS VSS VDD VDD net7 sky130_fd_sc_hd__buf_16
Xinput8 instr[16] VSS VSS VDD VDD net8 sky130_fd_sc_hd__buf_16
Xinput9 instr[17] VSS VSS VDD VDD net9 sky130_fd_sc_hd__buf_12
Xinput10 instr[18] VSS VSS VDD VDD net10 sky130_fd_sc_hd__buf_16
Xinput11 instr[19] VSS VSS VDD VDD net11 sky130_fd_sc_hd__buf_16
Xinput12 instr[1] VSS VSS VDD VDD net12 sky130_fd_sc_hd__buf_6
Xinput13 instr[20] VSS VSS VDD VDD net13 sky130_fd_sc_hd__buf_16
Xinput14 instr[21] VSS VSS VDD VDD net14 sky130_fd_sc_hd__buf_16
Xinput15 instr[22] VSS VSS VDD VDD net15 sky130_fd_sc_hd__buf_16
Xinput16 instr[23] VSS VSS VDD VDD net16 sky130_fd_sc_hd__buf_16
Xinput17 instr[24] VSS VSS VDD VDD net17 sky130_fd_sc_hd__buf_16
Xinput18 instr[25] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_2
Xinput19 instr[26] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_2
Xinput20 instr[27] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_2
Xinput21 instr[28] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_2
Xinput22 instr[29] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_2
Xinput23 instr[2] VSS VSS VDD VDD net23 sky130_fd_sc_hd__buf_6
Xinput24 instr[30] VSS VSS VDD VDD net24 sky130_fd_sc_hd__buf_8
Xinput25 instr[31] VSS VSS VDD VDD net25 sky130_fd_sc_hd__buf_4
Xinput26 instr[3] VSS VSS VDD VDD net26 sky130_fd_sc_hd__buf_4
Xinput27 instr[4] VSS VSS VDD VDD net27 sky130_fd_sc_hd__buf_6
Xinput28 instr[5] VSS VSS VDD VDD net28 sky130_fd_sc_hd__buf_4
Xinput29 instr[6] VSS VSS VDD VDD net29 sky130_fd_sc_hd__buf_6
Xinput30 instr[7] VSS VSS VDD VDD net30 sky130_fd_sc_hd__buf_4
Xinput31 instr[8] VSS VSS VDD VDD net31 sky130_fd_sc_hd__buf_4
Xinput32 instr[9] VSS VSS VDD VDD net32 sky130_fd_sc_hd__buf_2
Xinput33 readdata[0] VSS VSS VDD VDD net33 sky130_fd_sc_hd__buf_2
Xinput34 readdata[10] VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_1
Xinput35 readdata[11] VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_1
Xinput36 readdata[12] VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkbuf_1
Xinput37 readdata[13] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_1
Xinput38 readdata[14] VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_1
Xinput39 readdata[15] VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_2
Xinput40 readdata[16] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
Xinput41 readdata[17] VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_1
Xinput42 readdata[18] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_1
Xinput43 readdata[19] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
Xinput44 readdata[1] VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_1
Xinput45 readdata[20] VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_1
Xinput46 readdata[21] VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkbuf_1
Xinput47 readdata[22] VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkbuf_1
Xinput48 readdata[23] VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_1
Xinput49 readdata[24] VSS VSS VDD VDD net49 sky130_fd_sc_hd__clkbuf_4
Xinput50 readdata[25] VSS VSS VDD VDD net50 sky130_fd_sc_hd__clkbuf_1
Xinput51 readdata[26] VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkbuf_1
Xinput52 readdata[27] VSS VSS VDD VDD net52 sky130_fd_sc_hd__clkbuf_4
Xinput53 readdata[28] VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkbuf_2
Xinput54 readdata[29] VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkbuf_4
Xinput55 readdata[2] VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_1
Xinput56 readdata[30] VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_1
Xinput57 readdata[31] VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkbuf_1
Xinput58 readdata[3] VSS VSS VDD VDD net58 sky130_fd_sc_hd__clkbuf_1
Xinput59 readdata[4] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_1
Xinput60 readdata[5] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_1
Xinput61 readdata[6] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_1
Xinput62 readdata[7] VSS VSS VDD VDD net62 sky130_fd_sc_hd__clkbuf_1
Xinput63 readdata[8] VSS VSS VDD VDD net63 sky130_fd_sc_hd__clkbuf_1
Xinput64 readdata[9] VSS VSS VDD VDD net64 sky130_fd_sc_hd__clkbuf_1
Xinput65 reset VSS VSS VDD VDD net65 sky130_fd_sc_hd__buf_6
Xoutput66 net66 VSS VSS VDD VDD aluout[0] sky130_fd_sc_hd__clkbuf_1
Xoutput67 net67 VSS VSS VDD VDD aluout[10] sky130_fd_sc_hd__clkbuf_1
Xoutput68 net68 VSS VSS VDD VDD aluout[11] sky130_fd_sc_hd__clkbuf_1
Xoutput69 net69 VSS VSS VDD VDD aluout[12] sky130_fd_sc_hd__clkbuf_1
Xoutput70 net70 VSS VSS VDD VDD aluout[13] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net71 VSS VSS VDD VDD aluout[14] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net72 VSS VSS VDD VDD aluout[15] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net73 VSS VSS VDD VDD aluout[16] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net74 VSS VSS VDD VDD aluout[17] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net75 VSS VSS VDD VDD aluout[18] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net76 VSS VSS VDD VDD aluout[19] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net77 VSS VSS VDD VDD aluout[1] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net78 VSS VSS VDD VDD aluout[20] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net79 VSS VSS VDD VDD aluout[21] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net80 VSS VSS VDD VDD aluout[22] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net81 VSS VSS VDD VDD aluout[23] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net82 VSS VSS VDD VDD aluout[24] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net83 VSS VSS VDD VDD aluout[25] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net84 VSS VSS VDD VDD aluout[26] sky130_fd_sc_hd__clkbuf_1
Xoutput85 net85 VSS VSS VDD VDD aluout[27] sky130_fd_sc_hd__clkbuf_1
Xoutput86 net86 VSS VSS VDD VDD aluout[28] sky130_fd_sc_hd__clkbuf_1
Xoutput87 net87 VSS VSS VDD VDD aluout[29] sky130_fd_sc_hd__clkbuf_1
Xoutput88 net88 VSS VSS VDD VDD aluout[2] sky130_fd_sc_hd__clkbuf_1
Xoutput89 net89 VSS VSS VDD VDD aluout[30] sky130_fd_sc_hd__clkbuf_1
Xoutput90 net90 VSS VSS VDD VDD aluout[31] sky130_fd_sc_hd__clkbuf_1
Xoutput91 net91 VSS VSS VDD VDD aluout[3] sky130_fd_sc_hd__clkbuf_1
Xoutput92 net92 VSS VSS VDD VDD aluout[4] sky130_fd_sc_hd__clkbuf_1
Xoutput93 net93 VSS VSS VDD VDD aluout[5] sky130_fd_sc_hd__clkbuf_1
Xoutput94 net94 VSS VSS VDD VDD aluout[6] sky130_fd_sc_hd__clkbuf_1
Xoutput95 net95 VSS VSS VDD VDD aluout[7] sky130_fd_sc_hd__clkbuf_1
Xoutput96 net96 VSS VSS VDD VDD aluout[8] sky130_fd_sc_hd__clkbuf_1
Xoutput97 net97 VSS VSS VDD VDD aluout[9] sky130_fd_sc_hd__clkbuf_1
Xoutput98 net98 VSS VSS VDD VDD memread sky130_fd_sc_hd__clkbuf_1
Xoutput99 net99 VSS VSS VDD VDD memwrite sky130_fd_sc_hd__clkbuf_1
Xoutput100 net100 VSS VSS VDD VDD pc[0] sky130_fd_sc_hd__clkbuf_1
Xoutput101 net101 VSS VSS VDD VDD pc[10] sky130_fd_sc_hd__clkbuf_1
Xoutput102 net102 VSS VSS VDD VDD pc[11] sky130_fd_sc_hd__clkbuf_1
Xoutput103 net103 VSS VSS VDD VDD pc[12] sky130_fd_sc_hd__clkbuf_1
Xoutput104 net104 VSS VSS VDD VDD pc[13] sky130_fd_sc_hd__clkbuf_1
Xoutput105 net105 VSS VSS VDD VDD pc[14] sky130_fd_sc_hd__clkbuf_1
Xoutput106 net106 VSS VSS VDD VDD pc[15] sky130_fd_sc_hd__clkbuf_1
Xoutput107 net107 VSS VSS VDD VDD pc[16] sky130_fd_sc_hd__clkbuf_1
Xoutput108 net108 VSS VSS VDD VDD pc[17] sky130_fd_sc_hd__clkbuf_1
Xoutput109 net109 VSS VSS VDD VDD pc[18] sky130_fd_sc_hd__clkbuf_1
Xoutput110 net110 VSS VSS VDD VDD pc[19] sky130_fd_sc_hd__clkbuf_1
Xoutput111 net111 VSS VSS VDD VDD pc[1] sky130_fd_sc_hd__clkbuf_1
Xoutput112 net112 VSS VSS VDD VDD pc[20] sky130_fd_sc_hd__clkbuf_1
Xoutput113 net113 VSS VSS VDD VDD pc[21] sky130_fd_sc_hd__clkbuf_1
Xoutput114 net114 VSS VSS VDD VDD pc[22] sky130_fd_sc_hd__clkbuf_1
Xoutput115 net115 VSS VSS VDD VDD pc[23] sky130_fd_sc_hd__clkbuf_1
Xoutput116 net116 VSS VSS VDD VDD pc[24] sky130_fd_sc_hd__clkbuf_1
Xoutput117 net117 VSS VSS VDD VDD pc[25] sky130_fd_sc_hd__clkbuf_1
Xoutput118 net118 VSS VSS VDD VDD pc[26] sky130_fd_sc_hd__clkbuf_1
Xoutput119 net119 VSS VSS VDD VDD pc[27] sky130_fd_sc_hd__clkbuf_1
Xoutput120 net120 VSS VSS VDD VDD pc[28] sky130_fd_sc_hd__clkbuf_1
Xoutput121 net121 VSS VSS VDD VDD pc[29] sky130_fd_sc_hd__clkbuf_1
Xoutput122 net122 VSS VSS VDD VDD pc[2] sky130_fd_sc_hd__clkbuf_1
Xoutput123 net123 VSS VSS VDD VDD pc[30] sky130_fd_sc_hd__clkbuf_1
Xoutput124 net124 VSS VSS VDD VDD pc[31] sky130_fd_sc_hd__clkbuf_1
Xoutput125 net125 VSS VSS VDD VDD pc[3] sky130_fd_sc_hd__clkbuf_1
Xoutput126 net126 VSS VSS VDD VDD pc[4] sky130_fd_sc_hd__clkbuf_1
Xoutput127 net127 VSS VSS VDD VDD pc[5] sky130_fd_sc_hd__clkbuf_1
Xoutput128 net128 VSS VSS VDD VDD pc[6] sky130_fd_sc_hd__clkbuf_1
Xoutput129 net129 VSS VSS VDD VDD pc[7] sky130_fd_sc_hd__clkbuf_1
Xoutput130 net130 VSS VSS VDD VDD pc[8] sky130_fd_sc_hd__clkbuf_1
Xoutput131 net131 VSS VSS VDD VDD pc[9] sky130_fd_sc_hd__clkbuf_1
Xoutput132 net132 VSS VSS VDD VDD suspend sky130_fd_sc_hd__clkbuf_1
Xoutput133 net133 VSS VSS VDD VDD writedata[0] sky130_fd_sc_hd__clkbuf_1
Xoutput134 net134 VSS VSS VDD VDD writedata[10] sky130_fd_sc_hd__clkbuf_1
Xoutput135 net135 VSS VSS VDD VDD writedata[11] sky130_fd_sc_hd__clkbuf_1
Xoutput136 net136 VSS VSS VDD VDD writedata[12] sky130_fd_sc_hd__clkbuf_1
Xoutput137 net137 VSS VSS VDD VDD writedata[13] sky130_fd_sc_hd__clkbuf_1
Xoutput138 net138 VSS VSS VDD VDD writedata[14] sky130_fd_sc_hd__clkbuf_1
Xoutput139 net139 VSS VSS VDD VDD writedata[15] sky130_fd_sc_hd__clkbuf_1
Xoutput140 net140 VSS VSS VDD VDD writedata[16] sky130_fd_sc_hd__clkbuf_1
Xoutput141 net141 VSS VSS VDD VDD writedata[17] sky130_fd_sc_hd__clkbuf_1
Xoutput142 net142 VSS VSS VDD VDD writedata[18] sky130_fd_sc_hd__clkbuf_1
Xoutput143 net143 VSS VSS VDD VDD writedata[19] sky130_fd_sc_hd__clkbuf_1
Xoutput144 net413 VSS VSS VDD VDD writedata[1] sky130_fd_sc_hd__clkbuf_1
Xoutput145 net145 VSS VSS VDD VDD writedata[20] sky130_fd_sc_hd__clkbuf_1
Xoutput146 net146 VSS VSS VDD VDD writedata[21] sky130_fd_sc_hd__clkbuf_1
Xoutput147 net147 VSS VSS VDD VDD writedata[22] sky130_fd_sc_hd__clkbuf_1
Xoutput148 net148 VSS VSS VDD VDD writedata[23] sky130_fd_sc_hd__clkbuf_1
Xoutput149 net149 VSS VSS VDD VDD writedata[24] sky130_fd_sc_hd__clkbuf_1
Xoutput150 net150 VSS VSS VDD VDD writedata[25] sky130_fd_sc_hd__clkbuf_1
Xoutput151 net151 VSS VSS VDD VDD writedata[26] sky130_fd_sc_hd__clkbuf_1
Xoutput152 net152 VSS VSS VDD VDD writedata[27] sky130_fd_sc_hd__clkbuf_1
Xoutput153 net153 VSS VSS VDD VDD writedata[28] sky130_fd_sc_hd__clkbuf_1
Xoutput154 net154 VSS VSS VDD VDD writedata[29] sky130_fd_sc_hd__clkbuf_1
Xoutput155 net155 VSS VSS VDD VDD writedata[2] sky130_fd_sc_hd__clkbuf_1
Xoutput156 net156 VSS VSS VDD VDD writedata[30] sky130_fd_sc_hd__clkbuf_1
Xoutput157 net157 VSS VSS VDD VDD writedata[31] sky130_fd_sc_hd__clkbuf_1
Xoutput158 net158 VSS VSS VDD VDD writedata[3] sky130_fd_sc_hd__clkbuf_1
Xoutput159 net159 VSS VSS VDD VDD writedata[4] sky130_fd_sc_hd__clkbuf_1
Xoutput160 net160 VSS VSS VDD VDD writedata[5] sky130_fd_sc_hd__clkbuf_1
Xoutput161 net161 VSS VSS VDD VDD writedata[6] sky130_fd_sc_hd__clkbuf_1
Xoutput162 net162 VSS VSS VDD VDD writedata[7] sky130_fd_sc_hd__clkbuf_1
Xoutput163 net163 VSS VSS VDD VDD writedata[8] sky130_fd_sc_hd__clkbuf_1
Xoutput164 net164 VSS VSS VDD VDD writedata[9] sky130_fd_sc_hd__clkbuf_1
Xload_slew165 _1921_ VSS VSS VDD VDD net165 sky130_fd_sc_hd__buf_12
Xload_slew166 _1921_ VSS VSS VDD VDD net166 sky130_fd_sc_hd__buf_16
Xload_slew167 net707 VSS VSS VDD VDD net167 sky130_fd_sc_hd__buf_12
Xload_slew168 net169 VSS VSS VDD VDD net168 sky130_fd_sc_hd__buf_16
Xload_slew169 net246 VSS VSS VDD VDD net169 sky130_fd_sc_hd__buf_16
Xload_slew170 _1890_ VSS VSS VDD VDD net170 sky130_fd_sc_hd__buf_16
Xload_slew171 _1890_ VSS VSS VDD VDD net171 sky130_fd_sc_hd__buf_16
Xload_slew172 net175 VSS VSS VDD VDD net172 sky130_fd_sc_hd__buf_6
Xload_slew173 net174 VSS VSS VDD VDD net173 sky130_fd_sc_hd__buf_6
Xload_slew174 _1803_ VSS VSS VDD VDD net174 sky130_fd_sc_hd__buf_6
Xload_slew175 _1803_ VSS VSS VDD VDD net175 sky130_fd_sc_hd__buf_6
Xmax_cap176 net177 VSS VSS VDD VDD net176 sky130_fd_sc_hd__buf_8
Xmax_cap177 _1809_ VSS VSS VDD VDD net177 sky130_fd_sc_hd__buf_8
Xload_slew178 _0132_ VSS VSS VDD VDD net178 sky130_fd_sc_hd__buf_8
Xload_slew179 _0132_ VSS VSS VDD VDD net179 sky130_fd_sc_hd__buf_16
Xload_slew180 net181 VSS VSS VDD VDD net180 sky130_fd_sc_hd__buf_16
Xload_slew181 _0348_ VSS VSS VDD VDD net181 sky130_fd_sc_hd__buf_16
Xwire182 _0337_ VSS VSS VDD VDD net182 sky130_fd_sc_hd__buf_12
Xload_slew183 _0337_ VSS VSS VDD VDD net183 sky130_fd_sc_hd__buf_16
Xwire184 _0290_ VSS VSS VDD VDD net184 sky130_fd_sc_hd__buf_12
Xwire185 _0256_ VSS VSS VDD VDD net185 sky130_fd_sc_hd__buf_12
Xload_slew186 _0256_ VSS VSS VDD VDD net186 sky130_fd_sc_hd__buf_16
Xload_slew187 net188 VSS VSS VDD VDD net187 sky130_fd_sc_hd__buf_16
Xload_slew188 _0232_ VSS VSS VDD VDD net188 sky130_fd_sc_hd__buf_16
Xload_slew189 net191 VSS VSS VDD VDD net189 sky130_fd_sc_hd__buf_16
Xwire190 _0221_ VSS VSS VDD VDD net190 sky130_fd_sc_hd__buf_12
Xload_slew191 _0221_ VSS VSS VDD VDD net191 sky130_fd_sc_hd__buf_16
Xload_slew192 _0212_ VSS VSS VDD VDD net192 sky130_fd_sc_hd__buf_16
Xload_slew193 _0209_ VSS VSS VDD VDD net193 sky130_fd_sc_hd__buf_8
Xload_slew194 _0209_ VSS VSS VDD VDD net194 sky130_fd_sc_hd__buf_8
Xload_slew195 _0202_ VSS VSS VDD VDD net195 sky130_fd_sc_hd__buf_16
Xmax_cap196 net197 VSS VSS VDD VDD net196 sky130_fd_sc_hd__buf_16
Xload_slew197 _0202_ VSS VSS VDD VDD net197 sky130_fd_sc_hd__buf_16
Xload_slew198 _0192_ VSS VSS VDD VDD net198 sky130_fd_sc_hd__buf_16
Xload_slew199 _0192_ VSS VSS VDD VDD net199 sky130_fd_sc_hd__buf_16
Xload_slew200 _0176_ VSS VSS VDD VDD net200 sky130_fd_sc_hd__buf_16
Xwire201 _0176_ VSS VSS VDD VDD net201 sky130_fd_sc_hd__buf_12
Xload_slew202 _0128_ VSS VSS VDD VDD net202 sky130_fd_sc_hd__buf_16
Xload_slew203 net204 VSS VSS VDD VDD net203 sky130_fd_sc_hd__buf_12
Xwire204 _0263_ VSS VSS VDD VDD net204 sky130_fd_sc_hd__buf_12
Xload_slew205 _0224_ VSS VSS VDD VDD net205 sky130_fd_sc_hd__buf_16
Xload_slew206 net208 VSS VSS VDD VDD net206 sky130_fd_sc_hd__buf_16
Xload_slew207 net208 VSS VSS VDD VDD net207 sky130_fd_sc_hd__buf_16
Xload_slew208 net9 VSS VSS VDD VDD net208 sky130_fd_sc_hd__buf_16
Xload_slew209 net210 VSS VSS VDD VDD net209 sky130_fd_sc_hd__buf_16
Xload_slew210 net7 VSS VSS VDD VDD net210 sky130_fd_sc_hd__buf_16
Xload_slew211 net7 VSS VSS VDD VDD net211 sky130_fd_sc_hd__buf_16
Xload_slew212 net213 VSS VSS VDD VDD net212 sky130_fd_sc_hd__buf_16
Xload_slew213 net215 VSS VSS VDD VDD net213 sky130_fd_sc_hd__buf_16
Xload_slew214 net13 VSS VSS VDD VDD net214 sky130_fd_sc_hd__buf_16
Xload_slew215 net13 VSS VSS VDD VDD net215 sky130_fd_sc_hd__buf_16
Xdp.rf.rf\[0\]\[0\]$_DFFE_PP__216 VSS VSS VDD VDD _unconnected_0
+ net216 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[10\]$_DFFE_PP__217 VSS VSS VDD VDD _unconnected_1
+ net217 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[11\]$_DFFE_PP__218 VSS VSS VDD VDD _unconnected_2
+ net218 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[12\]$_DFFE_PP__219 VSS VSS VDD VDD _unconnected_3
+ net219 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[13\]$_DFFE_PP__220 VSS VSS VDD VDD _unconnected_4
+ net220 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[14\]$_DFFE_PP__221 VSS VSS VDD VDD _unconnected_5
+ net221 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[15\]$_DFFE_PP__222 VSS VSS VDD VDD _unconnected_6
+ net222 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[18\]$_DFFE_PP__223 VSS VSS VDD VDD _unconnected_7
+ net223 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[19\]$_DFFE_PP__224 VSS VSS VDD VDD _unconnected_8
+ net224 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[1\]$_DFFE_PP__225 VSS VSS VDD VDD _unconnected_9
+ net225 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[20\]$_DFFE_PP__226 VSS VSS VDD VDD _unconnected_10
+ net226 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[21\]$_DFFE_PP__227 VSS VSS VDD VDD _unconnected_11
+ net227 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[22\]$_DFFE_PP__228 VSS VSS VDD VDD _unconnected_12
+ net228 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[23\]$_DFFE_PP__229 VSS VSS VDD VDD _unconnected_13
+ net229 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[24\]$_DFFE_PP__230 VSS VSS VDD VDD _unconnected_14
+ net230 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[25\]$_DFFE_PP__231 VSS VSS VDD VDD _unconnected_15
+ net231 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[26\]$_DFFE_PP__232 VSS VSS VDD VDD _unconnected_16
+ net232 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[27\]$_DFFE_PP__233 VSS VSS VDD VDD _unconnected_17
+ net233 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[28\]$_DFFE_PP__234 VSS VSS VDD VDD _unconnected_18
+ net234 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[29\]$_DFFE_PP__235 VSS VSS VDD VDD _unconnected_19
+ net235 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[2\]$_DFFE_PP__236 VSS VSS VDD VDD _unconnected_20
+ net236 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[30\]$_DFFE_PP__237 VSS VSS VDD VDD _unconnected_21
+ net237 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[31\]$_DFFE_PP__238 VSS VSS VDD VDD _unconnected_22
+ net238 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[3\]$_DFFE_PP__239 VSS VSS VDD VDD _unconnected_23
+ net239 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[4\]$_DFFE_PP__240 VSS VSS VDD VDD _unconnected_24
+ net240 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[5\]$_DFFE_PP__241 VSS VSS VDD VDD _unconnected_25
+ net241 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[6\]$_DFFE_PP__242 VSS VSS VDD VDD _unconnected_26
+ net242 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[7\]$_DFFE_PP__243 VSS VSS VDD VDD _unconnected_27
+ net243 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[8\]$_DFFE_PP__244 VSS VSS VDD VDD _unconnected_28
+ net244 sky130_fd_sc_hd__conb_1
Xdp.rf.rf\[0\]\[9\]$_DFFE_PP__245 VSS VSS VDD VDD _unconnected_29
+ net245 sky130_fd_sc_hd__conb_1
Xclkbuf_leaf_1_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_1_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_2_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_2_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_3_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_3_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_4_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_4_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_5_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_5_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_6_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_6_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_7_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_7_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_8_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_8_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_9_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_9_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_10_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_10_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_11_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_11_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_12_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_12_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_13_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_13_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_14_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_14_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_15_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_15_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_16_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_16_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_17_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_17_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_18_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_18_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_19_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_19_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_20_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_20_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_21_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_21_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_22_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_22_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_23_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_23_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_24_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_24_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_25_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_25_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_26_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_26_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_27_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_27_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_28_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_28_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_29_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_29_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_30_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_30_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_31_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_31_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_32_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_32_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_33_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_33_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_34_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_34_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_35_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_35_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_36_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_36_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_37_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_37_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_38_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_38_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_39_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_39_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_40_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_40_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_41_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_41_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_42_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_42_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_43_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_43_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_44_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_44_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_45_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_45_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_46_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_46_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_47_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_47_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_48_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_48_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_49_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_49_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_50_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_50_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_51_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_51_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_52_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_52_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_53_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_53_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_54_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_54_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_55_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_55_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_56_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_56_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_57_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_57_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_58_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_58_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_59_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_59_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_60_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_60_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_61_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_61_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_62_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_62_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_63_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_63_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_64_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_64_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_65_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_65_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_66_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_66_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_67_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_67_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_68_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_68_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_69_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_69_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_70_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_70_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_71_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_71_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_72_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_72_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_73_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_73_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_74_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_74_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_75_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_75_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_76_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_76_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_77_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_77_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_78_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_78_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_79_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_79_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_80_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_80_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_81_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_81_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_82_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_82_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_83_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_83_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_84_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_84_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_85_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_85_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_86_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_86_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_87_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_87_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_88_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_88_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_89_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_89_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_90_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_90_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_91_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_91_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_92_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_92_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_93_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_93_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_94_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_94_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_95_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_95_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_96_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_96_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_97_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_97_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_98_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_98_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_99_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_99_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_100_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_100_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_101_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_101_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_102_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_102_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_103_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_103_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_4__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_4__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_5__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_5__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_6__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_6__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_7__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_7__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_3_0__leaf_clk VSS VSS VDD VDD _unconnected_30
+ sky130_fd_sc_hd__clkinv_8
Xclkload1 clknet_3_3__leaf_clk VSS VSS VDD VDD _unconnected_31
+ sky130_fd_sc_hd__clkinv_16
Xclkload2 clknet_3_4__leaf_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__inv_6
Xclkload3 clknet_3_5__leaf_clk VSS VSS VDD VDD _unconnected_33
+ sky130_fd_sc_hd__inv_16
Xclkload4 clknet_3_6__leaf_clk VSS VSS VDD VDD _unconnected_34
+ sky130_fd_sc_hd__clkinv_16
Xclkload5 clknet_3_7__leaf_clk VSS VSS VDD VDD _unconnected_35
+ sky130_fd_sc_hd__inv_6
Xclkload6 clknet_leaf_1_clk VSS VSS VDD VDD _unconnected_36
+ sky130_fd_sc_hd__clkbuf_1
Xclkload7 clknet_leaf_89_clk VSS VSS VDD VDD _unconnected_37
+ sky130_fd_sc_hd__clkinv_2
Xclkload8 clknet_leaf_90_clk VSS VSS VDD VDD _unconnected_38
+ sky130_fd_sc_hd__bufinv_16
Xclkload9 clknet_leaf_95_clk VSS VSS VDD VDD _unconnected_39
+ sky130_fd_sc_hd__clkinv_1
Xclkload10 clknet_leaf_96_clk VSS VSS VDD VDD _unconnected_40
+ sky130_fd_sc_hd__clkinv_1
Xclkload11 clknet_leaf_97_clk VSS VSS VDD VDD _unconnected_41
+ sky130_fd_sc_hd__clkinv_1
Xclkload12 clknet_leaf_98_clk VSS VSS VDD VDD _unconnected_42
+ sky130_fd_sc_hd__clkinv_1
Xclkload13 clknet_leaf_100_clk VSS VSS VDD VDD _unconnected_43
+ sky130_fd_sc_hd__clkinv_1
Xclkload14 clknet_leaf_101_clk VSS VSS VDD VDD _unconnected_44
+ sky130_fd_sc_hd__clkinv_2
Xclkload15 clknet_leaf_103_clk VSS VSS VDD VDD _unconnected_45
+ sky130_fd_sc_hd__clkinv_2
Xclkload16 clknet_leaf_2_clk VSS VSS VDD VDD _unconnected_46
+ sky130_fd_sc_hd__bufinv_16
Xclkload17 clknet_leaf_3_clk VSS VSS VDD VDD _unconnected_47
+ sky130_fd_sc_hd__clkinv_2
Xclkload18 clknet_leaf_4_clk VSS VSS VDD VDD _unconnected_48
+ sky130_fd_sc_hd__clkinv_1
Xclkload19 clknet_leaf_5_clk VSS VSS VDD VDD _unconnected_49
+ sky130_fd_sc_hd__clkinv_1
Xclkload20 clknet_leaf_6_clk VSS VSS VDD VDD _unconnected_50
+ sky130_fd_sc_hd__bufinv_16
Xclkload21 clknet_leaf_7_clk VSS VSS VDD VDD _unconnected_51
+ sky130_fd_sc_hd__clkinv_4
Xclkload22 clknet_leaf_8_clk VSS VSS VDD VDD _unconnected_52
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload23 clknet_leaf_9_clk VSS VSS VDD VDD _unconnected_53
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload24 clknet_leaf_11_clk VSS VSS VDD VDD _unconnected_54
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload25 clknet_leaf_12_clk VSS VSS VDD VDD _unconnected_55
+ sky130_fd_sc_hd__clkinv_2
Xclkload26 clknet_leaf_13_clk VSS VSS VDD VDD _unconnected_56
+ sky130_fd_sc_hd__bufinv_16
Xclkload27 clknet_leaf_14_clk VSS VSS VDD VDD _unconnected_57
+ sky130_fd_sc_hd__bufinv_16
Xclkload28 clknet_leaf_85_clk VSS VSS VDD VDD _unconnected_58
+ sky130_fd_sc_hd__bufinv_16
Xclkload29 clknet_leaf_87_clk VSS VSS VDD VDD _unconnected_59
+ sky130_fd_sc_hd__clkinv_4
Xclkload30 clknet_leaf_88_clk VSS VSS VDD VDD _unconnected_60
+ sky130_fd_sc_hd__clkinv_1
Xclkload31 clknet_leaf_68_clk VSS VSS VDD VDD _unconnected_61
+ sky130_fd_sc_hd__clkinv_2
Xclkload32 clknet_leaf_69_clk VSS VSS VDD VDD _unconnected_62
+ sky130_fd_sc_hd__clkinv_4
Xclkload33 clknet_leaf_70_clk VSS VSS VDD VDD _unconnected_63
+ sky130_fd_sc_hd__clkinv_1
Xclkload34 clknet_leaf_72_clk VSS VSS VDD VDD _unconnected_64
+ sky130_fd_sc_hd__clkbuf_1
Xclkload35 clknet_leaf_73_clk VSS VSS VDD VDD _unconnected_65
+ sky130_fd_sc_hd__clkbuf_1
Xclkload36 clknet_leaf_74_clk VSS VSS VDD VDD _unconnected_66
+ sky130_fd_sc_hd__clkinv_1
Xclkload37 clknet_leaf_75_clk VSS VSS VDD VDD _unconnected_67
+ sky130_fd_sc_hd__clkinv_2
Xclkload38 clknet_leaf_76_clk VSS VSS VDD VDD _unconnected_68
+ sky130_fd_sc_hd__clkbuf_1
Xclkload39 clknet_leaf_77_clk VSS VSS VDD VDD _unconnected_69
+ sky130_fd_sc_hd__clkinv_1
Xclkload40 clknet_leaf_78_clk VSS VSS VDD VDD _unconnected_70
+ sky130_fd_sc_hd__clkinv_1
Xclkload41 clknet_leaf_79_clk VSS VSS VDD VDD _unconnected_71
+ sky130_fd_sc_hd__clkinv_1
Xclkload42 clknet_leaf_80_clk VSS VSS VDD VDD _unconnected_72
+ sky130_fd_sc_hd__clkinv_2
Xclkload43 clknet_leaf_92_clk VSS VSS VDD VDD _unconnected_73
+ sky130_fd_sc_hd__clkinv_1
Xclkload44 clknet_leaf_93_clk VSS VSS VDD VDD _unconnected_74
+ sky130_fd_sc_hd__clkinv_2
Xclkload45 clknet_leaf_94_clk VSS VSS VDD VDD _unconnected_75
+ sky130_fd_sc_hd__bufinv_16
Xclkload46 clknet_leaf_65_clk VSS VSS VDD VDD _unconnected_76
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload47 clknet_leaf_66_clk VSS VSS VDD VDD _unconnected_77
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload48 clknet_leaf_67_clk VSS VSS VDD VDD _unconnected_78
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload49 clknet_leaf_81_clk VSS VSS VDD VDD _unconnected_79
+ sky130_fd_sc_hd__clkinv_1
Xclkload50 clknet_leaf_82_clk VSS VSS VDD VDD _unconnected_80
+ sky130_fd_sc_hd__clkbuf_1
Xclkload51 clknet_leaf_91_clk VSS VSS VDD VDD _unconnected_81
+ sky130_fd_sc_hd__clkinv_1
Xclkload52 clknet_leaf_17_clk VSS VSS VDD VDD _unconnected_82
+ sky130_fd_sc_hd__clkinv_2
Xclkload53 clknet_leaf_18_clk VSS VSS VDD VDD _unconnected_83
+ sky130_fd_sc_hd__clkinv_1
Xclkload54 clknet_leaf_19_clk VSS VSS VDD VDD _unconnected_84
+ sky130_fd_sc_hd__clkinv_1
Xclkload55 clknet_leaf_20_clk VSS VSS VDD VDD _unconnected_85
+ sky130_fd_sc_hd__clkbuf_1
Xclkload56 clknet_leaf_21_clk VSS VSS VDD VDD _unconnected_86
+ sky130_fd_sc_hd__clkinv_1
Xclkload57 clknet_leaf_22_clk VSS VSS VDD VDD _unconnected_87
+ sky130_fd_sc_hd__clkinv_2
Xclkload58 clknet_leaf_23_clk VSS VSS VDD VDD _unconnected_88
+ sky130_fd_sc_hd__clkinv_1
Xclkload59 clknet_leaf_24_clk VSS VSS VDD VDD _unconnected_89
+ sky130_fd_sc_hd__clkinv_2
Xclkload60 clknet_leaf_25_clk VSS VSS VDD VDD _unconnected_90
+ sky130_fd_sc_hd__bufinv_16
Xclkload61 clknet_leaf_26_clk VSS VSS VDD VDD _unconnected_91
+ sky130_fd_sc_hd__clkinv_2
Xclkload62 clknet_leaf_28_clk VSS VSS VDD VDD _unconnected_92
+ sky130_fd_sc_hd__clkinv_1
Xclkload63 clknet_leaf_44_clk VSS VSS VDD VDD _unconnected_93
+ sky130_fd_sc_hd__clkinv_2
Xclkload64 clknet_leaf_29_clk VSS VSS VDD VDD _unconnected_94
+ sky130_fd_sc_hd__clkinv_2
Xclkload65 clknet_leaf_30_clk VSS VSS VDD VDD _unconnected_95
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload66 clknet_leaf_31_clk VSS VSS VDD VDD _unconnected_96
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload67 clknet_leaf_32_clk VSS VSS VDD VDD _unconnected_97
+ sky130_fd_sc_hd__clkinv_2
Xclkload68 clknet_leaf_34_clk VSS VSS VDD VDD _unconnected_98
+ sky130_fd_sc_hd__clkbuf_1
Xclkload69 clknet_leaf_35_clk VSS VSS VDD VDD _unconnected_99
+ sky130_fd_sc_hd__clkinv_2
Xclkload70 clknet_leaf_36_clk VSS VSS VDD VDD _unconnected_100
+ sky130_fd_sc_hd__clkinv_1
Xclkload71 clknet_leaf_37_clk VSS VSS VDD VDD _unconnected_101
+ sky130_fd_sc_hd__bufinv_16
Xclkload72 clknet_leaf_38_clk VSS VSS VDD VDD _unconnected_102
+ sky130_fd_sc_hd__clkbuf_1
Xclkload73 clknet_leaf_42_clk VSS VSS VDD VDD _unconnected_103
+ sky130_fd_sc_hd__clkinv_2
Xclkload74 clknet_leaf_43_clk VSS VSS VDD VDD _unconnected_104
+ sky130_fd_sc_hd__clkbuf_1
Xclkload75 clknet_leaf_15_clk VSS VSS VDD VDD _unconnected_105
+ sky130_fd_sc_hd__clkinv_1
Xclkload76 clknet_leaf_45_clk VSS VSS VDD VDD _unconnected_106
+ sky130_fd_sc_hd__clkinv_2
Xclkload77 clknet_leaf_46_clk VSS VSS VDD VDD _unconnected_107
+ sky130_fd_sc_hd__clkinv_2
Xclkload78 clknet_leaf_47_clk VSS VSS VDD VDD _unconnected_108
+ sky130_fd_sc_hd__clkinv_2
Xclkload79 clknet_leaf_48_clk VSS VSS VDD VDD _unconnected_109
+ sky130_fd_sc_hd__clkinv_2
Xclkload80 clknet_leaf_49_clk VSS VSS VDD VDD _unconnected_110
+ sky130_fd_sc_hd__bufinv_16
Xclkload81 clknet_leaf_50_clk VSS VSS VDD VDD _unconnected_111
+ sky130_fd_sc_hd__clkbuf_1
Xclkload82 clknet_leaf_63_clk VSS VSS VDD VDD _unconnected_112
+ sky130_fd_sc_hd__inv_6
Xclkload83 clknet_leaf_64_clk VSS VSS VDD VDD _unconnected_113
+ sky130_fd_sc_hd__inv_6
Xclkload84 clknet_leaf_40_clk VSS VSS VDD VDD _unconnected_114
+ sky130_fd_sc_hd__clkbuf_1
Xclkload85 clknet_leaf_41_clk VSS VSS VDD VDD _unconnected_115
+ sky130_fd_sc_hd__clkinv_1
Xclkload86 clknet_leaf_51_clk VSS VSS VDD VDD _unconnected_116
+ sky130_fd_sc_hd__clkbuf_1
Xclkload87 clknet_leaf_52_clk VSS VSS VDD VDD _unconnected_117
+ sky130_fd_sc_hd__clkinv_2
Xclkload88 clknet_leaf_53_clk VSS VSS VDD VDD _unconnected_118
+ sky130_fd_sc_hd__clkinv_2
Xclkload89 clknet_leaf_55_clk VSS VSS VDD VDD _unconnected_119
+ sky130_fd_sc_hd__clkinv_1
Xclkload90 clknet_leaf_56_clk VSS VSS VDD VDD _unconnected_120
+ sky130_fd_sc_hd__clkbuf_1
Xclkload91 clknet_leaf_57_clk VSS VSS VDD VDD _unconnected_121
+ sky130_fd_sc_hd__clkbuf_1
Xclkload92 clknet_leaf_58_clk VSS VSS VDD VDD _unconnected_122
+ sky130_fd_sc_hd__clkinv_2
Xclkload93 clknet_leaf_59_clk VSS VSS VDD VDD _unconnected_123
+ sky130_fd_sc_hd__clkinv_1
Xclkload94 clknet_leaf_60_clk VSS VSS VDD VDD _unconnected_124
+ sky130_fd_sc_hd__bufinv_16
Xclkload95 clknet_leaf_61_clk VSS VSS VDD VDD _unconnected_125
+ sky130_fd_sc_hd__clkinv_1
Xrebuffer1 _1893_ VSS VSS VDD VDD net246 sky130_fd_sc_hd__buf_8
Xrebuffer2 net246 VSS VSS VDD VDD net247 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer3 net246 VSS VSS VDD VDD net248 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer4 net263 VSS VSS VDD VDD net249 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer5 net263 VSS VSS VDD VDD net250 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer6 net246 VSS VSS VDD VDD net251 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer7 net246 VSS VSS VDD VDD net252 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer8 net252 VSS VSS VDD VDD net253 sky130_fd_sc_hd__buf_4
Xrebuffer9 net253 VSS VSS VDD VDD net254 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer10 net253 VSS VSS VDD VDD net255 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer11 _1893_ VSS VSS VDD VDD net256 sky130_fd_sc_hd__dlygate4sd1_1
Xclone12 net260 VSS VSS VDD VDD net257 sky130_fd_sc_hd__clkbuf_16
Xrebuffer13 net169 VSS VSS VDD VDD net258 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer14 net258 VSS VSS VDD VDD net259 sky130_fd_sc_hd__buf_2
Xrebuffer15 net258 VSS VSS VDD VDD net260 sky130_fd_sc_hd__dlymetal6s4s_1
Xclone16 net262 VSS VSS VDD VDD net261 sky130_fd_sc_hd__clkbuf_16
Xrebuffer17 net246 VSS VSS VDD VDD net262 sky130_fd_sc_hd__dlygate4sd1_1
Xclone18 net264 VSS VSS VDD VDD net263 sky130_fd_sc_hd__clkbuf_16
Xrebuffer19 _1893_ VSS VSS VDD VDD net264 sky130_fd_sc_hd__dlygate4sd1_1
Xclone20 net408 _0138_ _1753_ VSS VSS VDD VDD net265 sky130_fd_sc_hd__o21a_2
Xclone21 _1605_ net430 net178 VSS VSS VDD VDD net266 sky130_fd_sc_hd__mux2i_2
Xclone22 net178 _3535_ net433 VSS VSS VDD VDD net267 sky130_fd_sc_hd__o21a_2
Xrebuffer23 dp.rf.rf\[11\]\[0\] VSS VSS VDD VDD net268 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer24 dp.rf.rf\[10\]\[0\] VSS VSS VDD VDD net269 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer25 _3518_ VSS VSS VDD VDD net270 sky130_fd_sc_hd__clkbuf_2
Xrebuffer26 net270 VSS VSS VDD VDD net271 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer30 _2697_ VSS VSS VDD VDD net275 sky130_fd_sc_hd__buf_2
Xclone31 net169 VSS VSS VDD VDD net276 sky130_fd_sc_hd__clkbuf_16
Xrebuffer35 net86 VSS VSS VDD VDD net280 sky130_fd_sc_hd__buf_6
Xrebuffer39 net84 VSS VSS VDD VDD net284 sky130_fd_sc_hd__buf_6
Xrebuffer43 _1845_ VSS VSS VDD VDD net288 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer56 net82 VSS VSS VDD VDD net301 sky130_fd_sc_hd__clkbuf_4
Xclone63 _3130_ _3133_ _3134_ VSS VSS VDD VDD net308 sky130_fd_sc_hd__a21oi_4
Xclone64 _3133_ _3130_ _3134_ VSS VSS VDD VDD net309 sky130_fd_sc_hd__a21oi_4
Xclone113 _3130_ _3133_ _3134_ VSS VSS VDD VDD net358 sky130_fd_sc_hd__a21oi_4
Xclone162 net410 _0138_ _1753_ VSS VSS VDD VDD net407 sky130_fd_sc_hd__o21ai_4
Xrebuffer163 net144 VSS VSS VDD VDD net408 sky130_fd_sc_hd__buf_6
Xrebuffer164 net408 VSS VSS VDD VDD net409 sky130_fd_sc_hd__buf_6
Xrebuffer165 net409 VSS VSS VDD VDD net410 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer166 net409 VSS VSS VDD VDD net411 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer167 net409 VSS VSS VDD VDD net412 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer168 net408 VSS VSS VDD VDD net413 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer175 _2680_ VSS VSS VDD VDD net420 sky130_fd_sc_hd__buf_6
Xrebuffer176 _1702_ VSS VSS VDD VDD net421 sky130_fd_sc_hd__buf_2
Xrebuffer177 net421 VSS VSS VDD VDD net422 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer178 net421 VSS VSS VDD VDD net423 sky130_fd_sc_hd__buf_2
Xrebuffer179 net423 VSS VSS VDD VDD net424 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer180 net423 VSS VSS VDD VDD net425 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer181 net421 VSS VSS VDD VDD net426 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer182 net426 VSS VSS VDD VDD net427 sky130_fd_sc_hd__buf_2
Xrebuffer183 _1618_ VSS VSS VDD VDD net428 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer184 _1618_ VSS VSS VDD VDD net429 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer185 net429 VSS VSS VDD VDD net430 sky130_fd_sc_hd__dlygate4sd1_1
Xclone186 _3539_ net158 net178 VSS VSS VDD VDD net431 sky130_fd_sc_hd__mux2_4
Xrebuffer187 _1701_ VSS VSS VDD VDD net432 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer188 net432 VSS VSS VDD VDD net433 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer189 dp.rf.rf\[21\]\[2\] VSS VSS VDD VDD net434 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer190 _3510_ VSS VSS VDD VDD net435 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer191 dp.rf.rf\[20\]\[2\] VSS VSS VDD VDD net436 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer192 _1619_ VSS VSS VDD VDD net437 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer193 net437 VSS VSS VDD VDD net438 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer194 net437 VSS VSS VDD VDD net439 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer195 net437 VSS VSS VDD VDD net440 sky130_fd_sc_hd__buf_6
Xrebuffer196 net440 VSS VSS VDD VDD net441 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer197 net441 VSS VSS VDD VDD net442 sky130_fd_sc_hd__buf_2
Xrebuffer198 net440 VSS VSS VDD VDD net443 sky130_fd_sc_hd__dlygate4sd1_1
Xclone220 _3539_ net158 net178 VSS VSS VDD VDD net465 sky130_fd_sc_hd__mux2_4
Xclone221 net409 _0138_ _1753_ VSS VSS VDD VDD net466 sky130_fd_sc_hd__o21a_2
Xclone229 _2781_ _3087_ _3232_ net530 _3234_ VSS VSS VDD VDD
+ net474 sky130_fd_sc_hd__o221ai_4
Xclone230 _2781_ _3087_ _3232_ net530 _3234_ VSS VSS VDD VDD
+ net475 sky130_fd_sc_hd__o221ai_4
Xrebuffer252 _3279_ VSS VSS VDD VDD net497 sky130_fd_sc_hd__buf_8
Xrebuffer253 net497 VSS VSS VDD VDD net498 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer254 net497 VSS VSS VDD VDD net499 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer255 net499 VSS VSS VDD VDD net500 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer256 net497 VSS VSS VDD VDD net501 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer257 net497 VSS VSS VDD VDD net502 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer285 _3233_ VSS VSS VDD VDD net530 sky130_fd_sc_hd__buf_12
Xclone286 _2781_ _3087_ _3232_ net530 _3234_ VSS VSS VDD VDD
+ net531 sky130_fd_sc_hd__o221ai_4
Xclone342 _3135_ _3058_ net607 VSS VSS VDD VDD net587 sky130_fd_sc_hd__a21oi_4
Xclone343 _3135_ _3058_ net607 VSS VSS VDD VDD net588 sky130_fd_sc_hd__a21oi_4
Xrebuffer46 _2336_ VSS VSS VDD VDD net304 sky130_fd_sc_hd__dlygate4sd3_1
Xrebuffer360 _3268_ VSS VSS VDD VDD net605 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer361 _0139_ VSS VSS VDD VDD net606 sky130_fd_sc_hd__buf_6
Xrebuffer362 _3214_ VSS VSS VDD VDD net607 sky130_fd_sc_hd__buf_12
Xclone363 _3135_ _3058_ net607 VSS VSS VDD VDD net608 sky130_fd_sc_hd__a21oi_4
Xrebuffer364 net79 VSS VSS VDD VDD net609 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer372 net83 VSS VSS VDD VDD net617 sky130_fd_sc_hd__clkbuf_2
Xrebuffer380 net81 VSS VSS VDD VDD net625 sky130_fd_sc_hd__dlygate4sd1_1
Xclone389 _2781_ _3068_ _3075_ _2741_ _3222_ VSS VSS VDD VDD
+ net634 sky130_fd_sc_hd__o221ai_4
Xclone390 _2781_ _3068_ _3075_ _2741_ net636 VSS VSS VDD VDD
+ net635 sky130_fd_sc_hd__o221ai_4
Xrebuffer391 _3222_ VSS VSS VDD VDD net636 sky130_fd_sc_hd__buf_6
Xclone392 _2781_ _3068_ _3075_ _2741_ _3222_ VSS VSS VDD VDD
+ net637 sky130_fd_sc_hd__o221ai_4
Xclone393 _2781_ _2940_ _2947_ _2741_ net492 VSS VSS VDD VDD
+ net638 sky130_fd_sc_hd__o221ai_4
Xclone394 _2781_ _2940_ _2947_ _2741_ net492 VSS VSS VDD VDD
+ net639 sky130_fd_sc_hd__o221ai_4
Xclone395 _3135_ _2976_ _3170_ _3171_ VSS VSS VDD VDD net640
+ sky130_fd_sc_hd__a211oi_4
Xclone403 _2781_ _2940_ _2947_ _2741_ net492 VSS VSS VDD VDD
+ net648 sky130_fd_sc_hd__o221ai_4
Xclone404 _2781_ _3013_ _3020_ _2741_ net659 VSS VSS VDD VDD
+ net649 sky130_fd_sc_hd__o221ai_4
Xclone405 _2781_ _3013_ _3020_ _2741_ net659 VSS VSS VDD VDD
+ net650 sky130_fd_sc_hd__o221ai_4
Xclone413 _2781_ _3013_ _3020_ _2741_ net659 VSS VSS VDD VDD
+ net658 sky130_fd_sc_hd__o221ai_4
Xrebuffer414 _3196_ VSS VSS VDD VDD net659 sky130_fd_sc_hd__buf_12
Xrebuffer415 net659 VSS VSS VDD VDD net660 sky130_fd_sc_hd__buf_6
Xclone416 _2781_ _2985_ _2988_ _2741_ net663 VSS VSS VDD VDD
+ net661 sky130_fd_sc_hd__o221ai_4
Xclone417 _2781_ _2985_ _2988_ _2741_ net663 VSS VSS VDD VDD
+ net662 sky130_fd_sc_hd__o221ai_4
Xrebuffer418 _3179_ VSS VSS VDD VDD net663 sky130_fd_sc_hd__buf_12
Xclone433 net301 _3203_ _3206_ _3202_ VSS VSS VDD VDD net678
+ sky130_fd_sc_hd__a2bb2oi_4
Xclone441 _0128_ _3097_ net523 _3135_ net527 VSS VSS VDD VDD
+ net686 sky130_fd_sc_hd__a221oi_4
Xrebuffer442 net686 VSS VSS VDD VDD net687 sky130_fd_sc_hd__buf_6
Xrebuffer443 net686 VSS VSS VDD VDD net688 sky130_fd_sc_hd__buf_6
Xrebuffer462 _1896_ VSS VSS VDD VDD net707 sky130_fd_sc_hd__buf_6
Xrebuffer463 _1896_ VSS VSS VDD VDD net708 sky130_fd_sc_hd__buf_2
Xrebuffer464 net708 VSS VSS VDD VDD net709 sky130_fd_sc_hd__buf_6
Xclone465 _3136_ net711 _3200_ VSS VSS VDD VDD net710 sky130_fd_sc_hd__a21boi_4
Xrebuffer466 _3199_ VSS VSS VDD VDD net711 sky130_fd_sc_hd__buf_12
Xclone467 _3225_ net420 _3228_ VSS VSS VDD VDD net712 sky130_fd_sc_hd__o21ai_4
Xwire1 dp.result2\[7\] VSS VSS VDD VDD net272 sky130_fd_sc_hd__buf_16
Xload_slew2 _3140_ VSS VSS VDD VDD net273 sky130_fd_sc_hd__buf_8
Xload_slew3 net14 VSS VSS VDD VDD net274 sky130_fd_sc_hd__buf_16
Xload_slew4 net278 VSS VSS VDD VDD net277 sky130_fd_sc_hd__buf_16
Xload_slew5 net14 VSS VSS VDD VDD net278 sky130_fd_sc_hd__buf_16
Xrebuffer12 _1844_ VSS VSS VDD VDD net279 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer47 _2268_ VSS VSS VDD VDD net305 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer62 net75 VSS VSS VDD VDD net321 sky130_fd_sc_hd__buf_6
Xrebuffer226 _3151_ VSS VSS VDD VDD net492 sky130_fd_sc_hd__buf_12
Xrebuffer227 net95 VSS VSS VDD VDD net493 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer242 net525 VSS VSS VDD VDD net514 sky130_fd_sc_hd__buf_6
Xrebuffer243 _3487_ VSS VSS VDD VDD net515 sky130_fd_sc_hd__buf_12
Xrebuffer244 net515 VSS VSS VDD VDD net516 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer245 net515 VSS VSS VDD VDD net517 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer246 net517 VSS VSS VDD VDD net518 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer247 _3495_ VSS VSS VDD VDD net519 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer248 net519 VSS VSS VDD VDD net520 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer249 _3495_ VSS VSS VDD VDD net521 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer250 net521 VSS VSS VDD VDD net522 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer251 _3103_ VSS VSS VDD VDD net523 sky130_fd_sc_hd__buf_2
Xclone252 net525 VSS VSS VDD VDD net524 sky130_fd_sc_hd__buf_2
Xrebuffer258 dp.result2\[31\] VSS VSS VDD VDD net525 sky130_fd_sc_hd__buf_6
Xrebuffer259 net525 VSS VSS VDD VDD net526 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer260 _3242_ VSS VSS VDD VDD net527 sky130_fd_sc_hd__buf_12
Xrebuffer338 net94 VSS VSS VDD VDD net613 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer339 dp.result2\[23\] VSS VSS VDD VDD net614 sky130_fd_sc_hd__buf_12
Xrebuffer440 dp.result2\[24\] VSS VSS VDD VDD net733 sky130_fd_sc_hd__buf_12
Xrebuffer441 dp.result2\[29\] VSS VSS VDD VDD net734 sky130_fd_sc_hd__buf_12
Xclone442 net301 _3203_ _3206_ _3202_ VSS VSS VDD VDD net735
+ sky130_fd_sc_hd__a2bb2oi_4
Xclone443 _2781_ _2985_ _2988_ _2741_ net663 VSS VSS VDD VDD
+ net736 sky130_fd_sc_hd__o221ai_4
Xclone444 _2781_ _3008_ _3011_ _2741_ net814 VSS VSS VDD VDD
+ net737 sky130_fd_sc_hd__o221ai_4
Xclone449 _2781_ _3008_ _3011_ _2741_ net815 VSS VSS VDD VDD
+ net742 sky130_fd_sc_hd__o221ai_4
Xrebuffer525 _3193_ VSS VSS VDD VDD net814 sky130_fd_sc_hd__buf_12
Xrebuffer526 net814 VSS VSS VDD VDD net815 sky130_fd_sc_hd__buf_4
Xrebuffer559 dp.result2\[16\] VSS VSS VDD VDD net848 sky130_fd_sc_hd__buf_6
Xrebuffer560 net848 VSS VSS VDD VDD net849 sky130_fd_sc_hd__buf_6
Xclone561 _2781_ _3000_ _3004_ _2741_ net851 VSS VSS VDD VDD
+ net850 sky130_fd_sc_hd__o221ai_4
Xrebuffer562 _3190_ VSS VSS VDD VDD net851 sky130_fd_sc_hd__buf_12
Xrebuffer563 _3463_ VSS VSS VDD VDD net852 sky130_fd_sc_hd__buf_8
Xrebuffer564 net852 VSS VSS VDD VDD net853 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer565 net853 VSS VSS VDD VDD net854 sky130_fd_sc_hd__buf_1
Xrebuffer566 net853 VSS VSS VDD VDD net855 sky130_fd_sc_hd__buf_4
Xrebuffer567 net855 VSS VSS VDD VDD net856 sky130_fd_sc_hd__dlygate4sd1_1
Xclone617 _3136_ net711 _3200_ VSS VSS VDD VDD net906 sky130_fd_sc_hd__a21boi_4
Xclone642 _3137_ net617 _3210_ VSS VSS VDD VDD net931 sky130_fd_sc_hd__o21a_2
Xclone643 net178 _3535_ net432 VSS VSS VDD VDD net932 sky130_fd_sc_hd__o21ai_2
Xrebuffer644 net640 VSS VSS VDD VDD net933 sky130_fd_sc_hd__buf_6
Xclone645 _2781_ _2979_ _2983_ _2741_ _3176_ VSS VSS VDD VDD
+ net934 sky130_fd_sc_hd__o221ai_4
Xclone646 _2781_ _2979_ _2983_ _2741_ _3176_ VSS VSS VDD VDD
+ net935 sky130_fd_sc_hd__o221ai_4
Xclone647 _3249_ _3136_ _3250_ VSS VSS VDD VDD net936 sky130_fd_sc_hd__a21boi_4
XANTENNA_1 net199 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_2 net187 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_3 net129 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_4 net123 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_5 net123 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_6 net121 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_7 net121 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_8 net121 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_9 _0955_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_10 net5 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_11 dp.result2\[19\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_12 dp.result2\[26\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_13 net617 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_14 _0005_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_15 _2833_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS riscv
