* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT smart_fifo almost_empty almost_full clear_errors clk
+ data_count[0] data_count[1] data_count[2] data_count[3] data_count[4]
+ empty error_count[0] error_count[10] error_count[11] error_count[12]
+ error_count[13] error_count[14] error_count[15] error_count[1]
+ error_count[2] error_count[3] error_count[4] error_count[5]
+ error_count[6] error_count[7] error_count[8] error_count[9]
+ error_detected full overflow_detected rd_data[0] rd_data[10]
+ rd_data[11] rd_data[12] rd_data[13] rd_data[14] rd_data[15]
+ rd_data[16] rd_data[17] rd_data[18] rd_data[19] rd_data[1]
+ rd_data[20] rd_data[21] rd_data[22] rd_data[23] rd_data[24]
+ rd_data[25] rd_data[26] rd_data[27] rd_data[28] rd_data[29]
+ rd_data[2] rd_data[30] rd_data[31] rd_data[3] rd_data[4] rd_data[5]
+ rd_data[6] rd_data[7] rd_data[8] rd_data[9] rd_en rd_valid
+ rst_n underflow_detected wr_data[0] wr_data[10] wr_data[11]
+ wr_data[12] wr_data[13] wr_data[14] wr_data[15] wr_data[16]
+ wr_data[17] wr_data[18] wr_data[19] wr_data[1] wr_data[20]
+ wr_data[21] wr_data[22] wr_data[23] wr_data[24] wr_data[25]
+ wr_data[26] wr_data[27] wr_data[28] wr_data[29] wr_data[2]
+ wr_data[30] wr_data[31] wr_data[3] wr_data[4] wr_data[5] wr_data[6]
+ wr_data[7] wr_data[8] wr_data[9] wr_en wr_ready
X_0518_ _0517_ VSS VSS VDD VDD net38 sky130_fd_sc_hd__inv_1
X_0519_ _0505_ _0497_ VSS VSS VDD VDD net40 sky130_fd_sc_hd__xor2_2
X_0520_ _0516_ _0502_ _0505_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__nand3b_1
X_0521_ _0505_ _0501_ _0504_ VSS VSS VDD VDD _0280_ sky130_fd_sc_hd__a21oi_1
X_0522_ _0279_ _0280_ VSS VSS VDD VDD _0281_ sky130_fd_sc_hd__nand2_1
X_0523_ _0500_ _0281_ VSS VSS VDD VDD net41 sky130_fd_sc_hd__xor2_1
X_0524_ _0500_ _0505_ _0497_ VSS VSS VDD VDD _0282_ sky130_fd_sc_hd__nand3_1
X_0525_ _0500_ _0504_ _0499_ VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__a21oi_1
X_0526_ wr_ptr\[4\] rd_ptr\[4\] VSS VSS VDD VDD _0284_ sky130_fd_sc_hd__xor2_2
X_0527_ _0282_ _0283_ _0284_ VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__a21oi_4
X_0528_ _0282_ _0283_ _0284_ VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__and3_2
X_0529_ _0285_ _0286_ VSS VSS VDD VDD net42 sky130_fd_sc_hd__nor2_1
X_0530_ net39 _0517_ _0500_ VSS VSS VDD VDD _0287_ sky130_fd_sc_hd__nand3b_1
X_0531_ _0279_ _0280_ _0287_ net40 VSS VSS VDD VDD _0288_
+ sky130_fd_sc_hd__a211o_1
X_0532_ _0500_ net39 _0517_ VSS VSS VDD VDD _0289_ sky130_fd_sc_hd__nor3b_1
X_0533_ net40 _0279_ _0280_ _0289_ VSS VSS VDD VDD _0290_
+ sky130_fd_sc_hd__nand4b_2
X_0534_ _0288_ _0290_ _0285_ _0286_ VSS VSS VDD VDD net61
+ sky130_fd_sc_hd__a211oi_4
X_0535_ _0285_ _0286_ _0288_ _0290_ VSS VSS VDD VDD net43
+ sky130_fd_sc_hd__a2bb2oi_4
X_0536_ net43 VSS VSS VDD VDD _0291_ sky130_fd_sc_hd__clkinv_4
X_0537_ _0291_ VSS VSS VDD VDD _0292_ sky130_fd_sc_hd__buf_6
X_0538_ _0292_ VSS VSS VDD VDD net95 sky130_fd_sc_hd__buf_4
X_0539_ net133 VSS VSS VDD VDD _0293_ sky130_fd_sc_hd__clkbuf_4
X_0540_ _0293_ net43 VSS VSS VDD VDD _0294_ sky130_fd_sc_hd__nand2_1
X_0541_ _0294_ VSS VSS VDD VDD net96 sky130_fd_sc_hd__inv_1
X_0542_ net60 VSS VSS VDD VDD _0295_ sky130_fd_sc_hd__inv_1
X_0543_ _0295_ net2 _0294_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__o21ai_0
X_0544_ wr_ptr\[2\] net35 VSS VSS VDD VDD _0296_ sky130_fd_sc_hd__nor2b_1
X_0545_ wr_ptr\[3\] _0296_ VSS VSS VDD VDD _0297_ sky130_fd_sc_hd__nor2b_1
X_0546_ _0509_ _0297_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__and2_4
X_0547_ _0512_ _0297_ VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__and2_4
X_0548_ _0510_ _0297_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__and2_4
X_0549_ _0514_ _0297_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__and2_4
X_0550_ net35 wr_ptr\[2\] VSS VSS VDD VDD _0298_ sky130_fd_sc_hd__nand2_1
X_0551_ wr_ptr\[3\] _0298_ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__nor2_1
X_0552_ _0509_ _0299_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__and2_4
X_0553_ _0512_ _0299_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__and2_4
X_0554_ _0510_ _0299_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__and2_4
X_0555_ _0514_ _0299_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__and2_4
X_0556_ wr_ptr\[3\] _0509_ _0296_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__and3_4
X_0557_ wr_ptr\[3\] _0512_ _0296_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__and3_4
X_0558_ wr_ptr\[3\] _0510_ _0296_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__and3_4
X_0559_ wr_ptr\[3\] _0514_ _0296_ VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__and3_4
X_0560_ net35 wr_ptr\[3\] wr_ptr\[2\] VSS VSS VDD VDD _0300_
+ sky130_fd_sc_hd__and3_1
X_0561_ _0509_ _0300_ VSS VSS VDD VDD _0004_ sky130_fd_sc_hd__and2_4
X_0562_ _0512_ _0300_ VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__and2_4
X_0563_ _0510_ _0300_ VSS VSS VDD VDD _0006_ sky130_fd_sc_hd__and2_4
X_0564_ _0514_ _0300_ VSS VSS VDD VDD _0007_ sky130_fd_sc_hd__and2_4
X_0565_ rd_ptr\[3\] VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__inv_1
X_0566_ rd_ptr\[1\] VSS VSS VDD VDD _0301_ sky130_fd_sc_hd__clkbuf_2
X_0567_ _0301_ VSS VSS VDD VDD _0302_ sky130_fd_sc_hd__buf_4
X_0568_ _0302_ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__buf_6
X_0569_ _0303_ VSS VSS VDD VDD _0495_ sky130_fd_sc_hd__inv_1
X_0570_ _0516_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__inv_1
X_0571_ rd_ptr\[2\] VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__buf_4
X_0572_ _0304_ VSS VSS VDD VDD _0305_ sky130_fd_sc_hd__buf_4
X_0573_ _0305_ VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__inv_1
X_0574_ wr_ptr\[0\] VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__inv_1
X_0575_ wr_ptr\[1\] VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__inv_1
X_0576_ net44 _0294_ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__xnor2_1
X_0577_ net55 net56 net57 net58 VSS VSS VDD VDD _0306_ sky130_fd_sc_hd__nand4_2
X_0578_ net52 net53 net54 VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__and3_1
X_0579_ net59 _0307_ VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__nand2_1
X_0580_ _0293_ _0507_ VSS VSS VDD VDD _0309_ sky130_fd_sc_hd__nand2_2
X_0581_ _0292_ _0306_ _0308_ _0309_ VSS VSS VDD VDD _0310_
+ sky130_fd_sc_hd__nor4_1
X_0582_ net45 _0310_ VSS VSS VDD VDD _0022_ sky130_fd_sc_hd__xor2_1
X_0583_ net59 net45 VSS VSS VDD VDD _0311_ sky130_fd_sc_hd__nand2_1
X_0584_ net44 net51 _0307_ VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__and3_1
X_0585_ _0293_ _0312_ VSS VSS VDD VDD _0313_ sky130_fd_sc_hd__nand2_2
X_0586_ _0291_ _0306_ _0311_ _0313_ VSS VSS VDD VDD _0314_
+ sky130_fd_sc_hd__nor4_1
X_0587_ net46 _0314_ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__xor2_1
X_0588_ _0306_ _0311_ VSS VSS VDD VDD _0315_ sky130_fd_sc_hd__nor2_1
X_0589_ net46 _0307_ _0315_ VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__nand3_1
X_0590_ _0292_ _0309_ _0316_ VSS VSS VDD VDD _0317_ sky130_fd_sc_hd__nor3_1
X_0591_ net47 _0317_ VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__xor2_1
X_0592_ net46 net47 _0315_ VSS VSS VDD VDD _0318_ sky130_fd_sc_hd__nand3_1
X_0593_ _0292_ _0313_ _0318_ VSS VSS VDD VDD _0319_ sky130_fd_sc_hd__nor3_1
X_0594_ net48 _0319_ VSS VSS VDD VDD _0025_ sky130_fd_sc_hd__xor2_1
X_0595_ net52 net53 net54 VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__nand3_1
X_0596_ net46 net47 net48 _0315_ VSS VSS VDD VDD _0321_ sky130_fd_sc_hd__nand4_1
X_0597_ _0291_ _0320_ _0309_ _0321_ VSS VSS VDD VDD _0322_
+ sky130_fd_sc_hd__nor4_1
X_0598_ net49 _0322_ VSS VSS VDD VDD _0026_ sky130_fd_sc_hd__xor2_1
X_0599_ _0293_ net49 _0312_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__nand3_1
X_0600_ _0292_ _0321_ _0323_ VSS VSS VDD VDD _0324_ sky130_fd_sc_hd__nor3_1
X_0601_ net50 _0324_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__xor2_1
X_0602_ net51 _0020_ net96 VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__mux2_1
X_0603_ _0291_ VSS VSS VDD VDD _0325_ sky130_fd_sc_hd__clkbuf_4
X_0604_ _0325_ _0309_ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__nor2_1
X_0605_ net52 _0326_ VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__xor2_1
X_0606_ _0293_ VSS VSS VDD VDD _0327_ sky130_fd_sc_hd__inv_1
X_0607_ net44 net52 net51 VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__nand3_1
X_0608_ _0327_ _0325_ _0328_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__nor3_1
X_0609_ net53 _0329_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__xor2_1
X_0610_ net52 net53 VSS VSS VDD VDD _0330_ sky130_fd_sc_hd__nand2_1
X_0611_ _0292_ _0330_ _0309_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__nor3_1
X_0612_ net54 _0331_ VSS VSS VDD VDD _0031_ sky130_fd_sc_hd__xor2_1
X_0613_ _0325_ _0313_ VSS VSS VDD VDD _0332_ sky130_fd_sc_hd__nor2_1
X_0614_ net55 _0332_ VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__xor2_1
X_0615_ net55 _0307_ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__nand2_1
X_0616_ _0292_ _0309_ _0333_ VSS VSS VDD VDD _0334_ sky130_fd_sc_hd__nor3_1
X_0617_ net56 _0334_ VSS VSS VDD VDD _0033_ sky130_fd_sc_hd__xor2_1
X_0618_ net55 net56 VSS VSS VDD VDD _0335_ sky130_fd_sc_hd__nand2_1
X_0619_ _0292_ _0335_ _0313_ VSS VSS VDD VDD _0336_ sky130_fd_sc_hd__nor3_1
X_0620_ net57 _0336_ VSS VSS VDD VDD _0034_ sky130_fd_sc_hd__xor2_1
X_0621_ net55 net56 net57 VSS VSS VDD VDD _0337_ sky130_fd_sc_hd__nand3_1
X_0622_ _0291_ _0320_ _0337_ _0309_ VSS VSS VDD VDD _0338_
+ sky130_fd_sc_hd__nor4_1
X_0623_ net58 _0338_ VSS VSS VDD VDD _0035_ sky130_fd_sc_hd__xor2_1
X_0624_ _0292_ _0306_ _0313_ VSS VSS VDD VDD _0339_ sky130_fd_sc_hd__nor3_1
X_0625_ net59 _0339_ VSS VSS VDD VDD _0036_ sky130_fd_sc_hd__xor2_1
X_0626_ rd_ptr\[0\] VSS VSS VDD VDD _0340_ sky130_fd_sc_hd__clkbuf_2
X_0627_ _0340_ VSS VSS VDD VDD _0341_ sky130_fd_sc_hd__buf_6
X_0628_ _0304_ VSS VSS VDD VDD _0342_ sky130_fd_sc_hd__buf_4
X_0629_ mem\[0\]\[0\] mem\[1\]\[0\] mem\[4\]\[0\] mem\[5\]\[0\]
+ _0341_ _0342_ VSS VSS VDD VDD _0343_ sky130_fd_sc_hd__mux4_1
X_0630_ _0301_ rd_ptr\[3\] VSS VSS VDD VDD _0344_ sky130_fd_sc_hd__or2_0
X_0631_ _0344_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__clkbuf_2
X_0632_ rd_ptr\[3\] _0301_ VSS VSS VDD VDD _0346_ sky130_fd_sc_hd__nand2b_2
X_0633_ _0346_ VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__buf_4
X_0634_ _0340_ VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__buf_6
X_0635_ _0348_ VSS VSS VDD VDD _0349_ sky130_fd_sc_hd__buf_6
X_0636_ mem\[2\]\[0\] mem\[3\]\[0\] mem\[6\]\[0\] mem\[7\]\[0\]
+ _0349_ _0305_ VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__mux4_1
X_0637_ _0343_ _0345_ _0347_ _0350_ VSS VSS VDD VDD _0351_
+ sky130_fd_sc_hd__o22ai_1
X_0638_ mem\[8\]\[0\] mem\[9\]\[0\] mem\[10\]\[0\] mem\[11\]\[0\]
+ _0341_ _0302_ VSS VSS VDD VDD _0352_ sky130_fd_sc_hd__mux4_1
X_0639_ _0342_ rd_ptr\[3\] VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__nand2b_2
X_0640_ _0342_ rd_ptr\[3\] VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__nand2_2
X_0641_ _0354_ VSS VSS VDD VDD _0355_ sky130_fd_sc_hd__buf_4
X_0642_ mem\[12\]\[0\] mem\[13\]\[0\] mem\[14\]\[0\] mem\[15\]\[0\]
+ _0349_ _0303_ VSS VSS VDD VDD _0356_ sky130_fd_sc_hd__mux4_1
X_0643_ _0352_ _0353_ _0355_ _0356_ VSS VSS VDD VDD _0357_
+ sky130_fd_sc_hd__o22ai_1
X_0644_ _0351_ _0357_ VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__nor2_1
X_0645_ _0293_ _0291_ VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__nand2_8
X_0646_ _0359_ VSS VSS VDD VDD _0360_ sky130_fd_sc_hd__buf_6
X_0647_ _0358_ last_valid_data\[0\] _0360_ VSS VSS VDD VDD
+ _0037_ sky130_fd_sc_hd__mux2_1
X_0648_ _0348_ VSS VSS VDD VDD _0361_ sky130_fd_sc_hd__buf_6
X_0649_ _0304_ VSS VSS VDD VDD _0362_ sky130_fd_sc_hd__clkbuf_8
X_0650_ mem\[2\]\[10\] mem\[3\]\[10\] mem\[6\]\[10\] mem\[7\]\[10\]
+ _0361_ _0362_ VSS VSS VDD VDD _0363_ sky130_fd_sc_hd__mux4_1
X_0651_ _0348_ VSS VSS VDD VDD _0364_ sky130_fd_sc_hd__buf_6
X_0652_ mem\[0\]\[10\] mem\[1\]\[10\] mem\[4\]\[10\] mem\[5\]\[10\]
+ _0364_ _0305_ VSS VSS VDD VDD _0365_ sky130_fd_sc_hd__mux4_1
X_0653_ _0345_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__buf_4
X_0654_ _0347_ _0363_ _0365_ _0366_ VSS VSS VDD VDD _0367_
+ sky130_fd_sc_hd__o22ai_1
X_0655_ _0348_ VSS VSS VDD VDD _0368_ sky130_fd_sc_hd__buf_6
X_0656_ _0301_ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__clkbuf_8
X_0657_ mem\[12\]\[10\] mem\[13\]\[10\] mem\[14\]\[10\] mem\[15\]\[10\]
+ _0368_ _0369_ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__mux4_1
X_0658_ mem\[8\]\[10\] mem\[9\]\[10\] mem\[10\]\[10\] mem\[11\]\[10\]
+ _0349_ _0303_ VSS VSS VDD VDD _0371_ sky130_fd_sc_hd__mux4_1
X_0659_ _0353_ VSS VSS VDD VDD _0372_ sky130_fd_sc_hd__buf_4
X_0660_ _0355_ _0370_ _0371_ _0372_ VSS VSS VDD VDD _0373_
+ sky130_fd_sc_hd__o22ai_1
X_0661_ _0367_ _0373_ VSS VSS VDD VDD _0374_ sky130_fd_sc_hd__nor2_1
X_0662_ _0374_ last_valid_data\[10\] _0360_ VSS VSS VDD VDD
+ _0038_ sky130_fd_sc_hd__mux2_1
X_0663_ mem\[2\]\[11\] mem\[3\]\[11\] mem\[6\]\[11\] mem\[7\]\[11\]
+ _0361_ _0362_ VSS VSS VDD VDD _0375_ sky130_fd_sc_hd__mux4_1
X_0664_ mem\[0\]\[11\] mem\[1\]\[11\] mem\[4\]\[11\] mem\[5\]\[11\]
+ _0364_ _0305_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__mux4_1
X_0665_ _0347_ _0375_ _0376_ _0366_ VSS VSS VDD VDD _0377_
+ sky130_fd_sc_hd__o22ai_1
X_0666_ mem\[12\]\[11\] mem\[13\]\[11\] mem\[14\]\[11\] mem\[15\]\[11\]
+ _0368_ _0369_ VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__mux4_1
X_0667_ mem\[8\]\[11\] mem\[9\]\[11\] mem\[10\]\[11\] mem\[11\]\[11\]
+ _0349_ _0303_ VSS VSS VDD VDD _0379_ sky130_fd_sc_hd__mux4_1
X_0668_ _0355_ _0378_ _0379_ _0372_ VSS VSS VDD VDD _0380_
+ sky130_fd_sc_hd__o22ai_1
X_0669_ _0377_ _0380_ VSS VSS VDD VDD _0381_ sky130_fd_sc_hd__nor2_1
X_0670_ _0381_ last_valid_data\[11\] _0360_ VSS VSS VDD VDD
+ _0039_ sky130_fd_sc_hd__mux2_1
X_0671_ mem\[2\]\[12\] mem\[3\]\[12\] mem\[6\]\[12\] mem\[7\]\[12\]
+ _0361_ _0362_ VSS VSS VDD VDD _0382_ sky130_fd_sc_hd__mux4_1
X_0672_ mem\[0\]\[12\] mem\[1\]\[12\] mem\[4\]\[12\] mem\[5\]\[12\]
+ _0364_ _0305_ VSS VSS VDD VDD _0383_ sky130_fd_sc_hd__mux4_1
X_0673_ _0347_ _0382_ _0383_ _0366_ VSS VSS VDD VDD _0384_
+ sky130_fd_sc_hd__o22ai_1
X_0674_ mem\[12\]\[12\] mem\[13\]\[12\] mem\[14\]\[12\] mem\[15\]\[12\]
+ _0368_ _0369_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__mux4_1
X_0675_ mem\[8\]\[12\] mem\[9\]\[12\] mem\[10\]\[12\] mem\[11\]\[12\]
+ _0349_ _0303_ VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__mux4_1
X_0676_ _0355_ _0385_ _0386_ _0372_ VSS VSS VDD VDD _0387_
+ sky130_fd_sc_hd__o22ai_1
X_0677_ _0384_ _0387_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__nor2_1
X_0678_ _0388_ last_valid_data\[12\] _0360_ VSS VSS VDD VDD
+ _0040_ sky130_fd_sc_hd__mux2_1
X_0679_ _0340_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__buf_6
X_0680_ mem\[2\]\[13\] mem\[3\]\[13\] mem\[6\]\[13\] mem\[7\]\[13\]
+ _0389_ _0362_ VSS VSS VDD VDD _0390_ sky130_fd_sc_hd__mux4_1
X_0681_ mem\[0\]\[13\] mem\[1\]\[13\] mem\[4\]\[13\] mem\[5\]\[13\]
+ _0364_ _0305_ VSS VSS VDD VDD _0391_ sky130_fd_sc_hd__mux4_1
X_0682_ _0347_ _0390_ _0391_ _0366_ VSS VSS VDD VDD _0392_
+ sky130_fd_sc_hd__o22ai_1
X_0683_ mem\[12\]\[13\] mem\[13\]\[13\] mem\[14\]\[13\] mem\[15\]\[13\]
+ _0368_ _0369_ VSS VSS VDD VDD _0393_ sky130_fd_sc_hd__mux4_1
X_0684_ mem\[8\]\[13\] mem\[9\]\[13\] mem\[10\]\[13\] mem\[11\]\[13\]
+ _0349_ _0303_ VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__mux4_1
X_0685_ _0355_ _0393_ _0394_ _0372_ VSS VSS VDD VDD _0395_
+ sky130_fd_sc_hd__o22ai_1
X_0686_ _0392_ _0395_ VSS VSS VDD VDD _0396_ sky130_fd_sc_hd__nor2_1
X_0687_ _0396_ last_valid_data\[13\] _0360_ VSS VSS VDD VDD
+ _0041_ sky130_fd_sc_hd__mux2_1
X_0688_ _0304_ VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__buf_4
X_0689_ mem\[2\]\[14\] mem\[3\]\[14\] mem\[6\]\[14\] mem\[7\]\[14\]
+ _0389_ _0397_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__mux4_1
X_0690_ _0348_ VSS VSS VDD VDD _0399_ sky130_fd_sc_hd__buf_6
X_0691_ mem\[0\]\[14\] mem\[1\]\[14\] mem\[4\]\[14\] mem\[5\]\[14\]
+ _0399_ _0305_ VSS VSS VDD VDD _0400_ sky130_fd_sc_hd__mux4_1
X_0692_ _0347_ _0398_ _0400_ _0366_ VSS VSS VDD VDD _0401_
+ sky130_fd_sc_hd__o22ai_1
X_0693_ mem\[12\]\[14\] mem\[13\]\[14\] mem\[14\]\[14\] mem\[15\]\[14\]
+ _0368_ _0369_ VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__mux4_1
X_0694_ mem\[8\]\[14\] mem\[9\]\[14\] mem\[10\]\[14\] mem\[11\]\[14\]
+ _0349_ _0303_ VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__mux4_1
X_0695_ _0355_ _0402_ _0403_ _0372_ VSS VSS VDD VDD _0404_
+ sky130_fd_sc_hd__o22ai_1
X_0696_ _0401_ _0404_ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__nor2_1
X_0697_ _0405_ last_valid_data\[14\] _0360_ VSS VSS VDD VDD
+ _0042_ sky130_fd_sc_hd__mux2_1
X_0698_ mem\[2\]\[15\] mem\[3\]\[15\] mem\[6\]\[15\] mem\[7\]\[15\]
+ _0389_ _0397_ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__mux4_1
X_0699_ _0304_ VSS VSS VDD VDD _0407_ sky130_fd_sc_hd__buf_4
X_0700_ mem\[0\]\[15\] mem\[1\]\[15\] mem\[4\]\[15\] mem\[5\]\[15\]
+ _0399_ _0407_ VSS VSS VDD VDD _0408_ sky130_fd_sc_hd__mux4_1
X_0701_ _0347_ _0406_ _0408_ _0366_ VSS VSS VDD VDD _0409_
+ sky130_fd_sc_hd__o22ai_1
X_0702_ _0348_ VSS VSS VDD VDD _0410_ sky130_fd_sc_hd__buf_6
X_0703_ _0301_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__buf_6
X_0704_ mem\[12\]\[15\] mem\[13\]\[15\] mem\[14\]\[15\] mem\[15\]\[15\]
+ _0410_ _0411_ VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__mux4_1
X_0705_ mem\[8\]\[15\] mem\[9\]\[15\] mem\[10\]\[15\] mem\[11\]\[15\]
+ _0349_ _0303_ VSS VSS VDD VDD _0413_ sky130_fd_sc_hd__mux4_1
X_0706_ _0355_ _0412_ _0413_ _0372_ VSS VSS VDD VDD _0414_
+ sky130_fd_sc_hd__o22ai_1
X_0707_ _0409_ _0414_ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__nor2_1
X_0708_ _0415_ last_valid_data\[15\] _0360_ VSS VSS VDD VDD
+ _0043_ sky130_fd_sc_hd__mux2_1
X_0709_ mem\[2\]\[16\] mem\[3\]\[16\] mem\[6\]\[16\] mem\[7\]\[16\]
+ _0389_ _0397_ VSS VSS VDD VDD _0416_ sky130_fd_sc_hd__mux4_1
X_0710_ mem\[0\]\[16\] mem\[1\]\[16\] mem\[4\]\[16\] mem\[5\]\[16\]
+ _0399_ _0407_ VSS VSS VDD VDD _0417_ sky130_fd_sc_hd__mux4_1
X_0711_ _0347_ _0416_ _0417_ _0366_ VSS VSS VDD VDD _0418_
+ sky130_fd_sc_hd__o22ai_1
X_0712_ mem\[12\]\[16\] mem\[13\]\[16\] mem\[14\]\[16\] mem\[15\]\[16\]
+ _0410_ _0411_ VSS VSS VDD VDD _0419_ sky130_fd_sc_hd__mux4_1
X_0713_ _0348_ VSS VSS VDD VDD _0420_ sky130_fd_sc_hd__clkbuf_8
X_0714_ _0302_ VSS VSS VDD VDD _0421_ sky130_fd_sc_hd__buf_4
X_0715_ mem\[8\]\[16\] mem\[9\]\[16\] mem\[10\]\[16\] mem\[11\]\[16\]
+ _0420_ _0421_ VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__mux4_1
X_0716_ _0355_ _0419_ _0422_ _0372_ VSS VSS VDD VDD _0423_
+ sky130_fd_sc_hd__o22ai_1
X_0717_ _0418_ _0423_ VSS VSS VDD VDD _0424_ sky130_fd_sc_hd__nor2_1
X_0718_ _0424_ last_valid_data\[16\] _0360_ VSS VSS VDD VDD
+ _0044_ sky130_fd_sc_hd__mux2_1
X_0719_ mem\[2\]\[17\] mem\[3\]\[17\] mem\[6\]\[17\] mem\[7\]\[17\]
+ _0389_ _0397_ VSS VSS VDD VDD _0425_ sky130_fd_sc_hd__mux4_1
X_0720_ mem\[0\]\[17\] mem\[1\]\[17\] mem\[4\]\[17\] mem\[5\]\[17\]
+ _0399_ _0407_ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__mux4_1
X_0721_ _0347_ _0425_ _0426_ _0366_ VSS VSS VDD VDD _0427_
+ sky130_fd_sc_hd__o22ai_1
X_0722_ mem\[12\]\[17\] mem\[13\]\[17\] mem\[14\]\[17\] mem\[15\]\[17\]
+ _0410_ _0411_ VSS VSS VDD VDD _0428_ sky130_fd_sc_hd__mux4_1
X_0723_ mem\[8\]\[17\] mem\[9\]\[17\] mem\[10\]\[17\] mem\[11\]\[17\]
+ _0420_ _0421_ VSS VSS VDD VDD _0429_ sky130_fd_sc_hd__mux4_1
X_0724_ _0355_ _0428_ _0429_ _0372_ VSS VSS VDD VDD _0430_
+ sky130_fd_sc_hd__o22ai_1
X_0725_ _0427_ _0430_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__nor2_1
X_0726_ _0359_ VSS VSS VDD VDD _0432_ sky130_fd_sc_hd__buf_6
X_0727_ _0431_ last_valid_data\[17\] _0432_ VSS VSS VDD VDD
+ _0045_ sky130_fd_sc_hd__mux2_1
X_0728_ mem\[2\]\[18\] mem\[3\]\[18\] mem\[6\]\[18\] mem\[7\]\[18\]
+ _0389_ _0397_ VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__mux4_1
X_0729_ mem\[0\]\[18\] mem\[1\]\[18\] mem\[4\]\[18\] mem\[5\]\[18\]
+ _0399_ _0407_ VSS VSS VDD VDD _0434_ sky130_fd_sc_hd__mux4_1
X_0730_ _0347_ _0433_ _0434_ _0366_ VSS VSS VDD VDD _0435_
+ sky130_fd_sc_hd__o22ai_1
X_0731_ mem\[12\]\[18\] mem\[13\]\[18\] mem\[14\]\[18\] mem\[15\]\[18\]
+ _0410_ _0411_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__mux4_1
X_0732_ mem\[8\]\[18\] mem\[9\]\[18\] mem\[10\]\[18\] mem\[11\]\[18\]
+ _0420_ _0421_ VSS VSS VDD VDD _0437_ sky130_fd_sc_hd__mux4_1
X_0733_ _0355_ _0436_ _0437_ _0372_ VSS VSS VDD VDD _0438_
+ sky130_fd_sc_hd__o22ai_1
X_0734_ _0435_ _0438_ VSS VSS VDD VDD _0439_ sky130_fd_sc_hd__nor2_1
X_0735_ _0439_ last_valid_data\[18\] _0432_ VSS VSS VDD VDD
+ _0046_ sky130_fd_sc_hd__mux2_1
X_0736_ _0346_ VSS VSS VDD VDD _0440_ sky130_fd_sc_hd__buf_6
X_0737_ mem\[2\]\[19\] mem\[3\]\[19\] mem\[6\]\[19\] mem\[7\]\[19\]
+ _0389_ _0397_ VSS VSS VDD VDD _0441_ sky130_fd_sc_hd__mux4_1
X_0738_ mem\[0\]\[19\] mem\[1\]\[19\] mem\[4\]\[19\] mem\[5\]\[19\]
+ _0399_ _0407_ VSS VSS VDD VDD _0442_ sky130_fd_sc_hd__mux4_1
X_0739_ _0440_ _0441_ _0442_ _0366_ VSS VSS VDD VDD _0443_
+ sky130_fd_sc_hd__o22ai_1
X_0740_ _0354_ VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__buf_6
X_0741_ mem\[12\]\[19\] mem\[13\]\[19\] mem\[14\]\[19\] mem\[15\]\[19\]
+ _0410_ _0411_ VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__mux4_1
X_0742_ mem\[8\]\[19\] mem\[9\]\[19\] mem\[10\]\[19\] mem\[11\]\[19\]
+ _0420_ _0421_ VSS VSS VDD VDD _0446_ sky130_fd_sc_hd__mux4_1
X_0743_ _0444_ _0445_ _0446_ _0372_ VSS VSS VDD VDD _0447_
+ sky130_fd_sc_hd__o22ai_1
X_0744_ _0443_ _0447_ VSS VSS VDD VDD _0448_ sky130_fd_sc_hd__nor2_1
X_0745_ _0448_ last_valid_data\[19\] _0432_ VSS VSS VDD VDD
+ _0047_ sky130_fd_sc_hd__mux2_1
X_0746_ mem\[2\]\[1\] mem\[3\]\[1\] mem\[6\]\[1\] mem\[7\]\[1\]
+ _0389_ _0397_ VSS VSS VDD VDD _0449_ sky130_fd_sc_hd__mux4_1
X_0747_ mem\[0\]\[1\] mem\[1\]\[1\] mem\[4\]\[1\] mem\[5\]\[1\]
+ _0399_ _0407_ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__mux4_1
X_0748_ _0345_ VSS VSS VDD VDD _0451_ sky130_fd_sc_hd__buf_4
X_0749_ _0440_ _0449_ _0450_ _0451_ VSS VSS VDD VDD _0452_
+ sky130_fd_sc_hd__o22ai_2
X_0750_ mem\[12\]\[1\] mem\[13\]\[1\] mem\[14\]\[1\] mem\[15\]\[1\]
+ _0410_ _0411_ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__mux4_1
X_0751_ mem\[8\]\[1\] mem\[9\]\[1\] mem\[10\]\[1\] mem\[11\]\[1\]
+ _0420_ _0421_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__mux4_1
X_0752_ _0353_ VSS VSS VDD VDD _0455_ sky130_fd_sc_hd__buf_6
X_0753_ _0444_ _0453_ _0454_ _0455_ VSS VSS VDD VDD _0456_
+ sky130_fd_sc_hd__o22ai_1
X_0754_ _0452_ _0456_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__nor2_1
X_0755_ _0457_ last_valid_data\[1\] _0432_ VSS VSS VDD VDD
+ _0048_ sky130_fd_sc_hd__mux2_1
X_0756_ mem\[2\]\[20\] mem\[3\]\[20\] mem\[6\]\[20\] mem\[7\]\[20\]
+ _0389_ _0397_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__mux4_1
X_0757_ mem\[0\]\[20\] mem\[1\]\[20\] mem\[4\]\[20\] mem\[5\]\[20\]
+ _0399_ _0407_ VSS VSS VDD VDD _0459_ sky130_fd_sc_hd__mux4_1
X_0758_ _0440_ _0458_ _0459_ _0451_ VSS VSS VDD VDD _0460_
+ sky130_fd_sc_hd__o22ai_2
X_0759_ mem\[12\]\[20\] mem\[13\]\[20\] mem\[14\]\[20\] mem\[15\]\[20\]
+ _0410_ _0411_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__mux4_1
X_0760_ mem\[8\]\[20\] mem\[9\]\[20\] mem\[10\]\[20\] mem\[11\]\[20\]
+ _0420_ _0421_ VSS VSS VDD VDD _0462_ sky130_fd_sc_hd__mux4_1
X_0761_ _0444_ _0461_ _0462_ _0455_ VSS VSS VDD VDD _0463_
+ sky130_fd_sc_hd__o22ai_1
X_0762_ _0460_ _0463_ VSS VSS VDD VDD _0464_ sky130_fd_sc_hd__nor2_1
X_0763_ _0464_ last_valid_data\[20\] _0432_ VSS VSS VDD VDD
+ _0049_ sky130_fd_sc_hd__mux2_1
X_0764_ mem\[2\]\[21\] mem\[3\]\[21\] mem\[6\]\[21\] mem\[7\]\[21\]
+ _0389_ _0397_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__mux4_1
X_0765_ mem\[0\]\[21\] mem\[1\]\[21\] mem\[4\]\[21\] mem\[5\]\[21\]
+ _0399_ _0407_ VSS VSS VDD VDD _0466_ sky130_fd_sc_hd__mux4_1
X_0766_ _0440_ _0465_ _0466_ _0451_ VSS VSS VDD VDD _0467_
+ sky130_fd_sc_hd__o22ai_1
X_0767_ mem\[12\]\[21\] mem\[13\]\[21\] mem\[14\]\[21\] mem\[15\]\[21\]
+ _0410_ _0411_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__mux4_1
X_0768_ mem\[8\]\[21\] mem\[9\]\[21\] mem\[10\]\[21\] mem\[11\]\[21\]
+ _0420_ _0421_ VSS VSS VDD VDD _0469_ sky130_fd_sc_hd__mux4_1
X_0769_ _0444_ _0468_ _0469_ _0455_ VSS VSS VDD VDD _0470_
+ sky130_fd_sc_hd__o22ai_1
X_0770_ _0467_ _0470_ VSS VSS VDD VDD _0471_ sky130_fd_sc_hd__nor2_1
X_0771_ _0471_ last_valid_data\[21\] _0432_ VSS VSS VDD VDD
+ _0050_ sky130_fd_sc_hd__mux2_1
X_0772_ _0340_ VSS VSS VDD VDD _0472_ sky130_fd_sc_hd__buf_6
X_0773_ mem\[2\]\[22\] mem\[3\]\[22\] mem\[6\]\[22\] mem\[7\]\[22\]
+ _0472_ _0397_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__mux4_1
X_0774_ mem\[0\]\[22\] mem\[1\]\[22\] mem\[4\]\[22\] mem\[5\]\[22\]
+ _0399_ _0407_ VSS VSS VDD VDD _0474_ sky130_fd_sc_hd__mux4_1
X_0775_ _0440_ _0473_ _0474_ _0451_ VSS VSS VDD VDD _0475_
+ sky130_fd_sc_hd__o22ai_1
X_0776_ mem\[12\]\[22\] mem\[13\]\[22\] mem\[14\]\[22\] mem\[15\]\[22\]
+ _0410_ _0411_ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__mux4_1
X_0777_ mem\[8\]\[22\] mem\[9\]\[22\] mem\[10\]\[22\] mem\[11\]\[22\]
+ _0420_ _0421_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__mux4_1
X_0778_ _0444_ _0476_ _0477_ _0455_ VSS VSS VDD VDD _0478_
+ sky130_fd_sc_hd__o22ai_1
X_0779_ _0475_ _0478_ VSS VSS VDD VDD _0479_ sky130_fd_sc_hd__nor2_1
X_0780_ _0479_ last_valid_data\[22\] _0432_ VSS VSS VDD VDD
+ _0051_ sky130_fd_sc_hd__mux2_1
X_0781_ _0304_ VSS VSS VDD VDD _0480_ sky130_fd_sc_hd__buf_4
X_0782_ mem\[2\]\[23\] mem\[3\]\[23\] mem\[6\]\[23\] mem\[7\]\[23\]
+ _0472_ _0480_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__mux4_1
X_0783_ _0348_ VSS VSS VDD VDD _0482_ sky130_fd_sc_hd__clkbuf_8
X_0784_ mem\[0\]\[23\] mem\[1\]\[23\] mem\[4\]\[23\] mem\[5\]\[23\]
+ _0482_ _0407_ VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__mux4_1
X_0785_ _0440_ _0481_ _0483_ _0451_ VSS VSS VDD VDD _0484_
+ sky130_fd_sc_hd__o22ai_1
X_0786_ mem\[12\]\[23\] mem\[13\]\[23\] mem\[14\]\[23\] mem\[15\]\[23\]
+ _0410_ _0411_ VSS VSS VDD VDD _0485_ sky130_fd_sc_hd__mux4_1
X_0787_ mem\[8\]\[23\] mem\[9\]\[23\] mem\[10\]\[23\] mem\[11\]\[23\]
+ _0420_ _0421_ VSS VSS VDD VDD _0486_ sky130_fd_sc_hd__mux4_1
X_0788_ _0444_ _0485_ _0486_ _0455_ VSS VSS VDD VDD _0487_
+ sky130_fd_sc_hd__o22ai_1
X_0789_ _0484_ _0487_ VSS VSS VDD VDD _0488_ sky130_fd_sc_hd__nor2_1
X_0790_ _0488_ last_valid_data\[23\] _0432_ VSS VSS VDD VDD
+ _0052_ sky130_fd_sc_hd__mux2_1
X_0791_ mem\[2\]\[24\] mem\[3\]\[24\] mem\[6\]\[24\] mem\[7\]\[24\]
+ _0472_ _0480_ VSS VSS VDD VDD _0489_ sky130_fd_sc_hd__mux4_1
X_0792_ _0304_ VSS VSS VDD VDD _0490_ sky130_fd_sc_hd__buf_6
X_0793_ mem\[0\]\[24\] mem\[1\]\[24\] mem\[4\]\[24\] mem\[5\]\[24\]
+ _0482_ _0490_ VSS VSS VDD VDD _0491_ sky130_fd_sc_hd__mux4_1
X_0794_ _0440_ _0489_ _0491_ _0451_ VSS VSS VDD VDD _0492_
+ sky130_fd_sc_hd__o22ai_1
X_0795_ _0348_ VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__buf_6
X_0796_ _0301_ VSS VSS VDD VDD _0494_ sky130_fd_sc_hd__buf_6
X_0797_ mem\[12\]\[24\] mem\[13\]\[24\] mem\[14\]\[24\] mem\[15\]\[24\]
+ _0493_ _0494_ VSS VSS VDD VDD _0080_ sky130_fd_sc_hd__mux4_1
X_0798_ mem\[8\]\[24\] mem\[9\]\[24\] mem\[10\]\[24\] mem\[11\]\[24\]
+ _0420_ _0421_ VSS VSS VDD VDD _0081_ sky130_fd_sc_hd__mux4_1
X_0799_ _0444_ _0080_ _0081_ _0455_ VSS VSS VDD VDD _0082_
+ sky130_fd_sc_hd__o22ai_1
X_0800_ _0492_ _0082_ VSS VSS VDD VDD _0083_ sky130_fd_sc_hd__nor2_1
X_0801_ _0083_ last_valid_data\[24\] _0432_ VSS VSS VDD VDD
+ _0053_ sky130_fd_sc_hd__mux2_1
X_0802_ mem\[2\]\[25\] mem\[3\]\[25\] mem\[6\]\[25\] mem\[7\]\[25\]
+ _0472_ _0480_ VSS VSS VDD VDD _0084_ sky130_fd_sc_hd__mux4_1
X_0803_ mem\[0\]\[25\] mem\[1\]\[25\] mem\[4\]\[25\] mem\[5\]\[25\]
+ _0482_ _0490_ VSS VSS VDD VDD _0085_ sky130_fd_sc_hd__mux4_1
X_0804_ _0440_ _0084_ _0085_ _0451_ VSS VSS VDD VDD _0086_
+ sky130_fd_sc_hd__o22ai_1
X_0805_ mem\[12\]\[25\] mem\[13\]\[25\] mem\[14\]\[25\] mem\[15\]\[25\]
+ _0493_ _0494_ VSS VSS VDD VDD _0087_ sky130_fd_sc_hd__mux4_1
X_0806_ _0348_ VSS VSS VDD VDD _0088_ sky130_fd_sc_hd__buf_4
X_0807_ _0302_ VSS VSS VDD VDD _0089_ sky130_fd_sc_hd__buf_4
X_0808_ mem\[8\]\[25\] mem\[9\]\[25\] mem\[10\]\[25\] mem\[11\]\[25\]
+ _0088_ _0089_ VSS VSS VDD VDD _0090_ sky130_fd_sc_hd__mux4_1
X_0809_ _0444_ _0087_ _0090_ _0455_ VSS VSS VDD VDD _0091_
+ sky130_fd_sc_hd__o22ai_1
X_0810_ _0086_ _0091_ VSS VSS VDD VDD _0092_ sky130_fd_sc_hd__nor2_1
X_0811_ _0092_ last_valid_data\[25\] _0432_ VSS VSS VDD VDD
+ _0054_ sky130_fd_sc_hd__mux2_1
X_0812_ mem\[2\]\[26\] mem\[3\]\[26\] mem\[6\]\[26\] mem\[7\]\[26\]
+ _0472_ _0480_ VSS VSS VDD VDD _0093_ sky130_fd_sc_hd__mux4_1
X_0813_ mem\[0\]\[26\] mem\[1\]\[26\] mem\[4\]\[26\] mem\[5\]\[26\]
+ _0482_ _0490_ VSS VSS VDD VDD _0094_ sky130_fd_sc_hd__mux4_1
X_0814_ _0440_ _0093_ _0094_ _0451_ VSS VSS VDD VDD _0095_
+ sky130_fd_sc_hd__o22ai_1
X_0815_ mem\[12\]\[26\] mem\[13\]\[26\] mem\[14\]\[26\] mem\[15\]\[26\]
+ _0493_ _0494_ VSS VSS VDD VDD _0096_ sky130_fd_sc_hd__mux4_1
X_0816_ mem\[8\]\[26\] mem\[9\]\[26\] mem\[10\]\[26\] mem\[11\]\[26\]
+ _0088_ _0089_ VSS VSS VDD VDD _0097_ sky130_fd_sc_hd__mux4_1
X_0817_ _0444_ _0096_ _0097_ _0455_ VSS VSS VDD VDD _0098_
+ sky130_fd_sc_hd__o22ai_2
X_0818_ _0095_ _0098_ VSS VSS VDD VDD _0099_ sky130_fd_sc_hd__nor2_1
X_0819_ _0359_ VSS VSS VDD VDD _0100_ sky130_fd_sc_hd__buf_6
X_0820_ _0099_ last_valid_data\[26\] _0100_ VSS VSS VDD VDD
+ _0055_ sky130_fd_sc_hd__mux2_1
X_0821_ mem\[2\]\[27\] mem\[3\]\[27\] mem\[6\]\[27\] mem\[7\]\[27\]
+ _0472_ _0480_ VSS VSS VDD VDD _0101_ sky130_fd_sc_hd__mux4_1
X_0822_ mem\[0\]\[27\] mem\[1\]\[27\] mem\[4\]\[27\] mem\[5\]\[27\]
+ _0482_ _0490_ VSS VSS VDD VDD _0102_ sky130_fd_sc_hd__mux4_1
X_0823_ _0440_ _0101_ _0102_ _0451_ VSS VSS VDD VDD _0103_
+ sky130_fd_sc_hd__o22ai_1
X_0824_ mem\[12\]\[27\] mem\[13\]\[27\] mem\[14\]\[27\] mem\[15\]\[27\]
+ _0493_ _0494_ VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__mux4_1
X_0825_ mem\[8\]\[27\] mem\[9\]\[27\] mem\[10\]\[27\] mem\[11\]\[27\]
+ _0088_ _0089_ VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__mux4_1
X_0826_ _0444_ _0104_ _0105_ _0455_ VSS VSS VDD VDD _0106_
+ sky130_fd_sc_hd__o22ai_1
X_0827_ _0103_ _0106_ VSS VSS VDD VDD _0107_ sky130_fd_sc_hd__nor2_1
X_0828_ _0107_ last_valid_data\[27\] _0100_ VSS VSS VDD VDD
+ _0056_ sky130_fd_sc_hd__mux2_1
X_0829_ _0346_ VSS VSS VDD VDD _0108_ sky130_fd_sc_hd__buf_4
X_0830_ mem\[2\]\[28\] mem\[3\]\[28\] mem\[6\]\[28\] mem\[7\]\[28\]
+ _0472_ _0480_ VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__mux4_1
X_0831_ mem\[0\]\[28\] mem\[1\]\[28\] mem\[4\]\[28\] mem\[5\]\[28\]
+ _0482_ _0490_ VSS VSS VDD VDD _0110_ sky130_fd_sc_hd__mux4_1
X_0832_ _0108_ _0109_ _0110_ _0451_ VSS VSS VDD VDD _0111_
+ sky130_fd_sc_hd__o22ai_1
X_0833_ _0354_ VSS VSS VDD VDD _0112_ sky130_fd_sc_hd__buf_4
X_0834_ mem\[12\]\[28\] mem\[13\]\[28\] mem\[14\]\[28\] mem\[15\]\[28\]
+ _0493_ _0494_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__mux4_1
X_0835_ mem\[8\]\[28\] mem\[9\]\[28\] mem\[10\]\[28\] mem\[11\]\[28\]
+ _0088_ _0089_ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__mux4_1
X_0836_ _0112_ _0113_ _0114_ _0455_ VSS VSS VDD VDD _0115_
+ sky130_fd_sc_hd__o22ai_1
X_0837_ _0111_ _0115_ VSS VSS VDD VDD _0116_ sky130_fd_sc_hd__nor2_1
X_0838_ _0116_ last_valid_data\[28\] _0100_ VSS VSS VDD VDD
+ _0057_ sky130_fd_sc_hd__mux2_1
X_0839_ mem\[2\]\[29\] mem\[3\]\[29\] mem\[6\]\[29\] mem\[7\]\[29\]
+ _0472_ _0480_ VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__mux4_1
X_0840_ mem\[0\]\[29\] mem\[1\]\[29\] mem\[4\]\[29\] mem\[5\]\[29\]
+ _0482_ _0490_ VSS VSS VDD VDD _0118_ sky130_fd_sc_hd__mux4_1
X_0841_ _0345_ VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__clkbuf_8
X_0842_ _0108_ _0117_ _0118_ _0119_ VSS VSS VDD VDD _0120_
+ sky130_fd_sc_hd__o22ai_1
X_0843_ mem\[12\]\[29\] mem\[13\]\[29\] mem\[14\]\[29\] mem\[15\]\[29\]
+ _0493_ _0494_ VSS VSS VDD VDD _0121_ sky130_fd_sc_hd__mux4_1
X_0844_ mem\[8\]\[29\] mem\[9\]\[29\] mem\[10\]\[29\] mem\[11\]\[29\]
+ _0088_ _0089_ VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__mux4_1
X_0845_ _0353_ VSS VSS VDD VDD _0123_ sky130_fd_sc_hd__buf_4
X_0846_ _0112_ _0121_ _0122_ _0123_ VSS VSS VDD VDD _0124_
+ sky130_fd_sc_hd__o22ai_1
X_0847_ _0120_ _0124_ VSS VSS VDD VDD _0125_ sky130_fd_sc_hd__nor2_1
X_0848_ _0125_ last_valid_data\[29\] _0100_ VSS VSS VDD VDD
+ _0058_ sky130_fd_sc_hd__mux2_1
X_0849_ mem\[2\]\[2\] mem\[3\]\[2\] mem\[6\]\[2\] mem\[7\]\[2\]
+ _0472_ _0480_ VSS VSS VDD VDD _0126_ sky130_fd_sc_hd__mux4_1
X_0850_ mem\[0\]\[2\] mem\[1\]\[2\] mem\[4\]\[2\] mem\[5\]\[2\]
+ _0482_ _0490_ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__mux4_1
X_0851_ _0108_ _0126_ _0127_ _0119_ VSS VSS VDD VDD _0128_
+ sky130_fd_sc_hd__o22ai_1
X_0852_ mem\[12\]\[2\] mem\[13\]\[2\] mem\[14\]\[2\] mem\[15\]\[2\]
+ _0493_ _0494_ VSS VSS VDD VDD _0129_ sky130_fd_sc_hd__mux4_1
X_0853_ mem\[8\]\[2\] mem\[9\]\[2\] mem\[10\]\[2\] mem\[11\]\[2\]
+ _0088_ _0089_ VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__mux4_1
X_0854_ _0112_ _0129_ _0130_ _0123_ VSS VSS VDD VDD _0131_
+ sky130_fd_sc_hd__o22ai_1
X_0855_ _0128_ _0131_ VSS VSS VDD VDD _0132_ sky130_fd_sc_hd__nor2_1
X_0856_ _0132_ last_valid_data\[2\] _0100_ VSS VSS VDD VDD
+ _0059_ sky130_fd_sc_hd__mux2_1
X_0857_ mem\[2\]\[30\] mem\[3\]\[30\] mem\[6\]\[30\] mem\[7\]\[30\]
+ _0472_ _0480_ VSS VSS VDD VDD _0133_ sky130_fd_sc_hd__mux4_1
X_0858_ mem\[0\]\[30\] mem\[1\]\[30\] mem\[4\]\[30\] mem\[5\]\[30\]
+ _0482_ _0490_ VSS VSS VDD VDD _0134_ sky130_fd_sc_hd__mux4_1
X_0859_ _0108_ _0133_ _0134_ _0119_ VSS VSS VDD VDD _0135_
+ sky130_fd_sc_hd__o22ai_1
X_0860_ mem\[12\]\[30\] mem\[13\]\[30\] mem\[14\]\[30\] mem\[15\]\[30\]
+ _0493_ _0494_ VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__mux4_1
X_0861_ mem\[8\]\[30\] mem\[9\]\[30\] mem\[10\]\[30\] mem\[11\]\[30\]
+ _0088_ _0089_ VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__mux4_1
X_0862_ _0112_ _0136_ _0137_ _0123_ VSS VSS VDD VDD _0138_
+ sky130_fd_sc_hd__o22ai_1
X_0863_ _0135_ _0138_ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__nor2_1
X_0864_ _0139_ last_valid_data\[30\] _0100_ VSS VSS VDD VDD
+ _0060_ sky130_fd_sc_hd__mux2_1
X_0865_ mem\[2\]\[31\] mem\[3\]\[31\] mem\[6\]\[31\] mem\[7\]\[31\]
+ _0341_ _0480_ VSS VSS VDD VDD _0140_ sky130_fd_sc_hd__mux4_1
X_0866_ mem\[0\]\[31\] mem\[1\]\[31\] mem\[4\]\[31\] mem\[5\]\[31\]
+ _0482_ _0490_ VSS VSS VDD VDD _0141_ sky130_fd_sc_hd__mux4_1
X_0867_ _0108_ _0140_ _0141_ _0119_ VSS VSS VDD VDD _0142_
+ sky130_fd_sc_hd__o22ai_1
X_0868_ mem\[12\]\[31\] mem\[13\]\[31\] mem\[14\]\[31\] mem\[15\]\[31\]
+ _0493_ _0494_ VSS VSS VDD VDD _0143_ sky130_fd_sc_hd__mux4_1
X_0869_ mem\[8\]\[31\] mem\[9\]\[31\] mem\[10\]\[31\] mem\[11\]\[31\]
+ _0088_ _0089_ VSS VSS VDD VDD _0144_ sky130_fd_sc_hd__mux4_1
X_0870_ _0112_ _0143_ _0144_ _0123_ VSS VSS VDD VDD _0145_
+ sky130_fd_sc_hd__o22ai_1
X_0871_ _0142_ _0145_ VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__nor2_1
X_0872_ _0146_ last_valid_data\[31\] _0100_ VSS VSS VDD VDD
+ _0061_ sky130_fd_sc_hd__mux2_1
X_0873_ mem\[2\]\[3\] mem\[3\]\[3\] mem\[6\]\[3\] mem\[7\]\[3\]
+ _0341_ _0342_ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__mux4_1
X_0874_ mem\[0\]\[3\] mem\[1\]\[3\] mem\[4\]\[3\] mem\[5\]\[3\]
+ _0361_ _0490_ VSS VSS VDD VDD _0148_ sky130_fd_sc_hd__mux4_1
X_0875_ _0108_ _0147_ _0148_ _0119_ VSS VSS VDD VDD _0149_
+ sky130_fd_sc_hd__o22ai_1
X_0876_ mem\[12\]\[3\] mem\[13\]\[3\] mem\[14\]\[3\] mem\[15\]\[3\]
+ _0493_ _0494_ VSS VSS VDD VDD _0150_ sky130_fd_sc_hd__mux4_1
X_0877_ mem\[8\]\[3\] mem\[9\]\[3\] mem\[10\]\[3\] mem\[11\]\[3\]
+ _0088_ _0089_ VSS VSS VDD VDD _0151_ sky130_fd_sc_hd__mux4_1
X_0878_ _0112_ _0150_ _0151_ _0123_ VSS VSS VDD VDD _0152_
+ sky130_fd_sc_hd__o22ai_1
X_0879_ _0149_ _0152_ VSS VSS VDD VDD _0153_ sky130_fd_sc_hd__nor2_1
X_0880_ _0153_ last_valid_data\[3\] _0100_ VSS VSS VDD VDD
+ _0062_ sky130_fd_sc_hd__mux2_1
X_0881_ mem\[2\]\[4\] mem\[3\]\[4\] mem\[6\]\[4\] mem\[7\]\[4\]
+ _0341_ _0342_ VSS VSS VDD VDD _0154_ sky130_fd_sc_hd__mux4_1
X_0882_ mem\[0\]\[4\] mem\[1\]\[4\] mem\[4\]\[4\] mem\[5\]\[4\]
+ _0361_ _0362_ VSS VSS VDD VDD _0155_ sky130_fd_sc_hd__mux4_1
X_0883_ _0108_ _0154_ _0155_ _0119_ VSS VSS VDD VDD _0156_
+ sky130_fd_sc_hd__o22ai_1
X_0884_ mem\[12\]\[4\] mem\[13\]\[4\] mem\[14\]\[4\] mem\[15\]\[4\]
+ _0364_ _0302_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__mux4_1
X_0885_ mem\[8\]\[4\] mem\[9\]\[4\] mem\[10\]\[4\] mem\[11\]\[4\]
+ _0088_ _0089_ VSS VSS VDD VDD _0158_ sky130_fd_sc_hd__mux4_1
X_0886_ _0112_ _0157_ _0158_ _0123_ VSS VSS VDD VDD _0159_
+ sky130_fd_sc_hd__o22ai_1
X_0887_ _0156_ _0159_ VSS VSS VDD VDD _0160_ sky130_fd_sc_hd__nor2_1
X_0888_ _0160_ last_valid_data\[4\] _0100_ VSS VSS VDD VDD
+ _0063_ sky130_fd_sc_hd__mux2_1
X_0889_ mem\[2\]\[5\] mem\[3\]\[5\] mem\[6\]\[5\] mem\[7\]\[5\]
+ _0341_ _0342_ VSS VSS VDD VDD _0161_ sky130_fd_sc_hd__mux4_1
X_0890_ mem\[0\]\[5\] mem\[1\]\[5\] mem\[4\]\[5\] mem\[5\]\[5\]
+ _0361_ _0362_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__mux4_1
X_0891_ _0108_ _0161_ _0162_ _0119_ VSS VSS VDD VDD _0163_
+ sky130_fd_sc_hd__o22ai_1
X_0892_ mem\[12\]\[5\] mem\[13\]\[5\] mem\[14\]\[5\] mem\[15\]\[5\]
+ _0364_ _0302_ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__mux4_1
X_0893_ mem\[8\]\[5\] mem\[9\]\[5\] mem\[10\]\[5\] mem\[11\]\[5\]
+ _0368_ _0369_ VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__mux4_1
X_0894_ _0112_ _0164_ _0165_ _0123_ VSS VSS VDD VDD _0166_
+ sky130_fd_sc_hd__o22ai_1
X_0895_ _0163_ _0166_ VSS VSS VDD VDD _0167_ sky130_fd_sc_hd__nor2_1
X_0896_ _0167_ last_valid_data\[5\] _0100_ VSS VSS VDD VDD
+ _0064_ sky130_fd_sc_hd__mux2_1
X_0897_ mem\[2\]\[6\] mem\[3\]\[6\] mem\[6\]\[6\] mem\[7\]\[6\]
+ _0341_ _0342_ VSS VSS VDD VDD _0168_ sky130_fd_sc_hd__mux4_1
X_0898_ mem\[0\]\[6\] mem\[1\]\[6\] mem\[4\]\[6\] mem\[5\]\[6\]
+ _0361_ _0362_ VSS VSS VDD VDD _0169_ sky130_fd_sc_hd__mux4_1
X_0899_ _0108_ _0168_ _0169_ _0119_ VSS VSS VDD VDD _0170_
+ sky130_fd_sc_hd__o22ai_1
X_0900_ mem\[12\]\[6\] mem\[13\]\[6\] mem\[14\]\[6\] mem\[15\]\[6\]
+ _0364_ _0302_ VSS VSS VDD VDD _0171_ sky130_fd_sc_hd__mux4_1
X_0901_ mem\[8\]\[6\] mem\[9\]\[6\] mem\[10\]\[6\] mem\[11\]\[6\]
+ _0368_ _0369_ VSS VSS VDD VDD _0172_ sky130_fd_sc_hd__mux4_1
X_0902_ _0112_ _0171_ _0172_ _0123_ VSS VSS VDD VDD _0173_
+ sky130_fd_sc_hd__o22ai_1
X_0903_ _0170_ _0173_ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__nor2_1
X_0904_ _0174_ last_valid_data\[6\] _0359_ VSS VSS VDD VDD
+ _0065_ sky130_fd_sc_hd__mux2_1
X_0905_ mem\[2\]\[7\] mem\[3\]\[7\] mem\[6\]\[7\] mem\[7\]\[7\]
+ _0341_ _0342_ VSS VSS VDD VDD _0175_ sky130_fd_sc_hd__mux4_1
X_0906_ mem\[0\]\[7\] mem\[1\]\[7\] mem\[4\]\[7\] mem\[5\]\[7\]
+ _0361_ _0362_ VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__mux4_1
X_0907_ _0108_ _0175_ _0176_ _0119_ VSS VSS VDD VDD _0177_
+ sky130_fd_sc_hd__o22ai_1
X_0908_ mem\[12\]\[7\] mem\[13\]\[7\] mem\[14\]\[7\] mem\[15\]\[7\]
+ _0364_ _0302_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__mux4_1
X_0909_ mem\[8\]\[7\] mem\[9\]\[7\] mem\[10\]\[7\] mem\[11\]\[7\]
+ _0368_ _0369_ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__mux4_1
X_0910_ _0112_ _0178_ _0179_ _0123_ VSS VSS VDD VDD _0180_
+ sky130_fd_sc_hd__o22ai_1
X_0911_ _0177_ _0180_ VSS VSS VDD VDD _0181_ sky130_fd_sc_hd__nor2_1
X_0912_ _0181_ last_valid_data\[7\] _0359_ VSS VSS VDD VDD
+ _0066_ sky130_fd_sc_hd__mux2_1
X_0913_ mem\[2\]\[8\] mem\[3\]\[8\] mem\[6\]\[8\] mem\[7\]\[8\]
+ _0341_ _0342_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__mux4_1
X_0914_ mem\[0\]\[8\] mem\[1\]\[8\] mem\[4\]\[8\] mem\[5\]\[8\]
+ _0361_ _0362_ VSS VSS VDD VDD _0183_ sky130_fd_sc_hd__mux4_1
X_0915_ _0346_ _0182_ _0183_ _0119_ VSS VSS VDD VDD _0184_
+ sky130_fd_sc_hd__o22ai_1
X_0916_ mem\[12\]\[8\] mem\[13\]\[8\] mem\[14\]\[8\] mem\[15\]\[8\]
+ _0364_ _0302_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__mux4_1
X_0917_ mem\[8\]\[8\] mem\[9\]\[8\] mem\[10\]\[8\] mem\[11\]\[8\]
+ _0368_ _0369_ VSS VSS VDD VDD _0186_ sky130_fd_sc_hd__mux4_1
X_0918_ _0354_ _0185_ _0186_ _0123_ VSS VSS VDD VDD _0187_
+ sky130_fd_sc_hd__o22ai_1
X_0919_ _0184_ _0187_ VSS VSS VDD VDD _0188_ sky130_fd_sc_hd__nor2_1
X_0920_ _0188_ last_valid_data\[8\] _0359_ VSS VSS VDD VDD
+ _0067_ sky130_fd_sc_hd__mux2_1
X_0921_ mem\[2\]\[9\] mem\[3\]\[9\] mem\[6\]\[9\] mem\[7\]\[9\]
+ _0341_ _0342_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__mux4_1
X_0922_ mem\[0\]\[9\] mem\[1\]\[9\] mem\[4\]\[9\] mem\[5\]\[9\]
+ _0361_ _0362_ VSS VSS VDD VDD _0190_ sky130_fd_sc_hd__mux4_1
X_0923_ _0346_ _0189_ _0190_ _0345_ VSS VSS VDD VDD _0191_
+ sky130_fd_sc_hd__o22ai_1
X_0924_ mem\[12\]\[9\] mem\[13\]\[9\] mem\[14\]\[9\] mem\[15\]\[9\]
+ _0364_ _0302_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__mux4_1
X_0925_ mem\[8\]\[9\] mem\[9\]\[9\] mem\[10\]\[9\] mem\[11\]\[9\]
+ _0368_ _0369_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__mux4_1
X_0926_ _0354_ _0192_ _0193_ _0353_ VSS VSS VDD VDD _0194_
+ sky130_fd_sc_hd__o22ai_1
X_0927_ _0191_ _0194_ VSS VSS VDD VDD _0195_ sky130_fd_sc_hd__nor2_1
X_0928_ _0195_ last_valid_data\[9\] _0359_ VSS VSS VDD VDD
+ _0068_ sky130_fd_sc_hd__mux2_1
X_0929_ last_valid_data_available VSS VSS VDD VDD _0196_ sky130_fd_sc_hd__buf_2
X_0930_ _0196_ _0360_ VSS VSS VDD VDD _0069_ sky130_fd_sc_hd__nand2b_1
X_0931_ _0349_ _0360_ VSS VSS VDD VDD _0070_ sky130_fd_sc_hd__xnor2_1
X_0932_ _0019_ _0303_ _0359_ VSS VSS VDD VDD _0071_ sky130_fd_sc_hd__mux2_1
X_0933_ _0293_ _0506_ _0325_ VSS VSS VDD VDD _0197_ sky130_fd_sc_hd__nand3_1
X_0934_ _0305_ _0197_ VSS VSS VDD VDD _0072_ sky130_fd_sc_hd__xnor2_1
X_0935_ _0349_ _0303_ _0305_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__nand3_1
X_0936_ _0327_ net43 _0198_ VSS VSS VDD VDD _0199_ sky130_fd_sc_hd__nor3_1
X_0937_ _0498_ _0199_ VSS VSS VDD VDD _0073_ sky130_fd_sc_hd__xnor2_1
X_0938_ _0305_ rd_ptr\[3\] _0506_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__nand3_1
X_0939_ _0327_ net43 _0200_ VSS VSS VDD VDD _0201_ sky130_fd_sc_hd__nor3_1
X_0940_ rd_ptr\[4\] _0201_ VSS VSS VDD VDD _0074_ sky130_fd_sc_hd__xor2_1
X_0941_ net61 net35 VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__nand2b_1
X_0942_ wr_ptr\[0\] _0202_ VSS VSS VDD VDD _0075_ sky130_fd_sc_hd__xnor2_1
X_0943_ _0018_ wr_ptr\[1\] _0202_ VSS VSS VDD VDD _0076_ sky130_fd_sc_hd__mux2_1
X_0944_ net61 _0514_ net35 VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__nand3b_1
X_0945_ wr_ptr\[2\] _0203_ VSS VSS VDD VDD _0077_ sky130_fd_sc_hd__xnor2_1
X_0946_ _0508_ _0017_ net61 _0298_ VSS VSS VDD VDD _0204_
+ sky130_fd_sc_hd__nor4_1
X_0947_ wr_ptr\[3\] _0204_ VSS VSS VDD VDD _0078_ sky130_fd_sc_hd__xor2_1
X_0948_ net61 _0007_ VSS VSS VDD VDD _0205_ sky130_fd_sc_hd__nand2b_1
X_0949_ wr_ptr\[4\] _0205_ VSS VSS VDD VDD _0079_ sky130_fd_sc_hd__xnor2_1
X_0950_ _0517_ net39 VSS VSS VDD VDD _0206_ sky130_fd_sc_hd__xor2_1
X_0951_ net40 net41 net42 _0206_ VSS VSS VDD VDD net36 sky130_fd_sc_hd__nor4_1
X_0952_ net39 net40 net41 net42 VSS VSS VDD VDD net37 sky130_fd_sc_hd__a31o_1
X_0953_ net35 net61 VSS VSS VDD VDD net62 sky130_fd_sc_hd__and2_0
X_0954_ _0291_ VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__buf_4
X_0955_ _0196_ VSS VSS VDD VDD _0208_ sky130_fd_sc_hd__clkbuf_8
X_0956_ _0208_ last_valid_data\[0\] VSS VSS VDD VDD _0209_
+ sky130_fd_sc_hd__nand2_1
X_0957_ net95 _0358_ VSS VSS VDD VDD _0210_ sky130_fd_sc_hd__nand2_1
X_0958_ _0207_ _0209_ _0210_ VSS VSS VDD VDD net63 sky130_fd_sc_hd__o21ai_0
X_0959_ _0208_ last_valid_data\[10\] VSS VSS VDD VDD _0211_
+ sky130_fd_sc_hd__nand2_1
X_0960_ net95 _0374_ VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__nand2_1
X_0961_ _0207_ _0211_ _0212_ VSS VSS VDD VDD net64 sky130_fd_sc_hd__o21ai_0
X_0962_ _0208_ last_valid_data\[11\] VSS VSS VDD VDD _0213_
+ sky130_fd_sc_hd__nand2_1
X_0963_ net95 _0381_ VSS VSS VDD VDD _0214_ sky130_fd_sc_hd__nand2_1
X_0964_ _0207_ _0213_ _0214_ VSS VSS VDD VDD net65 sky130_fd_sc_hd__o21ai_0
X_0965_ _0208_ last_valid_data\[12\] VSS VSS VDD VDD _0215_
+ sky130_fd_sc_hd__nand2_1
X_0966_ net95 _0388_ VSS VSS VDD VDD _0216_ sky130_fd_sc_hd__nand2_1
X_0967_ _0207_ _0215_ _0216_ VSS VSS VDD VDD net66 sky130_fd_sc_hd__o21ai_0
X_0968_ _0208_ last_valid_data\[13\] VSS VSS VDD VDD _0217_
+ sky130_fd_sc_hd__nand2_1
X_0969_ net95 _0396_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__nand2_1
X_0970_ _0207_ _0217_ _0218_ VSS VSS VDD VDD net67 sky130_fd_sc_hd__o21ai_0
X_0971_ _0208_ last_valid_data\[14\] VSS VSS VDD VDD _0219_
+ sky130_fd_sc_hd__nand2_1
X_0972_ net95 _0405_ VSS VSS VDD VDD _0220_ sky130_fd_sc_hd__nand2_1
X_0973_ _0207_ _0219_ _0220_ VSS VSS VDD VDD net68 sky130_fd_sc_hd__o21ai_0
X_0974_ _0208_ last_valid_data\[15\] VSS VSS VDD VDD _0221_
+ sky130_fd_sc_hd__nand2_1
X_0975_ net95 _0415_ VSS VSS VDD VDD _0222_ sky130_fd_sc_hd__nand2_1
X_0976_ _0207_ _0221_ _0222_ VSS VSS VDD VDD net69 sky130_fd_sc_hd__o21ai_0
X_0977_ _0291_ VSS VSS VDD VDD _0223_ sky130_fd_sc_hd__buf_6
X_0978_ _0208_ last_valid_data\[16\] VSS VSS VDD VDD _0224_
+ sky130_fd_sc_hd__nand2_1
X_0979_ net95 _0424_ VSS VSS VDD VDD _0225_ sky130_fd_sc_hd__nand2_1
X_0980_ _0223_ _0224_ _0225_ VSS VSS VDD VDD net70 sky130_fd_sc_hd__o21ai_1
X_0981_ _0208_ last_valid_data\[17\] VSS VSS VDD VDD _0226_
+ sky130_fd_sc_hd__nand2_1
X_0982_ net95 _0431_ VSS VSS VDD VDD _0227_ sky130_fd_sc_hd__nand2_1
X_0983_ _0223_ _0226_ _0227_ VSS VSS VDD VDD net71 sky130_fd_sc_hd__o21ai_1
X_0984_ _0208_ last_valid_data\[18\] VSS VSS VDD VDD _0228_
+ sky130_fd_sc_hd__nand2_1
X_0985_ _0325_ VSS VSS VDD VDD _0229_ sky130_fd_sc_hd__buf_6
X_0986_ _0229_ _0439_ VSS VSS VDD VDD _0230_ sky130_fd_sc_hd__nand2_1
X_0987_ _0223_ _0228_ _0230_ VSS VSS VDD VDD net72 sky130_fd_sc_hd__o21ai_0
X_0988_ _0196_ VSS VSS VDD VDD _0231_ sky130_fd_sc_hd__buf_6
X_0989_ _0231_ last_valid_data\[19\] VSS VSS VDD VDD _0232_
+ sky130_fd_sc_hd__nand2_1
X_0990_ _0229_ _0448_ VSS VSS VDD VDD _0233_ sky130_fd_sc_hd__nand2_1
X_0991_ _0223_ _0232_ _0233_ VSS VSS VDD VDD net73 sky130_fd_sc_hd__o21ai_0
X_0992_ _0231_ last_valid_data\[1\] VSS VSS VDD VDD _0234_
+ sky130_fd_sc_hd__nand2_1
X_0993_ _0229_ _0457_ VSS VSS VDD VDD _0235_ sky130_fd_sc_hd__nand2_1
X_0994_ _0223_ _0234_ _0235_ VSS VSS VDD VDD net74 sky130_fd_sc_hd__o21ai_0
X_0995_ _0231_ last_valid_data\[20\] VSS VSS VDD VDD _0236_
+ sky130_fd_sc_hd__nand2_1
X_0996_ _0229_ _0464_ VSS VSS VDD VDD _0237_ sky130_fd_sc_hd__nand2_1
X_0997_ _0223_ _0236_ _0237_ VSS VSS VDD VDD net75 sky130_fd_sc_hd__o21ai_0
X_0998_ _0231_ last_valid_data\[21\] VSS VSS VDD VDD _0238_
+ sky130_fd_sc_hd__nand2_1
X_0999_ _0229_ _0471_ VSS VSS VDD VDD _0239_ sky130_fd_sc_hd__nand2_1
X_1000_ _0223_ _0238_ _0239_ VSS VSS VDD VDD net76 sky130_fd_sc_hd__o21ai_0
X_1001_ _0231_ last_valid_data\[22\] VSS VSS VDD VDD _0240_
+ sky130_fd_sc_hd__nand2_1
X_1002_ _0229_ _0479_ VSS VSS VDD VDD _0241_ sky130_fd_sc_hd__nand2_1
X_1003_ _0223_ _0240_ _0241_ VSS VSS VDD VDD net77 sky130_fd_sc_hd__o21ai_0
X_1004_ _0231_ last_valid_data\[23\] VSS VSS VDD VDD _0242_
+ sky130_fd_sc_hd__nand2_1
X_1005_ _0229_ _0488_ VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__nand2_1
X_1006_ _0223_ _0242_ _0243_ VSS VSS VDD VDD net78 sky130_fd_sc_hd__o21ai_0
X_1007_ _0231_ last_valid_data\[24\] VSS VSS VDD VDD _0244_
+ sky130_fd_sc_hd__nand2_1
X_1008_ _0229_ _0083_ VSS VSS VDD VDD _0245_ sky130_fd_sc_hd__nand2_1
X_1009_ _0223_ _0244_ _0245_ VSS VSS VDD VDD net79 sky130_fd_sc_hd__o21ai_1
X_1010_ _0291_ VSS VSS VDD VDD _0246_ sky130_fd_sc_hd__buf_4
X_1011_ _0231_ last_valid_data\[25\] VSS VSS VDD VDD _0247_
+ sky130_fd_sc_hd__nand2_1
X_1012_ _0229_ _0092_ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__nand2_1
X_1013_ _0246_ _0247_ _0248_ VSS VSS VDD VDD net80 sky130_fd_sc_hd__o21ai_0
X_1014_ _0231_ last_valid_data\[26\] VSS VSS VDD VDD _0249_
+ sky130_fd_sc_hd__nand2_1
X_1015_ _0229_ _0099_ VSS VSS VDD VDD _0250_ sky130_fd_sc_hd__nand2_1
X_1016_ _0246_ _0249_ _0250_ VSS VSS VDD VDD net81 sky130_fd_sc_hd__o21ai_1
X_1017_ _0231_ last_valid_data\[27\] VSS VSS VDD VDD _0251_
+ sky130_fd_sc_hd__nand2_1
X_1018_ _0292_ VSS VSS VDD VDD _0252_ sky130_fd_sc_hd__buf_4
X_1019_ _0252_ _0107_ VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__nand2_1
X_1020_ _0246_ _0251_ _0253_ VSS VSS VDD VDD net82 sky130_fd_sc_hd__o21ai_0
X_1021_ _0196_ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__buf_4
X_1022_ _0254_ last_valid_data\[28\] VSS VSS VDD VDD _0255_
+ sky130_fd_sc_hd__nand2_1
X_1023_ _0252_ _0116_ VSS VSS VDD VDD _0256_ sky130_fd_sc_hd__nand2_1
X_1024_ _0246_ _0255_ _0256_ VSS VSS VDD VDD net83 sky130_fd_sc_hd__o21ai_0
X_1025_ _0254_ last_valid_data\[29\] VSS VSS VDD VDD _0257_
+ sky130_fd_sc_hd__nand2_1
X_1026_ _0252_ _0125_ VSS VSS VDD VDD _0258_ sky130_fd_sc_hd__nand2_1
X_1027_ _0246_ _0257_ _0258_ VSS VSS VDD VDD net84 sky130_fd_sc_hd__o21ai_0
X_1028_ _0254_ last_valid_data\[2\] VSS VSS VDD VDD _0259_
+ sky130_fd_sc_hd__nand2_1
X_1029_ _0252_ _0132_ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__nand2_1
X_1030_ _0246_ _0259_ _0260_ VSS VSS VDD VDD net85 sky130_fd_sc_hd__o21ai_0
X_1031_ _0254_ last_valid_data\[30\] VSS VSS VDD VDD _0261_
+ sky130_fd_sc_hd__nand2_1
X_1032_ _0252_ _0139_ VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__nand2_1
X_1033_ _0246_ _0261_ _0262_ VSS VSS VDD VDD net86 sky130_fd_sc_hd__o21ai_0
X_1034_ _0254_ last_valid_data\[31\] VSS VSS VDD VDD _0263_
+ sky130_fd_sc_hd__nand2_1
X_1035_ _0252_ _0146_ VSS VSS VDD VDD _0264_ sky130_fd_sc_hd__nand2_1
X_1036_ _0246_ _0263_ _0264_ VSS VSS VDD VDD net87 sky130_fd_sc_hd__o21ai_0
X_1037_ _0254_ last_valid_data\[3\] VSS VSS VDD VDD _0265_
+ sky130_fd_sc_hd__nand2_1
X_1038_ _0252_ _0153_ VSS VSS VDD VDD _0266_ sky130_fd_sc_hd__nand2_1
X_1039_ _0246_ _0265_ _0266_ VSS VSS VDD VDD net88 sky130_fd_sc_hd__o21ai_0
X_1040_ _0254_ last_valid_data\[4\] VSS VSS VDD VDD _0267_
+ sky130_fd_sc_hd__nand2_1
X_1041_ _0252_ _0160_ VSS VSS VDD VDD _0268_ sky130_fd_sc_hd__nand2_1
X_1042_ _0246_ _0267_ _0268_ VSS VSS VDD VDD net89 sky130_fd_sc_hd__o21ai_1
X_1043_ _0254_ last_valid_data\[5\] VSS VSS VDD VDD _0269_
+ sky130_fd_sc_hd__nand2_1
X_1044_ _0252_ _0167_ VSS VSS VDD VDD _0270_ sky130_fd_sc_hd__nand2_1
X_1045_ _0325_ _0269_ _0270_ VSS VSS VDD VDD net90 sky130_fd_sc_hd__o21ai_0
X_1046_ _0254_ last_valid_data\[6\] VSS VSS VDD VDD _0271_
+ sky130_fd_sc_hd__nand2_1
X_1047_ _0252_ _0174_ VSS VSS VDD VDD _0272_ sky130_fd_sc_hd__nand2_1
X_1048_ _0325_ _0271_ _0272_ VSS VSS VDD VDD net91 sky130_fd_sc_hd__o21ai_0
X_1049_ _0254_ last_valid_data\[7\] VSS VSS VDD VDD _0273_
+ sky130_fd_sc_hd__nand2_1
X_1050_ _0207_ _0181_ VSS VSS VDD VDD _0274_ sky130_fd_sc_hd__nand2_1
X_1051_ _0325_ _0273_ _0274_ VSS VSS VDD VDD net92 sky130_fd_sc_hd__o21ai_0
X_1052_ _0196_ last_valid_data\[8\] VSS VSS VDD VDD _0275_
+ sky130_fd_sc_hd__nand2_1
X_1053_ _0207_ _0188_ VSS VSS VDD VDD _0276_ sky130_fd_sc_hd__nand2_1
X_1054_ _0325_ _0275_ _0276_ VSS VSS VDD VDD net93 sky130_fd_sc_hd__o21ai_1
X_1055_ _0196_ last_valid_data\[9\] VSS VSS VDD VDD _0277_
+ sky130_fd_sc_hd__nand2_1
X_1056_ _0207_ _0195_ VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__nand2_1
X_1057_ _0325_ _0277_ _0278_ VSS VSS VDD VDD net94 sky130_fd_sc_hd__o21ai_1
X_1058_ net61 VSS VSS VDD VDD net97 sky130_fd_sc_hd__inv_1
X_1059_ _0495_ wr_ptr\[1\] _0496_ VSS VSS VDD VDD _0497_ net39
+ sky130_fd_sc_hd__fa_2
X_1060_ _0498_ wr_ptr\[3\] VSS VSS VDD VDD _0499_ _0500_ sky130_fd_sc_hd__ha_1
X_1061_ _0495_ wr_ptr\[1\] VSS VSS VDD VDD _0501_ _0502_ sky130_fd_sc_hd__ha_1
X_1062_ _0503_ wr_ptr\[2\] VSS VSS VDD VDD _0504_ _0505_ sky130_fd_sc_hd__ha_1
X_1063_ rd_ptr\[0\] rd_ptr\[1\] VSS VSS VDD VDD _0506_ _0019_
+ sky130_fd_sc_hd__ha_1
X_1064_ net44 net51 VSS VSS VDD VDD _0507_ _0020_ sky130_fd_sc_hd__ha_1
X_1065_ _0017_ _0508_ VSS VSS VDD VDD _0509_ _0018_ sky130_fd_sc_hd__ha_1
X_1066_ _0017_ wr_ptr\[1\] VSS VSS VDD VDD _0510_ _0511_ sky130_fd_sc_hd__ha_1
X_1067_ wr_ptr\[0\] _0508_ VSS VSS VDD VDD _0512_ _0513_ sky130_fd_sc_hd__ha_1
X_1068_ wr_ptr\[0\] wr_ptr\[1\] VSS VSS VDD VDD _0514_ _0515_
+ sky130_fd_sc_hd__ha_1
X_1069_ rd_ptr\[0\] _0017_ VSS VSS VDD VDD _0516_ _0517_ sky130_fd_sc_hd__ha_1
Xerror_count\[0\]$_DFFE_PN0P_ clknet_leaf_38_clk _0021_ net1
+ VSS VSS VDD VDD net44 sky130_fd_sc_hd__dfrtp_2
Xerror_count\[10\]$_DFFE_PN0P_ clknet_leaf_37_clk _0022_ net1
+ VSS VSS VDD VDD net45 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[11\]$_DFFE_PN0P_ clknet_leaf_38_clk _0023_ net1
+ VSS VSS VDD VDD net46 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[12\]$_DFFE_PN0P_ clknet_leaf_38_clk _0024_ net1
+ VSS VSS VDD VDD net47 sky130_fd_sc_hd__dfrtp_2
Xerror_count\[13\]$_DFFE_PN0P_ clknet_leaf_38_clk _0025_ net1
+ VSS VSS VDD VDD net48 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[14\]$_DFFE_PN0P_ clknet_leaf_37_clk _0026_ net1
+ VSS VSS VDD VDD net49 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[15\]$_DFFE_PN0P_ clknet_leaf_38_clk _0027_ net1
+ VSS VSS VDD VDD net50 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[1\]$_DFFE_PN0P_ clknet_leaf_37_clk _0028_ net1
+ VSS VSS VDD VDD net51 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[2\]$_DFFE_PN0P_ clknet_leaf_37_clk _0029_ net1
+ VSS VSS VDD VDD net52 sky130_fd_sc_hd__dfrtp_2
Xerror_count\[3\]$_DFFE_PN0P_ clknet_leaf_37_clk _0030_ net1
+ VSS VSS VDD VDD net53 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[4\]$_DFFE_PN0P_ clknet_leaf_37_clk _0031_ net1
+ VSS VSS VDD VDD net54 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[5\]$_DFFE_PN0P_ clknet_leaf_36_clk _0032_ net1
+ VSS VSS VDD VDD net55 sky130_fd_sc_hd__dfrtp_2
Xerror_count\[6\]$_DFFE_PN0P_ clknet_leaf_36_clk _0033_ net1
+ VSS VSS VDD VDD net56 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[7\]$_DFFE_PN0P_ clknet_leaf_36_clk _0034_ net1
+ VSS VSS VDD VDD net57 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[8\]$_DFFE_PN0P_ clknet_leaf_36_clk _0035_ net1
+ VSS VSS VDD VDD net58 sky130_fd_sc_hd__dfrtp_1
Xerror_count\[9\]$_DFFE_PN0P_ clknet_leaf_36_clk _0036_ net1
+ VSS VSS VDD VDD net59 sky130_fd_sc_hd__dfrtp_1
Xerror_detected$_DFF_PN0_ clknet_leaf_38_clk _0000_ net1 VSS
+ VSS VDD VDD net60 sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[0\]$_DFFE_PN0P_ clknet_leaf_48_clk _0037_
+ net1 VSS VSS VDD VDD last_valid_data\[0\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[10\]$_DFFE_PN0P_ clknet_leaf_41_clk _0038_
+ net1 VSS VSS VDD VDD last_valid_data\[10\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[11\]$_DFFE_PN0P_ clknet_leaf_41_clk _0039_
+ net1 VSS VSS VDD VDD last_valid_data\[11\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[12\]$_DFFE_PN0P_ clknet_leaf_40_clk _0040_
+ net1 VSS VSS VDD VDD last_valid_data\[12\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[13\]$_DFFE_PN0P_ clknet_leaf_41_clk _0041_
+ net1 VSS VSS VDD VDD last_valid_data\[13\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[14\]$_DFFE_PN0P_ clknet_leaf_48_clk _0042_
+ net1 VSS VSS VDD VDD last_valid_data\[14\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[15\]$_DFFE_PN0P_ clknet_leaf_48_clk _0043_
+ net1 VSS VSS VDD VDD last_valid_data\[15\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[16\]$_DFFE_PN0P_ clknet_leaf_47_clk _0044_
+ net1 VSS VSS VDD VDD last_valid_data\[16\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[17\]$_DFFE_PN0P_ clknet_leaf_46_clk _0045_
+ net1 VSS VSS VDD VDD last_valid_data\[17\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[18\]$_DFFE_PN0P_ clknet_leaf_2_clk _0046_
+ net1 VSS VSS VDD VDD last_valid_data\[18\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[19\]$_DFFE_PN0P_ clknet_leaf_2_clk _0047_
+ net1 VSS VSS VDD VDD last_valid_data\[19\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[1\]$_DFFE_PN0P_ clknet_leaf_3_clk _0048_
+ net1 VSS VSS VDD VDD last_valid_data\[1\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[20\]$_DFFE_PN0P_ clknet_leaf_10_clk _0049_
+ net1 VSS VSS VDD VDD last_valid_data\[20\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[21\]$_DFFE_PN0P_ clknet_leaf_10_clk _0050_
+ net1 VSS VSS VDD VDD last_valid_data\[21\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[22\]$_DFFE_PN0P_ clknet_leaf_11_clk _0051_
+ net1 VSS VSS VDD VDD last_valid_data\[22\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[23\]$_DFFE_PN0P_ clknet_leaf_13_clk _0052_
+ net1 VSS VSS VDD VDD last_valid_data\[23\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[24\]$_DFFE_PN0P_ clknet_leaf_15_clk _0053_
+ net1 VSS VSS VDD VDD last_valid_data\[24\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[25\]$_DFFE_PN0P_ clknet_leaf_15_clk _0054_
+ net1 VSS VSS VDD VDD last_valid_data\[25\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[26\]$_DFFE_PN0P_ clknet_leaf_23_clk _0055_
+ net1 VSS VSS VDD VDD last_valid_data\[26\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[27\]$_DFFE_PN0P_ clknet_leaf_23_clk _0056_
+ net1 VSS VSS VDD VDD last_valid_data\[27\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[28\]$_DFFE_PN0P_ clknet_leaf_23_clk _0057_
+ net1 VSS VSS VDD VDD last_valid_data\[28\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[29\]$_DFFE_PN0P_ clknet_leaf_25_clk _0058_
+ net1 VSS VSS VDD VDD last_valid_data\[29\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[2\]$_DFFE_PN0P_ clknet_leaf_25_clk _0059_
+ net1 VSS VSS VDD VDD last_valid_data\[2\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[30\]$_DFFE_PN0P_ clknet_leaf_23_clk _0060_
+ net1 VSS VSS VDD VDD last_valid_data\[30\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[31\]$_DFFE_PN0P_ clknet_leaf_24_clk _0061_
+ net1 VSS VSS VDD VDD last_valid_data\[31\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[3\]$_DFFE_PN0P_ clknet_leaf_28_clk _0062_
+ net1 VSS VSS VDD VDD last_valid_data\[3\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[4\]$_DFFE_PN0P_ clknet_leaf_29_clk _0063_
+ net1 VSS VSS VDD VDD last_valid_data\[4\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[5\]$_DFFE_PN0P_ clknet_leaf_30_clk _0064_
+ net1 VSS VSS VDD VDD last_valid_data\[5\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[6\]$_DFFE_PN0P_ clknet_leaf_30_clk _0065_
+ net1 VSS VSS VDD VDD last_valid_data\[6\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[7\]$_DFFE_PN0P_ clknet_leaf_36_clk _0066_
+ net1 VSS VSS VDD VDD last_valid_data\[7\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[8\]$_DFFE_PN0P_ clknet_leaf_34_clk _0067_
+ net1 VSS VSS VDD VDD last_valid_data\[8\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data\[9\]$_DFFE_PN0P_ clknet_leaf_34_clk _0068_
+ net1 VSS VSS VDD VDD last_valid_data\[9\] sky130_fd_sc_hd__dfrtp_1
Xlast_valid_data_available$_DFFE_PN0P_ clknet_leaf_43_clk
+ _0069_ net1 VSS VSS VDD VDD last_valid_data_available sky130_fd_sc_hd__dfrtp_1
Xmem\[0\]\[0\]$_DFFE_PP_ clknet_leaf_6_clk net3 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[10\]$_DFFE_PP_ clknet_leaf_42_clk net4 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[11\]$_DFFE_PP_ clknet_leaf_40_clk net5 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[12\]$_DFFE_PP_ clknet_leaf_42_clk net6 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[13\]$_DFFE_PP_ clknet_leaf_47_clk net7 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[14\]$_DFFE_PP_ clknet_leaf_46_clk net8 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[15\]$_DFFE_PP_ clknet_leaf_49_clk net9 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[16\]$_DFFE_PP_ clknet_leaf_49_clk net10 _0001_
+ VSS VSS VDD VDD mem\[0\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[17\]$_DFFE_PP_ clknet_leaf_50_clk net11 _0001_
+ VSS VSS VDD VDD mem\[0\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[18\]$_DFFE_PP_ clknet_leaf_1_clk net12 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[19\]$_DFFE_PP_ clknet_leaf_3_clk net13 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[1\]$_DFFE_PP_ clknet_leaf_7_clk net14 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[20\]$_DFFE_PP_ clknet_leaf_7_clk net15 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[21\]$_DFFE_PP_ clknet_leaf_8_clk net16 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[22\]$_DFFE_PP_ clknet_leaf_8_clk net17 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[23\]$_DFFE_PP_ clknet_leaf_12_clk net18 _0001_
+ VSS VSS VDD VDD mem\[0\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[24\]$_DFFE_PP_ clknet_leaf_16_clk net19 _0001_
+ VSS VSS VDD VDD mem\[0\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[25\]$_DFFE_PP_ clknet_leaf_14_clk net20 _0001_
+ VSS VSS VDD VDD mem\[0\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[26\]$_DFFE_PP_ clknet_leaf_16_clk net21 _0001_
+ VSS VSS VDD VDD mem\[0\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk net22 _0001_
+ VSS VSS VDD VDD mem\[0\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net23 _0001_
+ VSS VSS VDD VDD mem\[0\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net24 _0001_
+ VSS VSS VDD VDD mem\[0\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[2\]$_DFFE_PP_ clknet_leaf_26_clk net25 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[30\]$_DFFE_PP_ clknet_leaf_24_clk net26 _0001_
+ VSS VSS VDD VDD mem\[0\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0001_
+ VSS VSS VDD VDD mem\[0\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[3\]$_DFFE_PP_ clknet_leaf_31_clk net28 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[4\]$_DFFE_PP_ clknet_leaf_31_clk net29 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[5\]$_DFFE_PP_ clknet_leaf_20_clk net30 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[6\]$_DFFE_PP_ clknet_leaf_30_clk net31 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[7\]$_DFFE_PP_ clknet_leaf_35_clk net32 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[8\]$_DFFE_PP_ clknet_leaf_37_clk net33 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[9\]$_DFFE_PP_ clknet_leaf_45_clk net34 _0001_ VSS
+ VSS VDD VDD mem\[0\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[0\]$_DFFE_PP_ clknet_leaf_6_clk net3 _0002_ VSS
+ VSS VDD VDD mem\[10\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[10\]$_DFFE_PP_ clknet_leaf_41_clk net4 _0002_
+ VSS VSS VDD VDD mem\[10\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk net5 _0002_
+ VSS VSS VDD VDD mem\[10\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[12\]$_DFFE_PP_ clknet_leaf_40_clk net6 _0002_
+ VSS VSS VDD VDD mem\[10\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[13\]$_DFFE_PP_ clknet_leaf_48_clk net7 _0002_
+ VSS VSS VDD VDD mem\[10\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[14\]$_DFFE_PP_ clknet_leaf_48_clk net8 _0002_
+ VSS VSS VDD VDD mem\[10\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[15\]$_DFFE_PP_ clknet_leaf_50_clk net9 _0002_
+ VSS VSS VDD VDD mem\[10\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[16\]$_DFFE_PP_ clknet_leaf_51_clk net10 _0002_
+ VSS VSS VDD VDD mem\[10\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[17\]$_DFFE_PP_ clknet_leaf_51_clk net11 _0002_
+ VSS VSS VDD VDD mem\[10\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[18\]$_DFFE_PP_ clknet_leaf_0_clk net12 _0002_
+ VSS VSS VDD VDD mem\[10\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[19\]$_DFFE_PP_ clknet_leaf_2_clk net13 _0002_
+ VSS VSS VDD VDD mem\[10\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[1\]$_DFFE_PP_ clknet_leaf_3_clk net14 _0002_ VSS
+ VSS VDD VDD mem\[10\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[20\]$_DFFE_PP_ clknet_leaf_10_clk net15 _0002_
+ VSS VSS VDD VDD mem\[10\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[21\]$_DFFE_PP_ clknet_leaf_10_clk net16 _0002_
+ VSS VSS VDD VDD mem\[10\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net17 _0002_
+ VSS VSS VDD VDD mem\[10\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[23\]$_DFFE_PP_ clknet_leaf_12_clk net18 _0002_
+ VSS VSS VDD VDD mem\[10\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[24\]$_DFFE_PP_ clknet_leaf_12_clk net19 _0002_
+ VSS VSS VDD VDD mem\[10\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[25\]$_DFFE_PP_ clknet_leaf_19_clk net20 _0002_
+ VSS VSS VDD VDD mem\[10\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[26\]$_DFFE_PP_ clknet_leaf_20_clk net21 _0002_
+ VSS VSS VDD VDD mem\[10\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[27\]$_DFFE_PP_ clknet_leaf_18_clk net22 _0002_
+ VSS VSS VDD VDD mem\[10\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[28\]$_DFFE_PP_ clknet_leaf_20_clk net23 _0002_
+ VSS VSS VDD VDD mem\[10\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[29\]$_DFFE_PP_ clknet_leaf_28_clk net24 _0002_
+ VSS VSS VDD VDD mem\[10\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[2\]$_DFFE_PP_ clknet_leaf_26_clk net25 _0002_
+ VSS VSS VDD VDD mem\[10\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[30\]$_DFFE_PP_ clknet_leaf_21_clk net26 _0002_
+ VSS VSS VDD VDD mem\[10\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[31\]$_DFFE_PP_ clknet_leaf_22_clk net27 _0002_
+ VSS VSS VDD VDD mem\[10\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[3\]$_DFFE_PP_ clknet_leaf_31_clk net28 _0002_
+ VSS VSS VDD VDD mem\[10\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[4\]$_DFFE_PP_ clknet_leaf_32_clk net29 _0002_
+ VSS VSS VDD VDD mem\[10\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[5\]$_DFFE_PP_ clknet_leaf_33_clk net30 _0002_
+ VSS VSS VDD VDD mem\[10\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[6\]$_DFFE_PP_ clknet_leaf_32_clk net31 _0002_
+ VSS VSS VDD VDD mem\[10\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[7\]$_DFFE_PP_ clknet_leaf_34_clk net32 _0002_
+ VSS VSS VDD VDD mem\[10\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[8\]$_DFFE_PP_ clknet_leaf_35_clk net33 _0002_
+ VSS VSS VDD VDD mem\[10\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[9\]$_DFFE_PP_ clknet_leaf_45_clk net34 _0002_
+ VSS VSS VDD VDD mem\[10\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[0\]$_DFFE_PP_ clknet_leaf_6_clk net3 _0003_ VSS
+ VSS VDD VDD mem\[11\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[10\]$_DFFE_PP_ clknet_leaf_41_clk net4 _0003_
+ VSS VSS VDD VDD mem\[11\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk net5 _0003_
+ VSS VSS VDD VDD mem\[11\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[12\]$_DFFE_PP_ clknet_leaf_40_clk net6 _0003_
+ VSS VSS VDD VDD mem\[11\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[13\]$_DFFE_PP_ clknet_leaf_48_clk net7 _0003_
+ VSS VSS VDD VDD mem\[11\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[14\]$_DFFE_PP_ clknet_leaf_48_clk net8 _0003_
+ VSS VSS VDD VDD mem\[11\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[15\]$_DFFE_PP_ clknet_leaf_50_clk net9 _0003_
+ VSS VSS VDD VDD mem\[11\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[16\]$_DFFE_PP_ clknet_leaf_51_clk net10 _0003_
+ VSS VSS VDD VDD mem\[11\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[17\]$_DFFE_PP_ clknet_leaf_51_clk net11 _0003_
+ VSS VSS VDD VDD mem\[11\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[18\]$_DFFE_PP_ clknet_leaf_2_clk net12 _0003_
+ VSS VSS VDD VDD mem\[11\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[19\]$_DFFE_PP_ clknet_leaf_2_clk net13 _0003_
+ VSS VSS VDD VDD mem\[11\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[1\]$_DFFE_PP_ clknet_leaf_3_clk net14 _0003_ VSS
+ VSS VDD VDD mem\[11\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[20\]$_DFFE_PP_ clknet_leaf_11_clk net15 _0003_
+ VSS VSS VDD VDD mem\[11\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[21\]$_DFFE_PP_ clknet_leaf_10_clk net16 _0003_
+ VSS VSS VDD VDD mem\[11\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[22\]$_DFFE_PP_ clknet_leaf_13_clk net17 _0003_
+ VSS VSS VDD VDD mem\[11\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[23\]$_DFFE_PP_ clknet_leaf_12_clk net18 _0003_
+ VSS VSS VDD VDD mem\[11\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[24\]$_DFFE_PP_ clknet_leaf_11_clk net19 _0003_
+ VSS VSS VDD VDD mem\[11\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[25\]$_DFFE_PP_ clknet_leaf_19_clk net20 _0003_
+ VSS VSS VDD VDD mem\[11\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk net21 _0003_
+ VSS VSS VDD VDD mem\[11\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[27\]$_DFFE_PP_ clknet_leaf_18_clk net22 _0003_
+ VSS VSS VDD VDD mem\[11\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[28\]$_DFFE_PP_ clknet_leaf_20_clk net23 _0003_
+ VSS VSS VDD VDD mem\[11\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[29\]$_DFFE_PP_ clknet_leaf_28_clk net24 _0003_
+ VSS VSS VDD VDD mem\[11\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[2\]$_DFFE_PP_ clknet_leaf_28_clk net25 _0003_
+ VSS VSS VDD VDD mem\[11\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[30\]$_DFFE_PP_ clknet_leaf_21_clk net26 _0003_
+ VSS VSS VDD VDD mem\[11\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[31\]$_DFFE_PP_ clknet_leaf_31_clk net27 _0003_
+ VSS VSS VDD VDD mem\[11\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[3\]$_DFFE_PP_ clknet_leaf_31_clk net28 _0003_
+ VSS VSS VDD VDD mem\[11\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[4\]$_DFFE_PP_ clknet_leaf_31_clk net29 _0003_
+ VSS VSS VDD VDD mem\[11\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[5\]$_DFFE_PP_ clknet_leaf_33_clk net30 _0003_
+ VSS VSS VDD VDD mem\[11\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[6\]$_DFFE_PP_ clknet_leaf_34_clk net31 _0003_
+ VSS VSS VDD VDD mem\[11\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[7\]$_DFFE_PP_ clknet_leaf_34_clk net32 _0003_
+ VSS VSS VDD VDD mem\[11\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[8\]$_DFFE_PP_ clknet_leaf_43_clk net33 _0003_
+ VSS VSS VDD VDD mem\[11\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[9\]$_DFFE_PP_ clknet_leaf_45_clk net34 _0003_
+ VSS VSS VDD VDD mem\[11\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[0\]$_DFFE_PP_ clknet_leaf_45_clk net3 _0004_ VSS
+ VSS VDD VDD mem\[12\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[10\]$_DFFE_PP_ clknet_leaf_47_clk net4 _0004_
+ VSS VSS VDD VDD mem\[12\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[11\]$_DFFE_PP_ clknet_leaf_40_clk net5 _0004_
+ VSS VSS VDD VDD mem\[12\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[12\]$_DFFE_PP_ clknet_leaf_40_clk net6 _0004_
+ VSS VSS VDD VDD mem\[12\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[13\]$_DFFE_PP_ clknet_leaf_47_clk net7 _0004_
+ VSS VSS VDD VDD mem\[12\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[14\]$_DFFE_PP_ clknet_leaf_49_clk net8 _0004_
+ VSS VSS VDD VDD mem\[12\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[15\]$_DFFE_PP_ clknet_leaf_50_clk net9 _0004_
+ VSS VSS VDD VDD mem\[12\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[16\]$_DFFE_PP_ clknet_leaf_51_clk net10 _0004_
+ VSS VSS VDD VDD mem\[12\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[17\]$_DFFE_PP_ clknet_leaf_50_clk net11 _0004_
+ VSS VSS VDD VDD mem\[12\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[18\]$_DFFE_PP_ clknet_leaf_2_clk net12 _0004_
+ VSS VSS VDD VDD mem\[12\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[19\]$_DFFE_PP_ clknet_leaf_2_clk net13 _0004_
+ VSS VSS VDD VDD mem\[12\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[1\]$_DFFE_PP_ clknet_leaf_3_clk net14 _0004_ VSS
+ VSS VDD VDD mem\[12\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[20\]$_DFFE_PP_ clknet_leaf_10_clk net15 _0004_
+ VSS VSS VDD VDD mem\[12\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net16 _0004_
+ VSS VSS VDD VDD mem\[12\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net17 _0004_
+ VSS VSS VDD VDD mem\[12\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[23\]$_DFFE_PP_ clknet_leaf_13_clk net18 _0004_
+ VSS VSS VDD VDD mem\[12\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[24\]$_DFFE_PP_ clknet_leaf_18_clk net19 _0004_
+ VSS VSS VDD VDD mem\[12\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[25\]$_DFFE_PP_ clknet_leaf_19_clk net20 _0004_
+ VSS VSS VDD VDD mem\[12\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[26\]$_DFFE_PP_ clknet_leaf_19_clk net21 _0004_
+ VSS VSS VDD VDD mem\[12\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[27\]$_DFFE_PP_ clknet_leaf_18_clk net22 _0004_
+ VSS VSS VDD VDD mem\[12\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[28\]$_DFFE_PP_ clknet_leaf_20_clk net23 _0004_
+ VSS VSS VDD VDD mem\[12\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[29\]$_DFFE_PP_ clknet_leaf_28_clk net24 _0004_
+ VSS VSS VDD VDD mem\[12\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[2\]$_DFFE_PP_ clknet_leaf_27_clk net25 _0004_
+ VSS VSS VDD VDD mem\[12\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[30\]$_DFFE_PP_ clknet_leaf_22_clk net26 _0004_
+ VSS VSS VDD VDD mem\[12\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0004_
+ VSS VSS VDD VDD mem\[12\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[3\]$_DFFE_PP_ clknet_leaf_29_clk net28 _0004_
+ VSS VSS VDD VDD mem\[12\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[4\]$_DFFE_PP_ clknet_leaf_30_clk net29 _0004_
+ VSS VSS VDD VDD mem\[12\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[5\]$_DFFE_PP_ clknet_leaf_21_clk net30 _0004_
+ VSS VSS VDD VDD mem\[12\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[6\]$_DFFE_PP_ clknet_leaf_32_clk net31 _0004_
+ VSS VSS VDD VDD mem\[12\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[7\]$_DFFE_PP_ clknet_leaf_33_clk net32 _0004_
+ VSS VSS VDD VDD mem\[12\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[8\]$_DFFE_PP_ clknet_leaf_34_clk net33 _0004_
+ VSS VSS VDD VDD mem\[12\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[9\]$_DFFE_PP_ clknet_leaf_44_clk net34 _0004_
+ VSS VSS VDD VDD mem\[12\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[0\]$_DFFE_PP_ clknet_leaf_45_clk net3 _0005_ VSS
+ VSS VDD VDD mem\[13\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[10\]$_DFFE_PP_ clknet_leaf_42_clk net4 _0005_
+ VSS VSS VDD VDD mem\[13\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk net5 _0005_
+ VSS VSS VDD VDD mem\[13\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[12\]$_DFFE_PP_ clknet_leaf_41_clk net6 _0005_
+ VSS VSS VDD VDD mem\[13\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[13\]$_DFFE_PP_ clknet_leaf_47_clk net7 _0005_
+ VSS VSS VDD VDD mem\[13\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[14\]$_DFFE_PP_ clknet_leaf_49_clk net8 _0005_
+ VSS VSS VDD VDD mem\[13\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[15\]$_DFFE_PP_ clknet_leaf_50_clk net9 _0005_
+ VSS VSS VDD VDD mem\[13\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[16\]$_DFFE_PP_ clknet_leaf_0_clk net10 _0005_
+ VSS VSS VDD VDD mem\[13\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[17\]$_DFFE_PP_ clknet_leaf_50_clk net11 _0005_
+ VSS VSS VDD VDD mem\[13\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[18\]$_DFFE_PP_ clknet_leaf_1_clk net12 _0005_
+ VSS VSS VDD VDD mem\[13\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[19\]$_DFFE_PP_ clknet_leaf_2_clk net13 _0005_
+ VSS VSS VDD VDD mem\[13\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[1\]$_DFFE_PP_ clknet_leaf_3_clk net14 _0005_ VSS
+ VSS VDD VDD mem\[13\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[20\]$_DFFE_PP_ clknet_leaf_8_clk net15 _0005_
+ VSS VSS VDD VDD mem\[13\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[21\]$_DFFE_PP_ clknet_leaf_10_clk net16 _0005_
+ VSS VSS VDD VDD mem\[13\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net17 _0005_
+ VSS VSS VDD VDD mem\[13\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[23\]$_DFFE_PP_ clknet_leaf_13_clk net18 _0005_
+ VSS VSS VDD VDD mem\[13\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[24\]$_DFFE_PP_ clknet_leaf_15_clk net19 _0005_
+ VSS VSS VDD VDD mem\[13\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[25\]$_DFFE_PP_ clknet_leaf_7_clk net20 _0005_
+ VSS VSS VDD VDD mem\[13\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[26\]$_DFFE_PP_ clknet_leaf_19_clk net21 _0005_
+ VSS VSS VDD VDD mem\[13\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[27\]$_DFFE_PP_ clknet_leaf_18_clk net22 _0005_
+ VSS VSS VDD VDD mem\[13\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[28\]$_DFFE_PP_ clknet_leaf_18_clk net23 _0005_
+ VSS VSS VDD VDD mem\[13\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[29\]$_DFFE_PP_ clknet_leaf_28_clk net24 _0005_
+ VSS VSS VDD VDD mem\[13\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[2\]$_DFFE_PP_ clknet_leaf_28_clk net25 _0005_
+ VSS VSS VDD VDD mem\[13\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[30\]$_DFFE_PP_ clknet_leaf_23_clk net26 _0005_
+ VSS VSS VDD VDD mem\[13\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0005_
+ VSS VSS VDD VDD mem\[13\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[3\]$_DFFE_PP_ clknet_leaf_30_clk net28 _0005_
+ VSS VSS VDD VDD mem\[13\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[4\]$_DFFE_PP_ clknet_leaf_32_clk net29 _0005_
+ VSS VSS VDD VDD mem\[13\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[5\]$_DFFE_PP_ clknet_leaf_32_clk net30 _0005_
+ VSS VSS VDD VDD mem\[13\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[6\]$_DFFE_PP_ clknet_leaf_32_clk net31 _0005_
+ VSS VSS VDD VDD mem\[13\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[7\]$_DFFE_PP_ clknet_leaf_33_clk net32 _0005_
+ VSS VSS VDD VDD mem\[13\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[8\]$_DFFE_PP_ clknet_leaf_34_clk net33 _0005_
+ VSS VSS VDD VDD mem\[13\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[9\]$_DFFE_PP_ clknet_leaf_44_clk net34 _0005_
+ VSS VSS VDD VDD mem\[13\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[0\]$_DFFE_PP_ clknet_leaf_45_clk net3 _0006_ VSS
+ VSS VDD VDD mem\[14\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[10\]$_DFFE_PP_ clknet_leaf_41_clk net4 _0006_
+ VSS VSS VDD VDD mem\[14\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk net5 _0006_
+ VSS VSS VDD VDD mem\[14\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[12\]$_DFFE_PP_ clknet_leaf_40_clk net6 _0006_
+ VSS VSS VDD VDD mem\[14\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[13\]$_DFFE_PP_ clknet_leaf_47_clk net7 _0006_
+ VSS VSS VDD VDD mem\[14\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[14\]$_DFFE_PP_ clknet_leaf_49_clk net8 _0006_
+ VSS VSS VDD VDD mem\[14\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[15\]$_DFFE_PP_ clknet_leaf_50_clk net9 _0006_
+ VSS VSS VDD VDD mem\[14\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[16\]$_DFFE_PP_ clknet_leaf_0_clk net10 _0006_
+ VSS VSS VDD VDD mem\[14\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[17\]$_DFFE_PP_ clknet_leaf_51_clk net11 _0006_
+ VSS VSS VDD VDD mem\[14\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[18\]$_DFFE_PP_ clknet_leaf_1_clk net12 _0006_
+ VSS VSS VDD VDD mem\[14\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[19\]$_DFFE_PP_ clknet_leaf_2_clk net13 _0006_
+ VSS VSS VDD VDD mem\[14\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[1\]$_DFFE_PP_ clknet_leaf_9_clk net14 _0006_ VSS
+ VSS VDD VDD mem\[14\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[20\]$_DFFE_PP_ clknet_leaf_10_clk net15 _0006_
+ VSS VSS VDD VDD mem\[14\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net16 _0006_
+ VSS VSS VDD VDD mem\[14\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net17 _0006_
+ VSS VSS VDD VDD mem\[14\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[23\]$_DFFE_PP_ clknet_leaf_12_clk net18 _0006_
+ VSS VSS VDD VDD mem\[14\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[24\]$_DFFE_PP_ clknet_leaf_15_clk net19 _0006_
+ VSS VSS VDD VDD mem\[14\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[25\]$_DFFE_PP_ clknet_leaf_19_clk net20 _0006_
+ VSS VSS VDD VDD mem\[14\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[26\]$_DFFE_PP_ clknet_leaf_20_clk net21 _0006_
+ VSS VSS VDD VDD mem\[14\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[27\]$_DFFE_PP_ clknet_leaf_18_clk net22 _0006_
+ VSS VSS VDD VDD mem\[14\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[28\]$_DFFE_PP_ clknet_leaf_23_clk net23 _0006_
+ VSS VSS VDD VDD mem\[14\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[29\]$_DFFE_PP_ clknet_leaf_28_clk net24 _0006_
+ VSS VSS VDD VDD mem\[14\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[2\]$_DFFE_PP_ clknet_leaf_28_clk net25 _0006_
+ VSS VSS VDD VDD mem\[14\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[30\]$_DFFE_PP_ clknet_leaf_21_clk net26 _0006_
+ VSS VSS VDD VDD mem\[14\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0006_
+ VSS VSS VDD VDD mem\[14\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[3\]$_DFFE_PP_ clknet_leaf_29_clk net28 _0006_
+ VSS VSS VDD VDD mem\[14\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[4\]$_DFFE_PP_ clknet_leaf_32_clk net29 _0006_
+ VSS VSS VDD VDD mem\[14\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[5\]$_DFFE_PP_ clknet_leaf_33_clk net30 _0006_
+ VSS VSS VDD VDD mem\[14\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[6\]$_DFFE_PP_ clknet_leaf_32_clk net31 _0006_
+ VSS VSS VDD VDD mem\[14\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[7\]$_DFFE_PP_ clknet_leaf_33_clk net32 _0006_
+ VSS VSS VDD VDD mem\[14\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[8\]$_DFFE_PP_ clknet_leaf_34_clk net33 _0006_
+ VSS VSS VDD VDD mem\[14\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[9\]$_DFFE_PP_ clknet_leaf_44_clk net34 _0006_
+ VSS VSS VDD VDD mem\[14\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[0\]$_DFFE_PP_ clknet_leaf_45_clk net3 _0007_ VSS
+ VSS VDD VDD mem\[15\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[10\]$_DFFE_PP_ clknet_leaf_41_clk net4 _0007_
+ VSS VSS VDD VDD mem\[15\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[11\]$_DFFE_PP_ clknet_leaf_40_clk net5 _0007_
+ VSS VSS VDD VDD mem\[15\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[12\]$_DFFE_PP_ clknet_leaf_41_clk net6 _0007_
+ VSS VSS VDD VDD mem\[15\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[13\]$_DFFE_PP_ clknet_leaf_49_clk net7 _0007_
+ VSS VSS VDD VDD mem\[15\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[14\]$_DFFE_PP_ clknet_leaf_48_clk net8 _0007_
+ VSS VSS VDD VDD mem\[15\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[15\]$_DFFE_PP_ clknet_leaf_50_clk net9 _0007_
+ VSS VSS VDD VDD mem\[15\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[16\]$_DFFE_PP_ clknet_leaf_0_clk net10 _0007_
+ VSS VSS VDD VDD mem\[15\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[17\]$_DFFE_PP_ clknet_leaf_50_clk net11 _0007_
+ VSS VSS VDD VDD mem\[15\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[18\]$_DFFE_PP_ clknet_leaf_1_clk net12 _0007_
+ VSS VSS VDD VDD mem\[15\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[19\]$_DFFE_PP_ clknet_leaf_2_clk net13 _0007_
+ VSS VSS VDD VDD mem\[15\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[1\]$_DFFE_PP_ clknet_leaf_9_clk net14 _0007_ VSS
+ VSS VDD VDD mem\[15\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[20\]$_DFFE_PP_ clknet_leaf_10_clk net15 _0007_
+ VSS VSS VDD VDD mem\[15\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net16 _0007_
+ VSS VSS VDD VDD mem\[15\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net17 _0007_
+ VSS VSS VDD VDD mem\[15\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[23\]$_DFFE_PP_ clknet_leaf_13_clk net18 _0007_
+ VSS VSS VDD VDD mem\[15\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[24\]$_DFFE_PP_ clknet_leaf_15_clk net19 _0007_
+ VSS VSS VDD VDD mem\[15\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[25\]$_DFFE_PP_ clknet_leaf_19_clk net20 _0007_
+ VSS VSS VDD VDD mem\[15\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[26\]$_DFFE_PP_ clknet_leaf_20_clk net21 _0007_
+ VSS VSS VDD VDD mem\[15\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[27\]$_DFFE_PP_ clknet_leaf_18_clk net22 _0007_
+ VSS VSS VDD VDD mem\[15\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[28\]$_DFFE_PP_ clknet_leaf_23_clk net23 _0007_
+ VSS VSS VDD VDD mem\[15\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[29\]$_DFFE_PP_ clknet_leaf_28_clk net24 _0007_
+ VSS VSS VDD VDD mem\[15\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[2\]$_DFFE_PP_ clknet_leaf_28_clk net25 _0007_
+ VSS VSS VDD VDD mem\[15\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[30\]$_DFFE_PP_ clknet_leaf_22_clk net26 _0007_
+ VSS VSS VDD VDD mem\[15\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0007_
+ VSS VSS VDD VDD mem\[15\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[3\]$_DFFE_PP_ clknet_leaf_29_clk net28 _0007_
+ VSS VSS VDD VDD mem\[15\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[4\]$_DFFE_PP_ clknet_leaf_32_clk net29 _0007_
+ VSS VSS VDD VDD mem\[15\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[5\]$_DFFE_PP_ clknet_leaf_33_clk net30 _0007_
+ VSS VSS VDD VDD mem\[15\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[6\]$_DFFE_PP_ clknet_leaf_32_clk net31 _0007_
+ VSS VSS VDD VDD mem\[15\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[7\]$_DFFE_PP_ clknet_leaf_33_clk net32 _0007_
+ VSS VSS VDD VDD mem\[15\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[8\]$_DFFE_PP_ clknet_leaf_34_clk net33 _0007_
+ VSS VSS VDD VDD mem\[15\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[9\]$_DFFE_PP_ clknet_leaf_44_clk net34 _0007_
+ VSS VSS VDD VDD mem\[15\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[0\]$_DFFE_PP_ clknet_leaf_6_clk net3 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[10\]$_DFFE_PP_ clknet_leaf_42_clk net4 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[11\]$_DFFE_PP_ clknet_leaf_40_clk net5 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[12\]$_DFFE_PP_ clknet_leaf_42_clk net6 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[13\]$_DFFE_PP_ clknet_leaf_47_clk net7 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[14\]$_DFFE_PP_ clknet_leaf_46_clk net8 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[15\]$_DFFE_PP_ clknet_leaf_46_clk net9 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[16\]$_DFFE_PP_ clknet_leaf_0_clk net10 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[17\]$_DFFE_PP_ clknet_leaf_0_clk net11 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[18\]$_DFFE_PP_ clknet_leaf_4_clk net12 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[19\]$_DFFE_PP_ clknet_leaf_3_clk net13 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[1\]$_DFFE_PP_ clknet_leaf_5_clk net14 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[20\]$_DFFE_PP_ clknet_leaf_7_clk net15 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net16 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[22\]$_DFFE_PP_ clknet_leaf_11_clk net17 _0008_
+ VSS VSS VDD VDD mem\[1\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[23\]$_DFFE_PP_ clknet_leaf_12_clk net18 _0008_
+ VSS VSS VDD VDD mem\[1\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[24\]$_DFFE_PP_ clknet_leaf_14_clk net19 _0008_
+ VSS VSS VDD VDD mem\[1\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[25\]$_DFFE_PP_ clknet_leaf_14_clk net20 _0008_
+ VSS VSS VDD VDD mem\[1\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[26\]$_DFFE_PP_ clknet_leaf_17_clk net21 _0008_
+ VSS VSS VDD VDD mem\[1\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk net22 _0008_
+ VSS VSS VDD VDD mem\[1\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net23 _0008_
+ VSS VSS VDD VDD mem\[1\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[29\]$_DFFE_PP_ clknet_leaf_26_clk net24 _0008_
+ VSS VSS VDD VDD mem\[1\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[2\]$_DFFE_PP_ clknet_leaf_26_clk net25 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[30\]$_DFFE_PP_ clknet_leaf_24_clk net26 _0008_
+ VSS VSS VDD VDD mem\[1\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0008_
+ VSS VSS VDD VDD mem\[1\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[3\]$_DFFE_PP_ clknet_leaf_31_clk net28 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[4\]$_DFFE_PP_ clknet_leaf_30_clk net29 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[5\]$_DFFE_PP_ clknet_leaf_20_clk net30 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[6\]$_DFFE_PP_ clknet_leaf_30_clk net31 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[7\]$_DFFE_PP_ clknet_leaf_35_clk net32 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[8\]$_DFFE_PP_ clknet_leaf_34_clk net33 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[9\]$_DFFE_PP_ clknet_leaf_45_clk net34 _0008_ VSS
+ VSS VDD VDD mem\[1\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[0\]$_DFFE_PP_ clknet_leaf_6_clk net3 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[10\]$_DFFE_PP_ clknet_leaf_44_clk net4 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[11\]$_DFFE_PP_ clknet_leaf_43_clk net5 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[12\]$_DFFE_PP_ clknet_leaf_43_clk net6 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[13\]$_DFFE_PP_ clknet_leaf_46_clk net7 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[14\]$_DFFE_PP_ clknet_leaf_46_clk net8 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[15\]$_DFFE_PP_ clknet_leaf_46_clk net9 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[16\]$_DFFE_PP_ clknet_leaf_1_clk net10 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[17\]$_DFFE_PP_ clknet_leaf_0_clk net11 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[18\]$_DFFE_PP_ clknet_leaf_4_clk net12 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[19\]$_DFFE_PP_ clknet_leaf_5_clk net13 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[1\]$_DFFE_PP_ clknet_leaf_7_clk net14 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[20\]$_DFFE_PP_ clknet_leaf_7_clk net15 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net16 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[22\]$_DFFE_PP_ clknet_leaf_8_clk net17 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[23\]$_DFFE_PP_ clknet_leaf_14_clk net18 _0009_
+ VSS VSS VDD VDD mem\[2\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[24\]$_DFFE_PP_ clknet_leaf_14_clk net19 _0009_
+ VSS VSS VDD VDD mem\[2\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk net20 _0009_
+ VSS VSS VDD VDD mem\[2\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[26\]$_DFFE_PP_ clknet_leaf_17_clk net21 _0009_
+ VSS VSS VDD VDD mem\[2\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk net22 _0009_
+ VSS VSS VDD VDD mem\[2\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[28\]$_DFFE_PP_ clknet_leaf_23_clk net23 _0009_
+ VSS VSS VDD VDD mem\[2\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net24 _0009_
+ VSS VSS VDD VDD mem\[2\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[2\]$_DFFE_PP_ clknet_leaf_27_clk net25 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[30\]$_DFFE_PP_ clknet_leaf_23_clk net26 _0009_
+ VSS VSS VDD VDD mem\[2\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0009_
+ VSS VSS VDD VDD mem\[2\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[3\]$_DFFE_PP_ clknet_leaf_29_clk net28 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[4\]$_DFFE_PP_ clknet_leaf_29_clk net29 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[5\]$_DFFE_PP_ clknet_leaf_21_clk net30 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[6\]$_DFFE_PP_ clknet_leaf_29_clk net31 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[7\]$_DFFE_PP_ clknet_leaf_36_clk net32 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[8\]$_DFFE_PP_ clknet_leaf_35_clk net33 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[9\]$_DFFE_PP_ clknet_leaf_44_clk net34 _0009_ VSS
+ VSS VDD VDD mem\[2\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[0\]$_DFFE_PP_ clknet_leaf_5_clk net3 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[10\]$_DFFE_PP_ clknet_leaf_42_clk net4 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[11\]$_DFFE_PP_ clknet_leaf_43_clk net5 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[12\]$_DFFE_PP_ clknet_leaf_42_clk net6 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[13\]$_DFFE_PP_ clknet_leaf_47_clk net7 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[14\]$_DFFE_PP_ clknet_leaf_45_clk net8 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[15\]$_DFFE_PP_ clknet_leaf_49_clk net9 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[16\]$_DFFE_PP_ clknet_leaf_1_clk net10 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[17\]$_DFFE_PP_ clknet_leaf_0_clk net11 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[18\]$_DFFE_PP_ clknet_leaf_4_clk net12 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[19\]$_DFFE_PP_ clknet_leaf_4_clk net13 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[1\]$_DFFE_PP_ clknet_leaf_7_clk net14 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[20\]$_DFFE_PP_ clknet_leaf_7_clk net15 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net16 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[22\]$_DFFE_PP_ clknet_leaf_8_clk net17 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[23\]$_DFFE_PP_ clknet_leaf_15_clk net18 _0010_
+ VSS VSS VDD VDD mem\[3\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[24\]$_DFFE_PP_ clknet_leaf_14_clk net19 _0010_
+ VSS VSS VDD VDD mem\[3\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk net20 _0010_
+ VSS VSS VDD VDD mem\[3\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[26\]$_DFFE_PP_ clknet_leaf_17_clk net21 _0010_
+ VSS VSS VDD VDD mem\[3\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk net22 _0010_
+ VSS VSS VDD VDD mem\[3\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[28\]$_DFFE_PP_ clknet_leaf_17_clk net23 _0010_
+ VSS VSS VDD VDD mem\[3\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net24 _0010_
+ VSS VSS VDD VDD mem\[3\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[2\]$_DFFE_PP_ clknet_leaf_26_clk net25 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[30\]$_DFFE_PP_ clknet_leaf_22_clk net26 _0010_
+ VSS VSS VDD VDD mem\[3\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0010_
+ VSS VSS VDD VDD mem\[3\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[3\]$_DFFE_PP_ clknet_leaf_28_clk net28 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[4\]$_DFFE_PP_ clknet_leaf_29_clk net29 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[5\]$_DFFE_PP_ clknet_leaf_20_clk net30 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[6\]$_DFFE_PP_ clknet_leaf_29_clk net31 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[7\]$_DFFE_PP_ clknet_leaf_36_clk net32 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[8\]$_DFFE_PP_ clknet_leaf_35_clk net33 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[9\]$_DFFE_PP_ clknet_leaf_44_clk net34 _0010_ VSS
+ VSS VDD VDD mem\[3\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[0\]$_DFFE_PP_ clknet_leaf_6_clk net3 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[10\]$_DFFE_PP_ clknet_leaf_42_clk net4 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[11\]$_DFFE_PP_ clknet_leaf_40_clk net5 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[12\]$_DFFE_PP_ clknet_leaf_42_clk net6 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[13\]$_DFFE_PP_ clknet_leaf_47_clk net7 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[14\]$_DFFE_PP_ clknet_leaf_46_clk net8 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[15\]$_DFFE_PP_ clknet_leaf_49_clk net9 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[16\]$_DFFE_PP_ clknet_leaf_0_clk net10 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[17\]$_DFFE_PP_ clknet_leaf_50_clk net11 _0011_
+ VSS VSS VDD VDD mem\[4\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[18\]$_DFFE_PP_ clknet_leaf_4_clk net12 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[19\]$_DFFE_PP_ clknet_leaf_4_clk net13 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[1\]$_DFFE_PP_ clknet_leaf_5_clk net14 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[20\]$_DFFE_PP_ clknet_leaf_7_clk net15 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[21\]$_DFFE_PP_ clknet_leaf_8_clk net16 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[22\]$_DFFE_PP_ clknet_leaf_8_clk net17 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[23\]$_DFFE_PP_ clknet_leaf_15_clk net18 _0011_
+ VSS VSS VDD VDD mem\[4\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[24\]$_DFFE_PP_ clknet_leaf_14_clk net19 _0011_
+ VSS VSS VDD VDD mem\[4\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[25\]$_DFFE_PP_ clknet_leaf_16_clk net20 _0011_
+ VSS VSS VDD VDD mem\[4\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[26\]$_DFFE_PP_ clknet_leaf_17_clk net21 _0011_
+ VSS VSS VDD VDD mem\[4\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk net22 _0011_
+ VSS VSS VDD VDD mem\[4\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net23 _0011_
+ VSS VSS VDD VDD mem\[4\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net24 _0011_
+ VSS VSS VDD VDD mem\[4\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[2\]$_DFFE_PP_ clknet_leaf_26_clk net25 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[30\]$_DFFE_PP_ clknet_leaf_24_clk net26 _0011_
+ VSS VSS VDD VDD mem\[4\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0011_
+ VSS VSS VDD VDD mem\[4\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[3\]$_DFFE_PP_ clknet_leaf_31_clk net28 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[4\]$_DFFE_PP_ clknet_leaf_30_clk net29 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[5\]$_DFFE_PP_ clknet_leaf_21_clk net30 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[6\]$_DFFE_PP_ clknet_leaf_30_clk net31 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[7\]$_DFFE_PP_ clknet_leaf_35_clk net32 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[8\]$_DFFE_PP_ clknet_leaf_35_clk net33 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[9\]$_DFFE_PP_ clknet_leaf_45_clk net34 _0011_ VSS
+ VSS VDD VDD mem\[4\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[0\]$_DFFE_PP_ clknet_leaf_6_clk net3 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[10\]$_DFFE_PP_ clknet_leaf_42_clk net4 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk net5 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[12\]$_DFFE_PP_ clknet_leaf_42_clk net6 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[13\]$_DFFE_PP_ clknet_leaf_46_clk net7 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[14\]$_DFFE_PP_ clknet_leaf_46_clk net8 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[15\]$_DFFE_PP_ clknet_leaf_49_clk net9 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[16\]$_DFFE_PP_ clknet_leaf_1_clk net10 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[17\]$_DFFE_PP_ clknet_leaf_0_clk net11 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[18\]$_DFFE_PP_ clknet_leaf_4_clk net12 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[19\]$_DFFE_PP_ clknet_leaf_5_clk net13 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[1\]$_DFFE_PP_ clknet_leaf_5_clk net14 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[20\]$_DFFE_PP_ clknet_leaf_7_clk net15 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[21\]$_DFFE_PP_ clknet_leaf_8_clk net16 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[22\]$_DFFE_PP_ clknet_leaf_8_clk net17 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[23\]$_DFFE_PP_ clknet_leaf_12_clk net18 _0012_
+ VSS VSS VDD VDD mem\[5\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[24\]$_DFFE_PP_ clknet_leaf_14_clk net19 _0012_
+ VSS VSS VDD VDD mem\[5\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[25\]$_DFFE_PP_ clknet_leaf_16_clk net20 _0012_
+ VSS VSS VDD VDD mem\[5\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[26\]$_DFFE_PP_ clknet_leaf_17_clk net21 _0012_
+ VSS VSS VDD VDD mem\[5\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk net22 _0012_
+ VSS VSS VDD VDD mem\[5\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[28\]$_DFFE_PP_ clknet_leaf_24_clk net23 _0012_
+ VSS VSS VDD VDD mem\[5\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net24 _0012_
+ VSS VSS VDD VDD mem\[5\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[2\]$_DFFE_PP_ clknet_leaf_26_clk net25 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[30\]$_DFFE_PP_ clknet_leaf_24_clk net26 _0012_
+ VSS VSS VDD VDD mem\[5\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[31\]$_DFFE_PP_ clknet_leaf_24_clk net27 _0012_
+ VSS VSS VDD VDD mem\[5\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[3\]$_DFFE_PP_ clknet_leaf_31_clk net28 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[4\]$_DFFE_PP_ clknet_leaf_30_clk net29 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[5\]$_DFFE_PP_ clknet_leaf_20_clk net30 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[6\]$_DFFE_PP_ clknet_leaf_30_clk net31 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[7\]$_DFFE_PP_ clknet_leaf_35_clk net32 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[8\]$_DFFE_PP_ clknet_leaf_35_clk net33 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[9\]$_DFFE_PP_ clknet_leaf_44_clk net34 _0012_ VSS
+ VSS VDD VDD mem\[5\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[0\]$_DFFE_PP_ clknet_leaf_5_clk net3 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[10\]$_DFFE_PP_ clknet_leaf_43_clk net4 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[11\]$_DFFE_PP_ clknet_leaf_43_clk net5 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[12\]$_DFFE_PP_ clknet_leaf_42_clk net6 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[13\]$_DFFE_PP_ clknet_leaf_47_clk net7 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[14\]$_DFFE_PP_ clknet_leaf_45_clk net8 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[15\]$_DFFE_PP_ clknet_leaf_1_clk net9 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[16\]$_DFFE_PP_ clknet_leaf_1_clk net10 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[17\]$_DFFE_PP_ clknet_leaf_49_clk net11 _0013_
+ VSS VSS VDD VDD mem\[6\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[18\]$_DFFE_PP_ clknet_leaf_4_clk net12 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[19\]$_DFFE_PP_ clknet_leaf_4_clk net13 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[1\]$_DFFE_PP_ clknet_leaf_5_clk net14 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[20\]$_DFFE_PP_ clknet_leaf_6_clk net15 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net16 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[22\]$_DFFE_PP_ clknet_leaf_8_clk net17 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[23\]$_DFFE_PP_ clknet_leaf_14_clk net18 _0013_
+ VSS VSS VDD VDD mem\[6\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[24\]$_DFFE_PP_ clknet_leaf_14_clk net19 _0013_
+ VSS VSS VDD VDD mem\[6\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk net20 _0013_
+ VSS VSS VDD VDD mem\[6\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[26\]$_DFFE_PP_ clknet_leaf_17_clk net21 _0013_
+ VSS VSS VDD VDD mem\[6\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk net22 _0013_
+ VSS VSS VDD VDD mem\[6\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[28\]$_DFFE_PP_ clknet_leaf_17_clk net23 _0013_
+ VSS VSS VDD VDD mem\[6\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net24 _0013_
+ VSS VSS VDD VDD mem\[6\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[2\]$_DFFE_PP_ clknet_leaf_26_clk net25 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[30\]$_DFFE_PP_ clknet_leaf_22_clk net26 _0013_
+ VSS VSS VDD VDD mem\[6\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[31\]$_DFFE_PP_ clknet_leaf_26_clk net27 _0013_
+ VSS VSS VDD VDD mem\[6\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[3\]$_DFFE_PP_ clknet_leaf_28_clk net28 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[4\]$_DFFE_PP_ clknet_leaf_29_clk net29 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[5\]$_DFFE_PP_ clknet_leaf_22_clk net30 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[6\]$_DFFE_PP_ clknet_leaf_29_clk net31 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[7\]$_DFFE_PP_ clknet_leaf_36_clk net32 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[8\]$_DFFE_PP_ clknet_leaf_35_clk net33 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[9\]$_DFFE_PP_ clknet_leaf_44_clk net34 _0013_ VSS
+ VSS VDD VDD mem\[6\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[0\]$_DFFE_PP_ clknet_leaf_5_clk net3 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[10\]$_DFFE_PP_ clknet_leaf_43_clk net4 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[11\]$_DFFE_PP_ clknet_leaf_37_clk net5 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[12\]$_DFFE_PP_ clknet_leaf_42_clk net6 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[13\]$_DFFE_PP_ clknet_leaf_47_clk net7 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[14\]$_DFFE_PP_ clknet_leaf_4_clk net8 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[15\]$_DFFE_PP_ clknet_leaf_46_clk net9 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[16\]$_DFFE_PP_ clknet_leaf_4_clk net10 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[17\]$_DFFE_PP_ clknet_leaf_0_clk net11 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[18\]$_DFFE_PP_ clknet_leaf_4_clk net12 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[19\]$_DFFE_PP_ clknet_leaf_5_clk net13 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[1\]$_DFFE_PP_ clknet_leaf_7_clk net14 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[20\]$_DFFE_PP_ clknet_leaf_7_clk net15 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[21\]$_DFFE_PP_ clknet_leaf_9_clk net16 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[22\]$_DFFE_PP_ clknet_leaf_8_clk net17 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[23\]$_DFFE_PP_ clknet_leaf_14_clk net18 _0014_
+ VSS VSS VDD VDD mem\[7\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[24\]$_DFFE_PP_ clknet_leaf_14_clk net19 _0014_
+ VSS VSS VDD VDD mem\[7\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk net20 _0014_
+ VSS VSS VDD VDD mem\[7\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[26\]$_DFFE_PP_ clknet_leaf_17_clk net21 _0014_
+ VSS VSS VDD VDD mem\[7\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk net22 _0014_
+ VSS VSS VDD VDD mem\[7\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[28\]$_DFFE_PP_ clknet_leaf_23_clk net23 _0014_
+ VSS VSS VDD VDD mem\[7\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[29\]$_DFFE_PP_ clknet_leaf_27_clk net24 _0014_
+ VSS VSS VDD VDD mem\[7\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[2\]$_DFFE_PP_ clknet_leaf_27_clk net25 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[30\]$_DFFE_PP_ clknet_leaf_22_clk net26 _0014_
+ VSS VSS VDD VDD mem\[7\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[31\]$_DFFE_PP_ clknet_leaf_25_clk net27 _0014_
+ VSS VSS VDD VDD mem\[7\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[3\]$_DFFE_PP_ clknet_leaf_28_clk net28 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[4\]$_DFFE_PP_ clknet_leaf_29_clk net29 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[5\]$_DFFE_PP_ clknet_leaf_21_clk net30 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[6\]$_DFFE_PP_ clknet_leaf_29_clk net31 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[7\]$_DFFE_PP_ clknet_leaf_36_clk net32 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[8\]$_DFFE_PP_ clknet_leaf_35_clk net33 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[9\]$_DFFE_PP_ clknet_leaf_44_clk net34 _0014_ VSS
+ VSS VDD VDD mem\[7\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[0\]$_DFFE_PP_ clknet_leaf_5_clk net3 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[10\]$_DFFE_PP_ clknet_leaf_41_clk net4 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk net5 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[12\]$_DFFE_PP_ clknet_leaf_40_clk net6 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[13\]$_DFFE_PP_ clknet_leaf_48_clk net7 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[14\]$_DFFE_PP_ clknet_leaf_48_clk net8 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[15\]$_DFFE_PP_ clknet_leaf_50_clk net9 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[16\]$_DFFE_PP_ clknet_leaf_51_clk net10 _0015_
+ VSS VSS VDD VDD mem\[8\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[17\]$_DFFE_PP_ clknet_leaf_51_clk net11 _0015_
+ VSS VSS VDD VDD mem\[8\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[18\]$_DFFE_PP_ clknet_leaf_51_clk net12 _0015_
+ VSS VSS VDD VDD mem\[8\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[19\]$_DFFE_PP_ clknet_leaf_2_clk net13 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[1\]$_DFFE_PP_ clknet_leaf_3_clk net14 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[20\]$_DFFE_PP_ clknet_leaf_10_clk net15 _0015_
+ VSS VSS VDD VDD mem\[8\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[21\]$_DFFE_PP_ clknet_leaf_10_clk net16 _0015_
+ VSS VSS VDD VDD mem\[8\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[22\]$_DFFE_PP_ clknet_leaf_13_clk net17 _0015_
+ VSS VSS VDD VDD mem\[8\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[23\]$_DFFE_PP_ clknet_leaf_12_clk net18 _0015_
+ VSS VSS VDD VDD mem\[8\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[24\]$_DFFE_PP_ clknet_leaf_12_clk net19 _0015_
+ VSS VSS VDD VDD mem\[8\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[25\]$_DFFE_PP_ clknet_leaf_19_clk net20 _0015_
+ VSS VSS VDD VDD mem\[8\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk net21 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[27\]$_DFFE_PP_ clknet_leaf_18_clk net22 _0015_
+ VSS VSS VDD VDD mem\[8\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[28\]$_DFFE_PP_ clknet_leaf_21_clk net23 _0015_
+ VSS VSS VDD VDD mem\[8\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[29\]$_DFFE_PP_ clknet_leaf_31_clk net24 _0015_
+ VSS VSS VDD VDD mem\[8\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[2\]$_DFFE_PP_ clknet_leaf_26_clk net25 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[30\]$_DFFE_PP_ clknet_leaf_22_clk net26 _0015_
+ VSS VSS VDD VDD mem\[8\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[31\]$_DFFE_PP_ clknet_leaf_22_clk net27 _0015_
+ VSS VSS VDD VDD mem\[8\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[3\]$_DFFE_PP_ clknet_leaf_31_clk net28 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[4\]$_DFFE_PP_ clknet_leaf_33_clk net29 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[5\]$_DFFE_PP_ clknet_leaf_21_clk net30 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[6\]$_DFFE_PP_ clknet_leaf_32_clk net31 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[7\]$_DFFE_PP_ clknet_leaf_33_clk net32 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[8\]$_DFFE_PP_ clknet_leaf_43_clk net33 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[9\]$_DFFE_PP_ clknet_leaf_47_clk net34 _0015_ VSS
+ VSS VDD VDD mem\[8\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[0\]$_DFFE_PP_ clknet_leaf_6_clk net3 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[10\]$_DFFE_PP_ clknet_leaf_41_clk net4 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk net5 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[12\]$_DFFE_PP_ clknet_leaf_40_clk net6 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[13\]$_DFFE_PP_ clknet_leaf_48_clk net7 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[14\]$_DFFE_PP_ clknet_leaf_48_clk net8 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[15\]$_DFFE_PP_ clknet_leaf_50_clk net9 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[16\]$_DFFE_PP_ clknet_leaf_51_clk net10 _0016_
+ VSS VSS VDD VDD mem\[9\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[17\]$_DFFE_PP_ clknet_leaf_51_clk net11 _0016_
+ VSS VSS VDD VDD mem\[9\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[18\]$_DFFE_PP_ clknet_leaf_2_clk net12 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[19\]$_DFFE_PP_ clknet_leaf_2_clk net13 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[1\]$_DFFE_PP_ clknet_leaf_3_clk net14 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[20\]$_DFFE_PP_ clknet_leaf_10_clk net15 _0016_
+ VSS VSS VDD VDD mem\[9\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[21\]$_DFFE_PP_ clknet_leaf_10_clk net16 _0016_
+ VSS VSS VDD VDD mem\[9\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[22\]$_DFFE_PP_ clknet_leaf_13_clk net17 _0016_
+ VSS VSS VDD VDD mem\[9\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[23\]$_DFFE_PP_ clknet_leaf_13_clk net18 _0016_
+ VSS VSS VDD VDD mem\[9\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[24\]$_DFFE_PP_ clknet_leaf_12_clk net19 _0016_
+ VSS VSS VDD VDD mem\[9\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[25\]$_DFFE_PP_ clknet_leaf_19_clk net20 _0016_
+ VSS VSS VDD VDD mem\[9\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk net21 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[27\]$_DFFE_PP_ clknet_leaf_18_clk net22 _0016_
+ VSS VSS VDD VDD mem\[9\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[28\]$_DFFE_PP_ clknet_leaf_19_clk net23 _0016_
+ VSS VSS VDD VDD mem\[9\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[29\]$_DFFE_PP_ clknet_leaf_31_clk net24 _0016_
+ VSS VSS VDD VDD mem\[9\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[2\]$_DFFE_PP_ clknet_leaf_26_clk net25 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[30\]$_DFFE_PP_ clknet_leaf_22_clk net26 _0016_
+ VSS VSS VDD VDD mem\[9\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[31\]$_DFFE_PP_ clknet_leaf_22_clk net27 _0016_
+ VSS VSS VDD VDD mem\[9\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[3\]$_DFFE_PP_ clknet_leaf_31_clk net28 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[4\]$_DFFE_PP_ clknet_leaf_32_clk net29 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[5\]$_DFFE_PP_ clknet_leaf_21_clk net30 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[6\]$_DFFE_PP_ clknet_leaf_32_clk net31 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[7\]$_DFFE_PP_ clknet_leaf_34_clk net32 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[8\]$_DFFE_PP_ clknet_leaf_43_clk net33 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[9\]$_DFFE_PP_ clknet_leaf_45_clk net34 _0016_ VSS
+ VSS VDD VDD mem\[9\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xrd_ptr\[0\]$_DFFE_PN0P_ clknet_leaf_41_clk _0070_ net1 VSS
+ VSS VDD VDD rd_ptr\[0\] sky130_fd_sc_hd__dfrtp_4
Xrd_ptr\[1\]$_DFFE_PN0P_ clknet_leaf_43_clk _0071_ net1 VSS
+ VSS VDD VDD rd_ptr\[1\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[2\]$_DFFE_PN0P_ clknet_leaf_44_clk _0072_ net1 VSS
+ VSS VDD VDD rd_ptr\[2\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[3\]$_DFFE_PN0P_ clknet_leaf_37_clk _0073_ net1 VSS
+ VSS VDD VDD rd_ptr\[3\] sky130_fd_sc_hd__dfrtp_4
Xrd_ptr\[4\]$_DFFE_PN0P_ clknet_leaf_37_clk _0074_ net1 VSS
+ VSS VDD VDD rd_ptr\[4\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[0\]$_DFFE_PN0P_ clknet_leaf_39_clk _0075_ net1 VSS
+ VSS VDD VDD wr_ptr\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[1\]$_DFFE_PN0P_ clknet_leaf_39_clk _0076_ net1 VSS
+ VSS VDD VDD wr_ptr\[1\] sky130_fd_sc_hd__dfrtp_2
Xwr_ptr\[2\]$_DFFE_PN0P_ clknet_leaf_38_clk _0077_ net1 VSS
+ VSS VDD VDD wr_ptr\[2\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[3\]$_DFFE_PN0P_ clknet_leaf_38_clk _0078_ net1 VSS
+ VSS VDD VDD wr_ptr\[3\] sky130_fd_sc_hd__dfrtp_4
Xwr_ptr\[4\]$_DFFE_PN0P_ clknet_leaf_38_clk _0079_ net1 VSS
+ VSS VDD VDD wr_ptr\[4\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net98 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_16
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 net99 VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 net105 VSS VSS VDD VDD net3 sky130_fd_sc_hd__buf_4
Xinput3 net122 VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_4
Xinput4 net129 VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_4
Xinput5 net118 VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_4
Xinput6 net115 VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_4
Xinput7 net119 VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_4
Xinput8 net123 VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_4
Xinput9 net102 VSS VSS VDD VDD net10 sky130_fd_sc_hd__buf_4
Xinput10 net124 VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_4
Xinput11 net125 VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_4
Xinput12 net127 VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_4
Xinput13 net112 VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_4
Xinput14 net114 VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_4
Xinput15 net109 VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_4
Xinput16 net108 VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_4
Xinput17 net117 VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_4
Xinput18 net101 VSS VSS VDD VDD net19 sky130_fd_sc_hd__buf_4
Xinput19 net100 VSS VSS VDD VDD net20 sky130_fd_sc_hd__buf_4
Xinput20 net103 VSS VSS VDD VDD net21 sky130_fd_sc_hd__buf_4
Xinput21 net106 VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_4
Xinput22 net113 VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_4
Xinput23 net104 VSS VSS VDD VDD net24 sky130_fd_sc_hd__buf_4
Xinput24 net132 VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_4
Xinput25 net120 VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_4
Xinput26 net116 VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_4
Xinput27 net126 VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_4
Xinput28 net131 VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_4
Xinput29 net110 VSS VSS VDD VDD net30 sky130_fd_sc_hd__buf_4
Xinput30 net128 VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_4
Xinput31 net130 VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_4
Xinput32 net107 VSS VSS VDD VDD net33 sky130_fd_sc_hd__buf_4
Xinput33 net111 VSS VSS VDD VDD net34 sky130_fd_sc_hd__buf_4
Xinput34 net121 VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_2
Xoutput35 net36 VSS VSS VDD VDD almost_empty sky130_fd_sc_hd__clkbuf_1
Xoutput36 net37 VSS VSS VDD VDD almost_full sky130_fd_sc_hd__clkbuf_1
Xoutput37 net38 VSS VSS VDD VDD data_count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput38 net39 VSS VSS VDD VDD data_count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput39 net40 VSS VSS VDD VDD data_count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput40 net41 VSS VSS VDD VDD data_count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput41 net42 VSS VSS VDD VDD data_count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput42 net43 VSS VSS VDD VDD empty sky130_fd_sc_hd__clkbuf_1
Xoutput43 net44 VSS VSS VDD VDD error_count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput44 net45 VSS VSS VDD VDD error_count[10] sky130_fd_sc_hd__clkbuf_1
Xoutput45 net46 VSS VSS VDD VDD error_count[11] sky130_fd_sc_hd__clkbuf_1
Xoutput46 net47 VSS VSS VDD VDD error_count[12] sky130_fd_sc_hd__clkbuf_1
Xoutput47 net48 VSS VSS VDD VDD error_count[13] sky130_fd_sc_hd__clkbuf_1
Xoutput48 net49 VSS VSS VDD VDD error_count[14] sky130_fd_sc_hd__clkbuf_1
Xoutput49 net50 VSS VSS VDD VDD error_count[15] sky130_fd_sc_hd__clkbuf_1
Xoutput50 net51 VSS VSS VDD VDD error_count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput51 net52 VSS VSS VDD VDD error_count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput52 net53 VSS VSS VDD VDD error_count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput53 net54 VSS VSS VDD VDD error_count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput54 net55 VSS VSS VDD VDD error_count[5] sky130_fd_sc_hd__clkbuf_1
Xoutput55 net56 VSS VSS VDD VDD error_count[6] sky130_fd_sc_hd__clkbuf_1
Xoutput56 net57 VSS VSS VDD VDD error_count[7] sky130_fd_sc_hd__clkbuf_1
Xoutput57 net58 VSS VSS VDD VDD error_count[8] sky130_fd_sc_hd__clkbuf_1
Xoutput58 net59 VSS VSS VDD VDD error_count[9] sky130_fd_sc_hd__clkbuf_1
Xoutput59 net60 VSS VSS VDD VDD error_detected sky130_fd_sc_hd__clkbuf_1
Xoutput60 net61 VSS VSS VDD VDD full sky130_fd_sc_hd__clkbuf_1
Xoutput61 net62 VSS VSS VDD VDD overflow_detected sky130_fd_sc_hd__clkbuf_1
Xoutput62 net63 VSS VSS VDD VDD rd_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput63 net64 VSS VSS VDD VDD rd_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput64 net65 VSS VSS VDD VDD rd_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput65 net66 VSS VSS VDD VDD rd_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput66 net67 VSS VSS VDD VDD rd_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput67 net68 VSS VSS VDD VDD rd_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput68 net69 VSS VSS VDD VDD rd_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput69 net70 VSS VSS VDD VDD rd_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput70 net71 VSS VSS VDD VDD rd_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net72 VSS VSS VDD VDD rd_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net73 VSS VSS VDD VDD rd_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net74 VSS VSS VDD VDD rd_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net75 VSS VSS VDD VDD rd_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net76 VSS VSS VDD VDD rd_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net77 VSS VSS VDD VDD rd_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net78 VSS VSS VDD VDD rd_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net79 VSS VSS VDD VDD rd_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net80 VSS VSS VDD VDD rd_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net81 VSS VSS VDD VDD rd_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net82 VSS VSS VDD VDD rd_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net83 VSS VSS VDD VDD rd_data[28] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net84 VSS VSS VDD VDD rd_data[29] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net85 VSS VSS VDD VDD rd_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput85 net86 VSS VSS VDD VDD rd_data[30] sky130_fd_sc_hd__clkbuf_1
Xoutput86 net87 VSS VSS VDD VDD rd_data[31] sky130_fd_sc_hd__clkbuf_1
Xoutput87 net88 VSS VSS VDD VDD rd_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput88 net89 VSS VSS VDD VDD rd_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput89 net90 VSS VSS VDD VDD rd_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput90 net91 VSS VSS VDD VDD rd_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput91 net92 VSS VSS VDD VDD rd_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput92 net93 VSS VSS VDD VDD rd_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput93 net94 VSS VSS VDD VDD rd_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput94 net95 VSS VSS VDD VDD rd_valid sky130_fd_sc_hd__clkbuf_1
Xoutput95 net96 VSS VSS VDD VDD underflow_detected sky130_fd_sc_hd__clkbuf_1
Xoutput96 net97 VSS VSS VDD VDD wr_ready sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_0_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_1_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_1_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_2_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_2_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_3_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_3_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_4_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_4_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_5_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_5_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_6_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_6_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_7_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_7_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_8_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_8_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_9_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_9_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_10_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_10_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_11_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_11_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_12_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_12_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_13_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_13_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_14_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_14_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_15_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_15_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_16_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_16_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_17_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_17_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_18_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_18_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_19_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_19_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_20_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_20_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_21_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_21_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_22_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_22_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_23_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_23_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_24_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_24_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_25_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_25_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_26_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_26_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_27_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_27_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_28_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_28_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_29_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_29_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_30_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_30_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_31_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_31_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_32_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_32_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_33_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_33_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_34_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_34_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_35_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_35_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_36_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_36_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_37_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_37_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_38_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_38_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_39_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_39_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_40_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_40_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_41_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_41_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_42_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_42_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_43_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_43_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_44_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_44_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_45_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_45_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_46_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_46_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_47_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_47_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_48_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_48_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_49_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_49_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_50_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_50_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_51_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_51_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_2_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__inv_6
Xclkload1 clknet_2_2__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkinv_8
Xclkload2 clknet_2_3__leaf_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkinv_8
Xclkload3 clknet_leaf_0_clk VSS VSS VDD VDD _unconnected_3
+ sky130_fd_sc_hd__clkbuf_8
Xclkload4 clknet_leaf_1_clk VSS VSS VDD VDD _unconnected_4
+ sky130_fd_sc_hd__bufinv_16
Xclkload5 clknet_leaf_3_clk VSS VSS VDD VDD _unconnected_5
+ sky130_fd_sc_hd__bufinv_16
Xclkload6 clknet_leaf_4_clk VSS VSS VDD VDD _unconnected_6
+ sky130_fd_sc_hd__clkbuf_1
Xclkload7 clknet_leaf_5_clk VSS VSS VDD VDD _unconnected_7
+ sky130_fd_sc_hd__clkbuf_8
Xclkload8 clknet_leaf_45_clk VSS VSS VDD VDD _unconnected_8
+ sky130_fd_sc_hd__clkbuf_1
Xclkload9 clknet_leaf_46_clk VSS VSS VDD VDD _unconnected_9
+ sky130_fd_sc_hd__clkbuf_8
Xclkload10 clknet_leaf_47_clk VSS VSS VDD VDD _unconnected_10
+ sky130_fd_sc_hd__clkbuf_1
Xclkload11 clknet_leaf_48_clk VSS VSS VDD VDD _unconnected_11
+ sky130_fd_sc_hd__clkbuf_1
Xclkload12 clknet_leaf_49_clk VSS VSS VDD VDD _unconnected_12
+ sky130_fd_sc_hd__clkinv_2
Xclkload13 clknet_leaf_50_clk VSS VSS VDD VDD _unconnected_13
+ sky130_fd_sc_hd__clkbuf_1
Xclkload14 clknet_leaf_51_clk VSS VSS VDD VDD _unconnected_14
+ sky130_fd_sc_hd__clkbuf_8
Xclkload15 clknet_leaf_6_clk VSS VSS VDD VDD _unconnected_15
+ sky130_fd_sc_hd__clkbuf_1
Xclkload16 clknet_leaf_7_clk VSS VSS VDD VDD _unconnected_16
+ sky130_fd_sc_hd__clkbuf_1
Xclkload17 clknet_leaf_8_clk VSS VSS VDD VDD _unconnected_17
+ sky130_fd_sc_hd__clkbuf_8
Xclkload18 clknet_leaf_9_clk VSS VSS VDD VDD _unconnected_18
+ sky130_fd_sc_hd__clkinv_2
Xclkload19 clknet_leaf_11_clk VSS VSS VDD VDD _unconnected_19
+ sky130_fd_sc_hd__bufinv_16
Xclkload20 clknet_leaf_12_clk VSS VSS VDD VDD _unconnected_20
+ sky130_fd_sc_hd__clkinv_2
Xclkload21 clknet_leaf_13_clk VSS VSS VDD VDD _unconnected_21
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload22 clknet_leaf_14_clk VSS VSS VDD VDD _unconnected_22
+ sky130_fd_sc_hd__clkbuf_1
Xclkload23 clknet_leaf_15_clk VSS VSS VDD VDD _unconnected_23
+ sky130_fd_sc_hd__clkinv_1
Xclkload24 clknet_leaf_16_clk VSS VSS VDD VDD _unconnected_24
+ sky130_fd_sc_hd__clkbuf_1
Xclkload25 clknet_leaf_17_clk VSS VSS VDD VDD _unconnected_25
+ sky130_fd_sc_hd__bufinv_16
Xclkload26 clknet_leaf_18_clk VSS VSS VDD VDD _unconnected_26
+ sky130_fd_sc_hd__clkinv_2
Xclkload27 clknet_leaf_19_clk VSS VSS VDD VDD _unconnected_27
+ sky130_fd_sc_hd__clkinv_2
Xclkload28 clknet_leaf_20_clk VSS VSS VDD VDD _unconnected_28
+ sky130_fd_sc_hd__clkinv_2
Xclkload29 clknet_leaf_33_clk VSS VSS VDD VDD _unconnected_29
+ sky130_fd_sc_hd__clkinv_2
Xclkload30 clknet_leaf_34_clk VSS VSS VDD VDD _unconnected_30
+ sky130_fd_sc_hd__clkinv_1
Xclkload31 clknet_leaf_35_clk VSS VSS VDD VDD _unconnected_31
+ sky130_fd_sc_hd__clkinv_1
Xclkload32 clknet_leaf_36_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__clkinv_2
Xclkload33 clknet_leaf_37_clk VSS VSS VDD VDD _unconnected_33
+ sky130_fd_sc_hd__clkinv_2
Xclkload34 clknet_leaf_38_clk VSS VSS VDD VDD _unconnected_34
+ sky130_fd_sc_hd__bufinv_16
Xclkload35 clknet_leaf_39_clk VSS VSS VDD VDD _unconnected_35
+ sky130_fd_sc_hd__bufinv_16
Xclkload36 clknet_leaf_40_clk VSS VSS VDD VDD _unconnected_36
+ sky130_fd_sc_hd__clkbuf_1
Xclkload37 clknet_leaf_41_clk VSS VSS VDD VDD _unconnected_37
+ sky130_fd_sc_hd__clkbuf_1
Xclkload38 clknet_leaf_43_clk VSS VSS VDD VDD _unconnected_38
+ sky130_fd_sc_hd__clkinv_1
Xclkload39 clknet_leaf_44_clk VSS VSS VDD VDD _unconnected_39
+ sky130_fd_sc_hd__clkinv_1
Xclkload40 clknet_leaf_21_clk VSS VSS VDD VDD _unconnected_40
+ sky130_fd_sc_hd__bufinv_16
Xclkload41 clknet_leaf_22_clk VSS VSS VDD VDD _unconnected_41
+ sky130_fd_sc_hd__clkinv_2
Xclkload42 clknet_leaf_23_clk VSS VSS VDD VDD _unconnected_42
+ sky130_fd_sc_hd__bufinv_16
Xclkload43 clknet_leaf_24_clk VSS VSS VDD VDD _unconnected_43
+ sky130_fd_sc_hd__bufinv_16
Xclkload44 clknet_leaf_25_clk VSS VSS VDD VDD _unconnected_44
+ sky130_fd_sc_hd__clkinv_1
Xclkload45 clknet_leaf_26_clk VSS VSS VDD VDD _unconnected_45
+ sky130_fd_sc_hd__clkbuf_8
Xclkload46 clknet_leaf_27_clk VSS VSS VDD VDD _unconnected_46
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload47 clknet_leaf_29_clk VSS VSS VDD VDD _unconnected_47
+ sky130_fd_sc_hd__clkbuf_1
Xclkload48 clknet_leaf_30_clk VSS VSS VDD VDD _unconnected_48
+ sky130_fd_sc_hd__clkinv_2
Xclkload49 clknet_leaf_31_clk VSS VSS VDD VDD _unconnected_49
+ sky130_fd_sc_hd__clkbuf_1
Xclkload50 clknet_leaf_32_clk VSS VSS VDD VDD _unconnected_50
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net98 sky130_fd_sc_hd__dlygate4sd3_1
Xhold3 clear_errors VSS VSS VDD VDD net99 sky130_fd_sc_hd__dlygate4sd3_1
Xhold4 wr_data[25] VSS VSS VDD VDD net100 sky130_fd_sc_hd__dlygate4sd3_1
Xhold5 wr_data[24] VSS VSS VDD VDD net101 sky130_fd_sc_hd__dlygate4sd3_1
Xhold6 wr_data[16] VSS VSS VDD VDD net102 sky130_fd_sc_hd__dlygate4sd3_1
Xhold7 wr_data[26] VSS VSS VDD VDD net103 sky130_fd_sc_hd__dlygate4sd3_1
Xhold8 wr_data[29] VSS VSS VDD VDD net104 sky130_fd_sc_hd__dlygate4sd3_1
Xhold9 wr_data[0] VSS VSS VDD VDD net105 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 wr_data[27] VSS VSS VDD VDD net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 wr_data[8] VSS VSS VDD VDD net107 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 wr_data[22] VSS VSS VDD VDD net108 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 wr_data[21] VSS VSS VDD VDD net109 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 wr_data[5] VSS VSS VDD VDD net110 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 wr_data[9] VSS VSS VDD VDD net111 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 wr_data[1] VSS VSS VDD VDD net112 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 wr_data[28] VSS VSS VDD VDD net113 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 wr_data[20] VSS VSS VDD VDD net114 sky130_fd_sc_hd__dlygate4sd3_1
Xhold19 wr_data[13] VSS VSS VDD VDD net115 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 wr_data[31] VSS VSS VDD VDD net116 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 wr_data[23] VSS VSS VDD VDD net117 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 wr_data[12] VSS VSS VDD VDD net118 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 wr_data[14] VSS VSS VDD VDD net119 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 wr_data[30] VSS VSS VDD VDD net120 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 wr_en VSS VSS VDD VDD net121 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 wr_data[10] VSS VSS VDD VDD net122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 wr_data[15] VSS VSS VDD VDD net123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 wr_data[17] VSS VSS VDD VDD net124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 wr_data[18] VSS VSS VDD VDD net125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 wr_data[3] VSS VSS VDD VDD net126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 wr_data[19] VSS VSS VDD VDD net127 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 wr_data[6] VSS VSS VDD VDD net128 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 wr_data[11] VSS VSS VDD VDD net129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 wr_data[7] VSS VSS VDD VDD net130 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 wr_data[4] VSS VSS VDD VDD net131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 wr_data[2] VSS VSS VDD VDD net132 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 rd_en VSS VSS VDD VDD net133 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS smart_fifo
