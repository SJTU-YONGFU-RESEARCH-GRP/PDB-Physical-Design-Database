* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT mesh_router clk east_in_data[0] east_in_data[10] east_in_data[11]
+ east_in_data[12] east_in_data[13] east_in_data[14] east_in_data[15]
+ east_in_data[16] east_in_data[17] east_in_data[18] east_in_data[19]
+ east_in_data[1] east_in_data[20] east_in_data[21] east_in_data[22]
+ east_in_data[23] east_in_data[24] east_in_data[25] east_in_data[26]
+ east_in_data[27] east_in_data[28] east_in_data[29] east_in_data[2]
+ east_in_data[30] east_in_data[31] east_in_data[3] east_in_data[4]
+ east_in_data[5] east_in_data[6] east_in_data[7] east_in_data[8]
+ east_in_data[9] east_in_ready east_in_valid east_out_data[0]
+ east_out_data[10] east_out_data[11] east_out_data[12] east_out_data[13]
+ east_out_data[14] east_out_data[15] east_out_data[16] east_out_data[17]
+ east_out_data[18] east_out_data[19] east_out_data[1] east_out_data[20]
+ east_out_data[21] east_out_data[22] east_out_data[23] east_out_data[24]
+ east_out_data[25] east_out_data[26] east_out_data[27] east_out_data[28]
+ east_out_data[29] east_out_data[2] east_out_data[30] east_out_data[31]
+ east_out_data[3] east_out_data[4] east_out_data[5] east_out_data[6]
+ east_out_data[7] east_out_data[8] east_out_data[9] east_out_ready
+ east_out_valid local_in_data[0] local_in_data[10] local_in_data[11]
+ local_in_data[12] local_in_data[13] local_in_data[14] local_in_data[15]
+ local_in_data[16] local_in_data[17] local_in_data[18] local_in_data[19]
+ local_in_data[1] local_in_data[20] local_in_data[21] local_in_data[22]
+ local_in_data[23] local_in_data[24] local_in_data[25] local_in_data[26]
+ local_in_data[27] local_in_data[28] local_in_data[29] local_in_data[2]
+ local_in_data[30] local_in_data[31] local_in_data[3] local_in_data[4]
+ local_in_data[5] local_in_data[6] local_in_data[7] local_in_data[8]
+ local_in_data[9] local_in_ready local_in_valid local_out_data[0]
+ local_out_data[10] local_out_data[11] local_out_data[12] local_out_data[13]
+ local_out_data[14] local_out_data[15] local_out_data[16] local_out_data[17]
+ local_out_data[18] local_out_data[19] local_out_data[1] local_out_data[20]
+ local_out_data[21] local_out_data[22] local_out_data[23] local_out_data[24]
+ local_out_data[25] local_out_data[26] local_out_data[27] local_out_data[28]
+ local_out_data[29] local_out_data[2] local_out_data[30] local_out_data[31]
+ local_out_data[3] local_out_data[4] local_out_data[5] local_out_data[6]
+ local_out_data[7] local_out_data[8] local_out_data[9] local_out_ready
+ local_out_valid north_in_data[0] north_in_data[10] north_in_data[11]
+ north_in_data[12] north_in_data[13] north_in_data[14] north_in_data[15]
+ north_in_data[16] north_in_data[17] north_in_data[18] north_in_data[19]
+ north_in_data[1] north_in_data[20] north_in_data[21] north_in_data[22]
+ north_in_data[23] north_in_data[24] north_in_data[25] north_in_data[26]
+ north_in_data[27] north_in_data[28] north_in_data[29] north_in_data[2]
+ north_in_data[30] north_in_data[31] north_in_data[3] north_in_data[4]
+ north_in_data[5] north_in_data[6] north_in_data[7] north_in_data[8]
+ north_in_data[9] north_in_ready north_in_valid north_out_data[0]
+ north_out_data[10] north_out_data[11] north_out_data[12] north_out_data[13]
+ north_out_data[14] north_out_data[15] north_out_data[16] north_out_data[17]
+ north_out_data[18] north_out_data[19] north_out_data[1] north_out_data[20]
+ north_out_data[21] north_out_data[22] north_out_data[23] north_out_data[24]
+ north_out_data[25] north_out_data[26] north_out_data[27] north_out_data[28]
+ north_out_data[29] north_out_data[2] north_out_data[30] north_out_data[31]
+ north_out_data[3] north_out_data[4] north_out_data[5] north_out_data[6]
+ north_out_data[7] north_out_data[8] north_out_data[9] north_out_ready
+ north_out_valid rst_n south_in_data[0] south_in_data[10] south_in_data[11]
+ south_in_data[12] south_in_data[13] south_in_data[14] south_in_data[15]
+ south_in_data[16] south_in_data[17] south_in_data[18] south_in_data[19]
+ south_in_data[1] south_in_data[20] south_in_data[21] south_in_data[22]
+ south_in_data[23] south_in_data[24] south_in_data[25] south_in_data[26]
+ south_in_data[27] south_in_data[28] south_in_data[29] south_in_data[2]
+ south_in_data[30] south_in_data[31] south_in_data[3] south_in_data[4]
+ south_in_data[5] south_in_data[6] south_in_data[7] south_in_data[8]
+ south_in_data[9] south_in_ready south_in_valid south_out_data[0]
+ south_out_data[10] south_out_data[11] south_out_data[12] south_out_data[13]
+ south_out_data[14] south_out_data[15] south_out_data[16] south_out_data[17]
+ south_out_data[18] south_out_data[19] south_out_data[1] south_out_data[20]
+ south_out_data[21] south_out_data[22] south_out_data[23] south_out_data[24]
+ south_out_data[25] south_out_data[26] south_out_data[27] south_out_data[28]
+ south_out_data[29] south_out_data[2] south_out_data[30] south_out_data[31]
+ south_out_data[3] south_out_data[4] south_out_data[5] south_out_data[6]
+ south_out_data[7] south_out_data[8] south_out_data[9] south_out_ready
+ south_out_valid west_in_data[0] west_in_data[10] west_in_data[11]
+ west_in_data[12] west_in_data[13] west_in_data[14] west_in_data[15]
+ west_in_data[16] west_in_data[17] west_in_data[18] west_in_data[19]
+ west_in_data[1] west_in_data[20] west_in_data[21] west_in_data[22]
+ west_in_data[23] west_in_data[24] west_in_data[25] west_in_data[26]
+ west_in_data[27] west_in_data[28] west_in_data[29] west_in_data[2]
+ west_in_data[30] west_in_data[31] west_in_data[3] west_in_data[4]
+ west_in_data[5] west_in_data[6] west_in_data[7] west_in_data[8]
+ west_in_data[9] west_in_ready west_in_valid west_out_data[0]
+ west_out_data[10] west_out_data[11] west_out_data[12] west_out_data[13]
+ west_out_data[14] west_out_data[15] west_out_data[16] west_out_data[17]
+ west_out_data[18] west_out_data[19] west_out_data[1] west_out_data[20]
+ west_out_data[21] west_out_data[22] west_out_data[23] west_out_data[24]
+ west_out_data[25] west_out_data[26] west_out_data[27] west_out_data[28]
+ west_out_data[29] west_out_data[2] west_out_data[30] west_out_data[31]
+ west_out_data[3] west_out_data[4] west_out_data[5] west_out_data[6]
+ west_out_data[7] west_out_data[8] west_out_data[9] west_out_ready
+ west_out_valid
X_1606_ dest_id\[4\]\[5\] dest_id\[4\]\[4\] dest_id\[4\]\[7\]
+ dest_id\[4\]\[6\] _1274_ VDD VSS OR4_X2
X_1607_ _1274_ _1275_ VDD VSS BUF_X8
X_1608_ _1275_ _1276_ VDD VSS INV_X1
X_1609_ dest_id\[4\]\[0\] _1277_ VDD VSS BUF_X4
X_1610_ _1277_ _1278_ VDD VSS INV_X2
X_1611_ dest_id\[4\]\[1\] _1279_ VDD VSS CLKBUF_X3
X_1612_ dest_id\[4\]\[2\] _1280_ VDD VSS CLKBUF_X3
X_1613_ _1278_ _1279_ _1280_ _1281_ VDD VSS NOR3_X4
X_1614_ dest_id\[4\]\[3\] _1282_ VDD VSS BUF_X4
X_1615_ _1280_ _1283_ VDD VSS INV_X2
X_1616_ _1277_ _1282_ _1283_ _1284_ VDD VSS NOR3_X4
X_1617_ _1276_ _1281_ _1284_ _1285_ VDD VSS OAI21_X4
X_1618_ _1285_ _1603_ VDD VSS INV_X4
X_1619_ _1275_ _1282_ _1283_ _1277_ _1592_ VDD VSS NOR4_X4
X_1620_ _1592_ _1595_ VDD VSS INV_X1
X_1621_ _1279_ _1275_ _1286_ VDD VSS NOR2_X1
X_1622_ _1282_ _1287_ VDD VSS INV_X2
X_1623_ _1278_ _1287_ _1280_ _1288_ VDD VSS NOR3_X1
X_1624_ _1286_ _1288_ _1284_ _1591_ VDD VSS OAI21_X2
X_1625_ _1591_ _1598_ VDD VSS INV_X1
X_1626_ dest_id\[3\]\[5\] _1289_ VDD VSS BUF_X2
X_1627_ dest_id\[3\]\[4\] _1290_ VDD VSS BUF_X2
X_1628_ dest_id\[3\]\[7\] _1291_ VDD VSS BUF_X2
X_1629_ dest_id\[3\]\[6\] _1292_ VDD VSS BUF_X2
X_1630_ _1289_ _1290_ _1291_ _1292_ _1293_ VDD VSS NOR4_X4
X_1631_ dest_id\[3\]\[0\] _1294_ VDD VSS INV_X1
X_1632_ dest_id\[3\]\[2\] _1295_ VDD VSS BUF_X4
X_1633_ _1294_ dest_id\[3\]\[1\] _1295_ _1296_ VDD VSS NOR3_X4
X_1634_ _1295_ _1297_ VDD VSS INV_X2
X_1635_ dest_id\[3\]\[0\] dest_id\[3\]\[3\] _1297_ _1298_
+ VDD VSS NOR3_X4
X_1636_ _1293_ _1296_ _1298_ _1299_ VDD VSS OAI21_X4
X_1637_ _1299_ _1588_ VDD VSS INV_X2
X_1638_ dest_id\[3\]\[0\] _1300_ VDD VSS CLKBUF_X3
X_1639_ _1300_ _1297_ _1301_ VDD VSS NOR2_X1
X_1640_ dest_id\[3\]\[3\] _1302_ VDD VSS BUF_X4
X_1641_ _1289_ _1290_ _1291_ _1292_ _1303_ VDD VSS OR4_X4
X_1642_ _1302_ _1303_ _1304_ VDD VSS NOR2_X2
X_1643_ _1301_ _1304_ _1580_ VDD VSS NAND2_X2
X_1644_ dest_id\[3\]\[1\] _1305_ VDD VSS CLKBUF_X3
X_1645_ _1305_ _1303_ _1306_ VDD VSS OR2_X1
X_1646_ _1300_ _1302_ _1297_ _1307_ VDD VSS NAND3_X1
X_1647_ _1300_ dest_id\[3\]\[3\] _1297_ _1308_ VDD VSS OR3_X2
X_1648_ _1306_ _1307_ _1308_ _1583_ VDD VSS AOI21_X2
X_1649_ dest_id\[2\]\[5\] _1309_ VDD VSS BUF_X2
X_1650_ dest_id\[2\]\[4\] _1310_ VDD VSS BUF_X2
X_1651_ dest_id\[2\]\[7\] _1311_ VDD VSS BUF_X2
X_1652_ dest_id\[2\]\[6\] _1312_ VDD VSS BUF_X2
X_1653_ _1309_ _1310_ _1311_ _1312_ _1313_ VDD VSS NOR4_X4
X_1654_ dest_id\[2\]\[0\] _1314_ VDD VSS BUF_X4
X_1655_ _1314_ _1315_ VDD VSS INV_X2
X_1656_ dest_id\[2\]\[1\] _1316_ VDD VSS BUF_X4
X_1657_ dest_id\[2\]\[2\] _1317_ VDD VSS BUF_X4
X_1658_ _1315_ _1316_ _1317_ _1318_ VDD VSS NOR3_X4
X_1659_ dest_id\[2\]\[3\] _1319_ VDD VSS BUF_X4
X_1660_ _1317_ _1320_ VDD VSS INV_X2
X_1661_ _1314_ _1319_ _1320_ _1321_ VDD VSS NOR3_X4
X_1662_ _1313_ _1318_ _1321_ _1322_ VDD VSS OAI21_X4
X_1663_ _1322_ _1573_ VDD VSS INV_X2
X_1664_ _1309_ _1310_ _1311_ _1312_ _1323_ VDD VSS OR4_X4
X_1665_ _1323_ _1319_ _1320_ _1314_ _1562_ VDD VSS NOR4_X4
X_1666_ _1562_ _1565_ VDD VSS INV_X1
X_1667_ _1316_ _1323_ _1324_ VDD VSS OR2_X2
X_1668_ _1314_ _1319_ _1320_ _1325_ VDD VSS NAND3_X2
X_1669_ _1319_ _1326_ VDD VSS INV_X2
X_1670_ _1315_ _1326_ _1317_ _1327_ VDD VSS NAND3_X4
X_1671_ _1324_ _1325_ _1327_ _1568_ VDD VSS AOI21_X4
X_1672_ dest_id\[1\]\[5\] _1328_ VDD VSS BUF_X2
X_1673_ dest_id\[1\]\[4\] _1329_ VDD VSS BUF_X2
X_1674_ dest_id\[1\]\[7\] _1330_ VDD VSS BUF_X2
X_1675_ dest_id\[1\]\[6\] _1331_ VDD VSS BUF_X2
X_1676_ _1328_ _1329_ _1330_ _1331_ _1332_ VDD VSS NOR4_X4
X_1677_ dest_id\[1\]\[0\] _1333_ VDD VSS BUF_X4
X_1678_ _1333_ _1334_ VDD VSS INV_X2
X_1679_ dest_id\[1\]\[1\] _1335_ VDD VSS CLKBUF_X3
X_1680_ dest_id\[1\]\[2\] _1336_ VDD VSS BUF_X4
X_1681_ _1334_ _1335_ _1336_ _1337_ VDD VSS NOR3_X4
X_1682_ dest_id\[1\]\[3\] _1338_ VDD VSS CLKBUF_X3
X_1683_ _1336_ _1339_ VDD VSS INV_X2
X_1684_ _1339_ _1338_ _1333_ _1340_ VDD VSS NOR3_X4
X_1685_ _1332_ _1337_ _1340_ _1341_ VDD VSS OAI21_X4
X_1686_ _1341_ _1342_ VDD VSS INV_X4
X_1687_ _1342_ _1558_ VDD VSS BUF_X4
X_1688_ _1333_ _1339_ _1343_ VDD VSS NOR2_X1
X_1689_ _1328_ _1329_ _1330_ _1331_ _1344_ VDD VSS OR4_X4
X_1690_ _1338_ _1344_ _1345_ VDD VSS NOR2_X4
X_1691_ _1343_ _1345_ _1547_ VDD VSS AND2_X4
X_1692_ _1547_ _1550_ VDD VSS INV_X1
X_1693_ _1335_ _1344_ _1346_ VDD VSS NOR2_X1
X_1694_ _1338_ _1347_ VDD VSS INV_X2
X_1695_ _1334_ _1347_ _1336_ _1348_ VDD VSS NOR3_X2
X_1696_ _1346_ _1348_ _1340_ _1546_ VDD VSS OAI21_X2
X_1697_ _1546_ _1553_ VDD VSS INV_X1
X_1698_ dest_id\[0\]\[3\] _1349_ VDD VSS BUF_X2
X_1699_ dest_id\[0\]\[2\] _1350_ VDD VSS INV_X1
X_1700_ dest_id\[0\]\[0\] _1349_ _1350_ _1351_ VDD VSS NOR3_X4
X_1701_ dest_id\[0\]\[0\] _1352_ VDD VSS INV_X1
X_1702_ _1349_ _1353_ VDD VSS INV_X1
X_1703_ _1352_ _1353_ dest_id\[0\]\[2\] _1354_ VDD VSS NOR3_X2
X_1704_ _1351_ _1354_ _1355_ VDD VSS NOR2_X1
X_1705_ dest_id\[0\]\[5\] dest_id\[0\]\[4\] dest_id\[0\]\[7\]
+ dest_id\[0\]\[6\] _1356_ VDD VSS OR4_X1
X_1706_ dest_id\[0\]\[1\] _1355_ _1356_ _1532_ VDD VSS OR3_X2
X_1707_ _1532_ _1535_ VDD VSS INV_X1
X_1708_ dest_id\[0\]\[0\] _1350_ _1357_ VDD VSS NOR2_X1
X_1709_ _1349_ _1356_ _1358_ VDD VSS NOR2_X1
X_1710_ _1357_ _1358_ _1531_ VDD VSS AND2_X1
X_1711_ _1531_ _1538_ VDD VSS INV_X1
X_1712_ _1568_ _1561_ VDD VSS INV_X1
X_1713_ _1583_ _1576_ VDD VSS INV_X1
X_1714_ dest_id\[0\]\[5\] dest_id\[0\]\[4\] dest_id\[0\]\[7\]
+ dest_id\[0\]\[6\] _1359_ VDD VSS NOR4_X4
X_1715_ _1352_ dest_id\[0\]\[1\] dest_id\[0\]\[2\] _1360_
+ VDD VSS NOR3_X4
X_1716_ _1359_ _1360_ _1351_ _1361_ VDD VSS OAI21_X4
X_1717_ _1361_ _1362_ VDD VSS INV_X2
X_1718_ _1362_ _1543_ VDD VSS BUF_X4
X_1719_ _1580_ _1577_ VDD VSS INV_X1
X_1720_ rst_n _1363_ VDD VSS BUF_X4
X_1721_ input_buffer_valid\[0\] _1364_ VDD VSS CLKBUF_X3
X_1722_ _1364_ _1365_ VDD VSS INV_X4
X_1723_ _1365_ _1366_ VDD VSS BUF_X4
X_1724_ _1366_ _1367_ VDD VSS BUF_X8
X_1725_ _1363_ _1367_ net100 _1368_ VDD VSS NAND3_X2
X_1726_ _1368_ _1369_ VDD VSS CLKBUF_X3
X_1727_ net68 input_buffer\[0\]\[0\] _1369_ _0032_ VDD VSS
+ MUX2_X1
X_1728_ net69 input_buffer\[0\]\[10\] _1369_ _0033_ VDD VSS
+ MUX2_X1
X_1729_ net70 input_buffer\[0\]\[11\] _1369_ _0034_ VDD VSS
+ MUX2_X1
X_1730_ net71 input_buffer\[0\]\[12\] _1369_ _0035_ VDD VSS
+ MUX2_X1
X_1731_ net72 input_buffer\[0\]\[13\] _1369_ _0036_ VDD VSS
+ MUX2_X1
X_1732_ net73 input_buffer\[0\]\[14\] _1369_ _0037_ VDD VSS
+ MUX2_X1
X_1733_ net74 input_buffer\[0\]\[15\] _1369_ _0038_ VDD VSS
+ MUX2_X1
X_1734_ net75 input_buffer\[0\]\[16\] _1369_ _0039_ VDD VSS
+ MUX2_X1
X_1735_ net76 input_buffer\[0\]\[17\] _1369_ _0040_ VDD VSS
+ MUX2_X1
X_1736_ net77 input_buffer\[0\]\[18\] _1369_ _0041_ VDD VSS
+ MUX2_X1
X_1737_ _1368_ _1370_ VDD VSS CLKBUF_X3
X_1738_ net78 input_buffer\[0\]\[19\] _1370_ _0042_ VDD VSS
+ MUX2_X1
X_1739_ net79 input_buffer\[0\]\[1\] _1370_ _0043_ VDD VSS
+ MUX2_X1
X_1740_ net80 input_buffer\[0\]\[20\] _1370_ _0044_ VDD VSS
+ MUX2_X1
X_1741_ net81 input_buffer\[0\]\[21\] _1370_ _0045_ VDD VSS
+ MUX2_X1
X_1742_ net82 input_buffer\[0\]\[22\] _1370_ _0046_ VDD VSS
+ MUX2_X1
X_1743_ net83 input_buffer\[0\]\[23\] _1370_ _0047_ VDD VSS
+ MUX2_X1
X_1744_ net84 dest_id\[0\]\[0\] _1370_ _0048_ VDD VSS MUX2_X1
X_1745_ net85 dest_id\[0\]\[1\] _1370_ _0049_ VDD VSS MUX2_X1
X_1746_ net86 dest_id\[0\]\[2\] _1370_ _0050_ VDD VSS MUX2_X1
X_1747_ net87 _1349_ _1370_ _0051_ VDD VSS MUX2_X1
X_1748_ _1368_ _1371_ VDD VSS CLKBUF_X3
X_1749_ net88 dest_id\[0\]\[4\] _1371_ _0052_ VDD VSS MUX2_X1
X_1750_ net89 dest_id\[0\]\[5\] _1371_ _0053_ VDD VSS MUX2_X1
X_1751_ net90 input_buffer\[0\]\[2\] _1371_ _0054_ VDD VSS
+ MUX2_X1
X_1752_ net91 dest_id\[0\]\[6\] _1371_ _0055_ VDD VSS MUX2_X1
X_1753_ net92 dest_id\[0\]\[7\] _1371_ _0056_ VDD VSS MUX2_X1
X_1754_ net93 input_buffer\[0\]\[3\] _1371_ _0057_ VDD VSS
+ MUX2_X1
X_1755_ net94 input_buffer\[0\]\[4\] _1371_ _0058_ VDD VSS
+ MUX2_X1
X_1756_ net95 input_buffer\[0\]\[5\] _1371_ _0059_ VDD VSS
+ MUX2_X1
X_1757_ net96 input_buffer\[0\]\[6\] _1371_ _0060_ VDD VSS
+ MUX2_X1
X_1758_ net97 input_buffer\[0\]\[7\] _1371_ _0061_ VDD VSS
+ MUX2_X1
X_1759_ net98 input_buffer\[0\]\[8\] _1368_ _0062_ VDD VSS
+ MUX2_X1
X_1760_ net99 input_buffer\[0\]\[9\] _1368_ _0063_ VDD VSS
+ MUX2_X1
X_1761_ input_buffer_valid\[1\] _1372_ VDD VSS CLKBUF_X3
X_1762_ _1372_ _1373_ VDD VSS CLKBUF_X3
X_1763_ _1373_ _1374_ VDD VSS INV_X2
X_1764_ _1363_ _1374_ net33 _1375_ VDD VSS NAND3_X2
X_1765_ _1375_ _1376_ VDD VSS CLKBUF_X3
X_1766_ net1 input_buffer\[1\]\[0\] _1376_ _0064_ VDD VSS
+ MUX2_X1
X_1767_ net2 input_buffer\[1\]\[10\] _1376_ _0065_ VDD VSS
+ MUX2_X1
X_1768_ net3 input_buffer\[1\]\[11\] _1376_ _0066_ VDD VSS
+ MUX2_X1
X_1769_ net4 input_buffer\[1\]\[12\] _1376_ _0067_ VDD VSS
+ MUX2_X1
X_1770_ net5 input_buffer\[1\]\[13\] _1376_ _0068_ VDD VSS
+ MUX2_X1
X_1771_ net6 input_buffer\[1\]\[14\] _1376_ _0069_ VDD VSS
+ MUX2_X1
X_1772_ net7 input_buffer\[1\]\[15\] _1376_ _0070_ VDD VSS
+ MUX2_X1
X_1773_ net8 input_buffer\[1\]\[16\] _1376_ _0071_ VDD VSS
+ MUX2_X1
X_1774_ net9 input_buffer\[1\]\[17\] _1376_ _0072_ VDD VSS
+ MUX2_X1
X_1775_ net10 input_buffer\[1\]\[18\] _1376_ _0073_ VDD VSS
+ MUX2_X1
X_1776_ _1375_ _1377_ VDD VSS CLKBUF_X3
X_1777_ net11 input_buffer\[1\]\[19\] _1377_ _0074_ VDD VSS
+ MUX2_X1
X_1778_ net12 input_buffer\[1\]\[1\] _1377_ _0075_ VDD VSS
+ MUX2_X1
X_1779_ net13 input_buffer\[1\]\[20\] _1377_ _0076_ VDD VSS
+ MUX2_X1
X_1780_ net14 input_buffer\[1\]\[21\] _1377_ _0077_ VDD VSS
+ MUX2_X1
X_1781_ net15 input_buffer\[1\]\[22\] _1377_ _0078_ VDD VSS
+ MUX2_X1
X_1782_ net16 input_buffer\[1\]\[23\] _1377_ _0079_ VDD VSS
+ MUX2_X1
X_1783_ net17 _1333_ _1377_ _0080_ VDD VSS MUX2_X1
X_1784_ net18 _1335_ _1377_ _0081_ VDD VSS MUX2_X1
X_1785_ net19 _1336_ _1377_ _0082_ VDD VSS MUX2_X1
X_1786_ net20 _1338_ _1377_ _0083_ VDD VSS MUX2_X1
X_1787_ _1375_ _1378_ VDD VSS CLKBUF_X3
X_1788_ net21 _1329_ _1378_ _0084_ VDD VSS MUX2_X1
X_1789_ net22 _1328_ _1378_ _0085_ VDD VSS MUX2_X1
X_1790_ net23 input_buffer\[1\]\[2\] _1378_ _0086_ VDD VSS
+ MUX2_X1
X_1791_ net24 _1331_ _1378_ _0087_ VDD VSS MUX2_X1
X_1792_ net25 _1330_ _1378_ _0088_ VDD VSS MUX2_X1
X_1793_ net26 input_buffer\[1\]\[3\] _1378_ _0089_ VDD VSS
+ MUX2_X1
X_1794_ net27 input_buffer\[1\]\[4\] _1378_ _0090_ VDD VSS
+ MUX2_X1
X_1795_ net28 input_buffer\[1\]\[5\] _1378_ _0091_ VDD VSS
+ MUX2_X1
X_1796_ net29 input_buffer\[1\]\[6\] _1378_ _0092_ VDD VSS
+ MUX2_X1
X_1797_ net30 input_buffer\[1\]\[7\] _1378_ _0093_ VDD VSS
+ MUX2_X1
X_1798_ net31 input_buffer\[1\]\[8\] _1375_ _0094_ VDD VSS
+ MUX2_X1
X_1799_ net32 input_buffer\[1\]\[9\] _1375_ _0095_ VDD VSS
+ MUX2_X1
X_1800_ input_buffer\[2\]\[0\] _1379_ VDD VSS BUF_X2
X_1801_ input_buffer_valid\[2\] _1380_ VDD VSS BUF_X4
X_1802_ _1380_ _1381_ VDD VSS INV_X4
X_1803_ _1381_ net133 _1382_ VDD VSS AND2_X1
X_1804_ _1363_ _1382_ _1383_ VDD VSS NAND2_X4
X_1805_ _1383_ _1384_ VDD VSS BUF_X4
X_1806_ net101 _1379_ _1384_ _0096_ VDD VSS MUX2_X1
X_1807_ input_buffer\[2\]\[10\] _1385_ VDD VSS CLKBUF_X2
X_1808_ net102 _1385_ _1384_ _0097_ VDD VSS MUX2_X1
X_1809_ input_buffer\[2\]\[11\] _1386_ VDD VSS CLKBUF_X2
X_1810_ net103 _1386_ _1384_ _0098_ VDD VSS MUX2_X1
X_1811_ input_buffer\[2\]\[12\] _1387_ VDD VSS CLKBUF_X2
X_1812_ net104 _1387_ _1384_ _0099_ VDD VSS MUX2_X1
X_1813_ input_buffer\[2\]\[13\] _1388_ VDD VSS CLKBUF_X2
X_1814_ net105 _1388_ _1384_ _0100_ VDD VSS MUX2_X1
X_1815_ input_buffer\[2\]\[14\] _1389_ VDD VSS CLKBUF_X2
X_1816_ net106 _1389_ _1384_ _0101_ VDD VSS MUX2_X1
X_1817_ input_buffer\[2\]\[15\] _1390_ VDD VSS BUF_X2
X_1818_ net107 _1390_ _1384_ _0102_ VDD VSS MUX2_X1
X_1819_ input_buffer\[2\]\[16\] _1391_ VDD VSS CLKBUF_X2
X_1820_ net108 _1391_ _1384_ _0103_ VDD VSS MUX2_X1
X_1821_ input_buffer\[2\]\[17\] _1392_ VDD VSS CLKBUF_X2
X_1822_ net109 _1392_ _1384_ _0104_ VDD VSS MUX2_X1
X_1823_ input_buffer\[2\]\[18\] _1393_ VDD VSS CLKBUF_X2
X_1824_ net110 _1393_ _1384_ _0105_ VDD VSS MUX2_X1
X_1825_ input_buffer\[2\]\[19\] _1394_ VDD VSS BUF_X2
X_1826_ _1383_ _1395_ VDD VSS CLKBUF_X3
X_1827_ net111 _1394_ _1395_ _0106_ VDD VSS MUX2_X1
X_1828_ input_buffer\[2\]\[1\] _1396_ VDD VSS CLKBUF_X2
X_1829_ net112 _1396_ _1395_ _0107_ VDD VSS MUX2_X1
X_1830_ input_buffer\[2\]\[20\] _1397_ VDD VSS BUF_X2
X_1831_ net113 _1397_ _1395_ _0108_ VDD VSS MUX2_X1
X_1832_ input_buffer\[2\]\[21\] _1398_ VDD VSS CLKBUF_X2
X_1833_ net114 _1398_ _1395_ _0109_ VDD VSS MUX2_X1
X_1834_ input_buffer\[2\]\[22\] _1399_ VDD VSS CLKBUF_X2
X_1835_ net115 _1399_ _1395_ _0110_ VDD VSS MUX2_X1
X_1836_ input_buffer\[2\]\[23\] _1400_ VDD VSS BUF_X2
X_1837_ net116 _1400_ _1395_ _0111_ VDD VSS MUX2_X1
X_1838_ net117 _1314_ _1395_ _0112_ VDD VSS MUX2_X1
X_1839_ net118 _1316_ _1395_ _0113_ VDD VSS MUX2_X1
X_1840_ net119 _1317_ _1395_ _0114_ VDD VSS MUX2_X1
X_1841_ net120 _1319_ _1395_ _0115_ VDD VSS MUX2_X1
X_1842_ _1383_ _1401_ VDD VSS CLKBUF_X3
X_1843_ net121 _1310_ _1401_ _0116_ VDD VSS MUX2_X1
X_1844_ net122 _1309_ _1401_ _0117_ VDD VSS MUX2_X1
X_1845_ input_buffer\[2\]\[2\] _1402_ VDD VSS BUF_X2
X_1846_ net123 _1402_ _1401_ _0118_ VDD VSS MUX2_X1
X_1847_ net124 _1312_ _1401_ _0119_ VDD VSS MUX2_X1
X_1848_ net125 _1311_ _1401_ _0120_ VDD VSS MUX2_X1
X_1849_ input_buffer\[2\]\[3\] _0197_ VDD VSS BUF_X2
X_1850_ net126 _0197_ _1401_ _0121_ VDD VSS MUX2_X1
X_1851_ input_buffer\[2\]\[4\] _0198_ VDD VSS CLKBUF_X2
X_1852_ net127 _0198_ _1401_ _0122_ VDD VSS MUX2_X1
X_1853_ input_buffer\[2\]\[5\] _0199_ VDD VSS CLKBUF_X2
X_1854_ net128 _0199_ _1401_ _0123_ VDD VSS MUX2_X1
X_1855_ input_buffer\[2\]\[6\] _0200_ VDD VSS CLKBUF_X2
X_1856_ net129 _0200_ _1401_ _0124_ VDD VSS MUX2_X1
X_1857_ input_buffer\[2\]\[7\] _0201_ VDD VSS CLKBUF_X2
X_1858_ net130 _0201_ _1401_ _0125_ VDD VSS MUX2_X1
X_1859_ input_buffer\[2\]\[8\] _0202_ VDD VSS CLKBUF_X2
X_1860_ net131 _0202_ _1383_ _0126_ VDD VSS MUX2_X1
X_1861_ input_buffer\[2\]\[9\] _0203_ VDD VSS BUF_X2
X_1862_ net132 _0203_ _1383_ _0127_ VDD VSS MUX2_X1
X_1863_ input_buffer\[3\]\[0\] _0204_ VDD VSS BUF_X2
X_1864_ input_buffer_valid\[3\] _0205_ VDD VSS BUF_X4
X_1865_ _0205_ _0206_ VDD VSS INV_X4
X_1866_ _1363_ _0206_ net167 _0207_ VDD VSS NAND3_X4
X_1867_ _0207_ _0208_ VDD VSS BUF_X4
X_1868_ net135 _0204_ _0208_ _0128_ VDD VSS MUX2_X1
X_1869_ input_buffer\[3\]\[10\] _0209_ VDD VSS BUF_X2
X_1870_ net136 _0209_ _0208_ _0129_ VDD VSS MUX2_X1
X_1871_ input_buffer\[3\]\[11\] _0210_ VDD VSS BUF_X2
X_1872_ net137 _0210_ _0208_ _0130_ VDD VSS MUX2_X1
X_1873_ input_buffer\[3\]\[12\] _0211_ VDD VSS BUF_X2
X_1874_ net138 _0211_ _0208_ _0131_ VDD VSS MUX2_X1
X_1875_ input_buffer\[3\]\[13\] _0212_ VDD VSS BUF_X2
X_1876_ net139 _0212_ _0208_ _0132_ VDD VSS MUX2_X1
X_1877_ input_buffer\[3\]\[14\] _0213_ VDD VSS BUF_X2
X_1878_ net140 _0213_ _0208_ _0133_ VDD VSS MUX2_X1
X_1879_ input_buffer\[3\]\[15\] _0214_ VDD VSS BUF_X2
X_1880_ net141 _0214_ _0208_ _0134_ VDD VSS MUX2_X1
X_1881_ input_buffer\[3\]\[16\] _0215_ VDD VSS BUF_X2
X_1882_ net142 _0215_ _0208_ _0135_ VDD VSS MUX2_X1
X_1883_ input_buffer\[3\]\[17\] _0216_ VDD VSS BUF_X2
X_1884_ net143 _0216_ _0208_ _0136_ VDD VSS MUX2_X1
X_1885_ input_buffer\[3\]\[18\] _0217_ VDD VSS BUF_X2
X_1886_ net144 _0217_ _0208_ _0137_ VDD VSS MUX2_X1
X_1887_ input_buffer\[3\]\[19\] _0218_ VDD VSS BUF_X2
X_1888_ _0207_ _0219_ VDD VSS CLKBUF_X3
X_1889_ net145 _0218_ _0219_ _0138_ VDD VSS MUX2_X1
X_1890_ input_buffer\[3\]\[1\] _0220_ VDD VSS BUF_X2
X_1891_ net146 _0220_ _0219_ _0139_ VDD VSS MUX2_X1
X_1892_ input_buffer\[3\]\[20\] _0221_ VDD VSS BUF_X2
X_1893_ net147 _0221_ _0219_ _0140_ VDD VSS MUX2_X1
X_1894_ input_buffer\[3\]\[21\] _0222_ VDD VSS BUF_X2
X_1895_ net148 _0222_ _0219_ _0141_ VDD VSS MUX2_X1
X_1896_ input_buffer\[3\]\[22\] _0223_ VDD VSS BUF_X2
X_1897_ net149 _0223_ _0219_ _0142_ VDD VSS MUX2_X1
X_1898_ input_buffer\[3\]\[23\] _0224_ VDD VSS BUF_X2
X_1899_ net150 _0224_ _0219_ _0143_ VDD VSS MUX2_X1
X_1900_ net151 _1300_ _0219_ _0144_ VDD VSS MUX2_X1
X_1901_ net152 _1305_ _0219_ _0145_ VDD VSS MUX2_X1
X_1902_ net153 _1295_ _0219_ _0146_ VDD VSS MUX2_X1
X_1903_ net154 _1302_ _0219_ _0147_ VDD VSS MUX2_X1
X_1904_ _0207_ _0225_ VDD VSS CLKBUF_X3
X_1905_ net155 _1290_ _0225_ _0148_ VDD VSS MUX2_X1
X_1906_ net156 _1289_ _0225_ _0149_ VDD VSS MUX2_X1
X_1907_ input_buffer\[3\]\[2\] _0226_ VDD VSS BUF_X2
X_1908_ net157 _0226_ _0225_ _0150_ VDD VSS MUX2_X1
X_1909_ net158 _1292_ _0225_ _0151_ VDD VSS MUX2_X1
X_1910_ net159 _1291_ _0225_ _0152_ VDD VSS MUX2_X1
X_1911_ input_buffer\[3\]\[3\] _0227_ VDD VSS BUF_X2
X_1912_ net160 _0227_ _0225_ _0153_ VDD VSS MUX2_X1
X_1913_ input_buffer\[3\]\[4\] _0228_ VDD VSS BUF_X2
X_1914_ net161 _0228_ _0225_ _0154_ VDD VSS MUX2_X1
X_1915_ input_buffer\[3\]\[5\] _0229_ VDD VSS BUF_X2
X_1916_ net162 _0229_ _0225_ _0155_ VDD VSS MUX2_X1
X_1917_ input_buffer\[3\]\[6\] _0230_ VDD VSS BUF_X2
X_1918_ net163 _0230_ _0225_ _0156_ VDD VSS MUX2_X1
X_1919_ input_buffer\[3\]\[7\] _0231_ VDD VSS BUF_X2
X_1920_ net164 _0231_ _0225_ _0157_ VDD VSS MUX2_X1
X_1921_ input_buffer\[3\]\[8\] _0232_ VDD VSS BUF_X2
X_1922_ net165 _0232_ _0207_ _0158_ VDD VSS MUX2_X1
X_1923_ input_buffer\[3\]\[9\] _0233_ VDD VSS CLKBUF_X2
X_1924_ net166 _0233_ _0207_ _0159_ VDD VSS MUX2_X1
X_1925_ input_buffer\[4\]\[0\] _0234_ VDD VSS BUF_X2
X_1926_ input_buffer_valid\[4\] _0235_ VDD VSS BUF_X2
X_1927_ _0235_ _0236_ VDD VSS INV_X2
X_1928_ _0236_ net67 _1363_ _0237_ VDD VSS NAND3_X4
X_1929_ _0237_ _0238_ VDD VSS CLKBUF_X3
X_1930_ net35 _0234_ _0238_ _0160_ VDD VSS MUX2_X1
X_1931_ input_buffer\[4\]\[10\] _0239_ VDD VSS BUF_X2
X_1932_ net36 _0239_ _0238_ _0161_ VDD VSS MUX2_X1
X_1933_ input_buffer\[4\]\[11\] _0240_ VDD VSS BUF_X2
X_1934_ net37 _0240_ _0238_ _0162_ VDD VSS MUX2_X1
X_1935_ input_buffer\[4\]\[12\] _0241_ VDD VSS BUF_X2
X_1936_ net38 _0241_ _0238_ _0163_ VDD VSS MUX2_X1
X_1937_ input_buffer\[4\]\[13\] _0242_ VDD VSS BUF_X2
X_1938_ net39 _0242_ _0238_ _0164_ VDD VSS MUX2_X1
X_1939_ input_buffer\[4\]\[14\] _0243_ VDD VSS BUF_X2
X_1940_ net40 _0243_ _0238_ _0165_ VDD VSS MUX2_X1
X_1941_ input_buffer\[4\]\[15\] _0244_ VDD VSS BUF_X2
X_1942_ net41 _0244_ _0238_ _0166_ VDD VSS MUX2_X1
X_1943_ input_buffer\[4\]\[16\] _0245_ VDD VSS BUF_X2
X_1944_ net42 _0245_ _0238_ _0167_ VDD VSS MUX2_X1
X_1945_ input_buffer\[4\]\[17\] _0246_ VDD VSS CLKBUF_X2
X_1946_ net43 _0246_ _0238_ _0168_ VDD VSS MUX2_X1
X_1947_ input_buffer\[4\]\[18\] _0247_ VDD VSS CLKBUF_X2
X_1948_ net44 _0247_ _0238_ _0169_ VDD VSS MUX2_X1
X_1949_ input_buffer\[4\]\[19\] _0248_ VDD VSS CLKBUF_X2
X_1950_ _0237_ _0249_ VDD VSS CLKBUF_X3
X_1951_ net45 _0248_ _0249_ _0170_ VDD VSS MUX2_X1
X_1952_ input_buffer\[4\]\[1\] _0250_ VDD VSS CLKBUF_X2
X_1953_ net46 _0250_ _0249_ _0171_ VDD VSS MUX2_X1
X_1954_ input_buffer\[4\]\[20\] _0251_ VDD VSS BUF_X2
X_1955_ net47 _0251_ _0249_ _0172_ VDD VSS MUX2_X1
X_1956_ input_buffer\[4\]\[21\] _0252_ VDD VSS CLKBUF_X2
X_1957_ net48 _0252_ _0249_ _0173_ VDD VSS MUX2_X1
X_1958_ input_buffer\[4\]\[22\] _0253_ VDD VSS CLKBUF_X2
X_1959_ net49 _0253_ _0249_ _0174_ VDD VSS MUX2_X1
X_1960_ input_buffer\[4\]\[23\] _0254_ VDD VSS CLKBUF_X2
X_1961_ net50 _0254_ _0249_ _0175_ VDD VSS MUX2_X1
X_1962_ net51 _1277_ _0249_ _0176_ VDD VSS MUX2_X1
X_1963_ net52 _1279_ _0249_ _0177_ VDD VSS MUX2_X1
X_1964_ net53 _1280_ _0249_ _0178_ VDD VSS MUX2_X1
X_1965_ net54 _1282_ _0249_ _0179_ VDD VSS MUX2_X1
X_1966_ _0237_ _0255_ VDD VSS CLKBUF_X3
X_1967_ net55 dest_id\[4\]\[4\] _0255_ _0180_ VDD VSS MUX2_X1
X_1968_ net56 dest_id\[4\]\[5\] _0255_ _0181_ VDD VSS MUX2_X1
X_1969_ input_buffer\[4\]\[2\] _0256_ VDD VSS BUF_X2
X_1970_ net57 _0256_ _0255_ _0182_ VDD VSS MUX2_X1
X_1971_ net58 dest_id\[4\]\[6\] _0255_ _0183_ VDD VSS MUX2_X1
X_1972_ net59 dest_id\[4\]\[7\] _0255_ _0184_ VDD VSS MUX2_X1
X_1973_ input_buffer\[4\]\[3\] _0257_ VDD VSS BUF_X2
X_1974_ net60 _0257_ _0255_ _0185_ VDD VSS MUX2_X1
X_1975_ input_buffer\[4\]\[4\] _0258_ VDD VSS BUF_X2
X_1976_ net61 _0258_ _0255_ _0186_ VDD VSS MUX2_X1
X_1977_ input_buffer\[4\]\[5\] _0259_ VDD VSS BUF_X2
X_1978_ net62 _0259_ _0255_ _0187_ VDD VSS MUX2_X1
X_1979_ input_buffer\[4\]\[6\] _0260_ VDD VSS BUF_X2
X_1980_ net63 _0260_ _0255_ _0188_ VDD VSS MUX2_X1
X_1981_ input_buffer\[4\]\[7\] _0261_ VDD VSS BUF_X2
X_1982_ net64 _0261_ _0255_ _0189_ VDD VSS MUX2_X1
X_1983_ input_buffer\[4\]\[8\] _0262_ VDD VSS CLKBUF_X2
X_1984_ net65 _0262_ _0237_ _0190_ VDD VSS MUX2_X1
X_1985_ input_buffer\[4\]\[9\] _0263_ VDD VSS BUF_X2
X_1986_ net66 _0263_ _0237_ _0191_ VDD VSS MUX2_X1
X_1987_ _1364_ _0264_ VDD VSS CLKBUF_X3
X_1988_ _1363_ _0264_ net100 _0265_ VDD VSS OAI21_X1
X_1989_ local_out_ready _0266_ VDD VSS CLKBUF_X2
X_1990_ _0266_ _1543_ _0267_ VDD VSS NOR2_X1
X_1991_ _1536_ _0268_ VDD VSS BUF_X2
X_1992_ _1544_ _0269_ VDD VSS CLKBUF_X3
X_1993_ _0269_ _0270_ VDD VSS BUF_X4
X_1994_ _1533_ _0268_ _1541_ _0270_ _0271_ VDD VSS NOR4_X2
X_1995_ north_out_ready _0272_ VDD VSS CLKBUF_X2
X_1996_ _0272_ _0273_ VDD VSS INV_X1
X_1997_ net34 _0274_ VDD VSS INV_X1
X_1998_ _0274_ dest_id\[0\]\[1\] _0275_ VDD VSS AND2_X1
X_1999_ _0273_ _1360_ _0275_ _1357_ _0276_ VDD VSS AOI22_X2
X_2000_ net168 _0277_ VDD VSS INV_X1
X_2001_ net134 _0278_ VDD VSS INV_X1
X_2002_ _0277_ _1351_ _1354_ _0278_ _0279_ VDD VSS AOI22_X2
X_2003_ _1349_ _0276_ _0279_ dest_id\[0\]\[1\] _0280_ VDD
+ VSS OAI22_X2
X_2004_ _0267_ _0271_ _1543_ _1359_ _0280_ _0281_ VDD VSS
+ AOI221_X2
X_2005_ _1367_ net237 _0282_ VDD VSS NOR2_X1
X_2006_ _0265_ _0281_ _0282_ _0192_ VDD VSS AOI21_X1
X_2007_ _1373_ _0283_ VDD VSS CLKBUF_X3
X_2008_ _0283_ _0284_ VDD VSS BUF_X4
X_2009_ _1363_ _0284_ net33 _0285_ VDD VSS OAI21_X1
X_2010_ _0266_ _1558_ _0286_ VDD VSS NOR2_X1
X_2011_ _1554_ _0287_ VDD VSS CLKBUF_X3
X_2012_ _1556_ _0288_ VDD VSS BUF_X2
X_2013_ _1559_ _1548_ _0287_ _0288_ _0289_ VDD VSS NOR4_X1
X_2014_ _1558_ _0289_ _0290_ VDD VSS AND2_X1
X_2015_ _1374_ net169 _0286_ _0290_ _0291_ VDD VSS NOR4_X1
X_2016_ _0274_ _1335_ _1343_ _0292_ VDD VSS NAND3_X1
X_2017_ _1334_ _1335_ _1336_ _0293_ VDD VSS OR3_X4
X_2018_ _0292_ _0293_ _0272_ _0294_ VDD VSS OAI21_X1
X_2019_ _0278_ _1348_ _0295_ VDD VSS NAND2_X1
X_2020_ _1334_ _1347_ _1336_ _0296_ VDD VSS NAND3_X4
X_2021_ _0295_ _0296_ net168 _0297_ VDD VSS OAI21_X1
X_2022_ _1345_ _0294_ _0297_ _1346_ _0298_ VDD VSS AOI22_X1
X_2023_ _0285_ _0291_ _0298_ _0193_ VDD VSS AOI21_X1
X_2024_ _1363_ _0299_ VDD VSS INV_X1
X_2025_ _1381_ _0266_ _1322_ _0300_ VDD VSS AOI21_X1
X_2026_ net134 net168 _1562_ _0301_ VDD VSS MUX2_X1
X_2027_ _1563_ _0302_ VDD VSS BUF_X2
X_2028_ _1569_ _0303_ VDD VSS BUF_X2
X_2029_ _1571_ _0304_ VDD VSS BUF_X2
X_2030_ _1574_ _0302_ _0303_ _0304_ _0305_ VDD VSS OR4_X1
X_2031_ _1568_ _0301_ _0305_ _0306_ VDD VSS NAND3_X1
X_2032_ _0272_ net34 _1321_ _0307_ VDD VSS MUX2_X1
X_2033_ _1315_ _1316_ _1317_ _0308_ VDD VSS OR3_X4
X_2034_ _1315_ _1316_ _1317_ _0309_ VDD VSS NAND3_X1
X_2035_ _1319_ _0308_ _0309_ _0310_ VDD VSS AOI21_X2
X_2036_ _1313_ _0305_ _0307_ _0310_ _0311_ VDD VSS NAND4_X1
X_2037_ _0300_ _0306_ _0311_ _0312_ VDD VSS NAND3_X1
X_2038_ _1382_ net271 _1380_ _0313_ VDD VSS AOI21_X1
X_2039_ _0299_ _0312_ _0313_ _0194_ VDD VSS AOI21_X1
X_2040_ _0205_ _0314_ VDD VSS CLKBUF_X3
X_2041_ _1363_ _0314_ net167 _0315_ VDD VSS OAI21_X1
X_2042_ _0206_ net305 _0316_ VDD VSS OR2_X1
X_2043_ net134 _1580_ _0317_ VDD VSS NAND2_X1
X_2044_ _0277_ _1298_ _0318_ VDD VSS NAND2_X1
X_2045_ _1306_ _1307_ _0318_ _0319_ VDD VSS AOI21_X1
X_2046_ _0274_ _1305_ _1301_ _0320_ VDD VSS NAND3_X1
X_2047_ _1294_ _1305_ _1295_ _0321_ VDD VSS OR3_X2
X_2048_ _0320_ _0321_ _0272_ _0322_ VDD VSS OAI21_X1
X_2049_ _0316_ _0317_ _0319_ _0322_ _1304_ _0323_ VDD VSS
+ AOI221_X2
X_2050_ _0266_ _1299_ _0324_ VDD VSS NAND2_X1
X_2051_ _1589_ _0325_ VDD VSS CLKBUF_X3
X_2052_ _0325_ _0326_ VDD VSS BUF_X4
X_2053_ _1584_ _0327_ VDD VSS BUF_X2
X_2054_ _0326_ _1578_ _0327_ _1586_ _0328_ VDD VSS NOR4_X1
X_2055_ _0324_ _0328_ _1299_ _0329_ VDD VSS OAI21_X1
X_2056_ _0315_ _0323_ _0329_ _0195_ VDD VSS AOI21_X1
X_2057_ _0235_ _0330_ VDD VSS BUF_X4
X_2058_ _0272_ net34 _1592_ _0331_ VDD VSS MUX2_X1
X_2059_ _1282_ _1275_ _0332_ VDD VSS NOR2_X1
X_2060_ _1278_ _1279_ _1280_ _0333_ VDD VSS AND3_X1
X_2061_ _0332_ _0333_ _1281_ _0334_ VDD VSS OAI21_X2
X_2062_ _0330_ _0266_ _1603_ _0331_ _0334_ _0335_ VDD VSS
+ OAI221_X1
X_2063_ net134 net168 _1592_ _0336_ VDD VSS MUX2_X1
X_2064_ _1591_ _0336_ _0337_ VDD VSS NOR2_X1
X_2065_ _1363_ _0335_ _0337_ net67 _0330_ _0338_ VDD VSS OAI221_X1
X_2066_ _0338_ _0196_ VDD VSS INV_X1
X_2067_ _0235_ _1593_ _0339_ VDD VSS NAND2_X1
X_2068_ _1278_ _1287_ _1280_ _0340_ VDD VSS NAND3_X1
X_2069_ _1278_ _1279_ _1280_ _0341_ VDD VSS OR3_X1
X_2070_ _1275_ _0339_ _0340_ _0341_ _0342_ VDD VSS AOI211_X4
X_2071_ _0342_ _0343_ VDD VSS CLKBUF_X3
X_2072_ _0343_ _0344_ VDD VSS BUF_X4
X_2073_ _1578_ _0345_ VDD VSS INV_X2
X_2074_ _0206_ _1303_ _0346_ VDD VSS NOR2_X4
X_2075_ _0346_ _1298_ _1296_ _0347_ VDD VSS OAI21_X2
X_2076_ _0345_ _0347_ _0342_ _0348_ VDD VSS NOR3_X4
X_2077_ _0348_ _0349_ VDD VSS BUF_X4
X_2078_ _0234_ _0344_ _0349_ _0204_ _0350_ VDD VSS AOI22_X1
X_2079_ _1285_ _0339_ _0351_ VDD VSS OR2_X1
X_2080_ _0308_ _1327_ _0352_ VDD VSS NAND2_X2
X_2081_ _1380_ _0302_ _1313_ _0352_ _0353_ VDD VSS NAND4_X4
X_2082_ _0351_ _0347_ _0345_ _1379_ _0353_ _0354_ VDD VSS
+ OAI221_X2
X_2083_ _1380_ _0302_ _1313_ _0355_ VDD VSS NAND3_X1
X_2084_ _0355_ _1327_ _0308_ _0356_ VDD VSS AOI21_X4
X_2085_ _1533_ _0357_ VDD VSS INV_X2
X_2086_ _1372_ _1548_ net339 _0358_ VDD VSS NAND3_X2
X_2087_ _0358_ _0296_ _0293_ _0359_ VDD VSS AOI21_X4
X_2088_ _0357_ _0359_ _0360_ VDD VSS NOR2_X4
X_2089_ _0360_ _0361_ VDD VSS BUF_X4
X_2090_ _1366_ _0005_ _0362_ VDD VSS NOR2_X1
X_2091_ _1543_ _0362_ _0363_ VDD VSS AND2_X1
X_2092_ _1548_ _0364_ VDD VSS INV_X2
X_2093_ _0283_ input_buffer\[1\]\[0\] _0365_ VDD VSS NAND2_X1
X_2094_ _0364_ _0365_ _0366_ VDD VSS NOR2_X1
X_2095_ _0356_ _0361_ _0363_ _0366_ _1558_ _0367_ VDD VSS
+ AOI221_X1
X_2096_ _0350_ _0354_ _0367_ net170 VDD VSS OAI21_X1
X_2097_ _0239_ _0344_ _0349_ _0209_ _0368_ VDD VSS AOI22_X1
X_2098_ _0205_ _1293_ _0369_ VDD VSS NAND2_X2
X_2099_ _0345_ _0369_ _1308_ _0321_ _0370_ VDD VSS AOI211_X2
X_2100_ _0370_ _0342_ _0371_ VDD VSS NOR2_X4
X_2101_ _0371_ _0372_ VDD VSS CLKBUF_X3
X_2102_ _0353_ _0373_ VDD VSS CLKBUF_X3
X_2103_ _0372_ _0373_ _1385_ _0374_ VDD VSS OAI21_X1
X_2104_ _0302_ _0375_ VDD VSS INV_X1
X_2105_ _1381_ _1323_ _0376_ VDD VSS NOR2_X4
X_2106_ _0376_ _1321_ _1318_ _0377_ VDD VSS OAI21_X4
X_2107_ _0375_ _0377_ _0378_ VDD VSS NOR2_X4
X_2108_ _0378_ _0379_ VDD VSS BUF_X4
X_2109_ _1361_ _0380_ VDD VSS CLKBUF_X3
X_2110_ _0015_ _0381_ VDD VSS INV_X1
X_2111_ _1364_ _0381_ _0382_ VDD VSS NAND2_X1
X_2112_ _0380_ _0382_ _0383_ VDD VSS NOR2_X1
X_2113_ _0283_ input_buffer\[1\]\[10\] _0384_ VDD VSS AND2_X1
X_2114_ _0364_ _1341_ _0385_ VDD VSS NOR2_X4
X_2115_ _0385_ _0386_ VDD VSS BUF_X4
X_2116_ _0379_ _0361_ _0383_ _0384_ _0386_ _0387_ VDD VSS
+ AOI221_X1
X_2117_ _0368_ _0374_ _0387_ net171 VDD VSS OAI21_X1
X_2118_ _0240_ _0344_ _0349_ _0210_ _0388_ VDD VSS AOI22_X1
X_2119_ _0372_ _0373_ _1386_ _0389_ VDD VSS OAI21_X1
X_2120_ _1366_ _0016_ _0390_ VDD VSS NOR2_X1
X_2121_ _1543_ _0390_ _0391_ VDD VSS AND2_X1
X_2122_ _1373_ input_buffer\[1\]\[11\] _0392_ VDD VSS NAND2_X1
X_2123_ _0364_ _0392_ _0393_ VDD VSS NOR2_X1
X_2124_ _0356_ _0361_ _0391_ _0393_ _1558_ _0394_ VDD VSS
+ AOI221_X2
X_2125_ _0388_ _0389_ _0394_ net172 VDD VSS OAI21_X1
X_2126_ _0241_ _0344_ _0349_ _0211_ _0395_ VDD VSS AOI22_X1
X_2127_ _0372_ _0373_ _1387_ _0396_ VDD VSS OAI21_X1
X_2128_ _1361_ _0397_ VDD VSS BUF_X8
X_2129_ _1367_ _0017_ _0397_ _0398_ VDD VSS NOR3_X4
X_2130_ _0283_ input_buffer\[1\]\[12\] _0399_ VDD VSS AND2_X2
X_2131_ _0379_ _0361_ _0398_ _0399_ _0386_ _0400_ VDD VSS
+ AOI221_X2
X_2132_ _0395_ _0396_ _0400_ net173 VDD VSS OAI21_X1
X_2133_ _0242_ _0344_ _0349_ _0212_ _0401_ VDD VSS AOI22_X1
X_2134_ _0372_ _0373_ _1388_ _0402_ VDD VSS OAI21_X1
X_2135_ _1366_ _0403_ VDD VSS BUF_X8
X_2136_ _0403_ _0018_ _0397_ _0404_ VDD VSS NOR3_X4
X_2137_ _0283_ input_buffer\[1\]\[13\] _0405_ VDD VSS AND2_X2
X_2138_ _0379_ _0361_ _0404_ _0405_ _0386_ _0406_ VDD VSS
+ AOI221_X2
X_2139_ _0401_ _0402_ _0406_ net174 VDD VSS OAI21_X1
X_2140_ _0243_ _0344_ _0349_ _0213_ _0407_ VDD VSS AOI22_X1
X_2141_ _0372_ _0373_ _1389_ _0408_ VDD VSS OAI21_X1
X_2142_ _0403_ _0019_ _0397_ _0409_ VDD VSS NOR3_X4
X_2143_ _0283_ input_buffer\[1\]\[14\] _0410_ VDD VSS AND2_X2
X_2144_ _0379_ _0361_ _0409_ _0410_ _0386_ _0411_ VDD VSS
+ AOI221_X2
X_2145_ _0407_ _0408_ _0411_ net175 VDD VSS OAI21_X1
X_2146_ _0244_ _0344_ _0349_ _0214_ _0412_ VDD VSS AOI22_X1
X_2147_ _0372_ _0373_ _1390_ _0413_ VDD VSS OAI21_X1
X_2148_ _0403_ _0020_ _0397_ _0414_ VDD VSS NOR3_X4
X_2149_ _0283_ input_buffer\[1\]\[15\] _0415_ VDD VSS AND2_X2
X_2150_ _0379_ _0361_ _0414_ _0415_ _0386_ _0416_ VDD VSS
+ AOI221_X2
X_2151_ _0412_ _0413_ _0416_ net176 VDD VSS OAI21_X1
X_2152_ _0245_ _0344_ _0349_ _0215_ _0417_ VDD VSS AOI22_X1
X_2153_ _0372_ _0373_ _1391_ _0418_ VDD VSS OAI21_X1
X_2154_ _1361_ _0419_ VDD VSS BUF_X4
X_2155_ _0403_ _0021_ _0419_ _0420_ VDD VSS NOR3_X4
X_2156_ _0283_ input_buffer\[1\]\[16\] _0421_ VDD VSS AND2_X2
X_2157_ _0379_ _0361_ _0420_ _0421_ _0386_ _0422_ VDD VSS
+ AOI221_X2
X_2158_ _0417_ _0418_ _0422_ net177 VDD VSS OAI21_X1
X_2159_ _0246_ _0344_ _0349_ _0216_ _0423_ VDD VSS AOI22_X1
X_2160_ _0372_ _0373_ _1392_ _0424_ VDD VSS OAI21_X1
X_2161_ _0403_ _0022_ _0419_ _0425_ VDD VSS NOR3_X2
X_2162_ _1372_ _0426_ VDD VSS BUF_X2
X_2163_ _0426_ input_buffer\[1\]\[17\] _0427_ VDD VSS AND2_X1
X_2164_ _0379_ _0361_ _0425_ _0427_ _0386_ _0428_ VDD VSS
+ AOI221_X1
X_2165_ _0423_ _0424_ _0428_ net178 VDD VSS OAI21_X1
X_2166_ _0342_ _0429_ VDD VSS CLKBUF_X3
X_2167_ _0247_ _0429_ _0349_ _0217_ _0430_ VDD VSS AOI22_X1
X_2168_ _0372_ _0373_ _1393_ _0431_ VDD VSS OAI21_X1
X_2169_ _0403_ _0023_ _0419_ _0432_ VDD VSS NOR3_X2
X_2170_ _0426_ input_buffer\[1\]\[18\] _0433_ VDD VSS AND2_X1
X_2171_ _0379_ _0361_ _0432_ _0433_ _0386_ _0434_ VDD VSS
+ AOI221_X1
X_2172_ _0430_ _0431_ _0434_ net179 VDD VSS OAI21_X1
X_2173_ _0348_ _0435_ VDD VSS BUF_X4
X_2174_ _0248_ _0429_ _0435_ _0218_ _0436_ VDD VSS AOI22_X1
X_2175_ _0372_ _0373_ _1394_ _0437_ VDD VSS OAI21_X1
X_2176_ _0378_ _0438_ VDD VSS BUF_X4
X_2177_ _0360_ _0439_ VDD VSS BUF_X4
X_2178_ _1367_ _0024_ _0397_ _0440_ VDD VSS NOR3_X4
X_2179_ _1373_ input_buffer\[1\]\[19\] _0441_ VDD VSS AND2_X1
X_2180_ _0438_ _0439_ _0440_ _0441_ _0386_ _0442_ VDD VSS
+ AOI221_X2
X_2181_ _0436_ _0437_ _0442_ net180 VDD VSS OAI21_X1
X_2182_ _0250_ _0429_ _0435_ _0220_ _0443_ VDD VSS AOI22_X1
X_2183_ _0371_ _0444_ VDD VSS CLKBUF_X3
X_2184_ _0353_ _0445_ VDD VSS CLKBUF_X3
X_2185_ _0444_ _0445_ _1396_ _0446_ VDD VSS OAI21_X1
X_2186_ _0403_ _0006_ _0419_ _0447_ VDD VSS NOR3_X4
X_2187_ _0426_ input_buffer\[1\]\[1\] _0448_ VDD VSS AND2_X1
X_2188_ _0438_ _0439_ _0447_ _0448_ _0386_ _0449_ VDD VSS
+ AOI221_X2
X_2189_ _0443_ _0446_ _0449_ net181 VDD VSS OAI21_X1
X_2190_ _0251_ _0429_ _0435_ _0221_ _0450_ VDD VSS AOI22_X1
X_2191_ _0444_ _0445_ _1397_ _0451_ VDD VSS OAI21_X1
X_2192_ _0025_ _0452_ VDD VSS INV_X1
X_2193_ _1364_ _0452_ _0453_ VDD VSS NAND2_X1
X_2194_ _0397_ _0453_ _0454_ VDD VSS NOR2_X2
X_2195_ _0283_ input_buffer\[1\]\[20\] _0455_ VDD VSS AND2_X1
X_2196_ _0385_ _0456_ VDD VSS BUF_X4
X_2197_ _0438_ _0439_ _0454_ _0455_ _0456_ _0457_ VDD VSS
+ AOI221_X2
X_2198_ _0450_ _0451_ _0457_ net182 VDD VSS OAI21_X1
X_2199_ _0252_ _0429_ _0435_ _0222_ _0458_ VDD VSS AOI22_X1
X_2200_ _0444_ _0445_ _1398_ _0459_ VDD VSS OAI21_X1
X_2201_ _0403_ _0026_ _0419_ _0460_ VDD VSS NOR3_X2
X_2202_ _0426_ input_buffer\[1\]\[21\] _0461_ VDD VSS AND2_X1
X_2203_ _0438_ _0439_ _0460_ _0461_ _0456_ _0462_ VDD VSS
+ AOI221_X2
X_2204_ _0458_ _0459_ _0462_ net183 VDD VSS OAI21_X1
X_2205_ _0253_ _0429_ _0435_ _0223_ _0463_ VDD VSS AOI22_X1
X_2206_ _0444_ _0445_ _1399_ _0464_ VDD VSS OAI21_X1
X_2207_ _0403_ _0027_ _0419_ _0465_ VDD VSS NOR3_X2
X_2208_ _0426_ input_buffer\[1\]\[22\] _0466_ VDD VSS AND2_X1
X_2209_ _0438_ _0439_ _0465_ _0466_ _0456_ _0467_ VDD VSS
+ AOI221_X2
X_2210_ _0463_ _0464_ _0467_ net184 VDD VSS OAI21_X1
X_2211_ _0254_ _0429_ _0435_ _0224_ _0468_ VDD VSS AOI22_X1
X_2212_ _0444_ _0445_ _1400_ _0469_ VDD VSS OAI21_X1
X_2213_ _0403_ _0028_ _0419_ _0470_ VDD VSS NOR3_X4
X_2214_ _0426_ input_buffer\[1\]\[23\] _0471_ VDD VSS AND2_X2
X_2215_ _0438_ _0439_ _0470_ _0471_ _0456_ _0472_ VDD VSS
+ AOI221_X2
X_2216_ _0468_ _0469_ _0472_ net185 VDD VSS OAI21_X1
X_2217_ _1277_ _0429_ _0435_ _1300_ _0473_ VDD VSS AOI22_X1
X_2218_ _0444_ _0445_ _1314_ _0474_ VDD VSS OAI21_X1
X_2219_ _0357_ _0380_ _0475_ VDD VSS NOR2_X1
X_2220_ _0029_ _0476_ VDD VSS INV_X1
X_2221_ _1364_ _0476_ _0477_ VDD VSS NAND2_X1
X_2222_ _0359_ _0477_ _0478_ VDD VSS NOR2_X1
X_2223_ _0356_ _0475_ _0478_ _0359_ _1333_ _0479_ VDD VSS
+ AOI221_X2
X_2224_ _0473_ _0474_ _0479_ net186 VDD VSS OAI21_X1
X_2225_ _1279_ _0429_ _0435_ _1305_ _0480_ VDD VSS AOI22_X1
X_2226_ _0444_ _0445_ _1316_ _0481_ VDD VSS OAI21_X1
X_2227_ _1366_ _0030_ _0419_ _0482_ VDD VSS NOR3_X2
X_2228_ _0426_ _1335_ _0483_ VDD VSS AND2_X1
X_2229_ _0438_ _0439_ _0482_ _0483_ _0456_ _0484_ VDD VSS
+ AOI221_X2
X_2230_ _0480_ _0481_ _0484_ net187 VDD VSS OAI21_X1
X_2231_ _1278_ _0429_ _0435_ _1295_ _0485_ VDD VSS AOI22_X1
X_2232_ _0444_ _0445_ _1317_ _0486_ VDD VSS OAI21_X1
X_2233_ _0031_ _0487_ VDD VSS INV_X1
X_2234_ _1364_ _0487_ _0488_ VDD VSS NAND2_X1
X_2235_ _0357_ _0380_ _0359_ _0488_ _0489_ VDD VSS NOR4_X1
X_2236_ _1339_ _0296_ _0358_ _0490_ VDD VSS NOR3_X1
X_2237_ _0379_ _0489_ _0490_ _0491_ VDD VSS NOR3_X1
X_2238_ _0485_ _0486_ _0491_ net188 VDD VSS OAI21_X1
X_2239_ _0370_ _0356_ _1326_ _0492_ VDD VSS AOI21_X1
X_2240_ _1366_ _0000_ _0493_ VDD VSS NOR2_X2
X_2241_ _1359_ _0493_ _1360_ _1351_ _0494_ VDD VSS OAI211_X2
X_2242_ _0283_ _1338_ _0495_ VDD VSS NAND2_X1
X_2243_ _1341_ _0496_ VDD VSS BUF_X4
X_2244_ _0357_ _0359_ _0494_ _0495_ _0496_ _0364_ _0497_ VDD
+ VSS OAI33_X1
X_2245_ _0492_ _0497_ _0379_ _0498_ VDD VSS OAI21_X1
X_2246_ _0343_ _0370_ _1302_ _0499_ VDD VSS AOI21_X1
X_2247_ _1287_ _0344_ _0498_ _0499_ net189 VDD VSS AOI22_X2
X_2248_ _1365_ _0500_ VDD VSS CLKBUF_X3
X_2249_ _0500_ _0001_ _0501_ VDD VSS OR2_X1
X_2250_ _0370_ _0356_ _0359_ _0502_ VDD VSS NOR3_X1
X_2251_ _0351_ _0475_ _0502_ _0503_ VDD VSS NAND3_X2
X_2252_ _0501_ _0503_ net190 VDD VSS NOR2_X1
X_2253_ _0500_ _0002_ _0504_ VDD VSS OR2_X1
X_2254_ _0503_ _0504_ net191 VDD VSS NOR2_X1
X_2255_ _0256_ _0343_ _0435_ _0226_ _0505_ VDD VSS AOI22_X1
X_2256_ _0444_ _0445_ _1402_ _0506_ VDD VSS OAI21_X1
X_2257_ _1366_ _0007_ _0419_ _0507_ VDD VSS NOR3_X2
X_2258_ _0426_ input_buffer\[1\]\[2\] _0508_ VDD VSS AND2_X1
X_2259_ _0438_ _0439_ _0507_ _0508_ _0456_ _0509_ VDD VSS
+ AOI221_X2
X_2260_ _0505_ _0506_ _0509_ net192 VDD VSS OAI21_X1
X_2261_ _0500_ _0003_ _0510_ VDD VSS OR2_X1
X_2262_ _0503_ _0510_ net193 VDD VSS NOR2_X1
X_2263_ _0500_ _0004_ _0511_ VDD VSS OR2_X1
X_2264_ _0503_ _0511_ net194 VDD VSS NOR2_X1
X_2265_ _0257_ _0343_ _0348_ _0227_ _0512_ VDD VSS AOI22_X1
X_2266_ _0444_ _0445_ _0197_ _0513_ VDD VSS OAI21_X1
X_2267_ _1367_ _0008_ _0397_ _0514_ VDD VSS NOR3_X4
X_2268_ _1373_ input_buffer\[1\]\[3\] _0515_ VDD VSS AND2_X1
X_2269_ _0438_ _0439_ _0514_ _0515_ _0456_ _0516_ VDD VSS
+ AOI221_X2
X_2270_ _0512_ _0513_ _0516_ net195 VDD VSS OAI21_X1
X_2271_ _0258_ _0343_ _0348_ _0228_ _0517_ VDD VSS AOI22_X1
X_2272_ _0371_ _0353_ _0198_ _0518_ VDD VSS OAI21_X1
X_2273_ _1366_ _0009_ _0419_ _0519_ VDD VSS NOR3_X2
X_2274_ _0426_ input_buffer\[1\]\[4\] _0520_ VDD VSS AND2_X1
X_2275_ _0438_ _0439_ _0519_ _0520_ _0456_ _0521_ VDD VSS
+ AOI221_X2
X_2276_ _0517_ _0518_ _0521_ net196 VDD VSS OAI21_X1
X_2277_ _0259_ _0343_ _0348_ _0229_ _0522_ VDD VSS AOI22_X1
X_2278_ _0371_ _0353_ _0199_ _0523_ VDD VSS OAI21_X1
X_2279_ _1367_ _0010_ _0397_ _0524_ VDD VSS NOR3_X4
X_2280_ _1373_ input_buffer\[1\]\[5\] _0525_ VDD VSS AND2_X1
X_2281_ _0378_ _0360_ _0524_ _0525_ _0456_ _0526_ VDD VSS
+ AOI221_X2
X_2282_ _0522_ _0523_ _0526_ net197 VDD VSS OAI21_X1
X_2283_ _0260_ _0343_ _0348_ _0230_ _0527_ VDD VSS AOI22_X1
X_2284_ _0371_ _0353_ _0200_ _0528_ VDD VSS OAI21_X1
X_2285_ _1366_ _0011_ _1361_ _0529_ VDD VSS NOR3_X4
X_2286_ _0426_ input_buffer\[1\]\[6\] _0530_ VDD VSS AND2_X2
X_2287_ _0378_ _0360_ _0529_ _0530_ _0456_ _0531_ VDD VSS
+ AOI221_X2
X_2288_ _0527_ _0528_ _0531_ net198 VDD VSS OAI21_X1
X_2289_ _0261_ _0343_ _0348_ _0231_ _0532_ VDD VSS AOI22_X1
X_2290_ _0371_ _0353_ _0201_ _0533_ VDD VSS OAI21_X1
X_2291_ _1367_ _0012_ _0397_ _0534_ VDD VSS NOR3_X2
X_2292_ _1373_ input_buffer\[1\]\[7\] _0535_ VDD VSS AND2_X1
X_2293_ _0378_ _0360_ _0534_ _0535_ _0385_ _0536_ VDD VSS
+ AOI221_X1
X_2294_ _0532_ _0533_ _0536_ net199 VDD VSS OAI21_X1
X_2295_ _0262_ _0343_ _0348_ _0232_ _0537_ VDD VSS AOI22_X1
X_2296_ _0371_ _0353_ _0202_ _0538_ VDD VSS OAI21_X1
X_2297_ _1367_ _0013_ _0397_ _0539_ VDD VSS NOR3_X2
X_2298_ _1373_ input_buffer\[1\]\[8\] _0540_ VDD VSS AND2_X1
X_2299_ _0378_ _0360_ _0539_ _0540_ _0385_ _0541_ VDD VSS
+ AOI221_X2
X_2300_ _0537_ _0538_ _0541_ net200 VDD VSS OAI21_X1
X_2301_ _0263_ _0343_ _0348_ _0233_ _0542_ VDD VSS AOI22_X1
X_2302_ _0371_ _0353_ _0203_ _0543_ VDD VSS OAI21_X1
X_2303_ _1366_ _0014_ _0544_ VDD VSS NOR2_X1
X_2304_ _1543_ _0544_ _0545_ VDD VSS AND2_X1
X_2305_ _1373_ input_buffer\[1\]\[9\] _0546_ VDD VSS AND2_X1
X_2306_ _0378_ _0360_ _0545_ _0546_ _0385_ _0547_ VDD VSS
+ AOI221_X1
X_2307_ _0542_ _0543_ _0547_ net201 VDD VSS OAI21_X1
X_2308_ _0330_ _1605_ _0548_ VDD VSS AND2_X1
X_2309_ _1380_ _1575_ _0549_ VDD VSS AND2_X1
X_2310_ _1593_ _0548_ _0549_ _0302_ _0550_ VDD VSS AOI22_X1
X_2311_ _0284_ _1560_ _1548_ _0551_ VDD VSS NAND3_X1
X_2312_ _0264_ _1545_ _1533_ _0552_ VDD VSS NAND3_X1
X_2313_ _0314_ _1590_ _1578_ _0553_ VDD VSS NAND3_X1
X_2314_ _0550_ _0551_ _0552_ _0553_ net202 VDD VSS NAND4_X1
X_2315_ _0236_ _1603_ _1573_ _1381_ _0554_ VDD VSS OAI22_X4
X_2316_ _0554_ _0555_ VDD VSS BUF_X4
X_2317_ _1362_ _1341_ _1372_ _0556_ VDD VSS AOI21_X4
X_2318_ _0556_ _0557_ VDD VSS BUF_X4
X_2319_ _0557_ _0558_ VDD VSS BUF_X4
X_2320_ _0555_ _0558_ _0362_ _0559_ VDD VSS AOI21_X1
X_2321_ _0496_ _0560_ VDD VSS BUF_X4
X_2322_ _0365_ _0561_ VDD VSS INV_X1
X_2323_ _0206_ _1588_ _0562_ VDD VSS NOR2_X2
X_2324_ _0562_ _0563_ VDD VSS BUF_X4
X_2325_ _0560_ _0561_ _0563_ _0204_ _0564_ VDD VSS AOI22_X2
X_2326_ _0235_ _1285_ _0565_ VDD VSS NAND2_X1
X_2327_ _0565_ _0566_ VDD VSS BUF_X4
X_2328_ _0566_ _0567_ VDD VSS BUF_X4
X_2329_ _0205_ _1299_ _0568_ VDD VSS NAND2_X4
X_2330_ _0568_ _0569_ VDD VSS CLKBUF_X3
X_2331_ _1380_ _1322_ _1588_ _0206_ _0570_ VDD VSS OAI211_X4
X_2332_ _0570_ _0571_ VDD VSS CLKBUF_X3
X_2333_ _0567_ _0569_ _0204_ _0571_ _1379_ _0572_ VDD VSS
+ OAI221_X2
X_2334_ _0236_ _1603_ _0573_ VDD VSS NOR2_X2
X_2335_ _0573_ _0574_ VDD VSS CLKBUF_X3
X_2336_ _0234_ _0574_ _0575_ VDD VSS NAND2_X1
X_2337_ _0559_ _0564_ _0572_ _0575_ net204 VDD VSS AOI22_X2
X_2338_ _0264_ _0576_ VDD VSS CLKBUF_X3
X_2339_ _0576_ _0381_ _0558_ _0577_ VDD VSS NAND3_X1
X_2340_ _0555_ _0563_ _0209_ _0560_ _0384_ _0578_ VDD VSS
+ AOI221_X1
X_2341_ _0567_ _0569_ _0209_ _0571_ _1385_ _0579_ VDD VSS
+ OAI221_X1
X_2342_ _0239_ _0574_ _0580_ VDD VSS NAND2_X1
X_2343_ _0577_ _0578_ _0579_ _0580_ net205 VDD VSS AOI22_X1
X_2344_ _0555_ _0558_ _0390_ _0581_ VDD VSS AOI21_X1
X_2345_ _1558_ _0392_ _0582_ VDD VSS NOR2_X1
X_2346_ _0582_ _0563_ _0210_ _0583_ VDD VSS AOI21_X1
X_2347_ _0567_ _0569_ _0210_ _0571_ _1386_ _0584_ VDD VSS
+ OAI221_X1
X_2348_ _0240_ _0574_ _0585_ VDD VSS NAND2_X1
X_2349_ _0581_ _0583_ _0584_ _0585_ net206 VDD VSS AOI22_X1
X_2350_ _0017_ _0586_ VDD VSS INV_X1
X_2351_ _0576_ _0586_ _0558_ _0587_ VDD VSS NAND3_X1
X_2352_ _0555_ _0563_ _0211_ _0560_ _0399_ _0588_ VDD VSS
+ AOI221_X1
X_2353_ _0567_ _0569_ _0211_ _0571_ _1387_ _0589_ VDD VSS
+ OAI221_X1
X_2354_ _0241_ _0574_ _0590_ VDD VSS NAND2_X1
X_2355_ _0587_ _0588_ _0589_ _0590_ net207 VDD VSS AOI22_X1
X_2356_ _0018_ _0591_ VDD VSS INV_X1
X_2357_ _0576_ _0591_ _0558_ _0592_ VDD VSS NAND3_X1
X_2358_ _0555_ _0563_ _0212_ _0560_ _0405_ _0593_ VDD VSS
+ AOI221_X1
X_2359_ _0567_ _0569_ _0212_ _0571_ _1388_ _0594_ VDD VSS
+ OAI221_X1
X_2360_ _0242_ _0574_ _0595_ VDD VSS NAND2_X1
X_2361_ _0592_ _0593_ _0594_ _0595_ net208 VDD VSS AOI22_X1
X_2362_ _0019_ _0596_ VDD VSS INV_X1
X_2363_ _0576_ _0596_ _0558_ _0597_ VDD VSS NAND3_X1
X_2364_ _0555_ _0563_ _0213_ _0560_ _0410_ _0598_ VDD VSS
+ AOI221_X2
X_2365_ _0567_ _0569_ _0213_ _0571_ _1389_ _0599_ VDD VSS
+ OAI221_X1
X_2366_ _0243_ _0574_ _0600_ VDD VSS NAND2_X1
X_2367_ _0597_ _0598_ _0599_ _0600_ net209 VDD VSS AOI22_X1
X_2368_ _0020_ _0601_ VDD VSS INV_X1
X_2369_ _0576_ _0601_ _0558_ _0602_ VDD VSS NAND3_X1
X_2370_ _0555_ _0563_ _0214_ _0560_ _0415_ _0603_ VDD VSS
+ AOI221_X2
X_2371_ _0567_ _0569_ _0214_ _0571_ _1390_ _0604_ VDD VSS
+ OAI221_X2
X_2372_ _0573_ _0605_ VDD VSS CLKBUF_X3
X_2373_ _0244_ _0605_ _0606_ VDD VSS NAND2_X1
X_2374_ _0602_ _0603_ _0604_ _0606_ net210 VDD VSS AOI22_X2
X_2375_ _0021_ _0607_ VDD VSS INV_X1
X_2376_ _0576_ _0607_ _0558_ _0608_ VDD VSS NAND3_X1
X_2377_ _0562_ _0609_ VDD VSS BUF_X4
X_2378_ _0609_ _0610_ VDD VSS BUF_X4
X_2379_ _0555_ _0610_ _0215_ _0560_ _0421_ _0611_ VDD VSS
+ AOI221_X1
X_2380_ _0567_ _0569_ _0215_ _0571_ _1391_ _0612_ VDD VSS
+ OAI221_X1
X_2381_ _0245_ _0605_ _0613_ VDD VSS NAND2_X1
X_2382_ _0608_ _0611_ _0612_ _0613_ net211 VDD VSS AOI22_X1
X_2383_ _0022_ _0614_ VDD VSS INV_X1
X_2384_ _0576_ _0614_ _0558_ _0615_ VDD VSS NAND3_X1
X_2385_ _0554_ _0616_ VDD VSS BUF_X4
X_2386_ _0616_ _0610_ _0216_ _0560_ _0427_ _0617_ VDD VSS
+ AOI221_X1
X_2387_ _0565_ _0618_ VDD VSS BUF_X4
X_2388_ _0618_ _0569_ _0216_ _0571_ _1392_ _0619_ VDD VSS
+ OAI221_X1
X_2389_ _0246_ _0605_ _0620_ VDD VSS NAND2_X1
X_2390_ _0615_ _0617_ _0619_ _0620_ net212 VDD VSS AOI22_X1
X_2391_ _0023_ _0621_ VDD VSS INV_X1
X_2392_ _0576_ _0621_ _0558_ _0622_ VDD VSS NAND3_X1
X_2393_ _0496_ _0623_ VDD VSS BUF_X4
X_2394_ _0616_ _0610_ _0217_ _0623_ _0433_ _0624_ VDD VSS
+ AOI221_X2
X_2395_ _0618_ _0569_ _0217_ _0571_ _1393_ _0625_ VDD VSS
+ OAI221_X1
X_2396_ _0247_ _0605_ _0626_ VDD VSS NAND2_X1
X_2397_ _0622_ _0624_ _0625_ _0626_ net213 VDD VSS AOI22_X1
X_2398_ _0024_ _0627_ VDD VSS INV_X1
X_2399_ _0557_ _0628_ VDD VSS BUF_X4
X_2400_ _0576_ _0627_ _0628_ _0629_ VDD VSS NAND3_X1
X_2401_ _0616_ _0610_ _0218_ _0623_ _0441_ _0630_ VDD VSS
+ AOI221_X2
X_2402_ _0568_ _0631_ VDD VSS BUF_X4
X_2403_ _0570_ _0632_ VDD VSS BUF_X4
X_2404_ _0618_ _0631_ _0218_ _0632_ _1394_ _0633_ VDD VSS
+ OAI221_X2
X_2405_ _0248_ _0605_ _0634_ VDD VSS NAND2_X1
X_2406_ _0629_ _0630_ _0633_ _0634_ net214 VDD VSS AOI22_X2
X_2407_ _0264_ _0635_ VDD VSS CLKBUF_X3
X_2408_ _0006_ _0636_ VDD VSS INV_X1
X_2409_ _0635_ _0636_ _0628_ _0637_ VDD VSS NAND3_X1
X_2410_ _0616_ _0610_ _0220_ _0623_ _0448_ _0638_ VDD VSS
+ AOI221_X1
X_2411_ _0618_ _0631_ _0220_ _0632_ _1396_ _0639_ VDD VSS
+ OAI221_X1
X_2412_ _0250_ _0605_ _0640_ VDD VSS NAND2_X1
X_2413_ _0637_ _0638_ _0639_ _0640_ net215 VDD VSS AOI22_X1
X_2414_ _0635_ _0452_ _0628_ _0641_ VDD VSS NAND3_X1
X_2415_ _0616_ _0610_ _0221_ _0623_ _0455_ _0642_ VDD VSS
+ AOI221_X1
X_2416_ _0618_ _0631_ _0221_ _0632_ _1397_ _0643_ VDD VSS
+ OAI221_X1
X_2417_ _0251_ _0605_ _0644_ VDD VSS NAND2_X1
X_2418_ _0641_ _0642_ _0643_ _0644_ net216 VDD VSS AOI22_X1
X_2419_ _0026_ _0645_ VDD VSS INV_X1
X_2420_ _0635_ _0645_ _0628_ _0646_ VDD VSS NAND3_X1
X_2421_ _0616_ _0610_ _0222_ _0623_ _0461_ _0647_ VDD VSS
+ AOI221_X1
X_2422_ _0618_ _0631_ _0222_ _0632_ _1398_ _0648_ VDD VSS
+ OAI221_X1
X_2423_ _0252_ _0605_ _0649_ VDD VSS NAND2_X1
X_2424_ _0646_ _0647_ _0648_ _0649_ net217 VDD VSS AOI22_X1
X_2425_ _0027_ _0650_ VDD VSS INV_X1
X_2426_ _0635_ _0650_ _0628_ _0651_ VDD VSS NAND3_X1
X_2427_ _0616_ _0610_ _0223_ _0623_ _0466_ _0652_ VDD VSS
+ AOI221_X1
X_2428_ _0618_ _0631_ _0223_ _0632_ _1399_ _0653_ VDD VSS
+ OAI221_X1
X_2429_ _0253_ _0605_ _0654_ VDD VSS NAND2_X1
X_2430_ _0651_ _0652_ _0653_ _0654_ net218 VDD VSS AOI22_X1
X_2431_ _0028_ _0655_ VDD VSS INV_X1
X_2432_ _0635_ _0655_ _0628_ _0656_ VDD VSS NAND3_X1
X_2433_ _0616_ _0610_ _0224_ _0623_ _0471_ _0657_ VDD VSS
+ AOI221_X2
X_2434_ _0618_ _0631_ _0224_ _0632_ _1400_ _0658_ VDD VSS
+ OAI221_X2
X_2435_ _0254_ _0605_ _0659_ VDD VSS NAND2_X1
X_2436_ _0656_ _0657_ _0658_ _0659_ net219 VDD VSS AOI22_X2
X_2437_ _0635_ _0476_ _0628_ _0660_ VDD VSS NAND3_X1
X_2438_ _1374_ _1342_ _0661_ VDD VSS NOR2_X2
X_2439_ _0616_ _0610_ _1300_ _1333_ _0661_ _0662_ VDD VSS
+ AOI221_X2
X_2440_ _0618_ _0631_ _1300_ _0632_ _1314_ _0663_ VDD VSS
+ OAI221_X2
X_2441_ _0573_ _0664_ VDD VSS CLKBUF_X3
X_2442_ _1277_ _0664_ _0665_ VDD VSS NAND2_X1
X_2443_ _0660_ _0662_ _0663_ _0665_ net220 VDD VSS AOI22_X2
X_2444_ _0030_ _0666_ VDD VSS INV_X1
X_2445_ _0635_ _0666_ _0628_ _0667_ VDD VSS NAND3_X1
X_2446_ _0616_ _0609_ _1305_ _0623_ _0483_ _0668_ VDD VSS
+ AOI221_X2
X_2447_ _0618_ _0631_ _1305_ _0632_ _1316_ _0669_ VDD VSS
+ OAI221_X2
X_2448_ _1279_ _0664_ _0670_ VDD VSS NAND2_X1
X_2449_ _0667_ _0668_ _0669_ _0670_ net221 VDD VSS AOI22_X2
X_2450_ _0635_ _0487_ _0628_ _0671_ VDD VSS NAND3_X1
X_2451_ _0554_ _0609_ _1295_ _1336_ _0661_ _0672_ VDD VSS
+ AOI221_X2
X_2452_ _0566_ _0631_ _1295_ _0632_ _1317_ _0673_ VDD VSS
+ OAI221_X2
X_2453_ _1280_ _0664_ _0674_ VDD VSS NAND2_X1
X_2454_ _0671_ _0672_ _0673_ _0674_ net222 VDD VSS AOI22_X2
X_2455_ _1374_ _1347_ _0675_ VDD VSS NOR2_X1
X_2456_ _0555_ _0675_ _0560_ _0676_ VDD VSS AOI21_X1
X_2457_ _0493_ _0557_ _0563_ _1302_ _0677_ VDD VSS AOI22_X2
X_2458_ _0566_ _0631_ _1302_ _0632_ _1319_ _0678_ VDD VSS
+ OAI221_X2
X_2459_ _1282_ _0664_ _0679_ VDD VSS NAND2_X1
X_2460_ _0676_ _0677_ _0678_ _0679_ net223 VDD VSS AOI22_X2
X_2461_ _0330_ dest_id\[4\]\[4\] _0680_ VDD VSS NAND2_X1
X_2462_ _1381_ _1573_ _0681_ VDD VSS NOR2_X4
X_2463_ _0501_ _0682_ VDD VSS INV_X1
X_2464_ _0681_ _0557_ _0682_ _0284_ _1329_ _0683_ VDD VSS
+ AOI221_X2
X_2465_ _0205_ _0684_ VDD VSS BUF_X4
X_2466_ _0330_ _1285_ _1299_ _0684_ _0685_ VDD VSS AOI22_X4
X_2467_ _1380_ _1322_ _0686_ VDD VSS NAND2_X2
X_2468_ _0685_ _0686_ _1310_ _0687_ VDD VSS OAI21_X1
X_2469_ _0314_ _1290_ _0688_ VDD VSS NAND2_X1
X_2470_ _0680_ _0683_ _0687_ _0688_ _0574_ net224 VDD VSS
+ OAI221_X1
X_2471_ _0330_ dest_id\[4\]\[5\] _0689_ VDD VSS NAND2_X1
X_2472_ _0504_ _0690_ VDD VSS INV_X1
X_2473_ _0681_ _0556_ _0690_ _0284_ _1328_ _0691_ VDD VSS
+ AOI221_X2
X_2474_ _0685_ _0686_ _1309_ _0692_ VDD VSS OAI21_X1
X_2475_ _0314_ _1289_ _0693_ VDD VSS NAND2_X1
X_2476_ _0689_ _0691_ _0692_ _0693_ _0574_ net225 VDD VSS
+ OAI221_X1
X_2477_ _0007_ _0694_ VDD VSS INV_X1
X_2478_ _0635_ _0694_ _0628_ _0695_ VDD VSS NAND3_X1
X_2479_ _0554_ _0609_ _0226_ _0623_ _0508_ _0696_ VDD VSS
+ AOI221_X1
X_2480_ _0566_ _0568_ _0226_ _0570_ _1402_ _0697_ VDD VSS
+ OAI221_X1
X_2481_ _0256_ _0664_ _0698_ VDD VSS NAND2_X1
X_2482_ _0695_ _0696_ _0697_ _0698_ net226 VDD VSS AOI22_X1
X_2483_ _0330_ dest_id\[4\]\[6\] _0699_ VDD VSS NAND2_X1
X_2484_ _0510_ _0700_ VDD VSS INV_X1
X_2485_ _0681_ _0556_ _0700_ _0284_ _1331_ _0701_ VDD VSS
+ AOI221_X2
X_2486_ _0685_ _0686_ _1312_ _0702_ VDD VSS OAI21_X1
X_2487_ _0314_ _1292_ _0703_ VDD VSS NAND2_X1
X_2488_ _0699_ _0701_ _0702_ _0703_ _0574_ net227 VDD VSS
+ OAI221_X1
X_2489_ _0330_ dest_id\[4\]\[7\] _0704_ VDD VSS NAND2_X1
X_2490_ _0511_ _0705_ VDD VSS INV_X1
X_2491_ _0681_ _0556_ _0705_ _0284_ _1330_ _0706_ VDD VSS
+ AOI221_X2
X_2492_ _0685_ _0686_ _1311_ _0707_ VDD VSS OAI21_X1
X_2493_ _0314_ _1291_ _0708_ VDD VSS NAND2_X1
X_2494_ _0704_ _0706_ _0707_ _0708_ _0574_ net228 VDD VSS
+ OAI221_X1
X_2495_ _0008_ _0709_ VDD VSS INV_X1
X_2496_ _0635_ _0709_ _0557_ _0710_ VDD VSS NAND3_X1
X_2497_ _0554_ _0609_ _0227_ _0623_ _0515_ _0711_ VDD VSS
+ AOI221_X1
X_2498_ _0566_ _0568_ _0227_ _0570_ _0197_ _0712_ VDD VSS
+ OAI221_X1
X_2499_ _0257_ _0664_ _0713_ VDD VSS NAND2_X1
X_2500_ _0710_ _0711_ _0712_ _0713_ net229 VDD VSS AOI22_X1
X_2501_ _0009_ _0714_ VDD VSS INV_X1
X_2502_ _0264_ _0714_ _0557_ _0715_ VDD VSS NAND3_X1
X_2503_ _0554_ _0609_ _0228_ _0496_ _0520_ _0716_ VDD VSS
+ AOI221_X2
X_2504_ _0566_ _0568_ _0228_ _0570_ _0198_ _0717_ VDD VSS
+ OAI221_X1
X_2505_ _0258_ _0664_ _0718_ VDD VSS NAND2_X1
X_2506_ _0715_ _0716_ _0717_ _0718_ net230 VDD VSS AOI22_X1
X_2507_ _0010_ _0719_ VDD VSS INV_X1
X_2508_ _0264_ _0719_ _0557_ _0720_ VDD VSS NAND3_X1
X_2509_ _0554_ _0609_ _0229_ _0496_ _0525_ _0721_ VDD VSS
+ AOI221_X1
X_2510_ _0566_ _0568_ _0229_ _0570_ _0199_ _0722_ VDD VSS
+ OAI221_X1
X_2511_ _0259_ _0664_ _0723_ VDD VSS NAND2_X1
X_2512_ _0720_ _0721_ _0722_ _0723_ net231 VDD VSS AOI22_X1
X_2513_ _0011_ _0724_ VDD VSS INV_X1
X_2514_ _0264_ _0724_ _0557_ _0725_ VDD VSS NAND3_X1
X_2515_ _0554_ _0609_ _0230_ _0496_ _0530_ _0726_ VDD VSS
+ AOI221_X2
X_2516_ _0566_ _0568_ _0230_ _0570_ _0200_ _0727_ VDD VSS
+ OAI221_X1
X_2517_ _0260_ _0664_ _0728_ VDD VSS NAND2_X1
X_2518_ _0725_ _0726_ _0727_ _0728_ net232 VDD VSS AOI22_X1
X_2519_ _0012_ _0729_ VDD VSS INV_X1
X_2520_ _0264_ _0729_ _0557_ _0730_ VDD VSS NAND3_X1
X_2521_ _0554_ _0609_ _0231_ _0496_ _0535_ _0731_ VDD VSS
+ AOI221_X1
X_2522_ _0566_ _0568_ _0231_ _0570_ _0201_ _0732_ VDD VSS
+ OAI221_X1
X_2523_ _0261_ _0664_ _0733_ VDD VSS NAND2_X1
X_2524_ _0730_ _0731_ _0732_ _0733_ net233 VDD VSS AOI22_X1
X_2525_ _0013_ _0734_ VDD VSS INV_X1
X_2526_ _0264_ _0734_ _0557_ _0735_ VDD VSS NAND3_X1
X_2527_ _0554_ _0609_ _0232_ _0496_ _0540_ _0736_ VDD VSS
+ AOI221_X1
X_2528_ _0566_ _0568_ _0232_ _0570_ _0202_ _0737_ VDD VSS
+ OAI221_X1
X_2529_ _0262_ _0573_ _0738_ VDD VSS NAND2_X1
X_2530_ _0735_ _0736_ _0737_ _0738_ net234 VDD VSS AOI22_X1
X_2531_ _0233_ _0567_ _0563_ _0739_ VDD VSS NAND3_X1
X_2532_ _0685_ _0686_ _0203_ _0740_ VDD VSS OAI21_X1
X_2533_ _0681_ _0556_ _0544_ _0496_ _0546_ _0741_ VDD VSS
+ AOI221_X1
X_2534_ _0263_ _0742_ VDD VSS INV_X1
X_2535_ _0739_ _0740_ _0741_ _0742_ _0567_ net235 VDD VSS
+ OAI221_X1
X_2536_ _0661_ _0555_ _0563_ _0743_ VDD VSS NOR3_X1
X_2537_ _0743_ _1543_ _1367_ net236 VDD VSS OAI21_X1
X_2538_ _0235_ _1604_ _0744_ VDD VSS NAND2_X1
X_2539_ _0744_ _0745_ VDD VSS CLKBUF_X3
X_2540_ _0745_ _0746_ VDD VSS CLKBUF_X3
X_2541_ _0234_ _0746_ _0747_ VDD VSS NOR2_X1
X_2542_ _1380_ _1574_ _0748_ VDD VSS NAND2_X1
X_2543_ _0748_ _0749_ VDD VSS BUF_X8
X_2544_ _0749_ _0750_ VDD VSS BUF_X4
X_2545_ _1379_ _0750_ _0751_ VDD VSS NOR2_X1
X_2546_ _1372_ _1559_ _0752_ VDD VSS AND2_X4
Xrebuffer5 _1599_ net343 VDD VSS BUF_X1
X_2548_ _0752_ _0754_ VDD VSS BUF_X4
X_2549_ _0754_ _0755_ VDD VSS BUF_X4
X_2550_ _0500_ _0005_ _0754_ _0756_ VDD VSS NOR3_X1
X_2551_ input_buffer\[1\]\[0\] _0755_ _0756_ _0270_ _0757_
+ VDD VSS AOI22_X1
X_2552_ _0749_ _0758_ VDD VSS BUF_X4
X_2553_ _0751_ _0757_ _0758_ _0314_ _0326_ _0759_ VDD VSS
+ AOI221_X1
X_2554_ _0205_ _0325_ _0760_ VDD VSS AND2_X1
X_2555_ _0760_ _0761_ VDD VSS CLKBUF_X2
X_2556_ _0761_ _0762_ VDD VSS CLKBUF_X3
X_2557_ _0759_ _0762_ _0204_ _0763_ VDD VSS AOI21_X1
X_2558_ _0745_ _0764_ VDD VSS CLKBUF_X3
X_2559_ _0747_ _0763_ _0764_ net238 VDD VSS AOI21_X1
X_2560_ _0239_ _0746_ _0765_ VDD VSS NOR2_X1
X_2561_ _1385_ _0750_ _0766_ VDD VSS NOR2_X1
X_2562_ _0500_ _0015_ _0754_ _0767_ VDD VSS NOR3_X1
X_2563_ input_buffer\[1\]\[10\] _0755_ _0767_ _0270_ _0768_
+ VDD VSS AOI22_X1
X_2564_ _0766_ _0768_ _0758_ _0314_ _0326_ _0769_ VDD VSS
+ AOI221_X1
X_2565_ _0769_ _0762_ _0209_ _0770_ VDD VSS AOI21_X1
X_2566_ _0765_ _0770_ _0764_ net239 VDD VSS AOI21_X1
X_2567_ _0240_ _0746_ _0771_ VDD VSS NOR2_X1
X_2568_ _1386_ _0750_ _0772_ VDD VSS NOR2_X1
X_2569_ _0500_ _0016_ _0754_ _0773_ VDD VSS NOR3_X2
X_2570_ input_buffer\[1\]\[11\] _0755_ _0773_ _0270_ _0774_
+ VDD VSS AOI22_X2
X_2571_ _0772_ _0774_ _0758_ _0314_ _0326_ _0775_ VDD VSS
+ AOI221_X2
X_2572_ _0775_ _0762_ _0210_ _0776_ VDD VSS AOI21_X1
X_2573_ _0771_ _0776_ _0764_ net240 VDD VSS AOI21_X1
X_2574_ _0241_ _0746_ _0777_ VDD VSS NOR2_X1
X_2575_ _1387_ _0750_ _0778_ VDD VSS NOR2_X1
X_2576_ _0500_ _0017_ _0754_ _0779_ VDD VSS NOR3_X1
X_2577_ input_buffer\[1\]\[12\] _0755_ _0779_ _0270_ _0780_
+ VDD VSS AOI22_X2
X_2578_ _0205_ _0781_ VDD VSS BUF_X4
X_2579_ _0778_ _0780_ _0758_ _0781_ _0326_ _0782_ VDD VSS
+ AOI221_X2
X_2580_ _0782_ _0762_ _0211_ _0783_ VDD VSS AOI21_X1
X_2581_ _0777_ _0783_ _0764_ net241 VDD VSS AOI21_X1
X_2582_ _0242_ _0746_ _0784_ VDD VSS NOR2_X1
X_2583_ _1388_ _0750_ _0785_ VDD VSS NOR2_X1
X_2584_ _0500_ _0018_ _0754_ _0786_ VDD VSS NOR3_X1
X_2585_ input_buffer\[1\]\[13\] _0755_ _0786_ _0270_ _0787_
+ VDD VSS AOI22_X2
X_2586_ _0785_ _0787_ _0758_ _0781_ _0326_ _0788_ VDD VSS
+ AOI221_X2
X_2587_ _0788_ _0762_ _0212_ _0789_ VDD VSS AOI21_X1
X_2588_ _0784_ _0789_ _0764_ net242 VDD VSS AOI21_X1
X_2589_ _0243_ _0746_ _0790_ VDD VSS NOR2_X1
X_2590_ _1389_ _0750_ _0791_ VDD VSS NOR2_X1
X_2591_ _0752_ _0792_ VDD VSS BUF_X4
X_2592_ _0500_ _0019_ _0792_ _0793_ VDD VSS NOR3_X1
X_2593_ input_buffer\[1\]\[14\] _0755_ _0793_ _0270_ _0794_
+ VDD VSS AOI22_X2
X_2594_ _0791_ _0794_ _0758_ _0781_ _0326_ _0795_ VDD VSS
+ AOI221_X2
X_2595_ _0795_ _0762_ _0213_ _0796_ VDD VSS AOI21_X1
X_2596_ _0790_ _0796_ _0764_ net243 VDD VSS AOI21_X1
X_2597_ _0244_ _0746_ _0797_ VDD VSS NOR2_X1
X_2598_ _1390_ _0750_ _0798_ VDD VSS NOR2_X1
X_2599_ _1365_ _0799_ VDD VSS CLKBUF_X3
X_2600_ _0799_ _0020_ _0792_ _0800_ VDD VSS NOR3_X1
X_2601_ input_buffer\[1\]\[15\] _0755_ _0800_ _0270_ _0801_
+ VDD VSS AOI22_X2
X_2602_ _0798_ _0801_ _0758_ _0781_ _0326_ _0802_ VDD VSS
+ AOI221_X2
X_2603_ _0802_ _0762_ _0214_ _0803_ VDD VSS AOI21_X1
X_2604_ _0797_ _0803_ _0764_ net244 VDD VSS AOI21_X1
X_2605_ _0245_ _0746_ _0804_ VDD VSS NOR2_X1
X_2606_ _1391_ _0750_ _0805_ VDD VSS NOR2_X1
X_2607_ _0799_ _0021_ _0792_ _0806_ VDD VSS NOR3_X1
X_2608_ input_buffer\[1\]\[16\] _0755_ _0806_ _0270_ _0807_
+ VDD VSS AOI22_X2
X_2609_ _0805_ _0807_ _0758_ _0781_ _0326_ _0808_ VDD VSS
+ AOI221_X2
X_2610_ _0808_ _0762_ _0215_ _0809_ VDD VSS AOI21_X1
X_2611_ _0804_ _0809_ _0764_ net245 VDD VSS AOI21_X1
X_2612_ _0745_ _0810_ VDD VSS CLKBUF_X3
X_2613_ _0246_ _0810_ _0811_ VDD VSS NOR2_X1
X_2614_ _0749_ _0812_ VDD VSS BUF_X4
X_2615_ _1392_ _0812_ _0813_ VDD VSS NOR2_X1
X_2616_ _0799_ _0022_ _0792_ _0814_ VDD VSS NOR3_X1
X_2617_ input_buffer\[1\]\[17\] _0755_ _0814_ _0270_ _0815_
+ VDD VSS AOI22_X1
X_2618_ _0813_ _0815_ _0758_ _0781_ _0326_ _0816_ VDD VSS
+ AOI221_X1
X_2619_ _0816_ _0762_ _0216_ _0817_ VDD VSS AOI21_X1
X_2620_ _0811_ _0817_ _0764_ net246 VDD VSS AOI21_X1
X_2621_ _0247_ _0810_ _0818_ VDD VSS NOR2_X1
X_2622_ _1393_ _0812_ _0819_ VDD VSS NOR2_X1
X_2623_ _0799_ _0023_ _0792_ _0820_ VDD VSS NOR3_X1
X_2624_ _0269_ _0821_ VDD VSS BUF_X4
X_2625_ input_buffer\[1\]\[18\] _0755_ _0820_ _0821_ _0822_
+ VDD VSS AOI22_X1
X_2626_ _0325_ _0823_ VDD VSS BUF_X4
X_2627_ _0819_ _0822_ _0758_ _0781_ _0823_ _0824_ VDD VSS
+ AOI221_X1
X_2628_ _0824_ _0762_ _0217_ _0825_ VDD VSS AOI21_X1
X_2629_ _0818_ _0825_ _0764_ net247 VDD VSS AOI21_X1
X_2630_ _0248_ _0810_ _0826_ VDD VSS NOR2_X1
X_2631_ _1394_ _0812_ _0827_ VDD VSS NOR2_X1
X_2632_ _0754_ _0828_ VDD VSS BUF_X4
X_2633_ _0799_ _0024_ _0792_ _0829_ VDD VSS NOR3_X1
X_2634_ input_buffer\[1\]\[19\] _0828_ _0829_ _0821_ _0830_
+ VDD VSS AOI22_X1
X_2635_ _0749_ _0831_ VDD VSS BUF_X4
X_2636_ _0827_ _0830_ _0831_ _0781_ _0823_ _0832_ VDD VSS
+ AOI221_X1
X_2637_ _0761_ _0833_ VDD VSS CLKBUF_X3
X_2638_ _0832_ _0833_ _0218_ _0834_ VDD VSS AOI21_X1
X_2639_ _0745_ _0835_ VDD VSS CLKBUF_X3
X_2640_ _0826_ _0834_ _0835_ net248 VDD VSS AOI21_X1
X_2641_ _0250_ _0810_ _0836_ VDD VSS NOR2_X1
X_2642_ _1396_ _0812_ _0837_ VDD VSS NOR2_X1
X_2643_ _0799_ _0006_ _0792_ _0838_ VDD VSS NOR3_X1
X_2644_ input_buffer\[1\]\[1\] _0828_ _0838_ _0821_ _0839_
+ VDD VSS AOI22_X1
X_2645_ _0837_ _0839_ _0831_ _0781_ _0823_ _0840_ VDD VSS
+ AOI221_X1
X_2646_ _0840_ _0833_ _0220_ _0841_ VDD VSS AOI21_X1
X_2647_ _0836_ _0841_ _0835_ net249 VDD VSS AOI21_X1
X_2648_ _0251_ _0810_ _0842_ VDD VSS NOR2_X1
X_2649_ _1397_ _0812_ _0843_ VDD VSS NOR2_X1
X_2650_ _0799_ _0025_ _0792_ _0844_ VDD VSS NOR3_X1
X_2651_ input_buffer\[1\]\[20\] _0828_ _0844_ _0821_ _0845_
+ VDD VSS AOI22_X1
X_2652_ _0843_ _0845_ _0831_ _0781_ _0823_ _0846_ VDD VSS
+ AOI221_X1
X_2653_ _0846_ _0833_ _0221_ _0847_ VDD VSS AOI21_X1
X_2654_ _0842_ _0847_ _0835_ net250 VDD VSS AOI21_X1
X_2655_ _0252_ _0810_ _0848_ VDD VSS NOR2_X1
X_2656_ _1398_ _0812_ _0849_ VDD VSS NOR2_X1
X_2657_ _0799_ _0026_ _0792_ _0850_ VDD VSS NOR3_X1
X_2658_ input_buffer\[1\]\[21\] _0828_ _0850_ _0821_ _0851_
+ VDD VSS AOI22_X2
X_2659_ _0205_ _0852_ VDD VSS BUF_X4
X_2660_ _0849_ _0851_ _0831_ _0852_ _0823_ _0853_ VDD VSS
+ AOI221_X2
X_2661_ _0853_ _0833_ _0222_ _0854_ VDD VSS AOI21_X1
X_2662_ _0848_ _0854_ _0835_ net251 VDD VSS AOI21_X1
X_2663_ _0253_ _0810_ _0855_ VDD VSS NOR2_X1
X_2664_ _1399_ _0812_ _0856_ VDD VSS NOR2_X1
X_2665_ _0799_ _0027_ _0792_ _0857_ VDD VSS NOR3_X1
X_2666_ input_buffer\[1\]\[22\] _0828_ _0857_ _0821_ _0858_
+ VDD VSS AOI22_X2
X_2667_ _0856_ _0858_ _0831_ _0852_ _0823_ _0859_ VDD VSS
+ AOI221_X2
X_2668_ _0859_ _0833_ _0223_ _0860_ VDD VSS AOI21_X1
X_2669_ _0855_ _0860_ _0835_ net252 VDD VSS AOI21_X1
X_2670_ _0254_ _0810_ _0861_ VDD VSS NOR2_X1
X_2671_ _1400_ _0812_ _0862_ VDD VSS NOR2_X1
X_2672_ _0752_ _0863_ VDD VSS BUF_X4
X_2673_ _0799_ _0028_ _0863_ _0864_ VDD VSS NOR3_X2
X_2674_ input_buffer\[1\]\[23\] _0828_ _0864_ _0821_ _0865_
+ VDD VSS AOI22_X2
X_2675_ _0862_ _0865_ _0831_ _0852_ _0823_ _0866_ VDD VSS
+ AOI221_X2
X_2676_ _0866_ _0833_ _0224_ _0867_ VDD VSS AOI21_X1
X_2677_ _0861_ _0867_ _0835_ net253 VDD VSS AOI21_X1
X_2678_ _1277_ _0810_ _0868_ VDD VSS NOR2_X1
X_2679_ _1314_ _0812_ _0869_ VDD VSS NOR2_X1
X_2680_ _1365_ _0870_ VDD VSS CLKBUF_X3
X_2681_ _0870_ _0029_ _0863_ _0871_ VDD VSS NOR3_X1
X_2682_ _1333_ _0828_ _0871_ _0821_ _0872_ VDD VSS AOI22_X1
X_2683_ _0869_ _0872_ _0831_ _0852_ _0823_ _0873_ VDD VSS
+ AOI221_X1
X_2684_ _0873_ _0833_ _1300_ _0874_ VDD VSS AOI21_X1
X_2685_ _0868_ _0874_ _0835_ net254 VDD VSS AOI21_X2
X_2686_ _1279_ _0810_ _0875_ VDD VSS NOR2_X1
X_2687_ _1316_ _0812_ _0876_ VDD VSS NOR2_X1
X_2688_ _0870_ _0030_ _0863_ _0877_ VDD VSS NOR3_X1
X_2689_ _1335_ _0828_ _0877_ _0821_ _0878_ VDD VSS AOI22_X2
X_2690_ _0876_ _0878_ _0831_ _0852_ _0823_ _0879_ VDD VSS
+ AOI221_X2
X_2691_ _0879_ _0833_ _1305_ _0880_ VDD VSS AOI21_X1
X_2692_ _0875_ _0880_ _0835_ net255 VDD VSS AOI21_X1
X_2693_ _0745_ _0881_ VDD VSS CLKBUF_X3
X_2694_ _1280_ _0881_ _0882_ VDD VSS NOR2_X1
X_2695_ _0749_ _0883_ VDD VSS BUF_X4
X_2696_ _1317_ _0883_ _0884_ VDD VSS NOR2_X1
X_2697_ _0870_ _0031_ _0863_ _0885_ VDD VSS NOR3_X1
X_2698_ _1336_ _0828_ _0885_ _0821_ _0886_ VDD VSS AOI22_X1
X_2699_ _0884_ _0831_ _0886_ _0852_ _0823_ _0887_ VDD VSS
+ AOI221_X2
X_2700_ _0887_ _0833_ _1295_ _0888_ VDD VSS AOI21_X1
X_2701_ _0882_ _0888_ _0835_ net256 VDD VSS AOI21_X2
X_2702_ _1282_ _0881_ _0889_ VDD VSS NOR2_X1
X_2703_ _1319_ _0883_ _0890_ VDD VSS NOR2_X1
X_2704_ _0870_ _0000_ _0863_ _0891_ VDD VSS NOR3_X1
X_2705_ _0269_ _0892_ VDD VSS BUF_X4
X_2706_ _1338_ _0828_ _0891_ _0892_ _0893_ VDD VSS AOI22_X1
X_2707_ _0325_ _0894_ VDD VSS BUF_X4
X_2708_ _0890_ _0893_ _0831_ _0852_ _0894_ _0895_ VDD VSS
+ AOI221_X1
X_2709_ _0895_ _0833_ _1302_ _0896_ VDD VSS AOI21_X1
X_2710_ _0889_ _0896_ _0835_ net257 VDD VSS AOI21_X1
X_2711_ dest_id\[4\]\[4\] _0881_ _0897_ VDD VSS NOR2_X1
X_2712_ _1310_ _0883_ _0898_ VDD VSS NOR2_X1
X_2713_ _0754_ _0899_ VDD VSS BUF_X4
X_2714_ _0870_ _0001_ _0863_ _0900_ VDD VSS NOR3_X1
X_2715_ _1329_ _0899_ _0900_ _0892_ _0901_ VDD VSS AOI22_X2
X_2716_ _0749_ _0902_ VDD VSS BUF_X4
X_2717_ _0898_ _0901_ _0902_ _0852_ _0894_ _0903_ VDD VSS
+ AOI221_X2
X_2718_ _0761_ _0904_ VDD VSS CLKBUF_X3
X_2719_ _0903_ _0904_ _1290_ _0905_ VDD VSS AOI21_X1
X_2720_ _0745_ _0906_ VDD VSS CLKBUF_X3
X_2721_ _0897_ _0905_ _0906_ net258 VDD VSS AOI21_X1
X_2722_ dest_id\[4\]\[5\] _0881_ _0907_ VDD VSS NOR2_X1
X_2723_ _1309_ _0883_ _0908_ VDD VSS NOR2_X1
X_2724_ _0870_ _0002_ _0863_ _0909_ VDD VSS NOR3_X1
X_2725_ _1328_ _0899_ _0909_ _0892_ _0910_ VDD VSS AOI22_X2
X_2726_ _0908_ _0910_ _0902_ _0852_ _0894_ _0911_ VDD VSS
+ AOI221_X2
X_2727_ _0911_ _0904_ _1289_ _0912_ VDD VSS AOI21_X1
X_2728_ _0907_ _0912_ _0906_ net259 VDD VSS AOI21_X1
X_2729_ _0256_ _0881_ _0913_ VDD VSS NOR2_X1
X_2730_ _1402_ _0883_ _0914_ VDD VSS NOR2_X1
X_2731_ _0870_ _0007_ _0863_ _0915_ VDD VSS NOR3_X1
X_2732_ input_buffer\[1\]\[2\] _0899_ _0915_ _0892_ _0916_
+ VDD VSS AOI22_X2
X_2733_ _0914_ _0916_ _0902_ _0852_ _0894_ _0917_ VDD VSS
+ AOI221_X2
X_2734_ _0917_ _0904_ _0226_ _0918_ VDD VSS AOI21_X1
X_2735_ _0913_ _0918_ _0906_ net260 VDD VSS AOI21_X1
X_2736_ dest_id\[4\]\[6\] _0881_ _0919_ VDD VSS NOR2_X1
X_2737_ _1312_ _0883_ _0920_ VDD VSS NOR2_X1
X_2738_ _0870_ _0003_ _0863_ _0921_ VDD VSS NOR3_X1
X_2739_ _1331_ _0899_ _0921_ _0892_ _0922_ VDD VSS AOI22_X2
X_2740_ _0920_ _0922_ _0902_ _0684_ _0894_ _0923_ VDD VSS
+ AOI221_X2
X_2741_ _0923_ _0904_ _1292_ _0924_ VDD VSS AOI21_X1
X_2742_ _0919_ _0924_ _0906_ net261 VDD VSS AOI21_X1
X_2743_ dest_id\[4\]\[7\] _0881_ _0925_ VDD VSS NOR2_X1
X_2744_ _1311_ _0883_ _0926_ VDD VSS NOR2_X1
X_2745_ _0870_ _0004_ _0863_ _0927_ VDD VSS NOR3_X1
X_2746_ _1330_ _0899_ _0927_ _0892_ _0928_ VDD VSS AOI22_X2
X_2747_ _0926_ _0928_ _0902_ _0684_ _0894_ _0929_ VDD VSS
+ AOI221_X2
X_2748_ _0929_ _0904_ _1291_ _0930_ VDD VSS AOI21_X1
X_2749_ _0925_ _0930_ _0906_ net262 VDD VSS AOI21_X1
X_2750_ _0257_ _0881_ _0931_ VDD VSS NOR2_X1
X_2751_ _0197_ _0883_ _0932_ VDD VSS NOR2_X1
X_2752_ _0870_ _0008_ _0752_ _0933_ VDD VSS NOR3_X1
X_2753_ input_buffer\[1\]\[3\] _0899_ _0933_ _0892_ _0934_
+ VDD VSS AOI22_X1
X_2754_ _0932_ _0934_ _0902_ _0684_ _0894_ _0935_ VDD VSS
+ AOI221_X1
X_2755_ _0935_ _0904_ _0227_ _0936_ VDD VSS AOI21_X1
X_2756_ _0931_ _0936_ _0906_ net263 VDD VSS AOI21_X1
X_2757_ _0258_ _0881_ _0937_ VDD VSS NOR2_X1
X_2758_ _0198_ _0883_ _0938_ VDD VSS NOR2_X1
X_2759_ _1365_ _0009_ _0752_ _0939_ VDD VSS NOR3_X1
X_2760_ input_buffer\[1\]\[4\] _0899_ _0939_ _0892_ _0940_
+ VDD VSS AOI22_X1
X_2761_ _0938_ _0940_ _0902_ _0684_ _0894_ _0941_ VDD VSS
+ AOI221_X1
X_2762_ _0941_ _0904_ _0228_ _0942_ VDD VSS AOI21_X1
X_2763_ _0937_ _0942_ _0906_ net264 VDD VSS AOI21_X1
X_2764_ _0259_ _0881_ _0943_ VDD VSS NOR2_X1
X_2765_ _0199_ _0883_ _0944_ VDD VSS NOR2_X1
X_2766_ _1365_ _0010_ _0752_ _0945_ VDD VSS NOR3_X1
X_2767_ input_buffer\[1\]\[5\] _0899_ _0945_ _0892_ _0946_
+ VDD VSS AOI22_X1
X_2768_ _0944_ _0946_ _0902_ _0684_ _0894_ _0947_ VDD VSS
+ AOI221_X1
X_2769_ _0947_ _0904_ _0229_ _0948_ VDD VSS AOI21_X1
X_2770_ _0943_ _0948_ _0906_ net265 VDD VSS AOI21_X1
X_2771_ _0260_ _0745_ _0949_ VDD VSS NOR2_X1
X_2772_ _0200_ _0749_ _0950_ VDD VSS NOR2_X1
X_2773_ _1365_ _0011_ _0752_ _0951_ VDD VSS NOR3_X1
X_2774_ input_buffer\[1\]\[6\] _0899_ _0951_ _0892_ _0952_
+ VDD VSS AOI22_X1
X_2775_ _0950_ _0952_ _0902_ _0684_ _0894_ _0953_ VDD VSS
+ AOI221_X1
X_2776_ _0953_ _0904_ _0230_ _0954_ VDD VSS AOI21_X1
X_2777_ _0949_ _0954_ _0906_ net266 VDD VSS AOI21_X1
X_2778_ _0261_ _0745_ _0955_ VDD VSS NOR2_X1
X_2779_ _0201_ _0749_ _0956_ VDD VSS NOR2_X1
X_2780_ _1365_ _0012_ _0752_ _0957_ VDD VSS NOR3_X1
X_2781_ input_buffer\[1\]\[7\] _0899_ _0957_ _0269_ _0958_
+ VDD VSS AOI22_X1
X_2782_ _0956_ _0958_ _0902_ _0684_ _0325_ _0959_ VDD VSS
+ AOI221_X1
X_2783_ _0959_ _0904_ _0231_ _0960_ VDD VSS AOI21_X1
X_2784_ _0955_ _0960_ _0906_ net267 VDD VSS AOI21_X1
X_2785_ _0262_ _0745_ _0961_ VDD VSS NOR2_X1
X_2786_ _0202_ _0749_ _0962_ VDD VSS NOR2_X1
X_2787_ _1365_ _0013_ _0752_ _0963_ VDD VSS NOR3_X1
X_2788_ input_buffer\[1\]\[8\] _0754_ _0963_ _0269_ _0964_
+ VDD VSS AOI22_X1
X_2789_ _0962_ _0964_ _0750_ _0684_ _0325_ _0965_ VDD VSS
+ AOI221_X1
X_2790_ _0965_ _0761_ _0232_ _0966_ VDD VSS AOI21_X1
X_2791_ _0961_ _0966_ _0746_ net268 VDD VSS AOI21_X1
X_2792_ _0263_ _0745_ _0967_ VDD VSS NOR2_X1
X_2793_ _0203_ _0749_ _0968_ VDD VSS NOR2_X1
X_2794_ _1365_ _0014_ _0752_ _0969_ VDD VSS NOR3_X1
X_2795_ input_buffer\[1\]\[9\] _0754_ _0969_ _0269_ _0970_
+ VDD VSS AOI22_X1
X_2796_ _0968_ _0970_ _0750_ _0684_ _0325_ _0971_ VDD VSS
+ AOI221_X1
X_2797_ _0971_ _0761_ _0233_ _0972_ VDD VSS AOI21_X1
X_2798_ _0967_ _0972_ _0746_ net269 VDD VSS AOI21_X1
X_2799_ _1302_ _1590_ _0973_ VDD VSS NOR2_X1
X_2800_ _1579_ _1296_ _0346_ _0973_ _0974_ VDD VSS NAND4_X1
X_2801_ _1560_ _0975_ VDD VSS INV_X1
X_2802_ _0284_ _0975_ _1549_ _1337_ _0976_ VDD VSS AND4_X1
X_2803_ _1545_ _0977_ VDD VSS INV_X1
X_2804_ _0264_ _1534_ _0977_ _1360_ _0978_ VDD VSS AND4_X1
X_2805_ _1345_ _0976_ _0978_ _1358_ _0979_ VDD VSS AOI22_X1
X_2806_ _1564_ _0980_ VDD VSS INV_X1
X_2807_ _1575_ _0980_ _1321_ _0981_ VDD VSS NOR3_X1
X_2808_ _0376_ _0310_ _0981_ _0982_ VDD VSS NAND3_X1
X_2809_ _0330_ _1594_ _0983_ VDD VSS NAND2_X1
X_2810_ _1605_ _1592_ _0334_ _0983_ _0984_ VDD VSS OR4_X1
X_2811_ _0974_ _0979_ _0982_ _0984_ net270 VDD VSS NAND4_X1
X_2812_ _0235_ _1601_ _0985_ VDD VSS NAND2_X1
X_2813_ _1275_ _0985_ _0340_ _0341_ _0986_ VDD VSS AOI211_X4
X_2814_ _0986_ _0987_ VDD VSS BUF_X4
X_2815_ _0987_ _0988_ VDD VSS CLKBUF_X3
X_2816_ _1586_ _0346_ _1298_ _1296_ _0989_ VDD VSS OAI211_X4
X_2817_ _0989_ _0986_ _0990_ VDD VSS NOR2_X4
X_2818_ _0990_ _0991_ VDD VSS CLKBUF_X3
X_2819_ _0234_ _0988_ _0991_ _0204_ _0992_ VDD VSS AOI22_X1
X_2820_ _1380_ _0304_ _1313_ _0352_ _0993_ VDD VSS NAND4_X4
X_2821_ _0989_ _0985_ _1285_ _0993_ _1379_ _0994_ VDD VSS
+ OAI221_X2
X_2822_ _1380_ _0304_ _1313_ _0995_ VDD VSS NAND3_X2
X_2823_ _0995_ _1327_ _0308_ _0996_ VDD VSS AOI21_X4
X_2824_ _1541_ _0997_ VDD VSS INV_X2
X_2825_ _1372_ _0288_ net342 _0998_ VDD VSS NAND3_X2
X_2826_ _0998_ _0296_ _0293_ _0999_ VDD VSS AOI21_X4
X_2827_ _0997_ _0999_ _1000_ VDD VSS NOR2_X4
X_2828_ _0288_ _1001_ VDD VSS INV_X1
X_2829_ _1001_ _0365_ _1002_ VDD VSS NOR2_X1
X_2830_ _0996_ _1000_ _0363_ _1558_ _1002_ _1003_ VDD VSS
+ AOI221_X1
X_2831_ _0992_ _0994_ _1003_ net272 VDD VSS OAI21_X1
X_2832_ _0239_ _0988_ _0991_ _0209_ _1004_ VDD VSS AOI22_X1
X_2833_ _1586_ _1005_ VDD VSS INV_X1
X_2834_ _1005_ _0369_ _1308_ _0321_ _1006_ VDD VSS AOI211_X2
X_2835_ _1006_ _0986_ _1007_ VDD VSS NOR2_X4
X_2836_ _1007_ _1008_ VDD VSS CLKBUF_X3
X_2837_ _0993_ _1009_ VDD VSS CLKBUF_X3
X_2838_ _1008_ _1009_ _1385_ _1010_ VDD VSS OAI21_X1
X_2839_ _0304_ _1011_ VDD VSS INV_X1
X_2840_ _1011_ _0377_ _1012_ VDD VSS NOR2_X4
X_2841_ _1012_ _1013_ VDD VSS BUF_X4
X_2842_ _1001_ _1341_ _1014_ VDD VSS NOR2_X2
X_2843_ _1014_ _1015_ VDD VSS BUF_X4
X_2844_ _1000_ _1016_ VDD VSS BUF_X4
X_2845_ _1013_ _1015_ _0384_ _1016_ _0383_ _1017_ VDD VSS
+ AOI221_X1
X_2846_ _1004_ _1010_ _1017_ net273 VDD VSS OAI21_X1
X_2847_ _0240_ _0988_ _0991_ _0210_ _1018_ VDD VSS AOI22_X1
X_2848_ _1008_ _1009_ _1386_ _1019_ VDD VSS OAI21_X1
X_2849_ _1001_ _0392_ _1020_ VDD VSS NOR2_X1
X_2850_ _0996_ _1020_ _1558_ _0391_ _1000_ _1021_ VDD VSS
+ AOI221_X2
X_2851_ _1018_ _1019_ _1021_ net274 VDD VSS OAI21_X1
X_2852_ _0241_ _0988_ _0991_ _0211_ _1022_ VDD VSS AOI22_X1
X_2853_ _1008_ _1009_ _1387_ _1023_ VDD VSS OAI21_X1
X_2854_ _1013_ _1015_ _0399_ _1016_ _0398_ _1024_ VDD VSS
+ AOI221_X2
X_2855_ _1022_ _1023_ _1024_ net275 VDD VSS OAI21_X1
X_2856_ _0242_ _0988_ _0991_ _0212_ _1025_ VDD VSS AOI22_X1
X_2857_ _1008_ _1009_ _1388_ _1026_ VDD VSS OAI21_X1
X_2858_ _1013_ _1015_ _0405_ _1016_ _0404_ _1027_ VDD VSS
+ AOI221_X2
X_2859_ _1025_ _1026_ _1027_ net276 VDD VSS OAI21_X1
X_2860_ _0243_ _0988_ _0991_ _0213_ _1028_ VDD VSS AOI22_X1
X_2861_ _1008_ _1009_ _1389_ _1029_ VDD VSS OAI21_X1
X_2862_ _1013_ _1015_ _0410_ _1016_ _0409_ _1030_ VDD VSS
+ AOI221_X2
X_2863_ _1028_ _1029_ _1030_ net277 VDD VSS OAI21_X1
X_2864_ _0244_ _0988_ _0991_ _0214_ _1031_ VDD VSS AOI22_X1
X_2865_ _1008_ _1009_ _1390_ _1032_ VDD VSS OAI21_X1
X_2866_ _1013_ _1015_ _0415_ _1016_ _0414_ _1033_ VDD VSS
+ AOI221_X2
X_2867_ _1031_ _1032_ _1033_ net278 VDD VSS OAI21_X1
X_2868_ _0245_ _0988_ _0991_ _0215_ _1034_ VDD VSS AOI22_X1
X_2869_ _1008_ _1009_ _1391_ _1035_ VDD VSS OAI21_X1
X_2870_ _1013_ _1015_ _0421_ _1016_ _0420_ _1036_ VDD VSS
+ AOI221_X2
X_2871_ _1034_ _1035_ _1036_ net279 VDD VSS OAI21_X1
X_2872_ _0246_ _0988_ _0991_ _0216_ _1037_ VDD VSS AOI22_X1
X_2873_ _1008_ _1009_ _1392_ _1038_ VDD VSS OAI21_X1
X_2874_ _1012_ _1039_ VDD VSS BUF_X4
X_2875_ _1039_ _1015_ _0427_ _1016_ _0425_ _1040_ VDD VSS
+ AOI221_X1
X_2876_ _1037_ _1038_ _1040_ net280 VDD VSS OAI21_X1
X_2877_ _0986_ _1041_ VDD VSS CLKBUF_X3
X_2878_ _0247_ _1041_ _0991_ _0217_ _1042_ VDD VSS AOI22_X1
X_2879_ _1008_ _1009_ _1393_ _1043_ VDD VSS OAI21_X1
X_2880_ _1039_ _1015_ _0433_ _1016_ _0432_ _1044_ VDD VSS
+ AOI221_X1
X_2881_ _1042_ _1043_ _1044_ net281 VDD VSS OAI21_X1
X_2882_ _0990_ _1045_ VDD VSS CLKBUF_X3
X_2883_ _0248_ _1041_ _1045_ _0218_ _1046_ VDD VSS AOI22_X1
X_2884_ _1008_ _1009_ _1394_ _1047_ VDD VSS OAI21_X1
X_2885_ _0288_ _0441_ _1048_ VDD VSS AND2_X1
X_2886_ _0996_ _1048_ _1558_ _0440_ _1000_ _1049_ VDD VSS
+ AOI221_X2
X_2887_ _1046_ _1047_ _1049_ net282 VDD VSS OAI21_X1
X_2888_ _0250_ _1041_ _1045_ _0220_ _1050_ VDD VSS AOI22_X1
X_2889_ _1007_ _1051_ VDD VSS CLKBUF_X3
X_2890_ _0993_ _1052_ VDD VSS CLKBUF_X3
X_2891_ _1051_ _1052_ _1396_ _1053_ VDD VSS OAI21_X1
X_2892_ _1039_ _1015_ _0448_ _1016_ _0447_ _1054_ VDD VSS
+ AOI221_X2
X_2893_ _1050_ _1053_ _1054_ net283 VDD VSS OAI21_X1
X_2894_ _0251_ _1041_ _1045_ _0221_ _1055_ VDD VSS AOI22_X1
X_2895_ _1051_ _1052_ _1397_ _1056_ VDD VSS OAI21_X1
X_2896_ _1039_ _1015_ _0455_ _1016_ _0454_ _1057_ VDD VSS
+ AOI221_X2
X_2897_ _1055_ _1056_ _1057_ net284 VDD VSS OAI21_X1
X_2898_ _0252_ _1041_ _1045_ _0222_ _1058_ VDD VSS AOI22_X1
X_2899_ _1051_ _1052_ _1398_ _1059_ VDD VSS OAI21_X1
X_2900_ _1014_ _1060_ VDD VSS BUF_X4
X_2901_ _1000_ _1061_ VDD VSS BUF_X4
X_2902_ _1039_ _1060_ _0461_ _1061_ _0460_ _1062_ VDD VSS
+ AOI221_X1
X_2903_ _1058_ _1059_ _1062_ net285 VDD VSS OAI21_X1
X_2904_ _0253_ _1041_ _1045_ _0223_ _1063_ VDD VSS AOI22_X1
X_2905_ _1051_ _1052_ _1399_ _1064_ VDD VSS OAI21_X1
X_2906_ _1039_ _1060_ _0466_ _1061_ _0465_ _1065_ VDD VSS
+ AOI221_X1
X_2907_ _1063_ _1064_ _1065_ net286 VDD VSS OAI21_X1
X_2908_ _0254_ _1041_ _1045_ _0224_ _1066_ VDD VSS AOI22_X1
X_2909_ _1051_ _1052_ _1400_ _1067_ VDD VSS OAI21_X1
X_2910_ _1039_ _1060_ _0471_ _1061_ _0470_ _1068_ VDD VSS
+ AOI221_X2
X_2911_ _1066_ _1067_ _1068_ net287 VDD VSS OAI21_X1
X_2912_ _1277_ _1041_ _1045_ _1300_ _1069_ VDD VSS AOI22_X1
X_2913_ _1051_ _1052_ _1314_ _1070_ VDD VSS OAI21_X1
X_2914_ _0997_ _0380_ _0477_ _0999_ _1071_ VDD VSS NOR4_X1
X_2915_ _1333_ _0999_ _1072_ VDD VSS AND2_X1
X_2916_ _1013_ _1071_ _1072_ _1073_ VDD VSS NOR3_X1
X_2917_ _1069_ _1070_ _1073_ net288 VDD VSS OAI21_X1
X_2918_ _1279_ _1041_ _1045_ _1305_ _1074_ VDD VSS AOI22_X1
X_2919_ _1051_ _1052_ _1316_ _1075_ VDD VSS OAI21_X1
X_2920_ _1039_ _1060_ _0483_ _1061_ _0482_ _1076_ VDD VSS
+ AOI221_X1
X_2921_ _1074_ _1075_ _1076_ net289 VDD VSS OAI21_X1
X_2922_ _1278_ _1041_ _1045_ _1295_ _1077_ VDD VSS AOI22_X1
X_2923_ _1051_ _1052_ _1317_ _1078_ VDD VSS OAI21_X1
X_2924_ _0997_ _0380_ _0488_ _0999_ _1079_ VDD VSS NOR4_X1
X_2925_ _1339_ _0296_ _0998_ _1080_ VDD VSS NOR3_X1
X_2926_ _1013_ _1079_ _1080_ _1081_ VDD VSS NOR3_X1
X_2927_ _1077_ _1078_ _1081_ net290 VDD VSS OAI21_X1
X_2928_ _1006_ _0996_ _1326_ _1082_ VDD VSS AOI21_X1
X_2929_ _1001_ _0560_ _0495_ _0999_ _0494_ _0997_ _1083_ VDD
+ VSS OAI33_X1
X_2930_ _1082_ _1083_ _1013_ _1084_ VDD VSS OAI21_X1
X_2931_ _0987_ _1006_ _1302_ _1085_ VDD VSS AOI21_X1
X_2932_ _1287_ _0988_ _1084_ _1085_ net291 VDD VSS AOI22_X2
X_2933_ _1541_ _1543_ _0989_ _1086_ VDD VSS NAND3_X1
X_2934_ _0999_ _1013_ _0986_ _1086_ _1087_ VDD VSS OR4_X2
X_2935_ _0501_ _1087_ net292 VDD VSS NOR2_X1
X_2936_ _0504_ _1087_ net293 VDD VSS NOR2_X1
X_2937_ _0256_ _0987_ _1045_ _0226_ _1088_ VDD VSS AOI22_X1
X_2938_ _1051_ _1052_ _1402_ _1089_ VDD VSS OAI21_X1
X_2939_ _1039_ _1060_ _0508_ _1061_ _0507_ _1090_ VDD VSS
+ AOI221_X1
X_2940_ _1088_ _1089_ _1090_ net294 VDD VSS OAI21_X1
X_2941_ _0510_ _1087_ net295 VDD VSS NOR2_X1
X_2942_ _0511_ _1087_ net296 VDD VSS NOR2_X1
X_2943_ _0257_ _0987_ _0990_ _0227_ _1091_ VDD VSS AOI22_X1
X_2944_ _1051_ _1052_ _0197_ _1092_ VDD VSS OAI21_X1
X_2945_ _0288_ _0515_ _1093_ VDD VSS AND2_X1
X_2946_ _0996_ _1093_ _1558_ _0514_ _1000_ _1094_ VDD VSS
+ AOI221_X2
X_2947_ _1091_ _1092_ _1094_ net297 VDD VSS OAI21_X1
X_2948_ _0258_ _0987_ _0990_ _0228_ _1095_ VDD VSS AOI22_X1
X_2949_ _1007_ _0993_ _0198_ _1096_ VDD VSS OAI21_X1
X_2950_ _1039_ _1060_ _0520_ _1061_ _0519_ _1097_ VDD VSS
+ AOI221_X1
X_2951_ _1095_ _1096_ _1097_ net298 VDD VSS OAI21_X1
X_2952_ _0259_ _0987_ _0990_ _0229_ _1098_ VDD VSS AOI22_X1
X_2953_ _1007_ _0993_ _0199_ _1099_ VDD VSS OAI21_X1
X_2954_ _1012_ _1060_ _0525_ _1061_ _0524_ _1100_ VDD VSS
+ AOI221_X2
X_2955_ _1098_ _1099_ _1100_ net299 VDD VSS OAI21_X1
X_2956_ _0260_ _0987_ _0990_ _0230_ _1101_ VDD VSS AOI22_X1
X_2957_ _1007_ _0993_ _0200_ _1102_ VDD VSS OAI21_X1
X_2958_ _1012_ _1060_ _0530_ _1061_ _0529_ _1103_ VDD VSS
+ AOI221_X2
X_2959_ _1101_ _1102_ _1103_ net300 VDD VSS OAI21_X1
X_2960_ _0261_ _0987_ _0990_ _0231_ _1104_ VDD VSS AOI22_X1
X_2961_ _1007_ _0993_ _0201_ _1105_ VDD VSS OAI21_X1
X_2962_ _1012_ _1060_ _0535_ _1061_ _0534_ _1106_ VDD VSS
+ AOI221_X1
X_2963_ _1104_ _1105_ _1106_ net301 VDD VSS OAI21_X1
X_2964_ _0262_ _0987_ _0990_ _0232_ _1107_ VDD VSS AOI22_X1
X_2965_ _1007_ _0993_ _0202_ _1108_ VDD VSS OAI21_X1
X_2966_ _0288_ _0540_ _1109_ VDD VSS AND2_X1
X_2967_ _0996_ _1109_ _1342_ _0539_ _1000_ _1110_ VDD VSS
+ AOI221_X1
X_2968_ _1107_ _1108_ _1110_ net302 VDD VSS OAI21_X1
X_2969_ _0263_ _0987_ _0990_ _0233_ _1111_ VDD VSS AOI22_X1
X_2970_ _1007_ _0993_ _0203_ _1112_ VDD VSS OAI21_X1
X_2971_ _1012_ _1060_ _0546_ _1061_ _0545_ _1113_ VDD VSS
+ AOI221_X1
X_2972_ _1111_ _1112_ _1113_ net303 VDD VSS OAI21_X1
X_2973_ _1358_ _1360_ _1357_ _1114_ VDD VSS OAI21_X1
X_2974_ _1367_ _1534_ _0977_ _1115_ VDD VSS NOR3_X1
X_2975_ _1304_ _1301_ _1296_ _1116_ VDD VSS OAI21_X1
X_2976_ _1590_ _1117_ VDD VSS INV_X1
X_2977_ _0206_ _1117_ _1579_ _1118_ VDD VSS NOR3_X1
X_2978_ _1345_ _1343_ _1337_ _1119_ VDD VSS OAI21_X1
X_2979_ _1374_ _0975_ _1549_ _1120_ VDD VSS NOR3_X1
X_2980_ _1114_ _1115_ _1116_ _1118_ _1119_ _1120_ _1121_ VDD
+ VSS AOI222_X2
X_2981_ _1313_ _1321_ _0310_ _1122_ VDD VSS OAI21_X1
X_2982_ _1122_ _1123_ VDD VSS INV_X1
X_2983_ _0980_ _0549_ _1124_ VDD VSS NAND2_X1
X_2984_ _1594_ _1125_ VDD VSS INV_X1
X_2985_ _1125_ _0334_ _0548_ _1126_ VDD VSS NAND3_X1
X_2986_ _1121_ _1123_ _1124_ _1126_ _1592_ net304 VDD VSS
+ OAI221_X1
X_2987_ _0330_ net343 _1603_ _1127_ VDD VSS NAND3_X4
X_2988_ _0234_ _1127_ _1128_ VDD VSS NOR2_X1
X_2989_ _0235_ net343 _1603_ _1129_ VDD VSS AND3_X1
X_2990_ _1129_ _1130_ VDD VSS CLKBUF_X3
X_2991_ _0327_ _1131_ VDD VSS INV_X1
X_2992_ _1131_ _0369_ _1308_ _0321_ _1132_ VDD VSS AOI211_X4
X_2993_ _1130_ _1132_ _0204_ _1133_ VDD VSS AOI21_X1
X_2994_ _0327_ _0346_ _1298_ _1296_ _1134_ VDD VSS OAI211_X4
X_2995_ _0303_ _0376_ _1321_ _1318_ _1135_ VDD VSS OAI211_X4
X_2996_ _1135_ _1136_ VDD VSS CLKBUF_X3
X_2997_ _0287_ net341 _1337_ _1340_ _1137_ VDD VSS OAI211_X2
X_2998_ _1136_ _1137_ _0365_ _1138_ VDD VSS OAI21_X1
X_2999_ _1373_ _0287_ net340 _1139_ VDD VSS AND3_X1
X_3000_ _1139_ _1340_ _1337_ _1140_ VDD VSS OAI21_X4
X_3001_ _0268_ _1543_ _0362_ _1140_ _1141_ VDD VSS AND4_X1
X_3002_ _1134_ _1138_ _1141_ _1379_ _1136_ _1142_ VDD VSS
+ OAI221_X1
X_3003_ _1128_ _1133_ _1142_ net306 VDD VSS AOI21_X1
X_3004_ _0239_ _1127_ _1143_ VDD VSS NOR2_X1
X_3005_ _1130_ _1132_ _0209_ _1144_ VDD VSS AOI21_X1
X_3006_ _0268_ _1145_ VDD VSS INV_X2
X_3007_ _1372_ _0287_ _1332_ _1146_ VDD VSS NAND3_X1
X_3008_ _1146_ _0296_ _0293_ _1147_ VDD VSS AOI21_X4
X_3009_ _1145_ _0380_ _0382_ _1147_ _1148_ VDD VSS NOR4_X1
X_3010_ _0284_ input_buffer\[1\]\[10\] _1149_ VDD VSS NAND2_X1
X_3011_ _1136_ _1137_ _1149_ _1150_ VDD VSS OAI21_X1
X_3012_ _1134_ _1148_ _1150_ _1136_ _1385_ _1151_ VDD VSS
+ OAI221_X1
X_3013_ _1143_ _1144_ _1151_ net307 VDD VSS AOI21_X1
X_3014_ _0240_ _1127_ _1152_ VDD VSS NOR2_X1
X_3015_ _1130_ _1132_ _0210_ _1153_ VDD VSS AOI21_X1
X_3016_ _0268_ _1543_ _0390_ _1140_ _1154_ VDD VSS AND4_X1
X_3017_ _1136_ _1137_ _0392_ _1155_ VDD VSS OAI21_X1
X_3018_ _1134_ _1154_ _1155_ _1136_ _1386_ _1156_ VDD VSS
+ OAI221_X1
X_3019_ _1152_ _1153_ _1156_ net308 VDD VSS AOI21_X1
X_3020_ _0235_ _1599_ _1157_ VDD VSS NAND2_X1
X_3021_ _1275_ _1157_ _0340_ _0341_ _1158_ VDD VSS AOI211_X4
X_3022_ _1158_ _1159_ VDD VSS CLKBUF_X3
X_3023_ _1134_ _1158_ _1160_ VDD VSS NOR2_X2
X_3024_ _1160_ _1161_ VDD VSS CLKBUF_X3
X_3025_ _0241_ _1159_ _1161_ _0211_ _1162_ VDD VSS AOI22_X1
X_3026_ _1132_ _1158_ _1163_ VDD VSS NOR2_X2
X_3027_ _1163_ _1164_ VDD VSS CLKBUF_X3
X_3028_ _0303_ _1165_ VDD VSS INV_X1
X_3029_ _1381_ _1165_ _1323_ _1166_ VDD VSS NOR3_X2
X_3030_ _0352_ _1166_ _1167_ VDD VSS NAND2_X2
X_3031_ _1167_ _1168_ VDD VSS CLKBUF_X3
X_3032_ _1164_ _1168_ _1387_ _1169_ VDD VSS OAI21_X1
X_3033_ _1165_ _0377_ _1170_ VDD VSS NOR2_X4
X_3034_ _1170_ _1171_ VDD VSS BUF_X4
X_3035_ _0287_ _1342_ _1172_ VDD VSS AND2_X1
X_3036_ _1172_ _1173_ VDD VSS BUF_X4
X_3037_ _1173_ _1174_ VDD VSS BUF_X4
X_3038_ _1145_ _1147_ _1175_ VDD VSS NOR2_X2
X_3039_ _1175_ _1176_ VDD VSS BUF_X4
X_3040_ _1171_ _1174_ _0399_ _1176_ _0398_ _1177_ VDD VSS
+ AOI221_X2
X_3041_ _1162_ _1169_ _1177_ net309 VDD VSS OAI21_X1
X_3042_ _0242_ _1159_ _1161_ _0212_ _1178_ VDD VSS AOI22_X1
X_3043_ _1164_ _1168_ _1388_ _1179_ VDD VSS OAI21_X1
X_3044_ _1171_ _1174_ _0405_ _1176_ _0404_ _1180_ VDD VSS
+ AOI221_X2
X_3045_ _1178_ _1179_ _1180_ net310 VDD VSS OAI21_X1
X_3046_ _0243_ _1159_ _1161_ _0213_ _1181_ VDD VSS AOI22_X1
X_3047_ _1164_ _1168_ _1389_ _1182_ VDD VSS OAI21_X1
X_3048_ _1171_ _1174_ _0410_ _1176_ _0409_ _1183_ VDD VSS
+ AOI221_X2
X_3049_ _1181_ _1182_ _1183_ net311 VDD VSS OAI21_X1
X_3050_ _0244_ _1159_ _1161_ _0214_ _1184_ VDD VSS AOI22_X1
X_3051_ _1164_ _1168_ _1390_ _1185_ VDD VSS OAI21_X1
X_3052_ _1171_ _1174_ _0415_ _1176_ _0414_ _1186_ VDD VSS
+ AOI221_X2
X_3053_ _1184_ _1185_ _1186_ net312 VDD VSS OAI21_X1
X_3054_ _0245_ _1159_ _1161_ _0215_ _1187_ VDD VSS AOI22_X1
X_3055_ _1164_ _1168_ _1391_ _1188_ VDD VSS OAI21_X1
X_3056_ _1171_ _1174_ _0421_ _1176_ _0420_ _1189_ VDD VSS
+ AOI221_X2
X_3057_ _1187_ _1188_ _1189_ net313 VDD VSS OAI21_X1
X_3058_ _0246_ _1159_ _1161_ _0216_ _1190_ VDD VSS AOI22_X1
X_3059_ _1164_ _1168_ _1392_ _1191_ VDD VSS OAI21_X1
X_3060_ _1171_ _1174_ _0427_ _1176_ _0425_ _1192_ VDD VSS
+ AOI221_X1
X_3061_ _1190_ _1191_ _1192_ net314 VDD VSS OAI21_X1
X_3062_ _0247_ _1159_ _1161_ _0217_ _1193_ VDD VSS AOI22_X1
X_3063_ _1164_ _1168_ _1393_ _1194_ VDD VSS OAI21_X1
X_3064_ _1171_ _1174_ _0433_ _1176_ _0432_ _1195_ VDD VSS
+ AOI221_X1
X_3065_ _1193_ _1194_ _1195_ net315 VDD VSS OAI21_X1
X_3066_ _0248_ _1159_ _1161_ _0218_ _1196_ VDD VSS AOI22_X1
X_3067_ _1164_ _1168_ _1394_ _1197_ VDD VSS OAI21_X1
X_3068_ _1171_ _1174_ _0441_ _1176_ _0440_ _1198_ VDD VSS
+ AOI221_X1
X_3069_ _1196_ _1197_ _1198_ net316 VDD VSS OAI21_X1
X_3070_ _0250_ _1159_ _1161_ _0220_ _1199_ VDD VSS AOI22_X1
X_3071_ _1164_ _1168_ _1396_ _1200_ VDD VSS OAI21_X1
X_3072_ _1171_ _1174_ _0448_ _1176_ _0447_ _1201_ VDD VSS
+ AOI221_X1
X_3073_ _1199_ _1200_ _1201_ net317 VDD VSS OAI21_X1
X_3074_ _0251_ _1127_ _1202_ VDD VSS NOR2_X1
X_3075_ _1130_ _1132_ _0221_ _1203_ VDD VSS AOI21_X1
X_3076_ _1145_ _0380_ _0453_ _1147_ _1204_ VDD VSS NOR4_X1
X_3077_ _0284_ input_buffer\[1\]\[20\] _1205_ VDD VSS NAND2_X1
X_3078_ _1135_ _1137_ _1205_ _1206_ VDD VSS OAI21_X1
X_3079_ _1134_ _1204_ _1206_ _1136_ _1397_ _1207_ VDD VSS
+ OAI221_X1
X_3080_ _1202_ _1203_ _1207_ net318 VDD VSS AOI21_X1
X_3081_ _0252_ _1159_ _1161_ _0222_ _1208_ VDD VSS AOI22_X1
X_3082_ _1164_ _1168_ _1398_ _1209_ VDD VSS OAI21_X1
X_3083_ _1170_ _1174_ _0461_ _1176_ _0460_ _1210_ VDD VSS
+ AOI221_X1
X_3084_ _1208_ _1209_ _1210_ net319 VDD VSS OAI21_X1
X_3085_ _1158_ _1211_ VDD VSS CLKBUF_X3
X_3086_ _1160_ _1212_ VDD VSS CLKBUF_X3
X_3087_ _0253_ _1211_ _1212_ _0223_ _1213_ VDD VSS AOI22_X1
X_3088_ _1163_ _1214_ VDD VSS CLKBUF_X3
X_3089_ _1167_ _1215_ VDD VSS CLKBUF_X3
X_3090_ _1214_ _1215_ _1399_ _1216_ VDD VSS OAI21_X1
X_3091_ _1175_ _1217_ VDD VSS BUF_X4
X_3092_ _1170_ _1173_ _0466_ _1217_ _0465_ _1218_ VDD VSS
+ AOI221_X1
X_3093_ _1213_ _1216_ _1218_ net320 VDD VSS OAI21_X1
X_3094_ _0254_ _1211_ _1212_ _0224_ _1219_ VDD VSS AOI22_X1
X_3095_ _1214_ _1215_ _1400_ _1220_ VDD VSS OAI21_X1
X_3096_ _1170_ _1173_ _0471_ _1217_ _0470_ _1221_ VDD VSS
+ AOI221_X1
X_3097_ _1219_ _1220_ _1221_ net321 VDD VSS OAI21_X1
X_3098_ _1145_ _0380_ _0477_ _1147_ _1222_ VDD VSS NOR4_X2
X_3099_ _1135_ _1140_ _1334_ _1223_ VDD VSS OAI21_X1
X_3100_ _1134_ _1222_ _1223_ _1136_ _1314_ _1224_ VDD VSS
+ OAI221_X2
X_3101_ _1130_ _1132_ _1300_ _1225_ VDD VSS AOI21_X1
X_3102_ _1278_ _1130_ _1224_ _1225_ net322 VDD VSS AOI22_X2
X_3103_ _1279_ _1211_ _1212_ _1305_ _1226_ VDD VSS AOI22_X1
X_3104_ _1214_ _1215_ _1316_ _1227_ VDD VSS OAI21_X1
X_3105_ _1170_ _1173_ _0483_ _1217_ _0482_ _1228_ VDD VSS
+ AOI221_X1
X_3106_ _1226_ _1227_ _1228_ net323 VDD VSS OAI21_X1
X_3107_ _1280_ _1211_ _1212_ _1295_ _1229_ VDD VSS AOI22_X1
X_3108_ _1214_ _1215_ _1315_ _1230_ VDD VSS OAI21_X1
X_3109_ _1339_ _1140_ _1231_ VDD VSS NOR2_X1
X_3110_ _1145_ _0380_ _0488_ _1147_ _1232_ VDD VSS NOR4_X1
X_3111_ _1171_ _1231_ _1232_ _1233_ VDD VSS NOR3_X1
X_3112_ _1229_ _1230_ _1233_ net324 VDD VSS OAI21_X1
X_3113_ _1145_ _0494_ _1147_ _1234_ VDD VSS NOR3_X1
X_3114_ _0287_ _0675_ _1235_ VDD VSS NAND2_X1
X_3115_ _1135_ _1235_ _0496_ _1236_ VDD VSS OAI21_X1
X_3116_ _1134_ _1234_ _1236_ _1136_ _1319_ _1237_ VDD VSS
+ OAI221_X2
X_3117_ _1130_ _1132_ _1302_ _1238_ VDD VSS AOI21_X1
X_3118_ _1287_ _1130_ _1237_ _1238_ net325 VDD VSS AOI22_X2
X_3119_ _1145_ _0380_ _1132_ _1239_ VDD VSS NOR3_X2
X_3120_ _1140_ _1136_ _1127_ _1239_ _1240_ VDD VSS NAND4_X4
X_3121_ _0501_ _1240_ net326 VDD VSS NOR2_X1
X_3122_ _0504_ _1240_ net327 VDD VSS NOR2_X1
X_3123_ _0256_ _1211_ _1212_ _0226_ _1241_ VDD VSS AOI22_X1
X_3124_ _1214_ _1215_ _1402_ _1242_ VDD VSS OAI21_X1
X_3125_ _1170_ _1173_ _0508_ _1217_ _0507_ _1243_ VDD VSS
+ AOI221_X1
X_3126_ _1241_ _1242_ _1243_ net328 VDD VSS OAI21_X1
X_3127_ _0510_ _1240_ net329 VDD VSS NOR2_X1
X_3128_ _0511_ _1240_ net330 VDD VSS NOR2_X1
X_3129_ _0257_ _1211_ _1212_ _0227_ _1244_ VDD VSS AOI22_X1
X_3130_ _1214_ _1215_ _0197_ _1245_ VDD VSS OAI21_X1
X_3131_ _1170_ _1173_ _0515_ _1217_ _0514_ _1246_ VDD VSS
+ AOI221_X1
X_3132_ _1244_ _1245_ _1246_ net331 VDD VSS OAI21_X1
X_3133_ _0258_ _1211_ _1212_ _0228_ _1247_ VDD VSS AOI22_X1
X_3134_ _1214_ _1215_ _0198_ _1248_ VDD VSS OAI21_X1
X_3135_ _1170_ _1173_ _0520_ _1217_ _0519_ _1249_ VDD VSS
+ AOI221_X1
X_3136_ _1247_ _1248_ _1249_ net332 VDD VSS OAI21_X1
X_3137_ _0259_ _1211_ _1212_ _0229_ _1250_ VDD VSS AOI22_X1
X_3138_ _1214_ _1215_ _0199_ _1251_ VDD VSS OAI21_X1
X_3139_ _0352_ _1166_ _1252_ VDD VSS AND2_X1
X_3140_ _0287_ _0525_ _1253_ VDD VSS AND2_X1
X_3141_ _1252_ _1253_ _1342_ _0524_ _1217_ _1254_ VDD VSS
+ AOI221_X2
X_3142_ _1250_ _1251_ _1254_ net333 VDD VSS OAI21_X1
X_3143_ _0260_ _1211_ _1212_ _0230_ _1255_ VDD VSS AOI22_X1
X_3144_ _1214_ _1215_ _0200_ _1256_ VDD VSS OAI21_X1
X_3145_ _1170_ _1173_ _0530_ _1217_ _0529_ _1257_ VDD VSS
+ AOI221_X2
X_3146_ _1255_ _1256_ _1257_ net334 VDD VSS OAI21_X1
X_3147_ _0261_ _1211_ _1212_ _0231_ _1258_ VDD VSS AOI22_X1
X_3148_ _1214_ _1215_ _0201_ _1259_ VDD VSS OAI21_X1
X_3149_ _0287_ _0535_ _1260_ VDD VSS AND2_X1
X_3150_ _1252_ _1260_ _1342_ _0534_ _1217_ _1261_ VDD VSS
+ AOI221_X2
X_3151_ _1258_ _1259_ _1261_ net335 VDD VSS OAI21_X1
X_3152_ _0262_ _1158_ _1160_ _0232_ _1262_ VDD VSS AOI22_X1
X_3153_ _1163_ _1167_ _0202_ _1263_ VDD VSS OAI21_X1
X_3154_ _0287_ _0540_ _1264_ VDD VSS AND2_X1
X_3155_ _1252_ _1264_ _1342_ _0539_ _1175_ _1265_ VDD VSS
+ AOI221_X1
X_3156_ _1262_ _1263_ _1265_ net336 VDD VSS OAI21_X1
X_3157_ _0263_ _1158_ _1160_ _0233_ _1266_ VDD VSS AOI22_X1
X_3158_ _1163_ _1167_ _0203_ _1267_ VDD VSS OAI21_X1
X_3159_ _1170_ _1173_ _0546_ _1217_ _0545_ _1268_ VDD VSS
+ AOI221_X1
X_3160_ _1266_ _1267_ _1268_ net337 VDD VSS OAI21_X1
X_3161_ _0576_ _1545_ _0268_ _1269_ VDD VSS NAND3_X1
X_3162_ net344 _0548_ _1270_ VDD VSS NAND2_X1
X_3163_ _0314_ _1590_ _0327_ _1271_ VDD VSS NAND3_X1
X_3164_ _0284_ _1560_ _0287_ _1272_ VDD VSS AND3_X1
X_3165_ _1272_ _0549_ _0303_ _1273_ VDD VSS AOI21_X1
X_3166_ _1269_ _1270_ _1271_ _1273_ net338 VDD VSS NAND4_X1
X_3167_ _1531_ _1532_ _1533_ _1534_ VDD VSS HA_X1
X_3168_ _1531_ _1535_ _1536_ _1537_ VDD VSS HA_X1
X_3169_ _1538_ _1532_ _1539_ _1540_ VDD VSS HA_X1
X_3170_ _1538_ _1535_ _1541_ _1542_ VDD VSS HA_X1
X_3171_ _1539_ _1543_ _1544_ _1545_ VDD VSS HA_X1
X_3172_ _1546_ _1547_ _1548_ _1549_ VDD VSS HA_X1
X_3173_ _1546_ _1550_ _1551_ _1552_ VDD VSS HA_X1
X_3174_ _1553_ _1547_ _1554_ _1555_ VDD VSS HA_X1
X_3175_ _1553_ _1550_ _1556_ _1557_ VDD VSS HA_X1
X_3176_ _1551_ _1558_ _1559_ _1560_ VDD VSS HA_X1
X_3177_ _1561_ _1562_ _1563_ _1564_ VDD VSS HA_X1
X_3178_ _1561_ _1565_ _1566_ _1567_ VDD VSS HA_X1
X_3179_ _1568_ _1562_ _1569_ _1570_ VDD VSS HA_X1
X_3180_ _1568_ _1565_ _1571_ _1572_ VDD VSS HA_X1
X_3181_ _1566_ _1573_ _1574_ _1575_ VDD VSS HA_X1
X_3182_ _1576_ _1577_ _1578_ _1579_ VDD VSS HA_X1
X_3183_ _1576_ _1580_ _1581_ _1582_ VDD VSS HA_X1
X_3184_ _1583_ _1577_ _1584_ _1585_ VDD VSS HA_X1
X_3185_ _1583_ _1580_ _1586_ _1587_ VDD VSS HA_X1
X_3186_ _1581_ _1588_ _1589_ _1590_ VDD VSS HA_X1
X_3187_ _1591_ _1592_ _1593_ _1594_ VDD VSS HA_X1
X_3188_ _1591_ _1595_ _1596_ _1597_ VDD VSS HA_X1
X_3189_ _1598_ _1592_ _1599_ _1600_ VDD VSS HA_X1
X_3190_ _1598_ _1595_ _1601_ _1602_ VDD VSS HA_X1
X_3191_ _1596_ _1603_ _1604_ _1605_ VDD VSS HA_X1
Xinput_buffer\[0\]\[0\]$_DFFE_PP_ _0032_ clknet_4_5_0_clk
+ input_buffer\[0\]\[0\] _0005_ VDD VSS DFF_X1
Xinput_buffer\[0\]\[10\]$_DFFE_PP_ _0033_ clknet_4_5_0_clk
+ input_buffer\[0\]\[10\] _0015_ VDD VSS DFF_X1
Xinput_buffer\[0\]\[11\]$_DFFE_PP_ _0034_ clknet_4_6_0_clk
+ input_buffer\[0\]\[11\] _0016_ VDD VSS DFF_X1
Xinput_buffer\[0\]\[12\]$_DFFE_PP_ _0035_ clknet_4_6_0_clk
+ input_buffer\[0\]\[12\] _0017_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[13\]$_DFFE_PP_ _0036_ clknet_4_5_0_clk
+ input_buffer\[0\]\[13\] _0018_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[14\]$_DFFE_PP_ _0037_ clknet_4_5_0_clk
+ input_buffer\[0\]\[14\] _0019_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[15\]$_DFFE_PP_ _0038_ clknet_4_5_0_clk
+ input_buffer\[0\]\[15\] _0020_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[16\]$_DFFE_PP_ _0039_ clknet_4_6_0_clk
+ input_buffer\[0\]\[16\] _0021_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[17\]$_DFFE_PP_ _0040_ clknet_4_6_0_clk
+ input_buffer\[0\]\[17\] _0022_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[18\]$_DFFE_PP_ _0041_ clknet_4_6_0_clk
+ input_buffer\[0\]\[18\] _0023_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[19\]$_DFFE_PP_ _0042_ clknet_4_5_0_clk
+ input_buffer\[0\]\[19\] _0024_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[1\]$_DFFE_PP_ _0043_ clknet_4_6_0_clk
+ input_buffer\[0\]\[1\] _0006_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[20\]$_DFFE_PP_ _0044_ clknet_4_5_0_clk
+ input_buffer\[0\]\[20\] _0025_ VDD VSS DFF_X1
Xinput_buffer\[0\]\[21\]$_DFFE_PP_ _0045_ clknet_4_5_0_clk
+ input_buffer\[0\]\[21\] _0026_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[22\]$_DFFE_PP_ _0046_ clknet_4_5_0_clk
+ input_buffer\[0\]\[22\] _0027_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[23\]$_DFFE_PP_ _0047_ clknet_4_4_0_clk
+ input_buffer\[0\]\[23\] _0028_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[24\]$_DFFE_PP_ _0048_ clknet_4_4_0_clk
+ dest_id\[0\]\[0\] _0029_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[25\]$_DFFE_PP_ _0049_ clknet_4_1_0_clk
+ dest_id\[0\]\[1\] _0030_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[26\]$_DFFE_PP_ _0050_ clknet_4_1_0_clk
+ dest_id\[0\]\[2\] _0031_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[27\]$_DFFE_PP_ _0051_ clknet_4_1_0_clk
+ dest_id\[0\]\[3\] _0000_ VDD VSS DFF_X1
Xinput_buffer\[0\]\[28\]$_DFFE_PP_ _0052_ clknet_4_0_0_clk
+ dest_id\[0\]\[4\] _0001_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[29\]$_DFFE_PP_ _0053_ clknet_4_0_0_clk
+ dest_id\[0\]\[5\] _0002_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[2\]$_DFFE_PP_ _0054_ clknet_4_1_0_clk
+ input_buffer\[0\]\[2\] _0007_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[30\]$_DFFE_PP_ _0055_ clknet_4_0_0_clk
+ dest_id\[0\]\[6\] _0003_ VDD VSS DFF_X1
Xinput_buffer\[0\]\[31\]$_DFFE_PP_ _0056_ clknet_4_0_0_clk
+ dest_id\[0\]\[7\] _0004_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[3\]$_DFFE_PP_ _0057_ clknet_4_0_0_clk
+ input_buffer\[0\]\[3\] _0008_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[4\]$_DFFE_PP_ _0058_ clknet_4_1_0_clk
+ input_buffer\[0\]\[4\] _0009_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[5\]$_DFFE_PP_ _0059_ clknet_4_0_0_clk
+ input_buffer\[0\]\[5\] _0010_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[6\]$_DFFE_PP_ _0060_ clknet_4_0_0_clk
+ input_buffer\[0\]\[6\] _0011_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[7\]$_DFFE_PP_ _0061_ clknet_4_0_0_clk
+ input_buffer\[0\]\[7\] _0012_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[8\]$_DFFE_PP_ _0062_ clknet_4_1_0_clk
+ input_buffer\[0\]\[8\] _0013_ VDD VSS DFF_X2
Xinput_buffer\[0\]\[9\]$_DFFE_PP_ _0063_ clknet_4_3_0_clk
+ input_buffer\[0\]\[9\] _0014_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[0\]$_DFFE_PP_ _0064_ clknet_4_6_0_clk
+ input_buffer\[1\]\[0\] _1530_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[10\]$_DFFE_PP_ _0065_ clknet_4_6_0_clk
+ input_buffer\[1\]\[10\] _1529_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[11\]$_DFFE_PP_ _0066_ clknet_4_6_0_clk
+ input_buffer\[1\]\[11\] _1528_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[12\]$_DFFE_PP_ _0067_ clknet_4_6_0_clk
+ input_buffer\[1\]\[12\] _1527_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[13\]$_DFFE_PP_ _0068_ clknet_4_7_0_clk
+ input_buffer\[1\]\[13\] _1526_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[14\]$_DFFE_PP_ _0069_ clknet_4_7_0_clk
+ input_buffer\[1\]\[14\] _1525_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[15\]$_DFFE_PP_ _0070_ clknet_4_7_0_clk
+ input_buffer\[1\]\[15\] _1524_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[16\]$_DFFE_PP_ _0071_ clknet_4_7_0_clk
+ input_buffer\[1\]\[16\] _1523_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[17\]$_DFFE_PP_ _0072_ clknet_4_6_0_clk
+ input_buffer\[1\]\[17\] _1522_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[18\]$_DFFE_PP_ _0073_ clknet_4_6_0_clk
+ input_buffer\[1\]\[18\] _1521_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[19\]$_DFFE_PP_ _0074_ clknet_4_5_0_clk
+ input_buffer\[1\]\[19\] _1520_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[1\]$_DFFE_PP_ _0075_ clknet_4_5_0_clk
+ input_buffer\[1\]\[1\] _1519_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[20\]$_DFFE_PP_ _0076_ clknet_4_4_0_clk
+ input_buffer\[1\]\[20\] _1518_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[21\]$_DFFE_PP_ _0077_ clknet_4_5_0_clk
+ input_buffer\[1\]\[21\] _1517_ VDD VSS DFF_X2
Xinput_buffer\[1\]\[22\]$_DFFE_PP_ _0078_ clknet_4_4_0_clk
+ input_buffer\[1\]\[22\] _1516_ VDD VSS DFF_X2
Xinput_buffer\[1\]\[23\]$_DFFE_PP_ _0079_ clknet_4_4_0_clk
+ input_buffer\[1\]\[23\] _1515_ VDD VSS DFF_X2
Xinput_buffer\[1\]\[24\]$_DFFE_PP_ _0080_ clknet_4_4_0_clk
+ dest_id\[1\]\[0\] _1514_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[25\]$_DFFE_PP_ _0081_ clknet_4_4_0_clk
+ dest_id\[1\]\[1\] _1513_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[26\]$_DFFE_PP_ _0082_ clknet_4_4_0_clk
+ dest_id\[1\]\[2\] _1512_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[27\]$_DFFE_PP_ _0083_ clknet_4_4_0_clk
+ dest_id\[1\]\[3\] _1511_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[28\]$_DFFE_PP_ _0084_ clknet_4_0_0_clk
+ dest_id\[1\]\[4\] _1510_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[29\]$_DFFE_PP_ _0085_ clknet_4_0_0_clk
+ dest_id\[1\]\[5\] _1509_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[2\]$_DFFE_PP_ _0086_ clknet_4_0_0_clk
+ input_buffer\[1\]\[2\] _1508_ VDD VSS DFF_X2
Xinput_buffer\[1\]\[30\]$_DFFE_PP_ _0087_ clknet_4_3_0_clk
+ dest_id\[1\]\[6\] _1507_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[31\]$_DFFE_PP_ _0088_ clknet_4_3_0_clk
+ dest_id\[1\]\[7\] _1506_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[3\]$_DFFE_PP_ _0089_ clknet_4_3_0_clk
+ input_buffer\[1\]\[3\] _1505_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[4\]$_DFFE_PP_ _0090_ clknet_4_0_0_clk
+ input_buffer\[1\]\[4\] _1504_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[5\]$_DFFE_PP_ _0091_ clknet_4_3_0_clk
+ input_buffer\[1\]\[5\] _1503_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[6\]$_DFFE_PP_ _0092_ clknet_4_0_0_clk
+ input_buffer\[1\]\[6\] _1502_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[7\]$_DFFE_PP_ _0093_ clknet_4_0_0_clk
+ input_buffer\[1\]\[7\] _1501_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[8\]$_DFFE_PP_ _0094_ clknet_4_1_0_clk
+ input_buffer\[1\]\[8\] _1500_ VDD VSS DFF_X1
Xinput_buffer\[1\]\[9\]$_DFFE_PP_ _0095_ clknet_4_1_0_clk
+ input_buffer\[1\]\[9\] _1499_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[0\]$_DFFE_PP_ _0096_ clknet_4_7_0_clk
+ input_buffer\[2\]\[0\] _1498_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[10\]$_DFFE_PP_ _0097_ clknet_4_7_0_clk
+ input_buffer\[2\]\[10\] _1497_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[11\]$_DFFE_PP_ _0098_ clknet_4_7_0_clk
+ input_buffer\[2\]\[11\] _1496_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[12\]$_DFFE_PP_ _0099_ clknet_4_7_0_clk
+ input_buffer\[2\]\[12\] _1495_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[13\]$_DFFE_PP_ _0100_ clknet_4_7_0_clk
+ input_buffer\[2\]\[13\] _1494_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[14\]$_DFFE_PP_ _0101_ clknet_4_7_0_clk
+ input_buffer\[2\]\[14\] _1493_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[15\]$_DFFE_PP_ _0102_ clknet_4_13_0_clk
+ input_buffer\[2\]\[15\] _1492_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[16\]$_DFFE_PP_ _0103_ clknet_4_13_0_clk
+ input_buffer\[2\]\[16\] _1491_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[17\]$_DFFE_PP_ _0104_ clknet_4_13_0_clk
+ input_buffer\[2\]\[17\] _1490_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[18\]$_DFFE_PP_ _0105_ clknet_4_12_0_clk
+ input_buffer\[2\]\[18\] _1489_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[19\]$_DFFE_PP_ _0106_ clknet_4_12_0_clk
+ input_buffer\[2\]\[19\] _1488_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[1\]$_DFFE_PP_ _0107_ clknet_4_12_0_clk
+ input_buffer\[2\]\[1\] _1487_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[20\]$_DFFE_PP_ _0108_ clknet_4_15_0_clk
+ input_buffer\[2\]\[20\] _1486_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[21\]$_DFFE_PP_ _0109_ clknet_4_14_0_clk
+ input_buffer\[2\]\[21\] _1485_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[22\]$_DFFE_PP_ _0110_ clknet_4_14_0_clk
+ input_buffer\[2\]\[22\] _1484_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[23\]$_DFFE_PP_ _0111_ clknet_4_14_0_clk
+ input_buffer\[2\]\[23\] _1483_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[24\]$_DFFE_PP_ _0112_ clknet_4_11_0_clk
+ dest_id\[2\]\[0\] _1482_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[25\]$_DFFE_PP_ _0113_ clknet_4_11_0_clk
+ dest_id\[2\]\[1\] _1481_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[26\]$_DFFE_PP_ _0114_ clknet_4_11_0_clk
+ dest_id\[2\]\[2\] _1480_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[27\]$_DFFE_PP_ _0115_ clknet_4_11_0_clk
+ dest_id\[2\]\[3\] _1479_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[28\]$_DFFE_PP_ _0116_ clknet_4_2_0_clk
+ dest_id\[2\]\[4\] _1478_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[29\]$_DFFE_PP_ _0117_ clknet_4_2_0_clk
+ dest_id\[2\]\[5\] _1477_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[2\]$_DFFE_PP_ _0118_ clknet_4_10_0_clk
+ input_buffer\[2\]\[2\] _1476_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[30\]$_DFFE_PP_ _0119_ clknet_4_2_0_clk
+ dest_id\[2\]\[6\] _1475_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[31\]$_DFFE_PP_ _0120_ clknet_4_2_0_clk
+ dest_id\[2\]\[7\] _1474_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[3\]$_DFFE_PP_ _0121_ clknet_4_9_0_clk
+ input_buffer\[2\]\[3\] _1473_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[4\]$_DFFE_PP_ _0122_ clknet_4_8_0_clk
+ input_buffer\[2\]\[4\] _1472_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[5\]$_DFFE_PP_ _0123_ clknet_4_8_0_clk
+ input_buffer\[2\]\[5\] _1471_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[6\]$_DFFE_PP_ _0124_ clknet_4_8_0_clk
+ input_buffer\[2\]\[6\] _1470_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[7\]$_DFFE_PP_ _0125_ clknet_4_9_0_clk
+ input_buffer\[2\]\[7\] _1469_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[8\]$_DFFE_PP_ _0126_ clknet_4_11_0_clk
+ input_buffer\[2\]\[8\] _1468_ VDD VSS DFF_X1
Xinput_buffer\[2\]\[9\]$_DFFE_PP_ _0127_ clknet_4_9_0_clk
+ input_buffer\[2\]\[9\] _1467_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[0\]$_DFFE_PP_ _0128_ clknet_4_7_0_clk
+ input_buffer\[3\]\[0\] _1466_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[10\]$_DFFE_PP_ _0129_ clknet_4_7_0_clk
+ input_buffer\[3\]\[10\] _1465_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[11\]$_DFFE_PP_ _0130_ clknet_4_7_0_clk
+ input_buffer\[3\]\[11\] _1464_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[12\]$_DFFE_PP_ _0131_ clknet_4_7_0_clk
+ input_buffer\[3\]\[12\] _1463_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[13\]$_DFFE_PP_ _0132_ clknet_4_7_0_clk
+ input_buffer\[3\]\[13\] _1462_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[14\]$_DFFE_PP_ _0133_ clknet_4_13_0_clk
+ input_buffer\[3\]\[14\] _1461_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[15\]$_DFFE_PP_ _0134_ clknet_4_13_0_clk
+ input_buffer\[3\]\[15\] _1460_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[16\]$_DFFE_PP_ _0135_ clknet_4_13_0_clk
+ input_buffer\[3\]\[16\] _1459_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[17\]$_DFFE_PP_ _0136_ clknet_4_13_0_clk
+ input_buffer\[3\]\[17\] _1458_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[18\]$_DFFE_PP_ _0137_ clknet_4_12_0_clk
+ input_buffer\[3\]\[18\] _1457_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[19\]$_DFFE_PP_ _0138_ clknet_4_15_0_clk
+ input_buffer\[3\]\[19\] _1456_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[1\]$_DFFE_PP_ _0139_ clknet_4_15_0_clk
+ input_buffer\[3\]\[1\] _1455_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[20\]$_DFFE_PP_ _0140_ clknet_4_15_0_clk
+ input_buffer\[3\]\[20\] _1454_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[21\]$_DFFE_PP_ _0141_ clknet_4_14_0_clk
+ input_buffer\[3\]\[21\] _1453_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[22\]$_DFFE_PP_ _0142_ clknet_4_14_0_clk
+ input_buffer\[3\]\[22\] _1452_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[23\]$_DFFE_PP_ _0143_ clknet_4_14_0_clk
+ input_buffer\[3\]\[23\] _1451_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[24\]$_DFFE_PP_ _0144_ clknet_4_11_0_clk
+ dest_id\[3\]\[0\] _1450_ VDD VSS DFF_X2
Xinput_buffer\[3\]\[25\]$_DFFE_PP_ _0145_ clknet_4_11_0_clk
+ dest_id\[3\]\[1\] _1449_ VDD VSS DFF_X2
Xinput_buffer\[3\]\[26\]$_DFFE_PP_ _0146_ clknet_4_14_0_clk
+ dest_id\[3\]\[2\] _1448_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[27\]$_DFFE_PP_ _0147_ clknet_4_11_0_clk
+ dest_id\[3\]\[3\] _1447_ VDD VSS DFF_X2
Xinput_buffer\[3\]\[28\]$_DFFE_PP_ _0148_ clknet_4_8_0_clk
+ dest_id\[3\]\[4\] _1446_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[29\]$_DFFE_PP_ _0149_ clknet_4_2_0_clk
+ dest_id\[3\]\[5\] _1445_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[2\]$_DFFE_PP_ _0150_ clknet_4_10_0_clk
+ input_buffer\[3\]\[2\] _1444_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[30\]$_DFFE_PP_ _0151_ clknet_4_8_0_clk
+ dest_id\[3\]\[6\] _1443_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[31\]$_DFFE_PP_ _0152_ clknet_4_8_0_clk
+ dest_id\[3\]\[7\] _1442_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[3\]$_DFFE_PP_ _0153_ clknet_4_10_0_clk
+ input_buffer\[3\]\[3\] _1441_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[4\]$_DFFE_PP_ _0154_ clknet_4_9_0_clk
+ input_buffer\[3\]\[4\] _1440_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[5\]$_DFFE_PP_ _0155_ clknet_4_10_0_clk
+ input_buffer\[3\]\[5\] _1439_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[6\]$_DFFE_PP_ _0156_ clknet_4_10_0_clk
+ input_buffer\[3\]\[6\] _1438_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[7\]$_DFFE_PP_ _0157_ clknet_4_9_0_clk
+ input_buffer\[3\]\[7\] _1437_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[8\]$_DFFE_PP_ _0158_ clknet_4_9_0_clk
+ input_buffer\[3\]\[8\] _1436_ VDD VSS DFF_X1
Xinput_buffer\[3\]\[9\]$_DFFE_PP_ _0159_ clknet_4_9_0_clk
+ input_buffer\[3\]\[9\] _1435_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[0\]$_DFFE_PP_ _0160_ clknet_4_13_0_clk
+ input_buffer\[4\]\[0\] _1434_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[10\]$_DFFE_PP_ _0161_ clknet_4_12_0_clk
+ input_buffer\[4\]\[10\] _1433_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[11\]$_DFFE_PP_ _0162_ clknet_4_15_0_clk
+ input_buffer\[4\]\[11\] _1432_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[12\]$_DFFE_PP_ _0163_ clknet_4_15_0_clk
+ input_buffer\[4\]\[12\] _1431_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[13\]$_DFFE_PP_ _0164_ clknet_4_12_0_clk
+ input_buffer\[4\]\[13\] _1430_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[14\]$_DFFE_PP_ _0165_ clknet_4_13_0_clk
+ input_buffer\[4\]\[14\] _1429_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[15\]$_DFFE_PP_ _0166_ clknet_4_12_0_clk
+ input_buffer\[4\]\[15\] _1428_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[16\]$_DFFE_PP_ _0167_ clknet_4_15_0_clk
+ input_buffer\[4\]\[16\] _1427_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[17\]$_DFFE_PP_ _0168_ clknet_4_15_0_clk
+ input_buffer\[4\]\[17\] _1426_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[18\]$_DFFE_PP_ _0169_ clknet_4_15_0_clk
+ input_buffer\[4\]\[18\] _1425_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[19\]$_DFFE_PP_ _0170_ clknet_4_15_0_clk
+ input_buffer\[4\]\[19\] _1424_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[1\]$_DFFE_PP_ _0171_ clknet_4_15_0_clk
+ input_buffer\[4\]\[1\] _1423_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[20\]$_DFFE_PP_ _0172_ clknet_4_15_0_clk
+ input_buffer\[4\]\[20\] _1422_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[21\]$_DFFE_PP_ _0173_ clknet_4_14_0_clk
+ input_buffer\[4\]\[21\] _1421_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[22\]$_DFFE_PP_ _0174_ clknet_4_14_0_clk
+ input_buffer\[4\]\[22\] _1420_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[23\]$_DFFE_PP_ _0175_ clknet_4_14_0_clk
+ input_buffer\[4\]\[23\] _1419_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[24\]$_DFFE_PP_ _0176_ clknet_4_11_0_clk
+ dest_id\[4\]\[0\] _1418_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[25\]$_DFFE_PP_ _0177_ clknet_4_11_0_clk
+ dest_id\[4\]\[1\] _1417_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[26\]$_DFFE_PP_ _0178_ clknet_4_11_0_clk
+ dest_id\[4\]\[2\] _1416_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[27\]$_DFFE_PP_ _0179_ clknet_4_11_0_clk
+ dest_id\[4\]\[3\] _1415_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[28\]$_DFFE_PP_ _0180_ clknet_4_8_0_clk
+ dest_id\[4\]\[4\] _1414_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[29\]$_DFFE_PP_ _0181_ clknet_4_8_0_clk
+ dest_id\[4\]\[5\] _1413_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[2\]$_DFFE_PP_ _0182_ clknet_4_10_0_clk
+ input_buffer\[4\]\[2\] _1412_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[30\]$_DFFE_PP_ _0183_ clknet_4_8_0_clk
+ dest_id\[4\]\[6\] _1411_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[31\]$_DFFE_PP_ _0184_ clknet_4_8_0_clk
+ dest_id\[4\]\[7\] _1410_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[3\]$_DFFE_PP_ _0185_ clknet_4_10_0_clk
+ input_buffer\[4\]\[3\] _1409_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[4\]$_DFFE_PP_ _0186_ clknet_4_10_0_clk
+ input_buffer\[4\]\[4\] _1408_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[5\]$_DFFE_PP_ _0187_ clknet_4_10_0_clk
+ input_buffer\[4\]\[5\] _1407_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[6\]$_DFFE_PP_ _0188_ clknet_4_10_0_clk
+ input_buffer\[4\]\[6\] _1406_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[7\]$_DFFE_PP_ _0189_ clknet_4_10_0_clk
+ input_buffer\[4\]\[7\] _1405_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[8\]$_DFFE_PP_ _0190_ clknet_4_11_0_clk
+ input_buffer\[4\]\[8\] _1404_ VDD VSS DFF_X1
Xinput_buffer\[4\]\[9\]$_DFFE_PP_ _0191_ clknet_4_10_0_clk
+ input_buffer\[4\]\[9\] _1403_ VDD VSS DFF_X1
Xinput_buffer_valid\[0\]$_SDFF_PN0_ _0192_ clknet_4_1_0_clk
+ input_buffer_valid\[0\] net237 VDD VSS DFF_X1
Xinput_buffer_valid\[1\]$_SDFF_PN0_ _0193_ clknet_4_3_0_clk
+ input_buffer_valid\[1\] net169 VDD VSS DFF_X1
Xinput_buffer_valid\[2\]$_SDFF_PN0_ _0194_ clknet_4_2_0_clk
+ input_buffer_valid\[2\] net271 VDD VSS DFF_X1
Xinput_buffer_valid\[3\]$_SDFF_PN0_ _0195_ clknet_4_2_0_clk
+ input_buffer_valid\[3\] net305 VDD VSS DFF_X1
Xinput_buffer_valid\[4\]$_SDFF_PN0_ _0196_ clknet_4_2_0_clk
+ input_buffer_valid\[4\] net203 VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_103 VDD VSS TAPCELL_X1
Xinput1 east_in_data[0] net1 VDD VSS BUF_X1
Xinput2 east_in_data[10] net2 VDD VSS BUF_X1
Xinput3 east_in_data[11] net3 VDD VSS BUF_X1
Xinput4 east_in_data[12] net4 VDD VSS BUF_X1
Xinput5 east_in_data[13] net5 VDD VSS BUF_X1
Xinput6 east_in_data[14] net6 VDD VSS BUF_X1
Xinput7 east_in_data[15] net7 VDD VSS BUF_X1
Xinput8 east_in_data[16] net8 VDD VSS BUF_X1
Xinput9 east_in_data[17] net9 VDD VSS BUF_X1
Xinput10 east_in_data[18] net10 VDD VSS BUF_X1
Xinput11 east_in_data[19] net11 VDD VSS BUF_X1
Xinput12 east_in_data[1] net12 VDD VSS BUF_X1
Xinput13 east_in_data[20] net13 VDD VSS BUF_X1
Xinput14 east_in_data[21] net14 VDD VSS BUF_X1
Xinput15 east_in_data[22] net15 VDD VSS BUF_X1
Xinput16 east_in_data[23] net16 VDD VSS BUF_X1
Xinput17 east_in_data[24] net17 VDD VSS BUF_X1
Xinput18 east_in_data[25] net18 VDD VSS BUF_X1
Xinput19 east_in_data[26] net19 VDD VSS BUF_X1
Xinput20 east_in_data[27] net20 VDD VSS BUF_X1
Xinput21 east_in_data[28] net21 VDD VSS BUF_X1
Xinput22 east_in_data[29] net22 VDD VSS BUF_X1
Xinput23 east_in_data[2] net23 VDD VSS BUF_X1
Xinput24 east_in_data[30] net24 VDD VSS BUF_X1
Xinput25 east_in_data[31] net25 VDD VSS BUF_X1
Xinput26 east_in_data[3] net26 VDD VSS BUF_X1
Xinput27 east_in_data[4] net27 VDD VSS BUF_X1
Xinput28 east_in_data[5] net28 VDD VSS BUF_X1
Xinput29 east_in_data[6] net29 VDD VSS BUF_X1
Xinput30 east_in_data[7] net30 VDD VSS BUF_X1
Xinput31 east_in_data[8] net31 VDD VSS BUF_X1
Xinput32 east_in_data[9] net32 VDD VSS BUF_X1
Xinput33 east_in_valid net33 VDD VSS BUF_X1
Xinput34 east_out_ready net34 VDD VSS BUF_X1
Xinput35 local_in_data[0] net35 VDD VSS BUF_X1
Xinput36 local_in_data[10] net36 VDD VSS BUF_X1
Xinput37 local_in_data[11] net37 VDD VSS BUF_X1
Xinput38 local_in_data[12] net38 VDD VSS BUF_X1
Xinput39 local_in_data[13] net39 VDD VSS BUF_X1
Xinput40 local_in_data[14] net40 VDD VSS BUF_X1
Xinput41 local_in_data[15] net41 VDD VSS BUF_X1
Xinput42 local_in_data[16] net42 VDD VSS BUF_X1
Xinput43 local_in_data[17] net43 VDD VSS BUF_X1
Xinput44 local_in_data[18] net44 VDD VSS BUF_X1
Xinput45 local_in_data[19] net45 VDD VSS BUF_X1
Xinput46 local_in_data[1] net46 VDD VSS BUF_X1
Xinput47 local_in_data[20] net47 VDD VSS BUF_X1
Xinput48 local_in_data[21] net48 VDD VSS BUF_X1
Xinput49 local_in_data[22] net49 VDD VSS BUF_X1
Xinput50 local_in_data[23] net50 VDD VSS BUF_X1
Xinput51 local_in_data[24] net51 VDD VSS BUF_X1
Xinput52 local_in_data[25] net52 VDD VSS BUF_X1
Xinput53 local_in_data[26] net53 VDD VSS BUF_X1
Xinput54 local_in_data[27] net54 VDD VSS BUF_X1
Xinput55 local_in_data[28] net55 VDD VSS BUF_X1
Xinput56 local_in_data[29] net56 VDD VSS BUF_X1
Xinput57 local_in_data[2] net57 VDD VSS BUF_X1
Xinput58 local_in_data[30] net58 VDD VSS BUF_X1
Xinput59 local_in_data[31] net59 VDD VSS BUF_X1
Xinput60 local_in_data[3] net60 VDD VSS BUF_X1
Xinput61 local_in_data[4] net61 VDD VSS BUF_X1
Xinput62 local_in_data[5] net62 VDD VSS BUF_X1
Xinput63 local_in_data[6] net63 VDD VSS BUF_X1
Xinput64 local_in_data[7] net64 VDD VSS BUF_X1
Xinput65 local_in_data[8] net65 VDD VSS BUF_X1
Xinput66 local_in_data[9] net66 VDD VSS BUF_X1
Xinput67 local_in_valid net67 VDD VSS BUF_X1
Xinput68 north_in_data[0] net68 VDD VSS BUF_X1
Xinput69 north_in_data[10] net69 VDD VSS BUF_X1
Xinput70 north_in_data[11] net70 VDD VSS BUF_X1
Xinput71 north_in_data[12] net71 VDD VSS BUF_X1
Xinput72 north_in_data[13] net72 VDD VSS BUF_X1
Xinput73 north_in_data[14] net73 VDD VSS BUF_X1
Xinput74 north_in_data[15] net74 VDD VSS BUF_X1
Xinput75 north_in_data[16] net75 VDD VSS BUF_X1
Xinput76 north_in_data[17] net76 VDD VSS BUF_X1
Xinput77 north_in_data[18] net77 VDD VSS BUF_X1
Xinput78 north_in_data[19] net78 VDD VSS BUF_X1
Xinput79 north_in_data[1] net79 VDD VSS BUF_X1
Xinput80 north_in_data[20] net80 VDD VSS BUF_X1
Xinput81 north_in_data[21] net81 VDD VSS BUF_X1
Xinput82 north_in_data[22] net82 VDD VSS BUF_X1
Xinput83 north_in_data[23] net83 VDD VSS BUF_X1
Xinput84 north_in_data[24] net84 VDD VSS BUF_X1
Xinput85 north_in_data[25] net85 VDD VSS BUF_X1
Xinput86 north_in_data[26] net86 VDD VSS BUF_X1
Xinput87 north_in_data[27] net87 VDD VSS BUF_X1
Xinput88 north_in_data[28] net88 VDD VSS BUF_X1
Xinput89 north_in_data[29] net89 VDD VSS BUF_X1
Xinput90 north_in_data[2] net90 VDD VSS BUF_X1
Xinput91 north_in_data[30] net91 VDD VSS BUF_X1
Xinput92 north_in_data[31] net92 VDD VSS BUF_X1
Xinput93 north_in_data[3] net93 VDD VSS BUF_X1
Xinput94 north_in_data[4] net94 VDD VSS BUF_X1
Xinput95 north_in_data[5] net95 VDD VSS BUF_X1
Xinput96 north_in_data[6] net96 VDD VSS BUF_X1
Xinput97 north_in_data[7] net97 VDD VSS BUF_X1
Xinput98 north_in_data[8] net98 VDD VSS BUF_X1
Xinput99 north_in_data[9] net99 VDD VSS BUF_X1
Xinput100 north_in_valid net100 VDD VSS BUF_X1
Xinput101 south_in_data[0] net101 VDD VSS BUF_X1
Xinput102 south_in_data[10] net102 VDD VSS BUF_X1
Xinput103 south_in_data[11] net103 VDD VSS BUF_X1
Xinput104 south_in_data[12] net104 VDD VSS BUF_X1
Xinput105 south_in_data[13] net105 VDD VSS BUF_X1
Xinput106 south_in_data[14] net106 VDD VSS BUF_X1
Xinput107 south_in_data[15] net107 VDD VSS BUF_X1
Xinput108 south_in_data[16] net108 VDD VSS BUF_X1
Xinput109 south_in_data[17] net109 VDD VSS BUF_X1
Xinput110 south_in_data[18] net110 VDD VSS BUF_X1
Xinput111 south_in_data[19] net111 VDD VSS BUF_X1
Xinput112 south_in_data[1] net112 VDD VSS BUF_X1
Xinput113 south_in_data[20] net113 VDD VSS BUF_X1
Xinput114 south_in_data[21] net114 VDD VSS BUF_X1
Xinput115 south_in_data[22] net115 VDD VSS BUF_X1
Xinput116 south_in_data[23] net116 VDD VSS BUF_X1
Xinput117 south_in_data[24] net117 VDD VSS BUF_X1
Xinput118 south_in_data[25] net118 VDD VSS BUF_X1
Xinput119 south_in_data[26] net119 VDD VSS BUF_X1
Xinput120 south_in_data[27] net120 VDD VSS BUF_X1
Xinput121 south_in_data[28] net121 VDD VSS BUF_X1
Xinput122 south_in_data[29] net122 VDD VSS BUF_X1
Xinput123 south_in_data[2] net123 VDD VSS BUF_X1
Xinput124 south_in_data[30] net124 VDD VSS BUF_X1
Xinput125 south_in_data[31] net125 VDD VSS BUF_X1
Xinput126 south_in_data[3] net126 VDD VSS BUF_X1
Xinput127 south_in_data[4] net127 VDD VSS BUF_X1
Xinput128 south_in_data[5] net128 VDD VSS BUF_X1
Xinput129 south_in_data[6] net129 VDD VSS BUF_X1
Xinput130 south_in_data[7] net130 VDD VSS BUF_X1
Xinput131 south_in_data[8] net131 VDD VSS BUF_X1
Xinput132 south_in_data[9] net132 VDD VSS BUF_X1
Xinput133 south_in_valid net133 VDD VSS BUF_X1
Xinput134 south_out_ready net134 VDD VSS BUF_X1
Xinput135 west_in_data[0] net135 VDD VSS BUF_X1
Xinput136 west_in_data[10] net136 VDD VSS BUF_X1
Xinput137 west_in_data[11] net137 VDD VSS BUF_X1
Xinput138 west_in_data[12] net138 VDD VSS BUF_X1
Xinput139 west_in_data[13] net139 VDD VSS BUF_X1
Xinput140 west_in_data[14] net140 VDD VSS BUF_X1
Xinput141 west_in_data[15] net141 VDD VSS BUF_X1
Xinput142 west_in_data[16] net142 VDD VSS BUF_X1
Xinput143 west_in_data[17] net143 VDD VSS BUF_X1
Xinput144 west_in_data[18] net144 VDD VSS BUF_X1
Xinput145 west_in_data[19] net145 VDD VSS BUF_X1
Xinput146 west_in_data[1] net146 VDD VSS BUF_X1
Xinput147 west_in_data[20] net147 VDD VSS BUF_X1
Xinput148 west_in_data[21] net148 VDD VSS BUF_X1
Xinput149 west_in_data[22] net149 VDD VSS BUF_X1
Xinput150 west_in_data[23] net150 VDD VSS BUF_X1
Xinput151 west_in_data[24] net151 VDD VSS BUF_X1
Xinput152 west_in_data[25] net152 VDD VSS BUF_X1
Xinput153 west_in_data[26] net153 VDD VSS BUF_X1
Xinput154 west_in_data[27] net154 VDD VSS BUF_X1
Xinput155 west_in_data[28] net155 VDD VSS BUF_X1
Xinput156 west_in_data[29] net156 VDD VSS BUF_X1
Xinput157 west_in_data[2] net157 VDD VSS BUF_X1
Xinput158 west_in_data[30] net158 VDD VSS BUF_X1
Xinput159 west_in_data[31] net159 VDD VSS BUF_X1
Xinput160 west_in_data[3] net160 VDD VSS BUF_X1
Xinput161 west_in_data[4] net161 VDD VSS BUF_X1
Xinput162 west_in_data[5] net162 VDD VSS BUF_X1
Xinput163 west_in_data[6] net163 VDD VSS BUF_X1
Xinput164 west_in_data[7] net164 VDD VSS BUF_X1
Xinput165 west_in_data[8] net165 VDD VSS BUF_X1
Xinput166 west_in_data[9] net166 VDD VSS BUF_X1
Xinput167 west_in_valid net167 VDD VSS CLKBUF_X2
Xinput168 west_out_ready net168 VDD VSS BUF_X1
Xoutput169 net169 east_in_ready VDD VSS BUF_X1
Xoutput170 net170 east_out_data[0] VDD VSS BUF_X1
Xoutput171 net171 east_out_data[10] VDD VSS BUF_X1
Xoutput172 net172 east_out_data[11] VDD VSS BUF_X1
Xoutput173 net173 east_out_data[12] VDD VSS BUF_X1
Xoutput174 net174 east_out_data[13] VDD VSS BUF_X1
Xoutput175 net175 east_out_data[14] VDD VSS BUF_X1
Xoutput176 net176 east_out_data[15] VDD VSS BUF_X1
Xoutput177 net177 east_out_data[16] VDD VSS BUF_X1
Xoutput178 net178 east_out_data[17] VDD VSS BUF_X1
Xoutput179 net179 east_out_data[18] VDD VSS BUF_X1
Xoutput180 net180 east_out_data[19] VDD VSS BUF_X1
Xoutput181 net181 east_out_data[1] VDD VSS BUF_X1
Xoutput182 net182 east_out_data[20] VDD VSS BUF_X1
Xoutput183 net183 east_out_data[21] VDD VSS BUF_X1
Xoutput184 net184 east_out_data[22] VDD VSS BUF_X1
Xoutput185 net185 east_out_data[23] VDD VSS BUF_X1
Xoutput186 net186 east_out_data[24] VDD VSS BUF_X1
Xoutput187 net187 east_out_data[25] VDD VSS BUF_X1
Xoutput188 net188 east_out_data[26] VDD VSS BUF_X1
Xoutput189 net189 east_out_data[27] VDD VSS BUF_X1
Xoutput190 net190 east_out_data[28] VDD VSS BUF_X1
Xoutput191 net191 east_out_data[29] VDD VSS BUF_X1
Xoutput192 net192 east_out_data[2] VDD VSS BUF_X1
Xoutput193 net193 east_out_data[30] VDD VSS BUF_X1
Xoutput194 net194 east_out_data[31] VDD VSS BUF_X1
Xoutput195 net195 east_out_data[3] VDD VSS BUF_X1
Xoutput196 net196 east_out_data[4] VDD VSS BUF_X1
Xoutput197 net197 east_out_data[5] VDD VSS BUF_X1
Xoutput198 net198 east_out_data[6] VDD VSS BUF_X1
Xoutput199 net199 east_out_data[7] VDD VSS BUF_X1
Xoutput200 net200 east_out_data[8] VDD VSS BUF_X1
Xoutput201 net201 east_out_data[9] VDD VSS BUF_X1
Xoutput202 net202 east_out_valid VDD VSS BUF_X1
Xoutput203 net203 local_in_ready VDD VSS BUF_X1
Xoutput204 net204 local_out_data[0] VDD VSS BUF_X1
Xoutput205 net205 local_out_data[10] VDD VSS BUF_X1
Xoutput206 net206 local_out_data[11] VDD VSS BUF_X1
Xoutput207 net207 local_out_data[12] VDD VSS BUF_X1
Xoutput208 net208 local_out_data[13] VDD VSS BUF_X1
Xoutput209 net209 local_out_data[14] VDD VSS BUF_X1
Xoutput210 net210 local_out_data[15] VDD VSS BUF_X1
Xoutput211 net211 local_out_data[16] VDD VSS BUF_X1
Xoutput212 net212 local_out_data[17] VDD VSS BUF_X1
Xoutput213 net213 local_out_data[18] VDD VSS BUF_X1
Xoutput214 net214 local_out_data[19] VDD VSS BUF_X1
Xoutput215 net215 local_out_data[1] VDD VSS BUF_X1
Xoutput216 net216 local_out_data[20] VDD VSS BUF_X1
Xoutput217 net217 local_out_data[21] VDD VSS BUF_X1
Xoutput218 net218 local_out_data[22] VDD VSS BUF_X1
Xoutput219 net219 local_out_data[23] VDD VSS BUF_X1
Xoutput220 net220 local_out_data[24] VDD VSS BUF_X1
Xoutput221 net221 local_out_data[25] VDD VSS BUF_X1
Xoutput222 net222 local_out_data[26] VDD VSS BUF_X1
Xoutput223 net223 local_out_data[27] VDD VSS BUF_X1
Xoutput224 net224 local_out_data[28] VDD VSS BUF_X1
Xoutput225 net225 local_out_data[29] VDD VSS BUF_X1
Xoutput226 net226 local_out_data[2] VDD VSS BUF_X1
Xoutput227 net227 local_out_data[30] VDD VSS BUF_X1
Xoutput228 net228 local_out_data[31] VDD VSS BUF_X1
Xoutput229 net229 local_out_data[3] VDD VSS BUF_X1
Xoutput230 net230 local_out_data[4] VDD VSS BUF_X1
Xoutput231 net231 local_out_data[5] VDD VSS BUF_X1
Xoutput232 net232 local_out_data[6] VDD VSS BUF_X1
Xoutput233 net233 local_out_data[7] VDD VSS BUF_X1
Xoutput234 net234 local_out_data[8] VDD VSS BUF_X1
Xoutput235 net235 local_out_data[9] VDD VSS BUF_X1
Xoutput236 net236 local_out_valid VDD VSS BUF_X1
Xoutput237 net237 north_in_ready VDD VSS BUF_X1
Xoutput238 net238 north_out_data[0] VDD VSS BUF_X1
Xoutput239 net239 north_out_data[10] VDD VSS BUF_X1
Xoutput240 net240 north_out_data[11] VDD VSS BUF_X1
Xoutput241 net241 north_out_data[12] VDD VSS BUF_X1
Xoutput242 net242 north_out_data[13] VDD VSS BUF_X1
Xoutput243 net243 north_out_data[14] VDD VSS BUF_X1
Xoutput244 net244 north_out_data[15] VDD VSS BUF_X1
Xoutput245 net245 north_out_data[16] VDD VSS BUF_X1
Xoutput246 net246 north_out_data[17] VDD VSS BUF_X1
Xoutput247 net247 north_out_data[18] VDD VSS BUF_X1
Xoutput248 net248 north_out_data[19] VDD VSS BUF_X1
Xoutput249 net249 north_out_data[1] VDD VSS BUF_X1
Xoutput250 net250 north_out_data[20] VDD VSS BUF_X1
Xoutput251 net251 north_out_data[21] VDD VSS BUF_X1
Xoutput252 net252 north_out_data[22] VDD VSS BUF_X1
Xoutput253 net253 north_out_data[23] VDD VSS BUF_X1
Xoutput254 net254 north_out_data[24] VDD VSS BUF_X1
Xoutput255 net255 north_out_data[25] VDD VSS BUF_X1
Xoutput256 net256 north_out_data[26] VDD VSS BUF_X1
Xoutput257 net257 north_out_data[27] VDD VSS BUF_X1
Xoutput258 net258 north_out_data[28] VDD VSS BUF_X1
Xoutput259 net259 north_out_data[29] VDD VSS BUF_X1
Xoutput260 net260 north_out_data[2] VDD VSS BUF_X1
Xoutput261 net261 north_out_data[30] VDD VSS BUF_X1
Xoutput262 net262 north_out_data[31] VDD VSS BUF_X1
Xoutput263 net263 north_out_data[3] VDD VSS BUF_X1
Xoutput264 net264 north_out_data[4] VDD VSS BUF_X1
Xoutput265 net265 north_out_data[5] VDD VSS BUF_X1
Xoutput266 net266 north_out_data[6] VDD VSS BUF_X1
Xoutput267 net267 north_out_data[7] VDD VSS BUF_X1
Xoutput268 net268 north_out_data[8] VDD VSS BUF_X1
Xoutput269 net269 north_out_data[9] VDD VSS BUF_X1
Xoutput270 net270 north_out_valid VDD VSS BUF_X1
Xoutput271 net271 south_in_ready VDD VSS BUF_X1
Xoutput272 net272 south_out_data[0] VDD VSS BUF_X1
Xoutput273 net273 south_out_data[10] VDD VSS BUF_X1
Xoutput274 net274 south_out_data[11] VDD VSS BUF_X1
Xoutput275 net275 south_out_data[12] VDD VSS BUF_X1
Xoutput276 net276 south_out_data[13] VDD VSS BUF_X1
Xoutput277 net277 south_out_data[14] VDD VSS BUF_X1
Xoutput278 net278 south_out_data[15] VDD VSS BUF_X1
Xoutput279 net279 south_out_data[16] VDD VSS BUF_X1
Xoutput280 net280 south_out_data[17] VDD VSS BUF_X1
Xoutput281 net281 south_out_data[18] VDD VSS BUF_X1
Xoutput282 net282 south_out_data[19] VDD VSS BUF_X1
Xoutput283 net283 south_out_data[1] VDD VSS BUF_X1
Xoutput284 net284 south_out_data[20] VDD VSS BUF_X1
Xoutput285 net285 south_out_data[21] VDD VSS BUF_X1
Xoutput286 net286 south_out_data[22] VDD VSS BUF_X1
Xoutput287 net287 south_out_data[23] VDD VSS BUF_X1
Xoutput288 net288 south_out_data[24] VDD VSS BUF_X1
Xoutput289 net289 south_out_data[25] VDD VSS BUF_X1
Xoutput290 net290 south_out_data[26] VDD VSS BUF_X1
Xoutput291 net291 south_out_data[27] VDD VSS BUF_X1
Xoutput292 net292 south_out_data[28] VDD VSS BUF_X1
Xoutput293 net293 south_out_data[29] VDD VSS BUF_X1
Xoutput294 net294 south_out_data[2] VDD VSS BUF_X1
Xoutput295 net295 south_out_data[30] VDD VSS BUF_X1
Xoutput296 net296 south_out_data[31] VDD VSS BUF_X1
Xoutput297 net297 south_out_data[3] VDD VSS BUF_X1
Xoutput298 net298 south_out_data[4] VDD VSS BUF_X1
Xoutput299 net299 south_out_data[5] VDD VSS BUF_X1
Xoutput300 net300 south_out_data[6] VDD VSS BUF_X1
Xoutput301 net301 south_out_data[7] VDD VSS BUF_X1
Xoutput302 net302 south_out_data[8] VDD VSS BUF_X1
Xoutput303 net303 south_out_data[9] VDD VSS BUF_X1
Xoutput304 net304 south_out_valid VDD VSS BUF_X1
Xoutput305 net305 west_in_ready VDD VSS BUF_X1
Xoutput306 net306 west_out_data[0] VDD VSS BUF_X1
Xoutput307 net307 west_out_data[10] VDD VSS BUF_X1
Xoutput308 net308 west_out_data[11] VDD VSS BUF_X1
Xoutput309 net309 west_out_data[12] VDD VSS BUF_X1
Xoutput310 net310 west_out_data[13] VDD VSS BUF_X1
Xoutput311 net311 west_out_data[14] VDD VSS BUF_X1
Xoutput312 net312 west_out_data[15] VDD VSS BUF_X1
Xoutput313 net313 west_out_data[16] VDD VSS BUF_X1
Xoutput314 net314 west_out_data[17] VDD VSS BUF_X1
Xoutput315 net315 west_out_data[18] VDD VSS BUF_X1
Xoutput316 net316 west_out_data[19] VDD VSS BUF_X1
Xoutput317 net317 west_out_data[1] VDD VSS BUF_X1
Xoutput318 net318 west_out_data[20] VDD VSS BUF_X1
Xoutput319 net319 west_out_data[21] VDD VSS BUF_X1
Xoutput320 net320 west_out_data[22] VDD VSS BUF_X1
Xoutput321 net321 west_out_data[23] VDD VSS BUF_X1
Xoutput322 net322 west_out_data[24] VDD VSS BUF_X1
Xoutput323 net323 west_out_data[25] VDD VSS BUF_X1
Xoutput324 net324 west_out_data[26] VDD VSS BUF_X1
Xoutput325 net325 west_out_data[27] VDD VSS BUF_X1
Xoutput326 net326 west_out_data[28] VDD VSS BUF_X1
Xoutput327 net327 west_out_data[29] VDD VSS BUF_X1
Xoutput328 net328 west_out_data[2] VDD VSS BUF_X1
Xoutput329 net329 west_out_data[30] VDD VSS BUF_X1
Xoutput330 net330 west_out_data[31] VDD VSS BUF_X1
Xoutput331 net331 west_out_data[3] VDD VSS BUF_X1
Xoutput332 net332 west_out_data[4] VDD VSS BUF_X1
Xoutput333 net333 west_out_data[5] VDD VSS BUF_X1
Xoutput334 net334 west_out_data[6] VDD VSS BUF_X1
Xoutput335 net335 west_out_data[7] VDD VSS BUF_X1
Xoutput336 net336 west_out_data[8] VDD VSS BUF_X1
Xoutput337 net337 west_out_data[9] VDD VSS BUF_X1
Xoutput338 net338 west_out_valid VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_0_0_clk clknet_0_clk clknet_4_0_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_1_0_clk clknet_0_clk clknet_4_1_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_2_0_clk clknet_0_clk clknet_4_2_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_3_0_clk clknet_0_clk clknet_4_3_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_4_0_clk clknet_0_clk clknet_4_4_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_5_0_clk clknet_0_clk clknet_4_5_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_6_0_clk clknet_0_clk clknet_4_6_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_7_0_clk clknet_0_clk clknet_4_7_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_8_0_clk clknet_0_clk clknet_4_8_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_9_0_clk clknet_0_clk clknet_4_9_0_clk VDD VSS CLKBUF_X3
Xclkbuf_4_10_0_clk clknet_0_clk clknet_4_10_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_11_0_clk clknet_0_clk clknet_4_11_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_12_0_clk clknet_0_clk clknet_4_12_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_13_0_clk clknet_0_clk clknet_4_13_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_14_0_clk clknet_0_clk clknet_4_14_0_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_4_15_0_clk clknet_0_clk clknet_4_15_0_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_4_0_0_clk _unconnected_0 VDD VSS CLKBUF_X2
Xclkload1 clknet_4_1_0_clk _unconnected_1 VDD VSS INV_X4
Xclkload2 clknet_4_2_0_clk _unconnected_2 VDD VSS INV_X4
Xclkload3 clknet_4_3_0_clk _unconnected_3 VDD VSS INV_X4
Xclkload4 clknet_4_4_0_clk _unconnected_4 VDD VSS INV_X4
Xclkload5 clknet_4_5_0_clk _unconnected_5 VDD VSS INV_X2
Xclkload6 clknet_4_6_0_clk _unconnected_6 VDD VSS INV_X2
Xclkload7 clknet_4_8_0_clk _unconnected_7 VDD VSS INV_X2
Xclkload8 clknet_4_9_0_clk _unconnected_8 VDD VSS INV_X4
Xclkload9 clknet_4_10_0_clk _unconnected_9 VDD VSS INV_X2
Xclkload10 clknet_4_11_0_clk _unconnected_10 VDD VSS INV_X1
Xclkload11 clknet_4_12_0_clk _unconnected_11 VDD VSS INV_X4
Xclkload12 clknet_4_13_0_clk _unconnected_12 VDD VSS INV_X4
Xclkload13 clknet_4_14_0_clk _unconnected_13 VDD VSS INV_X2
Xclkload14 clknet_4_15_0_clk _unconnected_14 VDD VSS INV_X2
Xrebuffer1 _1332_ net339 VDD VSS BUF_X1
Xrebuffer2 _1332_ net340 VDD VSS BUF_X1
Xrebuffer3 net340 net341 VDD VSS BUF_X1
Xrebuffer4 _1332_ net342 VDD VSS BUF_X1
Xrebuffer6 net343 net344 VDD VSS BUF_X1
.ENDS mesh_router
