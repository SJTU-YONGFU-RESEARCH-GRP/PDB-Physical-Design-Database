* cell axi_lite_master
* pin write_data[8]
* pin wdata[8]
* pin write_data[7]
* pin wdata[7]
* pin write_strb[0]
* pin wstrb[0]
* pin write_data[6]
* pin write_data[5]
* pin wdata[6]
* pin wdata[5]
* pin wvalid
* pin wready
* pin write_data[20]
* pin write_data[21]
* pin write_data[17]
* pin write_data[19]
* pin write_data[24]
* pin wdata[20]
* pin wdata[21]
* pin wdata[17]
* pin write_data[16]
* pin wdata[24]
* pin wdata[16]
* pin write_data[14]
* pin wdata[14]
* pin write_data[23]
* pin write_data[22]
* pin write_data[18]
* pin write_data[0]
* pin write_data[1]
* pin write_addr[8]
* pin write_data[12]
* pin write_addr[9]
* pin wdata[23]
* pin wdata[22]
* pin wdata[18]
* pin wdata[0]
* pin awaddr[8]
* pin wdata[1]
* pin wdata[12]
* pin awaddr[9]
* pin write_data[11]
* pin write_addr[23]
* pin write_data[13]
* pin write_addr[20]
* pin wdata[11]
* pin write_addr[25]
* pin awaddr[23]
* pin write_addr[19]
* pin write_addr[18]
* pin write_addr[1]
* pin write_addr[24]
* pin awaddr[20]
* pin awaddr[22]
* pin awaddr[26]
* pin awaddr[1]
* pin awaddr[19]
* pin awaddr[24]
* pin awaddr[18]
* pin awaddr[21]
* pin awaddr[25]
* pin wstrb[3]
* pin wstrb[2]
* pin write_strb[2]
* pin write_data[9]
* pin write_strb[1]
* pin write_strb[3]
* pin wstrb[1]
* pin wdata[9]
* pin wdata[19]
* pin rst_n
* pin write_addr[22]
* pin write_addr[26]
* pin write_addr[21]
* pin read_data[19]
* pin awaddr[16]
* pin awaddr[14]
* pin rdata[27]
* pin rdata[19]
* pin wdata[13]
* pin write_addr[16]
* pin write_addr[14]
* pin rdata[24]
* pin read_data[24]
* pin write_addr[12]
* pin awaddr[12]
* pin rdata[20]
* pin read_data[20]
* pin read_data[27]
* pin awaddr[17]
* pin write_addr[17]
* pin read_data[26]
* pin write_data[10]
* pin wdata[15]
* pin write_addr[0]
* pin awaddr[0]
* pin wdata[10]
* pin rdata[26]
* pin write_data[15]
* pin write_addr[11]
* pin write_addr[7]
* pin bready
* pin rdata[23]
* pin read_data[23]
* pin awaddr[7]
* pin awaddr[10]
* pin bvalid
* pin awaddr[13]
* pin write_addr[13]
* pin rdata[1]
* pin awaddr[11]
* pin write_addr[10]
* pin write_addr[15]
* pin read_done
* pin read_data[1]
* pin awaddr[15]
* pin araddr[13]
* pin rdata[25]
* pin read_data[25]
* pin read_addr[13]
* pin rdata[22]
* pin read_data[21]
* pin rdata[21]
* pin read_addr[15]
* pin read_data[22]
* pin read_data[9]
* pin read_data[8]
* pin araddr[15]
* pin rdata[9]
* pin rdata[8]
* pin awready
* pin write_done
* pin clk
* pin awvalid
* pin araddr[16]
* pin write_req
* pin read_data[5]
* pin read_addr[16]
* pin araddr[0]
* pin read_data[3]
* pin rdata[5]
* pin read_addr[0]
* pin araddr[18]
* pin read_addr[18]
* pin rdata[3]
* pin rdata[6]
* pin read_data[6]
* pin read_data[15]
* pin read_data[30]
* pin rdata[30]
* pin rdata[15]
* pin rvalid
* pin read_req
* pin read_addr[10]
* pin arready
* pin araddr[10]
* pin read_data[4]
* pin read_data[28]
* pin rdata[28]
* pin arvalid
* pin rdata[31]
* pin read_data[31]
* pin rdata[4]
* pin read_addr[11]
* pin araddr[11]
* pin araddr[14]
* pin read_addr[14]
* pin rdata[7]
* pin read_data[29]
* pin read_data[7]
* pin read_addr[12]
* pin read_addr[17]
* pin araddr[12]
* pin rdata[29]
* pin rdata[2]
* pin read_data[2]
* pin araddr[17]
* pin write_addr[29]
* pin awaddr[29]
* pin araddr[9]
* pin araddr[8]
* pin rready
* pin rdata[10]
* pin wdata[27]
* pin wdata[4]
* pin read_addr[9]
* pin read_addr[8]
* pin write_data[28]
* pin wdata[30]
* pin wdata[28]
* pin write_data[30]
* pin araddr[4]
* pin write_addr[27]
* pin araddr[1]
* pin araddr[29]
* pin read_data[18]
* pin read_data[11]
* pin write_data[2]
* pin write_addr[2]
* pin read_addr[22]
* pin read_addr[1]
* pin araddr[22]
* pin rdata[18]
* pin read_addr[29]
* pin read_addr[4]
* pin read_addr[26]
* pin awaddr[4]
* pin awaddr[3]
* pin read_data[17]
* pin write_data[4]
* pin rdata[11]
* pin write_addr[4]
* pin read_addr[24]
* pin read_data[10]
* pin awaddr[27]
* pin write_data[31]
* pin araddr[24]
* pin read_addr[25]
* pin read_addr[30]
* pin read_addr[7]
* pin awaddr[5]
* pin rdata[12]
* pin rdata[13]
* pin wdata[2]
* pin write_data[27]
* pin read_addr[3]
* pin araddr[3]
* pin rdata[17]
* pin read_data[12]
* pin write_addr[3]
* pin read_addr[21]
* pin write_addr[5]
* pin wdata[31]
* pin read_data[13]
* pin wdata[25]
* pin araddr[30]
* pin araddr[26]
* pin araddr[20]
* pin rdata[0]
* pin read_addr[19]
* pin araddr[31]
* pin rdata[14]
* pin write_data[26]
* pin write_data[29]
* pin araddr[6]
* pin araddr[7]
* pin write_addr[6]
* pin awaddr[30]
* pin read_addr[5]
* pin write_data[25]
* pin wdata[29]
* pin wdata[26]
* pin wdata[3]
* pin araddr[25]
* pin araddr[19]
* pin read_addr[23]
* pin read_addr[20]
* pin read_addr[6]
* pin write_data[3]
* pin read_data[16]
* pin read_data[14]
* pin araddr[5]
* pin awaddr[31]
* pin awaddr[28]
* pin read_addr[28]
* pin araddr[2]
* pin write_addr[31]
* pin write_addr[30]
* pin awaddr[6]
* pin araddr[28]
* pin araddr[27]
* pin araddr[21]
* pin araddr[23]
* pin read_addr[27]
* pin read_addr[31]
* pin read_addr[2]
* pin awaddr[2]
* pin write_addr[28]
* pin rdata[16]
* pin read_data[0]
* pin VDD
* pin VSS,gf180mcu_gnd
.SUBCKT axi_lite_master 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 84 120 155
+ 156 174 184 199 201 205 207 208 213 216 221 222 224 225 232 234 235 240 241
+ 249 250 251 257 265 270 271 278 285 292 293 300 302 303 309 310 311 312 316
+ 318 319 325 334 336 337 338 340 341 343 349 351 352 357 363 364 366 373 376
+ 377 378 383 387 390 392 395 403 410 411 419 420 422 423 424 430 431 432 438
+ 439 441 442 445 446 447 449 457 462 463 464 467 472 473 474 476 477 478 479
+ 485 486 487 489 490 495 499 500 501 505 516 518 523 524 529 530 534 535 536
+ 537 542 543 544 555 557 558 559 561 566 567 571 574 575 576 577 589 590 591
+ 592 599 601 603 604 608 609 610 619 620 630 632 638 640 641 643 644 645 648
+ 651 653 654 655 656 657 658 667 670 673 688 693 696 697 707 718 724 729 732
+ 733 736 737 739 740 741 742 743 744 745 746 747 748 749 750 751 752 753 754
+ 755 756 757 758 759 760 761 762 763 764 765 766 767 768 769 770 771 772 773
+ 774
* net 1 write_data[8]
* net 2 wdata[8]
* net 3 write_data[7]
* net 4 wdata[7]
* net 5 write_strb[0]
* net 6 wstrb[0]
* net 7 write_data[6]
* net 8 write_data[5]
* net 9 wdata[6]
* net 10 wdata[5]
* net 11 wvalid
* net 12 wready
* net 13 write_data[20]
* net 14 write_data[21]
* net 15 write_data[17]
* net 16 write_data[19]
* net 17 write_data[24]
* net 18 wdata[20]
* net 19 wdata[21]
* net 20 wdata[17]
* net 21 write_data[16]
* net 22 wdata[24]
* net 23 wdata[16]
* net 24 write_data[14]
* net 25 wdata[14]
* net 26 write_data[23]
* net 27 write_data[22]
* net 28 write_data[18]
* net 29 write_data[0]
* net 30 write_data[1]
* net 31 write_addr[8]
* net 32 write_data[12]
* net 33 write_addr[9]
* net 34 wdata[23]
* net 35 wdata[22]
* net 36 wdata[18]
* net 37 wdata[0]
* net 38 awaddr[8]
* net 39 wdata[1]
* net 40 wdata[12]
* net 41 awaddr[9]
* net 42 write_data[11]
* net 43 write_addr[23]
* net 44 write_data[13]
* net 45 write_addr[20]
* net 46 wdata[11]
* net 47 write_addr[25]
* net 48 awaddr[23]
* net 49 write_addr[19]
* net 50 write_addr[18]
* net 51 write_addr[1]
* net 52 write_addr[24]
* net 53 awaddr[20]
* net 54 awaddr[22]
* net 55 awaddr[26]
* net 56 awaddr[1]
* net 57 awaddr[19]
* net 58 awaddr[24]
* net 59 awaddr[18]
* net 60 awaddr[21]
* net 61 awaddr[25]
* net 62 wstrb[3]
* net 63 wstrb[2]
* net 64 write_strb[2]
* net 65 write_data[9]
* net 66 write_strb[1]
* net 67 write_strb[3]
* net 68 wstrb[1]
* net 69 wdata[9]
* net 84 wdata[19]
* net 120 rst_n
* net 155 write_addr[22]
* net 156 write_addr[26]
* net 174 write_addr[21]
* net 184 read_data[19]
* net 199 awaddr[16]
* net 201 awaddr[14]
* net 205 rdata[27]
* net 207 rdata[19]
* net 208 wdata[13]
* net 213 write_addr[16]
* net 216 write_addr[14]
* net 221 rdata[24]
* net 222 read_data[24]
* net 224 write_addr[12]
* net 225 awaddr[12]
* net 232 rdata[20]
* net 234 read_data[20]
* net 235 read_data[27]
* net 240 awaddr[17]
* net 241 write_addr[17]
* net 249 read_data[26]
* net 250 write_data[10]
* net 251 wdata[15]
* net 257 write_addr[0]
* net 265 awaddr[0]
* net 270 wdata[10]
* net 271 rdata[26]
* net 278 write_data[15]
* net 285 write_addr[11]
* net 292 write_addr[7]
* net 293 bready
* net 300 rdata[23]
* net 302 read_data[23]
* net 303 awaddr[7]
* net 309 awaddr[10]
* net 310 bvalid
* net 311 awaddr[13]
* net 312 write_addr[13]
* net 316 rdata[1]
* net 318 awaddr[11]
* net 319 write_addr[10]
* net 325 write_addr[15]
* net 334 read_done
* net 336 read_data[1]
* net 337 awaddr[15]
* net 338 araddr[13]
* net 340 rdata[25]
* net 341 read_data[25]
* net 343 read_addr[13]
* net 349 rdata[22]
* net 351 read_data[21]
* net 352 rdata[21]
* net 357 read_addr[15]
* net 363 read_data[22]
* net 364 read_data[9]
* net 366 read_data[8]
* net 373 araddr[15]
* net 376 rdata[9]
* net 377 rdata[8]
* net 378 awready
* net 383 write_done
* net 387 clk
* net 390 awvalid
* net 392 araddr[16]
* net 395 write_req
* net 403 read_data[5]
* net 410 read_addr[16]
* net 411 araddr[0]
* net 419 read_data[3]
* net 420 rdata[5]
* net 422 read_addr[0]
* net 423 araddr[18]
* net 424 read_addr[18]
* net 430 rdata[3]
* net 431 rdata[6]
* net 432 read_data[6]
* net 438 read_data[15]
* net 439 read_data[30]
* net 441 rdata[30]
* net 442 rdata[15]
* net 445 rvalid
* net 446 read_req
* net 447 read_addr[10]
* net 449 arready
* net 457 araddr[10]
* net 462 read_data[4]
* net 463 read_data[28]
* net 464 rdata[28]
* net 467 arvalid
* net 472 rdata[31]
* net 473 read_data[31]
* net 474 rdata[4]
* net 476 read_addr[11]
* net 477 araddr[11]
* net 478 araddr[14]
* net 479 read_addr[14]
* net 485 rdata[7]
* net 486 read_data[29]
* net 487 read_data[7]
* net 489 read_addr[12]
* net 490 read_addr[17]
* net 495 araddr[12]
* net 499 rdata[29]
* net 500 rdata[2]
* net 501 read_data[2]
* net 505 araddr[17]
* net 516 write_addr[29]
* net 518 awaddr[29]
* net 523 araddr[9]
* net 524 araddr[8]
* net 529 rready
* net 530 rdata[10]
* net 534 wdata[27]
* net 535 wdata[4]
* net 536 read_addr[9]
* net 537 read_addr[8]
* net 542 write_data[28]
* net 543 wdata[30]
* net 544 wdata[28]
* net 555 write_data[30]
* net 557 araddr[4]
* net 558 write_addr[27]
* net 559 araddr[1]
* net 561 araddr[29]
* net 566 read_data[18]
* net 567 read_data[11]
* net 571 write_data[2]
* net 574 write_addr[2]
* net 575 read_addr[22]
* net 576 read_addr[1]
* net 577 araddr[22]
* net 589 rdata[18]
* net 590 read_addr[29]
* net 591 read_addr[4]
* net 592 read_addr[26]
* net 599 awaddr[4]
* net 601 awaddr[3]
* net 603 read_data[17]
* net 604 write_data[4]
* net 608 rdata[11]
* net 609 write_addr[4]
* net 610 read_addr[24]
* net 619 read_data[10]
* net 620 awaddr[27]
* net 630 write_data[31]
* net 632 araddr[24]
* net 638 read_addr[25]
* net 640 read_addr[30]
* net 641 read_addr[7]
* net 643 awaddr[5]
* net 644 rdata[12]
* net 645 rdata[13]
* net 648 wdata[2]
* net 651 write_data[27]
* net 653 read_addr[3]
* net 654 araddr[3]
* net 655 rdata[17]
* net 656 read_data[12]
* net 657 write_addr[3]
* net 658 read_addr[21]
* net 667 write_addr[5]
* net 670 wdata[31]
* net 673 read_data[13]
* net 688 wdata[25]
* net 693 araddr[30]
* net 696 araddr[26]
* net 697 araddr[20]
* net 707 rdata[0]
* net 718 read_addr[19]
* net 724 araddr[31]
* net 729 rdata[14]
* net 732 write_data[26]
* net 733 write_data[29]
* net 736 araddr[6]
* net 737 araddr[7]
* net 739 write_addr[6]
* net 740 awaddr[30]
* net 741 read_addr[5]
* net 742 write_data[25]
* net 743 wdata[29]
* net 744 wdata[26]
* net 745 wdata[3]
* net 746 araddr[25]
* net 747 araddr[19]
* net 748 read_addr[23]
* net 749 read_addr[20]
* net 750 read_addr[6]
* net 751 write_data[3]
* net 752 read_data[16]
* net 753 read_data[14]
* net 754 araddr[5]
* net 755 awaddr[31]
* net 756 awaddr[28]
* net 757 read_addr[28]
* net 758 araddr[2]
* net 759 write_addr[31]
* net 760 write_addr[30]
* net 761 awaddr[6]
* net 762 araddr[28]
* net 763 araddr[27]
* net 764 araddr[21]
* net 765 araddr[23]
* net 766 read_addr[27]
* net 767 read_addr[31]
* net 768 read_addr[2]
* net 769 awaddr[2]
* net 770 write_addr[28]
* net 771 rdata[16]
* net 772 read_data[0]
* net 773 VDD
* net 774 VSS,gf180mcu_gnd
* cell instance $2 r0 *1 36.96,5.04
X$2 1 773 774 76 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7 r0 *1 58.24,5.04
X$7 77 773 774 2 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10 r0 *1 49.84,5.04
X$10 3 773 774 128 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14 r0 *1 57.68,25.2
X$14 129 773 774 4 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $20 r0 *1 66.64,5.04
X$20 5 773 774 78 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $25 m0 *1 64.96,15.12
X$25 79 773 774 6 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $28 m0 *1 73.36,35.28
X$28 7 773 774 148 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33 m0 *1 75.6,55.44
X$33 8 773 774 196 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $36 r0 *1 72.8,35.28
X$36 153 773 774 9 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $40 m0 *1 81.2,45.36
X$40 164 773 774 10 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $45 m0 *1 87.36,65.52
X$45 228 773 774 11 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $48 r0 *1 89.6,65.52
X$48 12 773 774 229 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $52 r0 *1 91.84,5.04
X$52 13 773 774 102 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $57 r0 *1 75.04,5.04
X$57 14 773 774 80 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $61 r0 *1 101.92,5.04
X$61 15 773 774 82 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64 r0 *1 92.4,25.2
X$64 16 773 774 150 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68 r0 *1 92.4,45.36
X$68 17 773 774 185 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $72 m0 *1 90.72,25.2
X$72 130 773 774 18 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $76 m0 *1 82.32,15.12
X$76 81 773 774 19 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $81 m0 *1 100.24,15.12
X$81 83 773 774 20 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $84 r0 *1 104.16,35.28
X$84 21 773 774 159 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $88 m0 *1 104.72,45.36
X$88 171 773 774 22 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $93 r0 *1 109.76,45.36
X$93 189 773 774 23 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97 r0 *1 120.4,5.04
X$97 24 773 774 85 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $101 m0 *1 119.28,15.12
X$101 86 773 774 25 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $104 r0 *1 128.8,5.04
X$104 26 773 774 126 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $109 r0 *1 122.64,25.2
X$109 27 773 774 152 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $113 r0 *1 121.52,65.52
X$113 28 773 774 230 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $117 r0 *1 132.72,35.28
X$117 29 773 774 178 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $120 r0 *1 124.88,55.44
X$120 30 773 774 193 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $124 m0 *1 136.64,45.36
X$124 31 773 774 165 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $128 m0 *1 136.64,15.12
X$128 32 773 774 87 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $132 r0 *1 137.76,5.04
X$132 33 773 774 139 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $137 m0 *1 127.68,15.12
X$137 110 773 774 34 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $141 r0 *1 130.48,15.12
X$141 111 773 774 35 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $144 m0 *1 142.8,75.6
X$144 231 773 774 36 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $151 r0 *1 133.84,45.36
X$151 173 773 774 37 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $155 r0 *1 145.04,35.28
X$155 161 773 774 38 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $158 r0 *1 141.68,55.44
X$158 204 773 774 39 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $162 m0 *1 145.04,15.12
X$162 88 773 774 40 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $166 r0 *1 146.16,5.04
X$166 89 773 774 41 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $171 r0 *1 157.36,5.04
X$171 42 773 774 90 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $175 r0 *1 166.32,5.04
X$175 43 773 774 106 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $178 m0 *1 162.4,45.36
X$178 44 773 774 166 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $182 r0 *1 173.04,25.2
X$182 45 773 774 142 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $186 m0 *1 169.12,15.12
X$186 91 773 774 46 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $191 m0 *1 173.04,55.44
X$191 47 773 774 183 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $194 r0 *1 164.64,25.2
X$194 140 773 774 48 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $198 r0 *1 176.4,5.04
X$198 49 773 774 115 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $203 m0 *1 192.08,15.12
X$203 50 773 774 116 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $207 r0 *1 192.08,5.04
X$207 51 773 774 105 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $211 r0 *1 199.92,25.2
X$211 52 773 774 118 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $215 m0 *1 201.6,35.28
X$215 143 773 774 53 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $218 r0 *1 212.24,25.2
X$218 144 773 774 54 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $223 m0 *1 222.88,25.2
X$223 132 773 774 55 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $227 m0 *1 212.24,35.28
X$227 97 773 774 56 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $231 r0 *1 224,5.04
X$231 92 773 774 57 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $234 m0 *1 183.68,15.12
X$234 103 773 774 58 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $238 r0 *1 212.24,5.04
X$238 96 773 774 59 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $242 r0 *1 225.68,15.12
X$242 119 773 774 60 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $247 m0 *1 225.68,15.12
X$247 99 773 774 61 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $250 r0 *1 28.56,5.04
X$250 75 773 774 62 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $253 m0 *1 2.24,35.28
X$253 136 773 774 63 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $256 r0 *1 2.24,25.2
X$256 64 773 774 135 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $259 r0 *1 3.36,5.04
X$259 65 773 774 71 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $262 r0 *1 10.64,25.2
X$262 66 773 774 137 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $265 r0 *1 11.76,5.04
X$265 67 773 774 72 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $268 m0 *1 25.76,15.12
X$268 74 773 774 68 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $271 r0 *1 20.16,5.04
X$271 73 773 774 69 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $274 m0 *1 3.92,15.12
X$274 774 98 73 107 70 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $276 r0 *1 7.84,15.12
X$276 774 773 70 71 95 73 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $281 m0 *1 19.04,25.2
X$281 774 773 127 72 95 75 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $288 m0 *1 19.04,35.28
X$288 774 773 108 137 95 74 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $291 r0 *1 17.36,15.12
X$291 774 98 74 107 108 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $297 r0 *1 19.04,25.2
X$297 774 98 75 107 127 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $303 m0 *1 38.64,25.2
X$303 774 773 121 76 95 77 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $306 r0 *1 36.96,15.12
X$306 774 98 77 107 121 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $314 m0 *1 56,15.12
X$314 774 773 100 78 95 79 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $319 m0 *1 47.04,25.2
X$319 774 98 79 107 100 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $322 m0 *1 73.92,25.2
X$322 774 773 123 80 95 81 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $326 r0 *1 62.72,15.12
X$326 774 98 81 109 123 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $330 m0 *1 91.28,15.12
X$330 774 773 101 82 95 83 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $335 r0 *1 81.76,15.12
X$335 774 98 83 109 101 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $339 m0 *1 101.36,35.28
X$339 138 773 774 84 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $345 m0 *1 109.76,15.12
X$345 774 773 104 85 95 86 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $352 r0 *1 102.48,15.12
X$352 774 98 86 109 104 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $355 r0 *1 139.44,15.12
X$355 774 773 112 87 95 88 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $358 m0 *1 133.28,25.2
X$358 774 98 88 113 112 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $363 r0 *1 134.4,25.2
X$363 774 98 89 113 131 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $367 m0 *1 141.12,35.28
X$367 774 773 131 139 95 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $370 m0 *1 160.72,15.12
X$370 774 773 125 90 95 91 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $377 r0 *1 154.56,15.12
X$377 774 98 91 113 125 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $379 m0 *1 179.2,25.2
X$379 774 773 114 115 95 92 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $382 r0 *1 174.16,15.12
X$382 774 98 92 94 114 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $387 m0 *1 201.6,15.12
X$387 774 98 97 94 93 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $389 r0 *1 201.6,5.04
X$389 774 773 93 105 95 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $391 m0 *1 201.6,45.36
X$391 774 154 119 94 176 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $394 r0 *1 171.92,45.36
X$394 774 170 94 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $399 r0 *1 193.2,45.36
X$399 774 154 144 94 177 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $401 m0 *1 201.6,25.2
X$401 774 98 103 94 122 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $403 r0 *1 194.32,15.12
X$403 774 98 96 94 117 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $406 m0 *1 172.48,65.52
X$406 774 773 94 782 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $408 r0 *1 153.44,35.28
X$408 774 98 140 94 160 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $413 m0 *1 203.84,55.44
X$413 774 154 132 94 158 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $415 m0 *1 174.16,45.36
X$415 774 98 99 94 167 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $417 r0 *1 173.6,35.28
X$417 774 98 143 94 141 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $425 r0 *1 134.4,95.76
X$425 774 773 361 95 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $427 r0 *1 37.52,95.76
X$427 774 773 295 320 95 296 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $429 r0 *1 89.6,85.68
X$429 774 773 95 297 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $434 m0 *1 10.64,65.52
X$434 774 773 214 215 95 198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $436 r0 *1 12.32,75.6
X$436 774 773 266 267 95 256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $442 m0 *1 10.64,35.28
X$442 774 773 134 135 95 136 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $445 r0 *1 30.24,65.52
X$445 774 773 236 226 95 242 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $447 r0 *1 29.68,55.44
X$447 774 773 194 200 95 187 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $449 r0 *1 28,85.68
X$449 774 773 275 294 95 281 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $452 r0 *1 7.84,45.36
X$452 774 773 175 180 95 162 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $454 r0 *1 7.28,55.44
X$454 774 773 179 197 95 181 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $458 m0 *1 192.08,25.2
X$458 774 773 117 116 95 96 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $460 r0 *1 214.48,15.12
X$460 774 773 122 118 95 103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $462 r0 *1 212.24,45.36
X$462 774 773 177 157 95 144 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $465 r0 *1 220.64,45.36
X$465 774 773 176 168 95 119 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $468 m0 *1 11.2,85.68
X$468 774 773 279 286 95 274 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $470 r0 *1 211.12,35.28
X$470 774 773 158 146 95 132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $472 m0 *1 181.44,55.44
X$472 774 773 167 183 95 99 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $475 m0 *1 177.52,35.28
X$475 774 773 141 142 95 143 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $477 m0 *1 164.64,55.44
X$477 774 773 190 166 95 191 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $480 m0 *1 185.36,85.68
X$480 774 773 247 280 95 248 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $483 m0 *1 145.04,45.36
X$483 774 773 169 165 95 161 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $486 r0 *1 167.44,85.68
X$486 774 773 305 299 95 291 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $488 r0 *1 129.92,65.52
X$488 774 773 245 230 95 231 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $490 m0 *1 153.44,75.6
X$490 774 773 260 254 95 261 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $492 r0 *1 103.04,55.44
X$492 774 773 186 159 95 189 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $495 r0 *1 73.36,55.44
X$495 774 773 163 196 95 164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $498 m0 *1 92.96,35.28
X$498 774 773 149 150 95 138 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $500 m0 *1 87.36,55.44
X$500 774 773 188 185 95 171 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $504 r0 *1 122.08,15.12
X$504 774 773 124 126 95 110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $509 r0 *1 49.28,25.2
X$509 774 773 147 128 95 129 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $514 r0 *1 133.28,55.44
X$514 774 773 212 193 95 204 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $517 m0 *1 160.72,35.28
X$517 774 773 160 106 95 140 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $520 m0 *1 82.32,25.2
X$520 774 773 133 102 95 130 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $523 r0 *1 61.6,55.44
X$523 774 773 195 148 95 153 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $526 m0 *1 121.52,35.28
X$526 774 773 151 152 95 111 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $530 r0 *1 123.76,45.36
X$530 774 773 172 178 95 173 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $579 m0 *1 73.92,95.76
X$579 774 773 98 262 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $581 m0 *1 174.72,146.16
X$581 774 773 154 98 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $583 r0 *1 6.72,65.52
X$583 774 98 198 182 214 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $585 r0 *1 7.28,35.28
X$585 774 98 136 107 134 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $589 m0 *1 43.68,35.28
X$589 774 98 129 107 147 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $591 m0 *1 30.24,75.6
X$591 774 98 242 182 236 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $593 m0 *1 27.44,55.44
X$593 774 98 187 107 194 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $596 m0 *1 6.16,45.36
X$596 774 98 162 107 175 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $598 r0 *1 36.4,85.68
X$598 774 98 296 182 295 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $600 m0 *1 28,85.68
X$600 774 98 281 182 275 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $602 m0 *1 5.6,55.44
X$602 774 98 181 107 179 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $607 r0 *1 26.88,105.84
X$607 774 98 359 182 358 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $609 m0 *1 43.68,115.92
X$609 774 98 384 182 374 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $612 m0 *1 101.92,85.68
X$612 774 98 258 255 283 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $614 r0 *1 6.72,115.92
X$614 774 98 394 433 393 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $616 r0 *1 70.56,65.52
X$616 774 98 228 255 239 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $621 r0 *1 6.16,85.68
X$621 774 98 256 182 266 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $624 m0 *1 3.36,95.76
X$624 774 98 274 182 279 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $629 m0 *1 3.92,115.92
X$629 774 98 345 182 367 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $632 r0 *1 158.48,55.44
X$632 774 98 191 203 190 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $635 m0 *1 136.64,55.44
X$635 774 98 161 113 169 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $638 m0 *1 123.76,75.6
X$638 774 98 231 203 245 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $640 m0 *1 127.12,65.52
X$640 774 98 204 203 212 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $642 m0 *1 95.76,55.44
X$642 774 98 189 109 186 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $645 r0 *1 81.76,35.28
X$645 774 98 138 109 149 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $647 r0 *1 81.76,55.44
X$647 774 98 171 109 188 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $657 m0 *1 111.44,25.2
X$657 774 98 110 113 124 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $664 m0 *1 115.92,55.44
X$664 774 98 173 113 172 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $667 m0 *1 51.52,55.44
X$667 774 98 153 182 195 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $670 r0 *1 113.68,35.28
X$670 774 98 111 113 151 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $672 r0 *1 68.88,25.2
X$672 774 98 130 109 133 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $674 m0 *1 54.88,45.36
X$674 774 98 164 109 163 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $677 r0 *1 33.04,126
X$677 774 98 414 433 413 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $679 m0 *1 16.24,136.08
X$679 774 98 448 433 455 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $682 m0 *1 36.4,146.16
X$682 774 98 460 433 458 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $684 m0 *1 2.8,146.16
X$684 774 98 471 433 502 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $686 r0 *1 12.88,156.24
X$686 774 98 513 433 526 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $688 m0 *1 3.92,156.24
X$688 774 98 512 433 506 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $691 m0 *1 95.76,95.76
X$691 774 98 288 255 307 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $693 m0 *1 57.12,85.68
X$693 774 98 268 255 282 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $696 r0 *1 57.12,105.84
X$696 774 98 346 255 354 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $698 m0 *1 47.6,156.24
X$698 774 98 494 433 508 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $700 r0 *1 34.16,146.16
X$700 774 98 493 433 492 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $801 m0 *1 43.12,45.36
X$801 774 773 107 787 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $805 r0 *1 43.12,45.36
X$805 774 170 107 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $829 m0 *1 70.56,55.44
X$829 774 773 109 775 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $831 r0 *1 68.32,45.36
X$831 774 170 109 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $855 m0 *1 153.44,45.36
X$855 774 773 113 780 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $860 r0 *1 146.72,45.36
X$860 774 170 113 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $885 r0 *1 220.64,25.2
X$885 774 145 120 773 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $980 r0 *1 203.28,35.28
X$980 774 773 145 154 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $985 m0 *1 220.64,35.28
X$985 156 773 774 146 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1024 r0 *1 156.8,65.52
X$1024 774 154 218 203 217 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1026 m0 *1 180.88,95.76
X$1026 774 154 323 246 315 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1028 r0 *1 201.04,105.84
X$1028 774 154 365 246 380 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1030 m0 *1 201.6,105.84
X$1030 774 154 335 246 342 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1032 r0 *1 199.92,95.76
X$1032 774 154 301 246 324 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1035 r0 *1 203.28,65.52
X$1035 774 154 220 246 238 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1037 m0 *1 206.64,75.6
X$1037 774 154 192 246 237 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1040 m0 *1 181.44,65.52
X$1040 774 154 219 246 223 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1043 r0 *1 203.28,75.6
X$1043 774 154 263 246 273 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1045 m0 *1 204.4,126
X$1045 774 154 389 418 405 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1047 r0 *1 184.8,126
X$1047 774 154 402 418 391 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1049 r0 *1 203.84,126
X$1049 774 154 440 418 443 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1051 r0 *1 201.6,156.24
X$1051 774 154 532 418 547 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1053 r0 *1 199.92,146.16
X$1053 774 154 484 418 503 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1055 m0 *1 201.6,156.24
X$1055 774 154 510 418 520 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1057 r0 *1 200.48,166.32
X$1057 774 154 556 418 554 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1059 m0 *1 201.6,176.4
X$1059 774 154 572 569 586 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1061 m0 *1 176.96,156.24
X$1061 774 154 483 418 531 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1064 m0 *1 181.44,216.72
X$1064 774 154 710 569 684 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1066 r0 *1 170.24,216.72
X$1066 774 154 709 569 682 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1068 r0 *1 156.8,206.64
X$1068 774 154 692 583 681 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1070 r0 *1 203.28,186.48
X$1070 774 154 621 569 624 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1072 r0 *1 194.88,196.56
X$1072 774 154 647 569 650 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1074 m0 *1 162.96,196.56
X$1074 774 154 629 569 652 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1076 m0 *1 173.6,206.64
X$1076 774 154 669 569 668 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1078 m0 *1 157.92,156.24
X$1078 774 154 519 428 509 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1081 r0 *1 155.12,146.16
X$1081 774 154 482 428 522 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1083 r0 *1 202.16,216.72
X$1083 774 154 687 569 711 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1085 r0 *1 202.16,206.64
X$1085 774 154 686 569 685 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1087 m0 *1 202.72,216.72
X$1087 774 154 712 569 690 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1111 r0 *1 220.64,35.28
X$1111 155 773 774 157 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1142 r0 *1 15.68,55.44
X$1142 162 773 774 199 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1162 m0 *1 225.68,45.36
X$1162 174 773 774 168 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1173 r0 *1 44.24,186.48
X$1173 774 170 578 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1177 r0 *1 44.8,156.24
X$1177 774 170 433 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1180 r0 *1 69.44,186.48
X$1180 774 170 562 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1183 r0 *1 66.64,75.6
X$1183 774 170 255 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1186 r0 *1 41.44,75.6
X$1186 774 170 182 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1189 r0 *1 70,156.24
X$1189 774 170 451 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1194 m0 *1 105.28,115.92
X$1194 774 387 170 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1199 r0 *1 147.28,186.48
X$1199 774 170 583 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1204 r0 *1 173.04,156.24
X$1204 774 170 418 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1207 r0 *1 147.84,156.24
X$1207 774 170 428 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1210 r0 *1 175.84,75.6
X$1210 774 170 246 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1213 r0 *1 172.48,186.48
X$1213 774 170 569 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1216 r0 *1 150.64,75.6
X$1216 774 170 203 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1259 m0 *1 2.24,65.52
X$1259 213 773 774 180 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1263 m0 *1 19.04,65.52
X$1263 181 773 774 225 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1272 r0 *1 41.44,65.52
X$1272 774 773 182 788 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1293 m0 *1 225.68,55.44
X$1293 192 773 774 184 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1306 r0 *1 38.08,55.44
X$1306 187 773 774 201 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1319 r0 *1 178.64,55.44
X$1319 191 773 774 208 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1325 r0 *1 222.32,65.52
X$1325 774 773 237 209 206 192 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1345 m0 *1 2.8,75.6
X$1345 224 773 774 197 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1350 m0 *1 11.76,75.6
X$1350 198 773 774 240 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1358 m0 *1 27.44,65.52
X$1358 216 773 774 200 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1363 m0 *1 76.16,85.68
X$1363 774 277 773 282 202 258 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1365 m0 *1 79.52,65.52
X$1365 774 773 259 202 264 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1367 r0 *1 146.16,75.6
X$1367 774 773 203 777 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $1369 m0 *1 147.84,105.84
X$1369 774 262 350 203 353 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1372 m0 *1 146.16,85.68
X$1372 774 262 261 203 260 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1374 m0 *1 128.24,105.84
X$1374 774 262 332 203 339 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1382 r0 *1 148.4,85.68
X$1382 774 262 291 203 305 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1393 r0 *1 212.24,55.44
X$1393 205 773 774 210 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1396 r0 *1 214.48,115.92
X$1396 774 773 405 404 206 389 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1399 r0 *1 119.28,95.76
X$1399 329 331 298 774 773 206 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $1401 m0 *1 131.04,176.4
X$1401 774 773 553 564 206 565 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1403 r0 *1 182,95.76
X$1403 774 773 315 333 206 323 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1405 m0 *1 176.96,115.92
X$1405 774 773 382 381 206 362 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1407 m0 *1 155.68,65.52
X$1407 774 773 217 211 206 218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1409 m0 *1 220.64,105.84
X$1409 774 773 342 317 206 335 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1411 r0 *1 195.44,115.92
X$1411 774 773 391 401 206 402 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1414 m0 *1 212.8,115.92
X$1414 774 773 380 379 206 365 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1416 m0 *1 211.68,95.76
X$1416 774 773 324 304 206 301 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1419 r0 *1 147.28,105.84
X$1419 774 773 353 368 206 350 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1423 r0 *1 194.88,65.52
X$1423 774 773 223 233 206 219 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1425 m0 *1 212.8,65.52
X$1425 774 773 238 210 206 220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1427 r0 *1 222.32,75.6
X$1427 774 773 273 272 206 263 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1429 m0 *1 212.24,146.16
X$1429 774 773 503 475 206 484 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1431 m0 *1 213.92,136.08
X$1431 774 773 443 453 206 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1433 m0 *1 210.56,166.32
X$1433 774 773 547 545 206 532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1435 r0 *1 220.64,156.24
X$1435 774 773 520 533 206 510 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1437 r0 *1 193.76,136.08
X$1437 774 773 466 465 206 461 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1439 m0 *1 192.08,166.32
X$1439 774 773 531 498 206 483 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1441 m0 *1 175.28,226.8
X$1441 774 773 668 708 206 669 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1444 r0 *1 175.84,206.64
X$1444 774 773 682 683 206 709 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1446 r0 *1 160.72,216.72
X$1446 774 773 681 730 206 692 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1448 m0 *1 128.8,196.56
X$1448 774 773 617 628 206 618 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1450 r0 *1 142.8,136.08
X$1450 774 773 470 469 206 429 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1453 m0 *1 160.72,136.08
X$1453 774 773 456 444 206 452 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1455 m0 *1 128.24,146.16
X$1455 774 773 488 480 206 481 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1457 r0 *1 158.48,196.56
X$1457 774 773 652 646 206 629 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1459 m0 *1 161.28,166.32
X$1459 774 773 522 511 206 482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1461 m0 *1 153.44,196.56
X$1461 774 773 602 637 206 588 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1464 r0 *1 159.04,166.32
X$1464 774 773 509 568 206 519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1466 m0 *1 170.8,126
X$1466 774 773 408 417 206 400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1502 r0 *1 224,55.44
X$1502 207 773 774 209 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1515 m0 *1 164.08,65.52
X$1515 221 773 774 211 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1528 r0 *1 2.8,75.6
X$1528 241 773 774 215 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1538 r0 *1 178.08,65.52
X$1538 218 773 774 222 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1546 m0 *1 204.4,65.52
X$1546 219 773 774 234 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1550 m0 *1 224.56,65.52
X$1550 220 773 774 235 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1572 m0 *1 20.72,75.6
X$1572 257 773 774 226 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1575 m0 *1 72.24,65.52
X$1575 774 268 773 277 227 258 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1577 m0 *1 95.2,75.6
X$1577 773 228 229 774 227 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1580 r0 *1 81.76,85.68
X$1580 773 289 774 227 306 288 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1585 m0 *1 84.56,85.68
X$1585 773 269 774 284 253 228 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1587 r0 *1 87.92,75.6
X$1587 774 252 259 773 228 244 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1594 m0 *1 90.16,75.6
X$1594 774 773 243 244 229 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1606 r0 *1 186.48,65.52
X$1606 232 773 774 233 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1629 m0 *1 61.6,75.6
X$1629 774 773 252 239 253 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1638 r0 *1 33.04,75.6
X$1638 242 773 774 265 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1643 r0 *1 77.84,115.92
X$1643 774 773 243 407 396 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1646 r0 *1 89.04,95.76
X$1646 328 773 774 243 259 329 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $1648 r0 *1 89.04,105.84
X$1648 355 773 774 243 298 290 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $1651 r0 *1 84.56,95.76
X$1651 774 773 288 243 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $1653 r0 *1 89.04,126
X$1653 298 243 450 434 774 773 397 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1655 r0 *1 75.04,126
X$1655 434 243 425 436 258 773 774 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1657 m0 *1 85.68,126
X$1657 774 415 269 773 243 396 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1665 r0 *1 170.24,105.84
X$1665 774 262 362 246 382 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1673 m0 *1 173.04,75.6
X$1673 774 262 248 246 247 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1675 m0 *1 175.84,85.68
X$1675 774 773 246 783 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1692 m0 *1 192.08,75.6
X$1692 248 773 774 251 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1696 m0 *1 225.68,75.6
X$1696 263 773 774 249 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1699 m0 *1 161.84,75.6
X$1699 250 773 774 254 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1725 m0 *1 66.64,75.6
X$1725 774 255 781 773 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1738 m0 *1 19.6,85.68
X$1738 256 773 774 318 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1745 r0 *1 108.64,105.84
X$1745 773 258 774 330 370 388 369 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1747 r0 *1 101.92,85.68
X$1747 774 258 773 289 308 290 331 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1750 r0 *1 95.2,75.6
X$1750 774 773 258 269 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $1753 m0 *1 79.52,105.84
X$1753 774 773 258 347 327 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1759 r0 *1 111.44,95.76
X$1759 773 332 774 288 322 258 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1767 m0 *1 119.84,115.92
X$1767 774 773 259 369 321 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1769 r0 *1 123.76,105.84
X$1769 774 773 298 259 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1773 m0 *1 92.4,85.68
X$1773 259 773 288 290 774 284 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1775 r0 *1 87.92,115.92
X$1775 773 259 774 409 407 385 375 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1779 m0 *1 120.4,105.84
X$1779 773 322 774 356 339 259 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1794 m0 *1 165.2,85.68
X$1794 261 773 774 270 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1799 r0 *1 110.32,115.92
X$1799 774 262 321 428 388 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1802 r0 *1 164.08,115.92
X$1802 774 262 400 418 408 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1812 m0 *1 30.8,216.72
X$1812 774 262 698 578 675 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1814 r0 *1 81.76,206.64
X$1814 774 262 678 562 715 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1816 m0 *1 83.44,226.8
X$1816 774 262 725 562 702 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1818 r0 *1 174.72,136.08
X$1818 774 262 461 418 466 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1820 m0 *1 174.72,176.4
X$1820 774 262 541 569 570 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1822 m0 *1 79.52,186.48
X$1822 774 262 614 562 597 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1824 r0 *1 61.04,206.64
X$1824 774 262 677 562 674 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1827 r0 *1 58.24,176.4
X$1827 774 262 596 562 634 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1829 m0 *1 56.56,186.48
X$1829 774 262 613 562 595 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1831 m0 *1 60.48,216.72
X$1831 774 262 700 562 691 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1833 r0 *1 117.6,206.64
X$1833 774 262 679 583 695 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1836 m0 *1 108.64,216.72
X$1836 774 262 704 583 717 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1838 r0 *1 104.72,186.48
X$1838 774 262 616 562 615 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1840 m0 *1 175.84,186.48
X$1840 774 262 585 569 605 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1842 r0 *1 136.64,206.64
X$1842 774 262 694 583 680 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1845 m0 *1 137.2,216.72
X$1845 774 262 706 583 716 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1847 m0 *1 127.12,156.24
X$1847 774 262 540 428 548 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1849 r0 *1 122.08,146.16
X$1849 774 262 481 428 488 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1851 r0 *1 124.88,166.32
X$1851 774 262 565 428 553 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1853 r0 *1 134.4,126
X$1853 774 262 429 428 470 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1855 m0 *1 141.68,136.08
X$1855 774 262 452 428 456 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1857 m0 *1 106.96,136.08
X$1857 774 262 399 451 437 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1859 r0 *1 123.2,176.4
X$1859 774 262 600 583 584 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1861 r0 *1 123.76,186.48
X$1861 774 262 618 583 617 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1863 m0 *1 148.4,186.48
X$1863 774 262 588 583 602 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1866 m0 *1 80.08,156.24
X$1866 774 262 515 451 521 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1868 m0 *1 89.6,166.32
X$1868 774 262 539 451 527 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1871 m0 *1 103.6,176.4
X$1871 774 262 582 562 563 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1873 m0 *1 66.08,166.32
X$1873 774 262 552 451 538 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1876 m0 *1 95.76,126
X$1876 774 262 298 451 416 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1879 r0 *1 81.76,136.08
X$1879 774 262 450 451 468 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1881 m0 *1 95.76,146.16
X$1881 774 262 497 451 504 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1883 m0 *1 8.4,206.64
X$1883 774 262 660 578 659 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1885 r0 *1 28.56,166.32
X$1885 774 262 560 433 551 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1887 r0 *1 6.16,216.72
X$1887 774 262 721 578 719 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1889 m0 *1 6.72,216.72
X$1889 774 262 661 578 689 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1891 r0 *1 34.72,176.4
X$1891 774 262 594 578 581 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1894 m0 *1 27.44,206.64
X$1894 774 262 662 578 672 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1896 r0 *1 42,216.72
X$1896 774 262 699 578 714 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1898 r0 *1 42,206.64
X$1898 774 262 665 578 663 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1901 m0 *1 8.4,186.48
X$1901 774 262 611 578 593 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1904 r0 *1 7.28,176.4
X$1904 774 262 612 578 579 773 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1953 r0 *1 63.84,85.68
X$1953 773 288 774 287 264 276 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1965 m0 *1 2.8,85.68
X$1965 285 773 774 267 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1968 m0 *1 53.76,85.68
X$1968 774 773 268 276 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1970 r0 *1 55.44,85.68
X$1970 268 773 774 293 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1972 r0 *1 71.68,85.68
X$1972 774 289 288 773 268 287 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1978 m0 *1 99.12,105.84
X$1978 773 288 269 331 774 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $1981 m0 *1 94.08,115.92
X$1981 360 375 269 774 773 361 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $1983 m0 *1 81.76,95.76
X$1983 298 774 269 306 773 313 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1985 m0 *1 94.08,136.08
X$1985 773 269 385 774 416 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1987 r0 *1 101.92,115.92
X$1987 773 269 774 398 386 397 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1992 m0 *1 86.8,105.84
X$1992 773 269 774 314 355 397 328 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $2003 m0 *1 225.68,85.68
X$2003 271 773 774 272 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2014 r0 *1 16.8,95.76
X$2014 274 773 774 337 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2026 m0 *1 203.84,85.68
X$2026 278 773 774 280 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2039 m0 *1 34.16,95.76
X$2039 281 773 774 311 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2047 r0 *1 95.2,85.68
X$2047 774 773 283 298 308 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2058 r0 *1 4.48,95.76
X$2058 325 773 774 286 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2065 m0 *1 52.64,95.76
X$2065 310 773 774 287 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2068 m0 *1 80.64,115.92
X$2068 774 773 288 298 360 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $2074 r0 *1 82.88,115.92
X$2074 773 288 329 774 409 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2076 m0 *1 114.8,126
X$2076 774 426 773 398 427 288 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2097 r0 *1 76.72,95.76
X$2097 773 326 774 289 327 298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2106 r0 *1 103.6,105.84
X$2106 773 321 348 774 290 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2115 r0 *1 182.56,85.68
X$2115 291 773 774 303 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2120 m0 *1 164.64,95.76
X$2120 292 773 774 299 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2128 m0 *1 24.08,95.76
X$2128 312 773 774 294 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2133 m0 *1 43.68,95.76
X$2133 296 773 774 309 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2139 m0 *1 88.48,95.76
X$2139 774 307 297 773 314 313 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2143 r0 *1 101.92,95.76
X$2143 774 360 773 375 330 321 298 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2147 m0 *1 76.16,126
X$2147 774 298 773 435 415 425 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2150 m0 *1 66.08,126
X$2150 774 773 415 298 514 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $2160 r0 *1 106.4,126
X$2160 773 386 774 426 437 298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2176 r0 *1 212.24,85.68
X$2176 300 773 774 304 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2182 r0 *1 225.68,85.68
X$2182 301 773 774 302 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2225 m0 *1 225.68,95.76
X$2225 316 773 774 317 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2234 r0 *1 29.12,95.76
X$2234 319 773 774 320 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2245 r0 *1 147.84,115.92
X$2245 321 773 774 390 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2257 r0 *1 191.52,95.76
X$2257 323 773 774 341 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2268 r0 *1 76.16,105.84
X$2268 774 773 346 326 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2271 r0 *1 79.52,105.84
X$2271 773 347 774 360 354 326 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2280 m0 *1 113.12,105.84
X$2280 774 332 773 356 329 331 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2283 m0 *1 122.08,126
X$2283 773 399 427 774 329 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2299 r0 *1 118.72,105.84
X$2299 773 348 331 774 370 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2306 r0 *1 156.24,95.76
X$2306 332 773 774 334 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2315 m0 *1 181.44,105.84
X$2315 340 773 774 333 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2321 r0 *1 225.68,95.76
X$2321 335 773 774 336 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2329 m0 *1 17.36,105.84
X$2329 345 773 774 338 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2342 m0 *1 8.96,105.84
X$2342 343 773 774 344 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2346 r0 *1 10.08,105.84
X$2346 774 773 367 344 371 345 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2356 r0 *1 48.72,105.84
X$2356 346 773 774 383 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2367 m0 *1 146.16,115.92
X$2367 378 773 774 348 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2370 r0 *1 138.88,105.84
X$2370 349 773 774 368 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2375 r0 *1 160.16,105.84
X$2375 350 773 774 363 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2380 r0 *1 220.64,105.84
X$2380 365 773 774 351 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2383 m0 *1 221.2,115.92
X$2383 352 773 774 379 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2400 r0 *1 18.48,105.84
X$2400 357 773 774 372 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2404 m0 *1 26.88,115.92
X$2404 774 773 358 372 371 359 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2408 m0 *1 35.28,115.92
X$2408 359 773 774 373 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2421 m0 *1 182,196.56
X$2421 774 773 605 635 361 585 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2424 m0 *1 104.72,196.56
X$2424 774 773 615 642 361 616 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2426 r0 *1 104.72,176.4
X$2426 774 773 563 598 361 582 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2429 m0 *1 130.48,186.48
X$2429 774 773 584 625 361 600 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2431 m0 *1 216.16,196.56
X$2431 774 773 624 631 361 621 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2433 r0 *1 189.28,216.72
X$2433 774 773 684 731 361 710 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2435 r0 *1 115.36,216.72
X$2435 774 773 717 726 361 704 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2438 m0 *1 127.68,216.72
X$2438 774 773 695 705 361 679 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2440 r0 *1 138.32,216.72
X$2440 774 773 680 727 361 694 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2443 r0 *1 212.24,176.4
X$2443 774 773 554 587 361 556 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2445 m0 *1 212.24,186.48
X$2445 774 773 586 623 361 572 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2447 r0 *1 146.72,216.72
X$2447 774 773 716 728 361 706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2450 m0 *1 207.2,206.64
X$2450 774 773 650 649 361 647 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2452 m0 *1 133.84,166.32
X$2452 774 773 548 549 361 540 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2454 r0 *1 180.32,176.4
X$2454 774 773 570 607 361 541 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2456 m0 *1 201.6,226.8
X$2456 774 773 685 735 361 686 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2459 r0 *1 221.2,216.72
X$2459 774 773 711 734 361 687 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2461 m0 *1 221.76,216.72
X$2461 774 773 690 713 361 712 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2463 r0 *1 103.04,146.16
X$2463 774 773 504 496 361 497 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2465 r0 *1 102.48,156.24
X$2465 774 773 527 517 361 539 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2484 r0 *1 190.96,105.84
X$2484 362 773 774 366 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2492 r0 *1 185.36,115.92
X$2492 400 773 774 364 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2520 m0 *1 12.32,196.56
X$2520 774 773 579 626 371 612 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2522 r0 *1 47.6,166.32
X$2522 774 773 514 371 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2526 r0 *1 44.8,115.92
X$2526 774 773 374 406 371 384 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2529 m0 *1 34.16,126
X$2529 774 773 413 421 371 414 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2532 r0 *1 36.96,136.08
X$2532 774 773 458 459 371 460 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2534 r0 *1 15.12,136.08
X$2534 774 773 455 454 371 448 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2536 m0 *1 10.64,126
X$2536 774 773 393 412 371 394 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2538 m0 *1 48.72,166.32
X$2538 774 773 508 546 371 494 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2540 m0 *1 27.44,176.4
X$2540 774 773 551 580 371 560 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2542 m0 *1 38.08,186.48
X$2542 774 773 581 606 371 594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2544 r0 *1 20.16,206.64
X$2544 774 773 689 671 371 661 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2547 r0 *1 11.76,206.64
X$2547 774 773 659 639 371 660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2550 r0 *1 12.88,146.16
X$2550 774 773 502 491 371 471 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2552 m0 *1 11.76,166.32
X$2552 774 773 526 550 371 513 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2554 r0 *1 4.48,156.24
X$2554 774 773 506 525 371 512 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2556 m0 *1 36.96,156.24
X$2556 774 773 492 507 371 493 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2558 m0 *1 10.64,226.8
X$2558 774 773 719 720 371 721 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2560 r0 *1 11.2,186.48
X$2560 774 773 593 622 371 611 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2584 r0 *1 59.92,115.92
X$2584 395 773 774 375 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2589 m0 *1 162.4,126
X$2589 376 773 774 417 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2594 m0 *1 185.36,115.92
X$2594 377 773 774 381 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2619 r0 *1 31.92,115.92
X$2619 384 773 774 411 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2633 m0 *1 223.44,126
X$2633 389 773 774 419 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2642 m0 *1 19.04,126
X$2642 394 773 774 392 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2656 m0 *1 79.52,136.08
X$2656 446 773 774 396 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2671 r0 *1 114.8,136.08
X$2671 774 773 399 426 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2674 r0 *1 118.16,136.08
X$2674 399 773 774 529 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2687 m0 *1 192.08,126
X$2687 420 773 774 401 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2690 r0 *1 205.52,115.92
X$2690 402 773 774 403 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2699 r0 *1 222.88,126
X$2699 430 773 774 404 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2708 r0 *1 9.52,126
X$2708 422 773 774 406 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2723 m0 *1 2.24,126
X$2723 410 773 774 412 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2733 m0 *1 42.56,126
X$2733 414 773 774 423 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2755 m0 *1 173.04,166.32
X$2755 774 773 418 786 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $2779 r0 *1 17.92,126
X$2779 424 773 774 421 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2790 m0 *1 76.16,136.08
X$2790 774 773 450 425 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2799 r0 *1 115.36,126
X$2799 445 773 774 427 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2813 r0 *1 143.36,156.24
X$2813 774 773 428 776 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $2825 r0 *1 176.4,126
X$2825 429 773 774 439 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2833 r0 *1 210.56,136.08
X$2833 431 773 774 453 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2836 m0 *1 222.32,136.08
X$2836 440 773 774 432 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2845 m0 *1 40.88,166.32
X$2845 774 773 433 784 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $2869 m0 *1 44.8,136.08
X$2869 449 773 774 434 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2873 r0 *1 76.16,136.08
X$2873 774 435 436 773 468 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2879 m0 *1 169.12,136.08
X$2879 452 773 774 438 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2887 r0 *1 160.16,136.08
X$2887 441 773 774 469 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2892 r0 *1 168,126
X$2892 442 773 774 444 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2910 m0 *1 7.28,136.08
X$2910 447 773 774 454 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2915 r0 *1 23.52,136.08
X$2915 448 773 774 457 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2924 r0 *1 64.4,136.08
X$2924 450 773 774 467 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2940 m0 *1 70,156.24
X$2940 774 773 451 779 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $2972 m0 *1 21.84,146.16
X$2972 479 773 774 459 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2978 r0 *1 45.36,136.08
X$2978 460 773 774 478 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2986 r0 *1 218.96,136.08
X$2986 461 773 774 463 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2991 m0 *1 190.96,146.16
X$2991 483 773 774 462 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2996 r0 *1 202.16,136.08
X$2996 464 773 774 465 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3024 r0 *1 6.72,136.08
X$3024 471 773 774 477 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3029 r0 *1 174.16,146.16
X$3029 472 773 774 511 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3032 m0 *1 182.56,146.16
X$3032 482 773 774 473 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3035 r0 *1 185.92,146.16
X$3035 474 773 774 498 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3040 m0 *1 220.64,146.16
X$3040 485 773 774 475 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3045 r0 *1 3.36,146.16
X$3045 476 773 774 491 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3054 r0 *1 126.56,156.24
X$3054 530 773 774 480 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3057 r0 *1 134.96,156.24
X$3057 481 773 774 619 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3078 r0 *1 220.64,146.16
X$3078 484 773 774 487 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3083 m0 *1 225.68,156.24
X$3083 510 773 774 486 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3092 r0 *1 36.4,156.24
X$3092 489 773 774 546 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3095 m0 *1 28.56,156.24
X$3095 490 773 774 507 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3103 r0 *1 23.52,146.16
X$3103 493 773 774 505 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3112 r0 *1 54.88,146.16
X$3112 494 773 774 495 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3117 m0 *1 99.12,156.24
X$3117 516 773 774 496 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3121 m0 *1 107.52,156.24
X$3121 497 773 774 518 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3126 m0 *1 220.64,176.4
X$3126 499 773 774 533 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3129 r0 *1 220.64,166.32
X$3129 500 773 774 545 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3132 m0 *1 220.64,166.32
X$3132 532 773 774 501 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3169 m0 *1 3.36,166.32
X$3169 512 773 774 523 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3175 m0 *1 20.16,166.32
X$3175 513 773 774 524 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3184 m0 *1 91.84,216.72
X$3184 774 773 702 703 514 725 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3186 r0 *1 92.4,216.72
X$3186 774 773 715 738 514 678 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3188 m0 *1 84,196.56
X$3188 774 773 597 636 514 614 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3190 r0 *1 33.6,206.64
X$3190 774 773 672 676 514 662 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3192 r0 *1 33.6,216.72
X$3192 774 773 675 722 514 698 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3194 m0 *1 79.52,216.72
X$3194 774 773 691 701 514 700 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3196 r0 *1 61.04,216.72
X$3196 774 773 714 723 514 699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3198 m0 *1 58.8,196.56
X$3198 774 773 595 633 514 613 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3200 m0 *1 66.64,206.64
X$3200 774 773 674 666 514 677 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3203 m0 *1 67.2,196.56
X$3203 774 773 634 627 514 596 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3205 r0 *1 91.28,156.24
X$3205 774 773 521 528 514 515 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3208 r0 *1 70,166.32
X$3208 774 773 538 573 514 552 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3211 m0 *1 46.48,206.64
X$3211 774 773 663 664 514 665 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3228 r0 *1 92.4,166.32
X$3228 515 773 774 557 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3234 r0 *1 101.92,166.32
X$3234 574 773 774 517 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3244 m0 *1 156.24,176.4
X$3244 519 773 774 567 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3264 m0 *1 3.92,176.4
X$3264 536 773 774 525 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3276 m0 *1 95.2,176.4
X$3276 591 773 774 528 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3300 r0 *1 192.08,176.4
X$3300 585 773 774 534 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3305 m0 *1 201.6,166.32
X$3305 541 773 774 535 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3310 r0 *1 5.04,166.32
X$3310 537 773 774 550 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3316 m0 *1 108.64,166.32
X$3316 539 773 774 769 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3325 m0 *1 142.24,166.32
X$3325 540 773 774 620 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3334 r0 *1 203.84,176.4
X$3334 542 773 774 587 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3339 m0 *1 224.56,196.56
X$3339 572 773 774 543 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3342 r0 *1 224,176.4
X$3342 556 773 774 544 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3361 m0 *1 125.44,166.32
X$3361 558 773 774 549 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3372 r0 *1 78.4,166.32
X$3372 552 773 774 561 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3380 r0 *1 225.68,186.48
X$3380 555 773 774 623 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3396 m0 *1 46.48,186.48
X$3396 594 773 774 559 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3400 m0 *1 27.44,186.48
X$3400 560 773 774 577 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3421 m0 *1 68.32,176.4
X$3421 774 773 562 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $3434 m0 *1 122.64,176.4
X$3434 589 773 774 564 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3438 m0 *1 139.44,176.4
X$3438 565 773 774 566 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3451 r0 *1 157.92,176.4
X$3451 608 773 774 568 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3480 m0 *1 220.64,186.48
X$3480 571 773 774 631 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3491 m0 *1 72.8,176.4
X$3491 590 773 774 573 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3499 r0 *1 24.08,186.48
X$3499 575 773 774 580 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3504 r0 *1 26.32,176.4
X$3504 576 773 774 606 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3510 m0 *1 44.24,196.56
X$3510 774 773 578 785 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3539 m0 *1 110.32,186.48
X$3539 582 773 774 599 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3547 r0 *1 142.8,186.48
X$3547 774 773 583 778 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $3577 r0 *1 149.52,176.4
X$3577 588 773 774 603 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3594 r0 *1 2.8,186.48
X$3594 592 773 774 622 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3610 m0 *1 75.6,196.56
X$3610 596 773 774 693 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3615 m0 *1 101.92,186.48
X$3615 609 773 774 598 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3623 m0 *1 138.88,186.48
X$3623 600 773 774 601 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3637 m0 *1 167.44,186.48
X$3637 604 773 774 607 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3659 m0 *1 3.92,196.56
X$3659 610 773 774 626 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3662 r0 *1 12.88,196.56
X$3662 611 773 774 696 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3670 m0 *1 22.96,196.56
X$3670 612 773 774 632 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3676 m0 *1 75.04,206.64
X$3676 613 773 774 737 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3681 r0 *1 92.4,186.48
X$3681 614 773 774 654 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3691 r0 *1 109.2,196.56
X$3691 616 773 774 643 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3699 r0 *1 138.88,196.56
X$3699 618 773 774 656 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3711 r0 *1 222.32,196.56
X$3711 621 773 774 648 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3725 r0 *1 130.48,196.56
X$3725 657 773 774 625 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3733 r0 *1 63.84,196.56
X$3733 640 773 774 627 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3736 r0 *1 122.08,196.56
X$3736 644 773 774 628 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3740 m0 *1 165.2,206.64
X$3740 629 773 774 673 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3745 r0 *1 213.92,196.56
X$3745 630 773 774 649 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3757 r0 *1 72.24,196.56
X$3757 641 773 774 633 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3766 r0 *1 173.6,196.56
X$3766 651 773 774 635 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3769 r0 *1 86.8,196.56
X$3769 653 773 774 636 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3774 m0 *1 145.04,196.56
X$3774 655 773 774 637 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3779 r0 *1 4.48,196.56
X$3779 638 773 774 639 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3791 m0 *1 103.6,206.64
X$3791 667 773 774 642 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3801 m0 *1 154.56,206.64
X$3801 645 773 774 646 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3809 m0 *1 221.76,206.64
X$3809 647 773 774 670 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3845 r0 *1 3.36,206.64
X$3845 658 773 774 671 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3851 r0 *1 2.24,226.8
X$3851 660 773 774 746 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3860 r0 *1 19.04,226.8
X$3860 661 773 774 764 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3863 r0 *1 35.84,226.8
X$3863 662 773 774 763 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3870 m0 *1 44.8,226.8
X$3870 749 773 774 664 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3877 r0 *1 25.2,216.72
X$3877 665 773 774 697 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3881 r0 *1 66.08,226.8
X$3881 767 773 774 666 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3890 r0 *1 191.52,226.8
X$3890 669 773 774 772 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3919 r0 *1 44.24,226.8
X$3919 766 773 774 676 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3925 r0 *1 75.04,216.72
X$3925 677 773 774 724 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3932 r0 *1 103.6,216.72
X$3932 678 773 774 762 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3935 m0 *1 132.72,226.8
X$3935 679 773 774 740 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3947 r0 *1 174.72,226.8
X$3947 771 773 774 683 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3956 r0 *1 212.24,226.8
X$3956 686 773 774 743 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3963 r0 *1 221.2,206.64
X$3963 687 773 774 688 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3984 r0 *1 166.32,226.8
X$3984 692 773 774 753 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3992 r0 *1 143.36,226.8
X$3992 694 773 774 756 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4009 r0 *1 27.44,226.8
X$4009 698 773 774 765 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4019 m0 *1 63.84,226.8
X$4019 699 773 774 736 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4024 r0 *1 74.48,226.8
X$4024 700 773 774 754 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4030 m0 *1 75.04,226.8
X$4030 741 773 774 701 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4037 r0 *1 92.4,226.8
X$4037 768 773 774 703 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4039 r0 *1 120.96,226.8
X$4039 704 773 774 761 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4046 m0 *1 124.32,226.8
X$4046 760 773 774 705 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4051 r0 *1 151.76,226.8
X$4051 706 773 774 755 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4054 m0 *1 164.64,216.72
X$4054 707 773 774 708 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4063 r0 *1 183.12,226.8
X$4063 709 773 774 752 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4073 m0 *1 192.08,226.8
X$4073 710 773 774 745 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4083 r0 *1 220.64,226.8
X$4083 712 773 774 744 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4088 m0 *1 221.2,226.8
X$4088 732 773 774 713 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4109 m0 *1 2.24,226.8
X$4109 718 773 774 720 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4120 r0 *1 10.64,226.8
X$4120 721 773 774 747 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4126 m0 *1 30.8,226.8
X$4126 748 773 774 722 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4129 r0 *1 57.68,226.8
X$4129 750 773 774 723 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4138 r0 *1 101.92,226.8
X$4138 725 773 774 758 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4142 m0 *1 113.12,226.8
X$4142 739 773 774 726 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4144 r0 *1 134.96,226.8
X$4144 770 773 774 727 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4147 m0 *1 141.12,226.8
X$4147 759 773 774 728 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4150 m0 *1 159.6,226.8
X$4150 729 773 774 730 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4156 m0 *1 183.68,226.8
X$4156 751 773 774 731 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4161 r0 *1 203.84,226.8
X$4161 733 773 774 735 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4166 m0 *1 212.8,226.8
X$4166 742 773 774 734 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4179 m0 *1 103.04,226.8
X$4179 757 773 774 738 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS axi_lite_master

* cell gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyc_2 1 7 11 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* net 11 I
* net 13 NWELL,VDD
* device instance $1 r0 *1 8.34,3.365 pmos_5p0
M$1 6 5 17 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 8.34,4.085 pmos_5p0
M$2 17 5 13 13 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 10.14,3.785 pmos_5p0
M$3 7 6 13 13 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 4.34,3.365 pmos_5p0
M$5 4 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $6 r0 *1 6.18,3.365 pmos_5p0
M$6 16 4 5 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $7 r0 *1 4.34,4.085 pmos_5p0
M$7 13 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $8 r0 *1 6.18,4.085 pmos_5p0
M$8 13 4 16 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $9 r0 *1 2.18,3.365 pmos_5p0
M$9 15 2 3 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $10 r0 *1 0.87,4.085 pmos_5p0
M$10 13 11 2 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $11 r0 *1 2.18,4.085 pmos_5p0
M$11 13 2 15 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $12 r0 *1 0.92,0.795 nmos_5p0
M$12 1 11 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $13 r0 *1 2.23,0.795 nmos_5p0
M$13 12 2 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $14 r0 *1 2.23,1.515 nmos_5p0
M$14 3 2 12 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $15 r0 *1 4.39,0.52 nmos_5p0
M$15 1 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.2232P PS=1.98U PD=1.6U
* device instance $16 r0 *1 6.23,0.52 nmos_5p0
M$16 10 4 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.2232P AD=0.27P PS=1.6U PD=1.98U
* device instance $17 r0 *1 4.39,1.24 nmos_5p0
M$17 4 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $18 r0 *1 6.23,1.24 nmos_5p0
M$18 5 4 10 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $19 r0 *1 8.39,0.525 nmos_5p0
M$19 1 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $20 r0 *1 8.39,1.245 nmos_5p0
M$20 6 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $21 r0 *1 10.19,1.005 nmos_5p0
M$21 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyc_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_2
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_2 1 2 3 4 5 6
* net 1 ZN
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A1
* net 6 A3
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 6 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 9 4 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 1 5 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 8 5 1 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 4 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 6 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 3 6 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.553P PS=3.77U PD=3.77U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 1 4 3 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 3 5 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_4
* pin NWELL,VDD
* pin A2
* pin A1
* pin Z
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_4 1 2 3 5 6
* net 1 NWELL,VDD
* net 2 A2
* net 3 A1
* net 5 Z
* net 6 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.875 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.28U AS=1.3336P AD=0.8528P PS=6.69U PD=4.32U
* device instance $2 r0 *1 1.89,3.875 pmos_5p0
M$2 1 3 4 1 pmos_5p0 L=0.5U W=3.28U AS=0.8528P AD=0.8528P PS=4.32U PD=4.32U
* device instance $5 r0 *1 5.13,3.78 pmos_5p0
M$5 5 4 1 1 pmos_5p0 L=0.5U W=7.32U AS=2.0394P AD=2.2326P PS=9.58U PD=11.59U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 8 2 6 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 3 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 7 3 4 6 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 6 2 7 6 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 5 4 6 6 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_4

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* pin A2
* pin A1
* pin B
* pin ZN
* pin C
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_2 1 2 4 5 6 7 8
* net 1 A2
* net 2 A1
* net 4 B
* net 5 ZN
* net 6 C
* net 7 NWELL,VDD
* net 8 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 5 1 3 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.3359P PS=6.89U PD=5.12U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 3 2 5 7 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.37,3.78 pmos_5p0
M$5 12 4 3 7 pmos_5p0 L=0.5U W=1.83U AS=0.8601P AD=0.2196P PS=2.77U PD=2.07U
* device instance $6 r0 *1 6.11,3.78 pmos_5p0
M$6 7 6 12 7 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.549P PS=2.07U PD=2.43U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 11 6 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.549P AD=0.4392P PS=2.43U PD=2.31U
* device instance $8 r0 *1 8.19,3.78 pmos_5p0
M$8 3 4 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.4392P AD=0.8052P PS=2.31U PD=4.54U
* device instance $9 r0 *1 5.02,0.745 nmos_5p0
M$9 5 4 8 8 nmos_5p0 L=0.6U W=1.58U AS=0.5609P AD=0.553P PS=3.195U PD=3.77U
* device instance $10 r0 *1 6.14,0.745 nmos_5p0
M$10 8 6 5 8 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $13 r0 *1 0.92,0.942 nmos_5p0
M$13 10 1 8 8 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.1422P PS=3.25U PD=1.425U
* device instance $14 r0 *1 1.76,0.942 nmos_5p0
M$14 5 2 10 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 2.88,0.942 nmos_5p0
M$15 9 2 5 8 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 3.72,0.942 nmos_5p0
M$16 8 1 9 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A2
* pin A1
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A2
* net 4 A1
* net 5 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.61305P PS=4.54U PD=2.5U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 5 4 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 3 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 5 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 6 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 2 3 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $9 r0 *1 0.92,1.04 nmos_5p0
M$9 5 3 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1224P AD=1.1224P PS=7.04U PD=7.04U
* device instance $10 r0 *1 2.04,1.04 nmos_5p0
M$10 1 4 5 1 nmos_5p0 L=0.6U W=3.68U AS=0.9568P AD=0.9568P PS=5.76U PD=5.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__and4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_2 1 2 3 4 5 6 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.925,4.055 pmos_5p0
M$1 7 1 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $2 r0 *1 1.945,4.055 pmos_5p0
M$2 6 2 7 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $3 r0 *1 2.965,4.055 pmos_5p0
M$3 7 3 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $4 r0 *1 3.985,4.055 pmos_5p0
M$4 7 4 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.558P AD=0.3328P PS=2.53U PD=1.8U
* device instance $5 r0 *1 5.185,3.78 pmos_5p0
M$5 8 7 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.0338P AD=1.281P PS=4.88U PD=6.89U
* device instance $7 r0 *1 0.975,1.005 nmos_5p0
M$7 11 1 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $8 r0 *1 1.895,1.005 nmos_5p0
M$8 10 2 11 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $9 r0 *1 2.915,1.005 nmos_5p0
M$9 9 3 10 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $10 r0 *1 3.935,1.005 nmos_5p0
M$10 5 4 9 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $11 r0 *1 5.055,1.005 nmos_5p0
M$11 8 7 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_2 1 2 3 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 NWELL,VDD
* net 5 A2
* net 6 A3
* device instance $1 r0 *1 0.87,3.85 pmos_5p0
M$1 2 6 4 4 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.022P PS=5.78U PD=5.78U
* device instance $2 r0 *1 1.89,3.85 pmos_5p0
M$2 4 5 2 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.85 pmos_5p0
M$3 2 3 4 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 1.06,1 nmos_5p0
M$7 10 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1848P PS=3.52U PD=1.6U
* device instance $8 r0 *1 1.94,1 nmos_5p0
M$8 9 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1848P AD=0.2112P PS=1.6U PD=1.64U
* device instance $9 r0 *1 2.86,1 nmos_5p0
M$9 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $10 r0 *1 3.98,1 nmos_5p0
M$10 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $11 r0 *1 4.9,1 nmos_5p0
M$11 7 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $12 r0 *1 5.92,1 nmos_5p0
M$12 1 6 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.5808P PS=1.74U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_4 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__inv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=3.96U AS=1.2672P AD=1.2672P PS=7.2U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_3

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.2993P PS=6.99U PD=5.08U
* device instance $3 r0 *1 3.29,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.5071P PS=9.98U PD=11.89U
* device instance $7 r0 *1 0.92,1.23 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.4593P PS=3.59U PD=2.75U
* device instance $9 r0 *1 3.34,1.265 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.8935P AD=0.976P PS=5.46U PD=6.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 10 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 10 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 11 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 11 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 8 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 8 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_2
* pin NWELL,VDD
* pin B2
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B2
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.4758P PS=4.54U PD=2.35U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 6 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $5 r0 *1 5.45,3.78 pmos_5p0
M$5 11 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 6 7 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 10 7 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 6 5 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $14 r0 *1 6.52,1.005 nmos_5p0
M$14 8 7 6 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 11 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 10 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 9 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2
