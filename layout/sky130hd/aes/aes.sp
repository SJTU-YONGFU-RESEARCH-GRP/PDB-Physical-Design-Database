* cell aes_cipher_top
* pin key[7]
* pin text_in[22]
* pin text_in[31]
* pin text_in[30]
* pin text_in[23]
* pin text_in[25]
* pin text_in[21]
* pin text_in[26]
* pin text_in[27]
* pin text_out[31]
* pin text_in[24]
* pin text_in[16]
* pin text_out[30]
* pin text_out[2]
* pin text_in[6]
* pin text_out[25]
* pin text_in[29]
* pin text_in[8]
* pin text_out[26]
* pin text_out[6]
* pin text_in[28]
* pin text_in[7]
* pin text_out[28]
* pin text_out[29]
* pin text_out[27]
* pin text_in[0]
* pin text_in[1]
* pin text_in[3]
* pin text_in[5]
* pin text_in[9]
* pin key[19]
* pin text_in[2]
* pin text_out[18]
* pin key[123]
* pin key[126]
* pin text_out[23]
* pin key[18]
* pin key[23]
* pin key[22]
* pin text_out[20]
* pin text_out[19]
* pin key[21]
* pin text_out[21]
* pin text_out[22]
* pin key[20]
* pin text_in[78]
* pin text_in[76]
* pin text_in[75]
* pin text_out[7]
* pin text_out[24]
* pin text_in[14]
* pin text_in[4]
* pin text_in[12]
* pin VSS
* pin VDD
* pin key[107]
* pin text_out[85]
* pin text_out[116]
* pin text_out[93]
* pin key[95]
* pin text_out[121]
* pin clk
* pin text_in[93]
* pin key[9]
* pin text_in[124]
* pin key[106]
* pin key[10]
* pin text_in[79]
* pin text_out[122]
* pin key[74]
* pin key[84]
* pin text_out[0]
* pin text_out[79]
* pin key[16]
* pin text_out[117]
* pin key[4]
* pin text_in[126]
* pin key[105]
* pin text_in[125]
* pin key[36]
* pin key[117]
* pin key[81]
* pin text_out[127]
* pin key[27]
* pin key[17]
* pin key[45]
* pin text_out[125]
* pin key[109]
* pin text_out[17]
* pin key[0]
* pin key[13]
* pin text_in[18]
* pin key[112]
* pin text_in[77]
* pin key[77]
* pin key[122]
* pin key[14]
* pin key[85]
* pin text_out[3]
* pin key[60]
* pin text_out[77]
* pin ld
* pin key[11]
* pin text_in[35]
* pin key[35]
* pin text_out[76]
* pin text_in[123]
* pin text_in[11]
* pin key[41]
* pin text_out[78]
* pin key[90]
* pin key[108]
* pin key[94]
* pin key[43]
* pin key[56]
* pin key[12]
* pin text_out[75]
* pin key[51]
* pin key[93]
* pin key[116]
* pin text_out[16]
* pin text_out[1]
* pin key[82]
* pin text_out[15]
* pin key[89]
* pin text_out[8]
* pin key[2]
* pin key[52]
* pin text_in[17]
* pin key[53]
* pin key[62]
* pin key[120]
* pin text_out[126]
* pin text_out[14]
* pin text_out[11]
* pin text_in[13]
* pin key[49]
* pin text_in[10]
* pin text_out[13]
* pin text_out[10]
* pin key[32]
* pin text_in[15]
* pin text_in[115]
* pin key[121]
* pin key[1]
* pin key[73]
* pin text_out[12]
* pin key[3]
* pin key[57]
* pin key[88]
* pin key[75]
* pin text_out[9]
* pin key[55]
* pin key[76]
* pin text_out[36]
* pin key[5]
* pin key[44]
* pin text_in[20]
* pin key[125]
* pin key[64]
* pin text_out[4]
* pin key[78]
* pin key[124]
* pin text_out[123]
* pin text_out[5]
* pin key[6]
* pin key[46]
* pin key[110]
* pin key[113]
* pin key[63]
* pin text_out[124]
* pin key[114]
* pin text_out[120]
* pin key[127]
* pin key[31]
* pin text_in[127]
* pin text_in[64]
* pin text_in[112]
* pin text_in[117]
* pin key[91]
* pin key[15]
* pin key[34]
* pin text_out[84]
* pin text_in[19]
* pin key[92]
* pin key[111]
* pin text_in[95]
* pin key[50]
* pin key[59]
* pin key[47]
* pin key[42]
* pin text_in[121]
* pin key[86]
* pin key[24]
* pin text_in[94]
* pin key[40]
* pin key[30]
* pin key[72]
* pin text_out[64]
* pin text_out[119]
* pin text_out[94]
* pin text_out[32]
* pin key[58]
* pin text_in[119]
* pin text_in[92]
* pin key[54]
* pin text_in[74]
* pin key[25]
* pin text_out[92]
* pin text_in[37]
* pin key[80]
* pin key[8]
* pin text_in[91]
* pin key[48]
* pin key[26]
* pin text_in[114]
* pin key[118]
* pin key[79]
* pin key[66]
* pin text_out[91]
* pin key[28]
* pin key[87]
* pin key[39]
* pin key[119]
* pin key[29]
* pin key[97]
* pin text_in[86]
* pin text_out[81]
* pin key[33]
* pin text_in[89]
* pin text_in[65]
* pin text_out[72]
* pin text_in[39]
* pin key[65]
* pin text_out[80]
* pin text_in[81]
* pin key[102]
* pin text_in[116]
* pin key[96]
* pin text_out[95]
* pin key[68]
* pin key[69]
* pin text_out[87]
* pin text_out[118]
* pin key[100]
* pin text_out[90]
* pin text_out[38]
* pin text_in[73]
* pin key[115]
* pin text_in[120]
* pin text_in[90]
* pin key[99]
* pin text_in[40]
* pin text_in[85]
* pin text_out[82]
* pin key[104]
* pin text_out[74]
* pin key[83]
* pin text_in[48]
* pin text_out[104]
* pin text_in[87]
* pin text_in[70]
* pin text_in[80]
* pin text_in[88]
* pin text_out[67]
* pin text_in[38]
* pin text_in[103]
* pin text_out[49]
* pin text_in[58]
* pin text_in[67]
* pin text_out[97]
* pin text_out[89]
* pin text_in[84]
* pin text_in[83]
* pin text_in[82]
* pin text_out[41]
* pin text_out[50]
* pin text_out[57]
* pin text_in[104]
* pin text_out[114]
* pin text_in[57]
* pin text_in[51]
* pin text_out[51]
* pin text_out[83]
* pin text_out[42]
* pin text_in[55]
* pin text_in[113]
* pin text_out[52]
* pin text_in[36]
* pin text_out[112]
* pin text_out[115]
* pin text_in[63]
* pin text_out[86]
* pin text_out[56]
* pin text_in[56]
* pin text_in[52]
* pin text_out[54]
* pin text_in[72]
* pin text_in[118]
* pin rst
* pin text_out[55]
* pin text_in[59]
* pin text_out[73]
* pin text_out[63]
* pin text_out[113]
* pin text_out[88]
* pin text_out[59]
* pin text_in[41]
* pin text_in[42]
* pin text_in[122]
* pin text_out[58]
* pin text_in[50]
* pin text_in[34]
* pin text_out[53]
* pin text_in[49]
* pin text_out[34]
* pin key[61]
* pin key[67]
* pin text_in[33]
* pin text_out[35]
* pin text_out[39]
* pin text_out[48]
* pin text_in[69]
* pin text_in[66]
* pin text_in[32]
* pin text_out[37]
* pin text_out[40]
* pin text_out[66]
* pin text_out[47]
* pin text_out[70]
* pin text_out[99]
* pin key[101]
* pin text_out[105]
* pin text_out[111]
* pin text_out[108]
* pin text_out[43]
* pin text_out[44]
* pin key[70]
* pin key[103]
* pin text_in[107]
* pin key[38]
* pin text_out[98]
* pin text_out[106]
* pin text_out[100]
* pin text_out[101]
* pin text_in[44]
* pin text_in[45]
* pin text_out[46]
* pin key[37]
* pin text_out[107]
* pin text_in[96]
* pin text_out[103]
* pin text_out[69]
* pin text_out[68]
* pin text_out[62]
* pin key[71]
* pin text_in[71]
* pin text_out[102]
* pin text_out[71]
* pin text_out[33]
* pin text_in[68]
* pin text_out[60]
* pin text_out[45]
* pin key[98]
* pin text_in[97]
* pin done
* pin text_in[60]
* pin text_out[65]
* pin text_in[98]
* pin text_in[54]
* pin text_out[96]
* pin text_in[100]
* pin text_in[105]
* pin text_in[101]
* pin text_in[61]
* pin text_in[47]
* pin text_in[99]
* pin text_in[53]
* pin text_in[62]
* pin text_out[61]
* pin text_in[46]
* pin text_out[109]
* pin text_in[102]
* pin text_out[110]
* pin text_in[109]
* pin text_in[43]
* pin text_in[110]
* pin text_in[106]
* pin text_in[108]
* pin text_in[111]
.SUBCKT aes_cipher_top 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22
+ 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48
+ 49 50 51 52 53 57 73 2449 2543 2640 2711 2712 2838 2897 2939 2986 3049 3099
+ 3100 3142 3143 3211 3253 3288 3328 3379 3415 3463 3494 3530 3569 3612 3648
+ 3693 3734 3784 3785 3827 3828 3829 3882 3949 3979 4013 4014 4042 4043 4096
+ 4123 4125 4157 4216 4246 4283 4320 4322 4358 4401 4402 4411 4465 4499 4535
+ 4563 4599 4653 4696 4731 4734 4765 4803 4808 4812 4856 4857 4907 4951 4991
+ 5037 5072 5112 5156 5181 5182 5231 5232 5233 5234 5286 5326 5327 5347 5369
+ 5418 5438 5462 5463 5565 5608 5650 5735 5736 5785 5885 5956 5992 5993 6040
+ 6087 6146 6182 6231 6232 6284 6328 6368 6402 6403 6452 6453 6475 6512 6544
+ 6594 6639 6640 6677 6717 6767 6768 6793 6854 6891 6941 6977 7014 7015 7056
+ 7057 7071 7101 7130 7131 7201 7242 7243 7295 7296 7349 7383 7435 7465 7559
+ 7597 7598 7635 7636 7702 7727 7750 7782 7825 7826 7870 7872 7916 7918 7951
+ 7971 8026 8058 8085 8120 8161 8197 8234 8235 8279 8326 8328 8329 8421 8464
+ 8494 8526 8527 8571 8572 8620 8642 8715 8749 8784 8785 8817 8818 8862 8903
+ 8948 8978 8979 8982 8984 9019 9020 9062 9064 9065 9077 9078 9129 9156 9159
+ 9215 9251 9254 9290 9291 9327 9365 9469 9470 9516 9517 9519 9520 9524 9575
+ 9653 9654 9677 9708 9723 9770 9809 9846 9900 9979 10030 10093 10094 10133
+ 10135 10176 10224 10302 10393 10499 10500 10520 10531 10588 10684 10685 10723
+ 10795 10818 10833 10857 10960 10961 11010 11064 11124 11215 11216 11301 11372
+ 11419 11482 11554 11633 11700 11742 11794 11831 11874 11875 11948 11967 11997
+ 12052 12110 12111 12134 12137 12149 12157 12246 12257 12394 12410 12475 12509
+ 12541 12548 12549 12558 12559 12709 12718 12820 12831 12925 13035 13036 13139
+ 13252 13341 13434 13482 13483 13647 14040 14050 14056 14171 14207 14342 14352
+ 15242 15305 15337 15345 15396 15404 15407 15408 15409 15410 15411 15412 15413
+ 15414 15415 15416 15417 15418 15419 15420 15421 15422
* net 1 key[7]
* net 2 text_in[22]
* net 3 text_in[31]
* net 4 text_in[30]
* net 5 text_in[23]
* net 6 text_in[25]
* net 7 text_in[21]
* net 8 text_in[26]
* net 9 text_in[27]
* net 10 text_out[31]
* net 11 text_in[24]
* net 12 text_in[16]
* net 13 text_out[30]
* net 14 text_out[2]
* net 15 text_in[6]
* net 16 text_out[25]
* net 17 text_in[29]
* net 18 text_in[8]
* net 19 text_out[26]
* net 20 text_out[6]
* net 21 text_in[28]
* net 22 text_in[7]
* net 23 text_out[28]
* net 24 text_out[29]
* net 25 text_out[27]
* net 26 text_in[0]
* net 27 text_in[1]
* net 28 text_in[3]
* net 29 text_in[5]
* net 30 text_in[9]
* net 31 key[19]
* net 32 text_in[2]
* net 33 text_out[18]
* net 34 key[123]
* net 35 key[126]
* net 36 text_out[23]
* net 37 key[18]
* net 38 key[23]
* net 39 key[22]
* net 40 text_out[20]
* net 41 text_out[19]
* net 42 key[21]
* net 43 text_out[21]
* net 44 text_out[22]
* net 45 key[20]
* net 46 text_in[78]
* net 47 text_in[76]
* net 48 text_in[75]
* net 49 text_out[7]
* net 50 text_out[24]
* net 51 text_in[14]
* net 52 text_in[4]
* net 53 text_in[12]
* net 57 VSS
* net 73 VDD
* net 2449 key[107]
* net 2543 text_out[85]
* net 2640 text_out[116]
* net 2711 text_out[93]
* net 2712 key[95]
* net 2838 text_out[121]
* net 2897 clk
* net 2939 text_in[93]
* net 2986 key[9]
* net 3049 text_in[124]
* net 3099 key[106]
* net 3100 key[10]
* net 3142 text_in[79]
* net 3143 text_out[122]
* net 3211 key[74]
* net 3253 key[84]
* net 3288 text_out[0]
* net 3328 text_out[79]
* net 3379 key[16]
* net 3415 text_out[117]
* net 3463 key[4]
* net 3494 text_in[126]
* net 3530 key[105]
* net 3569 text_in[125]
* net 3612 key[36]
* net 3648 key[117]
* net 3693 key[81]
* net 3734 text_out[127]
* net 3784 key[27]
* net 3785 key[17]
* net 3827 key[45]
* net 3828 text_out[125]
* net 3829 key[109]
* net 3882 text_out[17]
* net 3949 key[0]
* net 3979 key[13]
* net 4013 text_in[18]
* net 4014 key[112]
* net 4042 text_in[77]
* net 4043 key[77]
* net 4096 key[122]
* net 4123 key[14]
* net 4125 key[85]
* net 4157 text_out[3]
* net 4216 key[60]
* net 4246 text_out[77]
* net 4283 ld
* net 4320 key[11]
* net 4322 text_in[35]
* net 4358 key[35]
* net 4401 text_out[76]
* net 4402 text_in[123]
* net 4411 text_in[11]
* net 4465 key[41]
* net 4499 text_out[78]
* net 4535 key[90]
* net 4563 key[108]
* net 4599 key[94]
* net 4653 key[43]
* net 4696 key[56]
* net 4731 key[12]
* net 4734 text_out[75]
* net 4765 key[51]
* net 4803 key[93]
* net 4808 key[116]
* net 4812 text_out[16]
* net 4856 text_out[1]
* net 4857 key[82]
* net 4907 text_out[15]
* net 4951 key[89]
* net 4991 text_out[8]
* net 5037 key[2]
* net 5072 key[52]
* net 5112 text_in[17]
* net 5156 key[53]
* net 5181 key[62]
* net 5182 key[120]
* net 5231 text_out[126]
* net 5232 text_out[14]
* net 5233 text_out[11]
* net 5234 text_in[13]
* net 5286 key[49]
* net 5326 text_in[10]
* net 5327 text_out[13]
* net 5347 text_out[10]
* net 5369 key[32]
* net 5418 text_in[15]
* net 5438 text_in[115]
* net 5462 key[121]
* net 5463 key[1]
* net 5565 key[73]
* net 5608 text_out[12]
* net 5650 key[3]
* net 5735 key[57]
* net 5736 key[88]
* net 5785 key[75]
* net 5885 text_out[9]
* net 5956 key[55]
* net 5992 key[76]
* net 5993 text_out[36]
* net 6040 key[5]
* net 6087 key[44]
* net 6146 text_in[20]
* net 6182 key[125]
* net 6231 key[64]
* net 6232 text_out[4]
* net 6284 key[78]
* net 6328 key[124]
* net 6368 text_out[123]
* net 6402 text_out[5]
* net 6403 key[6]
* net 6452 key[46]
* net 6453 key[110]
* net 6475 key[113]
* net 6512 key[63]
* net 6544 text_out[124]
* net 6594 key[114]
* net 6639 text_out[120]
* net 6640 key[127]
* net 6677 key[31]
* net 6717 text_in[127]
* net 6767 text_in[64]
* net 6768 text_in[112]
* net 6793 text_in[117]
* net 6854 key[91]
* net 6891 key[15]
* net 6941 key[34]
* net 6977 text_out[84]
* net 7014 text_in[19]
* net 7015 key[92]
* net 7056 key[111]
* net 7057 text_in[95]
* net 7071 key[50]
* net 7101 key[59]
* net 7130 key[47]
* net 7131 key[42]
* net 7201 text_in[121]
* net 7242 key[86]
* net 7243 key[24]
* net 7295 text_in[94]
* net 7296 key[40]
* net 7349 key[30]
* net 7383 key[72]
* net 7435 text_out[64]
* net 7465 text_out[119]
* net 7559 text_out[94]
* net 7597 text_out[32]
* net 7598 key[58]
* net 7635 text_in[119]
* net 7636 text_in[92]
* net 7702 key[54]
* net 7727 text_in[74]
* net 7750 key[25]
* net 7782 text_out[92]
* net 7825 text_in[37]
* net 7826 key[80]
* net 7870 key[8]
* net 7872 text_in[91]
* net 7916 key[48]
* net 7918 key[26]
* net 7951 text_in[114]
* net 7971 key[118]
* net 8026 key[79]
* net 8058 key[66]
* net 8085 text_out[91]
* net 8120 key[28]
* net 8161 key[87]
* net 8197 key[39]
* net 8234 key[119]
* net 8235 key[29]
* net 8279 key[97]
* net 8326 text_in[86]
* net 8328 text_out[81]
* net 8329 key[33]
* net 8421 text_in[89]
* net 8464 text_in[65]
* net 8494 text_out[72]
* net 8526 text_in[39]
* net 8527 key[65]
* net 8571 text_out[80]
* net 8572 text_in[81]
* net 8620 key[102]
* net 8642 text_in[116]
* net 8715 key[96]
* net 8749 text_out[95]
* net 8784 key[68]
* net 8785 key[69]
* net 8817 text_out[87]
* net 8818 text_out[118]
* net 8862 key[100]
* net 8903 text_out[90]
* net 8948 text_out[38]
* net 8978 text_in[73]
* net 8979 key[115]
* net 8982 text_in[120]
* net 8984 text_in[90]
* net 9019 key[99]
* net 9020 text_in[40]
* net 9062 text_in[85]
* net 9064 text_out[82]
* net 9065 key[104]
* net 9077 text_out[74]
* net 9078 key[83]
* net 9129 text_in[48]
* net 9156 text_out[104]
* net 9159 text_in[87]
* net 9215 text_in[70]
* net 9251 text_in[80]
* net 9254 text_in[88]
* net 9290 text_out[67]
* net 9291 text_in[38]
* net 9327 text_in[103]
* net 9365 text_out[49]
* net 9469 text_in[58]
* net 9470 text_in[67]
* net 9516 text_out[97]
* net 9517 text_out[89]
* net 9519 text_in[84]
* net 9520 text_in[83]
* net 9524 text_in[82]
* net 9575 text_out[41]
* net 9653 text_out[50]
* net 9654 text_out[57]
* net 9677 text_in[104]
* net 9708 text_out[114]
* net 9723 text_in[57]
* net 9770 text_in[51]
* net 9809 text_out[51]
* net 9846 text_out[83]
* net 9900 text_out[42]
* net 9979 text_in[55]
* net 10030 text_in[113]
* net 10093 text_out[52]
* net 10094 text_in[36]
* net 10133 text_out[112]
* net 10135 text_out[115]
* net 10176 text_in[63]
* net 10224 text_out[86]
* net 10302 text_out[56]
* net 10393 text_in[56]
* net 10499 text_in[52]
* net 10500 text_out[54]
* net 10520 text_in[72]
* net 10531 text_in[118]
* net 10588 rst
* net 10684 text_out[55]
* net 10685 text_in[59]
* net 10723 text_out[73]
* net 10795 text_out[63]
* net 10818 text_out[113]
* net 10833 text_out[88]
* net 10857 text_out[59]
* net 10960 text_in[41]
* net 10961 text_in[42]
* net 11010 text_in[122]
* net 11064 text_out[58]
* net 11124 text_in[50]
* net 11215 text_in[34]
* net 11216 text_out[53]
* net 11301 text_in[49]
* net 11372 text_out[34]
* net 11419 key[61]
* net 11482 key[67]
* net 11554 text_in[33]
* net 11633 text_out[35]
* net 11700 text_out[39]
* net 11742 text_out[48]
* net 11794 text_in[69]
* net 11831 text_in[66]
* net 11874 text_in[32]
* net 11875 text_out[37]
* net 11948 text_out[40]
* net 11967 text_out[66]
* net 11997 text_out[47]
* net 12052 text_out[70]
* net 12110 text_out[99]
* net 12111 key[101]
* net 12134 text_out[105]
* net 12137 text_out[111]
* net 12149 text_out[108]
* net 12157 text_out[43]
* net 12246 text_out[44]
* net 12257 key[70]
* net 12394 key[103]
* net 12410 text_in[107]
* net 12475 key[38]
* net 12509 text_out[98]
* net 12541 text_out[106]
* net 12548 text_out[100]
* net 12549 text_out[101]
* net 12558 text_in[44]
* net 12559 text_in[45]
* net 12709 text_out[46]
* net 12718 key[37]
* net 12820 text_out[107]
* net 12831 text_in[96]
* net 12925 text_out[103]
* net 13035 text_out[69]
* net 13036 text_out[68]
* net 13139 text_out[62]
* net 13252 key[71]
* net 13341 text_in[71]
* net 13434 text_out[102]
* net 13482 text_out[71]
* net 13483 text_out[33]
* net 13647 text_in[68]
* net 14040 text_out[60]
* net 14050 text_out[45]
* net 14056 key[98]
* net 14171 text_in[97]
* net 14207 done
* net 14342 text_in[60]
* net 14352 text_out[65]
* net 15242 text_in[98]
* net 15305 text_in[54]
* net 15337 text_out[96]
* net 15345 text_in[100]
* net 15396 text_in[105]
* net 15404 text_in[101]
* net 15407 text_in[61]
* net 15408 text_in[47]
* net 15409 text_in[99]
* net 15410 text_in[53]
* net 15411 text_in[62]
* net 15412 text_out[61]
* net 15413 text_in[46]
* net 15414 text_out[109]
* net 15415 text_in[102]
* net 15416 text_out[110]
* net 15417 text_in[109]
* net 15418 text_in[43]
* net 15419 text_in[110]
* net 15420 text_in[106]
* net 15421 text_in[108]
* net 15422 text_in[111]
* cell instance $10 r0 *1 200.56,182.24
X$10 73 1 57 73 4101 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14 r0 *1 210.68,2.72
X$14 73 2 57 73 120 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17 m0 *1 211.6,46.24
X$17 73 3 57 73 660 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20 r0 *1 213.44,46.24
X$20 73 4 57 73 554 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23 r0 *1 219.42,2.72
X$23 73 5 57 73 61 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26 r0 *1 215.74,2.72
X$26 73 6 57 73 60 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29 r0 *1 241.04,2.72
X$29 73 7 57 73 66 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32 r0 *1 219.88,46.24
X$32 73 8 57 73 507 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34 r0 *1 222.18,29.92
X$34 73 9 57 73 241 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38 r0 *1 228.62,51.68
X$38 73 607 57 73 10 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41 m0 *1 224.48,40.8
X$41 73 11 57 73 340 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44 r0 *1 226.32,35.36
X$44 73 12 57 73 309 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47 r0 *1 225.86,8.16
X$47 73 105 57 73 13 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50 m0 *1 226.32,8.16
X$50 73 339 57 73 14 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53 r0 *1 231.84,2.72
X$53 73 15 57 73 64 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56 m0 *1 230,8.16
X$56 73 86 57 73 16 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $59 r0 *1 233.22,35.36
X$59 73 17 57 73 310 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65 r0 *1 238.74,116.96
X$65 73 18 57 73 2292 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68 r0 *1 237.36,2.72
X$68 73 88 57 73 19 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72 r0 *1 239.66,8.16
X$72 73 77 57 73 20 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $75 m0 *1 243.34,8.16
X$75 73 21 57 73 92 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $78 r0 *1 247.02,2.72
X$78 73 22 57 73 67 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $84 m0 *1 246.1,133.28
X$84 73 2668 57 73 23 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $88 m0 *1 247.02,8.16
X$88 73 79 57 73 24 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $94 m0 *1 245.64,138.72
X$94 73 2889 57 73 25 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $98 m0 *1 252.08,8.16
X$98 73 26 57 73 80 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $101 m0 *1 258.06,8.16
X$101 73 27 57 73 78 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $104 r0 *1 253.46,2.72
X$104 73 28 57 73 183 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $107 r0 *1 267.26,2.72
X$107 73 29 57 73 145 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $110 r0 *1 270.94,2.72
X$110 73 30 57 73 70 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $113 m0 *1 273.7,13.6
X$113 73 31 57 73 169 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $122 m0 *1 231.38,138.72
X$122 73 32 57 73 2886 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $125 r0 *1 274.62,2.72
X$125 73 55 57 73 33 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $128 r0 *1 260.82,2.72
X$128 73 34 57 73 54 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $131 r0 *1 279.22,2.72
X$131 73 35 57 73 62 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $134 r0 *1 282.9,2.72
X$134 73 68 57 73 36 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $145 m0 *1 286.12,160.48
X$145 73 37 57 73 3460 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $148 r0 *1 288.42,2.72
X$148 73 38 57 73 350 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $151 r0 *1 288.42,8.16
X$151 73 39 57 73 90 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $154 m0 *1 290.26,8.16
X$154 73 113 57 73 40 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $157 m0 *1 274.62,8.16
X$157 73 94 57 73 41 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $160 r0 *1 298.54,2.72
X$160 73 42 57 73 65 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $162 m0 *1 296.24,8.16
X$162 73 112 57 73 43 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $166 m0 *1 300.84,8.16
X$166 73 74 57 73 44 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $169 r0 *1 306.36,2.72
X$169 73 45 57 73 63 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $172 r0 *1 406.64,2.72
X$172 73 46 57 73 59 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $174 r0 *1 431.94,8.16
X$174 73 47 57 73 82 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $177 r0 *1 433.78,2.72
X$177 73 48 57 73 58 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $183 r0 *1 205.16,182.24
X$183 73 4062 57 73 49 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $187 m0 *1 241.96,46.24
X$187 73 509 57 73 50 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $191 r0 *1 257.14,2.72
X$191 73 51 57 73 69 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $194 r0 *1 259.44,13.6
X$194 73 52 57 73 144 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $197 r0 *1 283.82,8.16
X$197 73 53 57 73 89 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $205 m0 *1 258.06,138.72
X$205 73 76 54 2786 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $210 r0 *1 264.96,13.6
X$210 57 55 93 127 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $219 m0 *1 261.74,8.16
X$219 57 76 56 93 78 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $221 m0 *1 272.32,171.36
X$221 73 3306 56 3771 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $1190 m0 *1 233.68,8.16
X$1190 57 77 75 71 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $1201 m0 *1 278.76,8.16
X$1201 57 68 93 72 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $1543 m0 *1 215.74,13.6
X$1543 57 105 75 104 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $1551 r0 *1 229.54,8.16
X$1551 57 88 75 87 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $1556 m0 *1 232.76,13.6
X$1556 57 76 98 75 64 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $1563 r0 *1 246.1,8.16
X$1563 57 76 95 91 92 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $1568 m0 *1 251.16,13.6
X$1568 57 76 108 93 80 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $1575 m0 *1 262.66,13.6
X$1575 57 76 109 93 69 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $1578 r0 *1 266.8,8.16
X$1578 57 94 93 97 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $1579 r0 *1 274.16,8.16
X$1579 57 96 93 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $1584 m0 *1 281.06,13.6
X$1584 73 76 90 110 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $1586 m0 *1 282.9,13.6
X$1586 57 113 93 99 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $1592 m0 *1 290.26,13.6
X$1592 57 112 93 111 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $1605 r0 *1 310.04,8.16
X$1605 73 76 63 85 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $1692 r0 *1 413.08,8.16
X$1692 57 76 84 83 59 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $1705 m0 *1 427.34,13.6
X$1705 73 83 57 73 57 sky130_fd_sc_hd__clkbuf_1
* cell instance $1707 m0 *1 428.72,13.6
X$1707 57 230 83 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $1712 r0 *1 435.62,8.16
X$1712 57 76 81 83 82 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $1731 m0 *1 462.76,13.6
X$1731 73 101 102 107 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $1735 m0 *1 465.52,13.6
X$1735 73 101 102 106 73 103 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $1999 r0 *1 217.12,13.6
X$1999 57 76 122 75 120 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $2001 r0 *1 230,13.6
X$2001 73 75 57 73 57 sky130_fd_sc_hd__clkinv_4
* cell instance $2008 r0 *1 239.2,13.6
X$2008 57 76 126 75 61 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $2020 r0 *1 275.08,13.6
X$2020 57 76 128 93 70 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $2095 r0 *1 436.08,13.6
X$2095 57 76 119 83 58 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $2097 r0 *1 447.58,13.6
X$2097 73 114 115 100 118 116 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $2102 r0 *1 450.8,13.6
X$2102 73 125 116 123 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $2107 r0 *1 458.62,13.6
X$2107 73 114 100 115 57 73 121 57 sky130_fd_sc_hd__a21oi_1
* cell instance $2108 r0 *1 460.46,13.6
X$2108 73 107 73 57 115 57 sky130_fd_sc_hd__buf_4
* cell instance $2282 m0 *1 230,19.04
X$2282 57 96 75 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $2284 m0 *1 239.66,19.04
X$2284 57 79 75 129 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $2291 m0 *1 259.9,19.04
X$2291 57 76 147 93 144 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $2298 m0 *1 283.82,19.04
X$2298 57 76 130 93 89 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $2350 m0 *1 436.54,19.04
X$2350 73 114 100 115 143 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $2357 m0 *1 450.34,19.04
X$2357 73 123 140 133 57 73 124 57 sky130_fd_sc_hd__a21oi_1
* cell instance $2361 m0 *1 460.46,19.04
X$2361 73 139 73 57 117 57 sky130_fd_sc_hd__buf_4
* cell instance $2362 m0 *1 463.22,19.04
X$2362 73 117 138 137 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $2363 m0 *1 464.6,19.04
X$2363 73 117 73 57 118 57 sky130_fd_sc_hd__buf_4
* cell instance $2644 m0 *1 253.46,24.48
X$2644 57 96 91 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $2645 r0 *1 253.46,19.04
X$2645 57 91 15446 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $2658 r0 *1 269.1,19.04
X$2658 57 76 164 93 145 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $2677 r0 *1 293.48,19.04
X$2677 57 74 93 146 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $2794 r0 *1 438.38,19.04
X$2794 73 142 100 114 149 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $2796 m0 *1 439.3,24.48
X$2796 73 114 148 168 149 73 57 167 57 sky130_fd_sc_hd__o31ai_1
* cell instance $2799 r0 *1 442.98,19.04
X$2799 73 166 141 150 131 57 73 132 57 sky130_fd_sc_hd__a31oi_1
* cell instance $2801 m0 *1 444.36,24.48
X$2801 73 165 151 152 73 166 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $2802 r0 *1 445.28,19.04
X$2802 73 131 167 132 57 73 133 57 sky130_fd_sc_hd__a21o_1
* cell instance $2803 m0 *1 446.2,24.48
X$2803 73 170 135 141 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $2804 m0 *1 447.58,24.48
X$2804 73 156 73 57 152 57 sky130_fd_sc_hd__buf_4
* cell instance $2812 m0 *1 452.64,24.48
X$2812 73 153 152 154 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $2814 m0 *1 454.48,24.48
X$2814 73 152 265 138 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $2821 m0 *1 458.16,24.48
X$2821 73 172 73 57 100 57 sky130_fd_sc_hd__buf_4
* cell instance $2823 m0 *1 461.38,24.48
X$2823 73 151 154 107 57 73 163 57 sky130_fd_sc_hd__a21oi_1
* cell instance $2825 r0 *1 462.3,19.04
X$2825 73 134 73 57 135 57 sky130_fd_sc_hd__buf_4
* cell instance $2826 m0 *1 463.22,24.48
X$2826 73 138 73 57 162 57 sky130_fd_sc_hd__buf_4
* cell instance $2828 m0 *1 465.98,24.48
X$2828 73 153 102 161 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $2831 r0 *1 470.58,19.04
X$2831 57 160 244 155 137 153 135 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $2836 r0 *1 475.64,19.04
X$2836 73 136 134 106 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $2849 m0 *1 487.14,24.48
X$2849 73 157 156 182 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $2852 m0 *1 489.44,24.48
X$2852 73 157 73 57 155 57 sky130_fd_sc_hd__buf_4
* cell instance $3113 r0 *1 253.46,24.48
X$3113 57 76 185 91 183 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $3122 r0 *1 275.08,24.48
X$3122 73 76 169 314 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $3124 r0 *1 277.38,24.48
X$3124 73 110 188 76 73 213 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $3194 r0 *1 423.2,24.48
X$3194 73 131 190 221 73 191 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $3209 r0 *1 453.1,24.48
X$3209 73 154 73 57 189 57 sky130_fd_sc_hd__buf_4
* cell instance $3210 r0 *1 455.86,24.48
X$3210 73 114 159 172 57 73 187 57 sky130_fd_sc_hd__a21oi_1
* cell instance $3213 r0 *1 459.08,24.48
X$3213 73 173 187 163 405 73 57 186 57 sky130_fd_sc_hd__o31ai_1
* cell instance $3222 r0 *1 477.48,24.48
X$3222 57 174 336 184 186 160 572 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $3223 r0 *1 480.7,24.48
X$3223 73 158 73 57 210 57 sky130_fd_sc_hd__buf_4
* cell instance $3228 r0 *1 488.52,24.48
X$3228 73 182 73 57 158 57 sky130_fd_sc_hd__buf_4
* cell instance $3229 r0 *1 491.28,24.48
X$3229 73 175 153 135 57 73 179 57 sky130_fd_sc_hd__a21oi_1
* cell instance $3230 r0 *1 493.12,24.48
X$3230 73 176 177 208 178 73 174 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $3231 r0 *1 495.88,24.48
X$3231 73 181 180 179 57 73 178 57 sky130_fd_sc_hd__a21oi_1
* cell instance $3409 m0 *1 280.6,29.92
X$3409 73 213 73 57 194 57 sky130_fd_sc_hd__clkinv_1
* cell instance $3410 m0 *1 281.98,29.92
X$3410 73 193 215 216 57 73 214 57 sky130_fd_sc_hd__a21oi_1
* cell instance $3411 m0 *1 283.82,29.92
X$3411 57 194 193 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $3461 m0 *1 426.88,29.92
X$3461 73 222 131 195 57 73 221 57 sky130_fd_sc_hd__a21oi_1
* cell instance $3464 m0 *1 430.1,29.92
X$3464 73 196 73 57 195 57 sky130_fd_sc_hd__buf_4
* cell instance $3466 m0 *1 433.32,29.92
X$3466 57 151 171 150 142 197 191 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $3469 m0 *1 438.84,29.92
X$3469 73 209 156 196 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $3470 m0 *1 440.22,29.92
X$3470 73 198 219 149 73 220 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $3474 m0 *1 446.2,29.92
X$3474 73 218 73 57 217 57 sky130_fd_sc_hd__buf_4
* cell instance $3477 m0 *1 451.72,29.92
X$3477 73 101 73 57 198 57 sky130_fd_sc_hd__buf_4
* cell instance $3480 m0 *1 457.24,29.92
X$3480 73 333 73 57 172 57 sky130_fd_sc_hd__buf_4
* cell instance $3484 m0 *1 463.22,29.92
X$3484 73 161 212 114 73 203 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $3485 m0 *1 465.06,29.92
X$3485 73 203 162 118 204 57 73 211 57 sky130_fd_sc_hd__a31oi_1
* cell instance $3486 m0 *1 467.36,29.92
X$3486 73 114 210 161 277 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $3496 m0 *1 486.22,29.92
X$3496 57 15516 157 209 207 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $3663 r0 *1 225.86,29.92
X$3663 57 76 242 322 241 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $3672 r0 *1 248.86,29.92
X$3672 57 76 243 91 67 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $3684 r0 *1 277.38,29.92
X$3684 73 213 73 57 253 57 sky130_fd_sc_hd__buf_4
* cell instance $3686 r0 *1 280.6,29.92
X$3686 73 246 214 254 73 223 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $3687 r0 *1 282.44,29.92
X$3687 73 247 192 224 216 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $3689 r0 *1 286.12,29.92
X$3689 73 192 224 247 57 73 215 57 sky130_fd_sc_hd__a21o_1
* cell instance $3764 r0 *1 433.32,29.92
X$3764 73 196 73 57 199 57 sky130_fd_sc_hd__buf_4
* cell instance $3766 r0 *1 436.54,29.92
X$3766 73 231 131 234 197 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $3769 r0 *1 440.68,29.92
X$3769 73 200 118 250 467 57 201 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $3771 r0 *1 443.9,29.92
X$3771 73 141 235 249 198 231 200 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $3773 r0 *1 448.96,29.92
X$3773 73 202 201 124 232 57 218 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $3782 r0 *1 461.84,29.92
X$3782 73 234 73 57 102 57 sky130_fd_sc_hd__buf_4
* cell instance $3783 r0 *1 464.6,29.92
X$3783 73 374 211 351 57 73 232 57 sky130_fd_sc_hd__a21oi_1
* cell instance $3797 r0 *1 488.98,29.92
X$3797 57 206 208 175 237 239 240 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $3798 r0 *1 492.2,29.92
X$3798 73 155 205 159 206 240 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $3973 m0 *1 270.48,35.36
X$3973 57 286 272 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $3977 m0 *1 279.68,35.36
X$3977 73 273 247 253 276 57 246 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $3983 m0 *1 293.02,35.36
X$3983 73 247 225 192 57 73 255 57 sky130_fd_sc_hd__a21oi_1
* cell instance $3984 m0 *1 294.86,35.36
X$3984 57 226 227 247 279 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $3985 m0 *1 297.16,35.36
X$3985 73 255 227 257 73 228 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $3987 m0 *1 299.46,35.36
X$3987 73 257 281 228 258 282 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $3992 m0 *1 311.88,35.36
X$3992 73 251 225 229 259 254 73 260 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $3993 m0 *1 315.1,35.36
X$3993 73 259 226 224 57 73 229 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4029 m0 *1 414.46,35.36
X$4029 73 319 285 262 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $4033 m0 *1 417.68,35.36
X$4033 73 222 262 252 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $4035 m0 *1 422.74,35.36
X$4035 73 151 284 285 233 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $4036 m0 *1 424.58,35.36
X$4036 73 190 73 57 263 57 sky130_fd_sc_hd__buf_4
* cell instance $4039 m0 *1 432.86,35.36
X$4039 73 331 73 57 142 57 sky130_fd_sc_hd__buf_4
* cell instance $4042 m0 *1 441.14,35.36
X$4042 73 245 73 57 219 57 sky130_fd_sc_hd__buf_4
* cell instance $4048 m0 *1 454.02,35.36
X$4048 73 265 73 57 248 57 sky130_fd_sc_hd__buf_4
* cell instance $4050 m0 *1 457.24,35.36
X$4050 73 162 264 283 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4053 m0 *1 460,35.36
X$4053 73 266 234 267 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $4054 m0 *1 461.38,35.36
X$4054 73 267 73 57 236 57 sky130_fd_sc_hd__buf_4
* cell instance $4055 m0 *1 464.14,35.36
X$4055 73 102 248 280 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4057 m0 *1 467.36,35.36
X$4057 73 277 233 278 264 274 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $4058 m0 *1 470.12,35.36
X$4058 73 275 245 244 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4063 m0 *1 477.94,35.36
X$4063 73 270 156 134 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $4064 m0 *1 479.32,35.36
X$4064 73 270 205 245 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4067 m0 *1 483.46,35.36
X$4067 73 234 73 57 205 57 sky130_fd_sc_hd__buf_4
* cell instance $4068 m0 *1 486.22,35.36
X$4068 73 237 210 206 73 268 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4069 m0 *1 488.06,35.36
X$4069 73 231 205 237 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $4072 m0 *1 491.74,35.36
X$4072 73 270 239 236 238 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $4073 m0 *1 494.04,35.36
X$4073 73 236 271 270 73 180 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4245 r0 *1 272.32,35.36
X$4245 73 314 312 76 57 73 286 57 sky130_fd_sc_hd__o21a_2
* cell instance $4248 r0 *1 278.3,35.36
X$4248 73 225 279 315 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4249 r0 *1 279.68,35.36
X$4249 73 287 279 273 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4250 r0 *1 281.06,35.36
X$4250 73 288 216 289 254 257 73 256 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $4257 r0 *1 296.24,35.36
X$4257 73 253 316 291 57 73 367 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4258 r0 *1 298.08,35.36
X$4258 73 256 257 292 57 73 291 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4259 r0 *1 299.92,35.36
X$4259 73 290 282 293 317 57 73 390 57 sky130_fd_sc_hd__a31oi_1
* cell instance $4261 r0 *1 304.06,35.36
X$4261 73 260 254 318 57 73 294 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4262 r0 *1 305.9,35.36
X$4262 73 294 257 293 356 57 317 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $4266 r0 *1 311.88,35.36
X$4266 73 254 353 321 73 292 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4296 r0 *1 382.72,35.36
X$4296 57 960 230 217 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $4308 r0 *1 413.08,35.36
X$4308 73 320 73 57 319 57 sky130_fd_sc_hd__buf_4
* cell instance $4309 r0 *1 415.84,35.36
X$4309 73 173 73 57 261 57 sky130_fd_sc_hd__buf_4
* cell instance $4311 r0 *1 419.52,35.36
X$4311 73 284 73 57 168 57 sky130_fd_sc_hd__buf_4
* cell instance $4312 r0 *1 422.28,35.36
X$4312 73 231 313 285 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $4316 r0 *1 425.96,35.36
X$4316 57 118 263 114 295 231 299 73 73 57 sky130_fd_sc_hd__o221a_2
* cell instance $4321 r0 *1 435.62,35.36
X$4321 73 275 73 57 295 57 sky130_fd_sc_hd__buf_4
* cell instance $4323 r0 *1 438.84,35.36
X$4323 73 296 313 275 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4326 r0 *1 441.6,35.36
X$4326 73 261 297 621 73 250 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4327 r0 *1 443.44,35.36
X$4327 73 311 298 209 219 73 297 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $4328 r0 *1 446.2,35.36
X$4328 73 199 73 57 298 57 sky130_fd_sc_hd__buf_4
* cell instance $4332 r0 *1 451.26,35.36
X$4332 73 296 73 57 114 57 sky130_fd_sc_hd__buf_4
* cell instance $4333 r0 *1 454.02,35.36
X$4333 73 308 296 265 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $4339 r0 *1 459.54,35.36
X$4339 73 267 73 57 320 57 sky130_fd_sc_hd__buf_4
* cell instance $4342 r0 *1 463.68,35.36
X$4342 73 300 73 57 148 57 sky130_fd_sc_hd__buf_4
* cell instance $4343 r0 *1 466.44,35.36
X$4343 73 280 264 269 268 73 381 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $4344 r0 *1 468.74,35.36
X$4344 73 114 148 305 238 73 57 349 57 sky130_fd_sc_hd__o31ai_1
* cell instance $4345 r0 *1 471.5,35.36
X$4345 73 299 306 184 304 57 202 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $4356 r0 *1 494.5,35.36
X$4356 57 377 304 180 303 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $4515 m0 *1 215.74,40.8
X$4515 57 339 322 307 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $4523 m0 *1 234.14,40.8
X$4523 57 76 342 322 310 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $4534 m0 *1 269.56,40.8
X$4534 73 258 382 420 344 324 327 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $4535 m0 *1 273.24,40.8
X$4535 73 247 287 362 326 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $4538 m0 *1 276.46,40.8
X$4538 73 247 315 326 73 346 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4542 m0 *1 280.14,40.8
X$4542 73 272 325 288 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4548 m0 *1 289.34,40.8
X$4548 73 329 76 350 57 73 328 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4550 m0 *1 293.02,40.8
X$4550 73 328 73 57 293 57 sky130_fd_sc_hd__buf_4
* cell instance $4551 m0 *1 295.78,40.8
X$4551 73 328 73 57 316 57 sky130_fd_sc_hd__inv_1
* cell instance $4558 m0 *1 306.82,40.8
X$4558 73 257 327 392 57 73 356 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4562 m0 *1 313.72,40.8
X$4562 73 229 357 330 57 73 353 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4606 m0 *1 412.16,40.8
X$4606 73 261 359 285 57 73 394 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4617 m0 *1 431.94,40.8
X$4617 73 296 73 57 222 57 sky130_fd_sc_hd__buf_4
* cell instance $4620 m0 *1 437,40.8
X$4620 73 331 151 245 209 332 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $4622 m0 *1 441.14,40.8
X$4622 73 311 313 333 73 358 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4626 m0 *1 444.82,40.8
X$4626 73 156 73 57 313 57 sky130_fd_sc_hd__buf_4
* cell instance $4628 m0 *1 448.04,40.8
X$4628 73 298 335 355 57 73 334 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4635 m0 *1 456.78,40.8
X$4635 73 155 355 333 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4638 m0 *1 462.76,40.8
X$4638 73 173 73 57 352 57 sky130_fd_sc_hd__buf_4
* cell instance $4643 m0 *1 471.96,40.8
X$4643 57 347 379 345 352 349 274 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $4648 m0 *1 477.48,40.8
X$4648 73 134 73 57 337 57 sky130_fd_sc_hd__buf_4
* cell instance $4650 m0 *1 481.16,40.8
X$4650 73 245 73 57 338 57 sky130_fd_sc_hd__buf_4
* cell instance $4652 m0 *1 485.76,40.8
X$4652 73 209 235 341 73 301 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4654 m0 *1 488.06,40.8
X$4654 73 343 337 359 237 73 341 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $4658 m0 *1 496.8,40.8
X$4658 73 305 302 206 73 303 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4663 m0 *1 500.94,40.8
X$4663 73 505 73 57 306 57 sky130_fd_sc_hd__buf_4
* cell instance $4821 r0 *1 225.86,40.8
X$4821 57 76 323 322 340 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $4837 r0 *1 270.48,40.8
X$4837 57 361 382 360 383 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $4838 r0 *1 272.78,40.8
X$4838 73 225 362 325 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4840 r0 *1 274.62,40.8
X$4840 73 363 385 364 57 73 289 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4841 r0 *1 276.46,40.8
X$4841 73 258 346 365 73 425 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4842 r0 *1 278.3,40.8
X$4842 73 360 422 348 385 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $4843 r0 *1 280.14,40.8
X$4843 73 247 361 348 386 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $4845 r0 *1 283.82,40.8
X$4845 73 258 387 193 73 366 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4846 r0 *1 285.66,40.8
X$4846 73 293 388 425 193 366 442 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $4849 r0 *1 289.34,40.8
X$4849 73 286 73 57 360 57 sky130_fd_sc_hd__buf_4
* cell instance $4852 r0 *1 296.24,40.8
X$4852 57 367 368 389 253 390 73 73 57 sky130_fd_sc_hd__a22oi_2
* cell instance $4856 r0 *1 306.82,40.8
X$4856 73 393 436 258 73 392 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4864 r0 *1 327.52,40.8
X$4864 73 363 73 57 254 57 sky130_fd_sc_hd__buf_4
* cell instance $4899 r0 *1 411.7,40.8
X$4899 73 374 391 394 57 73 435 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4902 r0 *1 414.92,40.8
X$4902 73 222 370 264 73 432 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4903 r0 *1 416.76,40.8
X$4903 73 369 302 222 73 391 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4904 r0 *1 418.6,40.8
X$4904 73 354 153 313 57 73 370 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4913 r0 *1 437.92,40.8
X$4913 73 150 332 131 73 424 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $4917 r0 *1 447.58,40.8
X$4917 73 371 334 249 170 151 372 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $4919 r0 *1 450.8,40.8
X$4919 73 335 134 384 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4925 r0 *1 460.46,40.8
X$4925 57 466 373 371 121 463 131 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $4928 r0 *1 466.44,40.8
X$4928 73 373 381 278 408 57 375 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $4932 r0 *1 472.42,40.8
X$4932 57 380 418 345 378 379 375 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $4933 r0 *1 475.64,40.8
X$4933 73 347 345 184 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $4940 r0 *1 486.68,40.8
X$4940 73 371 73 57 175 57 sky130_fd_sc_hd__buf_4
* cell instance $4941 r0 *1 489.44,40.8
X$4941 73 352 311 337 57 73 413 57 sky130_fd_sc_hd__a21oi_1
* cell instance $4942 r0 *1 491.28,40.8
X$4942 73 271 73 57 354 57 sky130_fd_sc_hd__buf_4
* cell instance $5105 m0 *1 224.94,46.24
X$5105 73 322 73 57 57 sky130_fd_sc_hd__clkinv_2
* cell instance $5107 m0 *1 227.7,46.24
X$5107 57 76 465 322 309 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $5119 m0 *1 255.3,46.24
X$5119 73 529 363 395 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $5122 m0 *1 258.06,46.24
X$5122 73 348 362 363 395 57 73 439 57 sky130_fd_sc_hd__a31oi_1
* cell instance $5128 m0 *1 263.58,46.24
X$5128 73 258 421 694 73 426 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $5129 m0 *1 266.34,46.24
X$5129 73 420 362 348 57 73 421 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5131 m0 *1 269.1,46.24
X$5131 73 420 396 383 364 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5134 m0 *1 275.54,46.24
X$5134 73 258 441 365 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $5138 m0 *1 278.76,46.24
X$5138 73 247 396 423 57 73 276 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5141 m0 *1 283.36,46.24
X$5141 73 258 386 401 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $5147 m0 *1 291.18,46.24
X$5147 73 427 254 397 426 57 428 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $5149 m0 *1 295.78,46.24
X$5149 73 428 398 293 73 368 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5150 m0 *1 297.62,46.24
X$5150 73 257 399 398 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $5151 m0 *1 299,46.24
X$5151 73 258 431 483 73 399 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5157 m0 *1 306.82,46.24
X$5157 73 434 471 400 57 73 436 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5158 m0 *1 308.66,46.24
X$5158 73 400 423 272 401 57 73 388 57 sky130_fd_sc_hd__a31oi_1
* cell instance $5164 m0 *1 318.78,46.24
X$5164 73 400 226 437 259 258 73 402 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $5165 m0 *1 322,46.24
X$5165 73 402 521 193 73 475 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5212 m0 *1 425.96,46.24
X$5212 73 430 403 118 301 73 429 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $5215 m0 *1 431.02,46.24
X$5215 73 371 403 143 770 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5217 m0 *1 433.78,46.24
X$5217 73 151 470 452 403 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5218 m0 *1 435.62,46.24
X$5218 73 335 234 404 73 469 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5231 m0 *1 460.46,46.24
X$5231 73 405 73 57 125 57 sky130_fd_sc_hd__buf_4
* cell instance $5232 m0 *1 463.22,46.24
X$5232 73 419 73 57 131 57 sky130_fd_sc_hd__buf_4
* cell instance $5235 m0 *1 468.28,46.24
X$5235 57 380 414 171 406 407 347 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $5238 m0 *1 472.42,46.24
X$5238 73 418 73 57 411 57 sky130_fd_sc_hd__buf_4
* cell instance $5242 m0 *1 477.02,46.24
X$5242 57 406 409 347 513 416 377 73 73 57 sky130_fd_sc_hd__a2111oi_1
* cell instance $5243 m0 *1 480.7,46.24
X$5243 73 376 235 209 410 73 409 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $5245 m0 *1 484.38,46.24
X$5245 73 410 359 415 417 57 204 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $5248 m0 *1 491.28,46.24
X$5248 73 460 413 412 414 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $5411 r0 *1 224.94,46.24
X$5411 57 96 322 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $5423 r0 *1 255.3,46.24
X$5423 73 558 395 512 73 438 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5424 r0 *1 257.14,46.24
X$5424 73 438 253 559 439 360 73 472 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $5431 r0 *1 269.56,46.24
X$5431 73 440 73 57 420 57 sky130_fd_sc_hd__buf_4
* cell instance $5432 r0 *1 272.32,46.24
X$5432 73 476 73 57 344 57 sky130_fd_sc_hd__buf_4
* cell instance $5436 r0 *1 281.52,46.24
X$5436 73 440 73 57 247 57 sky130_fd_sc_hd__buf_4
* cell instance $5441 r0 *1 287.5,46.24
X$5441 73 276 538 247 57 73 516 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5447 r0 *1 298.08,46.24
X$5447 73 592 361 443 468 57 73 431 57 sky130_fd_sc_hd__a31oi_1
* cell instance $5448 r0 *1 300.38,46.24
X$5448 73 443 287 279 57 73 468 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5451 r0 *1 303.6,46.24
X$5451 73 286 73 57 434 57 sky130_fd_sc_hd__buf_4
* cell instance $5454 r0 *1 310.96,46.24
X$5454 73 440 73 57 259 57 sky130_fd_sc_hd__buf_4
* cell instance $5457 r0 *1 314.18,46.24
X$5457 73 293 472 475 57 73 519 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5462 r0 *1 324.3,46.24
X$5462 57 361 523 434 476 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $5463 r0 *1 326.6,46.24
X$5463 73 400 225 523 259 253 73 524 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $5497 r0 *1 411.24,46.24
X$5497 73 429 433 527 477 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5498 r0 *1 413.08,46.24
X$5498 73 153 313 525 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $5499 r0 *1 414.46,46.24
X$5499 73 444 313 526 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $5501 r0 *1 416.3,46.24
X$5501 73 444 295 377 445 433 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $5502 r0 *1 419.06,46.24
X$5502 73 168 474 488 73 445 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5509 r0 *1 431.02,46.24
X$5509 73 473 73 57 470 57 sky130_fd_sc_hd__buf_4
* cell instance $5510 r0 *1 433.78,46.24
X$5510 73 446 470 492 57 73 447 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5511 r0 *1 435.62,46.24
X$5511 73 447 446 469 57 73 450 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5512 r0 *1 437.46,46.24
X$5512 73 449 522 150 424 57 73 520 57 sky130_fd_sc_hd__a31oi_1
* cell instance $5513 r0 *1 439.76,46.24
X$5513 73 448 220 767 450 73 467 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $5515 r0 *1 443.44,46.24
X$5515 73 170 234 452 488 449 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $5516 r0 *1 446.2,46.24
X$5516 73 371 473 404 57 73 451 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5518 r0 *1 448.96,46.24
X$5518 73 493 73 57 170 57 sky130_fd_sc_hd__buf_4
* cell instance $5520 r0 *1 451.72,46.24
X$5520 73 156 73 57 355 57 sky130_fd_sc_hd__buf_4
* cell instance $5528 r0 *1 461.38,46.24
X$5528 57 466 114 300 517 453 419 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $5529 r0 *1 465.06,46.24
X$5529 73 114 371 454 73 495 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5530 r0 *1 466.9,46.24
X$5530 73 311 114 371 454 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5531 r0 *1 468.74,46.24
X$5531 73 296 451 515 73 177 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5533 r0 *1 471.04,46.24
X$5533 73 376 355 652 296 453 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $5535 r0 *1 474.26,46.24
X$5535 73 455 374 457 514 57 378 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $5536 r0 *1 476.56,46.24
X$5536 73 359 209 456 73 501 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5539 r0 *1 478.86,46.24
X$5539 73 371 456 455 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $5541 r0 *1 482.08,46.24
X$5541 73 296 231 457 57 73 511 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5545 r0 *1 485.76,46.24
X$5545 73 458 510 175 508 57 416 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $5546 r0 *1 488.06,46.24
X$5546 73 359 419 205 459 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5548 r0 *1 490.36,46.24
X$5548 73 296 464 459 57 73 458 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5551 r0 *1 494.96,46.24
X$5551 73 270 462 461 57 73 463 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5553 r0 *1 498.64,46.24
X$5553 73 206 494 461 73 506 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5554 r0 *1 500.48,46.24
X$5554 73 556 73 57 461 57 sky130_fd_sc_hd__buf_4
* cell instance $5714 m0 *1 223.56,51.68
X$5714 57 76 557 322 507 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $5718 m0 *1 235.06,51.68
X$5718 57 509 322 528 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $5725 m0 *1 255.76,51.68
X$5725 73 360 512 193 57 73 478 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5727 m0 *1 258.52,51.68
X$5727 73 193 226 478 73 532 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5730 m0 *1 260.36,51.68
X$5730 73 533 561 532 73 479 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5734 m0 *1 267.26,51.68
X$5734 73 253 560 479 73 534 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5736 m0 *1 269.56,51.68
X$5736 73 589 480 383 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $5737 m0 *1 270.94,51.68
X$5737 73 481 480 476 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $5738 m0 *1 272.32,51.68
X$5738 73 286 57 73 440 57 sky130_fd_sc_hd__inv_2
* cell instance $5740 m0 *1 274.62,51.68
X$5740 73 563 258 534 57 73 482 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5741 m0 *1 276.46,51.68
X$5741 73 272 315 564 73 565 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5746 m0 *1 283.82,51.68
X$5746 73 570 272 568 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $5747 m0 *1 285.2,51.68
X$5747 73 293 537 442 73 484 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5752 m0 *1 289.34,51.68
X$5752 73 573 73 57 427 57 sky130_fd_sc_hd__buf_4
* cell instance $5756 m0 *1 297.16,51.68
X$5756 73 316 482 397 73 539 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5759 m0 *1 301.3,51.68
X$5759 73 573 617 194 73 485 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5764 m0 *1 306.82,51.68
X$5764 57 194 574 363 393 673 485 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $5765 m0 *1 310.04,51.68
X$5765 73 440 73 57 443 57 sky130_fd_sc_hd__buf_4
* cell instance $5766 m0 *1 312.8,51.68
X$5766 73 519 539 484 397 486 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $5771 m0 *1 322.46,51.68
X$5771 73 254 724 542 57 73 521 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5773 m0 *1 324.76,51.68
X$5773 73 259 576 542 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $5774 m0 *1 326.14,51.68
X$5774 73 538 259 577 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $5811 m0 *1 409.4,51.68
X$5811 73 487 581 264 184 57 73 527 57 sky130_fd_sc_hd__a31oi_1
* cell instance $5812 m0 *1 411.7,51.68
X$5812 73 526 490 488 73 581 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5813 m0 *1 413.54,51.68
X$5813 73 488 525 490 377 73 57 582 57 sky130_fd_sc_hd__o31ai_1
* cell instance $5816 m0 *1 417.68,51.68
X$5816 73 165 489 487 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $5818 m0 *1 419.98,51.68
X$5818 73 491 73 57 444 57 sky130_fd_sc_hd__buf_4
* cell instance $5822 m0 *1 424.58,51.68
X$5822 73 417 626 430 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $5823 m0 *1 425.96,51.68
X$5823 73 494 73 57 474 57 sky130_fd_sc_hd__buf_4
* cell instance $5826 m0 *1 436.08,51.68
X$5826 73 446 492 585 522 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5835 m0 *1 449.88,51.68
X$5835 73 493 545 494 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $5838 m0 *1 456.32,51.68
X$5838 73 619 546 518 73 407 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5839 m0 *1 458.16,51.68
X$5839 73 139 73 57 518 57 sky130_fd_sc_hd__buf_4
* cell instance $5841 m0 *1 462.76,51.68
X$5841 73 580 355 300 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $5843 m0 *1 464.6,51.68
X$5843 73 580 114 371 57 73 496 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5845 m0 *1 467.36,51.68
X$5845 73 495 496 355 73 547 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5847 m0 *1 469.66,51.68
X$5847 73 578 231 498 57 73 515 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5849 m0 *1 471.96,51.68
X$5849 73 355 497 547 73 514 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $5850 m0 *1 473.8,51.68
X$5850 73 456 371 359 499 57 73 497 57 sky130_fd_sc_hd__a31oi_1
* cell instance $5851 m0 *1 476.1,51.68
X$5851 57 408 501 335 500 205 489 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $5854 m0 *1 479.32,51.68
X$5854 73 209 296 457 569 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5855 m0 *1 481.16,51.68
X$5855 73 205 569 502 511 359 73 566 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $5856 m0 *1 484.38,51.68
X$5856 73 343 503 419 502 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5857 m0 *1 486.22,51.68
X$5857 73 296 419 473 549 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $5858 m0 *1 488.06,51.68
X$5858 73 549 155 205 57 73 508 57 sky130_fd_sc_hd__a21oi_1
* cell instance $5859 m0 *1 489.9,51.68
X$5859 73 136 550 464 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $5861 m0 *1 493.12,51.68
X$5861 73 552 73 57 410 57 sky130_fd_sc_hd__buf_4
* cell instance $5862 m0 *1 495.88,51.68
X$5862 73 335 550 556 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $5866 m0 *1 500.02,51.68
X$5866 57 505 506 657 175 181 504 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $5867 m0 *1 503.24,51.68
X$5867 73 555 376 337 57 73 504 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6023 r0 *1 217.58,51.68
X$6023 57 76 606 322 554 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $6032 r0 *1 252.08,51.68
X$6032 73 512 258 530 73 531 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6034 r0 *1 254.84,51.68
X$6034 73 420 480 558 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6035 r0 *1 256.22,51.68
X$6035 73 512 529 560 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6036 r0 *1 257.6,51.68
X$6036 73 530 793 531 360 559 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $6045 r0 *1 275.08,51.68
X$6045 73 535 193 258 611 57 563 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $6046 r0 *1 277.84,51.68
X$6046 73 536 533 396 287 535 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $6048 r0 *1 281.52,51.68
X$6048 57 363 612 397 536 568 565 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $6049 r0 *1 284.74,51.68
X$6049 57 570 538 530 587 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $6051 r0 *1 289.34,51.68
X$6051 73 571 73 57 279 57 sky130_fd_sc_hd__buf_4
* cell instance $6057 r0 *1 305.44,51.68
X$6057 73 434 480 330 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6059 r0 *1 307.74,51.68
X$6059 73 574 73 57 575 57 sky130_fd_sc_hd__buf_4
* cell instance $6068 r0 *1 323.38,51.68
X$6068 73 540 73 57 576 57 sky130_fd_sc_hd__buf_4
* cell instance $6071 r0 *1 327.52,51.68
X$6071 73 194 577 541 57 73 543 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6072 r0 *1 329.36,51.68
X$6072 73 524 543 254 73 625 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6075 r0 *1 336.72,51.68
X$6075 57 579 230 486 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $6107 r0 *1 412.62,51.68
X$6107 73 252 582 432 629 628 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $6117 r0 *1 432.86,51.68
X$6117 73 296 73 57 446 57 sky130_fd_sc_hd__buf_4
* cell instance $6118 r0 *1 435.62,51.68
X$6118 73 544 73 57 585 57 sky130_fd_sc_hd__buf_4
* cell instance $6119 r0 *1 438.38,51.68
X$6119 73 359 156 544 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6125 r0 *1 449.88,51.68
X$6125 73 546 584 371 73 140 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6128 r0 *1 454.48,51.68
X$6128 73 266 73 57 493 57 sky130_fd_sc_hd__buf_4
* cell instance $6132 r0 *1 460,51.68
X$6132 73 583 234 159 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6133 r0 *1 461.38,51.68
X$6133 73 583 73 57 580 57 sky130_fd_sc_hd__buf_4
* cell instance $6137 r0 *1 469.2,51.68
X$6137 73 493 503 550 578 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $6140 r0 *1 473.8,51.68
X$6140 73 371 231 359 503 57 499 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $6143 r0 *1 480.24,51.68
X$6143 57 572 205 548 567 566 551 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $6149 r0 *1 487.14,51.68
X$6149 73 562 296 343 419 57 510 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $6150 r0 *1 489.44,51.68
X$6150 73 136 205 599 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6152 r0 *1 491.28,51.68
X$6152 73 551 234 498 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6154 r0 *1 493.12,51.68
X$6154 73 270 205 553 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6156 r0 *1 495.42,51.68
X$6156 73 553 552 604 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6158 r0 *1 497.72,51.68
X$6158 73 553 73 57 489 57 sky130_fd_sc_hd__buf_4
* cell instance $6319 m0 *1 223.56,57.12
X$6319 57 607 322 586 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $6331 m0 *1 251.62,57.12
X$6331 73 790 73 57 287 57 sky130_fd_sc_hd__buf_4
* cell instance $6332 m0 *1 254.38,57.12
X$6332 73 608 73 57 529 57 sky130_fd_sc_hd__buf_4
* cell instance $6333 m0 *1 257.14,57.12
X$6333 73 512 587 361 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6338 m0 *1 259.9,57.12
X$6338 57 193 561 396 664 609 587 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $6339 m0 *1 263.12,57.12
X$6339 73 588 253 609 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6343 m0 *1 269.56,57.12
X$6343 73 589 587 362 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6346 m0 *1 273.7,57.12
X$6346 73 587 588 272 258 57 73 564 57 sky130_fd_sc_hd__a31oi_1
* cell instance $6353 m0 *1 284.74,57.12
X$6353 57 611 590 613 193 272 330 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $6357 m0 *1 289.8,57.12
X$6357 73 440 591 571 57 73 573 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6358 m0 *1 291.64,57.12
X$6358 73 591 73 57 423 57 sky130_fd_sc_hd__buf_4
* cell instance $6361 m0 *1 295.78,57.12
X$6361 73 635 480 593 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6364 m0 *1 298.54,57.12
X$6364 73 593 73 57 592 57 sky130_fd_sc_hd__buf_4
* cell instance $6365 m0 *1 301.3,57.12
X$6365 73 593 616 617 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $6371 m0 *1 310.96,57.12
X$6371 73 434 622 590 541 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $6372 m0 *1 312.8,57.12
X$6372 57 443 321 254 623 594 639 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $6415 m0 *1 409.86,57.12
X$6415 73 435 630 681 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6416 m0 *1 411.24,57.12
X$6416 57 473 596 446 595 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $6417 m0 *1 413.54,57.12
X$6417 73 596 73 57 629 57 sky130_fd_sc_hd__buf_4
* cell instance $6425 m0 *1 423.66,57.12
X$6425 73 627 73 57 417 57 sky130_fd_sc_hd__buf_4
* cell instance $6426 m0 *1 426.42,57.12
X$6426 73 488 620 595 57 73 626 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6430 m0 *1 431.48,57.12
X$6430 73 597 73 57 624 57 sky130_fd_sc_hd__buf_4
* cell instance $6432 m0 *1 434.7,57.12
X$6432 73 417 252 624 769 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $6433 m0 *1 436.54,57.12
X$6433 73 446 115 644 57 73 546 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6434 m0 *1 438.38,57.12
X$6434 73 488 678 544 57 73 597 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6435 m0 *1 440.22,57.12
X$6435 73 311 234 678 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6441 m0 *1 448.5,57.12
X$6441 73 493 313 598 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6445 m0 *1 450.34,57.12
X$6445 73 598 73 57 620 57 sky130_fd_sc_hd__buf_4
* cell instance $6447 m0 *1 454.94,57.12
X$6447 73 618 73 57 619 57 sky130_fd_sc_hd__buf_4
* cell instance $6451 m0 *1 460.92,57.12
X$6451 73 615 73 57 583 57 sky130_fd_sc_hd__inv_1
* cell instance $6452 m0 *1 462.3,57.12
X$6452 73 648 73 57 264 57 sky130_fd_sc_hd__buf_4
* cell instance $6454 m0 *1 466.9,57.12
X$6454 73 278 345 614 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6456 m0 *1 468.74,57.12
X$6456 73 651 73 57 278 57 sky130_fd_sc_hd__buf_4
* cell instance $6459 m0 *1 473.8,57.12
X$6459 73 371 717 372 73 671 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6464 m0 *1 478.4,57.12
X$6464 73 419 667 610 57 73 548 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6465 m0 *1 480.24,57.12
X$6465 73 359 231 610 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6466 m0 *1 481.62,57.12
X$6466 73 343 503 457 567 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $6468 m0 *1 487.14,57.12
X$6468 73 270 599 600 57 73 415 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6469 m0 *1 488.98,57.12
X$6469 73 601 73 57 136 57 sky130_fd_sc_hd__buf_4
* cell instance $6470 m0 *1 491.74,57.12
X$6470 73 156 73 57 603 57 sky130_fd_sc_hd__buf_4
* cell instance $6471 m0 *1 494.5,57.12
X$6471 73 602 603 552 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6473 m0 *1 496.34,57.12
X$6473 73 603 73 57 550 57 sky130_fd_sc_hd__buf_4
* cell instance $6475 m0 *1 499.56,57.12
X$6475 73 311 603 239 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6476 m0 *1 500.94,57.12
X$6476 73 601 603 271 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6477 m0 *1 502.32,57.12
X$6477 73 605 620 555 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6633 r0 *1 216.66,57.12
X$6633 57 76 661 322 660 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $6642 r0 *1 246.56,57.12
X$6642 73 608 73 57 633 57 sky130_fd_sc_hd__buf_4
* cell instance $6643 r0 *1 249.32,57.12
X$6643 73 634 73 57 512 57 sky130_fd_sc_hd__buf_4
* cell instance $6644 r0 *1 252.08,57.12
X$6644 57 15581 481 529 634 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $6645 r0 *1 256.68,57.12
X$6645 57 15677 635 608 588 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $6647 r0 *1 261.28,57.12
X$6647 73 665 193 664 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6653 r0 *1 272.78,57.12
X$6653 73 635 73 57 636 57 sky130_fd_sc_hd__buf_4
* cell instance $6654 r0 *1 275.54,57.12
X$6654 73 588 480 638 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6655 r0 *1 276.92,57.12
X$6655 57 637 636 530 480 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $6656 r0 *1 280.6,57.12
X$6656 73 533 637 536 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6658 r0 *1 282.44,57.12
X$6658 73 612 73 57 668 57 sky130_fd_sc_hd__buf_4
* cell instance $6659 r0 *1 285.2,57.12
X$6659 73 613 480 471 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6662 r0 *1 287.5,57.12
X$6662 73 613 587 571 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6669 r0 *1 297.16,57.12
X$6669 73 638 73 57 226 57 sky130_fd_sc_hd__buf_4
* cell instance $6672 r0 *1 302.68,57.12
X$6672 73 286 633 587 57 73 616 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6675 r0 *1 306.82,57.12
X$6675 73 434 638 674 57 73 673 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6677 r0 *1 310.5,57.12
X$6677 73 443 279 622 639 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $6685 r0 *1 331.2,57.12
X$6685 73 665 676 639 194 677 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $6713 r0 *1 399.74,57.12
X$6713 73 640 73 57 679 57 sky130_fd_sc_hd__buf_4
* cell instance $6718 r0 *1 408.02,57.12
X$6718 73 682 681 477 646 73 640 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $6721 r0 *1 412.62,57.12
X$6721 73 641 628 614 73 682 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6722 r0 *1 414.46,57.12
X$6722 73 642 73 57 683 57 sky130_fd_sc_hd__buf_4
* cell instance $6725 r0 *1 419.52,57.12
X$6725 73 643 284 488 73 723 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6726 r0 *1 421.36,57.12
X$6726 73 491 545 643 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $6734 r0 *1 434.7,57.12
X$6734 73 488 492 644 680 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $6735 r0 *1 436.54,57.12
X$6735 73 645 73 57 492 57 sky130_fd_sc_hd__buf_4
* cell instance $6738 r0 *1 440.68,57.12
X$6738 73 678 73 57 645 57 sky130_fd_sc_hd__buf_4
* cell instance $6742 r0 *1 449.42,57.12
X$6742 73 614 73 57 621 57 sky130_fd_sc_hd__buf_4
* cell instance $6745 r0 *1 453.1,57.12
X$6745 73 675 598 151 597 57 73 647 57 sky130_fd_sc_hd__a31oi_1
* cell instance $6751 r0 *1 462.3,57.12
X$6751 73 419 371 648 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6753 r0 *1 464.14,57.12
X$6753 57 642 647 650 649 648 103 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $6754 r0 *1 467.36,57.12
X$6754 73 651 345 649 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6755 r0 *1 468.74,57.12
X$6755 73 649 73 57 374 57 sky130_fd_sc_hd__buf_4
* cell instance $6757 r0 *1 472.42,57.12
X$6757 73 652 73 57 670 57 sky130_fd_sc_hd__buf_4
* cell instance $6758 r0 *1 475.18,57.12
X$6758 73 654 671 672 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6761 r0 *1 477.48,57.12
X$6761 73 666 654 663 669 73 351 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $6762 r0 *1 479.78,57.12
X$6762 73 337 655 231 73 666 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6763 r0 *1 481.62,57.12
X$6763 73 359 551 655 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6764 r0 *1 483,57.12
X$6764 73 498 656 311 73 663 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6767 r0 *1 485.76,57.12
X$6767 73 231 175 550 656 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $6769 r0 *1 488.52,57.12
X$6769 73 473 73 57 600 57 sky130_fd_sc_hd__buf_4
* cell instance $6771 r0 *1 493.12,57.12
X$6771 73 605 498 662 57 73 176 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6906 m0 *1 155.02,62.56
X$6906 73 685 728 684 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6909 m0 *1 158.7,62.56
X$6909 73 658 686 710 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6910 m0 *1 160.08,62.56
X$6910 73 632 686 631 687 73 57 711 57 sky130_fd_sc_hd__o31ai_1
* cell instance $6917 m0 *1 173.88,62.56
X$6917 73 688 1065 632 689 57 73 712 57 sky130_fd_sc_hd__a31oi_1
* cell instance $6918 m0 *1 176.18,62.56
X$6918 73 658 632 684 73 689 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6923 m0 *1 179.4,62.56
X$6923 57 713 632 659 735 685 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $6928 m0 *1 192.28,62.56
X$6928 57 685 714 686 632 715 631 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $6951 m0 *1 246.1,62.56
X$6951 57 15455 695 690 634 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $6953 m0 *1 251.16,62.56
X$6953 73 588 73 57 634 57 sky130_fd_sc_hd__inv_1
* cell instance $6954 m0 *1 252.54,62.56
X$6954 57 15475 692 690 634 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $6956 m0 *1 257.6,62.56
X$6956 73 692 587 693 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6957 m0 *1 258.98,62.56
X$6957 73 692 73 57 357 57 sky130_fd_sc_hd__buf_4
* cell instance $6960 m0 *1 261.74,62.56
X$6960 73 693 73 57 396 57 sky130_fd_sc_hd__buf_4
* cell instance $6962 m0 *1 268.18,62.56
X$6962 73 719 73 57 613 57 sky130_fd_sc_hd__inv_1
* cell instance $6971 m0 *1 281.98,62.56
X$6971 73 637 73 57 721 57 sky130_fd_sc_hd__buf_4
* cell instance $6976 m0 *1 288.88,62.56
X$6976 73 695 587 279 73 540 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $6977 m0 *1 290.72,62.56
X$6977 73 691 480 591 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6982 m0 *1 302.22,62.56
X$6982 73 633 587 696 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6984 m0 *1 304.06,62.56
X$6984 73 440 776 696 57 73 393 57 sky130_fd_sc_hd__a21oi_1
* cell instance $6986 m0 *1 306.36,62.56
X$6986 73 696 73 57 697 57 sky130_fd_sc_hd__buf_4
* cell instance $6989 m0 *1 311.42,62.56
X$6989 73 636 480 594 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $6990 m0 *1 312.8,62.56
X$6990 73 691 530 224 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $6997 m0 *1 322.92,62.56
X$6997 73 434 697 725 724 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $7035 m0 *1 411.24,62.56
X$7035 73 706 73 57 595 57 sky130_fd_sc_hd__buf_4
* cell instance $7040 m0 *1 417.22,62.56
X$7040 73 446 284 212 698 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $7041 m0 *1 419.06,62.56
X$7041 57 641 723 118 448 699 700 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $7045 m0 *1 423.2,62.56
X$7045 57 488 722 150 643 701 680 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $7050 m0 *1 436.54,62.56
X$7050 73 720 73 57 644 57 sky130_fd_sc_hd__buf_4
* cell instance $7055 m0 *1 446.2,62.56
X$7055 73 359 313 702 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7056 m0 *1 447.58,62.56
X$7056 73 702 73 57 302 57 sky130_fd_sc_hd__buf_4
* cell instance $7059 m0 *1 450.34,62.56
X$7059 73 311 488 645 73 718 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7068 m0 *1 472.88,62.56
X$7068 73 670 703 296 653 57 73 717 57 sky130_fd_sc_hd__a31oi_1
* cell instance $7069 m0 *1 475.18,62.56
X$7069 57 716 672 704 621 705 336 73 73 57 sky130_fd_sc_hd__a311oi_2
* cell instance $7072 m0 *1 480.7,62.56
X$7072 73 667 73 57 456 57 sky130_fd_sc_hd__buf_4
* cell instance $7076 m0 *1 486.68,62.56
X$7076 73 602 600 706 57 73 653 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7077 m0 *1 488.52,62.56
X$7077 57 602 296 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $7078 m0 *1 495.88,62.56
X$7078 73 270 556 707 57 73 750 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7079 m0 *1 497.72,62.56
X$7079 73 206 562 708 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7082 m0 *1 500.48,62.56
X$7082 73 703 708 657 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7085 m0 *1 503.24,62.56
X$7085 73 175 456 709 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7209 r0 *1 149.04,62.56
X$7209 73 726 781 730 745 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $7210 r0 *1 150.88,62.56
X$7210 73 687 745 727 685 728 73 729 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $7214 r0 *1 158.24,62.56
X$7214 73 729 73 57 746 57 sky130_fd_sc_hd__buf_4
* cell instance $7216 r0 *1 162.84,62.56
X$7216 73 730 748 749 632 57 73 731 57 sky130_fd_sc_hd__and4_1
* cell instance $7225 r0 *1 182.62,62.56
X$7225 73 726 753 713 73 754 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7229 r0 *1 192.74,62.56
X$7229 73 731 714 755 728 73 57 756 57 sky130_fd_sc_hd__o31ai_1
* cell instance $7232 r0 *1 197.8,62.56
X$7232 57 761 758 756 759 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $7236 r0 *1 205.16,62.56
X$7236 73 733 686 734 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7239 r0 *1 207.46,62.56
X$7239 73 734 732 632 73 826 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7241 r0 *1 209.76,62.56
X$7241 73 734 73 57 735 57 sky130_fd_sc_hd__buf_4
* cell instance $7255 r0 *1 245.64,62.56
X$7255 73 690 73 57 608 57 sky130_fd_sc_hd__inv_1
* cell instance $7256 r0 *1 247.02,62.56
X$7256 73 634 73 57 691 57 sky130_fd_sc_hd__buf_4
* cell instance $7258 r0 *1 250.24,62.56
X$7258 73 690 73 57 530 57 sky130_fd_sc_hd__buf_4
* cell instance $7260 r0 *1 253.46,62.56
X$7260 57 15655 737 608 634 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $7263 r0 *1 259.9,62.56
X$7263 57 15640 719 690 588 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $7266 r0 *1 265.42,62.56
X$7266 73 719 73 57 736 57 sky130_fd_sc_hd__buf_4
* cell instance $7269 r0 *1 275.54,62.56
X$7269 73 192 560 676 736 272 834 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $7272 r0 *1 281.06,62.56
X$7272 73 695 73 57 772 57 sky130_fd_sc_hd__buf_4
* cell instance $7275 r0 *1 286.58,62.56
X$7275 73 776 73 57 225 57 sky130_fd_sc_hd__buf_4
* cell instance $7277 r0 *1 289.34,62.56
X$7277 73 737 73 57 775 57 sky130_fd_sc_hd__buf_4
* cell instance $7282 r0 *1 300.84,62.56
X$7282 73 737 587 674 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7285 r0 *1 307.74,62.56
X$7285 73 674 73 57 859 57 sky130_fd_sc_hd__buf_4
* cell instance $7294 r0 *1 323.38,62.56
X$7294 73 721 272 676 357 838 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $7296 r0 *1 326.14,62.56
X$7296 73 616 73 57 780 57 sky130_fd_sc_hd__buf_4
* cell instance $7329 r0 *1 408.02,62.56
X$7329 73 446 358 738 73 778 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7332 r0 *1 412.16,62.56
X$7332 57 774 777 683 596 739 740 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $7333 r0 *1 415.38,62.56
X$7333 73 446 284 302 739 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $7334 r0 *1 417.22,62.56
X$7334 73 741 150 627 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7335 r0 *1 418.6,62.56
X$7335 73 627 73 57 774 57 sky130_fd_sc_hd__buf_4
* cell instance $7336 r0 *1 421.36,62.56
X$7336 73 698 446 771 57 73 700 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7339 r0 *1 424.12,62.56
X$7339 73 741 722 770 57 73 773 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7345 r0 *1 435.16,62.56
X$7345 73 742 313 331 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7349 r0 *1 439.76,62.56
X$7349 73 769 832 768 73 646 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7351 r0 *1 445.28,62.56
X$7351 73 742 73 57 165 57 sky130_fd_sc_hd__buf_4
* cell instance $7353 r0 *1 448.5,62.56
X$7353 73 384 73 57 766 57 sky130_fd_sc_hd__buf_4
* cell instance $7355 r0 *1 451.26,62.56
X$7355 73 765 766 584 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7357 r0 *1 453.56,62.56
X$7357 73 488 189 703 764 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $7362 r0 *1 459.08,62.56
X$7362 73 615 73 57 308 57 sky130_fd_sc_hd__buf_4
* cell instance $7366 r0 *1 472.88,62.56
X$7366 57 743 155 763 503 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $7367 r0 *1 476.56,62.56
X$7367 73 743 73 57 757 57 sky130_fd_sc_hd__buf_4
* cell instance $7375 r0 *1 489.9,62.56
X$7375 73 374 752 744 705 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $7378 r0 *1 495.88,62.56
X$7378 73 750 73 57 751 57 sky130_fd_sc_hd__buf_4
* cell instance $7379 r0 *1 498.64,62.56
X$7379 73 657 815 747 551 181 73 744 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $7509 m0 *1 154.1,68
X$7509 73 726 781 816 782 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $7511 m0 *1 156.4,68
X$7511 73 726 710 786 782 73 57 784 57 sky130_fd_sc_hd__o31ai_1
* cell instance $7513 m0 *1 159.62,68
X$7513 57 711 684 843 824 783 784 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $7518 m0 *1 169.28,68
X$7518 73 818 73 57 715 57 sky130_fd_sc_hd__buf_4
* cell instance $7521 m0 *1 176.18,68
X$7521 73 632 787 786 878 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $7526 m0 *1 179.4,68
X$7526 73 787 786 632 73 823 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7537 m0 *1 199.18,68
X$7537 73 824 684 825 57 73 759 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7539 m0 *1 204.7,68
X$7539 57 632 761 826 788 789 783 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $7545 m0 *1 211.14,68
X$7545 73 783 826 827 57 73 1216 57 sky130_fd_sc_hd__a21boi_0
* cell instance $7560 m0 *1 247.02,68
X$7560 73 790 73 57 791 57 sky130_fd_sc_hd__buf_4
* cell instance $7564 m0 *1 253,68
X$7564 73 792 480 790 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7567 m0 *1 257.14,68
X$7567 73 794 73 57 792 57 sky130_fd_sc_hd__inv_1
* cell instance $7573 m0 *1 266.8,68
X$7573 73 440 73 57 533 57 sky130_fd_sc_hd__buf_4
* cell instance $7577 m0 *1 274.62,68
X$7577 73 794 480 776 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7579 m0 *1 276.92,68
X$7579 73 258 834 961 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7582 m0 *1 282.44,68
X$7582 73 835 73 57 623 57 sky130_fd_sc_hd__buf_4
* cell instance $7589 m0 *1 298.08,68
X$7589 73 636 795 272 779 73 281 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $7596 m0 *1 310.5,68
X$7596 73 258 837 330 530 434 966 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $7604 m0 *1 327.06,68
X$7604 73 293 838 860 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7605 m0 *1 328.44,68
X$7605 73 272 361 791 57 73 796 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7607 m0 *1 331.2,68
X$7607 73 1165 361 272 796 57 73 797 57 sky130_fd_sc_hd__a31oi_1
* cell instance $7609 m0 *1 333.96,68
X$7609 73 193 797 677 73 1304 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7642 m0 *1 408.02,68
X$7642 73 446 1297 738 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7645 m0 *1 413.54,68
X$7645 73 184 773 798 73 57 836 57 sky130_fd_sc_hd__o21bai_1
* cell instance $7648 m0 *1 420.44,68
X$7648 73 799 73 57 284 57 sky130_fd_sc_hd__buf_4
* cell instance $7657 m0 *1 440.68,68
X$7657 73 802 264 764 886 833 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $7660 m0 *1 445.28,68
X$7660 57 762 832 150 884 751 831 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $7666 m0 *1 454.48,68
X$7666 57 801 718 308 667 803 804 805 73 73 57 sky130_fd_sc_hd__a222oi_1
* cell instance $7668 m0 *1 459.08,68
X$7668 73 311 234 803 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7669 m0 *1 460.46,68
X$7669 73 125 808 806 830 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $7671 m0 *1 462.76,68
X$7671 73 760 335 296 300 57 828 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $7672 m0 *1 465.52,68
X$7672 73 829 828 807 419 806 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $7673 m0 *1 468.28,68
X$7673 73 337 498 763 73 807 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7679 m0 *1 474.72,68
X$7679 73 809 234 743 57 73 762 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7683 m0 *1 477.48,68
X$7683 73 654 811 808 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7684 m0 *1 478.86,68
X$7684 73 757 760 881 296 359 669 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $7686 m0 *1 482.54,68
X$7686 73 822 880 821 231 359 811 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $7688 m0 *1 486.22,68
X$7688 73 819 359 498 57 73 821 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7690 m0 *1 488.98,68
X$7690 73 175 550 819 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7692 m0 *1 490.82,68
X$7692 57 813 337 812 175 343 550 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $7693 m0 *1 494.04,68
X$7693 73 605 876 813 752 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $7695 m0 *1 496.34,68
X$7695 73 817 73 57 815 57 sky130_fd_sc_hd__buf_4
* cell instance $7831 r0 *1 160.54,68
X$7831 73 659 842 632 73 687 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7833 r0 *1 166.06,68
X$7833 73 785 686 788 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $7834 r0 *1 168.36,68
X$7834 73 785 686 818 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7835 r0 *1 169.74,68
X$7835 73 818 786 726 73 877 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7836 r0 *1 171.58,68
X$7836 73 844 73 57 820 57 sky130_fd_sc_hd__buf_4
* cell instance $7838 r0 *1 175.26,68
X$7838 73 848 658 847 878 57 844 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $7842 r0 *1 182.16,68
X$7842 57 1119 753 785 847 726 848 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $7846 r0 *1 193.66,68
X$7846 73 749 952 998 57 73 755 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7871 r0 *1 256.22,68
X$7871 73 363 480 793 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7872 r0 *1 257.6,68
X$7872 73 792 850 592 915 420 885 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $7877 r0 *1 265.88,68
X$7877 73 794 73 57 857 57 sky130_fd_sc_hd__buf_4
* cell instance $7878 r0 *1 268.64,68
X$7878 73 440 587 850 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7880 r0 *1 273.7,68
X$7880 73 533 348 888 73 441 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7884 r0 *1 281.98,68
X$7884 73 363 851 853 73 537 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7887 r0 *1 285.2,68
X$7887 57 253 853 363 852 854 890 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $7889 r0 *1 288.42,68
X$7889 73 856 855 854 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7891 r0 *1 290.72,68
X$7891 73 772 587 855 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7895 r0 *1 297.16,68
X$7895 73 850 330 795 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7897 r0 *1 302.22,68
X$7897 73 858 193 857 330 73 890 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $7900 r0 *1 309.58,68
X$7900 73 443 622 859 57 73 858 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7902 r0 *1 312.34,68
X$7902 73 434 592 859 57 73 894 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7907 r0 *1 320.16,68
X$7907 57 57 779 73 691 587 73 sky130_fd_sc_hd__nor2_2
* cell instance $7943 r0 *1 408.02,68
X$7943 73 801 73 57 893 57 sky130_fd_sc_hd__buf_4
* cell instance $7944 r0 *1 410.78,68
X$7944 73 893 831 778 774 1135 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $7945 r0 *1 413.08,68
X$7945 73 830 889 777 836 57 73 892 57 sky130_fd_sc_hd__and4_1
* cell instance $7948 r0 *1 417.68,68
X$7948 57 295 861 891 212 490 446 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $7951 r0 *1 422.74,68
X$7951 73 448 864 377 861 57 862 73 57 sky130_fd_sc_hd__a22o_1
* cell instance $7952 r0 *1 425.96,68
X$7952 73 833 862 614 73 889 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $7953 r0 *1 427.8,68
X$7953 73 308 545 799 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7958 r0 *1 436.08,68
X$7958 73 863 337 699 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7959 r0 *1 437.46,68
X$7959 73 699 235 887 165 308 864 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $7961 r0 *1 441.14,68
X$7961 73 296 800 865 886 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $7962 r0 *1 442.98,68
X$7962 73 296 800 865 57 73 884 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7964 r0 *1 445.28,68
X$7964 73 359 296 805 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7972 r0 *1 459.54,68
X$7972 73 803 73 57 517 57 sky130_fd_sc_hd__buf_4
* cell instance $7975 r0 *1 463.68,68
X$7975 73 151 810 452 57 73 883 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7977 r0 *1 467.36,68
X$7977 73 101 73 57 763 57 sky130_fd_sc_hd__buf_4
* cell instance $7979 r0 *1 471.04,68
X$7979 57 15589 868 296 359 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $7980 r0 *1 475.64,68
X$7980 73 868 654 234 809 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $7983 r0 *1 477.94,68
X$7983 73 457 73 57 654 57 sky130_fd_sc_hd__buf_4
* cell instance $7984 r0 *1 480.7,68
X$7984 73 869 73 57 881 57 sky130_fd_sc_hd__buf_4
* cell instance $7985 r0 *1 483.46,68
X$7985 73 489 503 869 57 73 880 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7987 r0 *1 485.76,68
X$7987 73 551 550 869 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $7988 r0 *1 487.14,68
X$7988 73 870 550 804 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $7989 r0 *1 488.52,68
X$7989 73 804 73 57 810 57 sky130_fd_sc_hd__buf_4
* cell instance $7990 r0 *1 491.28,68
X$7990 73 270 810 599 57 73 871 57 sky130_fd_sc_hd__a21oi_1
* cell instance $7992 r0 *1 493.58,68
X$7992 73 814 460 871 876 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $7994 r0 *1 495.88,68
X$7994 73 707 73 57 452 57 sky130_fd_sc_hd__buf_4
* cell instance $8121 m0 *1 141.68,73.44
X$8121 73 726 781 903 57 73 902 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8122 m0 *1 143.52,73.44
X$8122 73 903 904 726 1201 57 73 839 57 sky130_fd_sc_hd__a31oi_1
* cell instance $8123 m0 *1 145.82,73.44
X$8123 73 726 875 903 841 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $8126 m0 *1 149.96,73.44
X$8126 73 749 728 839 57 73 840 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8130 m0 *1 152.26,73.44
X$8130 73 824 947 840 57 73 906 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8132 m0 *1 154.56,73.44
X$8132 57 726 947 847 788 842 841 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $8135 m0 *1 160.54,73.44
X$8135 73 686 631 904 73 908 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8140 m0 *1 170.2,73.44
X$8140 73 726 845 882 877 73 57 950 57 sky130_fd_sc_hd__o31ai_1
* cell instance $8143 m0 *1 175.72,73.44
X$8143 73 845 909 879 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8144 m0 *1 177.1,73.44
X$8144 73 846 686 632 73 909 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8149 m0 *1 180.32,73.44
X$8149 73 726 908 846 848 73 849 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $8152 m0 *1 185.38,73.44
X$8152 73 909 73 57 952 57 sky130_fd_sc_hd__buf_4
* cell instance $8160 m0 *1 202.86,73.44
X$8160 73 954 1246 726 73 827 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8165 m0 *1 207,73.44
X$8165 57 726 955 749 845 789 827 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $8166 m0 *1 210.22,73.44
X$8166 73 914 686 789 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8186 m0 *1 256.68,73.44
X$8186 73 253 885 1051 73 851 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8187 m0 *1 258.52,73.44
X$8187 73 361 73 57 915 57 sky130_fd_sc_hd__buf_4
* cell instance $8190 m0 *1 261.28,73.44
X$8190 73 916 73 57 665 57 sky130_fd_sc_hd__buf_4
* cell instance $8192 m0 *1 264.96,73.44
X$8192 57 440 856 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $8193 m0 *1 272.32,73.44
X$8193 73 794 587 324 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8195 m0 *1 274.16,73.44
X$8195 73 917 247 888 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8201 m0 *1 280.14,73.44
X$8201 73 792 587 835 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8208 m0 *1 291.18,73.44
X$8208 73 360 361 592 57 73 922 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8211 m0 *1 297.62,73.44
X$8211 73 850 73 57 921 57 sky130_fd_sc_hd__buf_4
* cell instance $8213 m0 *1 302.22,73.44
X$8213 57 330 665 968 316 857 434 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $8217 m0 *1 311.88,73.44
X$8217 57 258 965 964 895 894 966 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $8222 m0 *1 319.24,73.44
X$8222 73 856 963 594 437 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $8266 m0 *1 417.22,73.44
X$8266 73 958 73 57 490 57 sky130_fd_sc_hd__buf_4
* cell instance $8275 m0 *1 440.22,73.44
X$8275 73 863 545 800 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8280 m0 *1 445.28,73.44
X$8280 73 805 73 57 957 57 sky130_fd_sc_hd__buf_4
* cell instance $8286 m0 *1 455.86,73.44
X$8286 73 867 151 866 618 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $8294 m0 *1 474.72,73.44
X$8294 73 158 73 57 867 57 sky130_fd_sc_hd__buf_4
* cell instance $8298 m0 *1 477.94,73.44
X$8298 73 763 503 953 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8301 m0 *1 481.62,73.44
X$8301 73 869 953 760 503 231 822 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $8302 m0 *1 484.84,73.44
X$8302 73 175 234 760 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8306 m0 *1 494.5,73.44
X$8306 57 747 951 376 551 270 489 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $8310 m0 *1 499.56,73.44
X$8310 73 949 73 57 181 57 sky130_fd_sc_hd__buf_4
* cell instance $8313 m0 *1 503.7,73.44
X$8313 73 605 927 1020 175 709 946 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $8334 m0 *1 551.54,73.44
X$8334 73 944 73 57 943 57 sky130_fd_sc_hd__buf_4
* cell instance $8340 m0 *1 558.9,73.44
X$8340 57 943 873 941 940 1087 872 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $8345 m0 *1 570.86,73.44
X$8345 73 873 874 938 932 73 937 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $8355 m0 *1 588.8,73.44
X$8355 73 872 931 933 73 932 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8404 r0 *1 46.46,73.44
X$8404 73 897 896 1017 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8416 r0 *1 72.22,73.44
X$8416 73 934 73 57 936 57 sky130_fd_sc_hd__buf_4
* cell instance $8417 r0 *1 74.98,73.44
X$8417 73 901 935 898 977 57 1023 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $8421 r0 *1 80.96,73.44
X$8421 73 898 936 899 57 73 1021 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8424 r0 *1 85.56,73.44
X$8424 73 897 981 900 983 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $8425 r0 *1 87.4,73.44
X$8425 73 901 983 986 73 1024 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8427 r0 *1 92.92,73.44
X$8427 73 988 1027 899 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8448 r0 *1 140.3,73.44
X$8448 73 1464 781 726 902 57 73 989 57 sky130_fd_sc_hd__a31oi_1
* cell instance $8450 r0 *1 143.06,73.44
X$8450 73 847 989 990 73 905 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8453 r0 *1 147.66,73.44
X$8453 73 879 1153 847 73 990 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8454 r0 *1 149.5,73.44
X$8454 73 685 905 906 73 1030 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8459 r0 *1 154.56,73.44
X$8459 73 991 907 842 73 57 57 sky130_fd_sc_hd__and2_0
* cell instance $8460 r0 *1 156.86,73.44
X$8460 73 912 710 726 73 1034 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8464 r0 *1 164.68,73.44
X$8464 73 842 73 57 882 57 sky130_fd_sc_hd__buf_4
* cell instance $8466 r0 *1 168.36,73.44
X$8466 57 1036 950 1064 749 847 1206 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $8470 r0 *1 174.8,73.44
X$8470 73 712 1036 911 1035 57 910 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $8471 r0 *1 177.1,73.44
X$8471 73 910 73 57 1037 57 sky130_fd_sc_hd__buf_4
* cell instance $8474 r0 *1 180.32,73.44
X$8474 73 1330 907 912 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8476 r0 *1 182.16,73.44
X$8476 73 912 73 57 913 57 sky130_fd_sc_hd__buf_4
* cell instance $8477 r0 *1 184.92,73.44
X$8477 73 913 914 907 57 73 753 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8481 r0 *1 197.8,73.44
X$8481 73 882 995 632 73 1243 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8482 r0 *1 199.64,73.44
X$8482 73 914 996 995 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8485 r0 *1 202.4,73.44
X$8485 73 726 954 997 1042 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $8510 r0 *1 258.98,73.44
X$8510 57 794 916 690 588 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $8517 r0 *1 270.02,73.44
X$8517 73 959 856 325 57 73 1053 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8521 r0 *1 276.92,73.44
X$8521 73 257 961 1162 919 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $8522 r0 *1 278.76,73.44
X$8522 73 589 73 57 917 57 sky130_fd_sc_hd__buf_4
* cell instance $8523 r0 *1 281.52,73.44
X$8523 73 962 533 1000 917 387 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $8525 r0 *1 285.66,73.44
X$8525 73 919 257 920 57 73 918 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8527 r0 *1 287.5,73.44
X$8527 73 258 516 1052 73 920 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8528 r0 *1 289.34,73.44
X$8528 73 969 293 918 57 73 1136 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8532 r0 *1 294.4,73.44
X$8532 73 922 363 857 921 73 1052 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $8533 r0 *1 297.62,73.44
X$8533 73 316 73 57 923 57 sky130_fd_sc_hd__buf_4
* cell instance $8536 r0 *1 301.76,73.44
X$8536 73 792 587 970 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8538 r0 *1 304.06,73.44
X$8538 73 792 73 57 1049 57 sky130_fd_sc_hd__buf_4
* cell instance $8539 r0 *1 306.82,73.44
X$8539 73 443 423 970 57 73 1050 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8542 r0 *1 310.04,73.44
X$8542 57 258 967 257 1050 922 1142 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $8543 r0 *1 313.26,73.44
X$8543 73 293 965 967 57 73 969 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8550 r0 *1 324.76,73.44
X$8550 73 636 587 923 1047 924 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $8551 r0 *1 327.52,73.44
X$8551 73 258 860 924 57 73 1046 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8585 r0 *1 408.48,73.44
X$8585 73 404 73 57 1043 57 sky130_fd_sc_hd__buf_4
* cell instance $8586 r0 *1 411.24,73.44
X$8586 73 1004 799 1043 925 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $8587 r0 *1 414,73.44
X$8587 73 261 1041 925 1005 73 57 1040 57 sky130_fd_sc_hd__o31ai_1
* cell instance $8591 r0 *1 419.98,73.44
X$8591 73 1215 545 118 1033 740 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $8599 r0 *1 441.6,73.44
X$8599 73 1004 800 866 1079 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $8601 r0 *1 443.9,73.44
X$8601 73 500 1007 488 404 956 1005 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $8602 r0 *1 447.58,73.44
X$8602 73 493 151 1007 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8612 r0 *1 464.6,73.44
X$8612 73 493 151 1031 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $8613 r0 *1 466.9,73.44
X$8613 73 926 1011 376 151 73 1033 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $8614 r0 *1 470.12,73.44
X$8614 73 343 503 1011 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8623 r0 *1 486.68,73.44
X$8623 73 158 517 602 73 1028 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8627 r0 *1 491.74,73.44
X$8627 73 602 158 817 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8629 r0 *1 494.96,73.44
X$8629 73 271 335 926 57 73 951 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8632 r0 *1 499.56,73.44
X$8632 57 707 927 206 948 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $8637 r0 *1 505.08,73.44
X$8637 73 271 206 866 57 73 1020 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8638 r0 *1 506.92,73.44
X$8638 73 945 926 866 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8639 r0 *1 508.3,73.44
X$8639 73 945 73 57 376 57 sky130_fd_sc_hd__buf_4
* cell instance $8657 r0 *1 549.7,73.44
X$8657 73 1019 928 944 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8661 r0 *1 558.44,73.44
X$8661 73 942 73 57 941 57 sky130_fd_sc_hd__buf_4
* cell instance $8667 r0 *1 568.56,73.44
X$8667 73 939 928 1013 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8676 r0 *1 587.88,73.44
X$8676 73 872 930 929 933 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $8721 m0 *1 41.86,78.88
X$8721 73 971 975 1096 57 73 1016 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8726 m0 *1 48.3,78.88
X$8726 57 976 1101 1279 1017 972 898 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $8727 m0 *1 51.98,78.88
X$8727 73 1102 896 1104 1101 972 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $8728 m0 *1 54.74,78.88
X$8728 73 1058 73 57 973 57 sky130_fd_sc_hd__buf_4
* cell instance $8730 m0 *1 57.96,78.88
X$8730 73 1025 896 974 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8731 m0 *1 59.34,78.88
X$8731 73 974 73 57 975 57 sky130_fd_sc_hd__buf_4
* cell instance $8732 m0 *1 62.1,78.88
X$8732 57 974 977 985 1107 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $8734 m0 *1 65.32,78.88
X$8734 73 897 1058 934 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8735 m0 *1 66.7,78.88
X$8735 73 2171 73 57 1108 57 sky130_fd_sc_hd__buf_4
* cell instance $8739 m0 *1 71.3,78.88
X$8739 73 1108 979 977 981 978 73 1194 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $8741 m0 *1 74.98,78.88
X$8741 57 1109 978 976 1023 1195 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $8744 m0 *1 79.58,78.88
X$8744 73 1059 982 978 1021 57 1022 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $8746 m0 *1 82.34,78.88
X$8746 73 897 898 979 1111 73 57 1059 57 sky130_fd_sc_hd__o31ai_1
* cell instance $8748 m0 *1 85.56,78.88
X$8748 73 898 1317 1024 1026 1025 73 1061 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $8749 m0 *1 88.78,78.88
X$8749 73 985 984 1026 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8750 m0 *1 90.16,78.88
X$8750 73 986 1026 987 57 73 982 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8752 m0 *1 92.46,78.88
X$8752 73 1062 73 57 1027 57 sky130_fd_sc_hd__buf_4
* cell instance $8753 m0 *1 95.22,78.88
X$8753 73 1102 73 57 988 57 sky130_fd_sc_hd__buf_4
* cell instance $8775 m0 *1 143.52,78.88
X$8775 73 1112 73 57 903 57 sky130_fd_sc_hd__buf_4
* cell instance $8776 m0 *1 146.28,78.88
X$8776 73 991 73 57 846 57 sky130_fd_sc_hd__buf_4
* cell instance $8787 m0 *1 169.28,78.88
X$8787 73 686 992 1116 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8790 m0 *1 176.18,78.88
X$8790 73 993 994 992 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8791 m0 *1 177.56,78.88
X$8791 73 686 993 994 57 73 1038 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8795 m0 *1 180.32,78.88
X$8795 73 846 726 994 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8804 m0 *1 197.34,78.88
X$8804 73 996 994 1039 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8807 m0 *1 200.1,78.88
X$8807 73 1122 996 1042 1039 57 1045 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $8808 m0 *1 202.86,78.88
X$8808 73 913 997 632 73 1123 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8809 m0 *1 204.7,78.88
X$8809 73 998 1123 783 911 57 73 1069 57 sky130_fd_sc_hd__a31oi_1
* cell instance $8815 m0 *1 210.22,78.88
X$8815 73 632 914 996 57 73 1044 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8819 m0 *1 215.28,78.88
X$8819 73 685 1048 1045 1069 73 57 1124 57 sky130_fd_sc_hd__o31ai_1
* cell instance $8840 m0 *1 258.06,78.88
X$8840 73 1071 193 736 558 73 1051 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $8846 m0 *1 267.72,78.88
X$8846 73 916 480 348 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8847 m0 *1 269.1,78.88
X$8847 73 856 344 999 57 73 959 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8850 m0 *1 275.08,78.88
X$8850 73 588 587 192 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8856 m0 *1 281.98,78.88
X$8856 73 533 587 1000 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8859 m0 *1 286.12,78.88
X$8859 73 772 587 590 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8865 m0 *1 298.54,78.88
X$8865 57 318 1001 443 779 857 1000 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $8871 m0 *1 311.42,78.88
X$8871 73 1070 676 895 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8872 m0 *1 312.8,78.88
X$8872 73 964 73 57 397 57 sky130_fd_sc_hd__buf_4
* cell instance $8878 m0 *1 318.78,78.88
X$8878 73 964 721 1143 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8881 m0 *1 322.92,78.88
X$8881 73 1049 272 1002 73 1047 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8882 m0 *1 324.76,78.88
X$8882 73 1003 772 272 57 73 1002 57 sky130_fd_sc_hd__a21oi_1
* cell instance $8885 m0 *1 332.12,78.88
X$8885 73 272 1003 676 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8888 m0 *1 334.88,78.88
X$8888 73 775 443 1137 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8921 m0 *1 411.7,78.88
X$8921 57 473 1041 1004 706 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $8922 m0 *1 414,78.88
X$8922 73 1004 320 331 1132 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $8924 m0 *1 416.76,78.88
X$8924 73 1004 958 331 1130 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $8927 m0 *1 421.36,78.88
X$8927 73 359 545 958 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8932 m0 *1 424.12,78.88
X$8932 73 1129 73 57 701 57 sky130_fd_sc_hd__buf_4
* cell instance $8933 m0 *1 426.88,78.88
X$8933 73 1078 545 404 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8940 m0 *1 444.36,78.88
X$8940 73 1080 1006 865 73 771 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8941 m0 *1 446.2,78.88
X$8941 73 1006 1007 957 1008 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $8943 m0 *1 448.5,78.88
X$8943 57 1004 1126 765 562 702 1127 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $8947 m0 *1 452.18,78.88
X$8947 73 1080 234 562 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8949 m0 *1 454.02,78.88
X$8949 73 1009 73 57 488 57 sky130_fd_sc_hd__buf_4
* cell instance $8950 m0 *1 456.78,78.88
X$8950 73 1085 73 57 101 57 sky130_fd_sc_hd__buf_4
* cell instance $8951 m0 *1 459.54,78.88
X$8951 73 601 73 57 1080 57 sky130_fd_sc_hd__buf_4
* cell instance $8952 m0 *1 462.3,78.88
X$8952 73 1009 73 57 151 57 sky130_fd_sc_hd__buf_4
* cell instance $8954 m0 *1 465.52,78.88
X$8954 57 1032 1120 771 419 1010 829 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $8956 m0 *1 469.66,78.88
X$8956 73 1011 1031 234 73 1120 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8961 m0 *1 475.18,78.88
X$8961 73 1012 73 57 513 57 sky130_fd_sc_hd__buf_4
* cell instance $8965 m0 *1 478.86,78.88
X$8965 73 419 868 1029 926 57 1115 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $8966 m0 *1 481.62,78.88
X$8966 73 812 419 1029 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $8967 m0 *1 483,78.88
X$8967 73 949 73 57 419 57 sky130_fd_sc_hd__buf_4
* cell instance $8969 m0 *1 487.6,78.88
X$8969 57 15558 812 1009 311 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $8970 m0 *1 492.2,78.88
X$8970 73 1083 73 57 662 57 sky130_fd_sc_hd__buf_4
* cell instance $8971 m0 *1 494.96,78.88
X$8971 73 159 73 57 462 57 sky130_fd_sc_hd__buf_4
* cell instance $8976 m0 *1 500.48,78.88
X$8976 73 311 926 948 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $8977 m0 *1 501.86,78.88
X$8977 73 948 73 57 956 57 sky130_fd_sc_hd__buf_4
* cell instance $8980 m0 *1 504.62,78.88
X$8980 73 1078 73 57 945 57 sky130_fd_sc_hd__buf_4
* cell instance $8994 m0 *1 538.66,78.88
X$8994 73 1089 928 1013 1014 1103 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $8997 m0 *1 542.8,78.88
X$8997 73 1088 944 1014 73 1106 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $8998 m0 *1 544.64,78.88
X$8998 57 1014 1086 1099 1088 1100 1103 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $9005 m0 *1 556.14,78.88
X$9005 73 1089 928 1090 1018 1095 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $9011 m0 *1 567.18,78.88
X$9011 73 939 1092 940 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9013 m0 *1 569.48,78.88
X$9013 73 939 1015 1091 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9060 r0 *1 23.92,78.88
X$9060 73 901 1054 1055 73 1179 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9064 r0 *1 30.82,78.88
X$9064 73 1056 73 57 1145 57 sky130_fd_sc_hd__buf_4
* cell instance $9065 r0 *1 33.58,78.88
X$9065 73 1093 897 896 1056 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $9069 r0 *1 38.64,78.88
X$9069 73 973 1055 898 1016 57 1094 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $9071 r0 *1 41.86,78.88
X$9071 73 1097 1094 1147 1057 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9075 r0 *1 44.62,78.88
X$9075 73 1098 1022 1057 1186 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9076 r0 *1 46.46,78.88
X$9076 73 1017 73 57 1054 57 sky130_fd_sc_hd__buf_4
* cell instance $9077 r0 *1 49.22,78.88
X$9077 73 1025 896 1056 971 1189 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $9081 r0 *1 57.04,78.88
X$9081 73 1105 73 57 1058 57 sky130_fd_sc_hd__buf_4
* cell instance $9092 r0 *1 83.72,78.88
X$9092 73 986 980 987 1198 898 73 1111 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $9093 r0 *1 86.94,78.88
X$9093 73 1060 73 57 984 57 sky130_fd_sc_hd__buf_4
* cell instance $9094 r0 *1 89.7,78.88
X$9094 73 985 1060 1062 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9095 r0 *1 91.08,78.88
X$9095 73 1062 73 57 1235 57 sky130_fd_sc_hd__buf_4
* cell instance $9126 r0 *1 157.78,78.88
X$9126 73 726 781 1063 1204 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $9130 r0 *1 164.68,78.88
X$9130 73 785 907 1063 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9134 r0 *1 169.28,78.88
X$9134 73 1064 1116 1207 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9135 r0 *1 170.66,78.88
X$9135 73 1063 73 57 1065 57 sky130_fd_sc_hd__buf_4
* cell instance $9138 r0 *1 176.18,78.88
X$9138 73 1066 1038 1067 73 1035 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $9144 r0 *1 182.62,78.88
X$9144 73 1119 911 685 1121 57 1209 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $9147 r0 *1 187.68,78.88
X$9147 73 632 631 1068 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9149 r0 *1 189.52,78.88
X$9149 73 1068 1212 1125 686 728 73 1121 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $9152 r0 *1 200.1,78.88
X$9152 73 882 73 57 1161 57 sky130_fd_sc_hd__buf_4
* cell instance $9160 r0 *1 214.36,78.88
X$9160 73 685 1048 1066 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9176 r0 *1 257.6,78.88
X$9176 73 481 73 57 1070 57 sky130_fd_sc_hd__buf_4
* cell instance $9178 r0 *1 260.36,78.88
X$9178 73 587 481 1072 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $9180 r0 *1 263.12,78.88
X$9180 73 916 480 1224 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9184 r0 *1 269.56,78.88
X$9184 73 916 587 999 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9185 r0 *1 270.94,78.88
X$9185 73 258 1053 1225 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9188 r0 *1 275.08,78.88
X$9188 73 917 587 1072 856 1133 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $9191 r0 *1 282.44,78.88
X$9191 57 1134 721 917 258 856 558 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $9193 r0 *1 286.58,78.88
X$9193 73 1136 73 57 1073 57 sky130_fd_sc_hd__buf_4
* cell instance $9200 r0 *1 295.32,78.88
X$9200 73 397 1000 1138 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9201 r0 *1 296.7,78.88
X$9201 73 1138 397 921 57 73 1410 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9203 r0 *1 299,78.88
X$9203 73 192 258 1074 1228 1070 73 483 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $9208 r0 *1 310.96,78.88
X$9208 57 856 1142 258 594 1141 1075 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $9212 r0 *1 316.48,78.88
X$9212 57 1001 1726 443 964 779 1143 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $9215 r0 *1 321.08,78.88
X$9215 73 775 587 999 856 1075 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $9218 r0 *1 326.14,78.88
X$9218 73 856 225 999 1166 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $9219 r0 *1 327.98,78.88
X$9219 73 257 1140 1046 1139 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9253 r0 *1 409.4,78.88
X$9253 73 184 1135 1118 1218 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9255 r0 *1 412.16,78.88
X$9255 73 774 1132 1300 57 73 1076 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9256 r0 *1 414,78.88
X$9256 73 1076 1131 1040 614 73 57 1217 57 sky130_fd_sc_hd__o31ai_1
* cell instance $9258 r0 *1 417.68,78.88
X$9258 73 831 1130 1077 57 73 1131 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9259 r0 *1 419.52,78.88
X$9259 73 1078 73 57 891 57 sky130_fd_sc_hd__buf_4
* cell instance $9263 r0 *1 424.58,78.88
X$9263 73 774 1079 1128 57 73 1294 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9271 r0 *1 441.14,78.88
X$9271 73 491 1006 865 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9274 r0 *1 446.66,78.88
X$9274 73 720 159 1203 1004 500 73 1012 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $9282 r0 *1 463.68,78.88
X$9282 73 371 1081 1010 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $9283 r0 *1 465.98,78.88
X$9283 73 1083 1082 926 73 1081 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9285 r0 *1 468.74,78.88
X$9285 73 503 371 829 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9287 r0 *1 471.04,78.88
X$9287 73 1084 73 57 1118 57 sky130_fd_sc_hd__buf_4
* cell instance $9290 r0 *1 476.56,78.88
X$9290 73 1009 73 57 503 57 sky130_fd_sc_hd__buf_4
* cell instance $9292 r0 *1 479.32,78.88
X$9292 73 1117 926 551 1115 57 1084 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $9293 r0 *1 482.08,78.88
X$9293 73 156 73 57 926 57 sky130_fd_sc_hd__buf_4
* cell instance $9297 r0 *1 487.6,78.88
X$9297 73 1085 602 1083 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9299 r0 *1 490.82,78.88
X$9299 73 650 73 57 377 57 sky130_fd_sc_hd__buf_4
* cell instance $9316 r0 *1 534.52,78.88
X$9316 73 1086 73 57 1110 57 sky130_fd_sc_hd__buf_4
* cell instance $9318 r0 *1 538.2,78.88
X$9318 73 1087 1088 1018 73 1191 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9324 r0 *1 546.02,78.88
X$9324 73 1014 1434 1090 57 73 1286 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9378 m0 *1 26.22,84.32
X$9378 73 1144 1145 1179 57 73 1268 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9379 m0 *1 28.06,84.32
X$9379 73 897 973 1145 73 1180 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9385 m0 *1 37.26,84.32
X$9385 73 1146 73 57 898 57 sky130_fd_sc_hd__buf_4
* cell instance $9386 m0 *1 40.02,84.32
X$9386 73 1184 1144 1273 57 73 1185 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9391 m0 *1 46,84.32
X$9391 73 1186 1185 1148 1355 57 1190 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $9399 m0 *1 67.16,84.32
X$9399 73 1149 1192 1360 1193 57 73 1148 57 sky130_fd_sc_hd__a31oi_1
* cell instance $9403 m0 *1 71.3,84.32
X$9403 73 1194 1150 978 1362 73 1192 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $9406 m0 *1 76.82,84.32
X$9406 73 985 1196 1151 1150 1149 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $9407 m0 *1 79.58,84.32
X$9407 73 1197 1236 900 57 73 1151 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9409 m0 *1 82.34,84.32
X$9409 73 1152 73 57 900 57 sky130_fd_sc_hd__buf_4
* cell instance $9411 m0 *1 85.56,84.32
X$9411 73 1060 73 57 1152 57 sky130_fd_sc_hd__buf_4
* cell instance $9412 m0 *1 88.32,84.32
X$9412 73 1199 984 1239 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9436 m0 *1 141.22,84.32
X$9436 73 726 904 1112 57 73 1378 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9439 m0 *1 147.66,84.32
X$9439 73 907 1201 1241 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9440 m0 *1 149.04,84.32
X$9440 73 847 1289 1114 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9444 m0 *1 151.34,84.32
X$9444 73 733 726 1113 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9445 m0 *1 152.72,84.32
X$9445 57 1154 1155 749 847 1160 1156 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $9446 m0 *1 155.94,84.32
X$9446 73 726 1157 1204 73 1156 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9447 m0 *1 157.78,84.32
X$9447 73 907 631 1157 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9448 m0 *1 159.16,84.32
X$9448 73 1155 73 57 1158 57 sky130_fd_sc_hd__buf_4
* cell instance $9454 m0 *1 168.82,84.32
X$9454 73 1205 1113 686 73 1206 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9455 m0 *1 170.66,84.32
X$9455 73 1114 1208 1158 1207 1159 73 1210 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $9463 m0 *1 189.06,84.32
X$9463 73 726 1211 1212 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9470 m0 *1 198.72,84.32
X$9470 57 1299 632 913 1161 825 1472 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $9471 m0 *1 202.4,84.32
X$9471 73 632 845 1161 1214 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9477 m0 *1 210.68,84.32
X$9477 73 688 1044 1249 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9481 m0 *1 220.34,84.32
X$9481 73 1301 1302 1216 1548 57 1219 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $9484 m0 *1 224.48,84.32
X$9484 73 1219 73 57 1159 57 sky130_fd_sc_hd__buf_4
* cell instance $9499 m0 *1 258.98,84.32
X$9499 73 360 1072 791 57 73 1071 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9503 m0 *1 261.74,84.32
X$9503 73 533 693 1422 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9507 m0 *1 266.34,84.32
X$9507 57 423 694 533 1305 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $9511 m0 *1 275.08,84.32
X$9511 73 193 1307 1133 57 73 1227 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9517 m0 *1 286.12,84.32
X$9517 73 558 736 258 1229 57 1306 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $9520 m0 *1 288.88,84.32
X$9520 73 272 226 590 57 73 1229 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9525 m0 *1 300.38,84.32
X$9525 73 357 1000 1074 253 1168 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $9532 m0 *1 311.42,84.32
X$9532 73 434 225 590 57 73 1226 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9537 m0 *1 317.86,84.32
X$9537 73 921 775 193 1164 57 1163 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $9539 m0 *1 321.54,84.32
X$9539 73 272 963 594 1164 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9542 m0 *1 326.14,84.32
X$9542 73 1164 1223 923 73 1222 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9543 m0 *1 327.98,84.32
X$9543 73 1220 1222 968 57 73 1140 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9545 m0 *1 330.74,84.32
X$9545 73 772 921 1221 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9550 m0 *1 334.42,84.32
X$9550 73 193 1221 1166 1167 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $9551 m0 *1 336.26,84.32
X$9551 73 1220 1167 1168 57 73 1303 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9583 m0 *1 409.86,84.32
X$9583 57 15461 1215 1169 359 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $9593 m0 *1 427.34,84.32
X$9593 73 1169 199 1129 1077 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $9595 m0 *1 430.1,84.32
X$9595 73 545 1400 1170 1169 1128 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $9598 m0 *1 435.16,84.32
X$9598 73 159 73 57 1170 57 sky130_fd_sc_hd__buf_4
* cell instance $9601 m0 *1 440.68,84.32
X$9601 73 1004 159 1213 1127 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $9605 m0 *1 444.36,84.32
X$9605 73 165 1175 1254 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9606 m0 *1 445.74,84.32
X$9606 73 165 234 1171 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9607 m0 *1 447.12,84.32
X$9607 73 1004 199 1171 1203 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9608 m0 *1 448.96,84.32
X$9608 73 335 545 1172 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9611 m0 *1 450.34,84.32
X$9611 73 1172 73 57 703 57 sky130_fd_sc_hd__buf_4
* cell instance $9616 m0 *1 463.22,84.32
X$9616 73 1010 73 57 1202 57 sky130_fd_sc_hd__buf_4
* cell instance $9619 m0 *1 468.28,84.32
X$9619 73 1171 73 57 305 57 sky130_fd_sc_hd__buf_4
* cell instance $9625 m0 *1 475.18,84.32
X$9625 73 1173 73 57 457 57 sky130_fd_sc_hd__buf_4
* cell instance $9632 m0 *1 486.68,84.32
X$9632 73 870 234 706 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9634 m0 *1 488.98,84.32
X$9634 73 602 73 57 206 57 sky130_fd_sc_hd__buf_4
* cell instance $9635 m0 *1 491.74,84.32
X$9635 73 206 1174 870 73 412 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9636 m0 *1 493.58,84.32
X$9636 73 153 1175 460 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9639 m0 *1 496.34,84.32
X$9639 73 239 73 57 1174 57 sky130_fd_sc_hd__buf_4
* cell instance $9641 m0 *1 499.56,84.32
X$9641 73 1173 73 57 605 57 sky130_fd_sc_hd__buf_4
* cell instance $9660 m0 *1 539.58,84.32
X$9660 73 1089 928 1285 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9669 m0 *1 556.14,84.32
X$9669 57 1018 1284 1176 1188 1100 1095 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $9673 m0 *1 559.82,84.32
X$9673 73 1187 73 57 1087 57 sky130_fd_sc_hd__buf_4
* cell instance $9682 m0 *1 584.2,84.32
X$9682 73 1183 1181 1182 1177 57 73 1266 57 sky130_fd_sc_hd__a31oi_1
* cell instance $9685 m0 *1 586.5,84.32
X$9685 73 939 1178 1181 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9726 r0 *1 25.76,84.32
X$9726 73 1568 1144 1230 1268 57 1349 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $9730 r0 *1 33.58,84.32
X$9730 73 1102 896 1440 73 1272 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9732 r0 *1 36.34,84.32
X$9732 57 1277 1231 1272 1275 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $9734 r0 *1 40.94,84.32
X$9734 73 1276 978 1277 57 73 1273 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9741 r0 *1 49.22,84.32
X$9741 73 1278 73 57 1104 57 sky130_fd_sc_hd__buf_4
* cell instance $9742 r0 *1 51.98,84.32
X$9742 73 1104 1281 978 1101 57 1630 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $9743 r0 *1 54.74,84.32
X$9743 57 1282 1232 1190 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $9747 r0 *1 68.54,84.32
X$9747 73 1199 73 57 1101 57 sky130_fd_sc_hd__buf_4
* cell instance $9753 r0 *1 76.82,84.32
X$9753 73 978 1233 1234 1150 1444 1195 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $9754 r0 *1 80.04,84.32
X$9754 73 1236 1237 1150 73 1233 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9756 r0 *1 83.72,84.32
X$9756 73 1238 73 57 1237 57 sky130_fd_sc_hd__buf_4
* cell instance $9758 r0 *1 86.94,84.32
X$9758 73 1199 1152 1238 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9760 r0 *1 88.78,84.32
X$9760 73 1239 73 57 1198 57 sky130_fd_sc_hd__buf_4
* cell instance $9783 r0 *1 146.74,84.32
X$9783 73 658 726 1240 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9784 r0 *1 148.12,84.32
X$9784 73 733 1811 1241 73 1289 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9791 r0 *1 157.32,84.32
X$9791 73 1157 73 57 1290 57 sky130_fd_sc_hd__buf_4
* cell instance $9795 r0 *1 166.06,84.32
X$9795 73 733 1242 907 786 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9797 r0 *1 168.36,84.32
X$9797 73 847 907 1329 57 73 1064 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9798 r0 *1 170.2,84.32
X$9798 73 786 73 57 1291 57 sky130_fd_sc_hd__buf_4
* cell instance $9799 r0 *1 172.96,84.32
X$9799 73 1291 726 1065 57 73 1388 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9802 r0 *1 176.18,84.32
X$9802 73 907 1292 1240 1067 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9809 r0 *1 187.22,84.32
X$9809 73 1210 73 57 1591 57 sky130_fd_sc_hd__buf_4
* cell instance $9813 r0 *1 198.26,84.32
X$9813 73 686 1122 1244 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9814 r0 *1 199.64,84.32
X$9814 73 1245 1295 1244 1243 1293 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $9816 r0 *1 203.78,84.32
X$9816 73 1246 73 57 1296 57 sky130_fd_sc_hd__buf_4
* cell instance $9819 r0 *1 207.46,84.32
X$9819 73 1296 788 632 73 1248 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9821 r0 *1 209.76,84.32
X$9821 73 1247 1299 783 73 1398 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9823 r0 *1 212.52,84.32
X$9823 73 1160 1249 1248 57 73 1247 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9827 r0 *1 222.18,84.32
X$9827 73 685 728 1125 57 73 1301 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9842 r0 *1 260.36,84.32
X$9842 73 693 73 57 1250 57 sky130_fd_sc_hd__buf_4
* cell instance $9848 r0 *1 266.34,84.32
X$9848 73 636 587 1305 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9853 r0 *1 274.62,84.32
X$9853 73 856 835 1224 1307 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $9857 r0 *1 282.9,84.32
X$9857 73 775 480 225 360 1308 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $9858 r0 *1 285.66,84.32
X$9858 73 1251 590 258 1306 57 73 1409 57 sky130_fd_sc_hd__a31oi_1
* cell instance $9867 r0 *1 307.28,84.32
X$9867 73 622 73 57 1402 57 sky130_fd_sc_hd__buf_4
* cell instance $9868 r0 *1 310.04,84.32
X$9868 73 633 1003 622 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9869 r0 *1 311.42,84.32
X$9869 57 193 1408 258 1226 895 1406 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $9877 r0 *1 321.54,84.32
X$9877 73 357 1003 963 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $9879 r0 *1 324.3,84.32
X$9879 73 856 1336 1141 1223 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9883 r0 *1 335.34,84.32
X$9883 73 1304 1220 257 1303 57 1404 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $9916 r0 *1 413.54,84.32
X$9916 73 891 1298 1252 1004 1300 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $9917 r0 *1 416.3,84.32
X$9917 73 1252 73 57 1213 57 sky130_fd_sc_hd__buf_4
* cell instance $9918 r0 *1 419.06,84.32
X$9918 73 863 1006 1252 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9922 r0 *1 422.74,84.32
X$9922 73 1294 377 1253 57 73 1401 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9930 r0 *1 442.06,84.32
X$9930 73 1175 73 57 887 57 sky130_fd_sc_hd__buf_4
* cell instance $9931 r0 *1 444.82,84.32
X$9931 73 150 1254 1255 1394 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $9932 r0 *1 446.66,84.32
X$9932 73 1004 1172 865 57 73 1255 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9933 r0 *1 448.5,84.32
X$9933 73 1175 73 57 249 57 sky130_fd_sc_hd__buf_4
* cell instance $9936 r0 *1 453.1,84.32
X$9936 73 1203 73 57 1449 57 sky130_fd_sc_hd__buf_4
* cell instance $9938 r0 *1 456.32,84.32
X$9938 73 863 1004 1082 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9943 r0 *1 463.22,84.32
X$9943 73 765 1202 2100 57 73 1256 57 sky130_fd_sc_hd__a21oi_1
* cell instance $9945 r0 *1 465.98,84.32
X$9945 73 1381 73 57 448 57 sky130_fd_sc_hd__buf_4
* cell instance $9949 r0 *1 471.96,84.32
X$9949 73 706 73 57 1386 57 sky130_fd_sc_hd__buf_4
* cell instance $9951 r0 *1 475.64,84.32
X$9951 73 1257 1256 704 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $9953 r0 *1 477.02,84.32
X$9953 73 457 371 1381 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $9954 r0 *1 478.4,84.32
X$9954 73 503 1385 1382 73 1117 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9956 r0 *1 481.16,84.32
X$9956 73 457 73 57 1288 57 sky130_fd_sc_hd__buf_4
* cell instance $9960 r0 *1 485.76,84.32
X$9960 73 604 73 57 235 57 sky130_fd_sc_hd__buf_4
* cell instance $9962 r0 *1 490.36,84.32
X$9962 73 1085 73 57 1258 57 sky130_fd_sc_hd__buf_4
* cell instance $9964 r0 *1 493.58,84.32
X$9964 73 817 1375 604 1258 1175 1445 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $9966 r0 *1 497.26,84.32
X$9966 57 206 1260 551 239 305 1259 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $9967 r0 *1 500.48,84.32
X$9967 73 206 703 1675 1259 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $9969 r0 *1 502.78,84.32
X$9969 73 1260 73 57 1257 57 sky130_fd_sc_hd__buf_4
* cell instance $9979 r0 *1 529.92,84.32
X$9979 73 1014 1013 1183 1372 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $9989 r0 *1 546.02,84.32
X$9989 73 1286 1365 1368 73 1343 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $9991 r0 *1 551.54,84.32
X$9991 73 1284 73 57 1261 57 sky130_fd_sc_hd__buf_4
* cell instance $9997 r0 *1 566.26,84.32
X$9997 73 1014 1187 1188 1361 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10001 r0 *1 569.94,84.32
X$10001 73 1262 928 1187 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10004 r0 *1 573.62,84.32
X$10004 73 1629 1280 1018 1263 57 73 1265 57 sky130_fd_sc_hd__a31oi_1
* cell instance $10007 r0 *1 577.3,84.32
X$10007 73 1346 1263 1091 1264 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10008 r0 *1 579.14,84.32
X$10008 73 1262 1092 1183 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10011 r0 *1 583.28,84.32
X$10011 73 1182 1265 1266 73 1274 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10014 r0 *1 588.8,84.32
X$10014 57 1270 874 1269 1264 1267 1271 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $10050 m0 *1 22.54,89.76
X$10050 73 978 1349 1200 1309 1348 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $10053 m0 *1 26.68,89.76
X$10053 73 1350 1275 1144 1351 57 1147 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $10057 m0 *1 30.82,89.76
X$10057 73 1460 73 57 1144 57 sky130_fd_sc_hd__buf_4
* cell instance $10059 m0 *1 34.5,89.76
X$10059 73 1312 1275 1272 57 73 1310 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10060 m0 *1 36.34,89.76
X$10060 73 978 1310 1311 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10061 m0 *1 37.72,89.76
X$10061 73 1311 1354 1144 1313 57 73 1355 57 sky130_fd_sc_hd__a31oi_1
* cell instance $10063 m0 *1 40.48,89.76
X$10063 73 1275 1278 1096 57 73 1312 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10068 m0 *1 49.68,89.76
X$10068 73 1025 1358 1314 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10069 m0 *1 51.06,89.76
X$10069 73 1314 73 57 1281 57 sky130_fd_sc_hd__buf_4
* cell instance $10074 m0 *1 59.34,89.76
X$10074 73 1573 901 1315 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10076 m0 *1 61.18,89.76
X$10076 73 1359 1189 1107 1315 73 1360 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $10080 m0 *1 69.46,89.76
X$10080 73 980 1235 1316 1287 985 1362 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $10085 m0 *1 74.98,89.76
X$10085 73 1363 73 57 1236 57 sky130_fd_sc_hd__buf_4
* cell instance $10086 m0 *1 77.74,89.76
X$10086 73 1317 1318 1364 1236 981 1234 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $10092 m0 *1 87.86,89.76
X$10092 73 1239 73 57 1366 57 sky130_fd_sc_hd__buf_4
* cell instance $10093 m0 *1 90.62,89.76
X$10093 73 897 1238 1367 57 73 1319 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10095 m0 *1 92.92,89.76
X$10095 73 988 1366 1516 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10096 m0 *1 94.3,89.76
X$10096 73 1198 1416 897 1319 57 73 1320 57 sky130_fd_sc_hd__a31oi_1
* cell instance $10097 m0 *1 96.6,89.76
X$10097 73 1321 1320 1287 981 1370 1322 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $10101 m0 *1 101.66,89.76
X$10101 73 1322 73 57 1200 57 sky130_fd_sc_hd__buf_4
* cell instance $10115 m0 *1 137.08,89.76
X$10115 57 1376 1323 1378 1377 1374 1324 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $10117 m0 *1 140.76,89.76
X$10117 73 1325 1326 781 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $10118 m0 *1 143.06,89.76
X$10118 73 1525 1240 1377 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10122 m0 *1 150.88,89.76
X$10122 73 749 728 1327 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10125 m0 *1 152.26,89.76
X$10125 57 1380 1327 1241 1323 1034 1391 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $10127 m0 *1 157.32,89.76
X$10127 73 1328 726 1201 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10130 m0 *1 161,89.76
X$10130 73 1201 1292 1329 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10135 m0 *1 170.2,89.76
X$10135 73 907 1329 728 73 1383 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10142 m0 *1 178.94,89.76
X$10142 73 1330 1325 688 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10143 m0 *1 180.32,89.76
X$10143 73 1326 73 57 1330 57 sky130_fd_sc_hd__buf_4
* cell instance $10144 m0 *1 183.08,89.76
X$10144 73 1331 1325 787 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10145 m0 *1 184.46,89.76
X$10145 73 726 787 845 1387 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10147 m0 *1 188.14,89.76
X$10147 73 1295 1388 1332 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10152 m0 *1 195.96,89.76
X$10152 73 1332 1536 1389 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10153 m0 *1 197.34,89.76
X$10153 73 1389 783 1323 1390 57 2142 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $10154 m0 *1 200.1,89.76
X$10154 73 1293 1391 1392 57 73 1390 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10161 m0 *1 211.6,89.76
X$10161 57 1395 1160 1396 849 1333 1398 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $10163 m0 *1 216.2,89.76
X$10163 73 1211 726 996 1240 57 1399 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $10181 m0 *1 256.68,89.76
X$10181 73 856 1250 1402 1457 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $10186 m0 *1 263.12,89.76
X$10186 73 1403 73 57 1074 57 sky130_fd_sc_hd__buf_4
* cell instance $10190 m0 *1 271.86,89.76
X$10190 73 272 915 1334 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10192 m0 *1 274.16,89.76
X$10192 73 363 1227 193 1335 1334 1405 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $10196 m0 *1 279.22,89.76
X$10196 73 772 587 1250 856 1335 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $10204 m0 *1 294.4,89.76
X$10204 73 363 1456 1411 1410 857 73 290 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $10212 m0 *1 311.42,89.76
X$10212 57 272 1406 193 963 1336 1407 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $10254 m0 *1 408.02,89.76
X$10254 57 1429 1337 1004 359 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $10256 m0 *1 413.08,89.76
X$10256 57 1338 1253 1482 1298 1215 1337 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $10258 m0 *1 416.76,89.76
X$10258 73 153 1298 473 73 1297 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10260 m0 *1 419.52,89.76
X$10260 73 1339 891 1169 57 73 1451 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10266 m0 *1 424.58,89.76
X$10266 73 1549 73 57 190 57 sky130_fd_sc_hd__buf_4
* cell instance $10268 m0 *1 431.02,89.76
X$10268 73 1340 73 57 1400 57 sky130_fd_sc_hd__buf_4
* cell instance $10271 m0 *1 436.54,89.76
X$10271 73 1339 1340 720 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10273 m0 *1 439.76,89.76
X$10273 73 863 887 384 73 1397 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10277 m0 *1 444.36,89.76
X$10277 73 741 1254 1255 371 73 57 1393 57 sky130_fd_sc_hd__o31ai_1
* cell instance $10278 m0 *1 447.12,89.76
X$10278 73 1004 1006 1175 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10283 m0 *1 455.86,89.76
X$10283 73 1009 73 57 1004 57 sky130_fd_sc_hd__buf_4
* cell instance $10286 m0 *1 460,89.76
X$10286 73 1173 371 1448 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10287 m0 *1 461.38,89.76
X$10287 73 601 266 1340 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10294 m0 *1 472.88,89.76
X$10294 73 359 1386 1381 73 1487 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10299 m0 *1 477.48,89.76
X$10299 73 359 1173 1384 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10300 m0 *1 478.86,89.76
X$10300 73 1384 343 1288 57 73 1385 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10303 m0 *1 485.3,89.76
X$10303 73 335 1175 1381 1028 1379 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $10305 m0 *1 491.74,89.76
X$10305 73 1340 73 57 1375 57 sky130_fd_sc_hd__buf_4
* cell instance $10307 m0 *1 495.42,89.76
X$10307 73 951 73 57 1373 57 sky130_fd_sc_hd__buf_4
* cell instance $10323 m0 *1 530.84,89.76
X$10323 73 1182 1341 1371 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10328 m0 *1 533.6,89.76
X$10328 73 1018 1090 929 57 73 1341 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10331 m0 *1 539.58,89.76
X$10331 73 1018 1283 1285 1900 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $10334 m0 *1 546.02,89.76
X$10334 73 1342 73 57 1368 57 sky130_fd_sc_hd__buf_4
* cell instance $10335 m0 *1 548.78,89.76
X$10335 73 1369 1344 1099 73 1365 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10341 m0 *1 557.98,89.76
X$10341 73 1345 1092 1188 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10350 m0 *1 575.46,89.76
X$10350 73 1344 1262 1092 57 73 1263 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10355 m0 *1 583.28,89.76
X$10355 73 1356 1274 1270 57 73 1357 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10360 m0 *1 589.26,89.76
X$10360 57 1353 1352 1346 1347 874 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $10361 m0 *1 592.48,89.76
X$10361 73 1283 1504 1285 1618 872 1347 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $10401 r0 *1 27.14,89.76
X$10401 73 1732 896 1440 73 1350 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10404 r0 *1 31.28,89.76
X$10404 73 1689 73 57 1096 57 sky130_fd_sc_hd__buf_4
* cell instance $10407 r0 *1 38.64,89.76
X$10407 73 1626 1412 1414 73 1354 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10408 r0 *1 40.48,89.76
X$10408 73 1413 979 1415 971 978 73 1276 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $10412 r0 *1 45.08,89.76
X$10412 73 1414 73 57 1097 57 sky130_fd_sc_hd__buf_4
* cell instance $10414 r0 *1 48.3,89.76
X$10414 73 1358 1363 1101 57 73 1412 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10415 r0 *1 50.14,89.76
X$10415 73 979 1314 1508 971 1097 73 1631 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $10427 r0 *1 74.52,89.76
X$10427 73 985 1196 1463 1415 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10428 r0 *1 76.36,89.76
X$10428 73 985 1463 1443 73 1444 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $10431 r0 *1 84.64,89.76
X$10431 73 897 981 1364 1317 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $10432 r0 *1 86.48,89.76
X$10432 73 1199 73 57 981 57 sky130_fd_sc_hd__buf_4
* cell instance $10435 r0 *1 92,89.76
X$10435 73 1238 73 57 1446 57 sky130_fd_sc_hd__buf_4
* cell instance $10438 r0 *1 96.14,89.76
X$10438 73 988 1446 1189 1416 1518 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $10456 r0 *1 138.92,89.76
X$10456 73 907 1465 1374 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10461 r0 *1 151.34,89.76
X$10461 73 1327 73 57 783 57 sky130_fd_sc_hd__buf_4
* cell instance $10465 r0 *1 157.32,89.76
X$10465 73 733 1242 1418 1417 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10466 r0 *1 159.16,89.76
X$10466 73 1417 73 57 1292 57 sky130_fd_sc_hd__buf_4
* cell instance $10470 r0 *1 165.14,89.76
X$10470 73 785 73 57 1328 57 sky130_fd_sc_hd__buf_4
* cell instance $10477 r0 *1 180.32,89.76
X$10477 73 1331 785 1419 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10480 r0 *1 183.08,89.76
X$10480 73 1419 73 57 1211 57 sky130_fd_sc_hd__buf_4
* cell instance $10481 r0 *1 185.84,89.76
X$10481 73 1205 1245 1387 1912 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $10485 r0 *1 197.34,89.76
X$10485 73 726 1420 688 57 73 1470 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10486 r0 *1 199.18,89.76
X$10486 73 1418 1420 1421 825 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $10489 r0 *1 202.4,89.76
X$10489 73 1453 73 57 845 57 sky130_fd_sc_hd__buf_4
* cell instance $10490 r0 *1 205.16,89.76
X$10490 73 781 73 57 1471 57 sky130_fd_sc_hd__buf_4
* cell instance $10510 r0 *1 252.08,89.76
X$10510 73 791 1250 1554 360 258 73 1556 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $10514 r0 *1 258.52,89.76
X$10514 73 1308 1457 1556 258 257 73 1559 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $10520 r0 *1 265.42,89.76
X$10520 73 1422 1423 253 73 1560 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10524 r0 *1 273.24,89.76
X$10524 73 272 471 999 57 73 1423 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10527 r0 *1 276.46,89.76
X$10527 73 923 1405 223 57 73 1563 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10528 r0 *1 278.3,89.76
X$10528 73 856 1424 1251 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10538 r0 *1 294.86,89.76
X$10538 73 775 1425 1456 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10542 r0 *1 301.3,89.76
X$10542 73 856 1003 1228 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10543 r0 *1 302.68,89.76
X$10543 73 363 1049 1425 57 73 1565 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10547 r0 *1 307.74,89.76
X$10547 73 970 73 57 422 57 sky130_fd_sc_hd__buf_4
* cell instance $10553 r0 *1 317.4,89.76
X$10553 73 856 344 999 1564 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $10558 r0 *1 322.92,89.76
X$10558 73 594 73 57 1454 57 sky130_fd_sc_hd__buf_4
* cell instance $10559 r0 *1 325.68,89.76
X$10559 73 636 258 691 73 1641 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10560 r0 *1 327.52,89.76
X$10560 73 471 73 57 1426 57 sky130_fd_sc_hd__buf_4
* cell instance $10561 r0 *1 330.28,89.76
X$10561 73 1426 422 856 193 57 73 1561 57 sky130_fd_sc_hd__a31oi_1
* cell instance $10563 r0 *1 334.42,89.76
X$10563 73 1558 625 257 1404 57 73 1557 57 sky130_fd_sc_hd__a31oi_1
* cell instance $10596 r0 *1 409.4,89.76
X$10596 57 1552 1217 1524 1551 1452 374 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $10597 r0 *1 412.62,89.76
X$10597 57 1452 1297 1427 173 1004 489 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $10598 r0 *1 415.84,89.76
X$10598 73 1006 73 57 1298 57 sky130_fd_sc_hd__buf_4
* cell instance $10601 r0 *1 419.98,89.76
X$10601 73 1451 1533 1429 1339 73 1428 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $10603 r0 *1 422.74,89.76
X$10603 73 1169 1213 1450 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10604 r0 *1 424.12,89.76
X$10604 73 1169 1549 1450 118 1430 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $10607 r0 *1 428.26,89.76
X$10607 73 1339 1400 1547 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10613 r0 *1 438.38,89.76
X$10613 57 1431 1538 1430 1541 1397 614 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $10616 r0 *1 443.9,89.76
X$10616 73 1126 1394 768 73 1539 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10622 r0 *1 452.64,89.76
X$10622 73 1428 1432 283 1449 1532 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $10623 r0 *1 454.94,89.76
X$10623 73 1431 73 57 1432 57 sky130_fd_sc_hd__buf_4
* cell instance $10625 r0 *1 458.16,89.76
X$10625 73 1448 73 57 1431 57 sky130_fd_sc_hd__buf_4
* cell instance $10626 r0 *1 460.92,89.76
X$10626 73 1448 73 57 173 57 sky130_fd_sc_hd__buf_4
* cell instance $10628 r0 *1 464.14,89.76
X$10628 73 1169 675 956 57 73 1526 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10638 r0 *1 487.6,89.76
X$10638 57 1447 270 1432 1373 1379 1433 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $10640 r0 *1 492.2,89.76
X$10640 73 1520 1288 1445 57 73 1521 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10642 r0 *1 494.96,89.76
X$10642 73 650 270 462 956 73 1433 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $10644 r0 *1 497.72,89.76
X$10644 73 1519 73 57 650 57 sky130_fd_sc_hd__buf_4
* cell instance $10664 r0 *1 541.88,89.76
X$10664 73 1345 1092 1280 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10667 r0 *1 547.86,89.76
X$10667 73 940 1369 1018 73 2174 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10676 r0 *1 570.4,89.76
X$10676 73 1090 1280 1014 1442 57 73 1435 57 sky130_fd_sc_hd__a31oi_1
* cell instance $10679 r0 *1 575,89.76
X$10679 73 1177 1182 1435 1628 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $10687 r0 *1 596.16,89.76
X$10687 73 1271 73 57 1441 57 sky130_fd_sc_hd__buf_4
* cell instance $10690 r0 *1 603.06,89.76
X$10690 73 1436 1439 1092 73 1271 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10695 r0 *1 611.8,89.76
X$10695 73 1438 1269 1437 57 73 1499 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10724 m0 *1 21.62,95.2
X$10724 73 1498 73 57 978 57 sky130_fd_sc_hd__buf_4
* cell instance $10726 m0 *1 24.84,95.2
X$10726 73 1458 73 57 1107 57 sky130_fd_sc_hd__buf_4
* cell instance $10727 m0 *1 27.6,95.2
X$10727 73 1459 1502 1351 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10734 m0 *1 37.26,95.2
X$10734 73 1055 1506 1507 57 73 1230 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10740 m0 *1 44.16,95.2
X$10740 73 896 1459 1278 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $10742 m0 *1 47.38,95.2
X$10742 73 1363 1358 1458 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10743 m0 *1 48.76,95.2
X$10743 73 1461 73 57 1358 57 sky130_fd_sc_hd__buf_4
* cell instance $10745 m0 *1 51.98,95.2
X$10745 73 1102 1358 1462 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10746 m0 *1 53.36,95.2
X$10746 73 971 1443 1462 1508 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10748 m0 *1 55.66,95.2
X$10748 73 1101 1413 1509 1632 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $10751 m0 *1 58.88,95.2
X$10751 73 1510 73 57 1443 57 sky130_fd_sc_hd__buf_4
* cell instance $10755 m0 *1 67.62,95.2
X$10755 73 1513 1443 981 73 1512 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10768 m0 *1 92.46,95.2
X$10768 73 1459 1446 1516 73 1515 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10770 m0 *1 95.22,95.2
X$10770 73 1460 73 57 1416 57 sky130_fd_sc_hd__buf_4
* cell instance $10790 m0 *1 140.76,95.2
X$10790 73 685 1523 1522 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10792 m0 *1 143.06,95.2
X$10792 73 846 907 1525 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10798 m0 *1 152.26,95.2
X$10798 73 1464 1113 997 1465 73 2092 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $10801 m0 *1 162.38,95.2
X$10801 73 1585 1325 748 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10802 m0 *1 163.76,95.2
X$10802 73 748 73 57 1528 57 sky130_fd_sc_hd__buf_4
* cell instance $10806 m0 *1 168.36,95.2
X$10806 73 1211 907 1418 1291 57 2030 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $10807 m0 *1 171.12,95.2
X$10807 73 1331 907 1468 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10809 m0 *1 174.34,95.2
X$10809 73 907 1292 1660 1466 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10810 m0 *1 176.18,95.2
X$10810 73 1466 1529 907 57 73 1467 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10815 m0 *1 179.4,95.2
X$10815 73 1160 1066 1467 57 73 1530 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10817 m0 *1 181.7,95.2
X$10817 73 1468 73 57 1420 57 sky130_fd_sc_hd__buf_4
* cell instance $10822 m0 *1 194.12,95.2
X$10822 73 1469 686 1534 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10825 m0 *1 196.88,95.2
X$10825 73 1537 733 1391 1470 57 1536 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $10828 m0 *1 203.78,95.2
X$10828 57 15502 1469 1418 733 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $10832 m0 *1 209.3,95.2
X$10832 73 1543 1522 955 73 1545 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10834 m0 *1 212.98,95.2
X$10834 73 728 1472 1545 1546 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $10836 m0 *1 216.66,95.2
X$10836 73 1469 996 728 73 1473 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10838 m0 *1 220.34,95.2
X$10838 73 1662 1125 1473 73 57 1548 57 sky130_fd_sc_hd__o21bai_1
* cell instance $10853 m0 *1 253,95.2
X$10853 73 1592 360 1554 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10854 m0 *1 254.38,95.2
X$10854 73 257 1593 348 362 360 1555 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $10860 m0 *1 262.66,95.2
X$10860 73 1422 73 57 1474 57 sky130_fd_sc_hd__buf_4
* cell instance $10864 m0 *1 270.48,95.2
X$10864 57 258 1562 1477 694 1646 1225 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $10866 m0 *1 274.62,95.2
X$10866 73 915 348 1476 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10867 m0 *1 276,95.2
X$10867 73 1475 1424 363 1474 57 1162 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $10869 m0 *1 278.76,95.2
X$10869 73 272 226 224 57 73 1475 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10872 m0 *1 286.12,95.2
X$10872 73 360 1476 1566 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10877 m0 *1 292.1,95.2
X$10877 73 1645 73 57 1336 57 sky130_fd_sc_hd__buf_4
* cell instance $10881 m0 *1 303.14,95.2
X$10881 73 1565 1566 1477 1478 57 2795 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $10885 m0 *1 308.66,95.2
X$10885 73 1402 1250 1644 272 258 73 1757 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $10886 m0 *1 311.88,95.2
X$10886 73 736 587 1141 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10892 m0 *1 321.54,95.2
X$10892 73 856 423 837 1479 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $10894 m0 *1 324.3,95.2
X$10894 73 856 779 1336 1479 73 57 1480 57 sky130_fd_sc_hd__o31ai_1
* cell instance $10898 m0 *1 330.28,95.2
X$10898 73 2050 1561 1480 193 258 1558 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $10900 m0 *1 333.96,95.2
X$10900 73 258 1166 1640 57 73 1478 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10902 m0 *1 336.72,95.2
X$10902 73 1557 73 57 2817 57 sky130_fd_sc_hd__buf_4
* cell instance $10935 m0 *1 407.1,95.2
X$10935 73 1218 1552 1481 1553 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $10939 m0 *1 412.62,95.2
X$10939 73 359 863 1298 73 1482 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10941 m0 *1 414.92,95.2
X$10941 73 1338 1482 1550 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10949 m0 *1 428.26,95.2
X$10949 73 1169 369 1547 1542 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10950 m0 *1 430.1,95.2
X$10950 73 1544 1542 118 73 1540 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10954 m0 *1 439.76,95.2
X$10954 73 359 1169 1675 57 73 1541 57 sky130_fd_sc_hd__a21oi_1
* cell instance $10959 m0 *1 444.82,95.2
X$10959 73 1674 1539 1481 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10962 m0 *1 447.58,95.2
X$10962 73 1483 249 1484 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10963 m0 *1 448.96,95.2
X$10963 73 371 618 1484 1535 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10967 m0 *1 451.26,95.2
X$10967 73 266 73 57 1427 57 sky130_fd_sc_hd__buf_4
* cell instance $10970 m0 *1 456.32,95.2
X$10970 73 1173 73 57 765 57 sky130_fd_sc_hd__buf_4
* cell instance $10971 m0 *1 459.08,95.2
X$10971 73 1485 545 675 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $10974 m0 *1 461.84,95.2
X$10974 73 1483 1169 1338 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $10975 m0 *1 463.22,95.2
X$10975 73 765 1638 1485 1527 57 73 1382 57 sky130_fd_sc_hd__a31oi_1
* cell instance $10976 m0 *1 465.52,95.2
X$10976 73 1483 863 1173 1527 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $10980 m0 *1 471.96,95.2
X$10980 73 1338 73 57 1486 57 sky130_fd_sc_hd__buf_4
* cell instance $10982 m0 *1 475.18,95.2
X$10982 73 1487 1486 153 489 73 1909 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $10989 m0 *1 485.3,95.2
X$10989 73 1521 73 57 1524 57 sky130_fd_sc_hd__buf_4
* cell instance $10992 m0 *1 489.44,95.2
X$10992 73 207 73 57 359 57 sky130_fd_sc_hd__buf_4
* cell instance $10993 m0 *1 492.2,95.2
X$10993 73 1288 1809 551 73 1520 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $10994 m0 *1 494.04,95.2
X$10994 73 1488 73 57 551 57 sky130_fd_sc_hd__buf_4
* cell instance $10995 m0 *1 496.8,95.2
X$10995 73 949 1488 1519 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11014 m0 *1 531.3,95.2
X$11014 73 1489 1090 1106 1490 1517 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $11019 m0 *1 540.96,95.2
X$11019 73 1489 1092 1283 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11031 m0 *1 566.26,95.2
X$11031 73 1491 928 1492 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11032 m0 *1 567.64,95.2
X$11032 73 1018 1492 940 1493 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $11033 m0 *1 569.48,95.2
X$11033 73 1361 1493 1490 73 1494 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11035 m0 *1 572.24,95.2
X$11035 73 1014 1492 1495 1442 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $11046 m0 *1 589.26,95.2
X$11046 73 1504 1100 1505 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $11048 m0 *1 592.48,95.2
X$11048 73 1497 73 57 872 57 sky130_fd_sc_hd__buf_4
* cell instance $11051 m0 *1 599.84,95.2
X$11051 73 939 1497 1439 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11054 m0 *1 602.6,95.2
X$11054 73 1496 1500 1503 1499 57 1501 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $11091 r0 *1 23.46,95.2
X$11091 57 1458 1623 1275 1509 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $11092 r0 *1 25.76,95.2
X$11092 73 1567 1502 1509 73 1568 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11095 r0 *1 28.98,95.2
X$11095 73 1055 896 1570 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11096 r0 *1 30.36,95.2
X$11096 73 1569 1570 971 73 1695 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11097 r0 *1 32.2,95.2
X$11097 73 1461 1093 1567 57 73 1569 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11100 r0 *1 35.42,95.2
X$11100 73 1569 73 57 1231 57 sky130_fd_sc_hd__buf_4
* cell instance $11101 r0 *1 38.18,95.2
X$11101 73 1647 1506 1626 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11103 r0 *1 40.02,95.2
X$11103 73 1275 1461 1506 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11112 r0 *1 51.98,95.2
X$11112 73 1572 1631 1630 1571 73 57 1654 57 sky130_fd_sc_hd__o31ai_1
* cell instance $11113 r0 *1 54.74,95.2
X$11113 73 1511 73 57 1098 57 sky130_fd_sc_hd__buf_4
* cell instance $11116 r0 *1 58.88,95.2
X$11116 57 1101 1575 1574 1652 1462 1632 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $11119 r0 *1 64.4,95.2
X$11119 73 934 1512 1634 1511 57 73 1576 57 sky130_fd_sc_hd__a31oi_1
* cell instance $11120 r0 *1 66.7,95.2
X$11120 73 1575 1576 1636 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11122 r0 *1 68.54,95.2
X$11122 73 1513 73 57 1279 57 sky130_fd_sc_hd__buf_4
* cell instance $11130 r0 *1 83.72,95.2
X$11130 73 1370 1317 1507 57 73 1578 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11134 r0 *1 88.78,95.2
X$11134 57 2131 1102 1579 1572 1370 901 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $11135 r0 *1 92.46,95.2
X$11135 57 1579 1582 1577 1578 1515 1416 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $11137 r0 *1 96.14,95.2
X$11137 73 985 1460 1580 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11140 r0 *1 97.52,95.2
X$11140 73 1581 1580 1321 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11144 r0 *1 101.66,95.2
X$11144 73 1582 1581 1707 1637 57 1708 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $11168 r0 *1 155.94,95.2
X$11168 73 1584 907 732 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11169 r0 *1 157.32,95.2
X$11169 73 1528 1583 1113 1716 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $11172 r0 *1 160.54,95.2
X$11172 73 733 1585 631 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11176 r0 *1 169.74,95.2
X$11176 73 875 1468 1658 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11177 r0 *1 171.12,95.2
X$11177 57 15582 1529 726 1584 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $11178 r0 *1 175.72,95.2
X$11178 73 1030 1587 1586 1718 73 1455 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $11179 r0 *1 178.02,95.2
X$11179 73 1209 1208 1588 57 73 1586 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11182 r0 *1 179.86,95.2
X$11182 73 1590 1530 1589 1587 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $11185 r0 *1 182.62,95.2
X$11185 73 847 1911 754 1589 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $11186 r0 *1 184.46,95.2
X$11186 73 1245 1534 686 1531 1719 1590 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $11194 r0 *1 206.54,95.2
X$11194 73 1721 1661 684 1472 1642 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $11196 r0 *1 209.76,95.2
X$11196 73 726 1583 688 57 73 1661 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11198 r0 *1 212.06,95.2
X$11198 73 1642 1591 1546 1395 73 1643 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $11212 r0 *1 245.18,95.2
X$11212 57 15620 1592 690 480 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $11215 r0 *1 251.16,95.2
X$11215 73 856 1592 1474 193 57 2014 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $11218 r0 *1 255.3,95.2
X$11218 73 1594 360 1593 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11219 r0 *1 256.68,95.2
X$11219 73 363 1555 1595 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11230 r0 *1 273.7,95.2
X$11230 73 856 1224 1596 1646 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $11232 r0 *1 276,95.2
X$11232 73 857 480 1645 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11241 r0 *1 294.4,95.2
X$11241 73 1596 1755 272 257 1411 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $11245 r0 *1 303.6,95.2
X$11245 73 970 73 57 2193 57 sky130_fd_sc_hd__buf_4
* cell instance $11247 r0 *1 310.04,95.2
X$11247 73 272 1597 1141 1644 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $11248 r0 *1 311.88,95.2
X$11248 73 272 633 1599 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11253 r0 *1 316.02,95.2
X$11253 57 1598 856 1597 963 1564 1477 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $11257 r0 *1 324.3,95.2
X$11257 73 1141 257 1454 57 73 1724 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11258 r0 *1 326.14,95.2
X$11258 73 587 1641 1723 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11260 r0 *1 331.2,95.2
X$11260 73 1137 1599 587 73 1600 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11263 r0 *1 335.34,95.2
X$11263 73 775 1003 1426 272 1640 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $11298 r0 *1 414.46,95.2
X$11298 57 798 371 1671 1550 1601 741 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $11299 r0 *1 418.14,95.2
X$11299 73 371 1602 1601 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11300 r0 *1 419.52,95.2
X$11300 73 1427 1339 1672 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11301 r0 *1 420.9,95.2
X$11301 73 1638 354 958 1639 73 57 1602 57 sky130_fd_sc_hd__o31ai_1
* cell instance $11305 r0 *1 427.34,95.2
X$11305 73 1006 73 57 1339 57 sky130_fd_sc_hd__buf_4
* cell instance $11312 r0 *1 445.74,95.2
X$11312 73 831 73 57 767 57 sky130_fd_sc_hd__buf_4
* cell instance $11314 r0 *1 448.96,95.2
X$11314 73 1540 1604 1447 374 57 73 1603 57 sky130_fd_sc_hd__a31oi_1
* cell instance $11317 r0 *1 451.26,95.2
X$11317 73 264 248 545 1709 1605 1604 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $11324 r0 *1 459.54,95.2
X$11324 73 1485 1638 545 73 1605 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11328 r0 *1 467.36,95.2
X$11328 73 1606 1607 1526 767 1703 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $11331 r0 *1 472.42,95.2
X$11331 73 1487 73 57 1607 57 sky130_fd_sc_hd__buf_4
* cell instance $11336 r0 *1 482.54,95.2
X$11336 73 615 73 57 343 57 sky130_fd_sc_hd__buf_4
* cell instance $11339 r0 *1 486.22,95.2
X$11339 73 870 234 1673 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11340 r0 *1 487.6,95.2
X$11340 73 1009 1673 1174 73 1606 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $11341 r0 *1 490.36,95.2
X$11341 73 209 73 57 870 57 sky130_fd_sc_hd__buf_4
* cell instance $11358 r0 *1 530.84,95.2
X$11358 73 1489 928 1608 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11361 r0 *1 532.22,95.2
X$11361 73 1608 73 57 930 57 sky130_fd_sc_hd__buf_4
* cell instance $11365 r0 *1 540.96,95.2
X$11365 73 1988 1344 1635 73 1609 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11366 r0 *1 542.8,95.2
X$11366 73 1610 1609 1612 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11368 r0 *1 544.64,95.2
X$11368 73 872 1514 1285 57 73 1610 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11369 r0 *1 546.48,95.2
X$11369 73 1612 1343 1613 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11372 r0 *1 553.38,95.2
X$11372 73 1505 1614 1633 1611 57 73 1496 57 sky130_fd_sc_hd__a31oi_1
* cell instance $11373 r0 *1 555.68,95.2
X$11373 73 928 1436 1614 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11378 r0 *1 559.82,95.2
X$11378 73 1176 73 57 1635 57 sky130_fd_sc_hd__buf_4
* cell instance $11383 r0 *1 572.24,95.2
X$11383 73 1262 1092 1495 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11385 r0 *1 577.3,95.2
X$11385 73 937 1628 1698 1627 57 73 1694 57 sky130_fd_sc_hd__a31oi_1
* cell instance $11391 r0 *1 587.42,95.2
X$11391 73 1615 1353 1792 73 1617 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11392 r0 *1 589.26,95.2
X$11392 73 1616 1092 1618 73 931 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11397 r0 *1 596.62,95.2
X$11397 73 1617 73 57 1625 57 sky130_fd_sc_hd__buf_4
* cell instance $11398 r0 *1 599.38,95.2
X$11398 73 1494 73 57 1791 57 sky130_fd_sc_hd__buf_4
* cell instance $11399 r0 *1 602.14,95.2
X$11399 57 1690 1619 1624 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $11405 r0 *1 612.72,95.2
X$11405 57 1500 1621 1092 1182 1620 1622 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $11454 m0 *1 21.62,100.64
X$11454 73 1634 73 57 1688 57 sky130_fd_sc_hd__buf_4
* cell instance $11457 m0 *1 27.14,100.64
X$11457 73 1414 1146 1634 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11458 m0 *1 28.52,100.64
X$11458 73 1459 1461 1689 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11460 m0 *1 30.36,100.64
X$11460 73 1693 1696 1695 57 73 1692 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11461 m0 *1 32.2,100.64
X$11461 73 1647 1235 1696 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11466 m0 *1 45.54,100.64
X$11466 73 1648 73 57 1507 57 sky130_fd_sc_hd__buf_4
* cell instance $11467 m0 *1 48.3,100.64
X$11467 73 1567 1105 1648 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11468 m0 *1 49.68,100.64
X$11468 73 1649 986 1567 57 73 1650 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11469 m0 *1 51.52,100.64
X$11469 73 1650 73 57 1318 57 sky130_fd_sc_hd__buf_4
* cell instance $11475 m0 *1 59.8,100.64
X$11475 73 1651 1699 1652 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11477 m0 *1 62.1,100.64
X$11477 73 1652 73 57 1700 57 sky130_fd_sc_hd__buf_4
* cell instance $11483 m0 *1 78.2,100.64
X$11483 73 1414 73 57 1581 57 sky130_fd_sc_hd__buf_4
* cell instance $11490 m0 *1 90.62,100.64
X$11490 73 2022 73 57 1196 57 sky130_fd_sc_hd__buf_4
* cell instance $11493 m0 *1 94.76,100.64
X$11493 73 1102 1446 1653 1416 1704 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $11497 m0 *1 102.58,100.64
X$11497 73 1706 73 57 1707 57 sky130_fd_sc_hd__buf_4
* cell instance $11498 m0 *1 105.34,100.64
X$11498 73 1705 1654 1708 1740 1655 73 1806 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $11512 m0 *1 140.76,100.64
X$11512 73 1523 1711 1715 846 1710 1656 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $11517 m0 *1 150.88,100.64
X$11517 73 1656 783 1391 1376 57 73 1714 57 sky130_fd_sc_hd__a31oi_1
* cell instance $11521 m0 *1 156.4,100.64
X$11521 73 846 1715 1716 728 1813 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $11527 m0 *1 168.36,100.64
X$11527 73 1418 1658 1325 1205 73 1745 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $11532 m0 *1 184,100.64
X$11532 73 1584 726 1719 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11534 m0 *1 186.3,100.64
X$11534 73 733 1585 1325 73 1421 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11542 m0 *1 206.08,100.64
X$11542 73 1722 914 686 57 73 1721 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11546 m0 *1 216.2,100.64
X$11546 73 1295 1323 1662 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11549 m0 *1 218.96,100.64
X$11549 73 749 1048 1396 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11564 m0 *1 251.62,100.64
X$11564 57 15491 1594 633 587 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $11567 m0 *1 258.52,100.64
X$11567 73 1224 1424 360 258 1728 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $11569 m0 *1 264.96,100.64
X$11569 73 1305 226 360 1663 57 73 1729 57 sky130_fd_sc_hd__a31oi_1
* cell instance $11574 m0 *1 276,100.64
X$11574 73 272 835 1645 1663 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $11581 m0 *1 287.5,100.64
X$11581 73 1562 1664 923 253 57 73 1754 57 sky130_fd_sc_hd__a31oi_1
* cell instance $11584 m0 *1 292.1,100.64
X$11584 73 1645 1596 272 73 1727 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11593 m0 *1 317.4,100.64
X$11593 73 363 1726 1668 57 73 1725 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11596 m0 *1 320.62,100.64
X$11596 73 272 1724 1668 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11600 m0 *1 327.06,100.64
X$11600 57 1720 224 772 258 780 272 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $11603 m0 *1 331.66,100.64
X$11603 73 1220 344 1600 57 73 1669 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11606 m0 *1 334.88,100.64
X$11606 73 1720 1669 257 73 1670 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11607 m0 *1 336.72,100.64
X$11607 73 1670 73 57 1664 57 sky130_fd_sc_hd__buf_4
* cell instance $11639 m0 *1 418.14,100.64
X$11639 73 1672 73 57 1671 57 sky130_fd_sc_hd__buf_4
* cell instance $11644 m0 *1 430.56,100.64
X$11644 73 1638 1717 1673 1544 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $11647 m0 *1 436.54,100.64
X$11647 73 1713 1712 384 57 73 1551 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11648 m0 *1 438.38,100.64
X$11648 73 1676 1339 1712 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11654 m0 *1 445.74,100.64
X$11654 57 15539 1676 1638 1483 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $11655 m0 *1 450.34,100.64
X$11655 73 1676 73 57 1709 57 sky130_fd_sc_hd__buf_4
* cell instance $11659 m0 *1 459.54,100.64
X$11659 73 1812 73 57 1485 57 sky130_fd_sc_hd__buf_4
* cell instance $11662 m0 *1 466.9,100.64
X$11662 73 1483 1673 269 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11668 m0 *1 472.42,100.64
X$11668 73 209 1009 667 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11672 m0 *1 482.08,100.64
X$11672 73 1702 73 57 209 57 sky130_fd_sc_hd__buf_4
* cell instance $11676 m0 *1 488.06,100.64
X$11676 57 602 1169 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $11693 m0 *1 536.82,100.64
X$11693 57 57 1088 73 1680 1679 73 sky130_fd_sc_hd__nor2_2
* cell instance $11702 m0 *1 559.36,100.64
X$11702 73 1681 1182 1176 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11707 m0 *1 575.46,100.64
X$11707 73 2247 1495 1014 73 1682 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11708 m0 *1 577.3,100.64
X$11708 73 1894 1682 1698 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11719 m0 *1 601.22,100.64
X$11719 73 1501 2254 1694 1625 57 1624 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $11750 r0 *1 17.94,100.64
X$11750 57 1697 1691 1828 1623 1780 1730 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $11751 r0 *1 21.16,100.64
X$11751 73 1498 1460 1730 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11754 r0 *1 24.84,100.64
X$11754 73 1275 1689 1781 57 73 1780 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11755 r0 *1 26.68,100.64
X$11755 57 1782 1692 1733 1691 1784 73 73 57 sky130_fd_sc_hd__nor4_2
* cell instance $11756 r0 *1 31.28,100.64
X$11756 73 1414 1460 1693 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11761 r0 *1 39.56,100.64
X$11761 73 1787 1734 1786 73 1184 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11768 r0 *1 48.3,100.64
X$11768 57 1734 1318 1363 1789 971 901 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $11769 r0 *1 51.52,100.64
X$11769 73 971 1650 1736 73 1697 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11771 r0 *1 55.2,100.64
X$11771 73 1649 73 57 1699 57 sky130_fd_sc_hd__buf_4
* cell instance $11772 r0 *1 57.96,100.64
X$11772 73 1510 1199 1363 1699 73 1736 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $11774 r0 *1 61.64,100.64
X$11774 57 985 1794 1737 1231 1700 1572 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $11775 r0 *1 64.86,100.64
X$11775 73 1102 1649 1287 985 1737 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $11779 r0 *1 71.76,100.64
X$11779 57 1649 1060 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $11780 r0 *1 79.12,100.64
X$11780 73 1636 1796 1795 1655 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $11782 r0 *1 81.42,100.64
X$11782 73 1364 1797 1317 1572 1800 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $11785 r0 *1 89.7,100.64
X$11785 73 1733 73 57 1193 57 sky130_fd_sc_hd__buf_4
* cell instance $11792 r0 *1 101.2,100.64
X$11792 73 1706 73 57 1733 57 sky130_fd_sc_hd__buf_4
* cell instance $11793 r0 *1 103.96,100.64
X$11793 73 1804 1841 1511 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11796 r0 *1 108.1,100.64
X$11796 73 1806 73 57 1807 57 sky130_fd_sc_hd__buf_4
* cell instance $11808 r0 *1 139.84,100.64
X$11808 73 1326 73 57 1710 57 sky130_fd_sc_hd__buf_4
* cell instance $11810 r0 *1 143.06,100.64
X$11810 73 1711 73 57 1811 57 sky130_fd_sc_hd__buf_4
* cell instance $11819 r0 *1 162.38,100.64
X$11819 73 1813 1814 749 1743 57 73 1657 57 sky130_fd_sc_hd__a31oi_1
* cell instance $11823 r0 *1 167.9,100.64
X$11823 57 1815 1064 847 1744 1745 1659 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $11826 r0 *1 172.5,100.64
X$11826 73 1816 1657 1718 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11828 r0 *1 175.72,100.64
X$11828 73 1529 907 1747 73 1659 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11834 r0 *1 185.84,100.64
X$11834 73 685 1295 1744 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11845 r0 *1 211.14,100.64
X$11845 73 632 1471 1853 57 73 1543 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11848 r0 *1 215.74,100.64
X$11848 73 1662 73 57 1743 57 sky130_fd_sc_hd__buf_4
* cell instance $11860 r0 *1 252.08,100.64
X$11860 57 1821 96 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $11864 r0 *1 262.66,100.64
X$11864 73 253 1729 1560 73 1666 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11868 r0 *1 266.34,100.64
X$11868 73 1663 73 57 1825 57 sky130_fd_sc_hd__buf_4
* cell instance $11880 r0 *1 293.94,100.64
X$11880 73 779 1755 856 73 1665 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11881 r0 *1 295.78,100.64
X$11881 73 1665 1727 1163 193 363 73 1826 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $11883 r0 *1 299.46,100.64
X$11883 73 272 1597 1756 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11884 r0 *1 300.84,100.64
X$11884 73 1756 795 1228 736 857 1823 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $11886 r0 *1 304.98,100.64
X$11886 73 363 1666 575 73 1824 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11889 r0 *1 308.2,100.64
X$11889 73 1408 73 57 1863 57 sky130_fd_sc_hd__buf_4
* cell instance $11892 r0 *1 313.72,100.64
X$11892 73 1823 257 258 1598 57 1822 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $11895 r0 *1 316.94,100.64
X$11895 73 1725 1822 293 73 1667 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $11901 r0 *1 326.6,100.64
X$11901 73 856 1723 224 258 691 73 2004 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $11904 r0 *1 331.2,100.64
X$11904 73 856 422 1165 57 73 1820 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11905 r0 *1 333.04,100.64
X$11905 73 1818 665 856 57 73 1819 57 sky130_fd_sc_hd__a21oi_1
* cell instance $11908 r0 *1 339.02,100.64
X$11908 73 1137 73 57 1818 57 sky130_fd_sc_hd__buf_4
* cell instance $11937 r0 *1 410.32,100.64
X$11937 73 1213 73 57 1925 57 sky130_fd_sc_hd__buf_4
* cell instance $11940 r0 *1 415.38,100.64
X$11940 73 799 73 57 1923 57 sky130_fd_sc_hd__buf_4
* cell instance $11941 r0 *1 418.14,100.64
X$11941 73 1169 369 474 1921 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $11942 r0 *1 419.98,100.64
X$11942 73 1638 958 212 1817 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $11945 r0 *1 422.74,100.64
X$11945 57 1169 1761 741 1672 958 1918 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $11946 r0 *1 425.96,100.64
X$11946 73 1760 1759 1549 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11947 r0 *1 427.34,100.64
X$11947 73 1760 73 57 1717 57 sky130_fd_sc_hd__buf_4
* cell instance $11950 r0 *1 431.02,100.64
X$11950 73 343 1339 1760 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $11954 r0 *1 437.46,100.64
X$11954 57 1213 1675 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $11956 r0 *1 445.28,100.64
X$11956 73 1393 1761 1764 1763 741 1674 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $11957 r0 *1 448.5,100.64
X$11957 73 545 1677 1533 1764 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $11959 r0 *1 450.34,100.64
X$11959 73 343 1169 1677 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11962 r0 *1 453.1,100.64
X$11962 73 1085 73 57 491 57 sky130_fd_sc_hd__buf_4
* cell instance $11967 r0 *1 460.46,100.64
X$11967 73 1009 73 57 1638 57 sky130_fd_sc_hd__buf_4
* cell instance $11969 r0 *1 465.06,100.64
X$11969 73 1766 73 57 863 57 sky130_fd_sc_hd__buf_4
* cell instance $11972 r0 *1 472.42,100.64
X$11972 57 15670 1085 1702 1483 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $11981 r0 *1 491.74,100.64
X$11981 57 15573 1808 602 311 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $11984 r0 *1 497.72,100.64
X$11984 73 1769 57 73 602 57 sky130_fd_sc_hd__inv_2
* cell instance $11987 r0 *1 500.48,100.64
X$11987 73 1769 73 57 270 57 sky130_fd_sc_hd__buf_4
* cell instance $11998 r0 *1 526.24,100.64
X$11998 73 1680 1679 1678 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $11999 r0 *1 527.62,100.64
X$11999 73 1018 1608 1678 57 73 1803 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12000 r0 *1 529.46,100.64
X$12000 73 1802 73 57 1801 57 sky130_fd_sc_hd__buf_4
* cell instance $12003 r0 *1 533.14,100.64
X$12003 73 1489 1679 1701 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12011 r0 *1 546.94,100.64
X$12011 73 1018 1280 1285 57 73 1798 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12014 r0 *1 554.3,100.64
X$12014 73 1690 73 57 1768 57 sky130_fd_sc_hd__buf_4
* cell instance $12017 r0 *1 560.74,100.64
X$12017 73 1774 73 57 1687 57 sky130_fd_sc_hd__buf_4
* cell instance $12024 r0 *1 576.84,100.64
X$12024 73 1495 1680 1092 57 73 1793 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12028 r0 *1 583.74,100.64
X$12028 73 1616 1018 1681 1683 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $12038 r0 *1 604.44,100.64
X$12038 73 1791 1779 1783 1503 57 73 1790 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12040 r0 *1 610.42,100.64
X$12040 73 1683 73 57 1684 57 sky130_fd_sc_hd__buf_4
* cell instance $12042 r0 *1 613.18,100.64
X$12042 73 1092 1785 1686 1776 1783 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $12043 r0 *1 615.94,100.64
X$12043 73 1092 1684 1686 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12046 r0 *1 618.7,100.64
X$12046 73 1687 1777 1778 1262 1685 1779 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $12117 m0 *1 17.48,106.08
X$12117 73 1414 1146 1828 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12118 m0 *1 18.86,106.08
X$12118 73 1780 73 57 2515 57 sky130_fd_sc_hd__buf_4
* cell instance $12121 m0 *1 24.38,106.08
X$12121 73 1830 73 57 1888 57 sky130_fd_sc_hd__buf_4
* cell instance $12122 m0 *1 27.14,106.08
X$12122 73 1731 1888 1180 57 73 1786 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12126 m0 *1 30.82,106.08
X$12126 73 1693 73 57 1890 57 sky130_fd_sc_hd__buf_4
* cell instance $12130 m0 *1 40.02,106.08
X$12130 73 1648 1892 1788 1830 1831 73 1571 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $12134 m0 *1 48.3,106.08
X$12134 73 897 1735 1789 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12146 m0 *1 77.74,106.08
X$12146 73 1459 1060 1834 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12156 m0 *1 96.14,106.08
X$12156 73 1837 1800 1704 1738 1904 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $12157 m0 *1 98.9,106.08
X$12157 57 1739 1837 1902 1518 1839 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $12158 m0 *1 102.58,106.08
X$12158 73 1740 1738 1839 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12159 m0 *1 103.96,106.08
X$12159 73 1109 1841 1739 1741 1805 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $12160 m0 *1 106.26,106.08
X$12160 73 1740 1841 1998 57 73 1741 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12162 m0 *1 109.02,106.08
X$12162 73 1831 73 57 1841 57 sky130_fd_sc_hd__inv_1
* cell instance $12178 m0 *1 142.14,106.08
X$12178 73 1710 726 1842 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12182 m0 *1 149.5,106.08
X$12182 73 1842 73 57 1660 57 sky130_fd_sc_hd__buf_4
* cell instance $12185 m0 *1 153.64,106.08
X$12185 73 1906 1328 1742 57 73 727 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12186 m0 *1 155.48,106.08
X$12186 73 907 1846 749 73 1906 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12188 m0 *1 161,106.08
X$12188 73 1584 1325 997 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12189 m0 *1 162.38,106.08
X$12189 73 1844 73 57 730 57 sky130_fd_sc_hd__buf_4
* cell instance $12191 m0 *1 166.06,106.08
X$12191 73 1748 907 1844 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12197 m0 *1 173.42,106.08
X$12197 73 1383 1746 1907 73 1816 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12198 m0 *1 175.26,106.08
X$12198 73 907 1848 1747 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12199 m0 *1 176.64,106.08
X$12199 73 1747 1849 1746 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12200 m0 *1 178.02,106.08
X$12200 73 1326 73 57 1748 57 sky130_fd_sc_hd__buf_4
* cell instance $12201 m0 *1 180.78,106.08
X$12201 73 1748 1418 1850 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12202 m0 *1 182.16,106.08
X$12202 73 1850 73 57 1122 57 sky130_fd_sc_hd__buf_4
* cell instance $12211 m0 *1 197.34,106.08
X$12211 73 715 1914 783 73 1852 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12214 m0 *1 203.78,106.08
X$12214 73 1852 1912 1749 1295 57 73 1915 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12216 m0 *1 209.76,106.08
X$12216 73 726 1851 686 57 73 1750 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12217 m0 *1 211.6,106.08
X$12217 73 1853 1750 1854 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12218 m0 *1 212.98,106.08
X$12218 73 1854 1066 1249 1916 57 73 1749 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12221 m0 *1 217.58,106.08
X$12221 73 749 1125 1399 1917 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $12231 m0 *1 247.48,106.08
X$12231 73 1919 1855 360 73 1403 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12232 m0 *1 249.32,106.08
X$12232 73 691 1751 1855 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12236 m0 *1 253.46,106.08
X$12236 73 1594 360 1922 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12242 m0 *1 273.24,106.08
X$12242 73 344 915 2012 856 1753 73 1752 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $12243 m0 *1 276.46,106.08
X$12243 73 257 1563 1827 1927 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $12246 m0 *1 279.22,106.08
X$12246 57 1928 1752 1753 1859 253 1930 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $12247 m0 *1 282.44,106.08
X$12247 73 587 272 253 772 401 73 1859 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $12251 m0 *1 292.1,106.08
X$12251 73 923 2007 1826 73 1827 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $12259 m0 *1 312.34,106.08
X$12259 73 1862 272 1407 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12265 m0 *1 330.28,106.08
X$12265 73 772 1003 1165 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12268 m0 *1 333.96,106.08
X$12268 57 1820 2329 401 1819 1003 258 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $12293 m0 *1 411.24,106.08
X$12293 73 1925 595 1758 1169 831 73 1924 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $12294 m0 *1 414.46,106.08
X$12294 73 1169 1923 1671 1758 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $12297 m0 *1 417.22,106.08
X$12297 73 1923 1671 150 73 2114 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12298 m0 *1 419.06,106.08
X$12298 73 1921 1817 150 73 1920 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12300 m0 *1 424.58,106.08
X$12300 73 1717 1129 371 73 1865 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12301 m0 *1 426.42,106.08
X$12301 73 1759 73 57 1129 57 sky130_fd_sc_hd__buf_4
* cell instance $12306 m0 *1 441.14,106.08
X$12306 73 156 73 57 1006 57 sky130_fd_sc_hd__buf_4
* cell instance $12308 m0 *1 444.36,106.08
X$12308 73 1006 73 57 1762 57 sky130_fd_sc_hd__buf_4
* cell instance $12311 m0 *1 449.42,106.08
X$12311 73 150 1762 1868 57 73 1763 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12312 m0 *1 451.26,106.08
X$12312 73 1762 1868 371 73 1869 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12313 m0 *1 453.1,106.08
X$12313 57 1868 266 1812 1009 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $12316 m0 *1 459.08,106.08
X$12316 73 1913 73 57 1812 57 sky130_fd_sc_hd__inv_1
* cell instance $12318 m0 *1 464.14,106.08
X$12318 57 15526 266 1766 1765 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $12319 m0 *1 468.74,106.08
X$12319 73 1913 73 57 335 57 sky130_fd_sc_hd__buf_4
* cell instance $12321 m0 *1 471.96,106.08
X$12321 73 1765 73 57 311 57 sky130_fd_sc_hd__buf_4
* cell instance $12322 m0 *1 474.72,106.08
X$12322 73 1870 73 57 1766 57 sky130_fd_sc_hd__buf_4
* cell instance $12323 m0 *1 477.48,106.08
X$12323 73 1908 345 946 1909 73 1810 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $12325 m0 *1 480.24,106.08
X$12325 73 1993 500 311 235 73 1908 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $12327 m0 *1 484.38,106.08
X$12327 73 1871 73 57 1533 57 sky130_fd_sc_hd__buf_4
* cell instance $12328 m0 *1 487.14,106.08
X$12328 73 311 1009 1871 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12330 m0 *1 488.98,106.08
X$12330 73 1869 73 57 814 57 sky130_fd_sc_hd__buf_4
* cell instance $12331 m0 *1 491.74,106.08
X$12331 73 234 335 1169 57 73 1767 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12333 m0 *1 494.04,106.08
X$12333 73 1767 1871 1808 234 73 1809 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $12339 m0 *1 501.86,106.08
X$12339 73 1769 73 57 1009 57 sky130_fd_sc_hd__buf_4
* cell instance $12349 m0 *1 529.92,106.08
X$12349 73 1874 1018 1802 57 73 1774 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12350 m0 *1 531.76,106.08
X$12350 73 1345 928 1802 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12352 m0 *1 534.06,106.08
X$12352 57 15523 1875 1018 1489 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $12354 m0 *1 540.5,106.08
X$12354 73 2175 1900 1770 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12355 m0 *1 541.88,106.08
X$12355 73 1681 1770 1771 73 1772 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12356 m0 *1 543.72,106.08
X$12356 73 1876 1772 1613 73 1799 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12359 m0 *1 546.94,106.08
X$12359 73 1987 1798 1681 73 1771 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12364 m0 *1 556.6,106.08
X$12364 73 1177 1898 1773 872 1896 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $12365 m0 *1 559.36,106.08
X$12365 73 1616 1177 1092 73 1773 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12368 m0 *1 566.72,106.08
X$12368 73 1616 872 1092 1895 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $12370 m0 *1 569.02,106.08
X$12370 73 1177 1876 938 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12388 m0 *1 612.72,106.08
X$12388 73 1684 1881 1775 57 73 1622 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12393 m0 *1 623.3,106.08
X$12393 73 1886 1777 1437 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12416 r0 *1 18.86,106.08
X$12416 73 1828 73 57 1829 57 sky130_fd_sc_hd__buf_4
* cell instance $12420 r0 *1 24.84,106.08
X$12420 73 1498 1460 1830 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12422 r0 *1 28.06,106.08
X$12422 73 1651 73 57 1732 57 sky130_fd_sc_hd__buf_4
* cell instance $12424 r0 *1 32.66,106.08
X$12424 73 1890 1732 1832 57 73 1980 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12428 r0 *1 39.56,106.08
X$12428 73 1573 1735 1892 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12439 r0 *1 64.4,106.08
X$12439 73 1572 3151 1794 73 1835 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12442 r0 *1 68.54,106.08
X$12442 73 1833 73 57 1316 57 sky130_fd_sc_hd__buf_4
* cell instance $12447 r0 *1 74.06,106.08
X$12447 73 1366 73 57 1832 57 sky130_fd_sc_hd__buf_4
* cell instance $12448 r0 *1 76.82,106.08
X$12448 73 1581 1834 1833 1992 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $12449 r0 *1 78.66,106.08
X$12449 73 1834 73 57 1287 57 sky130_fd_sc_hd__buf_4
* cell instance $12450 r0 *1 81.42,106.08
X$12450 73 1897 1197 1835 57 73 1939 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12453 r0 *1 84.64,106.08
X$12453 73 2021 1061 1738 1731 57 73 1836 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12454 r0 *1 86.94,106.08
X$12454 73 1738 1899 1836 73 1838 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12456 r0 *1 90.62,106.08
X$12456 73 986 980 1994 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12457 r0 *1 92,106.08
X$12457 73 1366 1994 1995 1572 73 57 1840 57 sky130_fd_sc_hd__o31ai_1
* cell instance $12460 r0 *1 96.14,106.08
X$12460 73 1572 1901 1902 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12468 r0 *1 102.58,106.08
X$12468 73 1581 1903 1840 57 73 1637 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12470 r0 *1 104.88,106.08
X$12470 57 1804 1997 1805 1831 1939 1838 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $12484 r0 *1 141.22,106.08
X$12484 73 1710 726 1325 2023 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $12487 r0 *1 144.44,106.08
X$12487 73 816 1842 730 1843 73 2000 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $12490 r0 *1 149.04,106.08
X$12490 73 991 726 1846 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12496 r0 *1 161.92,106.08
X$12496 73 1328 1418 1845 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12498 r0 *1 163.76,106.08
X$12498 73 1845 1846 907 73 1847 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12499 r0 *1 165.6,106.08
X$12499 73 1845 1843 1325 73 2036 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12501 r0 *1 169.28,106.08
X$12501 73 1815 73 57 2005 57 sky130_fd_sc_hd__buf_4
* cell instance $12502 r0 *1 172.04,106.08
X$12502 73 1847 2135 847 1941 57 73 1907 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12503 r0 *1 174.34,106.08
X$12503 73 1748 1418 1848 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12505 r0 *1 176.18,106.08
X$12505 73 1848 73 57 993 57 sky130_fd_sc_hd__buf_4
* cell instance $12508 r0 *1 179.4,106.08
X$12508 73 735 1843 1748 73 1910 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12512 r0 *1 183.08,106.08
X$12512 73 1941 1910 2006 1911 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $12516 r0 *1 194.12,106.08
X$12516 57 2008 631 1851 1245 1537 686 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $12517 r0 *1 197.34,106.08
X$12517 73 1421 733 726 57 73 1914 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12522 r0 *1 207.46,106.08
X$12522 73 1661 2009 783 73 2011 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12526 r0 *1 211.14,106.08
X$12526 73 686 1584 1940 57 73 1943 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12528 r0 *1 216.66,106.08
X$12528 73 1396 1399 1943 1916 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $12540 r0 *1 247.48,106.08
X$12540 73 633 480 1919 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12541 r0 *1 248.86,106.08
X$12541 73 360 1919 1855 1856 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $12543 r0 *1 252.08,106.08
X$12543 73 1856 1922 2014 193 1753 73 1857 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $12546 r0 *1 259.44,106.08
X$12546 73 1857 73 57 1945 57 sky130_fd_sc_hd__buf_4
* cell instance $12555 r0 *1 273.7,106.08
X$12555 73 1751 587 1596 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12557 r0 *1 276,106.08
X$12557 73 1858 1929 257 1927 57 73 2792 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12558 r0 *1 278.3,106.08
X$12558 73 923 1928 1858 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12559 r0 *1 279.68,106.08
X$12559 73 772 253 587 73 1860 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12560 r0 *1 281.52,106.08
X$12560 73 253 592 1860 272 1861 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $12561 r0 *1 284.28,106.08
X$12561 73 1861 1947 2010 857 1862 1930 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $12564 r0 *1 288.42,106.08
X$12564 73 1931 193 1425 57 73 2010 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12565 r0 *1 290.26,106.08
X$12565 73 856 193 1931 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12571 r0 *1 300.84,106.08
X$12571 73 480 73 57 1003 57 sky130_fd_sc_hd__buf_4
* cell instance $12572 r0 *1 303.6,106.08
X$12572 73 923 1863 1956 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12582 r0 *1 323.38,106.08
X$12582 73 697 224 272 1864 57 73 2002 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12583 r0 *1 325.68,106.08
X$12583 73 272 779 1454 1864 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $12585 r0 *1 328.44,106.08
X$12585 73 1926 73 57 400 57 sky130_fd_sc_hd__buf_4
* cell instance $12622 r0 *1 417.22,106.08
X$12622 73 369 212 371 73 2111 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12627 r0 *1 425.04,106.08
X$12627 73 1867 1866 1169 73 1918 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12628 r0 *1 426.88,106.08
X$12628 73 1867 73 57 369 57 sky130_fd_sc_hd__buf_4
* cell instance $12631 r0 *1 430.56,106.08
X$12631 73 335 545 1867 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12634 r0 *1 433.32,106.08
X$12634 73 1866 73 57 212 57 sky130_fd_sc_hd__buf_4
* cell instance $12635 r0 *1 436.08,106.08
X$12635 73 1964 545 1866 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $12636 r0 *1 438.38,106.08
X$12636 73 500 73 57 1713 57 sky130_fd_sc_hd__buf_4
* cell instance $12640 r0 *1 447.58,106.08
X$12640 73 1869 73 57 1999 57 sky130_fd_sc_hd__buf_4
* cell instance $12646 r0 *1 458.62,106.08
X$12646 73 667 73 57 1965 57 sky130_fd_sc_hd__buf_4
* cell instance $12650 r0 *1 464.6,106.08
X$12650 57 15627 1913 1766 1765 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $12651 r0 *1 469.2,106.08
X$12651 57 345 1996 347 1032 520 1810 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $12653 r0 *1 476.1,106.08
X$12653 73 1870 73 57 1702 57 sky130_fd_sc_hd__inv_1
* cell instance $12655 r0 *1 477.48,106.08
X$12655 73 1870 73 57 231 57 sky130_fd_sc_hd__buf_4
* cell instance $12657 r0 *1 480.7,106.08
X$12657 73 1675 311 338 231 1993 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $12664 r0 *1 488.98,106.08
X$12664 73 1872 73 57 207 57 sky130_fd_sc_hd__buf_4
* cell instance $12665 r0 *1 491.74,106.08
X$12665 57 615 1873 1870 1872 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $12666 r0 *1 496.34,106.08
X$12666 73 1873 234 707 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12677 r0 *1 524.4,106.08
X$12677 73 1018 1905 1678 57 73 2095 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12680 r0 *1 529,106.08
X$12680 73 1874 73 57 1611 57 sky130_fd_sc_hd__buf_4
* cell instance $12683 r0 *1 532.68,106.08
X$12683 73 1345 73 57 1990 57 sky130_fd_sc_hd__buf_4
* cell instance $12693 r0 *1 556.6,106.08
X$12693 73 1877 1896 1099 1893 57 73 1985 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12696 r0 *1 559.36,106.08
X$12696 73 1968 73 57 1345 57 sky130_fd_sc_hd__buf_4
* cell instance $12701 r0 *1 568.56,106.08
X$12701 73 1895 938 1013 1878 57 73 1982 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12705 r0 *1 574.08,106.08
X$12705 73 1893 1681 1878 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12709 r0 *1 583.74,106.08
X$12709 73 1793 73 57 1887 57 sky130_fd_sc_hd__buf_4
* cell instance $12712 r0 *1 586.96,106.08
X$12712 57 1981 1879 1875 1182 1616 1092 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $12713 r0 *1 590.18,106.08
X$12713 73 1880 1685 1092 57 73 2066 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12714 r0 *1 592.02,106.08
X$12714 73 1882 1177 1880 57 73 1877 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12716 r0 *1 594.32,106.08
X$12716 73 1881 1092 1880 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12720 r0 *1 600.3,106.08
X$12720 73 1775 1979 1891 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12721 r0 *1 601.68,106.08
X$12721 73 1886 1891 1883 57 73 1882 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12722 r0 *1 603.52,106.08
X$12722 73 1884 1177 1883 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12724 r0 *1 606.74,106.08
X$12724 73 1497 73 57 1884 57 sky130_fd_sc_hd__buf_4
* cell instance $12727 r0 *1 612.26,106.08
X$12727 73 1889 1973 1970 1775 1621 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $12729 r0 *1 615.02,106.08
X$12729 57 1785 1436 1971 1885 1681 1975 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $12730 r0 *1 618.24,106.08
X$12730 73 1889 1884 1681 1885 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $12803 m0 *1 19.78,111.52
X$12803 73 1829 1976 1977 1309 1313 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $12804 m0 *1 22.54,111.52
X$12804 73 1933 2070 1830 1935 57 73 1932 57 sky130_fd_sc_hd__a31oi_1
* cell instance $12805 m0 *1 24.84,111.52
X$12805 73 1688 1735 1502 1647 1459 1978 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $12806 m0 *1 28.06,111.52
X$12806 73 985 1934 1107 1933 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $12816 m0 *1 51.98,111.52
X$12816 73 1281 979 1984 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12821 m0 *1 58.88,111.52
X$12821 73 1936 1101 1984 57 73 1986 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12822 m0 *1 60.72,111.52
X$12822 73 2201 1461 1833 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12826 m0 *1 68.54,111.52
X$12826 73 1829 2018 1937 57 73 1795 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12830 m0 *1 79.58,111.52
X$12830 73 1577 73 57 1936 57 sky130_fd_sc_hd__buf_4
* cell instance $12836 m0 *1 87.86,111.52
X$12836 73 1935 73 57 1731 57 sky130_fd_sc_hd__buf_4
* cell instance $12837 m0 *1 90.62,111.52
X$12837 73 1938 73 57 1935 57 sky130_fd_sc_hd__buf_4
* cell instance $12838 m0 *1 93.38,111.52
X$12838 73 1740 1831 1938 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12862 m0 *1 153.18,111.52
X$12862 73 1585 2027 1940 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12863 m0 *1 154.56,111.52
X$12863 73 728 1940 1715 1328 732 2386 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $12866 m0 *1 160.08,111.52
X$12866 73 1940 997 2026 73 2003 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12874 m0 *1 176.64,111.52
X$12874 73 1941 911 1208 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12875 m0 *1 178.02,111.52
X$12875 57 15517 2032 1242 1584 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $12877 m0 *1 183.08,111.52
X$12877 73 875 1849 1942 732 73 2006 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $12886 m0 *1 207,111.52
X$12886 73 632 1471 2104 57 73 2009 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12887 m0 *1 208.84,111.52
X$12887 73 1295 2105 1472 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12899 m0 *1 245.64,111.52
X$12899 73 1919 1944 856 73 2013 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12900 m0 *1 247.48,111.52
X$12900 73 2043 258 587 1944 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $12912 m0 *1 275.54,111.52
X$12912 73 856 1946 2012 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12917 m0 *1 279.22,111.52
X$12917 73 1597 2045 1946 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12919 m0 *1 281.06,111.52
X$12919 73 2043 1751 837 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12921 m0 *1 283.36,111.52
X$12921 73 589 1003 1755 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12922 m0 *1 284.74,111.52
X$12922 73 856 253 1947 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12923 m0 *1 286.12,111.52
X$12923 73 357 587 2045 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12924 m0 *1 287.5,111.52
X$12924 73 253 1948 1667 1754 73 1949 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $12925 m0 *1 290.26,111.52
X$12925 73 2045 1755 272 73 1950 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12927 m0 *1 292.56,111.52
X$12927 57 2007 1952 1950 258 193 1951 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $12928 m0 *1 295.78,111.52
X$12928 73 193 775 1425 57 73 1951 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12930 m0 *1 298.54,111.52
X$12930 73 272 587 1425 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12931 m0 *1 299.92,111.52
X$12931 73 1953 856 1228 772 1952 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $12932 m0 *1 302.22,111.52
X$12932 73 964 1954 1824 923 1956 1955 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $12936 m0 *1 307.28,111.52
X$12936 73 293 2117 1957 1929 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $12939 m0 *1 310.5,111.52
X$12939 73 1757 1958 193 73 1957 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $12941 m0 *1 313.26,111.52
X$12941 73 401 1959 1958 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12944 m0 *1 319.24,111.52
X$12944 73 856 697 725 57 73 1959 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12945 m0 *1 321.08,111.52
X$12945 73 272 258 1953 1960 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $12946 m0 *1 322.92,111.52
X$12946 73 775 1003 725 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $12949 m0 *1 327.06,111.52
X$12949 73 2004 293 1960 2002 258 73 1961 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $12951 m0 *1 331.2,111.52
X$12951 73 587 772 1926 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $12981 m0 *1 412.62,111.52
X$12981 73 1924 741 1962 57 73 630 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12984 m0 *1 416.76,111.52
X$12984 73 1169 2112 2111 57 73 2001 57 sky130_fd_sc_hd__a21oi_1
* cell instance $12985 m0 *1 418.6,111.52
X$12985 73 2114 1865 2001 1169 741 73 2110 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $12986 m0 *1 421.82,111.52
X$12986 73 1638 153 1639 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $12989 m0 *1 426.88,111.52
X$12989 73 1078 545 1759 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $12991 m0 *1 431.94,111.52
X$12991 73 1963 153 1169 1759 57 2150 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $12994 m0 *1 437.46,111.52
X$12994 73 742 73 57 1964 57 sky130_fd_sc_hd__buf_4
* cell instance $12996 m0 *1 441.14,111.52
X$12996 73 1964 1638 2054 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13002 m0 *1 448.5,111.52
X$13002 73 1078 1169 2107 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13006 m0 *1 458.16,111.52
X$13006 73 335 1638 545 1965 2056 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13010 m0 *1 468.74,111.52
X$13010 73 1765 73 57 1483 57 sky130_fd_sc_hd__buf_4
* cell instance $13014 m0 *1 473.34,111.52
X$13014 57 15505 742 1702 1765 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $13015 m0 *1 477.94,111.52
X$13015 73 1872 73 57 1765 57 sky130_fd_sc_hd__inv_1
* cell instance $13018 m0 *1 480.7,111.52
X$13018 57 15564 1078 1702 1872 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $13022 m0 *1 493.58,111.52
X$13022 73 1873 73 57 153 57 sky130_fd_sc_hd__buf_4
* cell instance $13036 m0 *1 527.16,111.52
X$13036 73 1681 2064 1371 57 73 1966 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13039 m0 *1 531.3,111.52
X$13039 73 1801 1701 1018 73 1991 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13042 m0 *1 537.74,111.52
X$13042 73 1966 1974 1967 1989 57 2243 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $13043 m0 *1 540.5,111.52
X$13043 73 2067 928 1988 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13044 m0 *1 541.88,111.52
X$13044 73 2090 73 57 1989 57 sky130_fd_sc_hd__buf_4
* cell instance $13050 m0 *1 554.76,111.52
X$13050 73 2087 73 57 1987 57 sky130_fd_sc_hd__buf_4
* cell instance $13051 m0 *1 557.52,111.52
X$13051 73 1985 73 57 1983 57 sky130_fd_sc_hd__buf_4
* cell instance $13054 m0 *1 561.66,111.52
X$13054 73 2085 73 57 1968 57 sky130_fd_sc_hd__clkinv_1
* cell instance $13057 m0 *1 564.42,111.52
X$13057 73 2085 73 57 1616 57 sky130_fd_sc_hd__buf_4
* cell instance $13060 m0 *1 569.48,111.52
X$13060 73 2068 73 57 1099 57 sky130_fd_sc_hd__buf_4
* cell instance $13062 m0 *1 575.92,111.52
X$13062 73 1979 1876 874 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13070 m0 *1 595.24,111.52
X$13070 73 1968 73 57 1889 57 sky130_fd_sc_hd__buf_4
* cell instance $13071 m0 *1 598,111.52
X$13071 73 2080 1889 928 57 73 1969 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13072 m0 *1 599.84,111.52
X$13072 73 1969 73 57 1504 57 sky130_fd_sc_hd__buf_4
* cell instance $13079 m0 *1 611.8,111.52
X$13079 73 2078 1092 1681 1182 57 73 1776 57 sky130_fd_sc_hd__a31oi_1
* cell instance $13080 m0 *1 614.1,111.52
X$13080 73 1971 1973 1970 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13081 m0 *1 615.48,111.52
X$13081 73 1972 1973 1775 73 1975 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13085 m0 *1 622.38,111.52
X$13085 73 2071 73 57 1974 57 sky130_fd_sc_hd__buf_4
* cell instance $13109 r0 *1 24.38,111.52
X$13109 73 1054 1055 2074 2073 57 1784 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $13110 r0 *1 27.14,111.52
X$13110 73 1732 2016 2015 1275 2070 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13112 r0 *1 31.74,111.52
X$13112 73 1732 2016 1316 73 2076 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13113 r0 *1 33.58,111.52
X$13113 73 971 1281 1440 2166 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13116 r0 *1 40.94,111.52
X$13116 73 1830 73 57 2079 57 sky130_fd_sc_hd__buf_4
* cell instance $13128 r0 *1 68.54,111.52
X$13128 73 1647 2017 1287 2019 2018 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13135 r0 *1 80.04,111.52
X$13135 73 1787 2020 2176 57 73 1796 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13141 r0 *1 94.3,111.52
X$13141 73 1370 980 2017 2022 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $13142 r0 *1 96.14,111.52
X$13142 73 2022 73 57 2088 57 sky130_fd_sc_hd__buf_4
* cell instance $13149 r0 *1 107.18,111.52
X$13149 73 1997 73 57 2089 57 sky130_fd_sc_hd__buf_4
* cell instance $13161 r0 *1 135.24,111.52
X$13161 57 2023 1811 914 2024 1851 2091 73 73 57 sky130_fd_sc_hd__o221a_2
* cell instance $13164 r0 *1 141.68,111.52
X$13164 73 2026 2025 2091 73 57 2999 57 sky130_fd_sc_hd__o21ai_1
* cell instance $13166 r0 *1 145.36,111.52
X$13166 73 1744 2026 2000 57 73 2025 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13172 r0 *1 152.26,111.52
X$13172 73 2029 2023 2092 57 73 2144 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13175 r0 *1 158.24,111.52
X$13175 73 685 728 2028 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13176 r0 *1 159.62,111.52
X$13176 73 2028 73 57 2029 57 sky130_fd_sc_hd__buf_4
* cell instance $13179 r0 *1 163.76,111.52
X$13179 73 1418 73 57 2027 57 sky130_fd_sc_hd__buf_4
* cell instance $13180 r0 *1 166.52,111.52
X$13180 73 730 875 2030 2027 847 73 2185 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $13183 r0 *1 172.04,111.52
X$13183 73 2028 73 57 1245 57 sky130_fd_sc_hd__buf_4
* cell instance $13186 r0 *1 177.56,111.52
X$13186 73 907 993 2098 73 2097 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13189 r0 *1 179.4,111.52
X$13189 73 2032 907 2098 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13192 r0 *1 182.16,111.52
X$13192 73 1331 1418 907 2033 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13193 r0 *1 184,111.52
X$13193 73 2032 907 2033 73 2034 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13196 r0 *1 191.36,111.52
X$13196 57 15631 2037 1418 733 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $13197 r0 *1 195.96,111.52
X$13197 57 2008 2099 1066 1743 746 2392 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $13198 r0 *1 199.18,111.52
X$13198 57 2034 2036 2101 1391 1066 2038 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $13200 r0 *1 203.78,111.52
X$13200 73 2037 996 2102 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13205 r0 *1 206.54,111.52
X$13205 73 1245 2102 2103 2011 73 57 2191 57 sky130_fd_sc_hd__o31ai_1
* cell instance $13211 r0 *1 221.72,111.52
X$13211 73 1396 1942 735 57 73 2038 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13223 r0 *1 248.4,111.52
X$13223 73 257 2109 2294 1728 2013 2039 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $13225 r0 *1 252.08,111.52
X$13225 73 2040 793 665 2295 73 2109 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $13227 r0 *1 256.22,111.52
X$13227 73 587 2041 2042 57 73 2040 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13230 r0 *1 259.44,111.52
X$13230 73 357 856 1753 2042 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13233 r0 *1 261.28,111.52
X$13233 73 857 360 2041 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13234 r0 *1 262.66,111.52
X$13234 73 923 2039 2667 73 1948 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13238 r0 *1 272.32,111.52
X$13238 57 15596 1862 1751 480 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $13241 r0 *1 281.06,111.52
X$13241 73 2043 1003 1597 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13245 r0 *1 285.66,111.52
X$13245 73 2044 73 57 852 57 sky130_fd_sc_hd__buf_4
* cell instance $13248 r0 *1 288.42,111.52
X$13248 73 357 480 2044 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13249 r0 *1 289.8,111.52
X$13249 73 272 2044 1596 2113 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $13254 r0 *1 297.62,111.52
X$13254 73 1070 795 258 73 2046 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13255 r0 *1 299.46,111.52
X$13255 73 1425 857 2046 2115 57 2047 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $13256 r0 *1 302.22,111.52
X$13256 73 697 272 2116 857 258 73 2048 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $13257 r0 *1 305.44,111.52
X$13257 73 2048 2047 253 73 2117 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13260 r0 *1 310.04,111.52
X$13260 73 775 587 2049 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13261 r0 *1 311.42,111.52
X$13261 73 2049 1070 587 57 73 1953 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13270 r0 *1 324.76,111.52
X$13270 73 357 1003 2147 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13271 r0 *1 326.14,111.52
X$13271 73 272 1454 725 1220 2118 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13272 r0 *1 328.9,111.52
X$13272 73 363 73 57 1220 57 sky130_fd_sc_hd__buf_4
* cell instance $13274 r0 *1 332.12,111.52
X$13274 73 1926 73 57 2119 57 sky130_fd_sc_hd__buf_4
* cell instance $13275 r0 *1 334.88,111.52
X$13275 73 2119 2147 272 1220 57 73 2050 57 sky130_fd_sc_hd__a31oi_1
* cell instance $13311 r0 *1 417.68,111.52
X$13311 73 1078 150 2112 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13314 r0 *1 421.36,111.52
X$13314 73 1999 2051 1920 73 2052 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13317 r0 *1 423.2,111.52
X$13317 73 545 2058 1639 57 73 2051 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13326 r0 *1 437.46,111.52
X$13326 73 545 73 57 1963 57 sky130_fd_sc_hd__buf_4
* cell instance $13329 r0 *1 442.98,111.52
X$13329 73 500 2053 2106 802 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $13331 r0 *1 445.28,111.52
X$13331 73 1762 2107 2054 57 73 2053 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13332 r0 *1 447.12,111.52
X$13332 73 2181 1999 2108 1008 1962 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $13340 r0 *1 458.62,111.52
X$13340 73 1963 1965 2055 57 73 2106 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13342 r0 *1 460.92,111.52
X$13342 73 1483 1169 2055 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13344 r0 *1 462.76,111.52
X$13344 73 2057 1169 234 2058 2100 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13345 r0 *1 465.52,111.52
X$13345 73 601 73 57 2057 57 sky130_fd_sc_hd__buf_4
* cell instance $13347 r0 *1 470.12,111.52
X$13347 73 742 73 57 2178 57 sky130_fd_sc_hd__buf_4
* cell instance $13348 r0 *1 472.88,111.52
X$13348 73 338 73 57 2157 57 sky130_fd_sc_hd__buf_4
* cell instance $13349 r0 *1 475.64,111.52
X$13349 73 2060 73 57 545 57 sky130_fd_sc_hd__buf_4
* cell instance $13354 r0 *1 481.16,111.52
X$13354 73 949 371 2061 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13355 r0 *1 482.54,111.52
X$13355 73 2061 73 57 500 57 sky130_fd_sc_hd__buf_4
* cell instance $13358 r0 *1 486.68,111.52
X$13358 57 2060 234 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $13359 r0 *1 494.04,111.52
X$13359 57 15638 2062 1870 1872 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $13360 r0 *1 498.64,111.52
X$13360 57 2062 601 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $13372 r0 *1 523.02,111.52
X$13372 73 1876 2094 2095 2063 73 57 2096 57 sky130_fd_sc_hd__o31ai_1
* cell instance $13375 r0 *1 528.54,111.52
X$13375 73 1973 2065 1991 2093 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13376 r0 *1 530.38,111.52
X$13376 73 1014 2066 2065 1876 2063 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13386 r0 *1 555.68,111.52
X$13386 73 1616 1092 2086 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13387 r0 *1 557.06,111.52
X$13387 73 1616 872 928 2169 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $13395 r0 *1 569.02,111.52
X$13395 73 1893 1973 1356 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13398 r0 *1 571.78,111.52
X$13398 73 1973 1182 2068 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13407 r0 *1 589.26,111.52
X$13407 73 1178 2083 2069 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13408 r0 *1 590.64,111.52
X$13408 73 1775 2082 1269 2639 1352 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13414 r0 *1 598.46,111.52
X$13414 73 2080 73 57 1497 57 sky130_fd_sc_hd__buf_4
* cell instance $13418 r0 *1 612.26,111.52
X$13418 73 928 2077 1269 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13423 r0 *1 619.16,111.52
X$13423 73 1972 2069 2075 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13424 r0 *1 620.54,111.52
X$13424 73 2069 73 57 1777 57 sky130_fd_sc_hd__buf_4
* cell instance $13426 r0 *1 623.76,111.52
X$13426 73 2075 2072 1182 73 2071 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13473 m0 *1 20.24,116.96
X$13473 73 1567 73 57 2121 57 sky130_fd_sc_hd__buf_4
* cell instance $13476 m0 *1 24.38,116.96
X$13476 73 1735 2121 2164 2016 2073 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $13478 m0 *1 27.6,116.96
X$13478 73 2121 2016 2081 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13481 m0 *1 30.36,116.96
X$13481 73 1461 73 57 2016 57 sky130_fd_sc_hd__buf_4
* cell instance $13482 m0 *1 33.12,116.96
X$13482 57 2123 2458 2122 2125 2166 1688 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $13484 m0 *1 40.48,116.96
X$13484 73 2074 73 57 1787 57 sky130_fd_sc_hd__buf_4
* cell instance $13488 m0 *1 49.22,116.96
X$13488 73 2124 1281 1101 2126 57 73 2125 57 sky130_fd_sc_hd__a31oi_1
* cell instance $13490 m0 *1 52.44,116.96
X$13490 57 2127 2126 971 1316 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $13491 m0 *1 54.74,116.96
X$13491 73 2128 73 57 1735 57 sky130_fd_sc_hd__buf_4
* cell instance $13495 m0 *1 59.34,116.96
X$13495 73 2170 2017 1287 73 2124 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13497 m0 *1 63.02,116.96
X$13497 73 1649 73 57 2017 57 sky130_fd_sc_hd__buf_4
* cell instance $13498 m0 *1 65.78,116.96
X$13498 73 1647 2203 2171 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13501 m0 *1 69.46,116.96
X$13501 73 2019 2171 2173 2129 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13502 m0 *1 71.3,116.96
X$13502 73 1279 2306 2129 1150 2021 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13506 m0 *1 80.04,116.96
X$13506 73 1459 2019 1364 2020 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13507 m0 *1 81.88,116.96
X$13507 73 2206 1279 2127 2130 986 2176 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $13510 m0 *1 86.02,116.96
X$13510 73 2130 2081 1287 57 73 1577 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13513 m0 *1 89.24,116.96
X$13513 73 2131 1279 2019 73 2373 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13518 m0 *1 100.74,116.96
X$13518 73 2130 2273 2088 1837 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $13536 m0 *1 145.36,116.96
X$13536 73 847 726 2314 1525 2133 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $13537 m0 *1 148.58,116.96
X$13537 73 1112 1421 2027 2133 57 73 2134 57 sky130_fd_sc_hd__a31oi_1
* cell instance $13540 m0 *1 152.26,116.96
X$13540 73 1941 1160 2482 2134 2139 73 57 57 sky130_fd_sc_hd__or4_1
* cell instance $13544 m0 *1 164.22,116.96
X$13544 73 2180 726 1658 57 73 2031 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13549 m0 *1 169.74,116.96
X$13549 73 2185 2490 1208 73 2136 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13552 m0 *1 172.96,116.96
X$13552 73 2186 73 57 1391 57 sky130_fd_sc_hd__buf_4
* cell instance $13553 m0 *1 175.72,116.96
X$13553 73 2097 1941 847 2031 57 2137 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $13556 m0 *1 183.08,116.96
X$13556 73 848 847 1160 1331 685 73 2187 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $13557 m0 *1 186.3,116.96
X$13557 73 2035 2138 2139 2136 2188 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13558 m0 *1 189.06,116.96
X$13558 73 728 2140 2187 73 2138 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13561 m0 *1 193.66,116.96
X$13561 73 2595 2037 686 2141 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $13563 m0 *1 195.96,116.96
X$13563 73 847 1914 2141 2035 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $13567 m0 *1 203.78,116.96
X$13567 73 726 2143 1660 686 57 2103 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $13568 m0 *1 206.54,116.96
X$13568 73 2143 996 1044 73 2140 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13570 m0 *1 209.3,116.96
X$13570 73 2191 2101 2105 73 2192 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13572 m0 *1 211.6,116.96
X$13572 73 1583 1471 1396 632 3179 73 2145 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $13574 m0 *1 215.28,116.96
X$13574 57 2194 2195 1743 2145 2144 1124 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $13591 m0 *1 259.44,116.96
X$13591 57 2198 793 2043 856 1751 697 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $13600 m0 *1 283.36,116.96
X$13600 73 2190 1134 257 73 2196 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13608 m0 *1 303.14,116.96
X$13608 73 2193 272 633 57 73 2116 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13617 m0 *1 326.6,116.96
X$13617 73 363 2148 2190 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13618 m0 *1 327.98,116.96
X$13618 73 2050 344 780 57 73 2189 57 sky130_fd_sc_hd__a21boi_0
* cell instance $13620 m0 *1 331.66,116.96
X$13620 73 272 2147 2119 57 73 2148 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13654 m0 *1 421.36,116.96
X$13654 73 2110 374 741 2052 73 2658 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $13658 m0 *1 432.4,116.96
X$13658 73 2150 73 57 2149 57 sky130_fd_sc_hd__buf_4
* cell instance $13659 m0 *1 435.16,116.96
X$13659 73 2182 1713 2149 2151 2184 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $13660 m0 *1 437.46,116.96
X$13660 73 831 73 57 2151 57 sky130_fd_sc_hd__buf_4
* cell instance $13662 m0 *1 441.14,116.96
X$13662 73 2053 73 57 2182 57 sky130_fd_sc_hd__buf_4
* cell instance $13665 m0 *1 444.82,116.96
X$13665 73 2054 73 57 2152 57 sky130_fd_sc_hd__buf_4
* cell instance $13666 m0 *1 447.58,116.96
X$13666 73 1963 1677 2152 57 73 2181 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13668 m0 *1 449.88,116.96
X$13668 73 2153 1963 150 73 2108 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13670 m0 *1 452.64,116.96
X$13670 73 2154 2153 1762 57 73 2155 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13672 m0 *1 456.32,116.96
X$13672 73 741 1082 2059 2156 73 57 2179 57 sky130_fd_sc_hd__o31ai_1
* cell instance $13673 m0 *1 459.08,116.96
X$13673 73 2056 2155 2156 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13675 m0 *1 461.38,116.96
X$13675 73 2055 73 57 2058 57 sky130_fd_sc_hd__buf_4
* cell instance $13677 m0 *1 465.98,116.96
X$13677 73 2057 2157 269 73 2477 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13680 m0 *1 469.2,116.96
X$13680 73 1675 1483 2157 2178 2059 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $13687 m0 *1 487.14,116.96
X$13687 73 2159 73 57 473 57 sky130_fd_sc_hd__buf_4
* cell instance $13689 m0 *1 490.82,116.96
X$13689 73 615 2233 2177 2159 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13705 m0 *1 530.84,116.96
X$13705 73 1014 2160 1090 2065 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13709 m0 *1 540.5,116.96
X$13709 73 2067 1092 929 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13712 m0 *1 547.4,116.96
X$13712 73 1018 928 2083 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13713 m0 *1 548.78,116.96
X$13713 73 2174 2172 2161 1876 1973 73 2090 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $13718 m0 *1 556.6,116.96
X$13718 73 1876 2169 2163 2161 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $13720 m0 *1 558.9,116.96
X$13720 73 2169 73 57 2168 57 sky130_fd_sc_hd__buf_4
* cell instance $13726 m0 *1 574.08,116.96
X$13726 73 930 2086 1346 1775 2084 73 2167 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $13729 m0 *1 580.06,116.96
X$13729 73 2165 1497 1092 73 57 1344 57 sky130_fd_sc_hd__o21ai_1
* cell instance $13745 m0 *1 618.7,116.96
X$13745 73 1497 1092 2253 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13747 m0 *1 621.92,116.96
X$13747 73 2252 73 57 2163 57 sky130_fd_sc_hd__buf_4
* cell instance $13771 r0 *1 19.78,116.96
X$13771 73 2121 2120 2298 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13773 r0 *1 23,116.96
X$13773 73 1498 1146 2074 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13774 r0 *1 24.38,116.96
X$13774 73 2256 2259 1978 57 73 2255 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13777 r0 *1 27.6,116.96
X$13777 73 1459 1275 2164 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13780 r0 *1 30.36,116.96
X$13780 73 1055 2258 1980 73 2259 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13782 r0 *1 32.66,116.96
X$13782 73 971 2076 1025 1235 73 2199 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $13785 r0 *1 40.02,116.96
X$13785 73 2200 1278 2262 971 2074 73 1788 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $13791 r0 *1 48.3,116.96
X$13791 73 971 1278 2015 2210 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13796 r0 *1 60.26,116.96
X$13796 73 2201 73 57 2202 57 sky130_fd_sc_hd__buf_4
* cell instance $13797 r0 *1 63.02,116.96
X$13797 73 2203 985 2128 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $13804 r0 *1 73.6,116.96
X$13804 73 2128 73 57 2205 57 sky130_fd_sc_hd__buf_4
* cell instance $13805 r0 *1 76.36,116.96
X$13805 73 1414 2127 1992 2019 2268 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13806 r0 *1 79.12,116.96
X$13806 73 2367 1150 1197 2270 57 1897 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $13807 r0 *1 81.88,116.96
X$13807 73 1150 2207 2270 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13808 r0 *1 83.26,116.96
X$13808 73 2020 2205 1238 1102 935 2207 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $13811 r0 *1 89.24,116.96
X$13811 73 1238 73 57 2120 57 sky130_fd_sc_hd__buf_4
* cell instance $13818 r0 *1 99.36,116.96
X$13818 73 1463 2208 2130 73 2132 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13819 r0 *1 101.2,116.96
X$13819 73 2209 2132 2210 1903 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13834 r0 *1 136.62,116.96
X$13834 73 914 2024 2275 685 2180 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13837 r0 *1 140.76,116.96
X$13837 73 684 73 57 2383 57 sky130_fd_sc_hd__buf_4
* cell instance $13847 r0 *1 158.7,116.96
X$13847 73 1744 2213 1714 73 2276 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13849 r0 *1 162.38,116.96
X$13849 73 2104 1941 1585 847 57 73 2183 57 sky130_fd_sc_hd__a31oi_1
* cell instance $13850 r0 *1 164.68,116.96
X$13850 73 843 2183 2277 57 73 2216 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13864 r0 *1 196.42,116.96
X$13864 73 2142 2620 2216 2099 57 2290 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $13868 r0 *1 202.4,116.96
X$13868 73 1585 2217 1246 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13871 r0 *1 205.62,116.96
X$13871 73 1584 996 2104 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13879 r0 *1 221.72,116.96
X$13879 57 2219 2218 2290 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $13880 r0 *1 229.08,116.96
X$13880 57 2291 2218 1643 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $13887 r0 *1 249.78,116.96
X$13887 73 257 2043 2293 57 73 2294 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13891 r0 *1 256.68,116.96
X$13891 73 690 73 57 1751 57 sky130_fd_sc_hd__buf_4
* cell instance $13894 r0 *1 260.36,116.96
X$13894 73 363 2297 1825 73 2296 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $13899 r0 *1 265.42,116.96
X$13899 73 856 2221 2297 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13901 r0 *1 267.72,116.96
X$13901 73 1862 2043 587 57 73 2221 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13905 r0 *1 274.62,116.96
X$13905 73 360 226 324 2222 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $13906 r0 *1 276.46,116.96
X$13906 73 360 1946 2222 258 2197 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13909 r0 *1 280.6,116.96
X$13909 73 2146 2197 1559 257 293 73 2223 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $13910 r0 *1 283.82,116.96
X$13910 73 2196 668 293 2223 57 73 2409 57 sky130_fd_sc_hd__a31oi_1
* cell instance $13914 r0 *1 290.26,116.96
X$13914 73 272 540 2412 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13920 r0 *1 297.62,116.96
X$13920 73 1751 587 251 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $13923 r0 *1 301.3,116.96
X$13923 73 258 2115 856 2147 251 2146 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $13924 r0 *1 304.98,116.96
X$13924 73 665 795 2413 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13926 r0 *1 307.28,116.96
X$13926 73 964 73 57 1477 57 sky130_fd_sc_hd__buf_4
* cell instance $13934 r0 *1 323.84,116.96
X$13934 73 856 540 2288 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $13935 r0 *1 325.22,116.96
X$13935 73 697 2147 2288 856 258 73 2226 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $13937 r0 *1 329.36,116.96
X$13937 73 2226 2189 923 73 2408 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $13960 r0 *1 378.58,116.96
X$13960 73 2286 73 57 2285 57 sky130_fd_sc_hd__buf_4
* cell instance $13984 r0 *1 433.78,116.96
X$13984 73 184 1401 2282 57 73 2281 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13985 r0 *1 435.62,116.96
X$13985 73 1169 2151 2150 2280 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $13987 r0 *1 437.92,116.96
X$13987 73 2057 1169 2151 57 73 2279 57 sky130_fd_sc_hd__a21oi_1
* cell instance $13989 r0 *1 443.44,116.96
X$13989 73 491 2057 2228 57 73 2278 57 sky130_fd_sc_hd__a21boi_0
* cell instance $13990 r0 *1 446.2,116.96
X$13990 57 15648 2153 1169 1483 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $13992 r0 *1 450.8,116.96
X$13992 73 1762 2107 139 1169 2228 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $13997 r0 *1 460,116.96
X$13997 73 1173 150 139 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14003 r0 *1 473.8,116.96
X$14003 73 2178 2230 2158 652 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $14007 r0 *1 478.4,116.96
X$14007 73 949 73 57 741 57 sky130_fd_sc_hd__buf_4
* cell instance $14011 r0 *1 485.76,116.96
X$14011 57 2158 156 2230 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $14012 r0 *1 489.9,116.96
X$14012 73 2233 2177 2060 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14016 r0 *1 499.56,116.96
X$14016 57 2237 2236 949 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $14025 r0 *1 526.24,116.96
X$14025 73 1014 2242 1090 57 73 2094 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14027 r0 *1 529.92,116.96
X$14027 73 1018 1905 2160 2064 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14031 r0 *1 534.06,116.96
X$14031 73 1018 2160 1898 2272 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14035 r0 *1 540.96,116.96
X$14035 57 15676 2267 872 1680 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $14038 r0 *1 547.86,116.96
X$14038 73 2086 73 57 2160 57 sky130_fd_sc_hd__buf_4
* cell instance $14039 r0 *1 550.62,116.96
X$14039 73 2172 73 57 1633 57 sky130_fd_sc_hd__buf_4
* cell instance $14041 r0 *1 557.06,116.96
X$14041 73 1014 2086 2266 57 73 2087 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14043 r0 *1 558.9,116.96
X$14043 73 2266 73 57 1090 57 sky130_fd_sc_hd__buf_4
* cell instance $14052 r0 *1 581.44,116.96
X$14052 57 2167 2362 874 1878 2257 2260 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $14056 r0 *1 589.26,116.96
X$14056 73 2249 1879 1267 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14057 r0 *1 590.64,116.96
X$14057 73 2165 1775 1092 73 2162 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14058 r0 *1 592.48,116.96
X$14058 73 2162 1267 2462 1876 1177 73 2257 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $14061 r0 *1 596.62,116.96
X$14061 73 1177 1893 2250 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14141 m0 *1 18.4,122.4
X$14141 57 2074 2353 2358 2354 2298 1932 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $14143 m0 *1 22.54,122.4
X$14143 73 2298 73 57 2256 57 sky130_fd_sc_hd__buf_4
* cell instance $14148 m0 *1 32.2,122.4
X$14148 73 971 2301 1440 57 73 2264 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14153 m0 *1 46,122.4
X$14153 73 2361 1275 2303 57 73 2258 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14154 m0 *1 47.84,122.4
X$14154 73 1054 73 57 2303 57 sky130_fd_sc_hd__buf_4
* cell instance $14157 m0 *1 54.74,122.4
X$14157 73 973 2170 2304 2264 57 2364 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $14161 m0 *1 60.26,122.4
X$14161 73 2202 73 57 1573 57 sky130_fd_sc_hd__buf_4
* cell instance $14165 m0 *1 69,122.4
X$14165 73 2202 1364 2204 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14168 m0 *1 72.68,122.4
X$14168 73 2204 73 57 1463 57 sky130_fd_sc_hd__buf_4
* cell instance $14172 m0 *1 81.42,122.4
X$14172 73 1370 1060 2470 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14177 m0 *1 86.02,122.4
X$14177 73 1025 1364 2312 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14178 m0 *1 87.4,122.4
X$14178 73 1199 73 57 2130 57 sky130_fd_sc_hd__buf_4
* cell instance $14180 m0 *1 90.62,122.4
X$14180 73 2271 2209 1901 2373 73 2655 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $14183 m0 *1 98.44,122.4
X$14183 73 2312 2130 1316 57 73 2374 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14184 m0 *1 100.28,122.4
X$14184 73 2312 73 57 2273 57 sky130_fd_sc_hd__buf_4
* cell instance $14185 m0 *1 103.04,122.4
X$14185 73 2273 2088 2130 73 2376 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14198 m0 *1 136.62,122.4
X$14198 73 2383 2275 2384 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14205 m0 *1 143.98,122.4
X$14205 73 726 816 2314 57 73 2211 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14207 m0 *1 146.28,122.4
X$14207 73 2212 2211 847 73 1814 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14208 m0 *1 148.12,122.4
X$14208 73 2027 875 730 57 73 2212 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14218 m0 *1 170.2,122.4
X$14218 57 15488 2214 1418 1584 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $14219 m0 *1 174.8,122.4
X$14219 73 2214 1325 2135 847 2215 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14221 m0 *1 178.48,122.4
X$14221 73 847 2319 2215 73 1588 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14233 m0 *1 209.3,122.4
X$14233 73 2186 2105 1160 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14234 m0 *1 210.68,122.4
X$14234 57 2217 686 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $14240 m0 *1 224.48,122.4
X$14240 57 2218 15437 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $14244 m0 *1 236.9,122.4
X$14244 73 2219 2399 73 129 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $14249 m0 *1 248.86,122.4
X$14249 73 1751 2401 2220 73 2293 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14252 m0 *1 253,122.4
X$14252 73 2325 2401 2295 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14253 m0 *1 254.38,122.4
X$14253 73 360 1753 2220 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14259 m0 *1 269.1,122.4
X$14259 57 15512 589 633 2043 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $14260 m0 *1 273.7,122.4
X$14260 73 589 587 324 856 2407 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14261 m0 *1 276.46,122.4
X$14261 73 589 2325 2115 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14268 m0 *1 285.66,122.4
X$14268 73 193 2409 2410 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14271 m0 *1 291.18,122.4
X$14271 57 2411 2113 1753 2190 2412 1727 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $14272 m0 *1 294.86,122.4
X$14272 57 15497 1001 1751 587 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $14273 m0 *1 299.46,122.4
X$14273 73 1001 779 856 73 2224 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14274 m0 *1 301.3,122.4
X$14274 73 2224 1727 2225 193 258 73 1954 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $14278 m0 *1 306.36,122.4
X$14278 73 2413 2115 193 2289 57 2225 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $14279 m0 *1 308.66,122.4
X$14279 73 272 423 2289 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14287 m0 *1 327.98,122.4
X$14287 73 1477 1961 2408 57 73 2287 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14306 m0 *1 377.66,122.4
X$14306 73 2402 2331 2284 2227 2403 2286 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $14316 m0 *1 402.96,122.4
X$14316 73 2283 2335 2331 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $14326 m0 *1 428.26,122.4
X$14326 57 230 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $14329 m0 *1 435.62,122.4
X$14329 57 2282 2184 2280 2278 2279 1963 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $14332 m0 *1 441.14,122.4
X$14332 73 1538 73 57 2395 57 sky130_fd_sc_hd__buf_4
* cell instance $14336 m0 *1 447.12,122.4
X$14336 73 2229 73 57 831 57 sky130_fd_sc_hd__buf_4
* cell instance $14338 m0 *1 450.34,122.4
X$14338 73 2154 150 2229 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14339 m0 *1 451.72,122.4
X$14339 73 1173 73 57 2154 57 sky130_fd_sc_hd__buf_4
* cell instance $14342 m0 *1 460,122.4
X$14342 73 405 73 57 768 57 sky130_fd_sc_hd__buf_4
* cell instance $14345 m0 *1 466.9,122.4
X$14345 73 2389 345 405 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14351 m0 *1 472.88,122.4
X$14351 73 2389 73 57 347 57 sky130_fd_sc_hd__buf_4
* cell instance $14354 m0 *1 480.24,122.4
X$14354 73 2340 2341 73 651 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $14355 m0 *1 483.46,122.4
X$14355 73 2342 119 2232 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $14356 m0 *1 485.76,122.4
X$14356 57 2230 2342 2234 2388 2231 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $14357 m0 *1 489.44,122.4
X$14357 57 2158 2231 2232 2235 2234 73 73 57 sky130_fd_sc_hd__a211oi_2
* cell instance $14358 m0 *1 494.04,122.4
X$14358 73 2232 2231 2235 2234 73 2177 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $14362 m0 *1 501.4,122.4
X$14362 57 1173 2236 2237 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $14364 m0 *1 508.3,122.4
X$14364 57 2344 230 2238 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $14365 m0 *1 515.66,122.4
X$14365 73 2385 2243 2239 2238 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $14368 m0 *1 519.8,122.4
X$14368 73 2380 2345 2096 2240 73 2239 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $14370 m0 *1 524.86,122.4
X$14370 73 2244 2094 1803 2274 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $14373 m0 *1 527.62,122.4
X$14373 73 1681 2346 1517 2377 2345 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14375 m0 *1 534.06,122.4
X$14375 73 1679 2067 2242 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $14379 m0 *1 542.34,122.4
X$14379 73 1014 1701 2246 73 2371 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14382 m0 *1 545.56,122.4
X$14382 73 1973 1876 2245 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14389 m0 *1 557.98,122.4
X$14389 73 2246 928 2266 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14392 m0 *1 564.88,122.4
X$14392 73 2265 1015 1344 73 2365 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14394 m0 *1 567.18,122.4
X$14394 73 2365 874 1356 2263 57 2348 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $14396 m0 *1 571.78,122.4
X$14396 73 928 2248 2068 73 2349 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14397 m0 *1 573.62,122.4
X$14397 57 2087 2261 2349 2245 2247 1018 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $14403 m0 *1 583.28,122.4
X$14403 73 2362 73 57 2363 57 sky130_fd_sc_hd__buf_4
* cell instance $14408 m0 *1 595.7,122.4
X$14408 73 2165 1092 1618 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14409 m0 *1 597.08,122.4
X$14409 73 2165 2080 2248 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14413 m0 *1 601.68,122.4
X$14413 73 2250 2552 2350 2254 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $14419 m0 *1 610.88,122.4
X$14419 73 2265 73 57 1972 57 sky130_fd_sc_hd__buf_4
* cell instance $14421 m0 *1 614.1,122.4
X$14421 73 2249 1775 2251 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14424 m0 *1 616.86,122.4
X$14424 73 2251 73 57 2351 57 sky130_fd_sc_hd__buf_4
* cell instance $14428 m0 *1 622.84,122.4
X$14428 73 2251 1092 2253 2352 2252 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $14449 r0 *1 18.4,122.4
X$14449 73 2353 73 57 2355 57 sky130_fd_sc_hd__buf_4
* cell instance $14450 r0 *1 21.16,122.4
X$14450 73 2299 2359 2452 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14452 r0 *1 23,122.4
X$14452 73 2122 2300 2453 2299 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14454 r0 *1 25.76,122.4
X$14454 73 971 2301 1440 2300 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14455 r0 *1 27.6,122.4
X$14455 73 2081 73 57 2301 57 sky130_fd_sc_hd__buf_4
* cell instance $14458 r0 *1 35.88,122.4
X$14458 73 2164 73 57 2360 57 sky130_fd_sc_hd__buf_4
* cell instance $14460 r0 *1 39.56,122.4
X$14460 73 1573 896 2417 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14461 r0 *1 40.94,122.4
X$14461 73 1573 1506 2079 2302 2359 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14465 r0 *1 44.62,122.4
X$14465 73 1235 73 57 2461 57 sky130_fd_sc_hd__buf_4
* cell instance $14470 r0 *1 56.12,122.4
X$14470 73 1572 2364 1738 73 2464 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14473 r0 *1 60.26,122.4
X$14473 73 986 2017 2304 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14476 r0 *1 63.02,122.4
X$14476 73 2304 2305 2019 73 2302 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14483 r0 *1 72.22,122.4
X$14483 73 2306 2304 2612 2366 2307 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $14486 r0 *1 76.82,122.4
X$14486 73 2418 1287 2368 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14487 r0 *1 78.2,122.4
X$14487 73 2368 979 2369 57 73 2367 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14488 r0 *1 80.04,122.4
X$14488 73 1572 2206 2308 2309 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14489 r0 *1 81.88,122.4
X$14489 57 2019 2471 2370 2310 2208 2020 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $14491 r0 *1 85.56,122.4
X$14491 73 1572 2471 2311 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14492 r0 *1 86.94,122.4
X$14492 73 2311 1572 2307 57 73 1899 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14494 r0 *1 89.7,122.4
X$14494 73 2205 1370 2120 2366 2474 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $14496 r0 *1 92.46,122.4
X$14496 73 2419 1235 1901 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14502 r0 *1 99.36,122.4
X$14502 73 1572 2374 2309 73 2375 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14504 r0 *1 103.04,122.4
X$14504 73 2305 73 57 2313 57 sky130_fd_sc_hd__buf_4
* cell instance $14518 r0 *1 137.08,122.4
X$14518 73 1742 1851 2384 2212 57 2381 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $14525 r0 *1 152.26,122.4
X$14525 73 726 730 2315 57 73 2480 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14527 r0 *1 154.56,122.4
X$14527 73 1941 733 2316 57 73 2481 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14528 r0 *1 156.4,122.4
X$14528 73 2026 1528 2387 73 2316 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14529 r0 *1 158.24,122.4
X$14529 73 726 2026 2387 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14532 r0 *1 163.76,122.4
X$14532 73 1328 2318 1528 2027 2317 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14533 r0 *1 166.52,122.4
X$14533 73 2027 2589 2317 73 2277 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14534 r0 *1 168.36,122.4
X$14534 73 1325 1211 2315 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14542 r0 *1 182.62,122.4
X$14542 73 733 1418 1849 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14547 r0 *1 194.12,122.4
X$14547 73 685 875 2321 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14548 r0 *1 195.5,122.4
X$14548 73 952 2321 2498 73 2323 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14550 r0 *1 198.26,122.4
X$14550 73 2320 1211 2429 735 2322 2392 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $14553 r0 *1 203.78,122.4
X$14553 73 996 1660 1851 2320 73 2499 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $14560 r0 *1 215.28,122.4
X$14560 73 1048 2394 1917 2324 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $14561 r0 *1 217.12,122.4
X$14561 73 2323 1048 824 2324 57 2503 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $14564 r0 *1 224.48,122.4
X$14564 57 96 2218 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $14574 r0 *1 248.86,122.4
X$14574 73 856 258 2401 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14577 r0 *1 254.38,122.4
X$14577 73 2401 2043 587 258 2508 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $14582 r0 *1 261.74,122.4
X$14582 73 360 587 2325 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14587 r0 *1 268.64,122.4
X$14587 73 226 258 2405 2325 1070 73 2406 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $14594 r0 *1 286.12,122.4
X$14594 73 2410 193 1073 57 73 2514 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14596 r0 *1 287.96,122.4
X$14596 57 293 2411 193 2326 1409 2513 73 73 57 sky130_fd_sc_hd__o221a_2
* cell instance $14613 r0 *1 327.06,122.4
X$14613 73 923 2406 2118 2327 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14614 r0 *1 328.9,122.4
X$14614 73 923 2329 2327 1477 2328 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14615 r0 *1 331.66,122.4
X$14615 57 251 2330 856 1165 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $14628 r0 *1 362.94,122.4
X$14628 57 2404 2403 2227 2491 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $14635 r0 *1 379.04,122.4
X$14635 57 15593 3029 2334 2438 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $14643 r0 *1 397.9,122.4
X$14643 73 2333 2332 2400 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14644 r0 *1 399.28,122.4
X$14644 73 2334 73 57 2333 57 sky130_fd_sc_hd__buf_4
* cell instance $14649 r0 *1 405.26,122.4
X$14649 73 2439 2397 2283 3071 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $14650 r0 *1 407.1,122.4
X$14650 73 2332 73 57 2335 57 sky130_fd_sc_hd__buf_4
* cell instance $14651 r0 *1 409.86,122.4
X$14651 73 2403 2491 2336 2337 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14652 r0 *1 411.7,122.4
X$14652 73 2337 2537 2487 2398 2336 2396 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $14660 r0 *1 430.56,122.4
X$14660 57 2390 230 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $14663 r0 *1 445.28,122.4
X$14663 73 2395 150 2179 57 73 2484 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14664 r0 *1 447.12,122.4
X$14664 73 1763 73 57 2393 57 sky130_fd_sc_hd__buf_4
* cell instance $14667 r0 *1 451.72,122.4
X$14667 73 2107 73 57 2338 57 sky130_fd_sc_hd__buf_4
* cell instance $14669 r0 *1 454.94,122.4
X$14669 73 1963 1677 115 2339 2391 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14672 r0 *1 459.08,122.4
X$14672 73 1963 2338 1703 73 2479 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14673 r0 *1 460.92,122.4
X$14673 73 1173 73 57 2339 57 sky130_fd_sc_hd__buf_4
* cell instance $14680 r0 *1 479.32,122.4
X$14680 73 2340 2341 2389 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $14681 r0 *1 482.54,122.4
X$14681 73 2656 2342 84 57 73 2340 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14685 r0 *1 486.68,122.4
X$14685 73 2342 119 2388 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $14686 r0 *1 488.98,122.4
X$14686 73 2342 2234 2388 2231 2233 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14693 r0 *1 507.38,122.4
X$14693 73 1979 1893 2343 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14694 r0 *1 508.76,122.4
X$14694 73 2343 73 57 2241 57 sky130_fd_sc_hd__buf_4
* cell instance $14700 r0 *1 515.66,122.4
X$14700 73 2382 73 57 2385 57 sky130_fd_sc_hd__buf_4
* cell instance $14704 r0 *1 529.46,122.4
X$14704 73 1803 1346 2379 2263 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $14706 r0 *1 531.3,122.4
X$14706 73 2272 2378 2269 57 73 2377 57 sky130_fd_sc_hd__a21o_1
* cell instance $14713 r0 *1 545.56,122.4
X$14713 73 2245 73 57 2244 57 sky130_fd_sc_hd__buf_4
* cell instance $14714 r0 *1 548.32,122.4
X$14714 73 2371 73 57 2372 57 sky130_fd_sc_hd__buf_4
* cell instance $14716 r0 *1 552.92,122.4
X$14716 73 2347 1614 1633 2241 57 73 2467 57 sky130_fd_sc_hd__a31oi_1
* cell instance $14717 r0 *1 555.22,122.4
X$14717 73 2168 2269 2347 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14722 r0 *1 559.82,122.4
X$14722 73 2241 73 57 1503 57 sky130_fd_sc_hd__buf_4
* cell instance $14731 r0 *1 584.2,122.4
X$14731 73 2265 73 57 2246 57 sky130_fd_sc_hd__buf_4
* cell instance $14742 r0 *1 606.28,122.4
X$14742 73 928 2248 2351 57 73 2457 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14743 r0 *1 608.12,122.4
X$14743 73 2248 2356 2456 2357 1681 73 2350 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $14817 m0 *1 17.48,127.84
X$14817 73 985 2271 2451 57 73 2414 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14818 m0 *1 19.32,127.84
X$14818 57 2450 1731 2255 2452 2548 1348 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $14821 m0 *1 24.38,127.84
X$14821 73 1275 2015 2415 2453 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14826 m0 *1 33.12,127.84
X$14826 73 1275 2455 2415 2458 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14827 m0 *1 34.96,127.84
X$14827 73 1781 73 57 2416 57 sky130_fd_sc_hd__buf_4
* cell instance $14828 m0 *1 37.72,127.84
X$14828 73 2417 73 57 2415 57 sky130_fd_sc_hd__buf_4
* cell instance $14831 m0 *1 45.08,127.84
X$14831 73 2170 2461 2416 1413 971 2557 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $14833 m0 *1 48.76,127.84
X$14833 73 1101 2015 2416 2308 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14844 m0 *1 74.52,127.84
X$14844 73 1363 73 57 2366 57 sky130_fd_sc_hd__buf_4
* cell instance $14845 m0 *1 77.28,127.84
X$14845 73 986 2019 2418 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14846 m0 *1 78.66,127.84
X$14846 73 2310 2418 1459 73 2469 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14847 m0 *1 80.5,127.84
X$14847 73 1370 1364 2310 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14848 m0 *1 81.88,127.84
X$14848 73 2470 73 57 979 57 sky130_fd_sc_hd__buf_4
* cell instance $14854 m0 *1 93.38,127.84
X$14854 73 2019 1572 2473 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14858 m0 *1 97.98,127.84
X$14858 73 2420 2473 1580 1316 1287 2572 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $14859 m0 *1 101.2,127.84
X$14859 73 2209 2088 2313 2421 73 57 2577 57 sky130_fd_sc_hd__o31ai_1
* cell instance $14860 m0 *1 103.96,127.84
X$14860 73 2130 2419 2209 57 73 2421 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14861 m0 *1 105.8,127.84
X$14861 73 2209 2474 2475 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14879 m0 *1 147.66,127.84
X$14879 73 658 907 1112 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14880 m0 *1 149.04,127.84
X$14880 73 2027 1583 2422 57 73 1153 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14881 m0 *1 150.88,127.84
X$14881 73 2422 1464 2480 726 2423 73 2482 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $14882 m0 *1 154.1,127.84
X$14882 73 2481 2485 1160 2486 57 2427 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $14889 m0 *1 172.5,127.84
X$14889 73 2424 2429 2135 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14892 m0 *1 175.26,127.84
X$14892 73 2137 1743 2425 2426 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $14893 m0 *1 178.02,127.84
X$14893 73 2426 1037 2427 758 57 2493 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $14896 m0 *1 182.62,127.84
X$14896 57 1849 2495 2143 1325 847 1418 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $14899 m0 *1 190.44,127.84
X$14899 73 1453 73 57 2424 57 sky130_fd_sc_hd__buf_4
* cell instance $14903 m0 *1 195.96,127.84
X$14903 73 726 2428 2318 1242 685 2498 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $14904 m0 *1 199.18,127.84
X$14904 73 2428 1418 2429 996 1392 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $14908 m0 *1 210.68,127.84
X$14908 73 2766 2499 1066 1160 57 73 2502 57 sky130_fd_sc_hd__a31oi_1
* cell instance $14912 m0 *1 218.04,127.84
X$14912 73 2579 2502 2503 2195 57 2603 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $14927 m0 *1 252.08,127.84
X$14927 73 633 587 2430 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14928 m0 *1 253.46,127.84
X$14928 73 2430 73 57 1424 57 sky130_fd_sc_hd__buf_4
* cell instance $14929 m0 *1 256.22,127.84
X$14929 73 633 2508 2431 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14932 m0 *1 258.98,127.84
X$14932 73 258 480 2510 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $14933 m0 *1 260.36,127.84
X$14933 73 2198 2509 923 2431 2505 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14934 m0 *1 263.12,127.84
X$14934 57 15511 2432 633 587 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $14937 m0 *1 269.1,127.84
X$14937 73 2432 856 2405 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14946 m0 *1 288.42,127.84
X$14946 73 856 592 193 73 2326 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14948 m0 *1 291.18,127.84
X$14948 73 2513 923 2601 57 73 2433 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14952 m0 *1 298.08,127.84
X$14952 73 964 2433 1955 73 2512 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14953 m0 *1 299.92,127.84
X$14953 73 856 226 251 57 73 2511 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14957 m0 *1 306.36,127.84
X$14957 73 856 2193 344 2506 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14958 m0 *1 308.2,127.84
X$14958 57 856 2507 363 1597 2049 2506 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $14960 m0 *1 315.1,127.84
X$14960 73 344 251 2434 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14961 m0 *1 316.48,127.84
X$14961 73 2434 272 258 2330 57 2504 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $14964 m0 *1 320.62,127.84
X$14964 73 923 2529 2505 257 2435 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $14966 m0 *1 324.3,127.84
X$14966 73 856 2147 251 57 73 2593 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14967 m0 *1 326.14,127.84
X$14967 73 193 2287 1139 2500 73 57 2501 57 sky130_fd_sc_hd__o31ai_1
* cell instance $14968 m0 *1 328.9,127.84
X$14968 73 193 2435 2328 2500 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14979 m0 *1 356.5,127.84
X$14979 73 2436 2588 2491 73 2437 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $14987 m0 *1 374.44,127.84
X$14987 73 2436 2492 2580 2917 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $14990 m0 *1 379.04,127.84
X$14990 73 2488 2436 2497 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $14991 m0 *1 380.42,127.84
X$14991 73 2438 2497 2437 57 73 2494 57 sky130_fd_sc_hd__a21oi_1
* cell instance $14994 m0 *1 386.86,127.84
X$14994 73 2438 2334 2496 2536 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $15001 m0 *1 402.5,127.84
X$15001 57 15568 2439 2335 2398 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $15004 m0 *1 408.48,127.84
X$15004 73 2439 2440 2571 2336 2492 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $15005 m0 *1 411.24,127.84
X$15005 73 2403 2491 2397 2440 73 57 2441 57 sky130_fd_sc_hd__o31ai_1
* cell instance $15006 m0 *1 414,127.84
X$15006 73 2335 2488 2397 57 73 2487 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15010 m0 *1 417.68,127.84
X$15010 73 2575 2441 2396 2440 2489 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $15019 m0 *1 444.36,127.84
X$15019 73 1603 2484 2281 2442 57 2483 73 57 sky130_fd_sc_hd__nor4b_1
* cell instance $15021 m0 *1 449.42,127.84
X$15021 73 2339 2393 1535 2443 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $15022 m0 *1 451.26,127.84
X$15022 73 2443 1532 768 73 2442 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15027 m0 *1 460,127.84
X$15027 73 768 2478 2479 2635 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15028 m0 *1 461.84,127.84
X$15028 57 2339 2478 371 2477 883 2391 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $15036 m0 *1 481.16,127.84
X$15036 57 1488 150 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $15037 m0 *1 488.52,127.84
X$15037 57 2566 371 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $15047 m0 *1 514.74,127.84
X$15047 73 3065 2274 2476 2444 73 57 2382 57 sky130_fd_sc_hd__o31ai_1
* cell instance $15048 m0 *1 517.5,127.84
X$15048 73 1182 2445 2241 57 73 2476 57 sky130_fd_sc_hd__a21o_1
* cell instance $15052 m0 *1 523.48,127.84
X$15052 73 2267 1681 928 2459 73 57 2445 57 sky130_fd_sc_hd__o31ai_1
* cell instance $15057 m0 *1 529.46,127.84
X$15057 73 1014 2472 2242 57 73 2379 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15064 m0 *1 548.32,127.84
X$15064 73 2244 2454 2467 73 2468 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15079 m0 *1 583.28,127.84
X$15079 73 1178 2083 939 73 2465 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15080 m0 *1 585.12,127.84
X$15080 73 1876 2446 2465 2466 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15081 m0 *1 586.96,127.84
X$15081 73 1775 1100 1262 1879 73 2446 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $15083 m0 *1 590.18,127.84
X$15083 73 2463 73 57 1100 57 sky130_fd_sc_hd__buf_4
* cell instance $15085 m0 *1 594.78,127.84
X$15085 73 1876 2542 2447 57 73 2462 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15088 m0 *1 598,127.84
X$15088 73 2460 73 57 939 57 sky130_fd_sc_hd__buf_4
* cell instance $15096 m0 *1 612.26,127.84
X$15096 73 1876 2447 2448 57 73 2456 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15099 m0 *1 618.24,127.84
X$15099 57 2448 1262 1886 2253 1879 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $15121 r0 *1 17.48,127.84
X$15121 73 2515 2414 1146 73 2545 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15123 r0 *1 19.78,127.84
X$15123 73 2451 73 57 2517 57 sky130_fd_sc_hd__buf_4
* cell instance $15124 r0 *1 22.54,127.84
X$15124 73 2516 2551 2517 2122 1977 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $15127 r0 *1 29.44,127.84
X$15127 73 2127 73 57 1934 57 sky130_fd_sc_hd__buf_4
* cell instance $15131 r0 *1 37.26,127.84
X$15131 73 1275 1413 2416 2554 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15132 r0 *1 39.1,127.84
X$15132 73 971 979 2517 2553 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15138 r0 *1 46,127.84
X$15138 73 1572 2557 2556 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15141 r0 *1 51.52,127.84
X$15141 73 2518 2360 896 3057 57 73 2558 57 sky130_fd_sc_hd__a31oi_1
* cell instance $15143 r0 *1 57.5,127.84
X$15143 73 2558 2464 2561 1738 2559 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $15144 r0 *1 59.8,127.84
X$15144 73 1572 1986 2563 73 2561 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15148 r0 *1 64.86,127.84
X$15148 57 2519 2677 2518 2303 2304 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $15155 r0 *1 75.44,127.84
X$15155 73 1572 2519 2469 57 73 2851 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15158 r0 *1 80.04,127.84
X$15158 73 2369 2366 2019 57 73 1797 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15163 r0 *1 93.38,127.84
X$15163 73 2473 73 57 2567 57 sky130_fd_sc_hd__buf_4
* cell instance $15164 r0 *1 96.14,127.84
X$15164 73 2366 2570 2473 2569 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $15169 r0 *1 99.82,127.84
X$15169 73 980 1580 986 73 2574 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15170 r0 *1 101.66,127.84
X$15170 73 1831 2572 2577 57 73 2573 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15183 r0 *1 136.16,127.84
X$15183 73 2381 685 2520 57 73 2521 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15184 r0 *1 138,127.84
X$15184 73 2521 73 57 2579 57 sky130_fd_sc_hd__buf_4
* cell instance $15185 r0 *1 140.76,127.84
X$15185 73 2026 3066 2584 73 2520 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15188 r0 *1 148.12,127.84
X$15188 73 2027 2581 1112 2585 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15190 r0 *1 150.42,127.84
X$15190 57 2027 2584 2026 2586 2424 2585 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $15196 r0 *1 160.08,127.84
X$15196 73 2104 2581 726 2003 57 73 2590 57 sky130_fd_sc_hd__a31oi_1
* cell instance $15200 r0 *1 168.36,127.84
X$15200 73 2522 1585 2318 57 73 2589 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15201 r0 *1 170.2,127.84
X$15201 73 2424 685 1585 2592 57 2522 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $15209 r0 *1 184,127.84
X$15209 57 1418 2878 2423 2586 2424 823 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $15211 r0 *1 189.06,127.84
X$15211 57 2758 2595 726 733 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $15216 r0 *1 200.56,127.84
X$15216 73 728 2597 2322 1453 2429 1302 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $15227 r0 *1 222.18,127.84
X$15227 57 2605 2218 2603 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $15234 r0 *1 240.12,127.84
X$15234 57 76 2607 2606 2292 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $15238 r0 *1 257.6,127.84
X$15238 57 2509 2510 258 360 1070 1424 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $15241 r0 *1 261.28,127.84
X$15241 73 592 2193 2604 360 1753 73 2625 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $15243 r0 *1 264.96,127.84
X$15243 73 2432 360 2604 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15247 r0 *1 274.16,127.84
X$15247 57 856 2602 193 2525 1424 2407 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $15250 r0 *1 278.76,127.84
X$15250 73 1070 480 2525 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15252 r0 *1 283.82,127.84
X$15252 73 2599 2602 1753 1945 57 73 2601 57 sky130_fd_sc_hd__a31oi_1
* cell instance $15261 r0 *1 300.38,127.84
X$15261 73 2330 2511 257 73 2598 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15262 r0 *1 302.22,127.84
X$15262 73 423 1072 272 2330 57 73 2526 57 sky130_fd_sc_hd__a31oi_1
* cell instance $15265 r0 *1 305.9,127.84
X$15265 73 363 2526 2507 73 2596 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15269 r0 *1 313.72,127.84
X$15269 73 272 859 2594 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15272 r0 *1 316.02,127.84
X$15272 73 736 856 587 73 2527 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15273 r0 *1 317.86,127.84
X$15273 73 856 423 2527 73 2528 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15276 r0 *1 320.62,127.84
X$15276 73 2504 258 2528 57 73 2529 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15278 r0 *1 324.3,127.84
X$15278 73 258 2330 2593 2630 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $15292 r0 *1 354.66,127.84
X$15292 73 2397 2591 2783 57 73 2530 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15294 r0 *1 356.96,127.84
X$15294 73 2227 2583 2588 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15295 r0 *1 358.34,127.84
X$15295 73 2661 2531 2530 73 2587 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15298 r0 *1 362.94,127.84
X$15298 73 2532 2404 2531 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15299 r0 *1 364.32,127.84
X$15299 73 2583 2404 3078 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15303 r0 *1 371.22,127.84
X$15303 73 2336 2582 2532 57 73 2533 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15304 r0 *1 373.06,127.84
X$15304 73 2535 2534 2533 73 2580 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15306 r0 *1 375.36,127.84
X$15306 73 2403 2491 2583 73 2534 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15308 r0 *1 380.88,127.84
X$15308 57 15656 2578 2488 2438 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $15310 r0 *1 385.94,127.84
X$15310 73 2536 73 57 2535 57 sky130_fd_sc_hd__buf_4
* cell instance $15320 r0 *1 407.56,127.84
X$15320 73 2400 73 57 2537 57 sky130_fd_sc_hd__buf_4
* cell instance $15323 r0 *1 414.46,127.84
X$15323 73 2488 2335 2576 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15326 r0 *1 418.14,127.84
X$15326 73 2336 2698 2538 57 73 2575 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15328 r0 *1 420.44,127.84
X$15328 73 2440 2538 2700 2571 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15332 r0 *1 423.66,127.84
X$15332 73 2398 2488 2538 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15350 r0 *1 460.92,127.84
X$15350 73 1996 73 57 2657 57 sky130_fd_sc_hd__buf_4
* cell instance $15362 r0 *1 489.44,127.84
X$15362 57 2565 2636 2566 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $15375 r0 *1 526.24,127.84
X$15375 57 1973 2564 1876 1803 2539 2093 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $15376 r0 *1 529.46,127.84
X$15376 73 1014 2242 2560 57 73 2539 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15380 r0 *1 532.68,127.84
X$15380 73 1491 928 2472 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15382 r0 *1 537.74,127.84
X$15382 73 1876 2562 2466 1681 3132 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $15404 r0 *1 590.18,127.84
X$15404 73 1775 2463 2460 1178 73 2447 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $15405 r0 *1 592.94,127.84
X$15405 73 2460 73 57 2352 57 sky130_fd_sc_hd__buf_4
* cell instance $15408 r0 *1 598,127.84
X$15408 57 2552 2372 1876 2555 2546 2540 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $15411 r0 *1 605.82,127.84
X$15411 73 2541 73 57 2459 57 sky130_fd_sc_hd__buf_4
* cell instance $15412 r0 *1 608.58,127.84
X$15412 73 2550 1439 928 73 2541 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15418 r0 *1 620.54,127.84
X$15418 73 2448 2549 2547 73 2454 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $15432 r0 *1 653.2,127.84
X$15432 73 2449 57 73 2544 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $15488 m0 *1 19.78,133.28
X$15488 73 1102 2516 2451 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15491 m0 *1 22.54,133.28
X$15491 57 15460 2641 1275 1093 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $15492 m0 *1 27.14,133.28
X$15492 73 2642 73 57 1440 57 sky130_fd_sc_hd__buf_4
* cell instance $15495 m0 *1 32.2,133.28
X$15495 73 2672 73 57 2455 57 sky130_fd_sc_hd__buf_4
* cell instance $15497 m0 *1 36.8,133.28
X$15497 73 1413 1934 971 2643 57 73 2646 57 sky130_fd_sc_hd__a31oi_1
* cell instance $15498 m0 *1 39.1,133.28
X$15498 73 971 1413 2417 57 73 2643 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15507 m0 *1 60.72,133.28
X$15507 73 1574 73 57 1359 57 sky130_fd_sc_hd__buf_4
* cell instance $15508 m0 *1 63.48,133.28
X$15508 57 15557 2611 2019 986 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $15512 m0 *1 73.14,133.28
X$15512 73 1647 2612 2568 1572 2563 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $15515 m0 *1 78.66,133.28
X$15515 73 1651 73 57 935 57 sky130_fd_sc_hd__buf_4
* cell instance $15517 m0 *1 83.26,133.28
X$15517 73 975 2653 2567 2680 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15519 m0 *1 85.56,133.28
X$15519 73 2130 975 2081 57 73 2652 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15523 m0 *1 90.62,133.28
X$15523 73 2613 986 2120 935 2614 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $15524 m0 *1 92.92,133.28
X$15524 73 2613 986 2130 2370 73 2568 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $15527 m0 *1 97.52,133.28
X$15527 57 2659 2567 986 2017 935 2570 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $15528 m0 *1 100.74,133.28
X$15528 73 2130 2209 2570 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15546 m0 *1 141.68,133.28
X$15546 73 1585 907 1464 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15552 m0 *1 159.62,133.28
X$15552 73 2315 2663 2029 2616 57 2523 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $15559 m0 *1 171.58,133.28
X$15559 73 2523 73 57 2621 57 sky130_fd_sc_hd__buf_4
* cell instance $15560 m0 *1 174.34,133.28
X$15560 73 685 1325 2592 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15561 m0 *1 175.72,133.28
X$15561 73 2592 2617 1418 73 2618 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15565 m0 *1 182.62,133.28
X$15565 73 2493 73 57 2619 57 sky130_fd_sc_hd__buf_4
* cell instance $15573 m0 *1 197.34,133.28
X$15573 73 2586 2617 2428 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15574 m0 *1 198.72,133.28
X$15574 73 733 2600 1453 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15575 m0 *1 200.1,133.28
X$15575 73 2622 73 57 1537 57 sky130_fd_sc_hd__buf_4
* cell instance $15576 m0 *1 202.86,133.28
X$15576 73 2143 996 2617 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15579 m0 *1 205.62,133.28
X$15579 73 1418 686 2622 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15580 m0 *1 207,133.28
X$15580 73 2623 2622 1711 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15581 m0 *1 208.38,133.28
X$15581 73 726 2600 2623 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15583 m0 *1 210.68,133.28
X$15583 73 1711 73 57 2769 57 sky130_fd_sc_hd__buf_4
* cell instance $15584 m0 *1 213.44,133.28
X$15584 73 2768 1066 2984 2621 57 2194 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $15592 m0 *1 229.08,133.28
X$15592 57 2669 2606 2619 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $15602 m0 *1 257.14,133.28
X$15602 73 588 73 57 2043 57 sky130_fd_sc_hd__buf_4
* cell instance $15603 m0 *1 259.9,133.28
X$15603 73 2625 2296 257 73 2626 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15604 m0 *1 261.74,133.28
X$15604 73 257 2524 2626 923 2667 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $15605 m0 *1 264.5,133.28
X$15605 73 363 73 57 1753 57 sky130_fd_sc_hd__buf_4
* cell instance $15611 m0 *1 282.44,133.28
X$15611 73 2628 736 587 57 73 962 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15612 m0 *1 284.28,133.28
X$15612 73 665 587 2628 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15613 m0 *1 285.66,133.28
X$15613 73 272 852 2628 2666 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $15617 m0 *1 290.72,133.28
X$15617 73 1001 856 253 2113 2599 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $15618 m0 *1 293.48,133.28
X$15618 73 856 2525 779 2665 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $15629 m0 *1 316.48,133.28
X$15629 73 2629 73 57 257 57 sky130_fd_sc_hd__buf_4
* cell instance $15630 m0 *1 319.24,133.28
X$15630 73 2594 2662 258 2630 57 73 2524 57 sky130_fd_sc_hd__a31oi_1
* cell instance $15632 m0 *1 322,133.28
X$15632 73 665 856 2662 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15649 m0 *1 363.4,133.28
X$15649 73 2631 73 57 2661 57 sky130_fd_sc_hd__buf_4
* cell instance $15653 m0 *1 373.98,133.28
X$15653 73 2583 2535 2632 2436 73 57 2631 57 sky130_fd_sc_hd__o31ai_1
* cell instance $15658 m0 *1 386.86,133.28
X$15658 73 2536 2632 2583 73 2633 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15684 m0 *1 454.48,133.28
X$15684 73 2657 2658 2635 2867 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15696 m0 *1 482.54,133.28
X$15696 73 2342 2654 2656 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15699 m0 *1 488.06,133.28
X$15699 57 1488 2636 2565 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $15716 m0 *1 528.54,133.28
X$15716 73 2555 2651 1874 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15719 m0 *1 532.68,133.28
X$15719 73 2472 73 57 1905 57 sky130_fd_sc_hd__buf_4
* cell instance $15722 m0 *1 536.82,133.28
X$15722 73 2267 1679 2858 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15723 m0 *1 538.2,133.28
X$15723 73 2067 2649 1280 1905 1018 2562 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $15726 m0 *1 545.56,133.28
X$15726 73 2083 73 57 2649 57 sky130_fd_sc_hd__buf_4
* cell instance $15729 m0 *1 549.7,133.28
X$15729 73 2648 2083 2172 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15735 m0 *1 556.6,133.28
X$15735 73 2733 73 57 1436 57 sky130_fd_sc_hd__buf_4
* cell instance $15738 m0 *1 564.88,133.28
X$15738 73 2638 73 57 1491 57 sky130_fd_sc_hd__buf_4
* cell instance $15742 m0 *1 575.92,133.28
X$15742 73 2637 928 2247 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15749 m0 *1 585.58,133.28
X$15749 73 2637 1178 2639 73 2260 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15750 m0 *1 587.42,133.28
X$15750 73 1971 2637 928 2639 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15753 m0 *1 592.02,133.28
X$15753 57 15552 2460 2265 1971 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $15760 m0 *1 610.88,133.28
X$15760 73 1092 1973 2550 57 73 1620 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15788 r0 *1 23.46,133.28
X$15788 73 2608 2015 2516 2641 1995 2674 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $15789 r0 *1 26.68,133.28
X$15789 73 1647 896 2642 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15795 r0 *1 41.86,133.28
X$15795 73 971 2015 2417 2722 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15798 r0 *1 44.16,133.28
X$15798 73 1098 2673 2645 2609 2556 2848 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $15799 r0 *1 47.84,133.28
X$15799 73 2645 2647 2674 57 73 2673 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15804 r0 *1 56.58,133.28
X$15804 73 2120 2675 2676 73 2647 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15807 r0 *1 59.8,133.28
X$15807 73 1460 2611 1461 57 73 2676 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15810 r0 *1 65.78,133.28
X$15810 73 1459 1101 2017 73 2610 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15811 r0 *1 67.62,133.28
X$15811 73 2727 2610 2017 2611 2681 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $15813 r0 *1 69.92,133.28
X$15813 73 2728 1101 2306 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15816 r0 *1 72.22,133.28
X$15816 73 1364 2306 2551 2679 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $15821 r0 *1 80.96,133.28
X$15821 73 1364 1797 2679 1572 2731 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $15823 r0 *1 84.18,133.28
X$15823 73 2672 73 57 2653 57 sky130_fd_sc_hd__buf_4
* cell instance $15826 r0 *1 92.46,133.28
X$15826 57 2209 2732 2803 2652 2614 2655 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $15832 r0 *1 99.36,133.28
X$15832 57 2677 2735 2017 2574 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $15833 r0 *1 101.66,133.28
X$15833 73 2210 73 57 2736 57 sky130_fd_sc_hd__buf_4
* cell instance $15849 r0 *1 147.66,133.28
X$15849 73 991 1325 2581 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15853 r0 *1 151.8,133.28
X$15853 73 1242 907 2615 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15857 r0 *1 155.02,133.28
X$15857 73 2615 73 57 1583 57 sky130_fd_sc_hd__buf_4
* cell instance $15859 r0 *1 158.24,133.28
X$15859 73 726 2581 2615 57 73 2616 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15860 r0 *1 160.08,133.28
X$15860 73 1418 2586 2663 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15865 r0 *1 176.18,133.28
X$15865 73 2748 847 2618 2685 73 2425 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $15868 r0 *1 178.94,133.28
X$15868 73 1122 1325 2423 2616 57 2752 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $15871 r0 *1 182.62,133.28
X$15871 57 685 2753 2758 2752 2495 2757 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $15876 r0 *1 198.72,133.28
X$15876 73 2617 1851 996 57 73 2760 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15878 r0 *1 201.48,133.28
X$15878 57 1048 2765 632 1295 1214 2617 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $15881 r0 *1 206.54,133.28
X$15881 73 2623 73 57 848 57 sky130_fd_sc_hd__buf_4
* cell instance $15884 r0 *1 210.22,133.28
X$15884 73 686 1942 2624 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15886 r0 *1 212.52,133.28
X$15886 73 2624 2143 2769 57 73 2768 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15890 r0 *1 222.18,133.28
X$15890 57 2774 2606 1807 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $15895 r0 *1 232.76,133.28
X$15895 73 2606 73 57 15425 57 sky130_fd_sc_hd__clkinvlp_4
* cell instance $15900 r0 *1 238.28,133.28
X$15900 57 2668 2606 2781 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $15901 r0 *1 245.64,133.28
X$15901 57 2983 2784 2043 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $15904 r0 *1 257.14,133.28
X$15904 57 2627 2784 856 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $15909 r0 *1 267.26,133.28
X$15909 73 2787 2627 73 97 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $15912 r0 *1 273.24,133.28
X$15912 73 2792 73 57 2790 57 sky130_fd_sc_hd__buf_4
* cell instance $15922 r0 *1 293.02,133.28
X$15922 73 2665 2666 964 73 2664 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $15923 r0 *1 294.86,133.28
X$15923 73 2598 2664 1753 1595 57 73 2796 57 sky130_fd_sc_hd__a31oi_1
* cell instance $15926 r0 *1 304.52,133.28
X$15926 73 2596 964 253 2795 57 2789 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $15930 r0 *1 313.72,133.28
X$15930 73 76 2785 65 73 2629 57 57 sky130_fd_sc_hd__a21oi_2
* cell instance $15949 r0 *1 355.58,133.28
X$15949 73 2661 2583 2782 57 73 2691 57 sky130_fd_sc_hd__a21oi_1
* cell instance $15958 r0 *1 375.36,133.28
X$15958 73 2632 73 57 2773 57 sky130_fd_sc_hd__buf_4
* cell instance $15961 r0 *1 380.88,133.28
X$15961 73 2693 2491 2632 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $15969 r0 *1 399.28,133.28
X$15969 57 2701 2695 2400 2770 2966 2696 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $15978 r0 *1 420.9,133.28
X$15978 73 2759 2633 2701 2634 2397 73 2754 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $15980 r0 *1 424.12,133.28
X$15980 73 2634 2633 2750 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $15988 r0 *1 443.44,133.28
X$15988 57 2747 2749 2483 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $15997 r0 *1 462.3,133.28
X$15997 73 2538 73 57 2746 57 sky130_fd_sc_hd__buf_4
* cell instance $16009 r0 *1 491.74,133.28
X$16009 57 2636 81 2745 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $16021 r0 *1 518.42,133.28
X$16021 73 1014 1280 1013 57 73 2742 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16027 r0 *1 532.22,133.28
X$16027 73 1014 1905 1280 2650 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $16028 r0 *1 534.06,133.28
X$16028 73 1191 2650 1635 1967 57 73 2704 57 sky130_fd_sc_hd__a31oi_1
* cell instance $16035 r0 *1 544.18,133.28
X$16035 73 1491 1092 1434 73 2738 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16039 r0 *1 557.06,133.28
X$16039 73 2637 1775 2733 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16041 r0 *1 558.44,133.28
X$16041 57 2085 2638 2637 2706 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $16044 r0 *1 565.34,133.28
X$16044 73 2638 73 57 1685 57 sky130_fd_sc_hd__buf_4
* cell instance $16047 r0 *1 572.24,133.28
X$16047 73 2707 1182 2706 1178 73 2730 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $16048 r0 *1 575.46,133.28
X$16048 73 1775 2708 2086 57 73 2707 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16055 r0 *1 592.94,133.28
X$16055 73 2460 73 57 2724 57 sky130_fd_sc_hd__buf_4
* cell instance $16059 r0 *1 597.54,133.28
X$16059 73 1635 1775 930 1618 73 2721 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $16060 r0 *1 599.84,133.28
X$16060 73 2261 73 57 2718 57 sky130_fd_sc_hd__buf_4
* cell instance $16067 r0 *1 621,133.28
X$16067 73 2717 2547 1778 1889 2072 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $16081 r0 *1 653.2,133.28
X$16081 73 2714 57 73 2640 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16090 m0 *1 16.1,138.72
X$16090 73 1275 2715 2271 57 73 2354 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16093 m0 *1 25.3,138.72
X$16093 73 2670 2608 2122 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16094 m0 *1 26.68,138.72
X$16094 73 2671 73 57 2271 57 sky130_fd_sc_hd__buf_4
* cell instance $16098 m0 *1 31.28,138.72
X$16098 73 2670 73 57 2645 57 sky130_fd_sc_hd__buf_4
* cell instance $16114 m0 *1 67.62,138.72
X$16114 73 2019 2675 2727 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16119 m0 *1 71.76,138.72
X$16119 73 2678 73 57 2612 57 sky130_fd_sc_hd__buf_4
* cell instance $16134 m0 *1 99.82,138.72
X$16134 57 2573 2682 1831 1740 2734 2375 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $16135 m0 *1 103.04,138.72
X$16135 73 3110 2681 2376 2736 2079 2737 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $16136 m0 *1 106.26,138.72
X$16136 73 2682 73 57 2862 57 sky130_fd_sc_hd__buf_4
* cell instance $16148 m0 *1 138.92,138.72
X$16148 73 1585 1742 1523 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16151 m0 *1 144.44,138.72
X$16151 73 907 2429 1464 73 2739 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16154 m0 *1 147.66,138.72
X$16154 73 1583 2023 2741 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16156 m0 *1 149.96,138.72
X$16156 73 2683 726 1843 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16160 m0 *1 151.8,138.72
X$16160 73 2743 73 57 816 57 sky130_fd_sc_hd__buf_4
* cell instance $16170 m0 *1 174.8,138.72
X$16170 73 2684 1843 907 73 2748 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16175 m0 *1 180.78,138.72
X$16175 73 1122 1418 2684 57 73 2751 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16176 m0 *1 182.62,138.72
X$16176 73 1743 2756 2753 2686 73 57 3074 57 sky130_fd_sc_hd__o31ai_1
* cell instance $16177 m0 *1 185.38,138.72
X$16177 73 749 1383 2687 57 73 2756 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16183 m0 *1 197.8,138.72
X$16183 73 1048 2760 1715 1584 726 2687 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $16185 m0 *1 201.94,138.72
X$16185 73 2763 2762 685 2765 57 2764 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $16190 m0 *1 206.54,138.72
X$16190 73 2764 2276 2192 1915 2688 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $16192 m0 *1 209.3,138.72
X$16192 73 2767 2624 1584 73 2766 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16203 m0 *1 235.06,138.72
X$16203 73 2669 2777 73 2781 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $16218 m0 *1 267.26,138.72
X$16218 73 3096 73 57 2787 57 sky130_fd_sc_hd__buf_4
* cell instance $16220 m0 *1 270.94,138.72
X$16220 57 2794 2689 2790 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $16225 m0 *1 284.74,138.72
X$16225 73 2514 73 57 2788 57 sky130_fd_sc_hd__buf_4
* cell instance $16232 m0 *1 299,138.72
X$16232 73 193 2796 2690 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16235 m0 *1 302.68,138.72
X$16235 73 923 2789 2690 2793 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $16243 m0 *1 313.26,138.72
X$16243 57 2791 258 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $16260 m0 *1 355.12,138.72
X$16260 73 2331 2779 2778 2780 2783 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $16265 m0 *1 363.86,138.72
X$16265 73 2693 2532 2776 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16270 m0 *1 370.76,138.72
X$16270 73 3022 2582 2583 57 73 2775 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16274 m0 *1 375.82,138.72
X$16274 57 2631 2772 2336 2771 2692 2880 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $16285 m0 *1 397.44,138.72
X$16285 57 15542 2697 2334 2694 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $16286 m0 *1 402.04,138.72
X$16286 73 2440 2697 2332 57 73 2695 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16288 m0 *1 404.34,138.72
X$16288 73 2698 2695 2761 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16291 m0 *1 407.1,138.72
X$16291 73 2697 73 57 2227 57 sky130_fd_sc_hd__buf_4
* cell instance $16294 m0 *1 412.62,138.72
X$16294 73 2537 2699 2755 2694 2227 2920 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $16298 m0 *1 418.6,138.72
X$16298 73 2921 2826 2283 2700 2759 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $16307 m0 *1 435.62,138.72
X$16307 73 2488 2440 2828 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16345 m0 *1 515.66,138.72
X$16345 73 1876 2703 2742 2702 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $16347 m0 *1 517.96,138.72
X$16347 73 2740 2864 2702 2444 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $16350 m0 *1 523.02,138.72
X$16350 73 1177 1893 1973 2740 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $16360 m0 *1 537.74,138.72
X$16360 73 2644 73 57 2067 57 sky130_fd_sc_hd__buf_4
* cell instance $16361 m0 *1 540.5,138.72
X$16361 73 2705 73 57 1679 57 sky130_fd_sc_hd__buf_4
* cell instance $16364 m0 *1 546.02,138.72
X$16364 57 2705 1092 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $16374 m0 *1 568.56,138.72
X$16374 57 2729 1876 2168 2852 2730 1979 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $16375 m0 *1 572.24,138.72
X$16375 73 2080 2705 1178 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16378 m0 *1 578.22,138.72
X$16378 73 1680 2637 2709 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16383 m0 *1 582.82,138.72
X$16383 73 1357 2726 2363 3573 57 3158 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $16388 m0 *1 589.72,138.72
X$16388 73 2933 2644 928 2463 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $16390 m0 *1 595.24,138.72
X$16390 73 2723 2709 2078 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16393 m0 *1 600.76,138.72
X$16393 73 1775 2719 2718 73 2720 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16396 m0 *1 603.98,138.72
X$16396 73 2837 73 57 1262 57 sky130_fd_sc_hd__buf_4
* cell instance $16413 m0 *1 638.02,138.72
X$16413 57 2714 2710 2716 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $16419 m0 *1 653.2,138.72
X$16419 73 2713 57 73 2711 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16429 r0 *1 17.48,138.72
X$16429 73 2642 2715 2840 985 2670 73 2797 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $16430 r0 *1 20.7,138.72
X$16430 73 2841 2797 2608 73 2358 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16433 r0 *1 27.14,138.72
X$16433 73 1093 2121 896 2671 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $16436 r0 *1 36.34,138.72
X$16436 73 2844 2645 1193 2123 57 2798 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $16438 r0 *1 39.56,138.72
X$16438 73 2554 2553 2846 2608 2645 73 2725 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $16442 r0 *1 44.16,138.72
X$16442 73 2798 73 57 2847 57 sky130_fd_sc_hd__buf_4
* cell instance $16443 r0 *1 46.92,138.72
X$16443 73 2949 2722 1572 2645 57 73 2799 57 sky130_fd_sc_hd__a31oi_1
* cell instance $16444 r0 *1 49.22,138.72
X$16444 57 2801 3342 1359 2799 2800 2079 2646 73 73 57 sky130_fd_sc_hd__a222oi_1
* cell instance $16445 r0 *1 52.9,138.72
X$16445 73 1731 2801 2848 73 2849 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16448 r0 *1 59.34,138.72
X$16448 73 2559 1309 2802 2849 57 2854 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $16449 r0 *1 62.1,138.72
X$16449 73 1193 2850 2725 2802 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $16457 r0 *1 74.98,138.72
X$16457 73 2853 1572 2803 2851 57 2850 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $16461 r0 *1 84.18,138.72
X$16461 73 2680 2731 1197 3426 57 73 2859 57 sky130_fd_sc_hd__a31oi_1
* cell instance $16464 r0 *1 91.08,138.72
X$16464 73 1197 1193 2804 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16467 r0 *1 95.22,138.72
X$16467 73 2803 3218 2732 73 2805 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16471 r0 *1 99.36,138.72
X$16471 73 2804 2860 2659 2735 986 2806 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $16472 r0 *1 102.58,138.72
X$16472 73 1731 2859 2806 3433 2807 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $16473 r0 *1 105.34,138.72
X$16473 73 2862 2807 1309 2805 73 2861 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $16474 r0 *1 108.56,138.72
X$16474 73 1804 1831 2808 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16475 r0 *1 109.94,138.72
X$16475 73 2808 73 57 1309 57 sky130_fd_sc_hd__buf_4
* cell instance $16488 r0 *1 140.3,138.72
X$16488 73 1523 2813 2026 2963 73 2809 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $16491 r0 *1 143.98,138.72
X$16491 73 2809 2683 2739 57 73 2762 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16493 r0 *1 147.66,138.72
X$16493 73 2741 2870 2026 73 2869 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16494 r0 *1 149.5,138.72
X$16494 73 658 1325 2422 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16495 r0 *1 150.88,138.72
X$16495 73 2422 1722 2873 2026 685 73 2486 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $16499 r0 *1 155.48,138.72
X$16499 73 726 2743 2581 57 73 2870 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16505 r0 *1 169.74,138.72
X$16505 73 685 2186 728 1324 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $16507 r0 *1 173.42,138.72
X$16507 57 2810 588 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $16511 r0 *1 182.16,138.72
X$16511 73 1325 2751 2877 847 2876 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $16512 r0 *1 184.92,138.72
X$16512 73 2879 2878 2876 2686 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $16521 r0 *1 207.46,138.72
X$16521 73 848 2624 1584 73 2882 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16524 r0 *1 213.44,138.72
X$16524 73 2909 73 57 1295 57 sky130_fd_sc_hd__buf_4
* cell instance $16529 r0 *1 225.86,138.72
X$16529 57 76 2887 2606 2886 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $16533 r0 *1 238.28,138.72
X$16533 57 2889 2606 2814 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $16534 r0 *1 245.64,138.72
X$16534 57 76 2893 2784 66 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $16535 r0 *1 256.68,138.72
X$16535 73 2784 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $16537 r0 *1 259.9,138.72
X$16537 73 2896 2815 73 2895 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $16543 r0 *1 269.56,138.72
X$16543 57 2894 2784 923 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $16545 r0 *1 277.38,138.72
X$16545 57 2891 2689 193 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $16547 r0 *1 286.58,138.72
X$16547 73 2890 2885 73 111 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $16552 r0 *1 292.56,138.72
X$16552 73 389 73 57 3095 57 sky130_fd_sc_hd__buf_4
* cell instance $16554 r0 *1 297.16,138.72
X$16554 73 2816 73 57 2913 57 sky130_fd_sc_hd__buf_4
* cell instance $16558 r0 *1 303.14,138.72
X$16558 73 2793 923 2817 57 73 2816 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16561 r0 *1 312.34,138.72
X$16561 73 2791 57 73 363 57 sky130_fd_sc_hd__inv_2
* cell instance $16562 r0 *1 313.72,138.72
X$16562 73 85 2888 76 73 2791 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $16564 r0 *1 316.48,138.72
X$16564 73 2629 73 57 964 57 sky130_fd_sc_hd__clkinv_1
* cell instance $16579 r0 *1 351.44,138.72
X$16579 73 2884 2819 2818 73 57 2782 57 sky130_fd_sc_hd__o21bai_1
* cell instance $16582 r0 *1 358.8,138.72
X$16582 73 2778 2227 2820 2818 2883 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $16584 r0 *1 362.94,138.72
X$16584 73 2693 73 57 2780 57 sky130_fd_sc_hd__buf_4
* cell instance $16585 r0 *1 365.7,138.72
X$16585 73 2779 2532 2696 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16589 r0 *1 369.38,138.72
X$16589 57 15617 2582 2491 2821 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $16593 r0 *1 376.28,138.72
X$16593 73 2822 2778 2775 73 2880 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16594 r0 *1 378.12,138.72
X$16594 73 2819 2284 2771 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16597 r0 *1 385.02,138.72
X$16597 57 2693 2824 2488 73 73 57 sky130_fd_sc_hd__ha_2
* cell instance $16602 r0 *1 399.74,138.72
X$16602 73 2824 73 57 2694 57 sky130_fd_sc_hd__buf_4
* cell instance $16605 r0 *1 403.88,138.72
X$16605 73 2331 73 57 3316 57 sky130_fd_sc_hd__buf_4
* cell instance $16609 r0 *1 412.62,138.72
X$16609 73 2491 2488 2398 2825 57 73 2699 57 sky130_fd_sc_hd__a31oi_1
* cell instance $16612 r0 *1 419.52,138.72
X$16612 73 2694 2826 2700 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16615 r0 *1 422.74,138.72
X$16615 73 2697 73 57 2874 57 sky130_fd_sc_hd__buf_4
* cell instance $16622 r0 *1 433.78,138.72
X$16622 73 3036 2284 2872 2634 2871 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $16623 r0 *1 436.54,138.72
X$16623 73 2828 73 57 2825 57 sky130_fd_sc_hd__buf_4
* cell instance $16628 r0 *1 450.34,138.72
X$16628 57 2866 2749 2867 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $16634 r0 *1 470.12,138.72
X$16634 57 2865 230 411 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $16653 r0 *1 515.66,138.72
X$16653 73 2832 1280 2863 1775 2651 73 2864 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $16657 r0 *1 522.1,138.72
X$16657 73 2833 73 57 1973 57 sky130_fd_sc_hd__buf_4
* cell instance $16659 r0 *1 526.7,138.72
X$16659 73 2833 1876 1490 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16663 r0 *1 535.44,138.72
X$16663 73 2709 2856 1679 2858 57 73 2857 57 sky130_fd_sc_hd__a31oi_1
* cell instance $16669 r0 *1 546.48,138.72
X$16669 73 1490 73 57 2855 57 sky130_fd_sc_hd__buf_4
* cell instance $16672 r0 *1 554.76,138.72
X$16672 73 2733 73 57 3574 57 sky130_fd_sc_hd__buf_4
* cell instance $16673 r0 *1 557.52,138.72
X$16673 73 2085 73 57 2834 57 sky130_fd_sc_hd__buf_4
* cell instance $16677 r0 *1 564.88,138.72
X$16677 73 2085 73 57 3044 57 sky130_fd_sc_hd__buf_4
* cell instance $16681 r0 *1 570.4,138.72
X$16681 73 2165 928 2832 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16685 r0 *1 580.06,138.72
X$16685 73 2637 2080 2077 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16688 r0 *1 584.2,138.72
X$16688 57 15673 2644 2637 1971 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $16692 r0 *1 590.18,138.72
X$16692 73 2644 73 57 2249 57 sky130_fd_sc_hd__buf_4
* cell instance $16698 r0 *1 600.76,138.72
X$16698 57 2845 2835 2836 2250 2720 2721 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $16700 r0 *1 604.9,138.72
X$16700 73 2703 3499 1490 73 2835 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16702 r0 *1 607.2,138.72
X$16702 73 2837 1775 2550 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16708 r0 *1 617.32,138.72
X$16708 73 2165 2549 2842 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16712 r0 *1 621.92,138.72
X$16712 73 1889 1876 2843 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16715 r0 *1 625.6,138.72
X$16715 73 2703 2842 1876 73 2839 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16781 m0 *1 13.8,144.16
X$16781 73 2200 73 57 2942 57 sky130_fd_sc_hd__buf_4
* cell instance $16784 m0 *1 18.86,144.16
X$16784 73 985 2948 2945 57 73 2840 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16785 m0 *1 20.7,144.16
X$16785 73 2945 73 57 2946 57 sky130_fd_sc_hd__buf_4
* cell instance $16791 m0 *1 31.28,144.16
X$16791 73 1649 73 57 896 57 sky130_fd_sc_hd__buf_4
* cell instance $16795 m0 *1 37.26,144.16
X$16795 73 896 2898 2948 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $16797 m0 *1 40.48,144.16
X$16797 57 2898 1025 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $16798 m0 *1 47.84,144.16
X$16798 73 2950 73 57 2949 57 sky130_fd_sc_hd__buf_4
* cell instance $16807 m0 *1 64.4,144.16
X$16807 73 2203 73 57 1364 57 sky130_fd_sc_hd__buf_4
* cell instance $16809 m0 *1 70.84,144.16
X$16809 73 2204 73 57 3059 57 sky130_fd_sc_hd__buf_4
* cell instance $16817 m0 *1 88.32,144.16
X$16817 73 2955 73 57 2803 57 sky130_fd_sc_hd__buf_4
* cell instance $16819 m0 *1 92,144.16
X$16819 73 2956 73 57 1705 57 sky130_fd_sc_hd__buf_4
* cell instance $16822 m0 *1 100.28,144.16
X$16822 73 2899 57 73 57 sky130_fd_sc_hd__clkinv_4
* cell instance $16823 m0 *1 103.5,144.16
X$16823 73 2961 2019 2209 57 73 2860 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16824 m0 *1 105.34,144.16
X$16824 57 2900 2899 2861 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $16840 m0 *1 149.5,144.16
X$16840 73 2869 1941 2813 2386 73 2964 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $16845 m0 *1 158.7,144.16
X$16845 73 1418 1290 2902 73 2968 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16846 m0 *1 160.54,144.16
X$16846 73 1242 726 907 2903 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $16847 m0 *1 162.38,144.16
X$16847 73 715 1324 2903 2902 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $16848 m0 *1 164.22,144.16
X$16848 73 2903 73 57 2767 57 sky130_fd_sc_hd__buf_4
* cell instance $16851 m0 *1 168.36,144.16
X$16851 73 2901 73 57 2320 57 sky130_fd_sc_hd__buf_4
* cell instance $16854 m0 *1 172.5,144.16
X$16854 73 2906 73 57 824 57 sky130_fd_sc_hd__buf_4
* cell instance $16856 m0 *1 176.18,144.16
X$16856 73 2320 1941 733 2907 57 73 2685 57 sky130_fd_sc_hd__a31oi_1
* cell instance $16857 m0 *1 178.48,144.16
X$16857 73 2811 2024 2877 73 2319 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16858 m0 *1 180.32,144.16
X$16858 73 2971 1325 2877 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16859 m0 *1 181.7,144.16
X$16859 73 1325 2811 2976 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16862 m0 *1 187.22,144.16
X$16862 73 685 911 2879 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $16863 m0 *1 188.6,144.16
X$16863 73 2976 2812 2423 73 2881 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16864 m0 *1 190.44,144.16
X$16864 73 1584 875 2024 57 73 2812 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16866 m0 *1 192.74,144.16
X$16866 73 2186 73 57 2813 57 sky130_fd_sc_hd__buf_4
* cell instance $16869 m0 *1 197.8,144.16
X$16869 73 1242 1715 1583 73 2908 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16870 m0 *1 199.64,144.16
X$16870 73 1048 2908 2980 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16871 m0 *1 201.02,144.16
X$16871 73 2882 2980 2881 2813 57 73 2763 57 sky130_fd_sc_hd__a31oi_1
* cell instance $16875 m0 *1 208.38,144.16
X$16875 73 2909 2105 911 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16878 m0 *1 211.14,144.16
X$16878 73 2910 73 57 2984 57 sky130_fd_sc_hd__buf_4
* cell instance $16884 m0 *1 225.4,144.16
X$16884 57 2985 685 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $16885 m0 *1 232.76,144.16
X$16885 57 96 2606 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $16893 m0 *1 253.92,144.16
X$16893 57 3088 2911 2815 2982 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $16894 m0 *1 262.2,144.16
X$16894 57 2896 2219 2669 2900 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $16900 m0 *1 279.22,144.16
X$16900 57 2892 2689 2913 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $16903 m0 *1 288.42,144.16
X$16903 57 96 2689 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $16904 m0 *1 297.62,144.16
X$16904 73 2512 73 57 2977 57 sky130_fd_sc_hd__buf_4
* cell instance $16911 m0 *1 312.34,144.16
X$16911 57 2885 3092 964 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $16921 m0 *1 341.78,144.16
X$16921 73 2914 2776 2588 2972 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $16935 m0 *1 377.66,144.16
X$16935 73 2824 73 57 2821 57 sky130_fd_sc_hd__buf_4
* cell instance $16936 m0 *1 380.42,144.16
X$16936 73 2438 2820 2918 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16937 m0 *1 381.8,144.16
X$16937 73 2823 2284 2969 2918 73 2916 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $16946 m0 *1 399.74,144.16
X$16946 73 2824 73 57 2827 57 sky130_fd_sc_hd__buf_4
* cell instance $16951 m0 *1 412.62,144.16
X$16951 57 2868 2920 2576 2494 3032 2965 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $16958 m0 *1 426.42,144.16
X$16958 73 2488 2440 2755 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16959 m0 *1 427.8,144.16
X$16959 73 2871 2925 2754 2397 2958 73 2924 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $16960 m0 *1 431.02,144.16
X$16960 73 2491 2926 2827 73 2823 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16963 m0 *1 434.24,144.16
X$16963 73 2827 2923 2872 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $16964 m0 *1 435.62,144.16
X$16964 73 2927 2828 2926 2923 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $16967 m0 *1 439.76,144.16
X$16967 73 2332 2926 2829 2962 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $16973 m0 *1 445.74,144.16
X$16973 73 3126 2830 3032 73 2925 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $16975 m0 *1 449.42,144.16
X$16975 73 2826 2831 2960 57 73 2830 57 sky130_fd_sc_hd__a21oi_1
* cell instance $16978 m0 *1 453.56,144.16
X$16978 57 230 2749 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $17006 m0 *1 531.76,144.16
X$17006 73 1372 2064 3347 2855 1967 73 3247 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $17007 m0 *1 534.98,144.16
X$17007 73 2704 2929 2930 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17009 m0 *1 536.82,144.16
X$17009 73 2931 1875 928 57 73 3061 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17019 m0 *1 563.96,144.16
X$17019 73 2953 73 57 2265 57 sky130_fd_sc_hd__inv_1
* cell instance $17021 m0 *1 569.02,144.16
X$17021 73 1775 3164 2832 57 73 2852 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17025 m0 *1 575.92,144.16
X$17025 73 2952 2729 1615 2951 57 2726 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $17030 m0 *1 585.12,144.16
X$17030 57 15493 2933 2637 2706 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $17034 m0 *1 597.54,144.16
X$17034 73 2932 2947 1441 2836 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $17035 m0 *1 599.38,144.16
X$17035 57 15567 2165 2265 1971 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $17040 m0 *1 610.88,144.16
X$17040 73 2550 2077 1092 73 2937 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17043 m0 *1 616.86,144.16
X$17043 73 2936 73 57 1778 57 sky130_fd_sc_hd__buf_4
* cell instance $17047 m0 *1 626.06,144.16
X$17047 73 2938 1777 2839 73 2943 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17049 m0 *1 629.74,144.16
X$17049 73 2843 73 57 2938 57 sky130_fd_sc_hd__buf_4
* cell instance $17056 m0 *1 645.84,144.16
X$17056 57 2713 2710 2941 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $17067 r0 *1 17.02,144.16
X$17067 73 2121 1275 2944 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17069 r0 *1 19.32,144.16
X$17069 73 1093 2121 2516 2945 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $17071 r0 *1 22.08,144.16
X$17071 73 1414 73 57 2670 57 sky130_fd_sc_hd__buf_4
* cell instance $17072 r0 *1 24.84,144.16
X$17072 73 985 2946 3052 57 73 2988 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17074 r0 *1 27.14,144.16
X$17074 73 1782 1309 3054 57 73 3055 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17075 r0 *1 28.98,144.16
X$17075 73 1275 2671 2200 57 73 2989 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17078 r0 *1 33.12,144.16
X$17078 73 2989 2988 2608 73 2609 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17081 r0 *1 39.56,144.16
X$17081 73 2989 1275 3056 57 73 3060 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17088 r0 *1 46.92,144.16
X$17088 73 1275 2170 2950 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $17091 r0 *1 51.52,144.16
X$17091 73 3107 73 57 3057 57 sky130_fd_sc_hd__buf_4
* cell instance $17097 r0 *1 69.46,144.16
X$17097 73 2993 3058 1460 73 2800 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17101 r0 *1 72.22,144.16
X$17101 73 1275 2995 3059 2993 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $17104 r0 *1 79.58,144.16
X$17104 73 1787 3060 2994 1831 2956 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $17106 r0 *1 83.26,144.16
X$17106 57 2957 2899 2854 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $17110 r0 *1 96.6,144.16
X$17110 73 2209 2996 2997 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17115 r0 *1 100.28,144.16
X$17115 57 1232 2899 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $17118 r0 *1 110.86,144.16
X$17118 57 2744 2899 3063 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $17128 r0 *1 139.84,144.16
X$17128 73 914 2901 2963 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17129 r0 *1 141.22,144.16
X$17129 73 2901 2811 1465 57 73 3066 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17130 r0 *1 143.06,144.16
X$17130 73 2683 1585 2811 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17133 r0 *1 147.2,144.16
X$17133 73 749 73 57 1941 57 sky130_fd_sc_hd__buf_4
* cell instance $17141 r0 *1 157.78,144.16
X$17141 73 3002 3068 1380 2968 2904 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $17142 r0 *1 160.54,144.16
X$17142 73 1941 2813 3002 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17146 r0 *1 168.36,144.16
X$17146 73 2005 2904 2905 3069 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $17148 r0 *1 170.66,144.16
X$17148 73 3846 820 2981 2905 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $17149 r0 *1 172.5,144.16
X$17149 73 2186 1323 2906 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17153 r0 *1 177.1,144.16
X$17153 57 15604 2971 726 1584 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $17158 r0 *1 184.92,144.16
X$17158 73 2188 3073 3074 2979 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $17161 r0 *1 188.14,144.16
X$17161 73 2217 73 57 1325 57 sky130_fd_sc_hd__buf_4
* cell instance $17162 r0 *1 190.9,144.16
X$17162 73 726 749 2600 3076 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $17163 r0 *1 192.74,144.16
X$17163 73 1851 749 2024 3075 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $17168 r0 *1 201.48,144.16
X$17168 73 749 2909 2981 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17175 r0 *1 211.6,144.16
X$17175 73 3006 3005 73 2909 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17177 r0 *1 215.74,144.16
X$17177 73 1282 73 57 2982 57 sky130_fd_sc_hd__buf_4
* cell instance $17181 r0 *1 226.32,144.16
X$17181 73 3010 2399 73 2985 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17182 r0 *1 229.54,144.16
X$17182 57 3006 606 3081 3080 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $17184 r0 *1 233.22,144.16
X$17184 73 2744 3455 73 71 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17187 r0 *1 237.36,144.16
X$17187 73 2605 3084 73 2814 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17188 r0 *1 240.58,144.16
X$17188 57 3010 342 3088 3080 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $17191 r0 *1 245.64,144.16
X$17191 57 3013 2747 3015 2219 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $17194 r0 *1 255.3,144.16
X$17194 57 96 2784 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $17197 r0 *1 264.96,144.16
X$17197 57 2912 2219 1282 2660 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $17200 r0 *1 274.62,144.16
X$17200 73 960 2890 2815 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17201 r0 *1 277.84,144.16
X$17201 73 3098 2912 3097 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17204 r0 *1 283.82,144.16
X$17204 57 2978 2669 2866 3096 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $17207 r0 *1 292.56,144.16
X$17207 57 2974 2689 3095 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $17208 r0 *1 299.92,144.16
X$17208 73 3093 2912 2975 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17212 r0 *1 312.34,144.16
X$17212 57 3019 3092 363 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $17215 r0 *1 320.16,144.16
X$17215 73 3019 73 57 3117 57 sky130_fd_sc_hd__buf_4
* cell instance $17218 r0 *1 328.44,144.16
X$17218 57 2973 3089 1553 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $17221 r0 *1 338.56,144.16
X$17221 73 960 73 57 3087 57 sky130_fd_sc_hd__buf_4
* cell instance $17225 r0 *1 344.08,144.16
X$17225 73 2962 2972 3085 73 3208 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17231 r0 *1 352.36,144.16
X$17231 73 2820 3021 2914 73 2970 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17232 r0 *1 354.2,144.16
X$17232 57 2915 3072 3452 3023 3022 3083 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $17233 r0 *1 357.42,144.16
X$17233 73 3024 2436 2883 57 73 3606 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17234 r0 *1 359.26,144.16
X$17234 57 3082 2915 3023 2916 2875 2587 73 73 57 sky130_fd_sc_hd__a41oi_2
* cell instance $17238 r0 *1 369.84,144.16
X$17238 73 2693 3025 3021 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $17239 r0 *1 372.14,144.16
X$17239 73 3025 73 57 2583 57 sky130_fd_sc_hd__buf_4
* cell instance $17246 r0 *1 389.16,144.16
X$17246 73 2693 73 57 2919 57 sky130_fd_sc_hd__buf_4
* cell instance $17247 r0 *1 391.92,144.16
X$17247 73 2919 2583 2967 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17249 r0 *1 395.14,144.16
X$17249 73 2919 2491 2966 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17255 r0 *1 402.96,144.16
X$17255 73 2966 73 57 3597 57 sky130_fd_sc_hd__buf_4
* cell instance $17256 r0 *1 405.72,144.16
X$17256 73 3071 2922 3072 57 73 57 sky130_fd_sc_hd__or2_0
* cell instance $17264 r0 *1 424.12,144.16
X$17264 73 3070 3020 2923 73 57 2875 57 sky130_fd_sc_hd__o21ai_1
* cell instance $17267 r0 *1 427.34,144.16
X$17267 73 2924 73 57 3035 57 sky130_fd_sc_hd__buf_4
* cell instance $17271 r0 *1 431.94,144.16
X$17271 73 2874 73 57 3036 57 sky130_fd_sc_hd__buf_4
* cell instance $17278 r0 *1 453.1,144.16
X$17278 73 2866 73 57 2660 57 sky130_fd_sc_hd__buf_4
* cell instance $17279 r0 *1 455.86,144.16
X$17279 73 3037 2959 2332 57 73 3067 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17307 r0 *1 520.26,144.16
X$17307 73 2080 73 57 1014 57 sky130_fd_sc_hd__buf_4
* cell instance $17308 r0 *1 523.02,144.16
X$17308 57 3064 2740 2928 3050 4148 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $17313 r0 *1 534.52,144.16
X$17313 57 2929 2857 2855 3040 2932 3061 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $17314 r0 *1 537.74,144.16
X$17314 73 2644 73 57 3041 57 sky130_fd_sc_hd__buf_4
* cell instance $17319 r0 *1 546.02,144.16
X$17319 73 2834 1775 2954 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17328 r0 *1 565.34,144.16
X$17328 73 2348 73 57 3903 57 sky130_fd_sc_hd__buf_4
* cell instance $17332 r0 *1 571.32,144.16
X$17332 73 3045 73 57 1629 57 sky130_fd_sc_hd__buf_4
* cell instance $17337 r0 *1 583.74,144.16
X$17337 57 15643 3047 2265 2706 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $17339 r0 *1 588.34,144.16
X$17339 57 15637 2837 2265 2706 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $17344 r0 *1 597.08,144.16
X$17344 73 1681 1876 2932 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17345 r0 *1 598.46,144.16
X$17345 57 2935 3053 2934 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $17346 r0 *1 605.82,144.16
X$17346 73 2845 3417 3051 1790 57 2934 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $17357 r0 *1 628.82,144.16
X$17357 73 2943 73 57 3050 57 sky130_fd_sc_hd__buf_4
* cell instance $17368 r0 *1 656.88,144.16
X$17368 73 2939 57 73 2940 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17421 m0 *1 12.42,149.6
X$17421 73 2944 73 57 2987 57 sky130_fd_sc_hd__buf_4
* cell instance $17423 m0 *1 16.1,149.6
X$17423 57 2942 1976 1275 1995 2987 2173 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $17426 m0 *1 20.7,149.6
X$17426 73 3146 73 57 2516 57 sky130_fd_sc_hd__buf_4
* cell instance $17428 m0 *1 23.92,149.6
X$17428 73 1460 73 57 2608 57 sky130_fd_sc_hd__buf_4
* cell instance $17429 m0 *1 26.68,149.6
X$17429 73 3102 73 57 3052 57 sky130_fd_sc_hd__buf_4
* cell instance $17433 m0 *1 31.28,149.6
X$17433 73 3055 73 57 3147 57 sky130_fd_sc_hd__buf_4
* cell instance $17436 m0 *1 36.8,149.6
X$17436 73 3104 73 57 2551 57 sky130_fd_sc_hd__buf_4
* cell instance $17438 m0 *1 40.02,149.6
X$17438 73 3106 73 57 3056 57 sky130_fd_sc_hd__buf_4
* cell instance $17439 m0 *1 42.78,149.6
X$17439 57 2990 1572 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $17440 m0 *1 50.14,149.6
X$17440 73 2990 2950 2991 2678 1649 3107 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $17441 m0 *1 53.36,149.6
X$17441 73 986 2728 2991 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17442 m0 *1 54.74,149.6
X$17442 73 2991 73 57 2675 57 sky130_fd_sc_hd__buf_4
* cell instance $17446 m0 *1 63.48,149.6
X$17446 73 2992 1364 2305 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17448 m0 *1 66.7,149.6
X$17448 73 2305 73 57 3153 57 sky130_fd_sc_hd__buf_4
* cell instance $17449 m0 *1 69.46,149.6
X$17449 73 2019 3154 3153 3058 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $17452 m0 *1 73.6,149.6
X$17452 73 2206 73 57 2677 57 sky130_fd_sc_hd__buf_4
* cell instance $17454 m0 *1 76.82,149.6
X$17454 73 2955 2081 3296 1199 3155 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $17455 m0 *1 79.58,149.6
X$17455 73 2268 3155 1150 3504 57 73 2994 57 sky130_fd_sc_hd__a31oi_1
* cell instance $17457 m0 *1 82.34,149.6
X$17457 73 980 3108 2995 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17458 m0 *1 83.72,149.6
X$17458 73 2728 1364 2996 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17461 m0 *1 87.4,149.6
X$17461 73 2995 73 57 2131 57 sky130_fd_sc_hd__buf_4
* cell instance $17463 m0 *1 93.84,149.6
X$17463 73 2996 73 57 2613 57 sky130_fd_sc_hd__buf_4
* cell instance $17464 m0 *1 96.6,149.6
X$17464 73 1275 2613 2370 2998 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $17465 m0 *1 98.44,149.6
X$17465 73 1275 2420 2998 73 3161 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17466 m0 *1 100.28,149.6
X$17466 73 2997 73 57 2961 57 sky130_fd_sc_hd__buf_4
* cell instance $17467 m0 *1 103.04,149.6
X$17467 73 1904 2737 3671 3163 2847 73 3063 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $17485 m0 *1 147.2,149.6
X$17485 73 2981 3166 2964 2999 3170 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $17488 m0 *1 151.34,149.6
X$17488 73 3000 73 57 1154 57 sky130_fd_sc_hd__buf_4
* cell instance $17491 m0 *1 158.24,149.6
X$17491 73 3001 907 2901 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17494 m0 *1 165.14,149.6
X$17494 73 3170 1323 3069 3169 57 3111 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $17496 m0 *1 168.36,149.6
X$17496 73 3304 3001 1205 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17499 m0 *1 171.12,149.6
X$17499 57 3004 3003 1851 1325 1584 632 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $17500 m0 *1 174.34,149.6
X$17500 73 1941 2743 2314 73 3112 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17502 m0 *1 179.86,149.6
X$17502 73 3004 73 57 1125 57 sky130_fd_sc_hd__buf_4
* cell instance $17505 m0 *1 184,149.6
X$17505 73 1942 3362 2907 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17508 m0 *1 190.9,149.6
X$17508 57 3174 2910 726 2423 3075 3112 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $17512 m0 *1 195.96,149.6
X$17512 57 3007 3113 2979 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $17514 m0 *1 204.24,149.6
X$17514 73 3304 73 57 914 57 sky130_fd_sc_hd__buf_4
* cell instance $17516 m0 *1 210.68,149.6
X$17516 73 3006 3005 2186 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17517 m0 *1 213.9,149.6
X$17517 73 3007 3005 73 104 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17518 m0 *1 217.12,149.6
X$17518 73 3008 73 57 1323 57 sky130_fd_sc_hd__buf_4
* cell instance $17519 m0 *1 219.88,149.6
X$17519 73 3009 3182 2105 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17521 m0 *1 223.56,149.6
X$17521 73 3009 3182 73 3008 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17524 m0 *1 229.08,149.6
X$17524 57 3009 661 3011 3080 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $17526 m0 *1 234.6,149.6
X$17526 73 3010 2399 3012 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17527 m0 *1 237.82,149.6
X$17527 73 3012 73 57 749 57 sky130_fd_sc_hd__buf_4
* cell instance $17529 m0 *1 241.5,149.6
X$17529 73 3014 3013 3081 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17530 m0 *1 244.72,149.6
X$17530 73 2744 2890 73 3014 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17534 m0 *1 251.16,149.6
X$17534 73 3086 3015 3011 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17535 m0 *1 254.38,149.6
X$17535 57 3194 3193 2815 2747 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $17536 m0 *1 263.12,149.6
X$17536 57 3090 164 2895 3018 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $17537 m0 *1 266.8,149.6
X$17537 73 3094 3193 73 3016 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17539 m0 *1 270.48,149.6
X$17539 73 2669 3017 73 2911 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17540 m0 *1 273.7,149.6
X$17540 57 3116 109 3016 3018 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $17544 m0 *1 279.68,149.6
X$17544 57 3197 2893 3097 3018 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $17545 m0 *1 283.36,149.6
X$17545 73 3017 3117 73 99 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17547 m0 *1 287.5,149.6
X$17547 73 3200 73 57 3198 57 sky130_fd_sc_hd__inv_1
* cell instance $17548 m0 *1 288.88,149.6
X$17548 57 3200 587 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $17551 m0 *1 298.54,149.6
X$17551 73 2890 2900 73 3093 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17569 m0 *1 342.7,149.6
X$17569 73 3020 3205 2761 3207 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $17574 m0 *1 351.44,149.6
X$17574 73 3121 73 57 3022 57 sky130_fd_sc_hd__buf_4
* cell instance $17575 m0 *1 354.2,149.6
X$17575 73 3209 2970 2336 3022 57 73 3083 57 sky130_fd_sc_hd__a31oi_1
* cell instance $17576 m0 *1 356.5,149.6
X$17576 73 3121 73 57 2436 57 sky130_fd_sc_hd__buf_4
* cell instance $17581 m0 *1 365.7,149.6
X$17581 73 3078 3077 3028 3022 3079 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $17584 m0 *1 372.6,149.6
X$17584 73 3123 73 57 3077 57 sky130_fd_sc_hd__buf_4
* cell instance $17585 m0 *1 375.36,149.6
X$17585 73 2535 3027 2436 73 3123 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17586 m0 *1 377.2,149.6
X$17586 73 3026 2491 2583 73 3027 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17587 m0 *1 379.04,149.6
X$17587 73 3029 73 57 3026 57 sky130_fd_sc_hd__buf_4
* cell instance $17588 m0 *1 381.8,149.6
X$17588 73 3029 73 57 3124 57 sky130_fd_sc_hd__buf_4
* cell instance $17592 m0 *1 389.16,149.6
X$17592 73 3030 73 57 2438 57 sky130_fd_sc_hd__buf_4
* cell instance $17595 m0 *1 396.52,149.6
X$17595 73 3030 57 73 2824 57 sky130_fd_sc_hd__inv_2
* cell instance $17596 m0 *1 397.9,149.6
X$17596 73 3031 3125 3033 3122 57 73 3028 57 sky130_fd_sc_hd__a31oi_1
* cell instance $17606 m0 *1 420.9,149.6
X$17606 73 3032 2700 3204 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17608 m0 *1 423.2,149.6
X$17608 73 3033 3125 3031 57 73 3070 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17610 m0 *1 426.88,149.6
X$17610 73 3034 73 57 3203 57 sky130_fd_sc_hd__buf_4
* cell instance $17611 m0 *1 429.64,149.6
X$17611 73 2874 2283 3275 2826 3034 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $17613 m0 *1 433.32,149.6
X$17613 73 2491 73 57 2927 57 sky130_fd_sc_hd__buf_4
* cell instance $17617 m0 *1 441.14,149.6
X$17617 73 3196 73 57 2926 57 sky130_fd_sc_hd__buf_4
* cell instance $17621 m0 *1 447.12,149.6
X$17621 73 3124 3037 2829 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17622 m0 *1 448.5,149.6
X$17622 73 2440 73 57 3037 57 sky130_fd_sc_hd__buf_4
* cell instance $17625 m0 *1 458.62,149.6
X$17625 57 3192 2700 3190 3032 3067 3037 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $17644 m0 *1 506,149.6
X$17644 57 3038 1775 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $17645 m0 *1 513.36,149.6
X$17645 73 2269 3187 3127 57 73 3065 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17648 m0 *1 516.58,149.6
X$17648 73 3038 73 57 1018 57 sky130_fd_sc_hd__buf_4
* cell instance $17651 m0 *1 521.64,149.6
X$17651 73 1775 2832 1283 57 73 3510 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17656 m0 *1 527.16,149.6
X$17656 73 1014 2472 3039 3127 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $17659 m0 *1 530.38,149.6
X$17659 73 2080 73 57 3062 57 sky130_fd_sc_hd__buf_4
* cell instance $17660 m0 *1 533.14,149.6
X$17660 73 3041 928 1898 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17662 m0 *1 536.36,149.6
X$17662 73 3129 2954 3173 2931 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $17663 m0 *1 539.12,149.6
X$17663 73 2954 1089 1775 57 73 3130 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17666 m0 *1 545.56,149.6
X$17666 73 3042 73 57 2856 57 sky130_fd_sc_hd__buf_4
* cell instance $17667 m0 *1 548.32,149.6
X$17667 73 1680 3129 1369 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17669 m0 *1 550.16,149.6
X$17669 73 2834 3062 3133 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17670 m0 *1 551.54,149.6
X$17670 73 2547 1775 3042 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17675 m0 *1 558.44,149.6
X$17675 73 2953 73 57 2637 57 sky130_fd_sc_hd__buf_4
* cell instance $17678 m0 *1 563.96,149.6
X$17678 73 1014 3135 942 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17679 m0 *1 565.34,149.6
X$17679 73 3044 928 3135 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17682 m0 *1 568.1,149.6
X$17682 73 3136 1685 3164 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $17683 m0 *1 570.4,149.6
X$17683 57 2540 3046 1775 2832 3045 3043 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $17690 m0 *1 585.12,149.6
X$17690 73 3047 73 57 1089 57 sky130_fd_sc_hd__buf_4
* cell instance $17691 m0 *1 587.88,149.6
X$17691 73 3047 1092 3046 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17694 m0 *1 596.62,149.6
X$17694 57 1619 3053 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $17697 m0 *1 608.12,149.6
X$17697 73 1967 3138 3051 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17705 m0 *1 624.22,149.6
X$17705 73 2352 1182 3148 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17713 m0 *1 638.94,149.6
X$17713 57 2710 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $17716 m0 *1 647.22,149.6
X$17716 73 3049 57 73 3145 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17724 r0 *1 5.52,149.6
X$17724 73 2986 57 73 3144 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17736 r0 *1 24.38,149.6
X$17736 73 2678 73 57 1502 57 sky130_fd_sc_hd__buf_4
* cell instance $17737 r0 *1 27.14,149.6
X$17737 73 1146 3418 3101 73 3054 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17739 r0 *1 29.44,149.6
X$17739 73 985 73 57 971 57 sky130_fd_sc_hd__buf_4
* cell instance $17741 r0 *1 32.66,149.6
X$17741 73 1102 1275 3103 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17743 r0 *1 34.5,149.6
X$17743 73 2608 3257 3105 3104 3103 3101 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $17746 r0 *1 40.48,149.6
X$17746 73 2201 3102 3105 73 57 3106 57 sky130_fd_sc_hd__o21ai_1
* cell instance $17755 r0 *1 49.68,149.6
X$17755 73 986 980 985 3104 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $17757 r0 *1 55.2,149.6
X$17757 73 3385 73 57 1413 57 sky130_fd_sc_hd__buf_4
* cell instance $17758 r0 *1 57.96,149.6
X$17758 73 2992 73 57 1647 57 sky130_fd_sc_hd__buf_4
* cell instance $17759 r0 *1 60.72,149.6
X$17759 73 3295 73 57 1509 57 sky130_fd_sc_hd__buf_4
* cell instance $17760 r0 *1 63.48,149.6
X$17760 73 3150 2017 3151 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17769 r0 *1 77.28,149.6
X$17769 73 1509 73 57 2370 57 sky130_fd_sc_hd__buf_4
* cell instance $17771 r0 *1 83.72,149.6
X$17771 73 1275 1150 2675 3156 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $17774 r0 *1 87.86,149.6
X$17774 57 3262 2019 1150 1995 2305 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $17778 r0 *1 94.3,149.6
X$17778 73 2678 73 57 3109 57 sky130_fd_sc_hd__buf_4
* cell instance $17782 r0 *1 97.06,149.6
X$17782 73 2019 2131 986 73 3159 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17785 r0 *1 99.82,149.6
X$17785 73 3109 3159 2079 2127 986 73 3162 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $17786 r0 *1 103.04,149.6
X$17786 73 3110 3161 3266 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17790 r0 *1 107.64,149.6
X$17790 57 3268 3165 3147 2355 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $17807 r0 *1 149.5,149.6
X$17807 73 1941 3167 3271 3000 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $17813 r0 *1 152.72,149.6
X$17813 73 1242 1325 875 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17818 r0 *1 163.76,149.6
X$17818 73 2590 2906 1941 3273 57 3169 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $17828 r0 *1 182.16,149.6
X$17828 57 2600 907 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $17830 r0 *1 190.44,149.6
X$17830 73 3175 3076 3176 57 73 3174 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17833 r0 *1 196.88,149.6
X$17833 73 685 996 2318 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17843 r0 *1 212.52,149.6
X$17843 73 632 3180 3280 57 73 3179 57 sky130_fd_sc_hd__a21oi_1
* cell instance $17845 r0 *1 215.28,149.6
X$17845 73 2600 73 57 996 57 sky130_fd_sc_hd__buf_4
* cell instance $17848 r0 *1 222.18,149.6
X$17848 57 3226 2606 2688 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $17851 r0 *1 231.38,149.6
X$17851 73 3090 73 57 3185 57 sky130_fd_sc_hd__buf_4
* cell instance $17858 r0 *1 237.36,149.6
X$17858 73 3007 2982 3114 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17859 r0 *1 240.58,149.6
X$17859 73 3114 3013 3282 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17863 r0 *1 248.86,149.6
X$17863 73 3007 2744 3193 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $17867 r0 *1 255.3,149.6
X$17867 57 3115 122 3194 3018 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $17868 r0 *1 258.98,149.6
X$17868 57 3195 243 3283 3018 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $17875 r0 *1 266.8,149.6
X$17875 57 3094 3015 2982 3087 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $17876 r0 *1 275.08,149.6
X$17876 73 3087 3017 73 3098 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $17878 r0 *1 279.22,149.6
X$17878 73 3197 73 57 4597 57 sky130_fd_sc_hd__buf_4
* cell instance $17880 r0 *1 282.9,149.6
X$17880 73 3115 73 57 3091 57 sky130_fd_sc_hd__buf_4
* cell instance $17881 r0 *1 285.66,149.6
X$17881 73 3116 73 57 3199 57 sky130_fd_sc_hd__buf_4
* cell instance $17885 r0 *1 288.42,149.6
X$17885 73 2689 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $17888 r0 *1 292.56,149.6
X$17888 57 3201 2689 2977 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $17892 r0 *1 306.36,149.6
X$17892 73 2975 73 57 3202 57 sky130_fd_sc_hd__buf_4
* cell instance $17899 r0 *1 315.56,149.6
X$17899 57 3092 15444 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $17911 r0 *1 341.32,149.6
X$17911 73 2884 3118 3119 73 3205 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $17913 r0 *1 344.08,149.6
X$17913 73 3377 3207 3208 3024 57 73 3206 57 sky130_fd_sc_hd__a31oi_1
* cell instance $17917 r0 *1 349.6,149.6
X$17917 73 3120 2818 3118 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $17918 r0 *1 350.98,149.6
X$17918 73 2970 73 57 3284 57 sky130_fd_sc_hd__buf_4
* cell instance $17919 r0 *1 353.74,149.6
X$17919 73 3118 73 57 3122 57 sky130_fd_sc_hd__buf_4
* cell instance $17922 r0 *1 360.64,149.6
X$17922 73 3026 73 57 3120 57 sky130_fd_sc_hd__buf_4
* cell instance $17923 r0 *1 363.4,149.6
X$17923 57 2914 3370 2436 3231 2776 3203 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $17934 r0 *1 383.18,149.6
X$17934 73 3027 73 57 3210 57 sky130_fd_sc_hd__buf_4
* cell instance $17938 r0 *1 395.14,149.6
X$17938 57 2919 3276 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $17945 r0 *1 405.26,149.6
X$17945 73 2403 2440 3125 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $17950 r0 *1 418.6,149.6
X$17950 73 3032 3033 2819 3204 57 73 3277 57 sky130_fd_sc_hd__a31oi_1
* cell instance $17962 r0 *1 442.06,149.6
X$17962 73 3126 73 57 3590 57 sky130_fd_sc_hd__buf_4
* cell instance $17963 r0 *1 444.82,149.6
X$17963 73 3033 3589 3196 3126 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $17966 r0 *1 449.42,149.6
X$17966 73 3124 73 57 2959 57 sky130_fd_sc_hd__buf_4
* cell instance $17972 r0 *1 454.94,149.6
X$17972 73 2829 73 57 3896 57 sky130_fd_sc_hd__buf_4
* cell instance $17975 r0 *1 459.08,149.6
X$17975 57 3190 3189 2826 3191 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $18004 r0 *1 516.58,149.6
X$18004 73 3038 73 57 2080 57 sky130_fd_sc_hd__inv_1
* cell instance $18005 r0 *1 517.96,149.6
X$18005 73 3184 3064 3128 3186 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $18006 r0 *1 519.8,149.6
X$18006 73 2380 2564 3183 3181 1611 73 3184 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $18008 r0 *1 524.86,149.6
X$18008 73 3178 3129 3130 57 73 3181 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18009 r0 *1 526.7,149.6
X$18009 73 1014 1905 1283 3177 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $18017 r0 *1 535.44,149.6
X$18017 73 3041 1679 3131 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18020 r0 *1 538.2,149.6
X$18020 73 3062 3041 3249 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $18024 r0 *1 545.56,149.6
X$18024 73 3133 3134 3129 57 73 3172 57 sky130_fd_sc_hd__a21o_1
* cell instance $18025 r0 *1 548.32,149.6
X$18025 73 3062 3131 1369 3168 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $18027 r0 *1 551.08,149.6
X$18027 73 2648 1775 3134 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18028 r0 *1 552.46,149.6
X$18028 73 3133 3042 3129 3246 57 73 3048 57 sky130_fd_sc_hd__a31oi_1
* cell instance $18037 r0 *1 565.34,149.6
X$18037 73 3135 73 57 3045 57 sky130_fd_sc_hd__buf_4
* cell instance $18039 r0 *1 568.56,149.6
X$18039 73 3045 73 57 3160 57 sky130_fd_sc_hd__buf_4
* cell instance $18042 r0 *1 573.62,149.6
X$18042 57 2952 1898 3137 1346 1775 3136 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $18045 r0 *1 580.98,149.6
X$18045 57 3157 3053 3158 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $18049 r0 *1 588.34,149.6
X$18049 57 3047 1886 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $18052 r0 *1 596.62,149.6
X$18052 57 3053 73 73 57 sky130_fd_sc_hd__inv_12
* cell instance $18053 r0 *1 602.6,149.6
X$18053 73 1881 928 2708 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18055 r0 *1 607.66,149.6
X$18055 73 1775 2717 2708 57 73 3152 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18057 r0 *1 611.34,149.6
X$18057 73 3048 2937 1876 3139 57 3140 73 57 sky130_fd_sc_hd__a22o_1
* cell instance $18061 r0 *1 614.56,149.6
X$18061 73 3256 1681 3140 57 73 3138 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18067 r0 *1 623.76,149.6
X$18067 73 3141 73 57 2356 57 sky130_fd_sc_hd__buf_4
* cell instance $18068 r0 *1 626.52,149.6
X$18068 57 3149 2843 1092 3141 3148 1886 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $18073 r0 *1 638.94,149.6
X$18073 57 1619 2710 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $18088 m0 *1 14.72,155.04
X$18088 73 3254 73 57 1995 57 sky130_fd_sc_hd__buf_4
* cell instance $18093 m0 *1 24.38,155.04
X$18093 57 15447 3212 1567 1055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $18096 m0 *1 30.36,155.04
X$18096 73 3212 73 57 1102 57 sky130_fd_sc_hd__buf_4
* cell instance $18097 m0 *1 33.12,155.04
X$18097 73 3212 3105 3102 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18100 m0 *1 35.88,155.04
X$18100 73 3213 1414 3105 3257 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $18102 m0 *1 39.56,155.04
X$18102 73 1649 73 57 3105 57 sky130_fd_sc_hd__buf_4
* cell instance $18104 m0 *1 43.24,155.04
X$18104 73 2419 3105 3214 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18107 m0 *1 49.22,155.04
X$18107 73 3258 73 57 980 57 sky130_fd_sc_hd__buf_4
* cell instance $18111 m0 *1 57.96,155.04
X$18111 73 3387 73 57 1105 57 sky130_fd_sc_hd__buf_4
* cell instance $18112 m0 *1 60.72,155.04
X$18112 73 1649 73 57 3215 57 sky130_fd_sc_hd__buf_4
* cell instance $18113 m0 *1 63.48,155.04
X$18113 73 3294 3216 3150 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18114 m0 *1 64.86,155.04
X$18114 73 3215 73 57 3108 57 sky130_fd_sc_hd__buf_4
* cell instance $18117 m0 *1 69,155.04
X$18117 73 2019 3261 3154 1937 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $18118 m0 *1 71.3,155.04
X$18118 73 3216 73 57 2206 57 sky130_fd_sc_hd__buf_4
* cell instance $18125 m0 *1 91.08,155.04
X$18125 73 1995 1370 2131 57 73 3217 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18127 m0 *1 93.38,155.04
X$18127 73 3262 1370 987 2677 3264 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $18128 m0 *1 95.68,155.04
X$18128 73 1460 73 57 2209 57 sky130_fd_sc_hd__buf_4
* cell instance $18130 m0 *1 102.12,155.04
X$18130 57 2209 3267 2734 3349 3434 2475 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $18131 m0 *1 105.34,155.04
X$18131 73 3266 3267 3163 3162 73 3268 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $18147 m0 *1 144.44,155.04
X$18147 73 3219 73 57 904 57 sky130_fd_sc_hd__buf_4
* cell instance $18150 m0 *1 148.58,155.04
X$18150 73 1585 3171 3219 57 73 3271 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18152 m0 *1 150.88,155.04
X$18152 73 726 907 3171 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18153 m0 *1 152.26,155.04
X$18153 73 904 3357 2026 3003 57 2873 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $18154 m0 *1 155.02,155.04
X$18154 73 1584 1325 3219 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18158 m0 *1 159.62,155.04
X$18158 73 3001 2026 3220 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18159 m0 *1 161,155.04
X$18159 73 907 1465 2024 73 3272 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18160 m0 *1 162.84,155.04
X$18160 73 3272 1584 2767 3274 57 3273 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $18161 m0 *1 165.6,155.04
X$18161 73 1331 3171 2423 73 3274 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18169 m0 *1 178.94,155.04
X$18169 73 3221 1531 3360 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18170 m0 *1 180.32,155.04
X$18170 73 3222 847 3361 57 73 3166 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18171 m0 *1 182.16,155.04
X$18171 73 3221 73 57 1942 57 sky130_fd_sc_hd__buf_4
* cell instance $18172 m0 *1 184.92,155.04
X$18172 73 733 1585 1531 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18174 m0 *1 188.14,155.04
X$18174 73 1584 726 1585 73 3364 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18175 m0 *1 189.98,155.04
X$18175 73 1418 685 1325 3176 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $18178 m0 *1 194.12,155.04
X$18178 73 1242 1418 2429 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18181 m0 *1 196.88,155.04
X$18181 73 2767 3220 1584 73 3278 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18182 m0 *1 198.72,155.04
X$18182 73 2879 3278 3448 2429 3223 73 1333 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $18183 m0 *1 201.94,155.04
X$18183 73 847 996 3223 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18185 m0 *1 204.24,155.04
X$18185 73 2217 1851 632 2586 57 3279 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $18186 m0 *1 207,155.04
X$18186 73 3224 3180 3279 632 1048 73 3222 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $18187 m0 *1 210.22,155.04
X$18187 73 3224 73 57 1853 57 sky130_fd_sc_hd__buf_4
* cell instance $18188 m0 *1 212.98,155.04
X$18188 73 1851 996 3280 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18192 m0 *1 217.58,155.04
X$18192 73 3225 73 57 1048 57 sky130_fd_sc_hd__buf_4
* cell instance $18197 m0 *1 224.02,155.04
X$18197 73 3226 3182 73 586 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $18209 m0 *1 252.54,155.04
X$18209 57 3188 3309 3227 2744 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $18212 m0 *1 264.04,155.04
X$18212 73 3193 3227 3228 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $18215 m0 *1 270.02,155.04
X$18215 73 3228 3285 3283 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $18217 m0 *1 275.08,155.04
X$18217 73 3475 2894 73 72 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $18219 m0 *1 278.76,155.04
X$18219 73 3286 2894 3229 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $18222 m0 *1 286.58,155.04
X$18222 73 76 3229 329 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18224 m0 *1 288.42,155.04
X$18224 57 3376 2689 1949 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $18235 m0 *1 316.94,155.04
X$18235 57 96 3092 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $18243 m0 *1 348.68,155.04
X$18243 73 2696 3287 2818 73 3230 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18245 m0 *1 350.98,155.04
X$18245 73 3284 3230 3373 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18248 m0 *1 356.96,155.04
X$18248 73 3231 2696 2818 73 3209 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18250 m0 *1 359.26,155.04
X$18250 73 2821 3119 3231 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18253 m0 *1 361.56,155.04
X$18253 73 2336 3079 3023 73 3942 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18255 m0 *1 364.32,155.04
X$18255 73 2696 3026 2532 57 73 3313 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18257 m0 *1 366.62,155.04
X$18257 73 2532 73 57 3232 57 sky130_fd_sc_hd__buf_4
* cell instance $18260 m0 *1 372.14,155.04
X$18260 73 3241 73 57 2532 57 sky130_fd_sc_hd__buf_4
* cell instance $18267 m0 *1 389.16,155.04
X$18267 57 15514 3235 2332 2438 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $18272 m0 *1 403.88,155.04
X$18272 73 2827 3033 3234 73 3233 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18274 m0 *1 406.18,155.04
X$18274 73 2283 2827 3317 57 73 3234 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18280 m0 *1 417.68,155.04
X$18280 73 2921 2440 3314 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18283 m0 *1 424.58,155.04
X$18283 73 3236 73 57 2820 57 sky130_fd_sc_hd__buf_4
* cell instance $18284 m0 *1 427.34,155.04
X$18284 73 3317 3037 3236 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18287 m0 *1 430.1,155.04
X$18287 73 3276 2283 3031 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18289 m0 *1 431.94,155.04
X$18289 73 2397 2778 2284 2819 2398 3237 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $18290 m0 *1 435.16,155.04
X$18290 57 3240 2397 2922 3238 3237 3239 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $18291 m0 *1 438.84,155.04
X$18291 73 2488 2927 2831 57 73 3239 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18292 m0 *1 440.68,155.04
X$18292 73 3317 3241 3196 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18293 m0 *1 442.06,155.04
X$18293 73 2634 3318 2761 57 73 3242 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18298 m0 *1 449.42,155.04
X$18298 73 3032 3240 3243 73 3320 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18299 m0 *1 451.26,155.04
X$18299 73 3319 3439 3242 57 73 3243 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18300 m0 *1 453.1,155.04
X$18300 57 3015 2749 3244 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $18303 m0 *1 462.76,155.04
X$18303 73 3233 73 57 3354 57 sky130_fd_sc_hd__buf_4
* cell instance $18313 m0 *1 490.36,155.04
X$18313 73 3199 3270 73 3245 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $18316 m0 *1 496.34,155.04
X$18316 73 3245 73 57 1979 57 sky130_fd_sc_hd__buf_4
* cell instance $18320 m0 *1 504.16,155.04
X$18320 73 3269 73 57 1182 57 sky130_fd_sc_hd__buf_4
* cell instance $18321 m0 *1 506.92,155.04
X$18321 57 3246 1876 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $18324 m0 *1 515.66,155.04
X$18324 57 3322 230 3186 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $18326 m0 *1 523.94,155.04
X$18326 73 3509 3129 3178 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18334 m0 *1 534.06,155.04
X$18334 73 3248 3928 3247 1110 3346 3128 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $18335 m0 *1 537.28,155.04
X$18335 73 2380 3132 3265 3345 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $18336 m0 *1 539.12,155.04
X$18336 73 3249 73 57 2175 57 sky130_fd_sc_hd__buf_4
* cell instance $18337 m0 *1 541.88,155.04
X$18337 73 3263 3327 3172 57 73 2346 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18341 m0 *1 552.92,155.04
X$18341 73 1775 3129 1015 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18347 m0 *1 564.88,155.04
X$18347 73 2165 73 57 2648 57 sky130_fd_sc_hd__buf_4
* cell instance $18350 m0 *1 575,155.04
X$18350 73 3160 1434 3260 1775 3250 73 2951 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $18352 m0 *1 579.14,155.04
X$18352 73 3338 73 57 3248 57 sky130_fd_sc_hd__buf_4
* cell instance $18354 m0 *1 582.36,155.04
X$18354 73 1177 2651 3250 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18357 m0 *1 586.04,155.04
X$18357 73 3259 73 57 2380 57 sky130_fd_sc_hd__buf_4
* cell instance $18358 m0 *1 588.8,155.04
X$18358 73 3250 2457 3336 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18360 m0 *1 592.02,155.04
X$18360 73 3251 1182 2352 1879 73 3337 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $18361 m0 *1 595.24,155.04
X$18361 73 2080 2082 3160 57 73 3251 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18371 m0 *1 613.18,155.04
X$18371 57 3256 3255 1775 1681 3252 3149 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $18374 m0 *1 623.76,155.04
X$18374 73 1182 1092 3141 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18383 m0 *1 643.54,155.04
X$18383 73 3142 57 73 3330 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18396 r0 *1 16.56,155.04
X$18396 73 3331 73 57 2015 57 sky130_fd_sc_hd__buf_4
* cell instance $18397 r0 *1 19.32,155.04
X$18397 73 1146 3261 3289 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18398 r0 *1 20.7,155.04
X$18398 73 1275 3290 3332 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18399 r0 *1 22.08,155.04
X$18399 73 3289 3332 3335 1502 3214 3333 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $18405 r0 *1 35.88,155.04
X$18405 73 3213 3291 2990 73 3292 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18407 r0 *1 38.64,155.04
X$18407 73 3294 2518 3291 3292 57 73 2846 57 sky130_fd_sc_hd__a31oi_1
* cell instance $18413 r0 *1 44.62,155.04
X$18413 73 1275 2361 3214 3293 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $18415 r0 *1 48.3,155.04
X$18415 73 3341 2015 1275 3293 57 73 3342 57 sky130_fd_sc_hd__a31oi_1
* cell instance $18417 r0 *1 51.06,155.04
X$18417 73 2992 1649 3384 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18418 r0 *1 52.44,155.04
X$18418 57 15628 2992 3258 1093 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $18419 r0 *1 57.04,155.04
X$18419 73 1370 2728 3294 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18421 r0 *1 59.34,155.04
X$18421 73 3258 3215 3295 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18422 r0 *1 60.72,155.04
X$18422 73 3295 73 57 3290 57 sky130_fd_sc_hd__buf_4
* cell instance $18423 r0 *1 63.48,155.04
X$18423 73 3290 3294 1275 73 3297 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $18424 r0 *1 66.24,155.04
X$18424 73 1513 73 57 3261 57 sky130_fd_sc_hd__buf_4
* cell instance $18430 r0 *1 72.68,155.04
X$18430 73 3296 73 57 3341 57 sky130_fd_sc_hd__buf_4
* cell instance $18432 r0 *1 75.9,155.04
X$18432 73 2017 1647 3296 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $18433 r0 *1 78.2,155.04
X$18433 73 1414 73 57 1197 57 sky130_fd_sc_hd__buf_4
* cell instance $18435 r0 *1 84.64,155.04
X$18435 73 1460 73 57 1150 57 sky130_fd_sc_hd__buf_4
* cell instance $18438 r0 *1 90.16,155.04
X$18438 73 1647 3297 3217 73 3298 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18439 r0 *1 92,155.04
X$18439 73 1197 3264 3110 3298 73 3348 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $18445 r0 *1 100.28,155.04
X$18445 73 2019 2420 3349 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18457 r0 *1 128.8,155.04
X$18457 73 3165 73 57 3351 57 sky130_fd_sc_hd__buf_4
* cell instance $18463 r0 *1 142.14,155.04
X$18463 73 726 1585 3299 1296 57 73 3353 57 sky130_fd_sc_hd__a31oi_1
* cell instance $18465 r0 *1 145.36,155.04
X$18465 73 991 3353 2275 2429 3355 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $18469 r0 *1 152.26,155.04
X$18469 73 875 2743 3220 3757 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $18473 r0 *1 157.32,155.04
X$18473 73 3001 728 3358 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18477 r0 *1 161.92,155.04
X$18477 73 1585 3001 3003 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18483 r0 *1 173.88,155.04
X$18483 73 3225 73 57 2026 57 sky130_fd_sc_hd__buf_4
* cell instance $18484 r0 *1 176.64,155.04
X$18484 73 2906 3300 3301 3073 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $18486 r0 *1 178.48,155.04
X$18486 73 3360 3392 3361 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $18491 r0 *1 185.38,155.04
X$18491 57 2318 3301 3363 3446 3592 3362 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $18493 r0 *1 189.06,155.04
X$18493 73 847 3364 3175 3220 73 3363 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $18494 r0 *1 191.82,155.04
X$18494 73 728 73 57 2423 57 sky130_fd_sc_hd__buf_4
* cell instance $18496 r0 *1 198.26,155.04
X$18496 73 3304 632 3302 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18497 r0 *1 199.64,155.04
X$18497 73 1585 726 3303 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18498 r0 *1 201.02,155.04
X$18498 73 2217 3303 3302 57 73 2597 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18500 r0 *1 203.78,155.04
X$18500 73 3303 73 57 2322 57 sky130_fd_sc_hd__buf_4
* cell instance $18502 r0 *1 206.54,155.04
X$18502 73 3304 2217 3180 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18503 r0 *1 207.92,155.04
X$18503 73 1584 1296 3224 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18507 r0 *1 212.06,155.04
X$18507 57 3084 3398 2600 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $18510 r0 *1 223.56,155.04
X$18510 57 3225 3305 2777 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $18511 r0 *1 229.54,155.04
X$18511 57 3454 728 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $18515 r0 *1 241.04,155.04
X$18515 73 3306 3282 3369 73 3368 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18516 r0 *1 242.88,155.04
X$18516 73 3306 98 3369 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18520 r0 *1 247.48,155.04
X$18520 73 3307 3007 3308 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $18521 r0 *1 250.7,155.04
X$18521 73 3308 3310 3086 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $18522 r0 *1 253.92,155.04
X$18522 73 3307 2747 3309 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $18524 r0 *1 258.98,155.04
X$18524 57 3305 95 3459 3018 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $18528 r0 *1 264.96,155.04
X$18528 73 3306 147 3371 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18532 r0 *1 272.32,155.04
X$18532 73 3374 3309 73 3462 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $18533 r0 *1 275.54,155.04
X$18533 57 3374 3285 3015 3226 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $18537 r0 *1 287.96,155.04
X$18537 73 3015 3375 73 146 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $18540 r0 *1 292.56,155.04
X$18540 57 3198 480 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $18546 r0 *1 312.34,155.04
X$18546 57 3378 3092 679 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $18556 r0 *1 340.86,155.04
X$18556 73 3456 3281 2969 3311 57 73 3377 57 sky130_fd_sc_hd__a31oi_1
* cell instance $18560 r0 *1 345.92,155.04
X$18560 73 3235 3232 3312 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18563 r0 *1 348.22,155.04
X$18563 73 3529 73 57 2884 57 sky130_fd_sc_hd__buf_4
* cell instance $18566 r0 *1 353.74,155.04
X$18566 73 3313 2491 2773 3372 57 3311 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $18572 r0 *1 369.38,155.04
X$18572 73 3370 73 57 3367 57 sky130_fd_sc_hd__buf_4
* cell instance $18573 r0 *1 372.14,155.04
X$18573 73 3313 73 57 4489 57 sky130_fd_sc_hd__buf_4
* cell instance $18576 r0 *1 377.2,155.04
X$18576 73 3026 3232 3554 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18584 r0 *1 398.82,155.04
X$18584 73 3033 3125 3315 57 73 3366 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18585 r0 *1 400.66,155.04
X$18585 73 3033 3315 3314 3281 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $18588 r0 *1 403.42,155.04
X$18588 73 3124 2283 3315 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18589 r0 *1 404.8,155.04
X$18589 73 3316 3317 2778 2822 3365 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $18605 r0 *1 449.42,155.04
X$18605 73 3319 3318 2868 3359 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $18608 r0 *1 454.94,155.04
X$18608 73 2336 73 57 3318 57 sky130_fd_sc_hd__buf_4
* cell instance $18613 r0 *1 461.38,155.04
X$18613 57 3189 3356 3354 3235 3037 2969 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $18615 r0 *1 468.28,155.04
X$18615 73 3320 73 57 4082 57 sky130_fd_sc_hd__buf_4
* cell instance $18626 r0 *1 489.9,155.04
X$18626 73 3199 3270 3321 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $18631 r0 *1 500.02,155.04
X$18631 73 3352 73 57 1893 57 sky130_fd_sc_hd__buf_4
* cell instance $18635 r0 *1 508.3,155.04
X$18635 73 3269 73 57 2651 57 sky130_fd_sc_hd__buf_4
* cell instance $18641 r0 *1 521.18,155.04
X$18641 73 3321 73 57 1177 57 sky130_fd_sc_hd__buf_4
* cell instance $18642 r0 *1 523.94,155.04
X$18642 73 3323 3062 3039 3350 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $18643 r0 *1 526.7,155.04
X$18643 73 3321 3246 1346 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18644 r0 *1 528.08,155.04
X$18644 73 3131 73 57 3323 57 sky130_fd_sc_hd__buf_4
* cell instance $18648 r0 *1 533.14,155.04
X$18648 73 3323 3324 1635 73 3346 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18649 r0 *1 534.98,155.04
X$18649 73 2930 1799 3345 3325 73 3326 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $18655 r0 *1 541.42,155.04
X$18655 73 3344 3249 3129 3246 57 73 3327 57 sky130_fd_sc_hd__a31oi_1
* cell instance $18658 r0 *1 549.24,155.04
X$18658 73 2648 1679 3039 73 3412 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18660 r0 *1 552,155.04
X$18660 73 2648 1015 3343 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18668 r0 *1 570.4,155.04
X$18668 73 3044 73 57 3340 57 sky130_fd_sc_hd__buf_4
* cell instance $18671 r0 *1 578.68,155.04
X$18671 73 1503 3337 3339 57 73 3338 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18676 r0 *1 586.96,155.04
X$18676 73 1177 1893 3259 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18682 r0 *1 600.3,155.04
X$18682 73 3259 73 57 3334 57 sky130_fd_sc_hd__buf_4
* cell instance $18685 r0 *1 607.66,155.04
X$18685 73 1775 3323 3252 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18707 r0 *1 656.88,155.04
X$18707 73 3253 57 73 3329 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18760 m0 *1 14.26,160.48
X$18760 73 897 985 3254 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18762 m0 *1 16.56,160.48
X$18762 57 3380 3381 3291 3254 2944 3331 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $18764 m0 *1 20.7,160.48
X$18764 73 2545 1831 2670 3333 73 3650 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $18765 m0 *1 23,160.48
X$18765 57 3380 1651 897 971 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $18766 m0 *1 26.68,160.48
X$18766 73 3571 2670 3381 57 73 3418 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18772 m0 *1 33.12,160.48
X$18772 57 15454 3213 1275 1055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $18774 m0 *1 39.56,160.48
X$18774 73 3419 73 57 2518 57 sky130_fd_sc_hd__buf_4
* cell instance $18777 m0 *1 44.62,160.48
X$18777 73 3382 73 57 2361 57 sky130_fd_sc_hd__buf_4
* cell instance $18778 m0 *1 47.38,160.48
X$18778 73 971 3382 3383 2262 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $18780 m0 *1 51.06,160.48
X$18780 73 3384 73 57 3383 57 sky130_fd_sc_hd__buf_4
* cell instance $18782 m0 *1 54.74,160.48
X$18782 73 3383 73 57 2208 57 sky130_fd_sc_hd__buf_4
* cell instance $18785 m0 *1 58.42,160.48
X$18785 73 2170 1461 3385 73 2420 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18786 m0 *1 60.26,160.48
X$18786 73 3466 73 57 2203 57 sky130_fd_sc_hd__buf_4
* cell instance $18789 m0 *1 64.4,160.48
X$18789 73 3386 2019 3216 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18792 m0 *1 67.16,160.48
X$18792 73 1093 3466 1513 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18794 m0 *1 70.38,160.48
X$18794 73 3387 73 57 3388 57 sky130_fd_sc_hd__buf_4
* cell instance $18796 m0 *1 73.6,160.48
X$18796 57 3389 3296 2728 1150 1199 3388 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $18799 m0 *1 78.2,160.48
X$18799 73 1197 3578 3389 3426 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $18802 m0 *1 81.42,160.48
X$18802 73 2728 2019 2470 57 73 3425 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18806 m0 *1 86.48,160.48
X$18806 73 3390 73 57 901 57 sky130_fd_sc_hd__buf_4
* cell instance $18807 m0 *1 89.24,160.48
X$18807 73 3429 73 57 1574 57 sky130_fd_sc_hd__buf_4
* cell instance $18809 m0 *1 92.46,160.48
X$18809 73 3429 73 57 3110 57 sky130_fd_sc_hd__buf_4
* cell instance $18811 m0 *1 96.14,160.48
X$18811 73 985 73 57 2019 57 sky130_fd_sc_hd__buf_4
* cell instance $18812 m0 *1 98.9,160.48
X$18812 73 1275 3703 2208 3434 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $18815 m0 *1 103.5,160.48
X$18815 73 2734 3163 3432 3433 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $18817 m0 *1 106.26,160.48
X$18817 73 1740 1831 3163 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18834 m0 *1 143.52,160.48
X$18834 57 15464 658 3540 3299 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $18835 m0 *1 148.12,160.48
X$18835 73 991 3171 2026 73 3515 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18836 m0 *1 149.96,160.48
X$18836 73 3514 2026 3355 57 73 3300 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18839 m0 *1 153.18,160.48
X$18839 73 733 1585 3358 57 73 3442 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18840 m0 *1 155.02,160.48
X$18840 73 3442 3391 3393 3392 2485 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $18841 m0 *1 157.32,160.48
X$18841 73 3392 1465 3391 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18844 m0 *1 162.84,160.48
X$18844 73 3221 73 57 1465 57 sky130_fd_sc_hd__buf_4
* cell instance $18850 m0 *1 170.66,160.48
X$18850 73 3443 726 2743 2026 3394 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $18853 m0 *1 180.32,160.48
X$18853 73 2600 73 57 3392 57 sky130_fd_sc_hd__buf_4
* cell instance $18855 m0 *1 183.54,160.48
X$18855 73 685 3395 3362 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18857 m0 *1 186.76,160.48
X$18857 73 2143 3396 3446 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18858 m0 *1 188.14,160.48
X$18858 73 3396 3299 3302 2423 3393 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $18859 m0 *1 190.44,160.48
X$18859 73 2217 73 57 3395 57 sky130_fd_sc_hd__buf_4
* cell instance $18865 m0 *1 197.34,160.48
X$18865 57 3448 1585 3001 3397 3394 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $18867 m0 *1 201.48,160.48
X$18867 73 3299 2600 2743 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18868 m0 *1 202.86,160.48
X$18868 73 3449 73 57 1418 57 sky130_fd_sc_hd__buf_4
* cell instance $18871 m0 *1 208.38,160.48
X$18871 73 3449 73 57 632 57 sky130_fd_sc_hd__buf_4
* cell instance $18874 m0 *1 213.9,160.48
X$18874 57 2217 3398 3084 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $18880 m0 *1 227.24,160.48
X$18880 73 3305 2777 73 3454 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $18884 m0 *1 233.68,160.48
X$18884 73 3399 73 57 3398 57 sky130_fd_sc_hd__buf_4
* cell instance $18886 m0 *1 236.9,160.48
X$18886 57 3399 242 3458 3080 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $18892 m0 *1 251.16,160.48
X$18892 57 3959 2784 480 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $18893 m0 *1 258.52,160.48
X$18893 57 3459 3400 3525 3547 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $18897 m0 *1 270.02,160.48
X$18897 73 2900 3017 3400 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $18900 m0 *1 274.62,160.48
X$18900 57 3461 126 3462 3018 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $18905 m0 *1 291.64,160.48
X$18905 57 3528 3609 3401 2911 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $18922 m0 *1 339.48,160.48
X$18922 73 2820 3402 2914 73 3456 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18926 m0 *1 344.54,160.48
X$18926 57 230 3089 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $18928 m0 *1 355.58,160.48
X$18928 73 2397 3453 3452 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $18936 m0 *1 368.46,160.48
X$18936 73 3450 3035 3451 3206 3527 73 57 57 sky130_fd_sc_hd__or4_1
* cell instance $18946 m0 *1 391.92,160.48
X$18946 73 2927 3403 3480 57 73 2692 57 sky130_fd_sc_hd__a21oi_1
* cell instance $18950 m0 *1 404.8,160.48
X$18950 73 2397 3405 3365 3447 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $18951 m0 *1 406.64,160.48
X$18951 73 2827 3403 3405 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $18957 m0 *1 417.22,160.48
X$18957 73 2576 3444 2283 73 3406 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $18958 m0 *1 419.06,160.48
X$18958 73 2283 3277 3406 3596 3404 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $18962 m0 *1 427.8,160.48
X$18962 57 2922 3407 2440 3595 73 73 57 sky130_fd_sc_hd__nor3b_2
* cell instance $18963 m0 *1 432.4,160.48
X$18963 73 2398 2488 2332 3407 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $18970 m0 *1 444.82,160.48
X$18970 73 3033 2755 3441 3409 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $18971 m0 *1 446.66,160.48
X$18971 73 3408 73 57 3440 57 sky130_fd_sc_hd__buf_4
* cell instance $18974 m0 *1 450.8,160.48
X$18974 73 2397 3440 3409 3439 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $18977 m0 *1 454.02,160.48
X$18977 73 3438 3359 3436 3437 57 3244 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $18978 m0 *1 456.32,160.48
X$18978 57 3318 3437 3032 2958 3192 3435 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $18990 m0 *1 488.98,160.48
X$18990 73 3430 3431 73 3352 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $18991 m0 *1 492.2,160.48
X$18991 57 3410 3411 3269 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $19000 m0 *1 518.42,160.48
X$19000 73 3427 3131 942 3414 3428 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $19008 m0 *1 538.2,160.48
X$19008 73 1177 3491 1967 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19009 m0 *1 539.58,160.48
X$19009 73 3344 73 57 3173 57 sky130_fd_sc_hd__buf_4
* cell instance $19012 m0 *1 546.94,160.48
X$19012 73 3424 73 57 3039 57 sky130_fd_sc_hd__buf_4
* cell instance $19013 m0 *1 549.7,160.48
X$19013 73 1775 3412 3168 73 3422 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19018 m0 *1 555.22,160.48
X$19018 73 3048 3423 3421 3422 57 3413 73 57 sky130_fd_sc_hd__a22o_1
* cell instance $19019 m0 *1 558.44,160.48
X$19019 73 1681 3413 3420 73 3325 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19025 m0 *1 572.7,160.48
X$19025 57 1894 3743 1971 1346 928 3414 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $19032 m0 *1 587.88,160.48
X$19032 73 2947 3336 3572 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19038 m0 *1 605.82,160.48
X$19038 57 3417 1681 3416 1981 4132 3334 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $19059 r0 *1 4.6,160.48
X$19059 73 3379 57 73 3495 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19067 r0 *1 20.24,160.48
X$19067 73 1093 3146 3331 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19070 r0 *1 26.22,160.48
X$19070 73 2015 2948 1275 3464 57 73 3498 57 sky130_fd_sc_hd__a31oi_1
* cell instance $19071 r0 *1 28.52,160.48
X$19071 73 1651 1275 3464 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19072 r0 *1 29.9,160.48
X$19072 73 3146 73 57 3291 57 sky130_fd_sc_hd__buf_4
* cell instance $19076 r0 *1 37.72,160.48
X$19076 73 1093 985 3419 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19079 r0 *1 40.48,160.48
X$19079 73 2955 73 57 1738 57 sky130_fd_sc_hd__buf_4
* cell instance $19086 r0 *1 48.76,160.48
X$19086 73 3258 1461 3382 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19087 r0 *1 50.14,160.48
X$19087 73 3384 73 57 3501 57 sky130_fd_sc_hd__buf_4
* cell instance $19091 r0 *1 61.18,160.48
X$19091 73 3465 2203 3387 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19092 r0 *1 62.56,160.48
X$19092 73 3258 73 57 3386 57 sky130_fd_sc_hd__buf_4
* cell instance $19100 r0 *1 72.22,160.48
X$19100 73 2017 1651 1199 3154 57 3577 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $19104 r0 *1 81.42,160.48
X$19104 57 2955 3504 986 3425 3505 3390 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $19106 r0 *1 86.48,160.48
X$19106 73 2955 73 57 2734 57 sky130_fd_sc_hd__buf_4
* cell instance $19108 r0 *1 90.16,160.48
X$19108 73 2955 3467 3429 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19109 r0 *1 91.54,160.48
X$19109 73 1647 985 3467 3506 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19133 r0 *1 144.44,160.48
X$19133 73 3299 1585 3395 2275 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $19135 r0 *1 149.96,160.48
X$19135 57 3515 3003 3514 685 3468 3469 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $19142 r0 *1 159.16,160.48
X$19142 73 3587 2683 3470 57 73 2213 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19145 r0 *1 163.76,160.48
X$19145 73 2322 3443 3471 73 3470 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19146 r0 *1 165.6,160.48
X$19146 73 1742 3469 1242 73 3471 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19149 r0 *1 169.74,160.48
X$19149 73 2026 3395 3443 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19150 r0 *1 171.12,160.48
X$19150 73 658 73 57 2143 57 sky130_fd_sc_hd__buf_4
* cell instance $19151 r0 *1 173.88,160.48
X$19151 73 3225 3392 3469 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19153 r0 *1 176.18,160.48
X$19153 73 3469 73 57 2757 57 sky130_fd_sc_hd__buf_4
* cell instance $19157 r0 *1 179.86,160.48
X$19157 73 733 1242 2684 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19161 r0 *1 182.62,160.48
X$19161 73 3225 73 57 847 57 sky130_fd_sc_hd__buf_4
* cell instance $19163 r0 *1 186.3,160.48
X$19163 73 726 2423 3396 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19167 r0 *1 192.74,160.48
X$19167 73 3001 2600 2024 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19169 r0 *1 195.04,160.48
X$19169 73 2600 3175 847 57 73 3472 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19170 r0 *1 196.88,160.48
X$19170 73 3472 847 715 57 73 3397 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19173 r0 *1 201.02,160.48
X$19173 73 3449 73 57 3001 57 sky130_fd_sc_hd__buf_4
* cell instance $19174 r0 *1 203.78,160.48
X$19174 73 1585 726 2743 57 73 3473 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19177 r0 *1 205.62,160.48
X$19177 73 685 3474 3473 2394 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19180 r0 *1 209.76,160.48
X$19180 57 3521 3113 1455 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $19195 r0 *1 244.26,160.48
X$19195 57 3857 2606 3351 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $19199 r0 *1 257.6,160.48
X$19199 73 3371 3602 3306 73 4584 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $19206 r0 *1 265.42,160.48
X$19206 73 3096 3475 3525 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $19211 r0 *1 280.6,160.48
X$19211 57 3526 2978 3608 3310 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $19218 r0 *1 292.56,160.48
X$19218 57 3476 130 3528 3018 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $19219 r0 *1 296.24,160.48
X$19219 57 3549 3475 3310 73 73 57 sky130_fd_sc_hd__xnor2_4
* cell instance $19220 r0 *1 306.36,160.48
X$19220 73 3476 73 57 3411 57 sky130_fd_sc_hd__buf_4
* cell instance $19221 r0 *1 309.12,160.48
X$19221 57 3549 3092 892 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $19231 r0 *1 326.14,160.48
X$19231 73 2501 73 57 3457 57 sky130_fd_sc_hd__buf_4
* cell instance $19239 r0 *1 342.7,160.48
X$19239 73 3477 2818 3478 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19241 r0 *1 345,160.48
X$19241 73 2336 3121 3372 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19244 r0 *1 347.76,160.48
X$19244 73 3119 3529 3478 3479 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19246 r0 *1 350.06,160.48
X$19246 73 2779 2914 3529 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19248 r0 *1 351.9,160.48
X$19248 73 3479 73 57 3520 57 sky130_fd_sc_hd__buf_4
* cell instance $19251 r0 *1 362.02,160.48
X$19251 57 3604 3089 3527 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $19258 r0 *1 377.2,160.48
X$19258 73 3477 3232 3480 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19264 r0 *1 393.76,160.48
X$19264 57 2927 3524 3481 3522 2967 2336 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $19267 r0 *1 396.98,160.48
X$19267 73 2927 3480 3125 57 73 3523 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19269 r0 *1 399.28,160.48
X$19269 73 2634 3366 3482 73 3481 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19279 r0 *1 419.06,160.48
X$19279 73 2576 3276 2332 57 73 3483 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19281 r0 *1 421.82,160.48
X$19281 73 3210 2927 3484 57 73 3238 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19285 r0 *1 424.12,160.48
X$19285 73 3482 3037 3483 73 57 4094 57 sky130_fd_sc_hd__o21bai_1
* cell instance $19287 r0 *1 427.34,160.48
X$19287 73 3485 73 57 3482 57 sky130_fd_sc_hd__buf_4
* cell instance $19290 r0 *1 431.02,160.48
X$19290 73 2397 3485 3520 3519 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19291 r0 *1 432.86,160.48
X$19291 57 3407 2283 3518 3485 2634 73 73 57 sky130_fd_sc_hd__o31ai_2
* cell instance $19305 r0 *1 469.66,160.48
X$19305 73 716 73 57 3516 57 sky130_fd_sc_hd__buf_4
* cell instance $19312 r0 *1 482.08,160.48
X$19312 73 2747 3270 73 3649 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $19316 r0 *1 488.06,160.48
X$19316 57 3430 3497 3188 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $19317 r0 *1 491.74,160.48
X$19317 57 3246 3411 3410 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $19324 r0 *1 509.68,160.48
X$19324 73 3428 73 57 3513 57 sky130_fd_sc_hd__buf_4
* cell instance $19330 r0 *1 518.42,160.48
X$19330 73 1775 3511 3427 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19332 r0 *1 521.64,160.48
X$19332 73 2651 3350 3510 3664 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19335 r0 *1 524.86,160.48
X$19335 57 15591 3509 3062 1680 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $19336 r0 *1 529.46,160.48
X$19336 73 3508 3509 1679 3487 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19340 r0 *1 533.14,160.48
X$19340 73 3324 3487 2855 73 3507 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19343 r0 *1 537.28,160.48
X$19343 73 1679 3488 3423 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19344 r0 *1 538.66,160.48
X$19344 73 2175 3173 3488 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19347 r0 *1 540.96,160.48
X$19347 73 2175 2856 3129 3566 57 73 3263 57 sky130_fd_sc_hd__a31oi_1
* cell instance $19350 r0 *1 547.86,160.48
X$19350 73 3327 73 57 3489 57 sky130_fd_sc_hd__buf_4
* cell instance $19351 r0 *1 550.62,160.48
X$19351 73 3412 73 57 4198 57 sky130_fd_sc_hd__buf_4
* cell instance $19357 r0 *1 559.82,160.48
X$19357 73 3490 2855 1503 3502 57 3420 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $19364 r0 *1 577.76,160.48
X$19364 73 3491 2555 1615 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19371 r0 *1 591.1,160.48
X$19371 73 3424 1775 2936 1886 2084 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $19378 r0 *1 605.36,160.48
X$19378 73 2082 1775 3493 2249 3499 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $19379 r0 *1 607.66,160.48
X$19379 73 3492 3152 3489 3416 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $19383 r0 *1 614.1,160.48
X$19383 73 3976 3565 3493 2165 1775 3490 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $19400 r0 *1 651.36,160.48
X$19400 73 3496 57 73 3415 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19433 m0 *1 18.4,165.92
X$19433 73 1275 2948 3532 57 73 3531 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19434 m0 *1 20.24,165.92
X$19434 73 1498 3736 3531 2841 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19436 m0 *1 23,165.92
X$19436 73 1651 3291 3532 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19437 m0 *1 24.38,165.92
X$19437 73 3533 73 57 1498 57 sky130_fd_sc_hd__buf_4
* cell instance $19438 m0 *1 27.14,165.92
X$19438 73 3503 73 57 3571 57 sky130_fd_sc_hd__buf_4
* cell instance $19440 m0 *1 30.36,165.92
X$19440 73 3533 73 57 2955 57 sky130_fd_sc_hd__buf_4
* cell instance $19441 m0 *1 33.12,165.92
X$19441 73 3788 3534 2199 2990 2844 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $19444 m0 *1 36.8,165.92
X$19444 73 3291 3500 1275 57 73 3654 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19446 m0 *1 39.1,165.92
X$19446 73 3291 3535 2200 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19447 m0 *1 40.48,165.92
X$19447 73 2201 73 57 3500 57 sky130_fd_sc_hd__buf_4
* cell instance $19449 m0 *1 43.7,165.92
X$19449 73 3500 73 57 2419 57 sky130_fd_sc_hd__buf_4
* cell instance $19452 m0 *1 47.84,165.92
X$19452 57 2678 3655 1459 3501 3382 985 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $19458 m0 *1 58.42,165.92
X$19458 73 3466 73 57 1461 57 sky130_fd_sc_hd__buf_4
* cell instance $19459 m0 *1 61.18,165.92
X$19459 73 3465 73 57 1199 57 sky130_fd_sc_hd__buf_4
* cell instance $19463 m0 *1 72.22,165.92
X$19463 73 3576 2173 3577 1199 2990 73 3578 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $19471 m0 *1 86.94,165.92
X$19471 73 985 3537 3390 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19474 m0 *1 91.08,165.92
X$19474 57 3432 3580 3506 3156 2569 3537 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $19477 m0 *1 99.82,165.92
X$19477 73 2997 3538 1275 73 3581 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19478 m0 *1 101.66,165.92
X$19478 73 986 3467 3538 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19481 m0 *1 104.42,165.92
X$19481 73 3582 1831 1706 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19483 m0 *1 106.72,165.92
X$19483 73 3582 73 57 1804 57 sky130_fd_sc_hd__buf_4
* cell instance $19500 m0 *1 145.36,165.92
X$19500 73 726 3395 1742 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19501 m0 *1 146.74,165.92
X$19501 73 2024 1326 3539 3540 3167 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $19502 m0 *1 149.04,165.92
X$19502 73 3299 3540 3001 57 73 3468 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19504 m0 *1 151.34,165.92
X$19504 73 3541 73 57 2586 57 sky130_fd_sc_hd__buf_4
* cell instance $19505 m0 *1 154.1,165.92
X$19505 73 3586 73 57 659 57 sky130_fd_sc_hd__buf_4
* cell instance $19508 m0 *1 158.24,165.92
X$19508 73 3358 3588 3587 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19514 m0 *1 168.82,165.92
X$19514 73 3171 2684 3542 3001 3847 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $19515 m0 *1 171.12,165.92
X$19515 73 3542 73 57 2314 57 sky130_fd_sc_hd__buf_4
* cell instance $19516 m0 *1 173.88,165.92
X$19516 73 3591 73 57 1722 57 sky130_fd_sc_hd__buf_4
* cell instance $19520 m0 *1 181.7,165.92
X$19520 73 1242 726 3221 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19523 m0 *1 188.6,165.92
X$19523 73 1326 73 57 3175 57 sky130_fd_sc_hd__buf_4
* cell instance $19524 m0 *1 191.36,165.92
X$19524 73 726 3679 3594 57 73 3592 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19526 m0 *1 194.12,165.92
X$19526 73 3175 1537 3588 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19528 m0 *1 195.96,165.92
X$19528 73 2024 3299 1715 3304 3474 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $19534 m0 *1 213.9,165.92
X$19534 73 3543 73 57 3449 57 sky130_fd_sc_hd__inv_1
* cell instance $19536 m0 *1 215.74,165.92
X$19536 57 3543 726 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $19538 m0 *1 223.56,165.92
X$19538 57 3543 3544 3598 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $19541 m0 *1 230.92,165.92
X$19541 57 3544 557 3545 3080 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $19544 m0 *1 236.9,165.92
X$19544 73 3767 73 57 3080 57 sky130_fd_sc_hd__buf_4
* cell instance $19547 m0 *1 242.42,165.92
X$19547 57 3600 2784 3457 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $19552 m0 *1 255.3,165.92
X$19552 73 3307 3601 3401 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $19555 m0 *1 259.9,165.92
X$19555 57 3602 3401 3547 2911 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $19557 m0 *1 270.02,165.92
X$19557 57 3547 2660 2605 3226 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $19559 m0 *1 278.76,165.92
X$19559 73 3461 2894 3605 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $19560 m0 *1 281.98,165.92
X$19560 73 3767 73 57 3018 57 sky130_fd_sc_hd__buf_4
* cell instance $19561 m0 *1 284.74,165.92
X$19561 73 2900 2865 3608 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $19565 m0 *1 295.78,165.92
X$19565 57 3609 3549 2900 3445 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $19583 m0 *1 340.86,165.92
X$19583 73 3478 73 57 3610 57 sky130_fd_sc_hd__buf_4
* cell instance $19585 m0 *1 344.54,165.92
X$19585 73 3610 2819 2818 57 73 3611 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19594 m0 *1 368,165.92
X$19594 73 3020 3550 3603 3477 3551 73 3553 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $19595 m0 *1 371.22,165.92
X$19595 73 3551 3552 2917 57 73 3450 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19597 m0 *1 373.98,165.92
X$19597 73 3553 73 57 3556 57 sky130_fd_sc_hd__buf_4
* cell instance $19598 m0 *1 376.74,165.92
X$19598 73 3554 73 57 3555 57 sky130_fd_sc_hd__buf_4
* cell instance $19608 m0 *1 401.58,165.92
X$19608 73 3482 2283 3558 57 73 3599 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19609 m0 *1 403.42,165.92
X$19609 73 3517 3557 3597 73 3558 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19614 m0 *1 412.16,165.92
X$19614 73 3559 73 57 3032 57 sky130_fd_sc_hd__buf_4
* cell instance $19615 m0 *1 414.92,165.92
X$19615 73 3559 2755 3522 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19617 m0 *1 416.76,165.92
X$19617 73 3522 73 57 3560 57 sky130_fd_sc_hd__buf_4
* cell instance $19618 m0 *1 419.52,165.92
X$19618 73 3560 4312 3191 73 3596 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19623 m0 *1 428.26,165.92
X$19623 73 3595 73 57 3593 57 sky130_fd_sc_hd__buf_4
* cell instance $19626 m0 *1 436.54,165.92
X$19626 73 3593 3037 2755 2827 3562 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $19627 m0 *1 438.84,165.92
X$19627 73 3561 3555 3557 73 3408 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19630 m0 *1 442.06,165.92
X$19630 73 3639 3590 3562 3486 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19633 m0 *1 445.28,165.92
X$19633 73 3517 3037 3589 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19634 m0 *1 446.66,165.92
X$19634 73 3589 73 57 3561 57 sky130_fd_sc_hd__buf_4
* cell instance $19637 m0 *1 454.02,165.92
X$19637 73 3032 3191 2826 3560 57 3563 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $19638 m0 *1 456.78,165.92
X$19638 73 3584 3583 2826 3563 57 73 3585 57 sky130_fd_sc_hd__a31oi_1
* cell instance $19640 m0 *1 459.54,165.92
X$19640 73 2959 3032 3037 73 3583 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19651 m0 *1 487.6,165.92
X$19651 73 3430 3431 3564 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $19653 m0 *1 494.5,165.92
X$19653 73 3564 73 57 3491 57 sky130_fd_sc_hd__buf_4
* cell instance $19663 m0 *1 525.32,165.92
X$19663 73 2724 1679 3511 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19665 m0 *1 527.16,165.92
X$19665 73 3511 73 57 3565 57 sky130_fd_sc_hd__buf_4
* cell instance $19666 m0 *1 529.92,165.92
X$19666 73 1979 3491 1342 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19668 m0 *1 532.22,165.92
X$19668 73 1489 3062 1679 73 3579 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19669 m0 *1 534.06,165.92
X$19669 73 3579 1489 2246 57 73 3324 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19671 m0 *1 536.36,165.92
X$19671 73 1177 3491 3507 3575 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $19686 m0 *1 575.92,165.92
X$19686 73 3567 3565 3160 1681 57 73 3339 57 sky130_fd_sc_hd__a31oi_1
* cell instance $19688 m0 *1 579.14,165.92
X$19688 73 3491 1681 1627 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19695 m0 *1 587.42,165.92
X$19695 73 3568 4505 3572 1627 57 73 3573 57 sky130_fd_sc_hd__a31oi_1
* cell instance $19699 m0 *1 592.94,165.92
X$19699 73 2933 73 57 1881 57 sky130_fd_sc_hd__buf_4
* cell instance $19702 m0 *1 599.84,165.92
X$19702 73 3424 73 57 2082 57 sky130_fd_sc_hd__buf_4
* cell instance $19711 m0 *1 615.94,165.92
X$19711 73 2549 73 57 3493 57 sky130_fd_sc_hd__buf_4
* cell instance $19714 m0 *1 623.3,165.92
X$19714 73 1685 2549 3492 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19724 m0 *1 642.62,165.92
X$19724 73 3494 57 73 3570 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19733 r0 *1 3.68,165.92
X$19733 73 3463 57 73 4405 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19741 r0 *1 17.48,165.92
X$19741 73 2173 2715 3737 985 1146 73 3613 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $19742 r0 *1 20.7,165.92
X$19742 73 3617 73 57 2715 57 sky130_fd_sc_hd__buf_4
* cell instance $19743 r0 *1 23.46,165.92
X$19743 73 1831 3651 3650 3831 2548 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $19744 r0 *1 26.22,165.92
X$19744 73 3620 73 57 1146 57 sky130_fd_sc_hd__buf_4
* cell instance $19745 r0 *1 28.98,165.92
X$19745 73 3652 3613 3614 1738 3651 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $19747 r0 *1 31.74,165.92
X$19747 57 3615 3653 985 1055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $19748 r0 *1 36.34,165.92
X$19748 57 3616 3419 3615 1460 3654 3146 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $19755 r0 *1 48.3,165.92
X$19755 73 3655 1460 1738 3616 57 3657 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $19756 r0 *1 51.06,165.92
X$19756 73 3658 3107 3657 1738 1831 73 3536 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $19759 r0 *1 55.66,165.92
X$19759 73 3617 73 57 3385 57 sky130_fd_sc_hd__buf_4
* cell instance $19760 r0 *1 58.42,165.92
X$19760 73 3536 73 57 3659 57 sky130_fd_sc_hd__buf_4
* cell instance $19761 r0 *1 61.18,165.92
X$19761 73 1370 1461 3619 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19762 r0 *1 62.56,165.92
X$19762 73 3619 3660 3661 1275 1414 73 3503 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $19765 r0 *1 67.16,165.92
X$19765 73 3619 73 57 3576 57 sky130_fd_sc_hd__buf_4
* cell instance $19774 r0 *1 78.66,165.92
X$19774 73 1651 3620 2678 73 57 3505 57 sky130_fd_sc_hd__o21ai_1
* cell instance $19776 r0 *1 82.34,165.92
X$19776 73 3505 73 57 3666 57 sky130_fd_sc_hd__buf_4
* cell instance $19778 r0 *1 86.02,165.92
X$19778 73 3621 3666 2734 3753 1998 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $19781 r0 *1 91.08,165.92
X$19781 73 3620 3537 1367 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19783 r0 *1 92.92,165.92
X$19783 73 1367 73 57 987 57 sky130_fd_sc_hd__buf_4
* cell instance $19784 r0 *1 95.68,165.92
X$19784 73 2419 987 3668 73 3669 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19789 r0 *1 99.36,165.92
X$19789 73 2734 3669 3581 2370 3467 73 3670 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $19790 r0 *1 102.58,165.92
X$19790 73 3348 3670 3659 1831 1804 73 3671 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $19805 r0 *1 140.76,165.92
X$19805 57 15674 991 3540 3622 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $19806 r0 *1 145.36,165.92
X$19806 73 726 3395 3539 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19808 r0 *1 147.66,165.92
X$19808 73 3540 73 57 1242 57 sky130_fd_sc_hd__buf_4
* cell instance $19809 r0 *1 150.42,165.92
X$19809 73 1326 3395 3541 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19811 r0 *1 151.8,165.92
X$19811 73 3358 3586 3541 3758 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $19814 r0 *1 155.48,165.92
X$19814 73 3299 73 57 733 57 sky130_fd_sc_hd__buf_4
* cell instance $19817 r0 *1 161,165.92
X$19817 73 726 3304 3392 57 73 3357 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19818 r0 *1 162.84,165.92
X$19818 73 3392 2683 3221 57 73 3759 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19820 r0 *1 165.14,165.92
X$19820 73 2957 73 57 3629 57 sky130_fd_sc_hd__buf_4
* cell instance $19822 r0 *1 169.74,165.92
X$19822 73 1331 3395 3542 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19825 r0 *1 173.88,165.92
X$19825 73 1331 3395 726 73 3591 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19827 r0 *1 176.18,165.92
X$19827 57 15662 1331 1585 3299 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $19833 r0 *1 186.3,165.92
X$19833 57 1326 3304 3678 3299 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $19834 r0 *1 190.9,165.92
X$19834 73 1584 847 3679 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19836 r0 *1 192.74,165.92
X$19836 73 1242 2423 3594 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19839 r0 *1 196.88,165.92
X$19839 73 1585 1537 998 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $19847 r0 *1 215.28,165.92
X$19847 73 3623 3682 73 3624 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $19848 r0 *1 218.5,165.92
X$19848 57 86 3113 3624 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $19849 r0 *1 225.86,165.92
X$19849 73 3625 3598 73 87 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $19851 r0 *1 230,165.92
X$19851 73 3856 3546 3545 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $19855 r0 *1 237.36,165.92
X$19855 73 2774 73 57 3601 57 sky130_fd_sc_hd__buf_4
* cell instance $19856 r0 *1 240.12,165.92
X$19856 73 2291 73 57 3623 57 sky130_fd_sc_hd__buf_4
* cell instance $19858 r0 *1 244.72,165.92
X$19858 57 3546 3630 3604 3623 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $19859 r0 *1 253,165.92
X$19859 73 3601 3604 3627 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $19860 r0 *1 256.22,165.92
X$19860 57 3458 3627 3628 3525 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $19863 r0 *1 264.96,165.92
X$19863 57 3548 3521 3629 3604 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $19864 r0 *1 273.24,165.92
X$19864 57 3628 2865 3521 3226 73 73 57 sky130_fd_sc_hd__xnor3_2
* cell instance $19866 r0 *1 283.82,165.92
X$19866 73 2605 2865 3775 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $19872 r0 *1 292.56,165.92
X$19872 73 3604 3475 3690 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $19875 r0 *1 298.54,165.92
X$19875 57 3692 3549 2774 2973 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $19877 r0 *1 308.66,165.92
X$19877 73 2973 73 57 3630 57 sky130_fd_sc_hd__buf_4
* cell instance $19885 r0 *1 321.54,165.92
X$19885 57 3691 3089 3516 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $19889 r0 *1 337.18,165.92
X$19889 73 2776 73 57 3631 57 sky130_fd_sc_hd__buf_4
* cell instance $19890 r0 *1 339.94,165.92
X$19890 73 2820 3631 2818 73 3689 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19893 r0 *1 342.24,165.92
X$19893 57 2818 3607 2591 3631 3632 3209 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $19894 r0 *1 345.46,165.92
X$19894 73 3232 3120 2818 57 73 3687 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19898 r0 *1 355.12,165.92
X$19898 73 3685 3404 3633 73 3686 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $19899 r0 *1 356.96,165.92
X$19899 73 2397 3607 3606 57 73 3633 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19905 r0 *1 368.46,165.92
X$19905 73 3555 3634 2818 3632 57 3603 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $19906 r0 *1 370.76,165.92
X$19906 73 3634 73 57 3639 57 sky130_fd_sc_hd__buf_4
* cell instance $19912 r0 *1 377.66,165.92
X$19912 73 2491 2825 3554 3683 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19916 r0 *1 382.72,165.92
X$19916 57 2578 3477 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $19919 r0 *1 392.84,165.92
X$19919 73 2578 73 57 3636 57 sky130_fd_sc_hd__buf_4
* cell instance $19922 r0 *1 396.52,165.92
X$19922 73 3636 3276 3776 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $19931 r0 *1 418.14,165.92
X$19931 73 2283 3020 3593 57 73 3680 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19941 r0 *1 438.84,165.92
X$19941 73 3555 73 57 3640 57 sky130_fd_sc_hd__buf_4
* cell instance $19942 r0 *1 441.6,165.92
X$19942 73 3033 2825 3640 3677 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $19948 r0 *1 454.94,165.92
X$19948 73 3585 3676 3642 3723 3438 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $19952 r0 *1 459.54,165.92
X$19952 73 3356 3674 3675 3556 73 3642 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $19956 r0 *1 467.82,165.92
X$19956 73 3673 2959 3316 57 73 3672 57 sky130_fd_sc_hd__a21oi_1
* cell instance $19958 r0 *1 470.12,165.92
X$19958 73 2865 73 57 3445 57 sky130_fd_sc_hd__buf_4
* cell instance $19983 r0 *1 527.62,165.92
X$19983 57 3667 3508 1775 1680 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $19993 r0 *1 552.92,165.92
X$19993 73 3664 3489 3662 57 73 3663 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20006 r0 *1 579.14,165.92
X$20006 73 1177 1615 3746 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20016 r0 *1 600.3,165.92
X$20016 73 1881 3136 3424 73 3656 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20019 r0 *1 604.9,165.92
X$20019 57 3740 1881 2249 3136 2082 1775 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $20024 r0 *1 616.4,165.92
X$20024 73 1775 3136 2549 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20032 r0 *1 632.5,165.92
X$20032 57 3735 2710 3649 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $20035 r0 *1 643.54,165.92
X$20035 73 3569 57 73 3647 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20094 m0 *1 14.72,171.36
X$20094 73 3512 57 73 3288 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20095 m0 *1 18.4,171.36
X$20095 73 3736 73 57 3737 57 sky130_fd_sc_hd__buf_4
* cell instance $20098 m0 *1 25.3,171.36
X$20098 57 15467 3695 1275 1055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $20100 m0 *1 30.36,171.36
X$20100 73 3695 1649 3741 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20102 m0 *1 32.66,171.36
X$20102 73 3653 3695 3146 2990 73 57 3534 57 sky130_fd_sc_hd__o31ai_1
* cell instance $20105 m0 *1 37.72,171.36
X$20105 57 15513 2201 3696 1055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $20106 m0 *1 42.32,171.36
X$20106 73 3535 73 57 3335 57 sky130_fd_sc_hd__buf_4
* cell instance $20109 m0 *1 46.46,171.36
X$20109 73 3696 73 57 1567 57 sky130_fd_sc_hd__buf_4
* cell instance $20110 m0 *1 49.22,171.36
X$20110 73 985 2419 3618 3146 57 3697 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $20111 m0 *1 51.98,171.36
X$20111 73 3701 2990 1275 3106 73 3658 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $20117 m0 *1 59.34,171.36
X$20117 73 1459 985 3618 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20118 m0 *1 60.72,171.36
X$20118 73 1093 1649 3660 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20119 m0 *1 62.1,171.36
X$20119 73 3660 73 57 2173 57 sky130_fd_sc_hd__buf_4
* cell instance $20121 m0 *1 66.7,171.36
X$20121 73 3698 73 57 3154 57 sky130_fd_sc_hd__buf_4
* cell instance $20122 m0 *1 69.46,171.36
X$20122 73 3618 73 57 2369 57 sky130_fd_sc_hd__buf_4
* cell instance $20125 m0 *1 74.98,171.36
X$20125 73 985 2728 3108 986 2369 73 3750 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $20127 m0 *1 79.12,171.36
X$20127 57 3621 3335 2728 1366 3700 3913 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $20128 m0 *1 82.34,171.36
X$20128 73 3390 73 57 3700 57 sky130_fd_sc_hd__buf_4
* cell instance $20133 m0 *1 93.84,171.36
X$20133 73 3537 1459 3467 57 73 3702 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20134 m0 *1 95.68,171.36
X$20134 73 1275 3702 3668 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20145 m0 *1 123.28,171.36
X$20145 57 1232 3755 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $20152 m0 *1 142.14,171.36
X$20152 73 3539 73 57 1715 57 sky130_fd_sc_hd__buf_4
* cell instance $20154 m0 *1 145.82,171.36
X$20154 57 15490 3704 1242 733 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $20156 m0 *1 150.88,171.36
X$20156 73 3704 73 57 1851 57 sky130_fd_sc_hd__buf_4
* cell instance $20157 m0 *1 153.64,171.36
X$20157 73 3704 3392 3586 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20160 m0 *1 160.54,171.36
X$20160 73 3684 73 57 3540 57 sky130_fd_sc_hd__inv_1
* cell instance $20163 m0 *1 163.3,171.36
X$20163 57 15565 785 3684 3622 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $20166 m0 *1 169.28,171.36
X$20166 73 3705 3759 2490 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20167 m0 *1 170.66,171.36
X$20167 73 1851 2024 847 73 3705 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20172 m0 *1 179.4,171.36
X$20172 73 785 3392 3804 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20175 m0 *1 188.14,171.36
X$20175 57 3678 1585 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $20179 m0 *1 197.34,171.36
X$20179 73 1537 2757 3761 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20180 m0 *1 198.72,171.36
X$20180 73 2757 847 1715 57 73 3850 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20182 m0 *1 201.02,171.36
X$20182 73 3622 73 57 1584 57 sky130_fd_sc_hd__buf_4
* cell instance $20185 m0 *1 205.16,171.36
X$20185 57 3766 3113 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $20186 m0 *1 214.36,171.36
X$20186 73 3629 3763 73 307 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20191 m0 *1 224.02,171.36
X$20191 73 3521 73 57 3625 57 sky130_fd_sc_hd__buf_4
* cell instance $20192 m0 *1 226.78,171.36
X$20192 73 3626 3807 73 3684 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20194 m0 *1 230.46,171.36
X$20194 73 3765 3546 3707 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $20195 m0 *1 233.68,171.36
X$20195 57 4019 2887 3707 3767 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $20197 m0 *1 239.2,171.36
X$20197 57 3626 323 3769 3767 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $20201 m0 *1 246.1,171.36
X$20201 73 3768 3708 73 3769 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20208 m0 *1 257.6,171.36
X$20208 73 3475 3226 3708 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $20209 m0 *1 260.82,171.36
X$20209 73 3708 73 57 3227 57 sky130_fd_sc_hd__buf_4
* cell instance $20212 m0 *1 269.1,171.36
X$20212 73 3096 3629 3709 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $20216 m0 *1 278.76,171.36
X$20216 57 2894 3461 3772 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $20218 m0 *1 288.42,171.36
X$20218 57 3774 3775 3692 3690 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $20235 m0 *1 338.56,171.36
X$20235 73 2336 3559 3710 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20236 m0 *1 339.94,171.36
X$20236 73 3710 73 57 2969 57 sky130_fd_sc_hd__buf_4
* cell instance $20239 m0 *1 344.08,171.36
X$20239 73 3781 3120 2914 57 73 3688 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20240 m0 *1 345.92,171.36
X$20240 57 3017 3889 3712 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $20241 m0 *1 353.28,171.36
X$20241 73 3783 73 57 3685 57 sky130_fd_sc_hd__buf_4
* cell instance $20242 m0 *1 356.04,171.36
X$20242 73 3714 73 57 3024 57 sky130_fd_sc_hd__buf_4
* cell instance $20251 m0 *1 374.9,171.36
X$20251 73 3683 3716 2397 73 3779 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20255 m0 *1 379.96,171.36
X$20255 73 3635 73 57 3716 57 sky130_fd_sc_hd__buf_4
* cell instance $20261 m0 *1 392.84,171.36
X$20261 73 2397 2967 3717 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20262 m0 *1 394.22,171.36
X$20262 73 3233 3717 3681 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20264 m0 *1 396.06,171.36
X$20264 73 2284 3776 2831 73 3635 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20267 m0 *1 402.04,171.36
X$20267 73 3447 2397 3773 57 73 3637 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20268 m0 *1 403.88,171.36
X$20268 73 3033 3234 3881 57 73 3773 57 sky130_fd_sc_hd__a21o_1
* cell instance $20277 m0 *1 422.74,171.36
X$20277 73 3557 2831 3403 3721 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $20279 m0 *1 428.26,171.36
X$20279 73 3719 3033 3595 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20283 m0 *1 438.84,171.36
X$20283 73 3557 2440 3484 57 73 3641 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20284 m0 *1 440.68,171.36
X$20284 73 3638 3641 2778 2822 3677 3675 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $20311 m0 *1 511.98,171.36
X$20311 73 3724 3513 3643 73 3762 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20312 m0 *1 513.82,171.36
X$20312 73 1979 3724 2863 57 73 3643 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20315 m0 *1 518.42,171.36
X$20315 73 1775 3725 3511 57 73 2863 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20322 m0 *1 529.92,171.36
X$20322 73 1283 3725 1611 3062 3644 73 3347 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $20325 m0 *1 535.44,171.36
X$20325 73 2555 3667 1679 57 73 3645 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20328 m0 *1 538.66,171.36
X$20328 73 3129 2856 3665 3726 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $20330 m0 *1 540.96,171.36
X$20330 57 3728 3726 2555 3246 3645 3423 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $20332 m0 *1 545.1,171.36
X$20332 57 3727 3754 3751 3575 2468 3728 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $20333 m0 *1 548.78,171.36
X$20333 73 3134 3665 1679 57 73 3752 57 sky130_fd_sc_hd__a21o_1
* cell instance $20337 m0 *1 554.76,171.36
X$20337 73 3644 3730 1092 73 3662 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20341 m0 *1 561.66,171.36
X$20341 73 930 3731 2269 3748 3646 73 3502 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $20344 m0 *1 566.26,171.36
X$20344 73 3748 1514 3732 57 73 3646 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20346 m0 *1 569.02,171.36
X$20346 73 3160 73 57 3732 57 sky130_fd_sc_hd__buf_4
* cell instance $20350 m0 *1 578.22,171.36
X$20350 73 3745 3746 3747 1792 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $20360 m0 *1 603.52,171.36
X$20360 73 3160 2717 3733 3740 57 73 3742 57 sky130_fd_sc_hd__a31oi_1
* cell instance $20366 m0 *1 613.18,171.36
X$20366 73 3739 3136 3493 2249 3139 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $20368 m0 *1 619.16,171.36
X$20368 73 1088 73 57 3738 57 sky130_fd_sc_hd__buf_4
* cell instance $20372 m0 *1 625.14,171.36
X$20372 73 3738 3733 1876 3492 57 2546 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $20380 m0 *1 644,171.36
X$20380 73 3735 57 73 5232 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20395 r0 *1 20.7,171.36
X$20395 73 985 3146 3786 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20397 r0 *1 23,171.36
X$20397 73 3786 73 57 2678 57 sky130_fd_sc_hd__buf_4
* cell instance $20401 r0 *1 28.06,171.36
X$20401 73 3694 1738 1831 1740 57 73 3831 57 sky130_fd_sc_hd__a31oi_1
* cell instance $20403 r0 *1 30.82,171.36
X$20403 73 1460 3741 3697 1738 73 57 3652 57 sky130_fd_sc_hd__o31ai_1
* cell instance $20405 r0 *1 34.5,171.36
X$20405 73 3832 1649 1781 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20407 r0 *1 36.8,171.36
X$20407 73 3832 73 57 1651 57 sky130_fd_sc_hd__buf_4
* cell instance $20416 r0 *1 47.38,171.36
X$20416 73 3696 73 57 3258 57 sky130_fd_sc_hd__buf_4
* cell instance $20417 r0 *1 50.14,171.36
X$20417 73 3620 73 57 2990 57 sky130_fd_sc_hd__buf_4
* cell instance $20419 r0 *1 54.74,171.36
X$20419 73 3466 73 57 3146 57 sky130_fd_sc_hd__buf_4
* cell instance $20423 r0 *1 63.48,171.36
X$20423 73 1649 3386 1275 3698 57 3661 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $20426 r0 *1 67.62,171.36
X$20426 73 1093 73 57 986 57 sky130_fd_sc_hd__buf_4
* cell instance $20431 r0 *1 71.76,171.36
X$20431 57 15583 3699 985 1093 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $20432 r0 *1 76.36,171.36
X$20432 73 3750 3699 3108 57 73 2853 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20434 r0 *1 79.12,171.36
X$20434 73 2990 986 2728 57 73 3841 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20436 r0 *1 81.42,171.36
X$20436 57 3700 3699 3753 2990 1459 3466 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $20440 r0 *1 91.54,171.36
X$20440 73 986 2678 3701 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20443 r0 *1 95.68,171.36
X$20443 57 3703 3843 1275 3467 3701 1316 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $20447 r0 *1 99.36,171.36
X$20447 73 1370 2127 3703 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20451 r0 *1 111.78,171.36
X$20451 57 3811 3755 2089 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $20453 r0 *1 123.28,171.36
X$20453 73 3755 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $20458 r0 *1 127.88,171.36
X$20458 57 3512 3755 3756 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $20463 r0 *1 147.2,171.36
X$20463 73 3622 73 57 2683 57 sky130_fd_sc_hd__buf_4
* cell instance $20465 r0 *1 150.88,171.36
X$20465 57 2423 3844 3758 3801 3357 3757 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $20469 r0 *1 154.56,171.36
X$20469 73 3844 73 57 3068 57 sky130_fd_sc_hd__buf_4
* cell instance $20484 r0 *1 187.22,171.36
X$20484 73 3684 73 57 3678 57 sky130_fd_sc_hd__buf_4
* cell instance $20487 r0 *1 194.12,171.36
X$20487 73 3804 73 57 954 57 sky130_fd_sc_hd__buf_4
* cell instance $20488 r0 *1 196.88,171.36
X$20488 73 1584 3761 3849 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20491 r0 *1 199.64,171.36
X$20491 73 3299 3850 3706 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20492 r0 *1 201.02,171.36
X$20492 73 3223 3299 3684 3706 57 3852 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $20503 r0 *1 223.56,171.36
X$20503 73 3625 3629 73 3855 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20504 r0 *1 226.78,171.36
X$20504 73 3625 3808 73 3765 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20505 r0 *1 230,171.36
X$20505 73 3629 3854 73 3856 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20513 r0 *1 246.56,171.36
X$20513 57 3768 3811 3868 3859 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $20516 r0 *1 256.22,171.36
X$20516 73 3306 2607 3858 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20518 r0 *1 258.52,171.36
X$20518 73 3857 73 57 3808 57 sky130_fd_sc_hd__buf_4
* cell instance $20521 r0 *1 261.28,171.36
X$20521 73 3604 3888 73 127 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20525 r0 *1 267.26,171.36
X$20525 57 4300 3709 3813 3628 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $20528 r0 *1 280.14,171.36
X$20528 73 3809 2605 3813 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $20529 r0 *1 283.36,171.36
X$20529 57 3867 3709 3813 3692 73 73 57 sky130_fd_sc_hd__xnor3_2
* cell instance $20535 r0 *1 293.94,171.36
X$20535 73 3549 73 57 3285 57 sky130_fd_sc_hd__buf_4
* cell instance $20536 r0 *1 296.7,171.36
X$20536 73 3857 3378 3865 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $20538 r0 *1 303.6,171.36
X$20538 57 3777 3809 3814 3859 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $20541 r0 *1 313.26,171.36
X$20541 73 3549 73 57 3814 57 sky130_fd_sc_hd__buf_4
* cell instance $20550 r0 *1 329.82,171.36
X$20550 73 3814 3431 73 3830 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20554 r0 *1 339.48,171.36
X$20554 73 3710 73 57 3711 57 sky130_fd_sc_hd__buf_4
* cell instance $20557 r0 *1 342.24,171.36
X$20557 73 2403 2491 3232 73 3781 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20559 r0 *1 344.54,171.36
X$20559 73 3869 3232 2821 2336 3782 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $20561 r0 *1 347.76,171.36
X$20561 73 3085 3687 3937 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20562 r0 *1 349.14,171.36
X$20562 73 3024 3711 3373 57 73 3871 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20564 r0 *1 354.66,171.36
X$20564 73 3686 3713 3941 3940 73 3712 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $20567 r0 *1 362.48,171.36
X$20567 73 3815 73 57 3713 57 sky130_fd_sc_hd__buf_4
* cell instance $20568 r0 *1 365.24,171.36
X$20568 57 3714 3815 3783 3599 3715 2397 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $20571 r0 *1 368.46,171.36
X$20571 73 3780 3020 3816 57 73 3451 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20575 r0 *1 375.36,171.36
X$20575 73 3869 3779 3681 57 73 3874 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20579 r0 *1 385.48,171.36
X$20579 73 3551 3778 3524 57 73 3877 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20580 r0 *1 387.32,171.36
X$20580 73 2397 3720 4689 3778 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $20584 r0 *1 394.22,171.36
X$20584 73 3637 73 57 3878 57 sky130_fd_sc_hd__buf_4
* cell instance $20587 r0 *1 396.98,171.36
X$20587 73 3718 3557 3879 57 73 3816 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20589 r0 *1 399.28,171.36
X$20589 73 3776 73 57 3484 57 sky130_fd_sc_hd__buf_4
* cell instance $20593 r0 *1 404.8,171.36
X$20593 73 2283 3719 3557 3817 57 3718 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $20595 r0 *1 408.48,171.36
X$20595 73 3191 2488 2283 3817 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $20600 r0 *1 421.82,171.36
X$20600 57 3557 3720 3770 3880 3561 3721 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $20613 r0 *1 447.58,171.36
X$20613 73 2750 3318 3722 3875 73 3723 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $20616 r0 *1 449.88,171.36
X$20616 73 3561 3764 2440 57 73 3870 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20640 r0 *1 504.16,171.36
X$20640 73 3246 73 57 3724 57 sky130_fd_sc_hd__buf_4
* cell instance $20646 r0 *1 513.82,171.36
X$20646 73 3762 73 57 3760 57 sky130_fd_sc_hd__buf_4
* cell instance $20658 r0 *1 544.64,171.36
X$20658 57 3754 2738 3729 2269 1775 2649 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $20659 r0 *1 547.86,171.36
X$20659 73 2651 3752 3823 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20661 r0 *1 549.7,171.36
X$20661 73 1681 3823 3860 1261 73 57 3751 57 sky130_fd_sc_hd__o31ai_1
* cell instance $20664 r0 *1 554.76,171.36
X$20664 73 3729 3748 3825 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20665 r0 *1 556.14,171.36
X$20665 73 1092 3825 3730 2947 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $20668 r0 *1 558.44,171.36
X$20668 73 3246 73 57 3421 57 sky130_fd_sc_hd__buf_4
* cell instance $20671 r0 *1 562.58,171.36
X$20671 73 3732 73 57 3749 57 sky130_fd_sc_hd__buf_4
* cell instance $20674 r0 *1 566.72,171.36
X$20674 73 3246 3136 3975 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20677 r0 *1 569.48,171.36
X$20677 73 2705 73 57 3136 57 sky130_fd_sc_hd__buf_4
* cell instance $20678 r0 *1 572.24,171.36
X$20678 73 3340 3748 3743 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20680 r0 *1 574.54,171.36
X$20680 73 3136 4065 3744 1775 3340 3745 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $20682 r0 *1 581.44,171.36
X$20682 73 2933 73 57 3729 57 sky130_fd_sc_hd__buf_4
* cell instance $20687 r0 *1 589.72,171.36
X$20687 73 2933 73 57 3836 57 sky130_fd_sc_hd__inv_1
* cell instance $20688 r0 *1 591.1,171.36
X$20688 73 3744 3136 3975 2837 3905 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $20695 r0 *1 602.14,171.36
X$20695 57 3834 1283 3733 2555 1504 3656 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $20696 r0 *1 605.36,171.36
X$20696 73 3733 3137 3743 3136 57 3911 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $20704 r0 *1 621.92,171.36
X$20704 73 1685 3733 3644 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20715 r0 *1 643.54,171.36
X$20715 73 3648 57 73 4652 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20746 m0 *1 2.76,176.8
X$20746 73 3785 57 73 3909 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20753 m0 *1 22.54,176.8
X$20753 73 985 3787 3617 57 73 3736 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20754 m0 *1 24.38,176.8
X$20754 73 3787 73 57 2127 57 sky130_fd_sc_hd__buf_4
* cell instance $20756 m0 *1 27.6,176.8
X$20756 73 3789 3788 3498 1460 3694 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $20759 m0 *1 32.2,176.8
X$20759 73 2672 1055 985 57 73 3788 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20760 m0 *1 34.04,176.8
X$20760 73 2170 3146 1460 73 3789 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20763 m0 *1 37.26,176.8
X$20763 73 3790 73 57 897 57 sky130_fd_sc_hd__buf_4
* cell instance $20764 m0 *1 40.02,176.8
X$20764 73 3790 73 57 3696 57 sky130_fd_sc_hd__inv_1
* cell instance $20765 m0 *1 41.4,176.8
X$20765 73 3885 73 57 2898 57 sky130_fd_sc_hd__buf_4
* cell instance $20766 m0 *1 44.16,176.8
X$20766 73 3791 73 57 2170 57 sky130_fd_sc_hd__buf_4
* cell instance $20769 m0 *1 49.22,176.8
X$20769 73 3792 73 57 1459 57 sky130_fd_sc_hd__buf_4
* cell instance $20771 m0 *1 52.44,176.8
X$20771 73 3791 3794 3793 3698 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $20772 m0 *1 54.28,176.8
X$20772 73 3792 3794 3793 3617 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $20777 m0 *1 59.34,176.8
X$20777 57 15476 3837 3258 1093 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $20779 m0 *1 67.62,176.8
X$20779 73 3108 1275 2898 3795 57 73 3838 57 sky130_fd_sc_hd__a31oi_1
* cell instance $20781 m0 *1 70.38,176.8
X$20781 73 3838 1460 3839 3796 3614 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $20782 m0 *1 72.68,176.8
X$20782 73 2173 3800 1460 73 3839 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20783 m0 *1 74.52,176.8
X$20783 73 3108 3799 3797 57 73 3796 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20784 m0 *1 76.36,176.8
X$20784 73 1651 1460 3798 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20786 m0 *1 78.2,176.8
X$20786 57 1275 3580 3799 3841 3798 3466 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $20787 m0 *1 81.42,176.8
X$20787 73 3837 3108 3842 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20788 m0 *1 82.8,176.8
X$20788 73 2728 1275 3800 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20791 m0 *1 85.56,176.8
X$20791 73 3466 73 57 3537 57 sky130_fd_sc_hd__buf_4
* cell instance $20793 m0 *1 89.24,176.8
X$20793 73 1370 3800 3537 73 1653 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $20794 m0 *1 91.08,176.8
X$20794 73 3620 73 57 3467 57 sky130_fd_sc_hd__buf_4
* cell instance $20795 m0 *1 93.84,176.8
X$20795 73 1459 1275 3537 3914 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $20797 m0 *1 97.52,176.8
X$20797 73 3842 3914 3467 3843 57 73 3218 57 sky130_fd_sc_hd__a31oi_1
* cell instance $20818 m0 *1 157.32,176.8
X$20818 73 3801 2870 3802 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20819 m0 *1 158.7,176.8
X$20819 73 3803 3002 2423 3802 73 3851 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $20821 m0 *1 163.76,176.8
X$20821 57 2423 3803 2143 788 3847 1742 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $20826 m0 *1 170.66,176.8
X$20826 73 3705 3917 3846 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20829 m0 *1 174.8,176.8
X$20829 73 3804 3591 3801 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20833 m0 *1 184,176.8
X$20833 57 3848 3113 3111 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $20836 m0 *1 193.66,176.8
X$20836 73 2423 998 3805 57 73 3806 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20838 m0 *1 195.96,176.8
X$20838 73 1851 848 3805 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20839 m0 *1 197.34,176.8
X$20839 57 2620 3851 3806 3849 3852 2981 73 73 57 sky130_fd_sc_hd__o41a_1
* cell instance $20841 m0 *1 203.32,176.8
X$20841 73 3919 73 57 3299 57 sky130_fd_sc_hd__buf_4
* cell instance $20845 m0 *1 212.06,176.8
X$20845 57 3809 3113 3853 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $20853 m0 *1 234.14,176.8
X$20853 73 3810 3807 73 528 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20854 m0 *1 237.36,176.8
X$20854 73 3809 73 57 3307 57 sky130_fd_sc_hd__buf_4
* cell instance $20858 m0 *1 247.94,176.8
X$20858 73 3848 73 57 3810 57 sky130_fd_sc_hd__buf_4
* cell instance $20864 m0 *1 258.06,176.8
X$20864 73 3811 3848 73 3812 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20868 m0 *1 267.26,176.8
X$20868 73 3812 73 57 3861 57 sky130_fd_sc_hd__buf_4
* cell instance $20877 m0 *1 293.48,176.8
X$20877 73 3777 3861 73 3864 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $20878 m0 *1 296.7,176.8
X$20878 73 3858 3864 3306 57 73 3862 57 sky130_fd_sc_hd__o21a_2
* cell instance $20880 m0 *1 300.38,176.8
X$20880 73 3378 73 57 3863 57 sky130_fd_sc_hd__buf_4
* cell instance $20890 m0 *1 326.6,176.8
X$20890 73 3691 73 57 3868 57 sky130_fd_sc_hd__buf_4
* cell instance $20897 m0 *1 337.18,176.8
X$20897 73 2780 3550 3933 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20898 m0 *1 338.56,176.8
X$20898 57 2818 3873 3711 3402 3632 3933 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $20899 m0 *1 341.78,176.8
X$20899 57 230 3889 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $20911 m0 *1 380.42,176.8
X$20911 73 3477 73 57 3764 57 sky130_fd_sc_hd__buf_4
* cell instance $20919 m0 *1 399.28,176.8
X$20919 73 4169 2440 3484 57 73 3879 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20920 m0 *1 401.12,176.8
X$20920 73 3033 3968 3031 57 73 3881 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20933 m0 *1 433.78,176.8
X$20933 73 3719 73 57 3876 57 sky130_fd_sc_hd__buf_4
* cell instance $20936 m0 *1 440.68,176.8
X$20936 73 3640 3876 2283 57 73 3818 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20942 m0 *1 447.12,176.8
X$20942 73 3819 3818 3872 2827 2826 3875 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $20944 m0 *1 450.8,176.8
X$20944 73 3764 2440 2960 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20947 m0 *1 456.32,176.8
X$20947 73 2826 2960 3441 3935 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $20952 m0 *1 466.9,176.8
X$20952 73 2826 3819 3820 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20953 m0 *1 468.28,176.8
X$20953 73 3899 3672 3870 3820 3819 3932 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $20972 m0 *1 525.32,176.8
X$20972 73 3821 928 3725 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20979 m0 *1 540.96,176.8
X$20979 73 3567 1088 1489 2649 73 3866 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $20982 m0 *1 546.48,176.8
X$20982 73 3823 3822 2928 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $20984 m0 *1 548.32,176.8
X$20984 73 3129 2723 3824 57 73 3822 57 sky130_fd_sc_hd__a21oi_1
* cell instance $20985 m0 *1 550.16,176.8
X$20985 73 3748 2724 3825 3129 57 3860 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $20990 m0 *1 555.22,176.8
X$20990 73 3824 73 57 3730 57 sky130_fd_sc_hd__inv_1
* cell instance $20995 m0 *1 563.5,176.8
X$20995 73 2547 3748 3824 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $20999 m0 *1 572.7,176.8
X$20999 73 2246 3421 3845 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21000 m0 *1 574.08,176.8
X$21000 73 3845 3824 3744 2077 3826 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $21001 m0 *1 576.38,176.8
X$21001 73 928 3826 3421 2077 73 3747 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $21006 m0 *1 583.28,176.8
X$21006 73 1680 2651 3744 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21009 m0 *1 586.04,176.8
X$21009 73 928 3744 3840 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21014 m0 *1 602.14,176.8
X$21014 73 3733 2719 1283 57 73 3835 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21016 m0 *1 604.44,176.8
X$21016 73 3733 3656 3833 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21017 m0 *1 605.82,176.8
X$21017 73 2837 73 57 4325 57 sky130_fd_sc_hd__buf_4
* cell instance $21023 m0 *1 616.4,176.8
X$21023 73 3062 73 57 3733 57 sky130_fd_sc_hd__buf_4
* cell instance $21036 m0 *1 650.44,176.8
X$21036 73 3908 57 73 3734 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21042 r0 *1 5.06,176.8
X$21042 73 3693 57 73 3907 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21043 r0 *1 8.74,176.8
X$21043 73 3784 57 73 6720 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21051 r0 *1 20.7,176.8
X$21051 57 2450 3853 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $21054 r0 *1 29.44,176.8
X$21054 73 897 1649 3787 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21056 r0 *1 32.66,176.8
X$21056 57 3792 3832 3790 3883 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $21057 r0 *1 37.26,176.8
X$21057 57 15644 3885 3884 1055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $21058 r0 *1 41.86,176.8
X$21058 73 3885 3791 3535 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21066 r0 *1 45.54,176.8
X$21066 73 3883 73 57 1370 57 sky130_fd_sc_hd__buf_4
* cell instance $21069 r0 *1 53.82,176.8
X$21069 73 3792 3794 3793 3886 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $21070 r0 *1 55.66,176.8
X$21070 73 3886 73 57 1510 57 sky130_fd_sc_hd__buf_4
* cell instance $21073 r0 *1 61.18,176.8
X$21073 57 3465 1275 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $21079 r0 *1 69.92,176.8
X$21079 73 3837 3108 3795 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21082 r0 *1 75.44,176.8
X$21082 73 985 1363 3797 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $21084 r0 *1 78.2,176.8
X$21084 73 1370 1275 3799 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21087 r0 *1 80.96,176.8
X$21087 73 1370 1275 3108 73 3913 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21089 r0 *1 83.26,176.8
X$21089 73 1370 2728 3466 73 2672 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21114 r0 *1 129.72,176.8
X$21114 73 3211 57 73 3916 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21130 r0 *1 169.28,176.8
X$21130 73 3847 73 57 3917 57 sky130_fd_sc_hd__buf_4
* cell instance $21145 r0 *1 201.48,176.8
X$21145 73 3919 73 57 3622 57 sky130_fd_sc_hd__inv_1
* cell instance $21155 r0 *1 214.36,176.8
X$21155 57 76 3920 3113 60 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $21165 r0 *1 238.28,176.8
X$21165 57 3921 465 3925 3767 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $21167 r0 *1 243.8,176.8
X$21167 73 3810 3226 3923 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $21183 r0 *1 275.54,176.8
X$21183 57 3926 3863 3810 3226 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $21184 r0 *1 284.28,176.8
X$21184 73 2891 73 57 3375 57 sky130_fd_sc_hd__buf_4
* cell instance $21189 r0 *1 287.96,176.8
X$21189 73 3809 2291 4103 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $21192 r0 *1 292.56,176.8
X$21192 57 3929 3310 3930 3865 73 73 57 sky130_fd_sc_hd__xnor3_2
* cell instance $21193 r0 *1 301.3,176.8
X$21193 57 3930 2291 3691 3961 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $21213 r0 *1 341.78,176.8
X$21213 73 3889 57 73 57 sky130_fd_sc_hd__clkbuf_1
* cell instance $21216 r0 *1 344.54,176.8
X$21216 73 3611 3232 3869 3782 57 73 3934 57 sky130_fd_sc_hd__a31oi_1
* cell instance $21220 r0 *1 348.68,176.8
X$21220 57 2914 3938 3939 3287 3372 3937 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $21223 r0 *1 356.04,176.8
X$21223 73 2397 3892 2691 3891 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $21224 r0 *1 357.88,176.8
X$21224 73 3891 3942 3944 73 3941 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21236 r0 *1 377.66,176.8
X$21236 73 3123 3764 3947 57 73 3948 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21249 r0 *1 406.64,176.8
X$21249 73 3817 73 57 3894 57 sky130_fd_sc_hd__buf_4
* cell instance $21255 r0 *1 421.82,176.8
X$21255 73 3719 2283 3880 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21267 r0 *1 433.78,176.8
X$21267 73 3519 3945 2969 57 73 3946 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21268 r0 *1 435.62,176.8
X$21268 73 3276 3872 3943 73 3945 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21277 r0 *1 455.86,176.8
X$21277 73 3894 3896 3895 73 3897 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21281 r0 *1 459.54,176.8
X$21281 73 3898 3897 3935 3674 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $21283 r0 *1 465.06,176.8
X$21283 73 3899 3819 3898 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21311 r0 *1 522.1,176.8
X$21311 73 3821 3900 3931 73 3183 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21320 r0 *1 536.36,176.8
X$21320 73 3866 3927 3918 3928 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $21338 r0 *1 569.02,176.8
X$21338 57 3924 1982 3760 3903 3902 3922 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $21342 r0 *1 578.68,176.8
X$21342 73 3836 73 57 3821 57 sky130_fd_sc_hd__buf_4
* cell instance $21344 r0 *1 585.12,176.8
X$21344 73 2356 3840 2246 73 3918 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21354 r0 *1 597.08,176.8
X$21354 73 3985 73 57 2703 57 sky130_fd_sc_hd__buf_4
* cell instance $21355 r0 *1 599.84,176.8
X$21355 73 3915 3835 1979 3421 3902 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $21357 r0 *1 603.52,176.8
X$21357 73 1681 3742 3906 73 3912 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21358 r0 *1 605.36,176.8
X$21358 57 3834 3906 3421 3911 3910 2269 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $21361 r0 *1 611.34,176.8
X$21361 57 3739 3836 1685 3062 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $21385 m0 *1 2.3,182.24
X$21385 73 3950 57 73 3882 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21386 m0 *1 5.98,182.24
X$21386 57 3950 3951 3953 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $21389 m0 *1 17.94,182.24
X$21389 73 3952 3909 3955 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21392 m0 *1 22.08,182.24
X$21392 57 3983 1460 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $21397 m0 *1 35.88,182.24
X$21397 73 3883 73 57 1055 57 sky130_fd_sc_hd__buf_4
* cell instance $21398 m0 *1 38.64,182.24
X$21398 57 15507 3791 3884 3984 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $21399 m0 *1 43.24,182.24
X$21399 73 3883 73 57 3984 57 sky130_fd_sc_hd__inv_1
* cell instance $21401 m0 *1 45.08,182.24
X$21401 73 3984 73 57 1093 57 sky130_fd_sc_hd__buf_4
* cell instance $21404 m0 *1 50.6,182.24
X$21404 73 3884 73 57 2728 57 sky130_fd_sc_hd__buf_4
* cell instance $21405 m0 *1 53.36,182.24
X$21405 57 3793 3466 3794 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $21407 m0 *1 57.96,182.24
X$21407 73 3954 73 57 3793 57 sky130_fd_sc_hd__buf_4
* cell instance $21421 m0 *1 95.68,182.24
X$21421 57 1821 1232 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $21432 m0 *1 127.42,182.24
X$21432 73 3811 4100 73 3756 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $21445 m0 *1 160.54,182.24
X$21445 73 3989 3990 4336 73 57 2810 57 sky130_fd_sc_hd__o21ai_1
* cell instance $21447 m0 *1 162.84,182.24
X$21447 73 3989 3955 5925 73 57 3956 57 sky130_fd_sc_hd__o21ai_1
* cell instance $21449 m0 *1 165.14,182.24
X$21449 73 3956 73 57 690 57 sky130_fd_sc_hd__buf_4
* cell instance $21453 m0 *1 172.5,182.24
X$21453 73 3854 4474 73 3953 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $21464 m0 *1 200.56,182.24
X$21464 57 3682 3957 3919 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $21471 m0 *1 223.56,182.24
X$21471 57 3957 3920 3994 3767 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $21473 m0 *1 227.7,182.24
X$21473 73 3887 3855 3995 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $21476 m0 *1 238.28,182.24
X$21476 73 3921 73 57 4196 57 sky130_fd_sc_hd__buf_4
* cell instance $21485 m0 *1 259.44,182.24
X$21485 73 3959 73 57 3888 57 sky130_fd_sc_hd__buf_4
* cell instance $21486 m0 *1 262.2,182.24
X$21486 57 3925 3812 3310 3868 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $21494 m0 *1 287.96,182.24
X$21494 73 3989 3460 3960 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21495 m0 *1 289.34,182.24
X$21495 73 3960 3999 3989 73 3200 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $21498 m0 *1 294.4,182.24
X$21498 57 3887 3630 3863 4001 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $21506 m0 *1 309.58,182.24
X$21506 73 3961 73 57 3859 57 sky130_fd_sc_hd__buf_4
* cell instance $21510 m0 *1 323.38,182.24
X$21510 57 3961 3889 4004 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $21518 m0 *1 344.08,182.24
X$21518 57 3372 3936 4598 3688 3312 4006 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $21519 m0 *1 347.3,182.24
X$21519 73 3119 3372 3611 4007 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $21520 m0 *1 349.14,182.24
X$21520 73 3934 3890 3938 73 3962 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21521 m0 *1 350.98,182.24
X$21521 73 3962 3963 3964 3023 57 73 3940 57 sky130_fd_sc_hd__a31oi_1
* cell instance $21522 m0 *1 353.28,182.24
X$21522 73 2488 4078 3890 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21530 m0 *1 367.54,182.24
X$21530 73 3965 3873 4010 3780 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $21533 m0 *1 370.76,182.24
X$21533 73 3966 2818 3869 3893 57 3892 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $21534 m0 *1 373.52,182.24
X$21534 73 4011 73 57 3869 57 sky130_fd_sc_hd__buf_4
* cell instance $21543 m0 *1 391.46,182.24
X$21543 73 2491 2634 4028 3715 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $21544 m0 *1 393.3,182.24
X$21544 73 3033 2967 4012 3893 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $21547 m0 *1 397.44,182.24
X$21547 73 3030 73 57 3969 57 sky130_fd_sc_hd__buf_4
* cell instance $21548 m0 *1 400.2,182.24
X$21548 73 3314 73 57 3968 57 sky130_fd_sc_hd__buf_4
* cell instance $21550 m0 *1 403.42,182.24
X$21550 73 3969 73 57 2398 57 sky130_fd_sc_hd__buf_4
* cell instance $21553 m0 *1 408.94,182.24
X$21553 73 3895 2488 2827 3970 57 73 4214 57 sky130_fd_sc_hd__a31oi_1
* cell instance $21554 m0 *1 411.24,182.24
X$21554 73 3517 3895 2283 73 3970 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21559 m0 *1 416.76,182.24
X$21559 73 3947 3680 3191 73 4008 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21566 m0 *1 435.62,182.24
X$21566 73 2440 3484 4005 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21569 m0 *1 442.52,182.24
X$21569 73 2491 2283 3550 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21575 m0 *1 455.86,182.24
X$21575 73 4003 3770 2283 3584 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $21586 m0 *1 482.08,182.24
X$21586 73 3868 4002 73 3901 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $21598 m0 *1 511.98,182.24
X$21598 73 4038 3971 1775 73 3187 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21602 m0 *1 522.1,182.24
X$21602 73 1438 3971 3931 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21604 m0 *1 523.94,182.24
X$21604 73 2724 3129 3971 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21609 m0 *1 527.62,182.24
X$21609 73 2833 73 57 2555 57 sky130_fd_sc_hd__buf_4
* cell instance $21613 m0 *1 533.6,182.24
X$21613 73 3414 4038 3062 73 2378 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21614 m0 *1 535.44,182.24
X$21614 57 15482 3998 3062 1489 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $21615 m0 *1 540.04,182.24
X$21615 73 3972 1775 3344 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21616 m0 *1 541.42,182.24
X$21616 73 2555 4070 3927 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21617 m0 *1 542.8,182.24
X$21617 73 1971 73 57 1489 57 sky130_fd_sc_hd__buf_4
* cell instance $21620 m0 *1 549.7,182.24
X$21620 73 3972 73 57 1019 57 sky130_fd_sc_hd__buf_4
* cell instance $21623 m0 *1 554.76,182.24
X$21623 73 1979 2555 3663 3997 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $21624 m0 *1 556.6,182.24
X$21624 73 1983 3997 3973 3924 57 73 3996 57 sky130_fd_sc_hd__a31oi_1
* cell instance $21630 m0 *1 575.46,182.24
X$21630 73 2077 2547 3992 57 73 3993 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21635 m0 *1 583.28,182.24
X$21635 73 3421 4038 3991 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21636 m0 *1 584.66,182.24
X$21636 73 3991 2246 2356 57 73 3904 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21638 m0 *1 586.96,182.24
X$21638 73 1680 3904 3988 73 3568 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21640 m0 *1 589.72,182.24
X$21640 73 3987 73 57 3988 57 sky130_fd_sc_hd__buf_4
* cell instance $21642 m0 *1 593.4,182.24
X$21642 57 3985 3987 3062 1177 3986 3905 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $21643 m0 *1 596.62,182.24
X$21643 73 2246 2936 3985 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21649 m0 *1 609.96,182.24
X$21649 73 3739 73 57 4400 57 sky130_fd_sc_hd__buf_4
* cell instance $21650 m0 *1 612.72,182.24
X$21650 73 2542 73 57 3976 57 sky130_fd_sc_hd__buf_4
* cell instance $21662 m0 *1 643.08,182.24
X$21662 57 3908 3981 3978 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $21665 m0 *1 653.2,182.24
X$21665 73 3980 57 73 3828 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21667 r0 *1 2.3,182.24
X$21667 73 3100 57 73 4049 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21669 r0 *1 7.82,182.24
X$21669 73 4014 57 73 4015 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21670 r0 *1 11.5,182.24
X$21670 73 3952 3907 4046 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21677 r0 *1 17.48,182.24
X$21677 57 4097 4098 3620 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $21679 r0 *1 28.52,182.24
X$21679 57 4053 1414 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $21682 r0 *1 40.48,182.24
X$21682 73 3790 73 57 3884 57 sky130_fd_sc_hd__buf_4
* cell instance $21686 r0 *1 44.16,182.24
X$21686 57 3791 1363 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $21689 r0 *1 52.9,182.24
X$21689 73 4016 73 57 3794 57 sky130_fd_sc_hd__buf_4
* cell instance $21692 r0 *1 58.42,182.24
X$21692 73 4016 3954 57 73 1649 57 sky130_fd_sc_hd__or2_4
* cell instance $21713 r0 *1 108.56,182.24
X$21713 73 2900 73 57 4057 57 sky130_fd_sc_hd__buf_4
* cell instance $21735 r0 *1 165.6,182.24
X$21735 57 4061 4060 690 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $21764 r0 *1 238.74,182.24
X$21764 57 3994 3958 4000 3923 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $21765 r0 *1 247.02,182.24
X$21765 57 4063 3307 3868 3859 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $21766 r0 *1 255.3,182.24
X$21766 57 3958 3854 3859 3475 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $21773 r0 *1 271.4,182.24
X$21773 73 3811 3854 4069 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $21777 r0 *1 283.82,182.24
X$21777 57 4071 3285 3868 3808 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $21781 r0 *1 293.48,182.24
X$21781 73 4001 73 57 3854 57 sky130_fd_sc_hd__buf_4
* cell instance $21782 r0 *1 296.24,182.24
X$21782 73 3865 73 57 4000 57 sky130_fd_sc_hd__buf_4
* cell instance $21799 r0 *1 342.24,182.24
X$21799 73 2914 2820 3402 4075 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $21802 r0 *1 345.46,182.24
X$21802 73 4075 4076 3085 73 4006 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21806 r0 *1 350.06,182.24
X$21806 73 4024 3085 2779 4007 57 73 3964 57 sky130_fd_sc_hd__a31oi_1
* cell instance $21808 r0 *1 352.82,182.24
X$21808 73 3085 4024 4078 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21815 r0 *1 369.84,182.24
X$21815 73 2397 4011 3085 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21817 r0 *1 371.68,182.24
X$21817 73 3085 73 57 3638 57 sky130_fd_sc_hd__buf_4
* cell instance $21820 r0 *1 375.36,182.24
X$21820 57 4083 2336 3948 4081 2772 3965 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $21824 r0 *1 385.02,182.24
X$21824 73 3877 4083 3967 4092 57 4004 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $21827 r0 *1 389.62,182.24
X$21827 73 2334 73 57 4029 57 sky130_fd_sc_hd__buf_4
* cell instance $21834 r0 *1 402.96,182.24
X$21834 73 4029 73 57 3317 57 sky130_fd_sc_hd__buf_4
* cell instance $21835 r0 *1 405.72,182.24
X$21835 73 2332 3241 4030 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21836 r0 *1 407.1,182.24
X$21836 73 4030 73 57 2778 57 sky130_fd_sc_hd__buf_4
* cell instance $21841 r0 *1 418.6,182.24
X$21841 73 2634 2489 4033 73 4009 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21842 r0 *1 420.44,182.24
X$21842 73 4009 2634 4032 57 73 4092 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21845 r0 *1 422.74,182.24
X$21845 57 2820 4034 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $21848 r0 *1 431.48,182.24
X$21848 73 4095 3276 3895 57 73 4491 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21849 r0 *1 433.32,182.24
X$21849 73 3714 3946 4680 57 73 3967 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21852 r0 *1 437.46,182.24
X$21852 73 3241 73 57 2283 57 sky130_fd_sc_hd__buf_4
* cell instance $21855 r0 *1 441.6,182.24
X$21855 73 3484 2283 3895 4035 57 4089 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $21860 r0 *1 452.18,182.24
X$21860 73 2826 2831 2960 4088 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $21868 r0 *1 471.5,182.24
X$21868 57 3096 230 4080 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $21870 r0 *1 478.86,182.24
X$21870 57 4002 3862 2953 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $21884 r0 *1 513.36,182.24
X$21884 73 3971 2651 1775 4038 57 4079 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $21891 r0 *1 534.06,182.24
X$21891 73 3129 3972 3062 57 73 4039 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21892 r0 *1 535.9,182.24
X$21892 57 4074 2856 3998 2651 4039 3129 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $21897 r0 *1 541.88,182.24
X$21897 73 4074 4056 2555 73 3265 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21907 r0 *1 565.34,182.24
X$21907 73 2953 73 57 3974 57 sky130_fd_sc_hd__buf_4
* cell instance $21909 r0 *1 568.56,182.24
X$21909 57 3975 4070 4068 3900 3421 2724 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $21910 r0 *1 571.78,182.24
X$21910 73 3974 1775 4068 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21913 r0 *1 575.46,182.24
X$21913 73 1775 3421 3974 73 3992 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $21915 r0 *1 578.22,182.24
X$21915 73 3836 1679 4041 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21922 r0 *1 592.94,182.24
X$21922 73 2724 3062 3975 3986 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $21927 r0 *1 601.68,182.24
X$21927 73 2936 73 57 3900 57 sky130_fd_sc_hd__buf_4
* cell instance $21928 r0 *1 604.44,182.24
X$21928 73 3334 3912 4058 4059 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $21933 r0 *1 612.72,182.24
X$21933 73 3421 3982 3976 57 73 4056 57 sky130_fd_sc_hd__a21oi_1
* cell instance $21934 r0 *1 614.56,182.24
X$21934 73 3977 928 3910 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $21936 r0 *1 616.4,182.24
X$21936 73 3977 1092 3982 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21952 r0 *1 653.2,182.24
X$21952 73 3979 57 73 4047 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21953 r0 *1 656.88,182.24
X$21953 73 4044 57 73 3328 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21955 m0 *1 4.14,187.68
X$21955 73 4013 57 73 4045 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21957 m0 *1 8.74,187.68
X$21957 57 3952 4050 3951 4045 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $21962 m0 *1 21.16,187.68
X$21962 73 3952 3495 3990 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21963 m0 *1 22.54,187.68
X$21963 73 3952 4049 4466 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $21964 m0 *1 23.92,187.68
X$21964 57 4052 4051 3533 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $21970 m0 *1 40.48,187.68
X$21970 57 4054 985 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $21974 m0 *1 51.52,187.68
X$21974 73 4054 57 73 3465 57 sky130_fd_sc_hd__inv_2
* cell instance $21976 m0 *1 53.82,187.68
X$21976 57 4016 3306 4017 4128 4018 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $21978 m0 *1 57.96,187.68
X$21978 57 3954 4018 4055 3767 4017 73 73 57 sky130_fd_sc_hd__a211oi_2
* cell instance $21993 m0 *1 95.68,187.68
X$21993 57 1232 73 73 57 sky130_fd_sc_hd__inv_12
* cell instance $22037 m0 *1 196.88,187.68
X$22037 57 3989 76 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $22043 m0 *1 212.52,187.68
X$22043 57 4297 4019 3763 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $22050 m0 *1 230,187.68
X$22050 57 4020 4050 3995 3767 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $22057 m0 *1 245.64,187.68
X$22057 73 4063 3923 73 4066 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $22061 m0 *1 252.08,187.68
X$22061 57 4064 108 4066 3767 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $22066 m0 *1 261.28,187.68
X$22066 57 4067 4020 3888 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $22085 m0 *1 310.5,187.68
X$22085 57 4001 3766 4021 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $22096 m0 *1 338.56,187.68
X$22096 57 4021 4093 3082 4022 4023 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $22101 m0 *1 347.76,187.68
X$22101 73 4025 4077 3871 4147 73 4023 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $22112 m0 *1 371.22,187.68
X$22112 73 3121 73 57 4011 57 sky130_fd_sc_hd__buf_4
* cell instance $22115 m0 *1 376.74,187.68
X$22115 73 4011 4212 4026 4081 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $22117 m0 *1 379.5,187.68
X$22117 73 4027 73 57 3965 57 sky130_fd_sc_hd__buf_4
* cell instance $22119 m0 *1 385.94,187.68
X$22119 73 4029 73 57 3939 57 sky130_fd_sc_hd__buf_4
* cell instance $22123 m0 *1 391.92,187.68
X$22123 73 2491 4028 3638 4086 4025 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $22128 m0 *1 396.06,187.68
X$22128 73 4087 3894 4028 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22130 m0 *1 401.12,187.68
X$22130 57 3719 3969 4029 73 73 57 sky130_fd_sc_hd__ha_2
* cell instance $22131 m0 *1 406.64,187.68
X$22131 73 3719 4030 4026 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22137 m0 *1 417.68,187.68
X$22137 73 4091 73 57 4076 57 sky130_fd_sc_hd__buf_4
* cell instance $22138 m0 *1 420.44,187.68
X$22138 73 4093 3023 4033 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22142 m0 *1 425.5,187.68
X$22142 73 4033 73 57 3722 57 sky130_fd_sc_hd__buf_4
* cell instance $22147 m0 *1 440.22,187.68
X$22147 73 3557 4035 3031 73 4090 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $22155 m0 *1 455.4,187.68
X$22155 73 2958 3638 4154 57 73 4085 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22158 m0 *1 460,187.68
X$22158 57 3872 3435 4003 4034 4084 2826 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $22159 m0 *1 463.22,187.68
X$22159 57 2826 4036 4153 4084 4034 3898 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $22161 m0 *1 466.9,187.68
X$22161 73 3932 4036 4085 4037 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $22162 m0 *1 468.74,187.68
X$22162 73 4205 4830 4082 4037 73 4080 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $22179 m0 *1 502.32,187.68
X$22179 73 4203 73 57 2236 57 sky130_fd_sc_hd__buf_4
* cell instance $22200 m0 *1 546.94,187.68
X$22200 73 4059 4073 3727 4116 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $22204 m0 *1 554.76,187.68
X$22204 73 3062 73 57 3748 57 sky130_fd_sc_hd__buf_4
* cell instance $22210 m0 *1 563.5,187.68
X$22210 73 3748 3421 3567 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22213 m0 *1 569.02,187.68
X$22213 57 15468 3972 3974 1971 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $22215 m0 *1 575.46,187.68
X$22215 73 4040 3567 4065 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22217 m0 *1 577.3,187.68
X$22217 73 3974 1092 4038 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22219 m0 *1 579.14,187.68
X$22219 73 4041 73 57 3731 57 sky130_fd_sc_hd__buf_4
* cell instance $22230 m0 *1 602.14,187.68
X$22230 73 1635 1887 3493 3137 1775 4058 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $22236 m0 *1 612.26,187.68
X$22236 73 3062 928 2936 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $22242 m0 *1 616.86,187.68
X$22242 57 15469 3977 1775 2547 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $22257 m0 *1 656.88,187.68
X$22257 73 4042 57 73 4048 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22259 r0 *1 4.14,187.68
X$22259 73 3949 57 73 4124 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22266 r0 *1 18.4,187.68
X$22266 57 3983 4098 4097 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $22268 r0 *1 24.84,187.68
X$22268 57 4053 4051 4052 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $22279 r0 *1 54.28,187.68
X$22279 73 3306 4127 4128 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $22280 r0 *1 56.58,187.68
X$22280 73 3306 4127 4055 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $22311 r0 *1 130.64,187.68
X$22311 73 3099 57 73 4134 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22325 r0 *1 164.22,187.68
X$22325 73 4060 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $22326 r0 *1 167.44,187.68
X$22326 57 1232 4060 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $22337 r0 *1 194.58,187.68
X$22337 73 4135 76 4101 57 73 4136 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22340 r0 *1 198.72,187.68
X$22340 57 4062 3113 4102 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $22342 r0 *1 206.08,187.68
X$22342 73 3307 4139 73 4102 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $22356 r0 *1 239.2,187.68
X$22356 73 3368 3455 4265 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $22359 r0 *1 243.8,187.68
X$22359 73 3859 2983 73 4131 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $22360 r0 *1 247.02,187.68
X$22360 57 4100 4064 4141 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $22370 r0 *1 271.4,187.68
X$22370 73 3771 4143 3306 73 4446 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $22371 r0 *1 274.16,187.68
X$22371 57 4143 3926 4069 4103 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $22374 r0 *1 283.82,187.68
X$22374 57 4144 4071 4069 4103 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $22394 r0 *1 337.18,187.68
X$22394 73 2591 3878 4145 4104 4022 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $22400 r0 *1 348.68,187.68
X$22400 73 4075 4146 3020 73 4077 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $22414 r0 *1 380.42,187.68
X$22414 73 4357 73 57 2334 57 sky130_fd_sc_hd__buf_4
* cell instance $22419 r0 *1 394.68,187.68
X$22419 73 3191 4029 2440 4152 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $22422 r0 *1 396.98,187.68
X$22422 73 3557 3968 4388 4086 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $22427 r0 *1 405.26,187.68
X$22427 73 3559 2283 2965 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22428 r0 *1 406.64,187.68
X$22428 73 2332 73 57 3033 57 sky130_fd_sc_hd__buf_4
* cell instance $22429 r0 *1 409.4,187.68
X$22429 73 4026 73 57 4155 57 sky130_fd_sc_hd__buf_4
* cell instance $22432 r0 *1 416.3,187.68
X$22432 73 4034 3317 3550 57 73 4109 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22436 r0 *1 421.36,187.68
X$22436 73 2283 2397 4156 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $22445 r0 *1 443.44,187.68
X$22445 73 3819 4090 3408 4110 57 4275 73 57 sky130_fd_sc_hd__a22o_1
* cell instance $22446 r0 *1 446.66,187.68
X$22446 73 3819 3317 3550 57 73 4110 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22450 r0 *1 450.8,187.68
X$22450 73 2826 4105 4578 4088 73 57 4154 57 sky130_fd_sc_hd__o31ai_1
* cell instance $22456 r0 *1 460.92,187.68
X$22456 73 4003 4095 4005 2826 4153 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $22474 r0 *1 504.62,187.68
X$22474 73 4150 3867 2342 57 73 4151 57 sky130_fd_sc_hd__o21a_2
* cell instance $22477 r0 *1 510.14,187.68
X$22477 73 2342 3867 4150 4111 4115 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $22479 r0 *1 513.36,187.68
X$22479 73 3867 2235 4111 4149 57 4114 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $22483 r0 *1 525.32,187.68
X$22483 73 3724 4112 4113 73 4148 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $22484 r0 *1 527.16,187.68
X$22484 73 2240 4072 4079 4113 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $22486 r0 *1 530.84,187.68
X$22486 73 2706 73 57 1680 57 sky130_fd_sc_hd__buf_4
* cell instance $22488 r0 *1 533.6,187.68
X$22488 73 4114 4115 3972 3424 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $22489 r0 *1 536.36,187.68
X$22489 73 3665 2856 1679 3343 57 73 4112 57 sky130_fd_sc_hd__a31oi_1
* cell instance $22494 r0 *1 546.48,187.68
X$22494 57 4334 4117 4116 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $22496 r0 *1 555.68,187.68
X$22496 57 4195 4117 3996 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $22503 r0 *1 572.24,187.68
X$22503 57 4142 3567 1685 928 2547 4040 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $22506 r0 *1 578.22,187.68
X$22506 73 3972 73 57 4120 57 sky130_fd_sc_hd__buf_4
* cell instance $22510 r0 *1 585.58,187.68
X$22510 73 1876 4120 1879 57 73 4140 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22511 r0 *1 587.42,187.68
X$22511 73 4120 73 57 3137 57 sky130_fd_sc_hd__buf_4
* cell instance $22512 r0 *1 590.18,187.68
X$22512 73 4137 73 57 1879 57 sky130_fd_sc_hd__buf_4
* cell instance $22517 r0 *1 598,187.68
X$22517 73 1775 3046 3915 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22521 r0 *1 605.36,187.68
X$22521 57 1876 4132 1681 3915 3833 4254 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $22526 r0 *1 613.64,187.68
X$22526 73 1971 73 57 2547 57 sky130_fd_sc_hd__buf_4
* cell instance $22539 r0 *1 639.86,187.68
X$22539 73 4043 57 73 4126 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22540 r0 *1 643.54,187.68
X$22540 57 4122 3981 3901 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $22542 r0 *1 651.36,187.68
X$22542 73 4125 57 73 4121 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22545 r0 *1 656.42,187.68
X$22545 73 4122 57 73 4991 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22548 m0 *1 4.14,193.12
X$22548 73 4096 57 73 4179 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22554 m0 *1 18.86,193.12
X$22554 57 3952 4127 3951 4182 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $22563 m0 *1 46.92,193.12
X$22563 73 4162 4183 4159 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22567 m0 *1 54.28,193.12
X$22567 73 4162 4133 4185 4192 4184 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $22572 m0 *1 59.34,193.12
X$22572 73 4159 4130 4129 4161 57 73 4160 57 sky130_fd_sc_hd__a31oi_1
* cell instance $22575 m0 *1 65.78,193.12
X$22575 73 4186 4163 4160 73 4188 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $22577 m0 *1 68.08,193.12
X$22577 73 4162 4099 4187 57 73 4186 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22582 m0 *1 71.3,193.12
X$22582 57 4163 4189 4130 4099 4822 4129 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $22585 m0 *1 76.82,193.12
X$22585 73 4129 4192 4190 57 73 4099 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22598 m0 *1 101.66,193.12
X$22598 73 4192 4191 4133 57 73 4257 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22635 m0 *1 187.22,193.12
X$22635 73 3989 4193 4135 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22644 m0 *1 205.16,193.12
X$22644 73 3195 4139 4138 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $22659 m0 *1 236.9,193.12
X$22659 57 2983 4196 4344 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $22678 m0 *1 281.06,193.12
X$22678 73 3605 73 57 4624 57 sky130_fd_sc_hd__buf_4
* cell instance $22680 m0 *1 285.66,193.12
X$22680 57 4201 128 4144 3767 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $22688 m0 *1 299.92,193.12
X$22688 57 4200 4201 4204 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $22692 m0 *1 313.72,193.12
X$22692 57 4204 2706 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $22704 m0 *1 339.02,193.12
X$22704 73 3402 73 57 4105 57 sky130_fd_sc_hd__buf_4
* cell instance $22707 m0 *1 341.78,193.12
X$22707 73 4106 73 57 3020 57 sky130_fd_sc_hd__buf_4
* cell instance $22708 m0 *1 344.54,193.12
X$22708 73 2336 3121 4106 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22711 m0 *1 348.22,193.12
X$22711 73 4087 4231 3020 73 4209 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $22713 m0 *1 350.52,193.12
X$22713 73 4208 4210 4209 3783 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $22714 m0 *1 352.36,193.12
X$22714 73 4208 73 57 4104 57 sky130_fd_sc_hd__buf_4
* cell instance $22722 m0 *1 367.54,193.12
X$22722 57 15571 4107 2491 2821 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $22727 m0 *1 376.28,193.12
X$22727 73 4167 73 57 4212 57 sky130_fd_sc_hd__buf_4
* cell instance $22730 m0 *1 381.8,193.12
X$22730 73 2488 4213 2402 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $22735 m0 *1 390.08,193.12
X$22735 73 2402 73 57 4168 57 sky130_fd_sc_hd__buf_4
* cell instance $22740 m0 *1 396.98,193.12
X$22740 73 4108 3898 4168 4147 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $22741 m0 *1 398.82,193.12
X$22741 73 4105 4169 3557 73 4108 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $22745 m0 *1 405.72,193.12
X$22745 73 4107 2283 2397 73 4215 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $22747 m0 *1 409.4,193.12
X$22747 57 4215 4031 4214 4170 4155 2397 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $22748 m0 *1 412.62,193.12
X$22748 73 2283 2827 2698 57 73 4170 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22751 m0 *1 416.76,193.12
X$22751 73 3191 2488 4351 57 73 3444 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22752 m0 *1 418.6,193.12
X$22752 73 2491 73 57 3557 57 sky130_fd_sc_hd__buf_4
* cell instance $22753 m0 *1 421.36,193.12
X$22753 73 2397 3880 3517 4156 73 4171 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $22757 m0 *1 424.58,193.12
X$22757 73 3895 4211 3314 57 73 4091 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22761 m0 *1 434.24,193.12
X$22761 73 2284 73 57 3872 57 sky130_fd_sc_hd__buf_4
* cell instance $22764 m0 *1 439.76,193.12
X$22764 73 2488 3033 2440 4172 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $22770 m0 *1 446.66,193.12
X$22770 73 4172 73 57 3673 57 sky130_fd_sc_hd__buf_4
* cell instance $22775 m0 *1 451.72,193.12
X$22775 73 3770 4031 4027 73 4207 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $22778 m0 *1 454.94,193.12
X$22778 73 4207 3770 4206 57 73 3436 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22797 m0 *1 501.4,193.12
X$22797 57 4111 4151 2705 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $22801 m0 *1 511.98,193.12
X$22801 73 2342 4173 4150 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $22812 m0 *1 531.3,193.12
X$22812 57 4203 4181 4202 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $22815 m0 *1 537.28,193.12
X$22815 73 1680 3062 4243 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $22816 m0 *1 538.66,193.12
X$22816 73 2706 73 57 4199 57 sky130_fd_sc_hd__inv_1
* cell instance $22817 m0 *1 540.04,193.12
X$22817 57 4199 1971 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $22818 m0 *1 547.4,193.12
X$22818 57 15541 4242 3062 1971 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $22819 m0 *1 552,193.12
X$22819 73 1775 1979 4198 4197 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $22823 m0 *1 556.6,193.12
X$22823 73 4175 4197 4118 4119 57 73 3973 57 sky130_fd_sc_hd__a31oi_1
* cell instance $22828 m0 *1 560.28,193.12
X$22828 73 1434 3748 1979 3749 73 4118 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $22831 m0 *1 565.34,193.12
X$22831 73 4176 1681 1979 4262 57 4119 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $22832 m0 *1 567.64,193.12
X$22832 73 1775 3421 4194 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $22835 m0 *1 571.78,193.12
X$22835 73 2651 3414 3255 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $22837 m0 *1 573.62,193.12
X$22837 73 4142 928 3993 57 73 4176 57 sky130_fd_sc_hd__a21oi_1
* cell instance $22839 m0 *1 575.92,193.12
X$22839 73 4177 73 57 2560 57 sky130_fd_sc_hd__buf_4
* cell instance $22840 m0 *1 578.68,193.12
X$22840 73 4120 928 4177 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $22848 m0 *1 588.8,193.12
X$22848 73 1775 1092 4137 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $22849 m0 *1 590.18,193.12
X$22849 73 4120 4137 2542 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $22851 m0 *1 592.02,193.12
X$22851 73 1886 3062 3665 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $22873 m0 *1 638.94,193.12
X$22873 57 4178 4181 3981 4048 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $22876 m0 *1 649.98,193.12
X$22876 57 4044 3981 4180 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $22881 r0 *1 4.14,193.12
X$22881 73 3612 57 73 4501 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22882 r0 *1 7.82,193.12
X$22882 73 3952 4124 4806 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $22885 r0 *1 10.58,193.12
X$22885 73 4158 57 73 4157 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22889 r0 *1 16.56,193.12
X$22889 57 4158 3951 4249 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $22905 r0 *1 58.42,193.12
X$22905 73 4192 4164 4253 4218 4223 73 4130 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $22915 r0 *1 82.8,193.12
X$22915 73 4218 4164 4225 73 4190 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $22917 r0 *1 85.56,193.12
X$22917 73 4165 73 57 4161 57 sky130_fd_sc_hd__buf_4
* cell instance $22928 r0 *1 102.58,193.12
X$22928 73 4257 73 57 4471 57 sky130_fd_sc_hd__buf_4
* cell instance $22946 r0 *1 148.58,193.12
X$22946 73 4136 73 57 4259 57 sky130_fd_sc_hd__buf_4
* cell instance $22952 r0 *1 155.02,193.12
X$22952 73 4136 73 57 4165 57 sky130_fd_sc_hd__inv_1
* cell instance $22956 r0 *1 164.68,193.12
X$22956 73 3601 4228 73 4249 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $22958 r0 *1 168.82,193.12
X$22958 57 4139 4060 4165 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $22965 r0 *1 183.54,193.12
X$22965 73 4679 4139 4193 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $22971 r0 *1 205.16,193.12
X$22971 73 3195 4139 73 4264 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $22988 r0 *1 241.5,193.12
X$22988 73 4265 73 57 4266 57 sky130_fd_sc_hd__buf_4
* cell instance $22991 r0 *1 248.4,193.12
X$22991 73 3306 185 4347 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $23002 r0 *1 270.02,193.12
X$23002 73 2627 3306 4273 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23003 r0 *1 271.4,193.12
X$23003 73 3306 2627 4166 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $23004 r0 *1 273.7,193.12
X$23004 57 4272 4166 4273 3774 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $23027 r0 *1 338.56,193.12
X$23027 57 4277 2818 4105 3287 3689 2336 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $23033 r0 *1 347.76,193.12
X$23033 73 3119 2819 2818 4087 57 4146 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $23034 r0 *1 350.52,193.12
X$23034 73 4093 3023 4208 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $23036 r0 *1 354.66,193.12
X$23036 73 4279 3119 4233 4306 3453 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $23037 r0 *1 356.96,193.12
X$23037 57 4279 2819 2488 2491 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $23040 r0 *1 362.02,193.12
X$23040 73 4107 3119 4280 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23041 r0 *1 363.4,193.12
X$23041 73 2818 3939 4233 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $23042 r0 *1 366.62,193.12
X$23042 73 4233 73 57 4276 57 sky130_fd_sc_hd__buf_4
* cell instance $23046 r0 *1 371.68,193.12
X$23046 73 3477 3232 2491 73 4234 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23047 r0 *1 373.52,193.12
X$23047 73 4152 4234 4167 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23050 r0 *1 375.82,193.12
X$23050 57 4945 3121 4167 3021 3124 4213 73 73 57 sky130_fd_sc_hd__a2111oi_2
* cell instance $23051 r0 *1 381.34,193.12
X$23051 73 4152 73 57 4238 57 sky130_fd_sc_hd__buf_4
* cell instance $23055 r0 *1 389.16,193.12
X$23055 73 3124 73 57 4232 57 sky130_fd_sc_hd__buf_4
* cell instance $23060 r0 *1 396.98,193.12
X$23060 73 2770 73 57 2634 57 sky130_fd_sc_hd__buf_4
* cell instance $23070 r0 *1 421.82,193.12
X$23070 73 4278 4171 4586 2778 3895 4032 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $23074 r0 *1 427.34,193.12
X$23074 73 3314 73 57 4239 57 sky130_fd_sc_hd__buf_4
* cell instance $23077 r0 *1 434.24,193.12
X$23077 73 3770 4005 4276 4211 3895 5098 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $23081 r0 *1 446.66,193.12
X$23081 73 4275 4104 2336 4240 57 73 4274 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23093 r0 *1 468.74,193.12
X$23093 73 4447 4269 3486 4104 73 57 4205 57 sky130_fd_sc_hd__o31ai_1
* cell instance $23106 r0 *1 496.34,193.12
X$23106 73 4123 57 73 4268 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23108 r0 *1 500.94,193.12
X$23108 57 4151 4111 4174 73 73 57 sky130_fd_sc_hd__xnor2_4
* cell instance $23113 r0 *1 513.82,193.12
X$23113 73 2342 4173 4149 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $23116 r0 *1 517.5,193.12
X$23116 73 4174 73 57 3129 57 sky130_fd_sc_hd__buf_4
* cell instance $23117 r0 *1 520.26,193.12
X$23117 57 4174 928 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $23121 r0 *1 530.84,193.12
X$23121 73 3177 2723 1177 1438 57 73 4175 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23123 r0 *1 533.14,193.12
X$23123 73 930 4243 1990 57 73 4263 57 sky130_fd_sc_hd__a21o_1
* cell instance $23127 r0 *1 540.96,193.12
X$23127 73 4242 3129 3724 73 3566 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23131 r0 *1 549.24,193.12
X$23131 57 1619 4117 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $23135 r0 *1 562.58,193.12
X$23135 73 4261 73 57 4072 57 sky130_fd_sc_hd__buf_4
* cell instance $23137 r0 *1 566.26,193.12
X$23137 73 2547 3255 4194 57 73 4262 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23144 r0 *1 580.98,193.12
X$23144 73 4041 4177 1775 2651 57 73 4244 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23154 r0 *1 601.68,193.12
X$23154 73 1886 1514 4243 57 73 4255 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23165 r0 *1 624.22,193.12
X$23165 73 4178 4121 4252 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23166 r0 *1 625.6,193.12
X$23166 57 4178 4251 4245 3570 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $23167 r0 *1 636.64,193.12
X$23167 73 4178 4126 4250 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23168 r0 *1 638.02,193.12
X$23168 57 4178 4248 3981 3647 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $23172 r0 *1 651.36,193.12
X$23172 57 4403 3981 4247 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $23175 m0 *1 4.14,198.56
X$23175 57 4283 3952 73 73 57 sky130_fd_sc_hd__buf_8
* cell instance $23178 m0 *1 11.96,198.56
X$23178 73 4322 57 73 4182 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23192 m0 *1 42.32,198.56
X$23192 73 4324 4327 4161 4284 57 73 4219 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23195 m0 *1 44.62,198.56
X$23195 73 4413 4217 4162 73 4414 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23199 m0 *1 52.44,198.56
X$23199 73 4218 4191 4328 4227 4288 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $23201 m0 *1 55.66,198.56
X$23201 73 4129 4184 4288 57 73 4220 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23205 m0 *1 60.72,198.56
X$23205 73 4227 4289 4331 57 73 4217 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23207 m0 *1 63.48,198.56
X$23207 73 4220 4330 4259 73 4221 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23209 m0 *1 65.78,198.56
X$23209 73 4219 4188 4665 4221 4284 4419 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $23210 m0 *1 69,198.56
X$23210 73 4291 4290 4256 57 73 4187 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23213 m0 *1 70.84,198.56
X$23213 73 4192 4222 4331 57 73 4291 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23215 m0 *1 73.6,198.56
X$23215 73 4223 4256 4189 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23218 m0 *1 76.36,198.56
X$23218 73 4332 4189 4224 4284 4287 73 4333 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $23226 m0 *1 95.68,198.56
X$23226 73 4292 4294 4225 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23232 m0 *1 103.5,198.56
X$23232 73 4227 4289 4293 57 73 4226 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23233 m0 *1 105.34,198.56
X$23233 73 4227 4293 4225 57 73 4258 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23237 m0 *1 113.16,198.56
X$23237 73 4658 4294 4295 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23239 m0 *1 115.46,198.56
X$23239 73 4295 4293 4260 4227 4129 73 4865 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $23240 m0 *1 118.68,198.56
X$23240 73 4227 4133 4222 57 73 4260 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23281 m0 *1 207.46,198.56
X$23281 73 4264 73 57 4338 57 sky130_fd_sc_hd__buf_4
* cell instance $23284 m0 *1 215.74,198.56
X$23284 57 4297 4374 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $23288 m0 *1 226.32,198.56
X$23288 73 4339 4298 4342 73 4267 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23295 m0 *1 239.66,198.56
X$23295 57 4344 4345 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $23296 m0 *1 247.02,198.56
X$23296 57 4346 3306 4300 4347 4228 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $23317 m0 *1 293.94,198.56
X$23317 73 4000 3548 4303 4229 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $23318 m0 *1 295.78,198.56
X$23318 73 4229 4349 4305 4348 3548 73 4230 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $23319 m0 *1 299,198.56
X$23319 73 4304 3548 4350 4349 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $23321 m0 *1 301.3,198.56
X$23321 73 4230 73 57 4335 57 sky130_fd_sc_hd__buf_4
* cell instance $23339 m0 *1 337.18,198.56
X$23339 73 4452 4277 2591 73 4145 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23344 m0 *1 346.38,198.56
X$23344 73 3559 73 57 2591 57 sky130_fd_sc_hd__buf_4
* cell instance $23347 m0 *1 351.9,198.56
X$23347 73 4231 73 57 4024 57 sky130_fd_sc_hd__buf_4
* cell instance $23349 m0 *1 356.5,198.56
X$23349 73 2491 4232 3119 57 73 4231 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23353 m0 *1 361.56,198.56
X$23353 57 4281 4280 3119 2914 3939 2779 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $23354 m0 *1 364.78,198.56
X$23354 73 2591 4281 4356 2336 4010 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $23358 m0 *1 369.38,198.56
X$23358 73 4093 3023 3714 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $23362 m0 *1 376.74,198.56
X$23362 73 2770 73 57 3121 57 sky130_fd_sc_hd__buf_4
* cell instance $23369 m0 *1 393.76,198.56
X$23369 73 2634 3966 4235 4232 3033 4355 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $23373 m0 *1 398.82,198.56
X$23373 73 4087 4012 3033 73 4282 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23376 m0 *1 404.8,198.56
X$23376 73 3714 73 57 3319 57 sky130_fd_sc_hd__buf_4
* cell instance $23377 m0 *1 407.56,198.56
X$23377 73 2770 73 57 4309 57 sky130_fd_sc_hd__buf_4
* cell instance $23378 m0 *1 410.32,198.56
X$23378 73 4309 2488 3191 3557 57 4311 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $23379 m0 *1 413.08,198.56
X$23379 73 2698 4309 3191 4311 57 73 4353 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23382 m0 *1 416.76,198.56
X$23382 73 4352 73 57 4351 57 sky130_fd_sc_hd__buf_4
* cell instance $23385 m0 *1 421.82,198.56
X$23385 73 4235 4313 2819 57 73 4278 57 sky130_fd_sc_hd__a21o_1
* cell instance $23388 m0 *1 424.58,198.56
X$23388 73 3517 2336 3947 73 4313 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23391 m0 *1 431.02,198.56
X$23391 73 3517 4236 3275 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23392 m0 *1 432.4,198.56
X$23392 73 3275 73 57 4237 57 sky130_fd_sc_hd__buf_4
* cell instance $23395 m0 *1 436.54,198.56
X$23395 73 2488 3947 4314 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23396 m0 *1 437.92,198.56
X$23396 73 3191 3317 4236 4456 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $23399 m0 *1 442.06,198.56
X$23399 73 3819 4238 4314 4315 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $23402 m0 *1 444.82,198.56
X$23402 73 4237 3403 3895 4089 57 73 4271 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23403 m0 *1 447.12,198.56
X$23403 57 3714 4240 3819 2336 4315 4316 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $23407 m0 *1 452.18,198.56
X$23407 73 4239 2831 2826 4317 57 73 4316 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23410 m0 *1 455.86,198.56
X$23410 73 2826 3896 4035 4317 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $23412 m0 *1 458.16,198.56
X$23412 73 4241 3318 4271 57 73 4206 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23413 m0 *1 460,198.56
X$23413 73 3318 4337 4282 57 73 4241 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23428 m0 *1 494.96,198.56
X$23428 57 4442 3038 4335 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $23438 m0 *1 519.8,198.56
X$23438 73 1681 2651 1438 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23451 m0 *1 548.32,198.56
X$23451 57 4117 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $23460 m0 *1 568.1,198.56
X$23460 73 4194 2560 4319 57 73 4261 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23470 m0 *1 587.88,198.56
X$23470 73 4244 73 57 4329 57 sky130_fd_sc_hd__buf_4
* cell instance $23475 m0 *1 600.76,198.56
X$23475 73 1514 73 57 2717 57 sky130_fd_sc_hd__buf_4
* cell instance $23478 m0 *1 605.82,198.56
X$23478 73 4325 3900 4244 73 4254 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23493 m0 *1 637.56,198.56
X$23493 57 4178 4173 3981 4321 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $23496 m0 *1 648.6,198.56
X$23496 57 1619 3981 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $23502 r0 *1 8.28,198.56
X$23502 73 3952 4405 4406 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23504 r0 *1 10.58,198.56
X$23504 73 4408 4097 4407 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $23518 r0 *1 40.94,198.56
X$23518 73 4162 4412 4414 4285 4324 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $23522 r0 *1 44.16,198.56
X$23522 73 4192 4286 4222 57 73 4413 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23524 r0 *1 46.92,198.56
X$23524 73 4287 73 57 4285 57 sky130_fd_sc_hd__buf_4
* cell instance $23529 r0 *1 58.42,198.56
X$23529 73 4191 73 57 4253 57 sky130_fd_sc_hd__buf_4
* cell instance $23539 r0 *1 73.14,198.56
X$23539 73 4419 73 57 4420 57 sky130_fd_sc_hd__buf_4
* cell instance $23546 r0 *1 90.16,198.56
X$23546 73 4469 4364 4332 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23560 r0 *1 123.74,198.56
X$23560 73 4370 73 57 4286 57 sky130_fd_sc_hd__buf_4
* cell instance $23578 r0 *1 161.92,198.56
X$23578 57 4336 4429 4431 2983 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $23599 r0 *1 211.6,198.56
X$23599 73 4266 4270 4433 4296 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $23600 r0 *1 213.44,198.56
X$23600 57 4338 4434 4266 4372 4296 4435 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $23601 r0 *1 216.66,198.56
X$23601 73 4297 57 73 4373 57 sky130_fd_sc_hd__inv_2
* cell instance $23606 r0 *1 229.54,198.56
X$23606 73 4339 4615 4342 73 4343 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23611 r0 *1 232.76,198.56
X$23611 73 4299 4341 4343 57 73 4376 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23617 r0 *1 241.5,198.56
X$23617 73 4376 73 57 4437 57 sky130_fd_sc_hd__buf_4
* cell instance $23620 r0 *1 247.02,198.56
X$23620 73 3306 185 4439 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $23621 r0 *1 249.32,198.56
X$23621 57 4377 4228 4439 3767 4300 73 73 57 sky130_fd_sc_hd__a211oi_2
* cell instance $23622 r0 *1 253.92,198.56
X$23622 73 4378 4379 4523 4374 4299 73 4301 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $23624 r0 *1 257.6,198.56
X$23624 73 4301 73 57 4270 57 sky130_fd_sc_hd__buf_4
* cell instance $23631 r0 *1 265.88,198.56
X$23631 73 4272 73 57 4443 57 sky130_fd_sc_hd__buf_4
* cell instance $23636 r0 *1 283.36,198.56
X$23636 73 3772 73 57 4302 57 sky130_fd_sc_hd__buf_4
* cell instance $23644 r0 *1 293.02,198.56
X$23644 73 3808 3863 73 4304 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $23646 r0 *1 296.7,198.56
X$23646 73 4304 4303 4348 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23647 r0 *1 298.08,198.56
X$23647 73 3548 4304 4350 4305 57 73 57 sky130_fd_sc_hd__or3b_2
* cell instance $23648 r0 *1 301.3,198.56
X$23648 73 3863 4200 73 4450 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $23672 r0 *1 352.82,198.56
X$23672 73 3632 4455 4457 3711 4210 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $23675 r0 *1 358.34,198.56
X$23675 73 2821 3119 4306 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23676 r0 *1 359.72,198.56
X$23676 73 3121 73 57 4385 57 sky130_fd_sc_hd__buf_4
* cell instance $23679 r0 *1 365.24,198.56
X$23679 73 4308 4307 3119 4460 4306 4356 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $23688 r0 *1 376.74,198.56
X$23688 73 2488 2491 4307 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23690 r0 *1 379.04,198.56
X$23690 73 4461 73 57 4357 57 sky130_fd_sc_hd__inv_1
* cell instance $23691 r0 *1 380.42,198.56
X$23691 73 4457 73 57 2698 57 sky130_fd_sc_hd__buf_4
* cell instance $23700 r0 *1 400.66,198.56
X$23700 73 3319 4354 4355 57 73 4591 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23702 r0 *1 402.96,198.56
X$23702 73 4168 4308 4588 4109 3191 73 4354 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $23705 r0 *1 408.48,198.56
X$23705 73 3191 3557 4308 4310 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $23706 r0 *1 410.32,198.56
X$23706 73 3895 4309 4462 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23708 r0 *1 412.16,198.56
X$23708 57 4462 4463 3517 3241 4310 4352 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $23709 r0 *1 415.38,198.56
X$23709 73 3895 4309 4352 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23710 r0 *1 416.76,198.56
X$23710 73 4462 73 57 4312 57 sky130_fd_sc_hd__buf_4
* cell instance $23723 r0 *1 437.46,198.56
X$23723 73 4456 73 57 4012 57 sky130_fd_sc_hd__buf_4
* cell instance $23724 r0 *1 440.22,198.56
X$23724 73 4456 73 57 4035 57 sky130_fd_sc_hd__buf_4
* cell instance $23726 r0 *1 443.44,198.56
X$23726 73 3714 3899 4340 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23729 r0 *1 448.96,198.56
X$23729 73 2491 4095 4213 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23737 r0 *1 463.68,198.56
X$23737 73 3819 4307 4448 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23750 r0 *1 490.82,198.56
X$23750 73 2660 3410 73 4445 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $23756 r0 *1 505.08,198.56
X$23756 73 4393 3724 4394 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23758 r0 *1 510.14,198.56
X$23758 73 4394 73 57 2269 57 sky130_fd_sc_hd__buf_4
* cell instance $23766 r0 *1 529.46,198.56
X$23766 73 1681 1342 2240 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23770 r0 *1 532.68,198.56
X$23770 73 4263 4436 4432 2269 57 73 3040 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23777 r0 *1 546.02,198.56
X$23777 73 2246 1679 1514 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23779 r0 *1 547.86,198.56
X$23779 57 3343 4430 1680 2269 3574 3414 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $23780 r0 *1 551.08,198.56
X$23780 73 4242 1092 4509 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23786 r0 *1 560.74,198.56
X$23786 73 2246 928 4318 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23787 r0 *1 562.12,198.56
X$23787 73 4318 73 57 3414 57 sky130_fd_sc_hd__buf_4
* cell instance $23796 r0 *1 575.46,198.56
X$23796 73 1775 1514 3260 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23797 r0 *1 576.84,198.56
X$23797 73 4421 4398 3922 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23803 r0 *1 586.5,198.56
X$23803 57 1619 15680 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $23806 r0 *1 597.08,198.56
X$23806 73 2246 1775 4417 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23809 r0 *1 601.22,198.56
X$23809 73 2651 4415 4255 4326 73 57 4398 57 sky130_fd_sc_hd__o31ai_1
* cell instance $23810 r0 *1 603.98,198.56
X$23810 73 2357 928 3900 2547 4415 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $23814 r0 *1 609.5,198.56
X$23814 73 2651 2717 4400 1092 1775 4326 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $23817 r0 *1 612.72,198.56
X$23817 73 1685 1092 4319 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23822 r0 *1 623.76,198.56
X$23822 57 4178 4323 4245 2940 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $23823 r0 *1 634.8,198.56
X$23823 57 4178 4409 4245 3330 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $23827 r0 *1 646.76,198.56
X$23827 57 3981 15441 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $23830 r0 *1 651.82,198.56
X$23830 73 4320 57 73 4404 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23832 r0 *1 655.96,198.56
X$23832 73 4403 57 73 4246 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23836 m0 *1 6.44,204
X$23836 57 4502 4407 4501 3952 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $23839 m0 *1 13.34,204
X$23839 57 1232 3951 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $23850 m0 *1 43.7,204
X$23850 73 4359 4162 4129 4570 57 73 4327 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23855 m0 *1 55.66,204
X$23855 73 4162 4360 4416 4185 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $23858 m0 *1 58.42,204
X$23858 73 4227 4253 4913 57 73 4361 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23860 m0 *1 60.72,204
X$23860 73 4416 4331 4227 4361 57 73 4362 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23861 m0 *1 63.02,204
X$23861 73 4287 4418 5167 4330 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $23862 m0 *1 64.86,204
X$23862 73 4162 4362 4418 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23869 m0 *1 76.82,204
X$23869 73 4504 4363 4284 4361 57 4224 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $23878 m0 *1 100.28,204
X$23878 73 4227 4366 4360 4365 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $23879 m0 *1 102.12,204
X$23879 73 4365 4227 4367 57 73 4423 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23880 m0 *1 103.96,204
X$23880 73 4366 4222 4364 73 4367 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23882 m0 *1 109.48,204
X$23882 73 3808 4368 73 4508 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $23888 m0 *1 123.28,204
X$23888 73 4223 4424 4370 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23891 m0 *1 125.58,204
X$23891 73 4370 73 57 4371 57 sky130_fd_sc_hd__buf_4
* cell instance $23892 m0 *1 128.34,204
X$23892 73 4510 4133 4227 4226 57 73 4511 57 sky130_fd_sc_hd__a31oi_1
* cell instance $23893 m0 *1 130.64,204
X$23893 73 4129 4371 4369 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23904 m0 *1 151.34,204
X$23904 73 4427 73 57 4200 57 sky130_fd_sc_hd__buf_4
* cell instance $23907 m0 *1 156.86,204
X$23907 73 4428 73 57 3306 57 sky130_fd_sc_hd__buf_4
* cell instance $23931 m0 *1 215.74,204
X$23931 73 4434 73 57 5125 57 sky130_fd_sc_hd__buf_4
* cell instance $23935 m0 *1 221.72,204
X$23935 73 4476 4374 4375 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23938 m0 *1 224.48,204
X$23938 73 4342 4339 4375 4299 73 57 4380 57 sky130_fd_sc_hd__o31ai_1
* cell instance $23939 m0 *1 227.24,204
X$23939 73 4375 73 57 4298 57 sky130_fd_sc_hd__buf_4
* cell instance $23946 m0 *1 245.64,204
X$23946 73 4346 4377 4522 73 57 57 sky130_fd_sc_hd__or2_2
* cell instance $23951 m0 *1 253,204
X$23951 73 4481 4438 4379 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $23952 m0 *1 254.38,204
X$23952 73 4379 73 57 4524 57 sky130_fd_sc_hd__buf_4
* cell instance $23958 m0 *1 264.04,204
X$23958 57 4368 4446 4526 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $23969 m0 *1 293.94,204
X$23969 73 4381 3306 4303 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $23988 m0 *1 335.8,204
X$23988 73 4453 73 57 4452 57 sky130_fd_sc_hd__buf_4
* cell instance $23989 m0 *1 338.56,204
X$23989 73 3477 2818 3232 4382 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $23990 m0 *1 340.4,204
X$23990 73 4454 3232 4382 73 4529 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $23992 m0 *1 342.24,204
X$23992 73 2336 4486 4383 57 73 4384 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23993 m0 *1 344.08,204
X$23993 73 2591 4454 3232 57 73 4383 57 sky130_fd_sc_hd__a21oi_1
* cell instance $23995 m0 *1 346.84,204
X$23995 57 15452 4454 3939 2821 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $23998 m0 *1 352.82,204
X$23998 57 3963 4384 4024 4458 4238 4385 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $23999 m0 *1 356.04,204
X$23999 73 2818 4306 4455 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24001 m0 *1 357.88,204
X$24001 73 4386 73 57 4458 57 sky130_fd_sc_hd__buf_4
* cell instance $24006 m0 *1 363.86,204
X$24006 57 15458 4460 2818 2821 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $24011 m0 *1 373.52,204
X$24011 73 4306 4387 3966 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24019 m0 *1 390.08,204
X$24019 73 2496 73 57 2332 57 sky130_fd_sc_hd__buf_4
* cell instance $24021 m0 *1 394.68,204
X$24021 73 4387 73 57 4388 57 sky130_fd_sc_hd__buf_4
* cell instance $24023 m0 *1 397.44,204
X$24023 73 4464 73 57 4169 57 sky130_fd_sc_hd__buf_4
* cell instance $24030 m0 *1 414.46,204
X$24030 73 4463 3241 4353 57 73 4389 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24033 m0 *1 417.68,204
X$24033 73 4389 3317 4312 57 73 4459 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24041 m0 *1 439.76,204
X$24041 73 4387 73 57 3441 57 sky130_fd_sc_hd__buf_4
* cell instance $24049 m0 *1 452.18,204
X$24049 73 3770 4451 4340 73 3676 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24052 m0 *1 459.54,204
X$24052 73 4084 3896 3895 73 4390 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24053 m0 *1 461.38,204
X$24053 73 3770 4337 4390 57 73 4449 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24055 m0 *1 465.06,204
X$24055 73 4448 2746 4449 3872 3899 73 4447 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $24068 m0 *1 493.12,204
X$24068 73 2342 4381 4444 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $24071 m0 *1 496.8,204
X$24071 73 4391 4444 4441 73 4442 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24076 m0 *1 500.94,204
X$24076 57 4393 4440 4392 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $24078 m0 *1 506.92,204
X$24078 57 4393 1681 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $24081 m0 *1 516.58,204
X$24081 73 4513 73 57 2833 57 sky130_fd_sc_hd__buf_4
* cell instance $24084 m0 *1 523.48,204
X$24084 73 4395 2237 73 4247 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $24087 m0 *1 527.62,204
X$24087 73 4334 2341 73 4397 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $24088 m0 *1 530.84,204
X$24088 73 1680 1679 2723 4436 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24094 m0 *1 544.64,204
X$24094 73 2547 1775 1514 4432 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24097 m0 *1 547.86,204
X$24097 73 1342 4430 4425 1611 4396 4073 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $24100 m0 *1 552.46,204
X$24100 73 2651 4509 4426 57 73 4497 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24102 m0 *1 554.76,204
X$24102 73 4497 1681 4498 57 73 4396 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24104 m0 *1 557.52,204
X$24104 73 3137 1775 928 2723 4426 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $24106 m0 *1 560.28,204
X$24106 73 3749 1434 1775 3043 57 73 4425 57 sky130_fd_sc_hd__a31oi_1
* cell instance $24108 m0 *1 563.04,204
X$24108 73 1775 4318 3043 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24112 m0 *1 567.64,204
X$24112 73 4140 3043 2723 928 1680 4498 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $24115 m0 *1 572.24,204
X$24115 73 3046 73 57 1434 57 sky130_fd_sc_hd__buf_4
* cell instance $24116 m0 *1 575,204
X$24116 73 1775 2651 4040 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24117 m0 *1 576.38,204
X$24117 57 4421 3975 3974 4506 4399 2547 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $24125 m0 *1 587.42,204
X$24125 57 2390 1619 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $24126 m0 *1 596.62,204
X$24126 73 4417 73 57 2723 57 sky130_fd_sc_hd__buf_4
* cell instance $24127 m0 *1 599.38,204
X$24127 73 4417 73 57 2357 57 sky130_fd_sc_hd__buf_4
* cell instance $24129 m0 *1 603.06,204
X$24129 73 928 3137 2719 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $24134 m0 *1 611.8,204
X$24134 73 2651 928 4400 4399 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24143 m0 *1 633.42,204
X$24143 73 4411 57 73 4321 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24145 m0 *1 637.56,204
X$24145 57 3496 4245 4410 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $24148 m0 *1 645.38,204
X$24148 57 4500 4245 4397 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $24152 m0 *1 655.96,204
X$24152 73 4654 57 73 4401 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24155 r0 *1 4.14,204
X$24155 57 4097 3951 4502 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $24168 r0 *1 34.04,204
X$24168 57 4472 1232 4287 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $24179 r0 *1 57.04,204
X$24179 73 4467 73 57 4416 57 sky130_fd_sc_hd__buf_4
* cell instance $24182 r0 *1 64.4,204
X$24182 73 4290 4569 4467 4331 4227 4468 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $24200 r0 *1 97.06,204
X$24200 73 4129 4366 4468 4470 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24204 r0 *1 100.74,204
X$24204 73 4508 73 57 4507 57 sky130_fd_sc_hd__buf_4
* cell instance $24208 r0 *1 111.78,204
X$24208 73 4363 4294 4287 4579 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24210 r0 *1 115.46,204
X$24210 73 4473 4369 4422 73 4748 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24212 r0 *1 119.14,204
X$24212 73 4424 4287 4473 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24213 r0 *1 120.52,204
X$24213 73 4473 4290 4223 4369 57 73 4832 57 sky130_fd_sc_hd__a31oi_1
* cell instance $24221 r0 *1 129.26,204
X$24221 73 4366 4471 4226 4611 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24223 r0 *1 134.78,204
X$24223 73 4129 4511 4512 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24241 r0 *1 172.04,204
X$24241 73 4061 73 57 4474 57 sky130_fd_sc_hd__buf_4
* cell instance $24251 r0 *1 184,204
X$24251 57 4472 4584 4475 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $24257 r0 *1 204.7,204
X$24257 57 4517 4516 4476 4374 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $24263 r0 *1 209.76,204
X$24263 57 15578 4518 4373 4589 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $24264 r0 *1 214.36,204
X$24264 73 4518 4342 4477 73 4478 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24265 r0 *1 216.2,204
X$24265 73 4299 4478 4520 73 4435 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24271 r0 *1 228.62,204
X$24271 57 4520 4593 4342 4374 4480 4479 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $24272 r0 *1 231.84,204
X$24272 73 4479 4480 4373 4339 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24276 r0 *1 233.68,204
X$24276 73 4479 4480 4374 4521 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24284 r0 *1 246.1,204
X$24284 73 4377 73 57 4714 57 sky130_fd_sc_hd__buf_4
* cell instance $24285 r0 *1 248.86,204
X$24285 57 15661 4481 4480 4479 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $24286 r0 *1 253.46,204
X$24286 73 4481 73 57 4482 57 sky130_fd_sc_hd__buf_4
* cell instance $24287 r0 *1 256.22,204
X$24287 73 4374 4483 4619 4523 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24293 r0 *1 260.82,204
X$24293 73 4141 73 57 4484 57 sky130_fd_sc_hd__inv_1
* cell instance $24297 r0 *1 264.96,204
X$24297 73 4526 73 57 4479 57 sky130_fd_sc_hd__buf_4
* cell instance $24299 r0 *1 269.56,204
X$24299 73 4380 4525 4527 73 57 57 sky130_fd_sc_hd__or2_2
* cell instance $24301 r0 *1 272.32,204
X$24301 73 4483 4485 4374 73 4528 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24332 r0 *1 340.4,204
X$24332 73 2780 2818 4530 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24336 r0 *1 341.78,204
X$24336 73 2403 2818 3119 4486 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24338 r0 *1 344.08,204
X$24338 73 4487 4530 3119 73 4531 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24342 r0 *1 347.76,204
X$24342 73 2821 2491 4487 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24347 r0 *1 356.04,204
X$24347 73 3939 2491 4457 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24350 r0 *1 362.02,204
X$24350 57 3944 4533 3023 3874 4762 3936 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $24353 r0 *1 366.62,204
X$24353 73 3939 3119 4488 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24364 r0 *1 378.12,204
X$24364 73 3944 2770 2285 4534 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24365 r0 *1 379.96,204
X$24365 73 4488 73 57 3403 57 sky130_fd_sc_hd__buf_4
* cell instance $24370 r0 *1 392.38,204
X$24370 57 2336 4453 4386 4464 2332 4532 73 73 57 sky130_fd_sc_hd__a2111oi_4
* cell instance $24376 r0 *1 404.8,204
X$24376 73 2491 4308 4490 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24377 r0 *1 406.18,204
X$24377 57 4688 4462 3517 4490 4012 3947 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $24381 r0 *1 414.46,204
X$24381 73 2921 73 57 2822 57 sky130_fd_sc_hd__buf_4
* cell instance $24388 r0 *1 426.42,204
X$24388 73 2819 4236 4387 73 4583 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24392 r0 *1 432.4,204
X$24392 73 4492 73 57 4386 57 sky130_fd_sc_hd__buf_4
* cell instance $24393 r0 *1 435.16,204
X$24393 73 2827 3872 4492 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24394 r0 *1 436.54,204
X$24394 73 3036 3241 4387 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24397 r0 *1 442.52,204
X$24397 73 2827 2778 3403 57 73 4493 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24398 r0 *1 444.36,204
X$24398 73 4238 4493 3770 73 4494 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24404 r0 *1 450.34,204
X$24404 73 3317 3872 4451 73 4519 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24407 r0 *1 454.94,204
X$24407 73 3517 73 57 4003 57 sky130_fd_sc_hd__buf_4
* cell instance $24419 r0 *1 477.94,204
X$24419 57 4829 4515 4420 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $24425 r0 *1 497.26,204
X$24425 73 4381 2342 4391 4441 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24427 r0 *1 500.94,204
X$24427 57 4496 4495 3202 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $24432 r0 *1 505.08,204
X$24432 73 4496 73 57 4440 57 sky130_fd_sc_hd__buf_4
* cell instance $24433 r0 *1 507.84,204
X$24433 73 4496 4392 73 4513 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $24437 r0 *1 515.2,204
X$24437 73 4514 73 57 2237 57 sky130_fd_sc_hd__buf_4
* cell instance $24441 r0 *1 521.18,204
X$24441 57 3322 6005 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $24466 r0 *1 576.84,204
X$24466 73 1177 3974 3046 4040 4506 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $24472 r0 *1 587.42,204
X$24472 73 929 1177 4329 3665 1092 73 4505 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $24493 r0 *1 632.96,204
X$24493 57 4178 4391 4245 4503 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $24503 r0 *1 653.2,204
X$24503 73 4402 57 73 4562 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24504 r0 *1 656.88,204
X$24504 73 4500 57 73 4499 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24506 m0 *1 2.76,209.44
X$24506 73 4465 57 73 4564 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24508 m0 *1 10.12,209.44
X$24508 73 4406 4565 3952 73 4536 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $24509 m0 *1 12.88,209.44
X$24509 57 4565 4567 4097 4472 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $24512 m0 *1 24.38,209.44
X$24512 73 4536 73 57 4129 57 sky130_fd_sc_hd__buf_4
* cell instance $24516 m0 *1 30.36,209.44
X$24516 73 4057 4472 73 4568 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $24520 m0 *1 42.78,209.44
X$24520 73 4227 4424 4569 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24521 m0 *1 44.16,209.44
X$24521 73 4192 4286 4660 57 73 4537 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24522 m0 *1 46,209.44
X$24522 73 4537 4162 4285 4572 57 4570 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $24526 m0 *1 51.52,209.44
X$24526 73 4422 4133 4663 73 4572 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24544 m0 *1 92.46,209.44
X$24544 73 4538 4294 4289 4227 4577 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $24552 m0 *1 113.16,209.44
X$24552 73 4192 4360 4579 4539 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24553 m0 *1 115,209.44
X$24553 73 4192 4129 4539 73 4581 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24556 m0 *1 118.22,209.44
X$24556 73 4504 4473 4538 73 4582 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24579 m0 *1 184,209.44
X$24579 57 4585 4584 4472 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $24586 m0 *1 207,209.44
X$24586 73 4522 4517 4683 73 4590 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24589 m0 *1 210.22,209.44
X$24589 73 4522 4517 4341 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24597 m0 *1 226.32,209.44
X$24597 57 15543 4541 4374 4589 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $24598 m0 *1 230.92,209.44
X$24598 73 4540 4541 4342 57 73 4593 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24600 m0 *1 233.68,209.44
X$24600 73 4522 4339 4542 4594 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24602 m0 *1 235.98,209.44
X$24602 73 4521 4685 4617 4541 4543 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $24605 m0 *1 243.8,209.44
X$24605 73 4595 4841 4477 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24612 m0 *1 259.44,209.44
X$24612 57 15484 4684 4141 4596 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $24614 m0 *1 264.5,209.44
X$24614 73 4484 73 57 4480 57 sky130_fd_sc_hd__buf_4
* cell instance $24615 m0 *1 267.26,209.44
X$24615 73 4526 57 73 4596 57 sky130_fd_sc_hd__inv_2
* cell instance $24625 m0 *1 290.26,209.44
X$24625 73 4299 4543 4372 73 4691 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24646 m0 *1 345.92,209.44
X$24646 57 4598 4531 3711 4093 4544 4529 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $24648 m0 *1 350.06,209.44
X$24648 73 4695 73 57 3475 57 sky130_fd_sc_hd__buf_4
* cell instance $24652 m0 *1 356.04,209.44
X$24652 73 3634 4457 4545 57 73 4544 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24653 m0 *1 357.88,209.44
X$24653 73 4545 4487 2403 73 4694 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24658 m0 *1 362.48,209.44
X$24658 73 2779 2818 4546 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24659 m0 *1 363.86,209.44
X$24659 73 4546 4488 3119 4457 2779 4693 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $24661 m0 *1 368.92,209.44
X$24661 57 4630 3023 2397 4547 4533 4592 73 73 57 sky130_fd_sc_hd__o311ai_1
* cell instance $24664 m0 *1 373.52,209.44
X$24664 57 4308 4548 2818 3944 4549 4489 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $24666 m0 *1 377.2,209.44
X$24666 73 4534 4548 4690 4547 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24667 m0 *1 379.04,209.44
X$24667 57 4488 4549 2491 4388 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $24670 m0 *1 383.64,209.44
X$24670 73 4550 73 57 2403 57 sky130_fd_sc_hd__buf_4
* cell instance $24675 m0 *1 390.08,209.44
X$24675 57 3025 2440 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $24677 m0 *1 397.9,209.44
X$24677 73 4551 2440 4464 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24679 m0 *1 400.2,209.44
X$24679 73 4580 4591 2397 73 4592 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24682 m0 *1 406.18,209.44
X$24682 73 4550 73 57 3517 57 sky130_fd_sc_hd__buf_4
* cell instance $24683 m0 *1 408.94,209.44
X$24683 73 2827 3317 4551 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24685 m0 *1 411.24,209.44
X$24685 73 4550 73 57 2921 57 sky130_fd_sc_hd__inv_1
* cell instance $24690 m0 *1 419.06,209.44
X$24690 73 2819 4552 4588 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24692 m0 *1 420.9,209.44
X$24692 73 3719 2397 4587 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24693 m0 *1 422.28,209.44
X$24693 73 4587 3899 4551 57 73 4586 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24696 m0 *1 426.42,209.44
X$24696 57 4756 4583 2822 3819 3895 4552 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $24699 m0 *1 435.16,209.44
X$24699 73 2827 4236 4554 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24700 m0 *1 436.54,209.44
X$24700 73 4554 73 57 4211 57 sky130_fd_sc_hd__buf_4
* cell instance $24704 m0 *1 442.52,209.44
X$24704 73 3895 4236 4552 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24707 m0 *1 445.28,209.44
X$24707 73 4555 4494 4556 2958 57 73 4580 57 sky130_fd_sc_hd__a31oi_1
* cell instance $24708 m0 *1 447.58,209.44
X$24708 73 3550 3673 2827 73 4556 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24710 m0 *1 449.88,209.44
X$24710 73 3819 4519 4555 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24711 m0 *1 451.26,209.44
X$24711 73 4678 73 57 4578 57 sky130_fd_sc_hd__buf_4
* cell instance $24723 m0 *1 478.86,209.44
X$24723 73 4673 73 57 345 57 sky130_fd_sc_hd__buf_4
* cell instance $24733 m0 *1 504.16,209.44
X$24733 73 4560 4559 4576 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $24735 m0 *1 508.3,209.44
X$24735 57 4514 4643 4575 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $24736 m0 *1 515.66,209.44
X$24736 73 4178 4560 4250 73 4575 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24740 m0 *1 523.48,209.44
X$24740 73 6005 4561 73 4180 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $24744 m0 *1 528.54,209.44
X$24744 73 3829 57 73 4574 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24777 m0 *1 620.54,209.44
X$24777 57 4178 4495 4245 4571 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $24780 m0 *1 633.42,209.44
X$24780 73 5326 57 73 4503 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24784 m0 *1 638.94,209.44
X$24784 57 4178 4566 4245 4562 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $24788 m0 *1 655.04,209.44
X$24788 73 3827 57 73 4655 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24793 r0 *1 8.28,209.44
X$24793 57 4657 3951 4507 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $24804 r0 *1 39.56,209.44
X$24804 73 4658 4424 4601 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24805 r0 *1 40.94,209.44
X$24805 73 4424 4602 4227 4601 57 4740 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $24811 r0 *1 51.98,209.44
X$24811 73 4602 4569 4663 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24817 r0 *1 66.7,209.44
X$24817 73 4603 4664 4161 73 4665 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24827 r0 *1 90.16,209.44
X$24827 73 4668 4424 4360 4192 4670 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $24828 r0 *1 92.92,209.44
X$24828 73 4366 4577 4670 4605 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24829 r0 *1 94.76,209.44
X$24829 73 4366 4666 4605 4129 4606 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $24835 r0 *1 101.2,209.44
X$24835 73 4218 4671 4423 4287 4672 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $24836 r0 *1 103.96,209.44
X$24836 73 4259 4606 4672 4706 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24837 r0 *1 105.8,209.44
X$24837 73 4218 4736 4258 4607 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24842 r0 *1 119.14,209.44
X$24842 73 4675 4581 4582 4674 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $24845 r0 *1 124.66,209.44
X$24845 73 4129 4607 4609 4608 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24850 r0 *1 130.18,209.44
X$24850 73 4610 4608 4165 73 4676 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24852 r0 *1 132.48,209.44
X$24852 73 4287 5172 4611 4610 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24875 r0 *1 187.68,209.44
X$24875 73 4585 73 57 4540 57 sky130_fd_sc_hd__buf_4
* cell instance $24876 r0 *1 190.44,209.44
X$24876 57 4475 4299 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $24887 r0 *1 218.5,209.44
X$24887 73 4372 4613 4612 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24890 r0 *1 225.4,209.44
X$24890 73 4267 4777 4477 4341 4540 4613 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $24892 r0 *1 229.08,209.44
X$24892 73 4614 73 57 4589 57 sky130_fd_sc_hd__buf_4
* cell instance $24896 r0 *1 234.14,209.44
X$24896 73 4684 73 57 4476 57 sky130_fd_sc_hd__buf_4
* cell instance $24899 r0 *1 238.28,209.44
X$24899 73 4522 73 57 4617 57 sky130_fd_sc_hd__buf_4
* cell instance $24900 r0 *1 241.04,209.44
X$24900 57 15602 4516 4480 4614 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $24903 r0 *1 249.78,209.44
X$24903 73 4141 73 57 4686 57 sky130_fd_sc_hd__buf_4
* cell instance $24907 r0 *1 255.76,209.44
X$24907 73 4620 4522 4619 73 57 57 sky130_fd_sc_hd__and2_0
* cell instance $24910 r0 *1 261.74,209.44
X$24910 73 4141 73 57 4718 57 sky130_fd_sc_hd__buf_4
* cell instance $24913 r0 *1 265.88,209.44
X$24913 73 4596 73 57 4614 57 sky130_fd_sc_hd__buf_4
* cell instance $24918 r0 *1 281.52,209.44
X$24918 73 4482 4622 4625 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24923 r0 *1 288.88,209.44
X$24923 73 4299 4625 4853 4623 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $24929 r0 *1 295.32,209.44
X$24929 57 4691 5063 4626 4623 4850 4372 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $24947 r0 *1 342.7,209.44
X$24947 73 3477 3119 4719 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24955 r0 *1 350.98,209.44
X$24955 57 4695 4882 4630 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $24959 r0 *1 363.4,209.44
X$24959 73 2336 4694 4693 57 73 4629 57 sky130_fd_sc_hd__a21oi_1
* cell instance $24962 r0 *1 368,209.44
X$24962 73 4385 4692 4629 3552 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $24967 r0 *1 375.36,209.44
X$24967 73 3030 73 57 2779 57 sky130_fd_sc_hd__buf_4
* cell instance $24969 r0 *1 379.04,209.44
X$24969 57 4461 2488 73 73 57 sky130_fd_sc_hd__buf_6
* cell instance $24970 r0 *1 383.18,209.44
X$24970 73 4093 4632 4690 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $24981 r0 *1 404.8,209.44
X$24981 73 3191 4687 4688 73 4632 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24984 r0 *1 408.94,209.44
X$24984 73 4635 4095 4634 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $24985 r0 *1 410.32,209.44
X$24985 73 3719 73 57 4635 57 sky130_fd_sc_hd__buf_4
* cell instance $24986 r0 *1 413.08,209.44
X$24986 73 4635 73 57 4636 57 sky130_fd_sc_hd__buf_4
* cell instance $24987 r0 *1 415.84,209.44
X$24987 73 4636 3550 2488 3947 57 4935 73 57 sky130_fd_sc_hd__a22o_1
* cell instance $24989 r0 *1 420.9,209.44
X$24989 73 4636 4236 4388 73 4760 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $24996 r0 *1 433.32,209.44
X$24996 73 3899 4682 4833 3819 4680 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $25001 r0 *1 442.98,209.44
X$25001 73 4340 73 57 4553 57 sky130_fd_sc_hd__buf_4
* cell instance $25002 r0 *1 445.74,209.44
X$25002 73 4636 4552 4639 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25005 r0 *1 449.42,209.44
X$25005 73 4636 4095 4678 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25009 r0 *1 452.18,209.44
X$25009 73 4213 73 57 4642 57 sky130_fd_sc_hd__buf_4
* cell instance $25016 r0 *1 461.38,209.44
X$25016 73 3191 4677 4639 2969 4557 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $25018 r0 *1 465.06,209.44
X$25018 73 3673 4095 3518 57 73 4677 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25020 r0 *1 467.36,209.44
X$25020 73 4557 2822 4642 57 73 4269 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25031 r0 *1 491.28,209.44
X$25031 73 4558 4561 4673 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $25034 r0 *1 495.88,209.44
X$25034 57 4646 4643 4647 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25035 r0 *1 503.24,209.44
X$25035 73 4646 73 57 4559 57 sky130_fd_sc_hd__buf_4
* cell instance $25037 r0 *1 506,209.44
X$25037 57 4647 4576 4655 4669 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $25041 r0 *1 513.36,209.44
X$25041 57 4744 4643 4648 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25042 r0 *1 520.72,209.44
X$25042 57 4648 4667 4574 4178 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $25048 r0 *1 531.76,209.44
X$25048 57 4978 4117 3326 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $25054 r0 *1 552,209.44
X$25054 57 4558 4409 4573 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $25066 r0 *1 575.46,209.44
X$25066 73 4178 3329 4741 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25077 r0 *1 601.68,209.44
X$25077 57 4661 4659 4652 4178 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $25094 r0 *1 631.58,209.44
X$25094 57 4802 4245 3830 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25101 r0 *1 643.54,209.44
X$25101 57 4654 4245 4656 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25111 m0 *1 14.72,214.88
X$25111 57 4810 3951 4131 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25120 m0 *1 37.72,214.88
X$25120 73 4817 73 57 4736 57 sky130_fd_sc_hd__buf_4
* cell instance $25121 m0 *1 40.48,214.88
X$25121 73 4738 4601 4600 4183 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $25122 m0 *1 42.32,214.88
X$25122 73 4737 4699 4227 4740 57 73 4359 57 sky130_fd_sc_hd__a31oi_1
* cell instance $25126 m0 *1 46.46,214.88
X$25126 73 4767 4601 4227 73 4662 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25127 m0 *1 48.3,214.88
X$25127 73 4129 4743 4700 57 73 4603 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25128 m0 *1 50.14,214.88
X$25128 73 4218 4604 4662 4700 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $25136 m0 *1 67.62,214.88
X$25136 73 4287 4702 4664 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25146 m0 *1 85.56,214.88
X$25146 57 4663 4703 5045 4859 4668 4666 73 73 57 sky130_fd_sc_hd__o221a_2
* cell instance $25147 m0 *1 89.7,214.88
X$25147 73 4424 4668 4331 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $25153 m0 *1 100.28,214.88
X$25153 73 4825 4223 4703 57 73 4671 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25166 m0 *1 126.04,214.88
X$25166 73 4705 4676 4706 57 73 5261 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25192 m0 *1 182.16,214.88
X$25192 57 4871 3185 4750 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $25196 m0 *1 195.96,214.88
X$25196 73 4751 4752 4709 73 4681 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25200 m0 *1 202.86,214.88
X$25200 57 4709 4754 4298 4138 4686 4707 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $25205 m0 *1 207.46,214.88
X$25205 73 4710 4373 4522 4708 4683 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $25214 m0 *1 229.54,214.88
X$25214 73 4614 4374 4615 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25217 m0 *1 232.3,214.88
X$25217 73 4713 73 57 4342 57 sky130_fd_sc_hd__buf_4
* cell instance $25220 m0 *1 235.06,214.88
X$25220 73 4616 4373 4617 73 4685 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25223 m0 *1 239.66,214.88
X$25223 73 4713 73 57 4438 57 sky130_fd_sc_hd__buf_4
* cell instance $25226 m0 *1 245.18,214.88
X$25226 57 4714 4713 4346 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $25233 m0 *1 254.38,214.88
X$25233 73 4716 4522 4483 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25234 m0 *1 255.76,214.88
X$25234 73 4620 73 57 4717 57 sky130_fd_sc_hd__buf_4
* cell instance $25236 m0 *1 259.44,214.88
X$25236 57 4716 4620 4718 4621 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $25239 m0 *1 264.04,214.88
X$25239 73 4484 73 57 4715 57 sky130_fd_sc_hd__buf_4
* cell instance $25240 m0 *1 266.8,214.88
X$25240 73 4526 73 57 4621 57 sky130_fd_sc_hd__buf_4
* cell instance $25243 m0 *1 270.94,214.88
X$25243 73 4855 4374 4618 4717 4525 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $25246 m0 *1 276,214.88
X$25246 73 4622 4526 4618 4717 4854 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $25265 m0 *1 315.56,214.88
X$25265 57 2888 4627 4764 3117 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $25276 m0 *1 344.08,214.88
X$25276 73 4719 73 57 4087 57 sky130_fd_sc_hd__buf_4
* cell instance $25278 m0 *1 347.3,214.88
X$25278 73 2776 4719 2914 73 4720 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25279 m0 *1 349.14,214.88
X$25279 73 4720 73 57 4628 57 sky130_fd_sc_hd__buf_4
* cell instance $25280 m0 *1 351.9,214.88
X$25280 73 2491 73 57 2914 57 sky130_fd_sc_hd__buf_4
* cell instance $25282 m0 *1 356.5,214.88
X$25282 73 2397 3559 3634 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25291 m0 *1 368.92,214.88
X$25291 73 4634 4631 4761 2491 2397 73 4692 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $25294 m0 *1 374.9,214.88
X$25294 73 2779 3241 4631 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25299 m0 *1 386.4,214.88
X$25299 73 4308 4628 4722 4689 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $25304 m0 *1 393.76,214.88
X$25304 73 2819 4723 4722 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25305 m0 *1 395.14,214.88
X$25305 73 4633 73 57 4532 57 sky130_fd_sc_hd__buf_4
* cell instance $25308 m0 *1 397.9,214.88
X$25308 73 4213 73 57 4723 57 sky130_fd_sc_hd__buf_4
* cell instance $25309 m0 *1 400.66,214.88
X$25309 73 3947 3191 2770 3523 57 4753 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $25311 m0 *1 404.34,214.88
X$25311 73 4723 2965 3317 73 4687 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25318 m0 *1 417.22,214.88
X$25318 73 4631 73 57 2831 57 sky130_fd_sc_hd__buf_4
* cell instance $25321 m0 *1 422.28,214.88
X$25321 73 3895 4760 4759 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25325 m0 *1 424.58,214.88
X$25325 73 4758 4553 4094 4724 57 73 4757 57 sky130_fd_sc_hd__a31oi_1
* cell instance $25327 m0 *1 427.8,214.88
X$25327 73 4637 4753 4756 4724 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $25330 m0 *1 431.02,214.88
X$25330 73 2826 4239 4237 4834 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $25331 m0 *1 432.86,214.88
X$25331 73 3036 4095 4633 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25332 m0 *1 434.24,214.88
X$25332 57 4682 4633 2826 4725 4554 4631 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $25335 m0 *1 439.3,214.88
X$25335 73 2819 4236 4726 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25337 m0 *1 442.52,214.88
X$25337 73 4725 4638 3943 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25339 m0 *1 444.36,214.88
X$25339 73 4727 73 57 4725 57 sky130_fd_sc_hd__buf_4
* cell instance $25340 m0 *1 447.12,214.88
X$25340 73 4727 73 57 3518 57 sky130_fd_sc_hd__buf_4
* cell instance $25344 m0 *1 450.8,214.88
X$25344 73 3895 4678 4726 4640 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $25346 m0 *1 453.56,214.88
X$25346 73 4239 4451 3895 4640 57 73 4641 57 sky130_fd_sc_hd__a31oi_1
* cell instance $25347 m0 *1 455.86,214.88
X$25347 73 3770 4641 3367 73 4749 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25350 m0 *1 459.08,214.88
X$25350 73 3191 4095 4638 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25351 m0 *1 460.46,214.88
X$25351 73 4638 4237 3895 57 73 4337 57 sky130_fd_sc_hd__a21o_1
* cell instance $25365 m0 *1 491.74,214.88
X$25365 57 4796 4643 4747 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25367 m0 *1 499.56,214.88
X$25367 73 4645 4745 4669 73 4746 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $25368 m0 *1 502.32,214.88
X$25368 73 4669 4047 4645 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25373 m0 *1 505.08,214.88
X$25373 73 4576 4392 4745 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $25374 m0 *1 508.3,214.88
X$25374 57 4560 4729 4514 4644 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $25376 m0 *1 517.04,214.88
X$25376 73 4744 73 57 4644 57 sky130_fd_sc_hd__buf_4
* cell instance $25377 m0 *1 519.8,214.88
X$25377 73 4729 4644 73 4667 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $25386 m0 *1 538.66,214.88
X$25386 73 4730 2565 73 4656 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $25402 m0 *1 574.54,214.88
X$25402 73 4178 4627 4741 73 4820 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25407 m0 *1 583.28,214.88
X$25407 73 4742 73 57 4650 57 sky130_fd_sc_hd__buf_4
* cell instance $25411 m0 *1 586.5,214.88
X$25411 73 4178 4739 4252 73 4649 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25412 m0 *1 588.34,214.88
X$25412 57 4912 4651 4649 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25416 m0 *1 598.92,214.88
X$25416 73 4799 4732 73 4659 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $25417 m0 *1 602.14,214.88
X$25417 57 4733 4651 4661 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25419 m0 *1 609.96,214.88
X$25419 73 4733 73 57 4732 57 sky130_fd_sc_hd__buf_4
* cell instance $25425 m0 *1 621.92,214.88
X$25425 73 5234 57 73 4571 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25439 m0 *1 639.86,214.88
X$25439 57 1619 4245 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $25446 r0 *1 3.68,214.88
X$25446 73 4696 57 73 4805 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25447 r0 *1 7.36,214.88
X$25447 73 4599 57 73 4807 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25450 r0 *1 12.42,214.88
X$25450 73 4657 57 73 4856 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25454 r0 *1 17.48,214.88
X$25454 73 4810 57 73 4812 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25457 r0 *1 28.52,214.88
X$25457 73 4538 4697 4816 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25458 r0 *1 29.9,214.88
X$25458 73 4816 4817 4284 4814 57 4815 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $25461 r0 *1 39.56,214.88
X$25461 73 4698 4858 4817 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25462 r0 *1 40.94,214.88
X$25462 73 4766 73 57 4698 57 sky130_fd_sc_hd__buf_4
* cell instance $25467 r0 *1 48.3,214.88
X$25467 73 4162 5567 4701 4743 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $25468 r0 *1 50.14,214.88
X$25468 73 5468 4698 4504 57 73 4701 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25482 r0 *1 87.4,214.88
X$25482 73 4766 73 57 4668 57 sky130_fd_sc_hd__buf_4
* cell instance $25492 r0 *1 108.56,214.88
X$25492 73 4223 4290 4704 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25496 r0 *1 115,214.88
X$25496 73 4705 4748 4928 57 73 4828 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25499 r0 *1 119.14,214.88
X$25499 73 4287 4192 4538 4294 57 4831 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $25527 r0 *1 182.16,214.88
X$25527 57 4750 3185 4774 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $25531 r0 *1 191.36,214.88
X$25531 73 4475 4774 4836 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25534 r0 *1 196.88,214.88
X$25534 73 4480 4707 4374 73 4752 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25537 r0 *1 202.86,214.88
X$25537 73 4338 4774 4755 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25538 r0 *1 204.24,214.88
X$25538 57 4338 4837 4681 4372 4838 4775 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $25540 r0 *1 207.46,214.88
X$25540 73 4540 4755 4590 57 73 4775 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25545 r0 *1 218.04,214.88
X$25545 73 4711 4522 4841 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25548 r0 *1 223.56,214.88
X$25548 73 4686 4522 4843 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25552 r0 *1 231.38,214.88
X$25552 73 4615 4778 4713 73 4847 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25556 r0 *1 235.52,214.88
X$25556 73 4684 4779 4778 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25560 r0 *1 238.74,214.88
X$25560 73 4479 4713 4780 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25563 r0 *1 242.42,214.88
X$25563 73 4715 4438 4938 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25566 r0 *1 246.56,214.88
X$25566 73 4713 73 57 4875 57 sky130_fd_sc_hd__buf_4
* cell instance $25567 r0 *1 249.32,214.88
X$25567 73 4716 73 57 4616 57 sky130_fd_sc_hd__buf_4
* cell instance $25568 r0 *1 252.08,214.88
X$25568 73 4715 4779 4595 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25569 r0 *1 253.46,214.88
X$25569 73 4614 4618 4595 5026 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $25572 r0 *1 256.68,214.88
X$25572 73 4522 73 57 4782 57 sky130_fd_sc_hd__buf_4
* cell instance $25573 r0 *1 259.44,214.88
X$25573 57 15657 4785 4484 4621 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $25577 r0 *1 264.96,214.88
X$25577 57 15597 4784 4718 4479 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $25578 r0 *1 269.56,214.88
X$25578 73 4621 73 57 4711 57 sky130_fd_sc_hd__buf_4
* cell instance $25580 r0 *1 272.78,214.88
X$25580 73 4843 4710 4782 57 73 4855 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25584 r0 *1 277.84,214.88
X$25584 73 4718 4374 4783 57 73 4786 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25585 r0 *1 279.68,214.88
X$25585 73 4854 4786 4372 73 4763 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25590 r0 *1 287.5,214.88
X$25590 73 4782 4614 4852 57 73 4853 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25614 r0 *1 344.54,214.88
X$25614 73 2819 3119 3287 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25620 r0 *1 349.14,214.88
X$25620 73 3287 2336 2818 3402 57 4789 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $25621 r0 *1 351.44,214.88
X$25621 73 2336 4087 2818 2819 4455 4845 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $25623 r0 *1 355.58,214.88
X$25623 57 4845 4762 4385 4842 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $25625 r0 *1 358.8,214.88
X$25625 73 4790 73 57 3402 57 sky130_fd_sc_hd__buf_4
* cell instance $25629 r0 *1 364.78,214.88
X$25629 73 3559 73 57 4308 57 sky130_fd_sc_hd__buf_4
* cell instance $25630 r0 *1 367.54,214.88
X$25630 73 4721 73 57 3632 57 sky130_fd_sc_hd__buf_4
* cell instance $25632 r0 *1 370.3,214.88
X$25632 73 2491 4790 4721 4761 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $25635 r0 *1 373.52,214.88
X$25635 73 4550 3241 4790 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25637 r0 *1 375.36,214.88
X$25637 57 4550 4792 4461 3030 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $25638 r0 *1 379.96,214.88
X$25638 73 4792 73 57 2819 57 sky130_fd_sc_hd__buf_4
* cell instance $25641 r0 *1 384.1,214.88
X$25641 73 4308 4628 4793 57 73 4944 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25647 r0 *1 395.6,214.88
X$25647 73 2818 2831 4633 4793 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $25656 r0 *1 414.92,214.88
X$25656 73 3559 73 57 3819 57 sky130_fd_sc_hd__buf_4
* cell instance $25661 r0 *1 422.74,214.88
X$25661 73 4759 4835 4758 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25664 r0 *1 426.42,214.88
X$25664 73 3770 4759 4834 57 73 4933 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25672 r0 *1 444.36,214.88
X$25672 73 3317 2491 4727 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25681 r0 *1 460.46,214.88
X$25681 73 2491 73 57 2826 57 sky130_fd_sc_hd__buf_4
* cell instance $25692 r0 *1 489.9,214.88
X$25692 73 4829 4795 73 4827 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $25693 r0 *1 493.12,214.88
X$25693 57 4747 4827 2544 4669 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $25694 r0 *1 497.26,214.88
X$25694 73 4796 73 57 4795 57 sky130_fd_sc_hd__buf_4
* cell instance $25696 r0 *1 503.7,214.88
X$25696 57 1619 4643 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $25699 r0 *1 513.36,214.88
X$25699 73 4669 73 57 4178 57 sky130_fd_sc_hd__buf_4
* cell instance $25711 r0 *1 541.88,214.88
X$25711 73 4195 73 57 4730 57 sky130_fd_sc_hd__buf_4
* cell instance $25724 r0 *1 572.7,214.88
X$25724 73 4821 73 57 4627 57 sky130_fd_sc_hd__buf_4
* cell instance $25725 r0 *1 575.46,214.88
X$25725 57 4742 4651 4820 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25727 r0 *1 583.28,214.88
X$25727 73 4794 4728 73 4819 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $25729 r0 *1 586.5,214.88
X$25729 57 1619 4651 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $25734 r0 *1 599.38,214.88
X$25734 57 4818 4819 4735 4178 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $25737 r0 *1 606.28,214.88
X$25737 73 4813 4728 73 2716 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $25738 r0 *1 609.5,214.88
X$25738 57 4728 4245 4818 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25744 r0 *1 623.76,214.88
X$25744 57 4178 4811 4245 3145 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $25752 r0 *1 643.54,214.88
X$25752 73 4653 57 73 4908 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25753 r0 *1 647.22,214.88
X$25753 73 4808 57 73 4735 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25755 r0 *1 651.36,214.88
X$25755 73 4802 57 73 4907 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25756 r0 *1 655.04,214.88
X$25756 73 2712 57 73 6978 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25778 m0 *1 52.9,220.32
X$25778 73 4767 4699 4227 4915 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $25779 m0 *1 55.66,220.32
X$25779 73 4285 4915 4860 4771 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $25784 m0 *1 65.78,220.32
X$25784 73 4600 4704 4424 73 4769 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25786 m0 *1 68.08,220.32
X$25786 73 4769 4770 4218 4863 57 73 4702 57 sky130_fd_sc_hd__a31oi_1
* cell instance $25790 m0 *1 71.3,220.32
X$25790 73 4768 4703 4822 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25793 m0 *1 76.82,220.32
X$25793 73 4363 4957 4770 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25801 m0 *1 87.86,220.32
X$25801 73 4192 4164 4660 4604 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $25809 m0 *1 100.28,220.32
X$25809 73 4223 4364 4922 57 73 4825 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25812 m0 *1 106.72,220.32
X$25812 73 5436 4771 4259 4705 4828 73 4826 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $25819 m0 *1 116.38,220.32
X$25819 73 4424 4129 4864 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25821 m0 *1 118.22,220.32
X$25821 73 4294 4287 4866 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25822 m0 *1 119.6,220.32
X$25822 73 4831 4868 4864 57 73 4772 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25825 m0 *1 122.82,220.32
X$25825 73 4832 4675 4772 4869 4290 73 4929 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $25838 m0 *1 149.04,220.32
X$25838 57 4729 4870 4773 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25854 m0 *1 185.84,220.32
X$25854 57 4871 4372 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $25861 m0 *1 199.18,220.32
X$25861 73 4774 4712 4840 73 4754 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25867 m0 *1 207,220.32
X$25867 73 4839 4373 4840 4686 4838 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $25870 m0 *1 210.68,220.32
X$25870 73 4873 4878 4839 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25872 m0 *1 212.98,220.32
X$25872 73 4871 4342 4776 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25874 m0 *1 216.2,220.32
X$25874 73 4776 73 57 4707 57 sky130_fd_sc_hd__buf_4
* cell instance $25875 m0 *1 218.96,220.32
X$25875 73 4299 4934 4874 57 73 4844 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25877 m0 *1 221.26,220.32
X$25877 73 4712 4615 4616 73 4874 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25880 m0 *1 224.02,220.32
X$25880 73 4266 4844 4846 4755 73 57 4936 57 sky130_fd_sc_hd__o31ai_1
* cell instance $25883 m0 *1 232.3,220.32
X$25883 73 4617 4937 4540 4594 57 4846 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $25887 m0 *1 235.52,220.32
X$25887 73 4373 73 57 4779 57 sky130_fd_sc_hd__buf_4
* cell instance $25889 m0 *1 239.2,220.32
X$25889 73 4780 73 57 4712 57 sky130_fd_sc_hd__buf_4
* cell instance $25891 m0 *1 242.88,220.32
X$25891 73 4938 73 57 4781 57 sky130_fd_sc_hd__buf_4
* cell instance $25892 m0 *1 245.64,220.32
X$25892 73 4715 4776 4939 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $25893 m0 *1 247.02,220.32
X$25893 73 5024 4346 4714 4940 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $25897 m0 *1 254.84,220.32
X$25897 57 57 4522 4378 4711 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $25902 m0 *1 261.28,220.32
X$25902 73 4378 73 57 4783 57 sky130_fd_sc_hd__buf_4
* cell instance $25905 m0 *1 265.42,220.32
X$25905 73 4784 4684 4787 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25906 m0 *1 266.8,220.32
X$25906 73 4785 4875 4485 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $25907 m0 *1 268.18,220.32
X$25907 73 4784 73 57 4710 57 sky130_fd_sc_hd__buf_4
* cell instance $25914 m0 *1 284.74,220.32
X$25914 73 4718 4707 4878 4873 4372 4946 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $25917 m0 *1 287.96,220.32
X$25917 73 4787 4782 4779 4849 57 4851 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $25920 m0 *1 293.02,220.32
X$25920 73 4781 4873 4851 4779 4877 73 4850 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $25923 m0 *1 300.38,220.32
X$25923 73 4428 4880 4350 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $25936 m0 *1 323.84,220.32
X$25936 57 4883 4882 4788 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $25943 m0 *1 335.8,220.32
X$25943 73 4627 4764 4949 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $25955 m0 *1 354.66,220.32
X$25955 73 4884 2397 2818 4789 57 73 4842 57 sky130_fd_sc_hd__a31oi_1
* cell instance $25962 m0 *1 367.54,220.32
X$25962 73 4791 3119 4634 73 4884 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $25966 m0 *1 370.3,220.32
X$25966 73 4551 73 57 4791 57 sky130_fd_sc_hd__buf_4
* cell instance $25981 m0 *1 408.02,220.32
X$25981 73 4551 73 57 4886 57 sky130_fd_sc_hd__buf_4
* cell instance $25985 m0 *1 416.76,220.32
X$25985 73 3770 4886 3947 57 73 4835 57 sky130_fd_sc_hd__a21oi_1
* cell instance $25999 m0 *1 444.82,220.32
X$25999 73 3899 4892 4833 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26005 m0 *1 452.18,220.32
X$26005 73 2336 4027 4637 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26008 m0 *1 455.86,220.32
X$26008 73 4637 4459 4888 4749 4830 57 73 57 sky130_fd_sc_hd__o22a_1
* cell instance $26022 m0 *1 490.36,220.32
X$26022 57 4894 4829 2231 4796 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $26029 m0 *1 505.54,220.32
X$26029 57 4643 15436 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $26031 m0 *1 510.6,220.32
X$26031 57 2231 4643 4923 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $26041 m0 *1 532.68,220.32
X$26041 73 4797 2231 73 4798 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $26045 m0 *1 545.1,220.32
X$26045 73 4900 4920 4898 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26047 m0 *1 546.94,220.32
X$26047 73 1768 73 57 4797 57 sky130_fd_sc_hd__buf_4
* cell instance $26056 m0 *1 559.82,220.32
X$26056 73 4917 5090 4903 57 73 4824 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26058 m0 *1 562.12,220.32
X$26058 73 5000 4900 4823 4824 57 4914 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $26063 m0 *1 573.62,220.32
X$26063 57 4821 4794 4650 4728 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $26067 m0 *1 584.66,220.32
X$26067 57 4739 4799 4800 4732 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $26070 m0 *1 592.94,220.32
X$26070 73 4912 73 57 4800 57 sky130_fd_sc_hd__buf_4
* cell instance $26075 m0 *1 607.66,220.32
X$26075 73 4911 4901 4990 57 73 4910 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26078 m0 *1 610.88,220.32
X$26078 73 4809 4732 73 4410 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $26089 m0 *1 637.56,220.32
X$26089 57 4178 3497 4245 4801 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $26092 m0 *1 648.6,220.32
X$26092 57 4804 4245 4798 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $26093 m0 *1 655.96,220.32
X$26093 73 4804 57 73 4734 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26097 r0 *1 7.82,220.32
X$26097 73 3952 4805 4993 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26111 r0 *1 39.1,220.32
X$26111 73 4858 73 57 4859 57 sky130_fd_sc_hd__buf_4
* cell instance $26120 r0 *1 59.34,220.32
X$26120 73 4697 73 57 4703 57 sky130_fd_sc_hd__buf_4
* cell instance $26124 r0 *1 68.54,220.32
X$26124 73 4862 4861 4697 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26126 r0 *1 69.92,220.32
X$26126 73 4227 4294 4861 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26128 r0 *1 71.76,220.32
X$26128 73 4861 73 57 4256 57 sky130_fd_sc_hd__buf_4
* cell instance $26143 r0 *1 108.1,220.32
X$26143 73 4290 4287 4859 73 4867 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26144 r0 *1 109.94,220.32
X$26144 73 4924 73 57 4773 57 sky130_fd_sc_hd__buf_4
* cell instance $26147 r0 *1 115.46,220.32
X$26147 57 4928 4864 4926 4927 4866 4469 4867 73 73 57 sky130_fd_sc_hd__a222oi_1
* cell instance $26148 r0 *1 119.14,220.32
X$26148 73 4223 4227 4868 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26151 r0 *1 124.2,220.32
X$26151 73 4957 4192 4866 57 73 4869 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26156 r0 *1 134.32,220.32
X$26156 57 4675 5014 4259 4512 5015 4929 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $26175 r0 *1 182.16,220.32
X$26175 57 5047 1821 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $26179 r0 *1 200.56,220.32
X$26179 73 4516 4840 4930 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26181 r0 *1 202.86,220.32
X$26181 73 4930 4872 4931 73 5022 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26184 r0 *1 206.54,220.32
X$26184 73 4342 4476 4373 57 73 4872 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26190 r0 *1 212.98,220.32
X$26190 73 4847 73 57 5050 57 sky130_fd_sc_hd__buf_4
* cell instance $26202 r0 *1 239.66,220.32
X$26202 73 4780 4483 4374 73 5109 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26205 r0 *1 248.86,220.32
X$26205 73 4779 4941 4939 57 73 5025 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26206 r0 *1 250.7,220.32
X$26206 73 4482 4372 4875 4941 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $26210 r0 *1 258.98,220.32
X$26210 73 4684 73 57 4876 57 sky130_fd_sc_hd__buf_4
* cell instance $26217 r0 *1 272.32,220.32
X$26217 73 4876 4622 4528 4877 5031 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $26223 r0 *1 285.66,220.32
X$26223 73 4782 4482 4374 4947 57 4964 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $26226 r0 *1 290.26,220.32
X$26226 73 4779 4948 4877 73 5035 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26229 r0 *1 296.24,220.32
X$26229 73 4967 4873 5032 4374 4877 73 4626 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $26230 r0 *1 299.46,220.32
X$26230 73 4784 4875 4879 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26231 r0 *1 300.84,220.32
X$26231 73 4374 4879 4849 5032 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $26235 r0 *1 308.66,220.32
X$26235 73 4880 73 57 4381 57 sky130_fd_sc_hd__buf_4
* cell instance $26240 r0 *1 316.48,220.32
X$26240 73 4950 4881 2785 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26244 r0 *1 321.08,220.32
X$26244 57 4881 4739 4883 2885 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $26251 r0 *1 336.26,220.32
X$26251 57 5027 4949 4848 4950 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $26267 r0 *1 366.62,220.32
X$26267 73 3025 73 57 3119 57 sky130_fd_sc_hd__buf_4
* cell instance $26269 r0 *1 369.38,220.32
X$26269 73 2818 3119 4885 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26270 r0 *1 370.76,220.32
X$26270 73 4093 3023 3551 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26271 r0 *1 372.14,220.32
X$26271 73 4885 73 57 3947 57 sky130_fd_sc_hd__buf_4
* cell instance $26275 r0 *1 377.66,220.32
X$26275 73 4945 73 57 4942 57 sky130_fd_sc_hd__buf_4
* cell instance $26276 r0 *1 380.42,220.32
X$26276 57 4972 4721 4792 4943 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $26279 r0 *1 384.1,220.32
X$26279 73 4944 3551 2336 4942 57 5021 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $26281 r0 *1 388.24,220.32
X$26281 73 2496 73 57 2818 57 sky130_fd_sc_hd__buf_4
* cell instance $26287 r0 *1 397.9,220.32
X$26287 73 2818 73 57 3895 57 sky130_fd_sc_hd__buf_4
* cell instance $26291 r0 *1 403.42,220.32
X$26291 73 3025 73 57 4095 57 sky130_fd_sc_hd__buf_4
* cell instance $26294 r0 *1 407.56,220.32
X$26294 57 3895 4887 3770 4886 4095 4634 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $26296 r0 *1 411.24,220.32
X$26296 73 2336 4887 4889 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26299 r0 *1 415.38,220.32
X$26299 73 2965 3819 4545 57 73 5020 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26300 r0 *1 417.22,220.32
X$26300 73 4888 3819 4935 57 73 5019 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26305 r0 *1 424.12,220.32
X$26305 73 5018 4890 4757 4274 73 5017 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $26306 r0 *1 426.42,220.32
X$26306 73 4933 4889 3722 4932 4890 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $26312 r0 *1 433.78,220.32
X$26312 73 3241 73 57 4236 57 sky130_fd_sc_hd__buf_4
* cell instance $26313 r0 *1 436.54,220.32
X$26313 73 4891 73 57 4545 57 sky130_fd_sc_hd__buf_4
* cell instance $26318 r0 *1 448.04,220.32
X$26318 73 3191 4095 4891 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26319 r0 *1 449.42,220.32
X$26319 73 3317 4236 4893 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26322 r0 *1 451.72,220.32
X$26322 73 4893 73 57 4451 57 sky130_fd_sc_hd__buf_4
* cell instance $26331 r0 *1 465.06,220.32
X$26331 73 2397 73 57 3899 57 sky130_fd_sc_hd__buf_4
* cell instance $26342 r0 *1 488.06,220.32
X$26342 73 4731 57 73 5010 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26344 r0 *1 492.66,220.32
X$26344 73 4669 4404 5008 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26345 r0 *1 494.04,220.32
X$26345 57 5009 4894 4895 4111 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $26346 r0 *1 502.32,220.32
X$26346 73 3445 4111 73 4909 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $26348 r0 *1 505.54,220.32
X$26348 73 4894 4895 73 4925 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $26349 r0 *1 508.76,220.32
X$26349 57 5005 4925 4908 4178 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $26351 r0 *1 513.36,220.32
X$26351 57 4923 4894 5528 4178 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $26357 r0 *1 532.22,220.32
X$26357 73 4921 4896 4898 4897 73 5003 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $26361 r0 *1 540.96,220.32
X$26361 73 4919 73 57 4918 57 sky130_fd_sc_hd__buf_4
* cell instance $26362 r0 *1 543.72,220.32
X$26362 73 4919 73 57 4920 57 sky130_fd_sc_hd__buf_4
* cell instance $26364 r0 *1 547.4,220.32
X$26364 73 4899 4898 5168 57 73 4823 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26370 r0 *1 561.2,220.32
X$26370 73 4902 4901 4903 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26371 r0 *1 562.58,220.32
X$26371 73 4903 73 57 4916 57 sky130_fd_sc_hd__buf_4
* cell instance $26372 r0 *1 565.34,220.32
X$26372 73 4914 73 57 4997 57 sky130_fd_sc_hd__buf_4
* cell instance $26381 r0 *1 588.8,220.32
X$26381 57 4651 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $26389 r0 *1 609.96,220.32
X$26389 57 15671 4904 4905 4900 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $26393 r0 *1 615.94,220.32
X$26393 57 4896 4904 5606 4906 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $26411 m0 *1 2.76,225.76
X$26411 73 4857 57 73 4992 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26426 m0 *1 36.8,225.76
X$26426 73 4602 4858 5113 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26428 m0 *1 38.64,225.76
X$26428 73 4227 4952 4858 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26444 m0 *1 70.84,225.76
X$26444 73 4256 4290 4284 4954 57 5088 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $26449 m0 *1 82.34,225.76
X$26449 73 4290 4424 5089 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26456 m0 *1 88.78,225.76
X$26456 73 4292 4294 4699 73 5093 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26463 m0 *1 102.58,225.76
X$26463 73 4218 5011 4826 4955 73 57 4924 57 sky130_fd_sc_hd__o31ai_1
* cell instance $26474 m0 *1 126.96,225.76
X$26474 73 4227 4922 4328 57 73 5012 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26475 m0 *1 128.8,225.76
X$26475 73 4287 5012 4956 5015 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $26480 m0 *1 137.54,225.76
X$26480 73 5014 73 57 5016 57 sky130_fd_sc_hd__buf_4
* cell instance $26503 m0 *1 190.9,225.76
X$26503 73 5048 4774 4686 4958 57 4751 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $26509 m0 *1 199.18,225.76
X$26509 73 4959 73 57 4958 57 sky130_fd_sc_hd__buf_4
* cell instance $26510 m0 *1 201.94,225.76
X$26510 73 4836 73 57 4931 57 sky130_fd_sc_hd__buf_4
* cell instance $26521 m0 *1 227.7,225.76
X$26521 57 15563 4937 4374 4589 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $26527 m0 *1 243.34,225.76
X$26527 73 4614 4715 4617 4960 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $26530 m0 *1 247.94,225.76
X$26530 73 4716 73 57 5024 57 sky130_fd_sc_hd__inv_1
* cell instance $26534 m0 *1 251.16,225.76
X$26534 57 4961 5033 4542 5025 4962 4959 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $26535 m0 *1 254.38,225.76
X$26535 73 5026 4372 5028 57 73 4962 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26538 m0 *1 258.52,225.76
X$26538 73 4875 4787 5029 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26541 m0 *1 259.9,225.76
X$26541 73 4716 73 57 5060 57 sky130_fd_sc_hd__buf_4
* cell instance $26544 m0 *1 268.18,225.76
X$26544 73 4299 4625 5030 5111 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $26551 m0 *1 283.36,225.76
X$26551 73 4963 4960 4374 4964 57 73 4965 57 sky130_fd_sc_hd__a31oi_1
* cell instance $26552 m0 *1 285.66,225.76
X$26552 73 4372 4965 4763 73 5036 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26557 m0 *1 288.88,225.76
X$26557 73 4966 4964 4267 4877 5035 5034 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $26558 m0 *1 292.1,225.76
X$26558 73 4966 4875 4959 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26559 m0 *1 293.48,225.76
X$26559 73 4785 4782 4947 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26560 m0 *1 294.86,225.76
X$26560 73 4947 4959 4779 73 5104 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26573 m0 *1 323.38,225.76
X$26573 73 4739 4968 4969 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $26574 m0 *1 326.6,225.76
X$26574 73 4883 73 57 4968 57 sky130_fd_sc_hd__buf_4
* cell instance $26575 m0 *1 329.36,225.76
X$26575 57 4788 4969 5157 4950 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $26577 m0 *1 333.96,225.76
X$26577 57 4764 4882 5027 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $26581 m0 *1 345,225.76
X$26581 57 4970 4882 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $26593 m0 *1 371.68,225.76
X$26593 73 2491 3025 4971 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26594 m0 *1 373.06,225.76
X$26594 73 4971 73 57 2284 57 sky130_fd_sc_hd__buf_4
* cell instance $26597 m0 *1 378.12,225.76
X$26597 73 3944 3023 4027 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $26598 m0 *1 380.42,225.76
X$26598 73 4972 4943 73 3241 57 57 sky130_fd_sc_hd__and2_2
* cell instance $26599 m0 *1 383.18,225.76
X$26599 57 57 4943 3025 4972 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $26601 m0 *1 387.32,225.76
X$26601 73 5023 57 73 2496 57 sky130_fd_sc_hd__inv_2
* cell instance $26607 m0 *1 396.52,225.76
X$26607 73 3030 73 57 3191 57 sky130_fd_sc_hd__buf_4
* cell instance $26610 m0 *1 402.04,225.76
X$26610 73 5021 73 57 5100 57 sky130_fd_sc_hd__buf_4
* cell instance $26612 m0 *1 406.64,225.76
X$26612 73 4095 3711 3191 73 4973 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26615 m0 *1 414,225.76
X$26615 73 5020 3317 4235 4973 73 4974 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $26618 m0 *1 417.22,225.76
X$26618 73 5019 4008 4974 5100 57 73 5018 57 sky130_fd_sc_hd__a31oi_1
* cell instance $26623 m0 *1 423.66,225.76
X$26623 73 5017 73 57 5099 57 sky130_fd_sc_hd__buf_4
* cell instance $26626 m0 *1 431.02,225.76
X$26626 73 3895 4095 4235 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26627 m0 *1 432.4,225.76
X$26627 73 3036 4235 5013 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26635 m0 *1 446.66,225.76
X$26635 73 3036 4236 4975 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26640 m0 *1 450.8,225.76
X$26640 57 2491 4892 4976 4891 4975 4893 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $26641 m0 *1 454.02,225.76
X$26641 73 3899 4027 4888 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26643 m0 *1 457.24,225.76
X$26643 73 4003 2491 4095 4976 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $26645 m0 *1 459.54,225.76
X$26645 73 4975 73 57 4084 57 sky130_fd_sc_hd__buf_4
* cell instance $26647 m0 *1 464.14,225.76
X$26647 57 4977 2336 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $26649 m0 *1 471.96,225.76
X$26649 57 5096 2397 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $26656 m0 *1 492.2,225.76
X$26656 73 5008 5009 4669 73 5007 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $26659 m0 *1 496.34,225.76
X$26659 73 5006 73 57 4111 57 sky130_fd_sc_hd__buf_4
* cell instance $26665 m0 *1 505.08,225.76
X$26665 57 4979 4643 5005 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $26666 m0 *1 512.44,225.76
X$26666 73 4979 73 57 4895 57 sky130_fd_sc_hd__buf_4
* cell instance $26676 m0 *1 531.3,225.76
X$26676 73 5003 73 57 5004 57 sky130_fd_sc_hd__buf_4
* cell instance $26677 m0 *1 534.06,225.76
X$26677 73 4982 4980 4981 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26678 m0 *1 535.44,225.76
X$26678 73 4981 73 57 4983 57 sky130_fd_sc_hd__buf_4
* cell instance $26681 m0 *1 542.34,225.76
X$26681 73 4905 4980 4919 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26686 m0 *1 550.62,225.76
X$26686 73 4983 4905 4901 57 73 5001 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26694 m0 *1 559.82,225.76
X$26694 73 4902 4984 4999 73 5000 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26698 m0 *1 569.48,225.76
X$26698 73 4918 4986 4980 57 73 4985 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26700 m0 *1 573.16,225.76
X$26700 73 4985 73 57 5069 57 sky130_fd_sc_hd__buf_4
* cell instance $26703 m0 *1 578.22,225.76
X$26703 73 4986 4982 4987 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26712 m0 *1 588.34,225.76
X$26712 73 4989 4982 4996 4987 57 4988 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $26713 m0 *1 591.1,225.76
X$26713 57 4998 5082 4994 4899 4988 4995 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $26719 m0 *1 606.74,225.76
X$26719 73 4989 73 57 4990 57 sky130_fd_sc_hd__buf_4
* cell instance $26738 m0 *1 644,225.76
X$26738 73 5418 57 73 4801 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26741 m0 *1 653.2,225.76
X$26741 73 5072 57 73 4848 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26744 r0 *1 5.98,225.76
X$26744 57 5073 3951 4568 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $26753 r0 *1 26.22,225.76
X$26753 57 4129 5076 5075 4815 5238 4161 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $26756 r0 *1 32.2,225.76
X$26756 73 5079 73 57 4133 57 sky130_fd_sc_hd__buf_4
* cell instance $26765 r0 *1 48.3,225.76
X$26765 73 5038 4703 5039 4658 4602 5002 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $26766 r0 *1 51.52,225.76
X$26766 73 5040 4675 4285 5002 73 4953 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $26768 r0 *1 55.2,225.76
X$26768 73 4602 5039 4675 73 5084 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26769 r0 *1 57.04,225.76
X$26769 73 4129 5083 5084 5085 4675 5041 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $26775 r0 *1 71.76,225.76
X$26775 57 4129 5087 5041 5335 5088 4161 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $26776 r0 *1 74.98,225.76
X$26776 73 4218 5086 5087 4955 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $26780 r0 *1 81.88,225.76
X$26780 73 4227 4191 5089 57 73 5042 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26782 r0 *1 84.18,225.76
X$26782 73 5089 73 57 4737 57 sky130_fd_sc_hd__buf_4
* cell instance $26784 r0 *1 88.78,225.76
X$26784 57 5094 5093 5045 4129 4192 4504 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $26796 r0 *1 117.76,225.76
X$26796 73 4165 4953 4674 57 73 5379 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26804 r0 *1 127.42,225.76
X$26804 73 5046 73 57 4100 57 sky130_fd_sc_hd__buf_4
* cell instance $26827 r0 *1 187.68,225.76
X$26827 73 4774 73 57 4966 57 sky130_fd_sc_hd__buf_4
* cell instance $26828 r0 *1 190.44,225.76
X$26828 73 4841 73 57 5048 57 sky130_fd_sc_hd__buf_4
* cell instance $26829 r0 *1 193.2,225.76
X$26829 73 4585 4774 5051 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $26833 r0 *1 199.64,225.76
X$26833 73 4852 4712 5049 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $26834 r0 *1 201.02,225.76
X$26834 57 5054 5050 4836 5103 5049 5051 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $26835 r0 *1 204.7,225.76
X$26835 73 4373 73 57 5106 57 sky130_fd_sc_hd__buf_4
* cell instance $26843 r0 *1 216.66,225.76
X$26843 73 5106 5029 4372 73 5105 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $26848 r0 *1 231.38,225.76
X$26848 57 5055 5108 4937 4299 4616 4438 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $26850 r0 *1 234.6,225.76
X$26850 73 4372 5057 5055 5058 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $26855 r0 *1 242.88,225.76
X$26855 73 5109 73 57 5056 57 sky130_fd_sc_hd__buf_4
* cell instance $26858 r0 *1 247.94,225.76
X$26858 73 4841 73 57 5133 57 sky130_fd_sc_hd__buf_4
* cell instance $26860 r0 *1 251.62,225.76
X$26860 73 5029 73 57 4963 57 sky130_fd_sc_hd__buf_4
* cell instance $26861 r0 *1 254.38,225.76
X$26861 57 1821 3766 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $26867 r0 *1 269.1,225.76
X$26867 73 5111 5057 4966 5110 57 5059 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $26868 r0 *1 271.4,225.76
X$26868 73 5059 4527 5058 57 73 5199 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26871 r0 *1 277.38,225.76
X$26871 73 5033 73 57 5107 57 sky130_fd_sc_hd__buf_4
* cell instance $26883 r0 *1 304.98,225.76
X$26883 73 5104 73 57 5102 57 sky130_fd_sc_hd__buf_4
* cell instance $26904 r0 *1 350.98,225.76
X$26904 73 3630 4381 73 5101 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $26918 r0 *1 386.86,225.76
X$26918 57 5023 2491 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $26926 r0 *1 407.1,225.76
X$26926 73 2770 73 57 3770 57 sky130_fd_sc_hd__buf_4
* cell instance $26929 r0 *1 415.38,225.76
X$26929 57 2890 4970 5099 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $26935 r0 *1 432.4,225.76
X$26935 57 3770 4932 3899 4491 5013 5098 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $26950 r0 *1 475.18,225.76
X$26950 57 5097 4732 5096 73 73 57 sky130_fd_sc_hd__xnor2_4
* cell instance $26958 r0 *1 502.32,225.76
X$26958 73 3087 4392 73 5095 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $26982 r0 *1 562.12,225.76
X$26982 73 5066 73 57 4999 57 sky130_fd_sc_hd__buf_4
* cell instance $26989 r0 *1 571.32,225.76
X$26989 73 4998 5068 5067 4899 5902 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $26990 r0 *1 574.08,225.76
X$26990 73 5165 4982 5069 57 73 5068 57 sky130_fd_sc_hd__a21oi_1
* cell instance $26997 r0 *1 592.48,225.76
X$26997 73 5082 73 57 5618 57 sky130_fd_sc_hd__buf_4
* cell instance $27003 r0 *1 602.14,225.76
X$27003 73 4902 4982 5162 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27007 r0 *1 606.74,225.76
X$27007 73 5077 5069 4990 5071 4982 5247 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $27008 r0 *1 609.96,225.76
X$27008 73 4982 4906 5071 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27020 r0 *1 636.18,225.76
X$27020 57 5074 4245 4909 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27031 m0 *1 8.28,231.2
X$27031 73 5112 57 73 5158 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27032 m0 *1 11.96,231.2
X$27032 57 3952 5078 3951 5158 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $27041 m0 *1 31.28,231.2
X$27041 73 5160 4424 5079 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27045 m0 *1 37.72,231.2
X$27045 73 5113 73 57 5161 57 sky130_fd_sc_hd__buf_4
* cell instance $27053 m0 *1 52.9,231.2
X$27053 73 4191 73 57 5116 57 sky130_fd_sc_hd__buf_4
* cell instance $27055 m0 *1 56.12,231.2
X$27055 73 4192 5116 5117 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27057 m0 *1 57.96,231.2
X$27057 73 4467 4360 4192 5117 57 73 5083 57 sky130_fd_sc_hd__a31oi_1
* cell instance $27058 m0 *1 60.26,231.2
X$27058 73 4192 4289 5115 57 73 5085 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27067 m0 *1 82.34,231.2
X$27067 73 5042 73 57 5170 57 sky130_fd_sc_hd__buf_4
* cell instance $27070 m0 *1 86.48,231.2
X$27070 73 5170 4227 5043 57 73 5044 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27071 m0 *1 88.32,231.2
X$27071 73 4766 4424 4164 73 5043 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27072 m0 *1 90.16,231.2
X$27072 73 4285 5044 5119 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27074 m0 *1 93.38,231.2
X$27074 73 5094 5119 4366 73 5171 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27080 m0 *1 101.66,231.2
X$27080 73 4165 5257 5011 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27088 m0 *1 118.68,231.2
X$27088 57 5046 5120 4223 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27106 m0 *1 155.02,231.2
X$27106 57 4870 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $27114 m0 *1 172.5,231.2
X$27114 57 5078 5177 3929 3767 73 73 57 sky130_fd_sc_hd__mux2i_4
* cell instance $27119 m0 *1 188.14,231.2
X$27119 73 4373 4871 5382 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27127 m0 *1 203.78,231.2
X$27127 73 4138 5022 5052 57 73 5124 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27132 m0 *1 212.98,231.2
X$27132 73 5641 5105 4299 5053 5052 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $27145 m0 *1 241.5,231.2
X$27145 73 5106 4960 4524 4966 5053 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $27149 m0 *1 247.48,231.2
X$27149 73 4940 73 57 5131 57 sky130_fd_sc_hd__buf_4
* cell instance $27152 m0 *1 251.16,231.2
X$27152 73 4299 5180 4961 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27154 m0 *1 254.38,231.2
X$27154 57 3766 73 73 57 sky130_fd_sc_hd__clkinv_16
* cell instance $27159 m0 *1 270.94,231.2
X$27159 73 4875 4785 4779 57 73 5179 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27164 m0 *1 282.44,231.2
X$27164 73 5060 4875 4963 4374 5178 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $27169 m0 *1 290.72,231.2
X$27169 73 4966 5062 5034 73 5176 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27170 m0 *1 292.56,231.2
X$27170 73 5061 4877 5284 57 73 5062 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27172 m0 *1 295.32,231.2
X$27172 73 5176 5126 5063 5057 5064 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $27194 m0 *1 345,231.2
X$27194 57 4882 73 73 57 sky130_fd_sc_hd__clkbuf_8
* cell instance $27205 m0 *1 373.06,231.2
X$27205 73 5101 73 57 5137 57 sky130_fd_sc_hd__buf_4
* cell instance $27209 m0 *1 382.26,231.2
X$27209 57 4943 5174 5173 5175 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $27214 m0 *1 390.08,231.2
X$27214 57 4728 5140 2770 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $27225 m0 *1 420.44,231.2
X$27225 73 4093 3023 2958 73 57 57 sky130_fd_sc_hd__or2_2
* cell instance $27249 m0 *1 473.8,231.2
X$27249 57 4732 5097 4977 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $27252 m0 *1 479.78,231.2
X$27252 57 4970 4515 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $27253 m0 *1 488.98,231.2
X$27253 57 4392 4515 5141 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27266 m0 *1 520.26,231.2
X$27266 73 5533 73 57 5142 57 sky130_fd_sc_hd__buf_4
* cell instance $27277 m0 *1 544.64,231.2
X$27277 57 5169 5065 5067 5092 4982 5146 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $27280 m0 *1 550.62,231.2
X$27280 73 5213 4984 5001 5143 5065 5091 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $27287 m0 *1 560.28,231.2
X$27287 73 5147 4980 5066 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27288 m0 *1 561.66,231.2
X$27288 73 4986 5066 4917 73 5166 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27301 m0 *1 592.48,231.2
X$27301 73 4995 4994 5070 5164 57 73 5081 57 sky130_fd_sc_hd__a31oi_1
* cell instance $27303 m0 *1 598.46,231.2
X$27303 73 5142 5080 5151 5164 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $27306 m0 *1 601.68,231.2
X$27306 73 4906 5162 5248 57 73 5080 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27307 m0 *1 603.52,231.2
X$27307 73 4982 5153 4994 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27308 m0 *1 604.9,231.2
X$27308 73 4900 5159 4899 5152 73 5227 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $27309 m0 *1 607.66,231.2
X$27309 73 5070 5071 5154 73 5159 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27312 m0 *1 610.88,231.2
X$27312 73 5070 5152 5077 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27329 m0 *1 642.62,231.2
X$27329 73 5156 57 73 5157 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27330 m0 *1 646.3,231.2
X$27330 57 3980 4245 5155 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27346 r0 *1 28.06,231.2
X$27346 57 5161 5238 5183 5042 4675 5241 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $27350 r0 *1 37.26,231.2
X$27350 57 5114 5424 4768 5113 5160 4569 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $27352 r0 *1 40.94,231.2
X$27352 73 5114 73 57 5163 57 sky130_fd_sc_hd__buf_4
* cell instance $27357 r0 *1 46.46,231.2
X$27357 73 4285 5245 5243 5040 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $27360 r0 *1 52.9,231.2
X$27360 73 4227 5116 5115 57 73 5245 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27361 r0 *1 54.74,231.2
X$27361 73 4192 5116 5376 4860 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $27364 r0 *1 60.72,231.2
X$27364 73 5160 4192 4737 57 73 5118 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27365 r0 *1 62.56,231.2
X$27365 73 4218 5249 5118 5167 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $27390 r0 *1 123.28,231.2
X$27390 73 5121 5188 4956 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27397 r0 *1 132.02,231.2
X$27397 57 5172 5122 5121 4218 4192 4957 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $27400 r0 *1 139.38,231.2
X$27400 73 4192 5122 4604 73 5265 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27408 r0 *1 155.02,231.2
X$27408 57 5266 4870 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $27421 r0 *1 193.66,231.2
X$27421 73 5051 73 57 5194 57 sky130_fd_sc_hd__buf_4
* cell instance $27422 r0 *1 196.42,231.2
X$27422 57 15592 5123 4480 4589 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $27425 r0 *1 202.4,231.2
X$27425 73 5123 5269 5197 73 57 5103 57 sky130_fd_sc_hd__o21ai_1
* cell instance $27426 r0 *1 204.24,231.2
X$27426 57 5269 4710 5106 5197 73 73 57 sky130_fd_sc_hd__nand3_2
* cell instance $27428 r0 *1 207.92,231.2
X$27428 73 5123 5197 5270 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27433 r0 *1 218.04,231.2
X$27433 73 5126 4612 5271 5196 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $27434 r0 *1 219.88,231.2
X$27434 57 4934 4589 5197 5392 4843 5130 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $27435 r0 *1 223.56,231.2
X$27435 73 5125 5196 5127 6131 57 5358 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $27436 r0 *1 225.86,231.2
X$27436 73 5273 5128 4266 4936 57 73 5127 57 sky130_fd_sc_hd__a31oi_1
* cell instance $27446 r0 *1 243.34,231.2
X$27446 73 4299 5129 4374 4960 4963 5128 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $27450 r0 *1 255.3,231.2
X$27450 73 5131 4619 4374 73 5277 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27453 r0 *1 258.52,231.2
X$27453 73 4619 73 57 5132 57 sky130_fd_sc_hd__buf_4
* cell instance $27456 r0 *1 261.74,231.2
X$27456 73 5060 4875 4524 73 5279 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27463 r0 *1 271.86,231.2
X$27463 57 5061 5130 5200 4877 5179 4875 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $27467 r0 *1 282.9,231.2
X$27467 57 4374 5280 4966 5201 5028 5178 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $27469 r0 *1 286.58,231.2
X$27469 57 4374 5134 4852 5133 5132 4299 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $27475 r0 *1 293.02,231.2
X$27475 57 4618 5284 5060 5028 5201 4374 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $27477 r0 *1 299.92,231.2
X$27477 73 4779 5202 4878 4877 5135 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $27478 r0 *1 302.68,231.2
X$27478 73 4372 5135 5134 5283 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $27479 r0 *1 304.52,231.2
X$27479 73 4843 73 57 5136 57 sky130_fd_sc_hd__buf_4
* cell instance $27480 r0 *1 307.28,231.2
X$27480 73 4779 5132 5136 73 5285 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $27511 r0 *1 382.72,231.2
X$27511 73 5139 2342 5173 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27512 r0 *1 384.1,231.2
X$27512 73 5139 5206 5174 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $27513 r0 *1 386.4,231.2
X$27513 73 5138 5206 5139 73 4972 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $27515 r0 *1 389.62,231.2
X$27515 73 5139 2342 5206 5138 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $27517 r0 *1 391.92,231.2
X$27517 57 3559 5140 4728 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $27547 r0 *1 463.22,231.2
X$27547 57 5877 4515 4450 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27551 r0 *1 476.56,231.2
X$27551 73 4746 73 57 5275 57 sky130_fd_sc_hd__inv_1
* cell instance $27553 r0 *1 477.94,231.2
X$27553 73 5275 73 57 5141 57 sky130_fd_sc_hd__buf_4
* cell instance $27558 r0 *1 486.22,231.2
X$27558 57 5272 4515 5137 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27564 r0 *1 505.54,231.2
X$27564 57 5328 5210 5095 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27571 r0 *1 526.7,231.2
X$27571 73 5147 73 57 5144 57 sky130_fd_sc_hd__buf_4
* cell instance $27572 r0 *1 529.46,231.2
X$27572 73 5092 4899 4921 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27576 r0 *1 532.22,231.2
X$27576 57 4897 5211 5143 5142 5144 5145 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $27578 r0 *1 537.28,231.2
X$27578 73 5212 4980 5211 73 5169 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27584 r0 *1 548.32,231.2
X$27584 73 4983 5215 5143 73 5168 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27587 r0 *1 551.54,231.2
X$27587 73 5065 4983 5148 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27591 r0 *1 558.44,231.2
X$27591 73 5145 73 57 4901 57 sky130_fd_sc_hd__buf_4
* cell instance $27594 r0 *1 562.58,231.2
X$27594 73 5092 73 57 5150 57 sky130_fd_sc_hd__buf_4
* cell instance $27596 r0 *1 566.26,231.2
X$27596 73 5212 5147 5263 73 5218 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27601 r0 *1 575,231.2
X$27601 73 5214 4989 5149 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27602 r0 *1 576.38,231.2
X$27602 73 4982 5259 5149 5165 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $27603 r0 *1 578.22,231.2
X$27603 73 4904 5214 5148 73 5898 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27606 r0 *1 581.44,231.2
X$27606 73 4917 5256 5258 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27608 r0 *1 583.74,231.2
X$27608 73 5081 73 57 5253 57 sky130_fd_sc_hd__buf_4
* cell instance $27616 r0 *1 598.92,231.2
X$27616 73 5070 4996 5154 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27621 r0 *1 607.2,231.2
X$27621 73 5321 4902 5153 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27623 r0 *1 609.04,231.2
X$27623 73 5153 73 57 5229 57 sky130_fd_sc_hd__buf_4
* cell instance $27628 r0 *1 617.78,231.2
X$27628 73 4899 5091 5240 5150 5701 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $27633 r0 *1 624.22,231.2
X$27633 73 4902 4982 5230 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27634 r0 *1 625.6,231.2
X$27634 73 5236 5237 5230 5151 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $27646 r0 *1 653.2,231.2
X$27646 73 5074 57 73 5233 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27710 m0 *1 43.7,236.64
X$27710 73 4768 5244 5183 5241 57 5243 73 57 sky130_fd_sc_hd__a22o_1
* cell instance $27713 m0 *1 48.3,236.64
X$27713 73 4658 4424 5115 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27720 m0 *1 62.56,236.64
X$27720 73 5039 5290 4859 4290 5249 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $27723 m0 *1 70.38,236.64
X$27723 73 4218 5250 5184 57 73 4863 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27725 m0 *1 72.68,236.64
X$27725 73 4227 5185 4164 5250 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $27729 m0 *1 80.96,236.64
X$27729 73 5252 5039 5187 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27736 m0 *1 93.84,236.64
X$27736 73 4366 5340 5171 4165 5186 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $27740 m0 *1 99.82,236.64
X$27740 73 5622 5254 4285 4333 57 73 5257 57 sky130_fd_sc_hd__a31oi_1
* cell instance $27749 m0 *1 114.54,236.64
X$27749 73 4192 5185 4133 57 73 5189 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27750 m0 *1 116.38,236.64
X$27750 73 4285 5187 5189 5190 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $27752 m0 *1 119.14,236.64
X$27752 73 4218 5190 4865 5191 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $27754 m0 *1 121.9,236.64
X$27754 73 5527 5191 4259 73 5262 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27755 m0 *1 123.74,236.64
X$27755 73 5261 4705 5262 5186 5267 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $27758 m0 *1 128.34,236.64
X$27758 73 5120 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $27781 m0 *1 190.9,236.64
X$27781 73 5192 5048 5193 57 73 5268 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27782 m0 *1 192.74,236.64
X$27782 73 5354 4711 5194 57 73 5192 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27788 m0 *1 207,236.64
X$27788 73 4266 4338 5195 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27789 m0 *1 208.38,236.64
X$27789 73 5195 73 57 5126 57 sky130_fd_sc_hd__buf_4
* cell instance $27793 m0 *1 217.12,236.64
X$27793 73 5197 5479 5270 4372 5198 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $27810 m0 *1 258.52,236.64
X$27810 57 4779 5273 4299 4483 5132 5278 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $27823 m0 *1 297.62,236.64
X$27823 73 4879 73 57 5202 57 sky130_fd_sc_hd__buf_4
* cell instance $27828 m0 *1 307.28,236.64
X$27828 57 5203 5198 5285 4849 5282 4372 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $27840 m0 *1 343.16,236.64
X$27840 57 4880 4882 5281 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27852 m0 *1 378.12,236.64
X$27852 73 5205 73 57 4461 57 sky130_fd_sc_hd__buf_4
* cell instance $27857 m0 *1 389.16,236.64
X$27857 73 2342 5207 5206 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27888 m0 *1 479.32,236.64
X$27888 73 5007 73 57 5209 57 sky130_fd_sc_hd__clkinv_1
* cell instance $27889 m0 *1 480.7,236.64
X$27889 57 5006 4515 5209 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27891 m0 *1 488.98,236.64
X$27891 57 4799 5210 5274 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $27912 m0 *1 550.16,236.64
X$27912 73 4902 5146 5213 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27917 m0 *1 558.44,236.64
X$27917 73 4902 5214 5215 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27919 m0 *1 561.66,236.64
X$27919 73 5216 5092 5214 4982 5217 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $27920 m0 *1 564.42,236.64
X$27920 73 5212 4999 5217 57 73 5264 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27922 m0 *1 566.72,236.64
X$27922 73 5147 5341 5236 5263 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $27928 m0 *1 579.14,236.64
X$27928 73 4917 5218 5260 5258 73 5219 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $27930 m0 *1 582.36,236.64
X$27930 73 5337 5219 5246 5220 4998 5255 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $27931 m0 *1 585.58,236.64
X$27931 73 5224 5221 4998 73 5220 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27932 m0 *1 587.42,236.64
X$27932 57 5221 5216 5222 5147 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $27934 m0 *1 592.94,236.64
X$27934 73 4980 5222 5251 57 73 4995 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27938 m0 *1 601.22,236.64
X$27938 73 5226 5251 5248 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $27939 m0 *1 602.6,236.64
X$27939 73 5225 73 57 5152 57 sky130_fd_sc_hd__buf_4
* cell instance $27940 m0 *1 605.36,236.64
X$27940 73 5154 5228 5247 73 5246 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $27942 m0 *1 607.66,236.64
X$27942 73 5333 5226 4982 57 73 5228 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27944 m0 *1 609.96,236.64
X$27944 73 5229 5154 5242 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $27948 m0 *1 617.32,236.64
X$27948 73 5323 5152 5239 4899 5240 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $27959 m0 *1 642.62,236.64
X$27959 73 5235 57 73 5231 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27968 r0 *1 4.6,236.64
X$27968 73 5182 57 73 5329 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27979 r0 *1 34.96,236.64
X$27979 73 4227 4133 5331 57 73 5288 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27980 r0 *1 36.8,236.64
X$27980 73 5288 73 57 5332 57 sky130_fd_sc_hd__buf_4
* cell instance $27997 r0 *1 73.6,236.64
X$27997 73 4675 5185 5336 57 73 5335 57 sky130_fd_sc_hd__a21oi_1
* cell instance $27999 r0 *1 75.9,236.64
X$27999 73 5290 73 57 5045 57 sky130_fd_sc_hd__buf_4
* cell instance $28018 r0 *1 124.66,236.64
X$28018 73 5439 4922 4331 57 73 5345 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28022 r0 *1 128.34,236.64
X$28022 57 1232 5120 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $28043 r0 *1 186.76,236.64
X$28043 73 4373 4299 5193 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28046 r0 *1 190.9,236.64
X$28046 73 4711 4299 5197 73 5354 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28051 r0 *1 201.48,236.64
X$28051 73 4589 4373 4708 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28060 r0 *1 212.98,236.64
X$28060 57 4522 5197 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $28062 r0 *1 224.02,236.64
X$28062 57 5361 3766 5358 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $28063 r0 *1 231.38,236.64
X$28063 73 5131 4710 5197 57 73 5362 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28065 r0 *1 233.22,236.64
X$28065 73 4476 5131 5197 73 5456 57 57 sky130_fd_sc_hd__a21oi_2
* cell instance $28070 r0 *1 238.74,236.64
X$28070 73 4712 5131 4374 73 5365 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28073 r0 *1 241.96,236.64
X$28073 73 4266 4338 5180 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28074 r0 *1 243.34,236.64
X$28074 73 4617 4482 4374 5581 57 5129 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $28088 r0 *1 283.82,236.64
X$28088 73 4482 4374 4372 5368 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $28089 r0 *1 285.66,236.64
X$28089 73 5368 4782 5395 5300 73 5301 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $28093 r0 *1 290.26,236.64
X$28093 73 4717 4374 4372 5302 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $28095 r0 *1 292.56,236.64
X$28095 73 5363 5301 4877 5057 57 73 5563 57 sky130_fd_sc_hd__a31oi_1
* cell instance $28096 r0 *1 294.86,236.64
X$28096 73 4374 5364 5302 4875 5363 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $28098 r0 *1 298.08,236.64
X$28098 73 4784 5291 5282 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28126 r0 *1 368.46,236.64
X$28126 73 5204 5360 5303 73 5359 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28127 r0 *1 370.3,236.64
X$28127 57 15613 5398 5276 5281 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $28131 r0 *1 376.74,236.64
X$28131 73 5307 5359 5141 5356 57 73 5357 57 sky130_fd_sc_hd__a31oi_1
* cell instance $28147 r0 *1 418.14,236.64
X$28147 57 5355 5311 5276 5303 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $28149 r0 *1 422.74,236.64
X$28149 73 5311 5308 5208 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28150 r0 *1 424.12,236.64
X$28150 73 5353 5303 5312 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28155 r0 *1 431.48,236.64
X$28155 73 5281 5352 5310 57 73 5351 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28160 r0 *1 442.98,236.64
X$28160 73 5276 5308 5310 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28173 r0 *1 468.74,236.64
X$28173 57 5209 5308 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $28174 r0 *1 476.1,236.64
X$28174 57 5007 5315 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $28178 r0 *1 485.76,236.64
X$28178 57 4669 5207 5210 5316 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $28181 r0 *1 501.4,236.64
X$28181 73 5272 57 73 5347 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $28192 r0 *1 526.7,236.64
X$28192 73 4911 5317 5346 73 5434 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28197 r0 *1 534.52,236.64
X$28197 73 4986 5433 5320 5341 4982 5317 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $28205 r0 *1 550.62,236.64
X$28205 73 4917 5213 5343 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28210 r0 *1 559.82,236.64
X$28210 73 5215 5319 5147 73 5342 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28218 r0 *1 571.78,236.64
X$28218 73 5264 73 57 5338 57 sky130_fd_sc_hd__buf_4
* cell instance $28221 r0 *1 580.06,236.64
X$28221 73 5339 73 57 5337 57 sky130_fd_sc_hd__inv_1
* cell instance $28223 r0 *1 581.9,236.64
X$28223 73 5223 73 57 5320 57 sky130_fd_sc_hd__buf_4
* cell instance $28226 r0 *1 585.58,236.64
X$28226 73 4900 4902 4980 5223 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $28231 r0 *1 596.16,236.64
X$28231 73 5251 5223 5427 5334 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $28232 r0 *1 598,236.64
X$28232 73 4911 5334 5330 57 73 5704 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28235 r0 *1 602.14,236.64
X$28235 73 4900 4906 5225 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28237 r0 *1 605.36,236.64
X$28237 73 5070 4906 5224 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28238 r0 *1 606.74,236.64
X$28238 73 5321 4902 4982 5333 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $28239 r0 *1 608.58,236.64
X$28239 73 5222 5229 5224 57 73 5322 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28240 r0 *1 610.42,236.64
X$28240 73 5322 5242 4982 73 5330 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28243 r0 *1 615.94,236.64
X$28243 73 5147 73 57 5251 57 sky130_fd_sc_hd__buf_4
* cell instance $28249 r0 *1 631.12,236.64
X$28249 73 5251 5325 4900 73 5892 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28250 r0 *1 632.96,236.64
X$28250 73 4905 5150 5325 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28255 r0 *1 643.54,236.64
X$28255 73 5328 57 73 5327 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $28272 m0 *1 30.36,242.08
X$28272 73 5287 4814 5289 5161 57 5422 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $28273 m0 *1 32.66,242.08
X$28273 73 5160 5374 4660 57 73 5287 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28276 m0 *1 36.8,242.08
X$28276 57 5375 5424 5289 5344 5161 5160 73 73 57 sky130_fd_sc_hd__a2111oi_1
* cell instance $28281 m0 *1 43.24,242.08
X$28281 73 5375 73 57 5428 57 sky130_fd_sc_hd__buf_4
* cell instance $28285 m0 *1 51.98,242.08
X$28285 73 5244 73 57 4504 57 sky130_fd_sc_hd__buf_4
* cell instance $28297 m0 *1 74.06,242.08
X$28297 73 4192 5378 5336 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28305 m0 *1 89.7,242.08
X$28305 73 5517 5252 4504 57 73 5340 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28320 m0 *1 123.28,242.08
X$28320 57 5380 4366 5344 5345 5627 4287 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $28324 m0 *1 130.64,242.08
X$28324 73 4363 4424 5745 73 5122 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28331 m0 *1 142.14,242.08
X$28331 73 5265 4366 4287 5428 57 5441 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $28332 m0 *1 144.9,242.08
X$28332 73 5441 5380 4165 73 5443 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28334 m0 *1 150.42,242.08
X$28334 73 5381 73 57 3763 57 sky130_fd_sc_hd__buf_4
* cell instance $28356 m0 *1 201.48,242.08
X$28356 57 4299 5445 4966 5292 5385 5446 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $28361 m0 *1 206.08,242.08
X$28361 73 4589 5291 5292 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28363 m0 *1 208.38,242.08
X$28363 73 4374 5362 5385 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28372 m0 *1 228.16,242.08
X$28372 73 5106 5389 5390 57 73 5030 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28374 m0 *1 230.46,242.08
X$28374 73 4711 4480 4617 73 5390 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28378 m0 *1 232.76,242.08
X$28378 73 5291 4840 5298 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $28383 m0 *1 245.18,242.08
X$28383 57 5295 5293 4374 5367 5294 4966 5292 73 73 57 sky130_fd_sc_hd__a222oi_1
* cell instance $28388 m0 *1 253.92,242.08
X$28388 73 4374 4372 5367 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28389 m0 *1 255.3,242.08
X$28389 73 5126 4299 5295 5296 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $28396 m0 *1 266.8,242.08
X$28396 73 4876 5297 5278 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28397 m0 *1 268.18,242.08
X$28397 73 4711 5367 5300 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28400 m0 *1 273.7,242.08
X$28400 57 5393 5392 4785 4966 4782 5298 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $28406 m0 *1 280.14,242.08
X$28406 73 5126 4877 5393 5299 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $28407 m0 *1 281.98,242.08
X$28407 73 5296 5280 5299 57 73 5366 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28414 m0 *1 292.56,242.08
X$28414 73 4966 5060 5364 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $28447 m0 *1 366.62,242.08
X$28447 73 5353 5315 5360 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28452 m0 *1 372.6,242.08
X$28452 57 15546 5490 5276 5304 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $28453 m0 *1 377.2,242.08
X$28453 73 5491 5459 5305 5304 5141 73 5356 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $28456 m0 *1 384.56,242.08
X$28456 73 5306 5455 5315 73 5454 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28462 m0 *1 393.3,242.08
X$28462 73 5313 5309 5307 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28463 m0 *1 394.68,242.08
X$28463 73 5276 5303 5306 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28468 m0 *1 398.36,242.08
X$28468 73 5276 5308 5309 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28470 m0 *1 400.66,242.08
X$28470 73 5453 73 57 5452 57 sky130_fd_sc_hd__buf_4
* cell instance $28471 m0 *1 403.42,242.08
X$28471 73 5453 5309 5281 73 5401 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28472 m0 *1 405.26,242.08
X$28472 73 5204 5451 5281 73 5449 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28474 m0 *1 408.02,242.08
X$28474 73 5141 6263 5447 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28480 m0 *1 416.76,242.08
X$28480 57 4970 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $28483 m0 *1 422.74,242.08
X$28483 73 5402 5303 5315 5312 5444 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $28484 m0 *1 425.5,242.08
X$28484 73 5313 5303 5312 73 5404 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28485 m0 *1 427.34,242.08
X$28485 73 5315 5404 5314 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28486 m0 *1 428.72,242.08
X$28486 73 5314 5208 5399 5349 57 73 5350 57 sky130_fd_sc_hd__a31oi_1
* cell instance $28488 m0 *1 431.48,242.08
X$28488 73 5399 6022 6209 5349 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $28512 m0 *1 481.16,242.08
X$28512 57 5235 4515 5409 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $28516 m0 *1 491.74,242.08
X$28516 57 5348 5210 4445 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $28518 m0 *1 499.56,242.08
X$28518 57 5047 2390 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $28526 m0 *1 523.94,242.08
X$28526 73 5437 5531 5435 73 57 5346 57 sky130_fd_sc_hd__o21bai_1
* cell instance $28529 m0 *1 529,242.08
X$28529 73 5434 73 57 5423 57 sky130_fd_sc_hd__buf_4
* cell instance $28532 m0 *1 531.76,242.08
X$28532 57 57 5412 4984 4982 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $28534 m0 *1 534.52,242.08
X$28534 73 5318 73 57 5433 57 sky130_fd_sc_hd__buf_4
* cell instance $28535 m0 *1 537.28,242.08
X$28535 73 4982 5412 5318 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28537 m0 *1 540.5,242.08
X$28537 73 5318 73 57 5146 57 sky130_fd_sc_hd__buf_4
* cell instance $28540 m0 *1 545.56,242.08
X$28540 73 5412 5065 5341 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $28549 m0 *1 559.36,242.08
X$28549 57 5430 5216 4984 5320 5342 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $28563 m0 *1 592.48,242.08
X$28563 73 5222 4980 5319 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28564 m0 *1 593.86,242.08
X$28564 73 5426 73 57 5427 57 sky130_fd_sc_hd__buf_4
* cell instance $28574 m0 *1 617.32,242.08
X$28574 73 4902 5251 5323 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28578 m0 *1 624.68,242.08
X$28578 73 5324 5416 5230 4910 73 57 5421 57 sky130_fd_sc_hd__o31ai_1
* cell instance $28583 m0 *1 634.34,242.08
X$28583 73 5325 73 57 5419 57 sky130_fd_sc_hd__buf_4
* cell instance $28595 r0 *1 2.76,242.08
X$28595 73 5369 57 73 6794 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $28603 r0 *1 20.24,242.08
X$28603 73 5370 4424 5371 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28604 r0 *1 21.62,242.08
X$28604 73 5371 73 57 5376 57 sky130_fd_sc_hd__buf_4
* cell instance $28608 r0 *1 30.82,242.08
X$28608 73 5377 5372 4814 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28609 r0 *1 32.2,242.08
X$28609 73 4227 5241 5373 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28610 r0 *1 33.58,242.08
X$28610 73 5373 73 57 5188 57 sky130_fd_sc_hd__buf_4
* cell instance $28611 r0 *1 36.34,242.08
X$28611 73 5373 5374 5424 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28613 r0 *1 38.18,242.08
X$28613 73 5370 5372 5344 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28616 r0 *1 40.94,242.08
X$28616 73 5372 73 57 5039 57 sky130_fd_sc_hd__buf_4
* cell instance $28621 r0 *1 45.54,242.08
X$28621 73 5289 73 57 4162 57 sky130_fd_sc_hd__buf_4
* cell instance $28625 r0 *1 56.58,242.08
X$28625 73 5377 4569 5370 4504 73 5514 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $28636 r0 *1 80.5,242.08
X$28636 73 5432 4285 5431 57 73 5517 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28647 r0 *1 107.18,242.08
X$28647 73 5572 5252 4192 57 73 5524 57 sky130_fd_sc_hd__a21boi_0
* cell instance $28648 r0 *1 109.94,242.08
X$28648 73 4424 5524 5472 73 5436 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28659 r0 *1 137.08,242.08
X$28659 57 5381 5120 5439 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $28668 r0 *1 160.08,242.08
X$28668 57 5542 4870 5267 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $28681 r0 *1 189.06,242.08
X$28681 73 5382 73 57 5394 57 sky130_fd_sc_hd__buf_4
* cell instance $28685 r0 *1 196.88,242.08
X$28685 73 4686 5268 5383 4372 5478 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $28688 r0 *1 201.94,242.08
X$28688 73 5445 5478 5547 4138 5124 73 5448 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $28691 r0 *1 205.62,242.08
X$28691 73 5448 5386 5546 4837 5384 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $28695 r0 *1 211.6,242.08
X$28695 73 5387 4540 4138 4266 57 73 5386 57 sky130_fd_sc_hd__a31oi_1
* cell instance $28699 r0 *1 224.94,242.08
X$28699 73 4616 4966 5388 5389 73 57 5293 57 sky130_fd_sc_hd__o31ai_1
* cell instance $28701 r0 *1 228.16,242.08
X$28701 73 4710 5388 5389 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28703 r0 *1 230.46,242.08
X$28703 73 5030 5458 5549 73 5387 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28712 r0 *1 250.24,242.08
X$28712 73 4616 4374 5391 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28714 r0 *1 252.08,242.08
X$28714 73 5391 73 57 4542 57 sky130_fd_sc_hd__buf_4
* cell instance $28724 r0 *1 273.24,242.08
X$28724 73 4374 4782 5297 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28725 r0 *1 274.62,242.08
X$28725 73 5460 5298 4622 4482 4717 5483 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $28728 r0 *1 285.2,242.08
X$28728 73 5394 5461 4718 73 5395 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28735 r0 *1 293.02,242.08
X$28735 73 4877 5562 5563 73 5560 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28737 r0 *1 295.78,242.08
X$28737 73 5394 4873 4967 57 73 5556 57 sky130_fd_sc_hd__a21boi_0
* cell instance $28738 r0 *1 298.54,242.08
X$28738 73 4877 5282 5554 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28742 r0 *1 305.9,242.08
X$28742 57 4299 5396 5394 6344 5645 5136 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $28744 r0 *1 309.58,242.08
X$28744 57 5553 5102 4299 5126 5396 5203 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $28767 r0 *1 363.4,242.08
X$28767 73 5397 5398 5315 57 73 5552 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28770 r0 *1 367.54,242.08
X$28770 73 5304 5353 5455 5315 57 5397 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $28772 r0 *1 370.3,242.08
X$28772 73 5353 5315 5489 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28779 r0 *1 378.12,242.08
X$28779 57 15607 5440 5276 5303 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $28782 r0 *1 385.02,242.08
X$28782 73 5399 5457 5454 5548 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $28790 r0 *1 401.12,242.08
X$28790 73 5400 5315 5453 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28794 r0 *1 405.26,242.08
X$28794 73 5401 5403 5449 5447 5450 5631 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $28798 r0 *1 414.92,242.08
X$28798 73 5355 5315 5545 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28799 r0 *1 416.3,242.08
X$28799 57 2390 4970 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $28805 r0 *1 434.24,242.08
X$28805 57 5408 5309 5402 5351 5400 5405 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $28806 r0 *1 437.46,242.08
X$28806 73 5281 5406 5309 5541 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $28807 r0 *1 439.3,242.08
X$28807 73 5491 5442 5541 5281 5399 73 5407 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $28808 r0 *1 442.52,242.08
X$28808 73 5407 5399 5408 57 73 5539 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28811 r0 *1 445.74,242.08
X$28811 73 5308 5440 5540 5493 57 5403 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $28830 r0 *1 490.36,242.08
X$28830 73 5438 57 73 5316 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $28831 r0 *1 494.04,242.08
X$28831 57 5210 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $28840 r0 *1 521.64,242.08
X$28840 57 5412 5411 5147 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $28841 r0 *1 525.78,242.08
X$28841 73 5410 73 57 5435 57 sky130_fd_sc_hd__buf_4
* cell instance $28843 r0 *1 529,242.08
X$28843 73 5411 73 57 5145 57 sky130_fd_sc_hd__buf_4
* cell instance $28854 r0 *1 551.08,242.08
X$28854 73 5222 4982 4980 5410 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $28856 r0 *1 556.6,242.08
X$28856 73 5412 73 57 5214 57 sky130_fd_sc_hd__buf_4
* cell instance $28860 r0 *1 564.88,242.08
X$28860 73 2935 73 57 5520 57 sky130_fd_sc_hd__buf_4
* cell instance $28863 r0 *1 568.56,242.08
X$28863 73 4982 5341 5320 57 73 5519 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28864 r0 *1 570.4,242.08
X$28864 73 4917 5429 4916 5496 5216 73 5518 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $28866 r0 *1 575.46,242.08
X$28866 73 5413 5498 4905 73 5429 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28868 r0 *1 577.76,242.08
X$28868 73 5321 5214 5498 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28874 r0 *1 590.64,242.08
X$28874 73 5413 73 57 5415 57 sky130_fd_sc_hd__buf_4
* cell instance $28875 r0 *1 593.4,242.08
X$28875 73 5251 4980 5413 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28879 r0 *1 597.08,242.08
X$28879 73 5225 5509 5251 73 5414 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28880 r0 *1 598.92,242.08
X$28880 73 4917 5425 5414 57 73 5507 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28881 r0 *1 600.76,242.08
X$28881 73 4902 5415 5425 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28892 r0 *1 624.22,242.08
X$28892 73 5237 73 57 5416 57 sky130_fd_sc_hd__buf_4
* cell instance $28894 r0 *1 628.82,242.08
X$28894 73 4900 5417 5324 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28896 r0 *1 631.12,242.08
X$28896 73 5324 73 57 5420 57 sky130_fd_sc_hd__buf_4
* cell instance $28897 r0 *1 633.88,242.08
X$28897 73 4899 5420 5419 57 73 5502 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28902 r0 *1 643.54,242.08
X$28902 73 4563 57 73 5501 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $28963 m0 *1 20.24,247.52
X$28963 73 4192 5371 5331 57 73 5465 57 sky130_fd_sc_hd__a21oi_1
* cell instance $28965 m0 *1 23.92,247.52
X$28965 73 5464 5465 4675 73 5504 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $28969 m0 *1 30.36,247.52
X$28969 73 4658 5372 5464 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $28971 m0 *1 32.2,247.52
X$28971 73 5422 73 57 5506 57 sky130_fd_sc_hd__buf_4
* cell instance $28974 m0 *1 37.72,247.52
X$28974 73 5374 4658 4192 5160 5466 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $28979 m0 *1 49.68,247.52
X$28979 73 4218 5468 5466 5467 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $28985 m0 *1 59.8,247.52
X$28985 73 5467 73 57 5470 57 sky130_fd_sc_hd__buf_4
* cell instance $28989 m0 *1 69,247.52
X$28989 73 5514 5515 5469 4162 4285 73 5513 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $28990 m0 *1 72.22,247.52
X$28990 73 4223 5471 4191 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $28991 m0 *1 73.6,247.52
X$28991 73 4467 4360 4192 5620 57 73 5469 57 sky130_fd_sc_hd__a31oi_1
* cell instance $28993 m0 *1 79.58,247.52
X$28993 73 5516 5471 5039 5521 5431 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $29009 m0 *1 114.08,247.52
X$29009 73 4129 5526 4294 73 5472 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $29010 m0 *1 116.84,247.52
X$29010 73 4927 4292 4192 57 73 5526 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29011 m0 *1 118.68,247.52
X$29011 73 4658 4227 5529 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29013 m0 *1 121.9,247.52
X$29013 73 4366 5532 5473 57 73 5527 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29017 m0 *1 132.02,247.52
X$29017 73 4424 5474 5475 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29018 m0 *1 133.4,247.52
X$29018 73 5475 5535 4218 5470 57 73 5476 57 sky130_fd_sc_hd__a31oi_1
* cell instance $29023 m0 *1 141.68,247.52
X$29023 73 5513 73 57 5537 57 sky130_fd_sc_hd__buf_4
* cell instance $29024 m0 *1 144.44,247.52
X$29024 73 5537 4287 5476 57 73 5538 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29040 m0 *1 185.84,247.52
X$29040 73 4372 5543 4616 5382 73 5576 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $29047 m0 *1 196.42,247.52
X$29047 73 4540 5477 5544 4622 4711 5383 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $29049 m0 *1 200.1,247.52
X$29049 73 5578 5197 5291 4480 5477 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $29052 m0 *1 207,247.52
X$29052 73 4338 4540 5728 5546 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29057 m0 *1 218.5,247.52
X$29057 73 5130 5479 5197 4540 57 73 4777 57 sky130_fd_sc_hd__a31oi_1
* cell instance $29063 m0 *1 230.92,247.52
X$29063 73 5480 5481 4966 73 5549 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29064 m0 *1 232.76,247.52
X$29064 73 5106 4876 5197 57 73 5481 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29066 m0 *1 235.52,247.52
X$29066 57 4374 5660 4372 4485 5480 5365 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $29070 m0 *1 247.02,247.52
X$29070 73 4711 4715 4522 5480 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $29075 m0 *1 256.68,247.52
X$29075 73 5480 73 57 4849 57 sky130_fd_sc_hd__buf_4
* cell instance $29078 m0 *1 264.96,247.52
X$29078 73 5106 5279 6398 73 5482 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29081 m0 *1 268.18,247.52
X$29081 73 4372 5482 5558 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29084 m0 *1 271.86,247.52
X$29084 73 4877 4966 5483 57 73 5559 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29085 m0 *1 273.7,247.52
X$29085 73 5460 5028 4783 5392 4708 5484 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $29086 m0 *1 276.92,247.52
X$29086 73 4372 5484 5485 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29092 m0 *1 287.5,247.52
X$29092 73 4877 5036 5588 73 5486 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29094 m0 *1 290.26,247.52
X$29094 73 5485 4372 5487 57 73 5562 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29095 m0 *1 292.1,247.52
X$29095 73 5564 5486 5560 5366 73 5561 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $29096 m0 *1 294.4,247.52
X$29096 73 5107 5488 5557 57 73 5564 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29097 m0 *1 296.24,247.52
X$29097 57 4299 5557 5954 5555 5556 5646 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $29124 m0 *1 366.16,247.52
X$29124 73 5304 5452 5551 5550 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $29127 m0 *1 372.14,247.52
X$29127 73 5489 73 57 5459 57 sky130_fd_sc_hd__buf_4
* cell instance $29129 m0 *1 375.82,247.52
X$29129 73 5637 73 57 5491 57 sky130_fd_sc_hd__buf_4
* cell instance $29140 m0 *1 405.72,247.52
X$29140 73 5401 73 57 5632 57 sky130_fd_sc_hd__buf_4
* cell instance $29147 m0 *1 419.06,247.52
X$29147 73 5490 5315 5141 5444 5724 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $29148 m0 *1 421.82,247.52
X$29148 73 5313 5315 5352 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29150 m0 *1 425.04,247.52
X$29150 73 5402 5492 5493 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29154 m0 *1 432.86,247.52
X$29154 73 5494 5315 5405 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29175 m0 *1 490.36,247.52
X$29175 57 5717 5210 5536 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $29179 m0 *1 499.56,247.52
X$29179 73 5812 73 57 2565 57 sky130_fd_sc_hd__buf_4
* cell instance $29187 m0 *1 520.26,247.52
X$29187 73 5533 73 57 5437 57 sky130_fd_sc_hd__buf_4
* cell instance $29191 m0 *1 529,247.52
X$29191 73 5530 73 57 5531 57 sky130_fd_sc_hd__buf_4
* cell instance $29197 m0 *1 545.56,247.52
X$29197 73 5525 73 57 4900 57 sky130_fd_sc_hd__buf_4
* cell instance $29200 m0 *1 549.7,247.52
X$29200 73 4902 5147 4900 73 5523 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29201 m0 *1 551.54,247.52
X$29201 73 5511 4917 5343 5522 5495 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $29209 m0 *1 573.16,247.52
X$29209 73 5147 5412 5496 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29210 m0 *1 574.54,247.52
X$29210 73 5497 73 57 5216 57 sky130_fd_sc_hd__buf_4
* cell instance $29211 m0 *1 577.3,247.52
X$29211 73 5147 5259 5498 5603 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $29216 m0 *1 582.82,247.52
X$29216 73 5510 73 57 5259 57 sky130_fd_sc_hd__buf_4
* cell instance $29217 m0 *1 585.58,247.52
X$29217 73 5499 5090 5512 5511 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29219 m0 *1 587.88,247.52
X$29219 73 5496 73 57 5505 57 sky130_fd_sc_hd__buf_4
* cell instance $29222 m0 *1 596.16,247.52
X$29222 73 4996 5497 5426 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $29227 m0 *1 607.2,247.52
X$29227 73 5505 5321 5499 5226 5616 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $29230 m0 *1 611.8,247.52
X$29230 73 5071 73 57 5499 57 sky130_fd_sc_hd__buf_4
* cell instance $29234 m0 *1 617.78,247.52
X$29234 73 5500 5420 5503 5239 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29236 m0 *1 623.3,247.52
X$29236 73 5612 73 57 5237 57 sky130_fd_sc_hd__buf_4
* cell instance $29244 m0 *1 644,247.52
X$29244 73 5348 57 73 5608 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29251 r0 *1 7.82,247.52
X$29251 73 5463 57 73 5610 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29260 r0 *1 31.28,247.52
X$29260 73 5566 5241 5372 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29263 r0 *1 34.96,247.52
X$29263 73 5566 73 57 4192 57 sky130_fd_sc_hd__buf_4
* cell instance $29272 r0 *1 50.6,247.52
X$29272 73 4191 5568 4227 57 73 5567 57 sky130_fd_sc_hd__a21o_1
* cell instance $29275 r0 *1 56.12,247.52
X$29275 73 5377 4922 5468 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29277 r0 *1 57.96,247.52
X$29277 73 3952 3144 5534 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29279 r0 *1 61.18,247.52
X$29279 73 5568 73 57 4360 57 sky130_fd_sc_hd__buf_4
* cell instance $29282 r0 *1 68.08,247.52
X$29282 73 4192 5569 4422 73 5515 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29289 r0 *1 74.52,247.52
X$29289 73 4192 5569 4218 73 5620 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29299 r0 *1 99.36,247.52
X$29299 73 4675 5571 5188 4658 4294 5622 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $29302 r0 *1 107.18,247.52
X$29302 73 4658 4227 5572 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29306 r0 *1 116.84,247.52
X$29306 73 5624 5472 5573 73 57 5473 57 sky130_fd_sc_hd__o21bai_1
* cell instance $29307 r0 *1 119.6,247.52
X$29307 73 5529 5573 5472 5439 4538 5532 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $29311 r0 *1 126.96,247.52
X$29311 73 5846 4424 4366 5574 5627 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $29312 r0 *1 129.72,247.52
X$29312 73 5521 4227 4424 5575 5574 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $29313 r0 *1 132.48,247.52
X$29313 73 4223 4227 5575 73 5474 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29318 r0 *1 145.82,247.52
X$29318 73 4675 4259 5538 57 73 5634 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29329 r0 *1 168.36,247.52
X$29329 73 5542 73 57 5636 57 sky130_fd_sc_hd__buf_4
* cell instance $29340 r0 *1 185.38,247.52
X$29340 73 4711 5577 5576 73 5638 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29341 r0 *1 187.22,247.52
X$29341 73 4373 4686 4372 57 73 5577 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29345 r0 *1 200.1,247.52
X$29345 73 5388 4540 4372 5578 73 5544 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $29346 r0 *1 202.4,247.52
X$29346 73 4686 4522 5935 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29347 r0 *1 203.78,247.52
X$29347 73 4522 73 57 5579 57 sky130_fd_sc_hd__buf_4
* cell instance $29353 r0 *1 211.6,247.52
X$29353 73 5643 5388 4711 5543 57 5641 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $29356 r0 *1 216.2,247.52
X$29356 73 5580 73 57 5130 57 sky130_fd_sc_hd__buf_4
* cell instance $29370 r0 *1 247.02,247.52
X$29370 73 5582 5583 5294 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29376 r0 *1 258.98,247.52
X$29376 73 4782 4482 5583 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $29384 r0 *1 266.34,247.52
X$29384 73 4374 4781 5583 57 73 5648 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29386 r0 *1 270.02,247.52
X$29386 57 5559 4877 5584 5126 5558 5585 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $29388 r0 *1 274.62,247.52
X$29388 73 5180 73 57 5488 57 sky130_fd_sc_hd__buf_4
* cell instance $29393 r0 *1 286.12,247.52
X$29393 73 5649 4374 4946 57 73 5586 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29395 r0 *1 287.96,247.52
X$29395 73 5587 4877 5586 57 73 5588 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29399 r0 *1 292.56,247.52
X$29399 73 5060 5291 5647 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29401 r0 *1 294.4,247.52
X$29401 73 5647 4849 4966 5648 57 5555 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $29402 r0 *1 296.7,247.52
X$29402 73 4782 4785 4374 4372 57 5646 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $29404 r0 *1 301.3,247.52
X$29404 73 4374 4372 4875 5589 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29405 r0 *1 303.14,247.52
X$29405 73 4614 4622 5589 57 73 5645 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29425 r0 *1 355.12,247.52
X$29425 73 5644 5141 5552 57 73 5642 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29426 r0 *1 356.96,247.52
X$29426 73 5591 5642 5633 73 5590 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29427 r0 *1 358.8,247.52
X$29427 73 5592 5490 5308 57 73 5640 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29430 r0 *1 363.4,247.52
X$29430 57 5141 5834 5591 5639 5550 5593 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $29431 r0 *1 366.62,247.52
X$29431 73 5399 5595 5304 5352 5594 5593 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $29434 r0 *1 370.76,247.52
X$29434 73 5304 5489 5637 57 73 5595 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29440 r0 *1 376.74,247.52
X$29440 73 5402 5308 5594 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29443 r0 *1 382.72,247.52
X$29443 73 5596 73 57 5591 57 sky130_fd_sc_hd__buf_4
* cell instance $29448 r0 *1 395.14,247.52
X$29448 57 5399 5597 5276 5635 5592 5598 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $29455 r0 *1 405.72,247.52
X$29455 73 5631 73 57 5633 57 sky130_fd_sc_hd__buf_4
* cell instance $29457 r0 *1 412.16,247.52
X$29457 73 5494 5630 5598 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29468 r0 *1 438.38,247.52
X$29468 73 5598 5599 5597 5399 5600 73 5723 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $29475 r0 *1 452.18,247.52
X$29475 73 5494 5452 5628 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29484 r0 *1 474.72,247.52
X$29484 57 3410 5775 5596 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $29486 r0 *1 482.08,247.52
X$29486 73 4669 5625 5010 73 5626 57 57 sky130_fd_sc_hd__a21oi_2
* cell instance $29490 r0 *1 487.14,247.52
X$29490 73 4669 5720 5625 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29493 r0 *1 489.9,247.52
X$29493 57 5536 5623 5501 4669 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $29494 r0 *1 494.04,247.52
X$29494 57 6383 5210 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $29504 r0 *1 521.64,247.52
X$29504 73 5682 5144 5716 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29517 r0 *1 550.62,247.52
X$29517 73 5523 4980 5410 5685 57 5710 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $29519 r0 *1 557.06,247.52
X$29519 73 5495 73 57 5621 57 sky130_fd_sc_hd__buf_4
* cell instance $29526 r0 *1 569.02,247.52
X$29526 73 4899 5603 5519 5508 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $29532 r0 *1 581.44,247.52
X$29532 73 5603 73 57 5619 57 sky130_fd_sc_hd__buf_4
* cell instance $29538 r0 *1 593.86,247.52
X$29538 73 5604 5615 5618 5617 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $29544 r0 *1 607.66,247.52
X$29544 73 4911 5614 5616 5615 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $29546 r0 *1 609.96,247.52
X$29546 73 4902 5500 5605 57 73 5614 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29549 r0 *1 612.72,247.52
X$29549 73 5071 73 57 5613 57 sky130_fd_sc_hd__buf_4
* cell instance $29555 r0 *1 624.68,247.52
X$29555 73 4905 6792 5612 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29558 r0 *1 633.42,247.52
X$29558 73 5607 5611 5783 57 73 5609 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29559 r0 *1 635.26,247.52
X$29559 73 5222 5150 5417 5607 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $29567 r0 *1 651.36,247.52
X$29567 73 4803 57 73 5694 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29582 m0 *1 30.82,252.96
X$29582 73 4227 4660 4328 5706 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29591 m0 *1 51.52,252.96
X$29591 73 6044 73 57 5624 57 sky130_fd_sc_hd__buf_4
* cell instance $29594 m0 *1 55.66,252.96
X$29594 73 4227 5376 5653 57 73 5795 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29598 m0 *1 63.48,252.96
X$29598 73 5653 73 57 4699 57 sky130_fd_sc_hd__buf_4
* cell instance $29600 m0 *1 68.08,252.96
X$29600 73 4290 5471 4922 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29605 m0 *1 74.98,252.96
X$29605 73 4862 73 57 4957 57 sky130_fd_sc_hd__buf_4
* cell instance $29608 m0 *1 81.88,252.96
X$29608 73 4227 4699 4328 5654 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29613 m0 *1 87.4,252.96
X$29613 73 4227 4767 5570 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29615 m0 *1 89.24,252.96
X$29615 73 4227 4699 4164 5655 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29616 m0 *1 91.08,252.96
X$29616 73 4192 5185 4737 5656 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29617 m0 *1 92.92,252.96
X$29617 73 4285 5657 4675 5655 5656 5714 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $29618 m0 *1 96.6,252.96
X$29618 73 5570 4922 4675 5571 57 5657 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $29623 m0 *1 106.72,252.96
X$29623 73 5521 4227 5572 73 5715 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29633 m0 *1 126.04,252.96
X$29633 73 5575 5807 4424 4129 57 73 5573 57 sky130_fd_sc_hd__a31oi_1
* cell instance $29636 m0 *1 129.72,252.96
X$29636 73 4363 4227 5575 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29661 m0 *1 188.6,252.96
X$29661 73 5725 5658 5638 4438 5585 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $29664 m0 *1 193.66,252.96
X$29664 73 4966 4852 5659 57 73 5658 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29666 m0 *1 195.96,252.96
X$29666 73 4711 4686 5659 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29668 m0 *1 199.18,252.96
X$29668 73 5580 5659 5388 5726 57 73 4433 57 sky130_fd_sc_hd__a31oi_1
* cell instance $29669 m0 *1 201.48,252.96
X$29669 73 4710 5579 5727 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29671 m0 *1 203.78,252.96
X$29671 73 4438 73 57 5388 57 sky130_fd_sc_hd__buf_4
* cell instance $29674 m0 *1 206.54,252.96
X$29674 73 5660 5729 5728 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29676 m0 *1 209.76,252.96
X$29676 73 4482 5106 5578 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29680 m0 *1 218.96,252.96
X$29680 73 4616 5106 5479 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29686 m0 *1 226.32,252.96
X$29686 73 5751 73 57 4840 57 sky130_fd_sc_hd__buf_4
* cell instance $29696 m0 *1 248.86,252.96
X$29696 73 4482 4374 5822 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29699 m0 *1 251.16,252.96
X$29699 73 4711 4781 5581 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29742 m0 *1 356.04,252.96
X$29742 73 5141 5640 5733 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29748 m0 *1 364.78,252.96
X$29748 73 5308 5663 5303 5204 57 5639 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $29753 m0 *1 371.68,252.96
X$29753 73 5308 5663 5637 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $29755 m0 *1 374.9,252.96
X$29755 57 15477 5663 5276 5313 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $29758 m0 *1 382.26,252.96
X$29758 73 5596 5308 5730 57 73 5457 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29764 m0 *1 390.54,252.96
X$29764 73 5400 5315 5830 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29778 m0 *1 419.52,252.96
X$29778 57 5141 5668 5600 5667 6133 5724 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $29787 m0 *1 440.22,252.96
X$29787 73 5723 5600 5350 57 73 5722 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29792 m0 *1 448.5,252.96
X$29792 73 5596 73 57 5600 57 sky130_fd_sc_hd__buf_4
* cell instance $29795 m0 *1 451.26,252.96
X$29795 73 5675 5721 5674 5923 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $29796 m0 *1 453.1,252.96
X$29796 73 5628 5599 5141 5600 57 5675 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $29800 m0 *1 461.84,252.96
X$29800 73 5596 5141 5540 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29801 m0 *1 463.22,252.96
X$29801 73 5676 73 57 5596 57 sky130_fd_sc_hd__buf_4
* cell instance $29805 m0 *1 469.2,252.96
X$29805 73 5626 73 57 5676 57 sky130_fd_sc_hd__inv_1
* cell instance $29815 m0 *1 487.6,252.96
X$29815 57 5720 5719 5876 3410 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $29816 m0 *1 496.34,252.96
X$29816 73 5717 73 57 5718 57 sky130_fd_sc_hd__buf_4
* cell instance $29827 m0 *1 517.5,252.96
X$29827 73 5716 5678 5601 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29833 m0 *1 530.84,252.96
X$29833 57 5681 5682 5143 5412 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $29838 m0 *1 537.28,252.96
X$29838 73 5065 4984 5320 73 5684 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29839 m0 *1 539.12,252.96
X$29839 73 5684 73 57 6079 57 sky130_fd_sc_hd__buf_4
* cell instance $29841 m0 *1 542.8,252.96
X$29841 73 5687 73 57 5682 57 sky130_fd_sc_hd__buf_4
* cell instance $29844 m0 *1 546.94,252.96
X$29844 57 5602 5604 5601 5804 5522 5437 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $29845 m0 *1 550.16,252.96
X$29845 73 5092 4899 5685 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29846 m0 *1 551.54,252.96
X$29846 73 5685 73 57 5602 57 sky130_fd_sc_hd__buf_4
* cell instance $29852 m0 *1 558.9,252.96
X$29852 73 5437 5430 6103 73 5689 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29857 m0 *1 567.64,252.96
X$29857 73 5214 4989 5711 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29858 m0 *1 569.02,252.96
X$29858 73 4982 5320 5711 5798 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29863 m0 *1 582.36,252.96
X$29863 73 5883 5503 5602 5147 5619 73 5707 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $29866 m0 *1 585.58,252.96
X$29866 73 5497 4980 5510 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29867 m0 *1 586.96,252.96
X$29867 73 5708 73 57 4911 57 sky130_fd_sc_hd__buf_4
* cell instance $29870 m0 *1 595.24,252.96
X$29870 57 5617 5705 5691 5689 5707 5704 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $29880 m0 *1 615.94,252.96
X$29880 73 5611 5147 5606 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $29881 m0 *1 618.24,252.96
X$29881 73 5691 5700 5701 57 73 5699 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29885 m0 *1 631.12,252.96
X$29885 73 5697 5696 5698 5338 57 73 5693 57 sky130_fd_sc_hd__a31oi_1
* cell instance $29886 m0 *1 633.42,252.96
X$29886 73 5222 5150 5696 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29888 m0 *1 635.26,252.96
X$29888 73 5251 5609 5693 73 5695 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29899 r0 *1 2.3,252.96
X$29899 73 5565 57 73 5784 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29902 r0 *1 13.34,252.96
X$29902 73 3952 5610 6093 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29909 r0 *1 21.16,252.96
X$29909 73 5737 5241 5331 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29910 r0 *1 22.54,252.96
X$29910 73 4129 5738 5786 73 5702 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29911 r0 *1 24.38,252.96
X$29911 73 4129 5703 5504 5786 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29912 r0 *1 26.22,252.96
X$29912 73 4161 5702 5076 73 5791 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29913 r0 *1 28.06,252.96
X$29913 73 4284 5709 5790 73 5738 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29914 r0 *1 29.9,252.96
X$29914 57 4227 5790 4284 4738 5651 5706 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $29915 r0 *1 33.12,252.96
X$29915 73 5739 73 57 4284 57 sky130_fd_sc_hd__buf_4
* cell instance $29918 r0 *1 37.26,252.96
X$29918 73 4768 4424 5651 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $29920 r0 *1 39.56,252.96
X$29920 73 5331 73 57 4510 57 sky130_fd_sc_hd__buf_4
* cell instance $29927 r0 *1 46.46,252.96
X$29927 73 4192 5741 5567 73 5709 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29928 r0 *1 48.3,252.96
X$29928 73 5652 4292 5241 57 73 5741 57 sky130_fd_sc_hd__a21oi_1
* cell instance $29930 r0 *1 51.06,252.96
X$29930 57 4227 5713 4284 5569 5652 5899 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $29931 r0 *1 54.28,252.96
X$29931 57 4284 5742 4285 5797 5795 5713 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $29933 r0 *1 57.96,252.96
X$29933 73 4161 5742 6461 5629 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $29943 r0 *1 74.98,252.96
X$29943 73 4192 4767 5185 5800 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $29944 r0 *1 77.74,252.96
X$29944 73 5800 5743 5739 73 5254 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $29946 r0 *1 81.42,252.96
X$29946 57 4227 5802 5739 5569 4767 5654 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $29958 r0 *1 107.18,252.96
X$29958 73 4294 5715 5805 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $29962 r0 *1 117.76,252.96
X$29962 73 4366 5379 5911 5746 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $29973 r0 *1 138.92,252.96
X$29973 73 5016 5629 4366 5746 57 73 5810 57 sky130_fd_sc_hd__a31oi_1
* cell instance $29996 r0 *1 200.56,252.96
X$29996 73 4374 4712 5727 5815 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $30001 r0 *1 207.46,252.96
X$30001 73 4266 5816 5547 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30010 r0 *1 225.86,252.96
X$30010 73 4373 4438 5751 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30015 r0 *1 235.06,252.96
X$30015 73 5106 5752 4485 6031 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $30021 r0 *1 246.1,252.96
X$30021 73 5752 4712 5106 73 5753 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30026 r0 *1 257.6,252.96
X$30026 73 5391 4785 4374 57 73 5823 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30036 r0 *1 276.46,252.96
X$30036 73 5554 5753 5661 5734 4877 6038 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $30037 r0 *1 279.68,252.96
X$30037 73 4718 5297 5661 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30040 r0 *1 283.82,252.96
X$30040 73 5755 5201 4374 73 5734 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30042 r0 *1 286.58,252.96
X$30042 73 4614 4875 5755 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30048 r0 *1 294.4,252.96
X$30048 73 4779 5756 5132 5829 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $30051 r0 *1 298.54,252.96
X$30051 73 4540 73 57 4877 57 sky130_fd_sc_hd__buf_4
* cell instance $30074 r0 *1 362.48,252.96
X$30074 73 5662 5494 5760 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30075 r0 *1 363.86,252.96
X$30075 73 5315 5760 5732 5731 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30079 r0 *1 368.46,252.96
X$30079 73 5834 73 57 5761 57 sky130_fd_sc_hd__buf_4
* cell instance $30080 r0 *1 371.22,252.96
X$30080 73 5353 5304 5835 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30081 r0 *1 372.6,252.96
X$30081 73 5662 5304 5835 73 5730 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30085 r0 *1 377.2,252.96
X$30085 73 5591 5357 5763 5666 5973 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $30087 r0 *1 380.42,252.96
X$30087 73 5764 5943 5399 5208 5731 5763 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $30089 r0 *1 384.56,252.96
X$30089 73 5304 5308 5664 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30093 r0 *1 392.38,252.96
X$30093 73 5830 73 57 5665 57 sky130_fd_sc_hd__buf_4
* cell instance $30097 r0 *1 396.52,252.96
X$30097 73 5353 5664 5667 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30106 r0 *1 416.3,252.96
X$30106 73 5596 5545 5826 5770 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $30109 r0 *1 419.52,252.96
X$30109 57 5600 5669 5668 5825 5769 5666 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $30111 r0 *1 422.74,252.96
X$30111 73 5667 5493 5141 5768 57 5769 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $30114 r0 *1 426.42,252.96
X$30114 73 5281 5771 5936 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30115 r0 *1 427.8,252.96
X$30115 73 5670 5669 5824 5671 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30120 r0 *1 431.94,252.96
X$30120 73 5665 5491 5771 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30124 r0 *1 439.3,252.96
X$30124 73 5671 5819 5672 5928 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30125 r0 *1 441.14,252.96
X$30125 73 5818 5673 5722 5672 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30135 r0 *1 467.36,252.96
X$30135 73 5626 73 57 5764 57 sky130_fd_sc_hd__buf_4
* cell instance $30140 r0 *1 478.4,252.96
X$30140 73 3989 73 57 4669 57 sky130_fd_sc_hd__buf_4
* cell instance $30141 r0 *1 481.16,252.96
X$30141 57 5814 5872 5694 4669 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $30144 r0 *1 486.68,252.96
X$30144 73 5677 5718 73 5623 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $30145 r0 *1 489.9,252.96
X$30145 57 5719 5677 5812 5718 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $30156 r0 *1 522.1,252.96
X$30156 57 5777 5776 5143 5679 5680 5497 5411 73 73 57 sky130_fd_sc_hd__a222oi_1
* cell instance $30157 r0 *1 525.78,252.96
X$30157 73 5777 73 57 5686 57 sky130_fd_sc_hd__buf_4
* cell instance $30158 r0 *1 528.54,252.96
X$30158 73 5143 4982 5679 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30160 r0 *1 530.38,252.96
X$30160 73 5144 5681 5808 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30162 r0 *1 531.76,252.96
X$30162 73 4982 5681 5792 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30165 r0 *1 535.44,252.96
X$30165 73 5907 4980 5683 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30166 r0 *1 536.82,252.96
X$30166 73 5683 73 57 5211 57 sky130_fd_sc_hd__buf_4
* cell instance $30170 r0 *1 541.42,252.96
X$30170 73 5144 5806 5683 57 73 5522 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30178 r0 *1 559.36,252.96
X$30178 73 5687 5417 5688 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30179 r0 *1 560.74,252.96
X$30179 73 5688 73 57 5712 57 sky130_fd_sc_hd__buf_4
* cell instance $30184 r0 *1 569.48,252.96
X$30184 57 5780 5779 5798 5799 5710 5796 73 73 57 sky130_fd_sc_hd__a311oi_2
* cell instance $30192 r0 *1 593.86,252.96
X$30192 73 5507 4917 5686 57 73 6082 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30195 r0 *1 599.84,252.96
X$30195 73 5690 5510 5251 73 5779 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30197 r0 *1 603.52,252.96
X$30197 73 4901 5497 5792 5793 57 5788 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $30200 r0 *1 607.66,252.96
X$30200 73 4905 5417 5692 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30201 r0 *1 609.04,252.96
X$30201 73 5692 73 57 5690 57 sky130_fd_sc_hd__buf_4
* cell instance $30205 r0 *1 617.32,252.96
X$30205 73 5070 5788 5789 5781 5700 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $30212 r0 *1 631.12,252.96
X$30212 73 5781 5229 5697 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30284 m0 *1 37.26,258.4
X$30284 73 5740 73 57 4412 57 sky130_fd_sc_hd__buf_4
* cell instance $30288 m0 *1 47.84,258.4
X$30288 73 5838 73 57 4767 57 sky130_fd_sc_hd__buf_4
* cell instance $30289 m0 *1 50.6,258.4
X$30289 73 4422 5241 5652 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30291 m0 *1 52.44,258.4
X$30291 73 4227 5794 5652 5743 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $30304 m0 *1 82.34,258.4
X$30304 73 4285 5802 5801 5744 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30309 m0 *1 92.92,258.4
X$30309 73 4165 5714 5744 57 73 5803 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30315 m0 *1 107.18,258.4
X$30315 73 5805 5910 4366 4470 57 73 5918 57 sky130_fd_sc_hd__a31oi_1
* cell instance $30324 m0 *1 125.12,258.4
X$30324 73 4290 5439 5807 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30334 m0 *1 145.82,258.4
X$30334 73 5809 73 57 5677 57 sky130_fd_sc_hd__buf_4
* cell instance $30349 m0 *1 186.3,258.4
X$30349 73 4616 4374 4372 4438 73 57 5725 57 sky130_fd_sc_hd__o31ai_1
* cell instance $30356 m0 *1 200.1,258.4
X$30356 73 5747 5388 4299 73 5726 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30358 m0 *1 202.4,258.4
X$30358 73 5964 5748 4618 4616 4374 5446 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $30360 m0 *1 207.46,258.4
X$30360 73 6030 4338 4540 5749 73 5816 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $30361 m0 *1 209.76,258.4
X$30361 73 4374 4873 5582 5749 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30362 m0 *1 211.6,258.4
X$30362 73 4710 5106 5388 73 6207 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30363 m0 *1 213.44,258.4
X$30363 73 4480 5106 5643 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30366 m0 *1 217.12,258.4
X$30366 73 4266 4138 5057 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30368 m0 *1 218.96,258.4
X$30368 73 5759 4374 5750 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30369 m0 *1 220.34,258.4
X$30369 73 5579 5479 5750 57 73 6127 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30374 m0 *1 226.32,258.4
X$30374 73 5751 73 57 5821 57 sky130_fd_sc_hd__buf_4
* cell instance $30382 m0 *1 248.86,258.4
X$30382 73 5392 5822 5754 73 5941 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30388 m0 *1 263.12,258.4
X$30388 73 4480 4374 5945 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30389 m0 *1 264.5,258.4
X$30389 73 5945 73 57 4852 57 sky130_fd_sc_hd__buf_4
* cell instance $30394 m0 *1 274.16,258.4
X$30394 73 5060 4374 5754 5460 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30400 m0 *1 284.28,258.4
X$30400 73 4875 4372 5757 4715 4374 73 5649 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $30401 m0 *1 287.5,258.4
X$30401 73 4374 5755 5756 5758 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $30403 m0 *1 291.18,258.4
X$30403 73 5758 4374 5827 57 73 5487 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30404 m0 *1 293.02,258.4
X$30404 73 5201 5060 4782 57 73 5827 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30405 m0 *1 294.86,258.4
X$30405 73 5759 4875 5757 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30409 m0 *1 304.06,258.4
X$30409 73 4849 5757 4374 73 5953 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30429 m0 *1 358.34,258.4
X$30429 73 5353 5304 5308 5732 5948 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $30436 m0 *1 373.98,258.4
X$30436 57 5833 5492 5313 5591 5762 5204 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $30437 m0 *1 377.2,258.4
X$30437 57 5765 5307 5942 5833 5832 5591 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $30438 m0 *1 380.42,258.4
X$30438 73 5304 5594 5831 57 73 5305 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30447 m0 *1 400.66,258.4
X$30447 73 5308 6137 5450 73 5937 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30449 m0 *1 402.96,258.4
X$30449 73 5766 5765 5828 73 5767 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30452 m0 *1 408.94,258.4
X$30452 73 5666 5767 5922 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30454 m0 *1 412.16,258.4
X$30454 73 5308 5306 5864 5826 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $30460 m0 *1 419.52,258.4
X$30460 73 5399 6134 5825 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30464 m0 *1 426.88,258.4
X$30464 73 5673 5931 5932 5770 5772 5824 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $30467 m0 *1 431.48,258.4
X$30467 73 4746 73 57 5766 57 sky130_fd_sc_hd__buf_4
* cell instance $30468 m0 *1 434.24,258.4
X$30468 57 5141 6021 5773 5768 5493 5405 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $30470 m0 *1 439.3,258.4
X$30470 73 5670 5673 5774 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30471 m0 *1 440.68,258.4
X$30471 73 5774 5867 6124 5820 5764 73 5819 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $30473 m0 *1 444.36,258.4
X$30473 73 5773 5308 5491 73 5927 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30478 m0 *1 454.94,258.4
X$30478 73 5459 5817 5540 5281 5917 73 5721 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $30482 m0 *1 463.22,258.4
X$30482 73 5919 73 57 5274 57 sky130_fd_sc_hd__buf_4
* cell instance $30484 m0 *1 466.44,258.4
X$30484 57 5775 73 73 57 sky130_fd_sc_hd__clkbuf_8
* cell instance $30490 m0 *1 481.62,258.4
X$30490 57 6007 5775 5814 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $30492 m0 *1 489.44,258.4
X$30492 73 5875 5719 5912 73 5813 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30493 m0 *1 491.28,258.4
X$30493 57 5812 5210 5813 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $30502 m0 *1 518.88,258.4
X$30502 73 5679 5811 4980 73 5909 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30504 m0 *1 521.18,258.4
X$30504 73 5776 73 57 5678 57 sky130_fd_sc_hd__buf_4
* cell instance $30506 m0 *1 524.4,258.4
X$30506 73 4986 5144 5811 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30512 m0 *1 536.36,258.4
X$30512 73 5907 73 57 4986 57 sky130_fd_sc_hd__buf_4
* cell instance $30516 m0 *1 548.32,258.4
X$30516 73 4982 5906 5712 57 73 5804 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30522 m0 *1 556.14,258.4
X$30522 73 5525 5147 5778 73 5260 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30524 m0 *1 558.9,258.4
X$30524 73 5214 5525 4905 57 73 5778 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30530 m0 *1 577.3,258.4
X$30530 57 15537 5884 5147 5321 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $30549 m0 *1 632.5,258.4
X$30549 73 5150 5500 5611 5782 57 73 5891 57 sky130_fd_sc_hd__a31oi_1
* cell instance $30559 m0 *1 653.66,258.4
X$30559 73 5785 57 73 5528 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $30565 r0 *1 3.68,258.4
X$30565 73 5736 57 73 5890 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $30574 r0 *1 21.16,258.4
X$30574 73 4538 4192 4424 5893 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30577 r0 *1 25.76,258.4
X$30577 73 5471 73 57 5241 57 sky130_fd_sc_hd__buf_4
* cell instance $30578 r0 *1 28.52,258.4
X$30578 57 4227 5703 5739 4738 5794 5837 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $30579 r0 *1 31.74,258.4
X$30579 73 5791 73 57 5895 57 sky130_fd_sc_hd__buf_4
* cell instance $30581 r0 *1 34.96,258.4
X$30581 73 5838 5839 4227 5837 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $30582 r0 *1 37.72,258.4
X$30582 57 5188 5740 4602 4600 5471 5183 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $30590 r0 *1 49.22,258.4
X$30590 73 5840 5241 5838 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30593 r0 *1 52.9,258.4
X$30593 73 5840 73 57 4768 57 sky130_fd_sc_hd__buf_4
* cell instance $30597 r0 *1 62.1,258.4
X$30597 57 15658 5840 4290 4223 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $30602 r0 *1 71.76,258.4
X$30602 73 5841 5745 5839 57 73 4954 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30604 r0 *1 74.52,258.4
X$30604 73 5840 73 57 5121 57 sky130_fd_sc_hd__buf_4
* cell instance $30605 r0 *1 77.28,258.4
X$30605 73 4768 5841 5516 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $30611 r0 *1 95.22,258.4
X$30611 73 4218 5895 5843 73 5845 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30613 r0 *1 97.06,258.4
X$30613 73 5844 5803 4218 73 5843 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30622 r0 *1 120.06,258.4
X$30622 57 5913 4504 5846 4705 4363 5915 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $30623 r0 *1 123.28,258.4
X$30623 57 4609 4504 5847 4366 5521 5915 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $30632 r0 *1 143.06,258.4
X$30632 73 4259 5920 5918 5848 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30633 r0 *1 144.9,258.4
X$30633 73 5634 5921 5848 5443 4675 5924 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $30643 r0 *1 164.22,258.4
X$30643 57 5925 6337 6048 4061 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $30644 r0 *1 172.5,258.4
X$30644 57 5929 5963 5810 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $30651 r0 *1 188.14,258.4
X$30651 73 5193 4299 5752 57 73 5930 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30654 r0 *1 192.74,258.4
X$30654 73 4480 5197 6024 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30658 r0 *1 200.1,258.4
X$30658 73 5933 4516 5579 57 73 5748 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30659 r0 *1 201.94,258.4
X$30659 57 5935 5934 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $30667 r0 *1 224.94,258.4
X$30667 73 4138 4266 5969 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $30671 r0 *1 230.46,258.4
X$30671 73 4480 5579 5854 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30674 r0 *1 235.52,258.4
X$30674 73 4717 5108 5850 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30678 r0 *1 241.96,258.4
X$30678 73 4338 4266 5940 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $30680 r0 *1 247.94,258.4
X$30680 73 4299 5850 5851 57 73 5852 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30681 r0 *1 249.78,258.4
X$30681 73 5852 4777 5941 57 73 6135 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30682 r0 *1 251.62,258.4
X$30682 73 5756 5849 4374 73 5851 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30683 r0 *1 253.46,258.4
X$30683 73 4879 73 57 5849 57 sky130_fd_sc_hd__buf_4
* cell instance $30690 r0 *1 265.88,258.4
X$30690 73 5106 4879 4849 5946 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $30692 r0 *1 269.56,258.4
X$30692 73 5297 5947 4877 5946 57 5110 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $30693 r0 *1 272.32,258.4
X$30693 73 4374 5756 5757 5853 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $30696 r0 *1 276.46,258.4
X$30696 73 4877 5854 5460 5949 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30700 r0 *1 284.74,258.4
X$30700 73 4879 5133 5855 73 6501 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30703 r0 *1 287.5,258.4
X$30703 73 5759 4782 5201 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30710 r0 *1 294.86,258.4
X$30710 73 4374 4966 5461 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30712 r0 *1 298.08,258.4
X$30712 73 5855 4873 4878 5856 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30715 r0 *1 302.68,258.4
X$30715 73 5856 5953 5194 5057 57 73 5952 57 sky130_fd_sc_hd__a31oi_1
* cell instance $30717 r0 *1 308.66,258.4
X$30717 57 5951 6121 5283 5488 5553 73 73 57 sky130_fd_sc_hd__a31o_1
* cell instance $30739 r0 *1 358.34,258.4
X$30739 73 5762 5304 5732 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30740 r0 *1 359.72,258.4
X$30740 73 5440 5308 5399 5948 5859 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $30745 r0 *1 373.52,258.4
X$30745 73 5662 5315 5831 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30750 r0 *1 383.18,258.4
X$30750 73 5304 5459 5861 57 73 5944 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30753 r0 *1 387.32,258.4
X$30753 73 5830 5861 5303 57 73 5942 57 sky130_fd_sc_hd__a21o_1
* cell instance $30757 r0 *1 395.6,258.4
X$30757 73 5281 5665 5861 57 73 5939 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30760 r0 *1 399.74,258.4
X$30760 73 5862 73 57 5863 57 sky130_fd_sc_hd__buf_4
* cell instance $30762 r0 *1 402.96,258.4
X$30762 57 5600 5828 5766 5863 6217 5937 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $30767 r0 *1 418.14,258.4
X$30767 73 5766 73 57 5399 57 sky130_fd_sc_hd__buf_4
* cell instance $30771 r0 *1 425.04,258.4
X$30771 73 5764 5863 5936 5141 73 57 5932 57 sky130_fd_sc_hd__o31ai_1
* cell instance $30773 r0 *1 428.26,258.4
X$30773 73 5457 6126 5865 57 73 5931 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30776 r0 *1 431.02,258.4
X$30776 73 5764 5866 5405 57 73 5865 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30780 r0 *1 437.92,258.4
X$30780 57 5926 5775 5928 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $30786 r0 *1 452.18,258.4
X$30786 73 5868 5923 5666 5670 57 73 5869 57 sky130_fd_sc_hd__a31oi_1
* cell instance $30787 r0 *1 454.48,258.4
X$30787 73 5869 6120 5870 5922 5670 5919 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $30792 r0 *1 466.44,258.4
X$30792 57 4970 5775 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $30796 r0 *1 480.24,258.4
X$30796 73 5871 73 57 5872 57 sky130_fd_sc_hd__buf_4
* cell instance $30798 r0 *1 483.46,258.4
X$30798 73 4669 5916 5873 73 5914 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $30802 r0 *1 487.14,258.4
X$30802 73 4669 73 57 5875 57 sky130_fd_sc_hd__buf_4
* cell instance $30803 r0 *1 489.9,258.4
X$30803 73 5719 5874 6008 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $30804 r0 *1 493.12,258.4
X$30804 73 5875 5787 5912 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30805 r0 *1 494.5,258.4
X$30805 73 5876 73 57 5874 57 sky130_fd_sc_hd__buf_4
* cell instance $30816 r0 *1 516.58,258.4
X$30816 73 4899 5909 5601 5905 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30822 r0 *1 529,258.4
X$30822 73 4921 5878 5808 5908 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $30827 r0 *1 536.82,258.4
X$30827 73 4982 73 57 5500 57 sky130_fd_sc_hd__buf_4
* cell instance $30831 r0 *1 542.8,258.4
X$30831 73 4921 73 57 5900 57 sky130_fd_sc_hd__buf_4
* cell instance $30836 r0 *1 555.68,258.4
X$30836 73 4983 73 57 5698 57 sky130_fd_sc_hd__buf_4
* cell instance $30841 r0 *1 561.66,258.4
X$30841 73 5712 5236 4982 5166 57 73 5904 57 sky130_fd_sc_hd__a31oi_1
* cell instance $30842 r0 *1 563.96,258.4
X$30842 73 5712 73 57 5903 57 sky130_fd_sc_hd__buf_4
* cell instance $30848 r0 *1 573.16,258.4
X$30848 73 5879 5902 5901 5339 57 73 5880 57 sky130_fd_sc_hd__a31oi_1
* cell instance $30849 r0 *1 575.46,258.4
X$30849 57 5882 5879 5260 5884 4980 5900 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $30850 r0 *1 578.68,258.4
X$30850 73 5881 5900 5898 57 73 6359 57 sky130_fd_sc_hd__a21oi_1
* cell instance $30852 r0 *1 580.98,258.4
X$30852 57 5896 5882 4982 5321 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $30854 r0 *1 585.58,258.4
X$30854 73 5884 4996 5897 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $30863 r0 *1 602.6,258.4
X$30863 73 5510 73 57 5894 57 sky130_fd_sc_hd__buf_4
* cell instance $30865 r0 *1 609.04,258.4
X$30865 57 5690 6085 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $30876 r0 *1 633.88,258.4
X$30876 73 5892 5891 5888 5417 5070 73 5889 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $30877 r0 *1 637.1,258.4
X$30877 73 5695 5070 5886 5889 57 5887 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $30884 r0 *1 653.2,258.4
X$30884 73 5877 57 73 5885 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $30935 m0 *1 4.14,263.84
X$30935 73 5836 57 73 5993 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $30936 m0 *1 7.82,263.84
X$30936 57 5836 5994 5958 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $30939 m0 *1 17.94,263.84
X$30939 73 6643 4097 73 5958 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $30940 m0 *1 21.16,263.84
X$30940 73 5737 73 57 4538 57 sky130_fd_sc_hd__buf_4
* cell instance $30942 m0 *1 24.38,263.84
X$30942 57 15480 5183 5959 4227 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $30951 m0 *1 50.6,263.84
X$30951 73 4538 5241 4467 4227 5899 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $30952 m0 *1 53.36,263.84
X$30952 73 5959 73 57 4422 57 sky130_fd_sc_hd__buf_4
* cell instance $30959 m0 *1 63.02,263.84
X$30959 73 6002 73 57 4600 57 sky130_fd_sc_hd__buf_4
* cell instance $30962 m0 *1 69.92,263.84
X$30962 73 5840 4294 4467 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30971 m0 *1 87.86,263.84
X$30971 73 4422 4424 5961 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $30974 m0 *1 93.84,263.84
X$30974 73 5183 5471 4675 5842 6010 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $30978 m0 *1 99.82,263.84
X$30978 73 5962 73 57 4363 57 sky130_fd_sc_hd__buf_4
* cell instance $30979 m0 *1 102.58,263.84
X$30979 73 4424 5962 4293 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $30982 m0 *1 106.26,263.84
X$30982 73 5378 4705 4285 6152 4704 73 6013 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $30983 m0 *1 109.48,263.84
X$30983 73 6013 6017 6014 4165 57 73 5911 57 sky130_fd_sc_hd__and4_1
* cell instance $30989 m0 *1 122.82,263.84
X$30989 57 15521 5846 6018 5439 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $30992 m0 *1 128.8,263.84
X$30992 73 4363 5439 5915 5807 5842 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $30995 m0 *1 134.32,263.84
X$30995 73 5121 5915 4510 73 6020 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31002 m0 *1 145.82,263.84
X$31002 73 6113 6023 4165 73 5921 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31018 m0 *1 192.74,263.84
X$31018 73 6024 73 57 5752 57 sky130_fd_sc_hd__buf_4
* cell instance $31022 m0 *1 197.34,263.84
X$31022 73 4717 5579 5933 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31024 m0 *1 199.64,263.84
X$31024 73 4373 4873 4781 57 73 6026 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31026 m0 *1 201.94,263.84
X$31026 57 5271 5964 6026 5815 5965 4372 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $31027 m0 *1 205.62,263.84
X$31027 73 5966 5291 6030 73 5729 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31038 m0 *1 235.06,263.84
X$31038 73 6031 5853 4540 4966 6050 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $31041 m0 *1 245.18,263.84
X$31041 73 5849 5581 5855 73 5938 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31046 m0 *1 255.76,263.84
X$31046 73 5581 73 57 6035 57 sky130_fd_sc_hd__buf_4
* cell instance $31052 m0 *1 272.32,263.84
X$31052 73 5967 5199 6036 5584 73 5968 57 57 sky130_fd_sc_hd__nand4b_1
* cell instance $31053 m0 *1 275.54,263.84
X$31053 73 4785 73 57 5947 57 sky130_fd_sc_hd__buf_4
* cell instance $31055 m0 *1 278.76,263.84
X$31055 73 4374 4783 5954 57 73 6039 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31058 m0 *1 286.12,263.84
X$31058 73 4618 4787 4378 73 6037 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31062 m0 *1 293.02,263.84
X$31062 73 5759 4875 5954 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31064 m0 *1 298.08,263.84
X$31064 73 5202 6035 5461 73 5955 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31082 m0 *1 339.94,263.84
X$31082 57 5950 6033 5972 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $31086 m0 *1 353.74,263.84
X$31086 73 5591 6508 6032 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31088 m0 *1 355.58,263.84
X$31088 73 6032 5857 5673 73 5858 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31090 m0 *1 358.34,263.84
X$31090 73 5973 5858 5670 6144 57 73 5972 57 sky130_fd_sc_hd__a31oi_1
* cell instance $31093 m0 *1 361.56,263.84
X$31093 73 5762 5308 5974 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31094 m0 *1 362.94,263.84
X$31094 73 5974 73 57 5204 57 sky130_fd_sc_hd__buf_4
* cell instance $31097 m0 *1 368.46,263.84
X$31097 73 5764 6028 6025 5857 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $31099 m0 *1 371.22,263.84
X$31099 73 5399 6029 5942 57 73 6028 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31102 m0 *1 380.42,263.84
X$31102 73 5831 5594 5860 5304 5399 73 5943 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $31105 m0 *1 385.94,263.84
X$31105 73 5402 5664 5862 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31117 m0 *1 410.78,263.84
X$31117 73 5281 5352 5630 57 73 5860 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31126 m0 *1 438.84,263.84
X$31126 73 6021 5772 6125 57 73 5820 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31129 m0 *1 442.06,263.84
X$31129 73 5281 5442 6019 5599 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $31134 m0 *1 455.4,263.84
X$31134 73 5281 5406 6016 5917 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $31144 m0 *1 473.34,263.84
X$31144 73 579 6012 5978 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $31145 m0 *1 476.56,263.84
X$31145 73 5978 5979 73 5916 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $31146 m0 *1 479.78,263.84
X$31146 57 5871 5978 5979 6007 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $31149 m0 *1 490.36,263.84
X$31149 57 5876 5210 5981 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $31154 m0 *1 501.4,263.84
X$31154 73 6007 73 57 5983 57 sky130_fd_sc_hd__buf_4
* cell instance $31160 m0 *1 514.74,263.84
X$31160 57 5983 5984 6006 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $31162 m0 *1 522.56,263.84
X$31162 73 4980 6004 5500 57 73 5776 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31167 m0 *1 530.84,263.84
X$31167 73 6003 5983 73 2941 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $31176 m0 *1 558.44,263.84
X$31176 73 6001 73 57 5799 57 sky130_fd_sc_hd__buf_4
* cell instance $31181 m0 *1 571.32,263.84
X$31181 73 5799 5988 6000 5901 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $31200 m0 *1 616.4,263.84
X$31200 73 5070 5323 5613 5991 5995 5789 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $31201 m0 *1 619.62,263.84
X$31201 57 5699 5990 6186 5887 73 73 57 sky130_fd_sc_hd__nor3_2
* cell instance $31211 m0 *1 644,263.84
X$31211 73 5992 57 73 5787 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31220 r0 *1 14.26,263.84
X$31220 73 3952 6093 6092 73 57 5957 57 sky130_fd_sc_hd__o21ai_1
* cell instance $31223 r0 *1 16.56,263.84
X$31223 73 5957 73 57 6042 57 sky130_fd_sc_hd__inv_1
* cell instance $31224 r0 *1 17.94,263.84
X$31224 73 5957 73 57 5959 57 sky130_fd_sc_hd__buf_4
* cell instance $31237 r0 *1 52.44,263.84
X$31237 73 4536 5377 5244 57 73 5910 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31239 r0 *1 55.2,263.84
X$31239 73 5377 4424 5569 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31241 r0 *1 58.42,263.84
X$31241 73 5160 4227 6002 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31246 r0 *1 68.54,263.84
X$31246 73 5960 73 57 5797 57 sky130_fd_sc_hd__buf_4
* cell instance $31251 r0 *1 74.52,263.84
X$31251 73 5471 73 57 4294 57 sky130_fd_sc_hd__buf_4
* cell instance $31256 r0 *1 86.94,263.84
X$31256 73 5841 5961 4922 57 73 5960 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31257 r0 *1 88.78,263.84
X$31257 73 5961 73 57 4364 57 sky130_fd_sc_hd__buf_4
* cell instance $31259 r0 *1 95.22,263.84
X$31259 73 6192 6010 4259 4285 6011 73 5844 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $31264 r0 *1 103.04,263.84
X$31264 73 4660 4293 4218 4227 57 6106 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $31278 r0 *1 139.84,263.84
X$31278 73 4129 6561 5920 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31290 r0 *1 165.14,263.84
X$31290 57 6015 5963 5924 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $31302 r0 *1 201.02,263.84
X$31302 57 57 5197 5291 4374 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $31306 r0 *1 206.08,263.84
X$31306 73 4711 4686 5966 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31312 r0 *1 218.96,263.84
X$31312 73 6128 5964 6127 4380 6130 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $31334 r0 *1 272.78,263.84
X$31334 73 4966 6135 6051 73 6036 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31335 r0 *1 274.62,263.84
X$31335 73 5031 6218 4966 5969 57 73 6051 57 sky130_fd_sc_hd__a31oi_1
* cell instance $31336 r0 *1 276.92,263.84
X$31336 73 6038 6052 5970 73 5967 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31337 r0 *1 278.76,263.84
X$31337 73 6039 5949 5971 6053 5970 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $31339 r0 *1 282.44,263.84
X$31339 73 4299 6054 5971 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31340 r0 *1 283.82,263.84
X$31340 57 4618 6054 4876 4948 4374 4715 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $31346 r0 *1 292.56,263.84
X$31346 57 5968 6055 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $31351 r0 *1 310.04,263.84
X$31351 73 6141 5952 6230 5951 57 6145 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $31362 r0 *1 332.12,263.84
X$31362 73 6056 73 57 6048 57 sky130_fd_sc_hd__buf_4
* cell instance $31363 r0 *1 334.88,263.84
X$31363 73 5950 6034 73 6056 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $31364 r0 *1 338.1,263.84
X$31364 57 4970 6033 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $31372 r0 *1 361.1,263.84
X$31372 73 6348 73 57 5304 57 sky130_fd_sc_hd__buf_4
* cell instance $31374 r0 *1 367.54,263.84
X$31374 73 5360 5303 6027 6029 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $31386 r0 *1 393.3,263.84
X$31386 73 5975 5664 5635 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31390 r0 *1 396.06,263.84
X$31390 73 5664 73 57 6064 57 sky130_fd_sc_hd__buf_4
* cell instance $31392 r0 *1 400.66,263.84
X$31392 73 5306 5976 5303 57 73 6137 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31399 r0 *1 415.38,263.84
X$31399 73 5975 5308 5630 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31413 r0 *1 446.66,263.84
X$31413 73 5676 4746 6073 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31414 r0 *1 448.04,263.84
X$31414 73 6073 5977 5674 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31422 r0 *1 460.46,263.84
X$31422 73 5315 5353 5494 5406 57 6494 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $31426 r0 *1 469.66,263.84
X$31426 57 3270 5775 5818 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $31428 r0 *1 477.02,263.84
X$31428 73 5980 73 57 5670 57 sky130_fd_sc_hd__buf_4
* cell instance $31433 r0 *1 487.6,263.84
X$31433 73 6009 5875 4268 57 73 5980 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31434 r0 *1 489.44,263.84
X$31434 73 5875 6118 6009 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31436 r0 *1 491.28,263.84
X$31436 57 5981 6008 5982 5875 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $31446 r0 *1 514.28,263.84
X$31446 57 6075 6114 5983 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $31448 r0 *1 521.18,263.84
X$31448 57 5984 4323 6110 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $31455 r0 *1 535.44,263.84
X$31455 73 5065 4980 5985 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31460 r0 *1 543.72,263.84
X$31460 73 5143 5144 5906 57 73 6080 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31462 r0 *1 546.02,263.84
X$31462 73 5985 73 57 5987 57 sky130_fd_sc_hd__buf_4
* cell instance $31468 r0 *1 558.9,263.84
X$31468 73 6077 4899 6001 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31470 r0 *1 561.2,263.84
X$31470 73 6886 5799 5986 57 73 6103 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31476 r0 *1 569.48,263.84
X$31476 73 4982 5987 5903 6000 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $31481 r0 *1 584.2,263.84
X$31481 73 5321 5999 5512 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31484 r0 *1 589.26,263.84
X$31484 73 5426 5503 6101 5500 5708 73 6100 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $31485 r0 *1 592.48,263.84
X$31485 57 5881 5989 5150 6100 5997 6082 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $31488 r0 *1 596.62,263.84
X$31488 73 5989 73 57 6096 57 sky130_fd_sc_hd__buf_4
* cell instance $31491 r0 *1 600.76,263.84
X$31491 73 5426 73 57 5996 57 sky130_fd_sc_hd__buf_4
* cell instance $31492 r0 *1 603.52,263.84
X$31492 73 5987 5996 6097 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31494 r0 *1 605.36,263.84
X$31494 73 5605 5987 6083 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31520 m0 *1 11.96,269.28
X$31520 57 15472 4766 6042 6041 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $31525 m0 *1 17.94,269.28
X$31525 73 6043 73 57 5737 57 sky130_fd_sc_hd__buf_4
* cell instance $31526 m0 *1 20.7,269.28
X$31526 73 4766 5241 6370 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31530 m0 *1 27.14,269.28
X$31530 73 6094 73 57 4368 57 sky130_fd_sc_hd__buf_4
* cell instance $31532 m0 *1 30.36,269.28
X$31532 73 6041 73 57 5377 57 sky130_fd_sc_hd__buf_4
* cell instance $31535 m0 *1 35.88,269.28
X$31535 73 5377 5241 4738 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31539 m0 *1 42.32,269.28
X$31539 73 6099 73 57 4602 57 sky130_fd_sc_hd__buf_4
* cell instance $31543 m0 *1 46,269.28
X$31543 73 5160 5244 5038 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31545 m0 *1 49.22,269.28
X$31545 73 4424 5160 4227 57 73 6044 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31551 m0 *1 58.42,269.28
X$31551 73 6041 73 57 6045 57 sky130_fd_sc_hd__inv_1
* cell instance $31552 m0 *1 59.8,269.28
X$31552 73 6045 73 57 5160 57 sky130_fd_sc_hd__buf_4
* cell instance $31553 m0 *1 62.56,269.28
X$31553 73 6042 73 57 4290 57 sky130_fd_sc_hd__buf_4
* cell instance $31562 m0 *1 81.42,269.28
X$31562 73 4290 5841 5569 73 6102 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31566 m0 *1 87.4,269.28
X$31566 73 4294 4675 5121 73 6104 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31569 m0 *1 91.54,269.28
X$31569 73 6045 73 57 4469 57 sky130_fd_sc_hd__buf_4
* cell instance $31576 m0 *1 103.96,269.28
X$31576 73 6106 5121 4957 57 73 6107 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31584 m0 *1 115.92,269.28
X$31584 73 5841 73 57 5439 57 sky130_fd_sc_hd__buf_4
* cell instance $31585 m0 *1 118.68,269.28
X$31585 73 6047 6195 5913 4705 4285 73 6011 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $31586 m0 *1 121.9,269.28
X$31586 73 4290 5439 5915 6108 6047 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $31589 m0 *1 124.66,269.28
X$31589 73 4223 4290 6108 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31590 m0 *1 126.04,269.28
X$31590 73 4366 4660 4957 6018 4469 6112 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $31593 m0 *1 134.78,269.28
X$31593 73 5121 5439 4424 5807 6111 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $31599 m0 *1 145.36,269.28
X$31599 73 4287 6197 6113 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31605 m0 *1 155.94,269.28
X$31605 73 6116 73 57 4228 57 sky130_fd_sc_hd__buf_4
* cell instance $31618 m0 *1 188.6,269.28
X$31618 73 4966 5930 6123 6122 4589 6121 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $31630 m0 *1 217.12,269.28
X$31630 57 6128 4589 4876 4622 6129 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $31636 m0 *1 228.16,269.28
X$31636 57 6131 4966 6310 6211 6050 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $31640 m0 *1 233.68,269.28
X$31640 73 4483 73 57 6132 57 sky130_fd_sc_hd__buf_4
* cell instance $31675 m0 *1 309.58,269.28
X$31675 73 6142 6589 4931 57 73 6141 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31687 m0 *1 338.1,269.28
X$31687 57 6033 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $31694 m0 *1 356.04,269.28
X$31694 73 5591 6057 6224 73 6143 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31695 m0 *1 357.88,269.28
X$31695 73 6143 6058 5670 6059 57 6144 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $31704 m0 *1 371.22,269.28
X$31704 73 6139 5141 6140 57 73 6057 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31707 m0 *1 380.42,269.28
X$31707 73 6060 73 57 6059 57 sky130_fd_sc_hd__buf_4
* cell instance $31708 m0 *1 383.18,269.28
X$31708 57 5141 6139 5402 6138 5768 6061 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $31709 m0 *1 386.4,269.28
X$31709 73 5975 6062 6138 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31714 m0 *1 390.54,269.28
X$31714 73 6063 5450 6324 5666 57 6060 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $31720 m0 *1 396.52,269.28
X$31720 57 6063 6136 5313 5766 5281 6061 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $31726 m0 *1 412.16,269.28
X$31726 73 6066 5281 5864 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31732 m0 *1 419.06,269.28
X$31732 73 6069 5494 6067 57 73 6134 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31733 m0 *1 420.9,269.28
X$31733 73 5281 6062 6068 57 73 6133 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31736 m0 *1 422.74,269.28
X$31736 73 5494 6062 5442 57 73 6069 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31738 m0 *1 425.04,269.28
X$31738 73 5975 73 57 5400 57 sky130_fd_sc_hd__buf_4
* cell instance $31741 m0 *1 430.56,269.28
X$31741 73 5494 6068 6070 6126 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $31745 m0 *1 438.38,269.28
X$31745 73 5494 6027 6070 57 73 6072 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31746 m0 *1 440.22,269.28
X$31746 73 6072 5976 6353 57 73 6125 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31750 m0 *1 444.82,269.28
X$31750 73 6069 5494 5927 57 73 6502 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31757 m0 *1 456.78,269.28
X$31757 73 5353 5308 6071 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31769 m0 *1 481.16,269.28
X$31769 57 6119 6311 5914 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $31770 m0 *1 488.52,269.28
X$31770 73 6117 3270 73 6118 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $31771 m0 *1 491.74,269.28
X$31771 73 5875 6088 5873 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31777 m0 *1 500.48,269.28
X$31777 73 6087 57 73 5982 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31784 m0 *1 512.9,269.28
X$31784 73 4917 6198 6115 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31786 m0 *1 515.2,269.28
X$31786 73 5984 73 57 6114 57 sky130_fd_sc_hd__buf_4
* cell instance $31787 m0 *1 517.96,269.28
X$31787 73 6075 6074 5533 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31788 m0 *1 519.34,269.28
X$31788 73 6006 73 57 6109 57 sky130_fd_sc_hd__buf_4
* cell instance $31789 m0 *1 522.1,269.28
X$31789 73 5147 73 57 6076 57 sky130_fd_sc_hd__buf_4
* cell instance $31793 m0 *1 528.08,269.28
X$31793 73 6075 73 57 6077 57 sky130_fd_sc_hd__buf_4
* cell instance $31797 m0 *1 534.52,269.28
X$31797 73 6078 73 57 5065 57 sky130_fd_sc_hd__buf_4
* cell instance $31803 m0 *1 551.08,269.28
X$31803 57 5708 6105 5143 5145 6080 4918 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $31817 m0 *1 582.36,269.28
X$31817 73 6190 5090 6081 5999 5437 73 5997 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $31820 m0 *1 585.58,269.28
X$31820 73 5999 5319 6361 6081 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $31823 m0 *1 589.72,269.28
X$31823 73 5500 5605 5998 57 73 6101 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31827 m0 *1 594.78,269.28
X$31827 73 5500 5509 5319 6084 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $31828 m0 *1 597.08,269.28
X$31828 73 6096 5705 6289 6098 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $31832 m0 *1 605.36,269.28
X$31832 73 5999 6083 6084 73 6374 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31834 m0 *1 607.66,269.28
X$31834 73 5999 6085 5894 6095 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $31838 m0 *1 612.26,269.28
X$31838 73 6077 73 57 5781 57 sky130_fd_sc_hd__buf_4
* cell instance $31844 m0 *1 624.22,269.28
X$31844 73 6086 73 57 5256 57 sky130_fd_sc_hd__buf_4
* cell instance $31845 m0 *1 626.98,269.28
X$31845 73 6085 5150 6086 57 73 6091 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31846 m0 *1 628.82,269.28
X$31846 73 5991 4906 6086 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31849 m0 *1 634.34,269.28
X$31849 73 5500 6091 6089 5502 6090 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $31855 m0 *1 642.16,269.28
X$31855 73 6182 57 73 6088 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31861 r0 *1 4.14,269.28
X$31861 73 5073 57 73 6232 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31862 r0 *1 7.82,269.28
X$31862 73 6040 57 73 6641 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31865 r0 *1 12.88,269.28
X$31865 73 3952 6147 4806 57 6041 73 57 sky130_fd_sc_hd__o21ai_2
* cell instance $31871 r0 *1 17.02,269.28
X$31871 57 6094 5994 5959 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $31872 r0 *1 24.38,269.28
X$31872 57 6099 6043 5959 6041 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $31878 r0 *1 39.56,269.28
X$31878 73 6043 5566 6149 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31879 r0 *1 40.94,269.28
X$31879 73 6043 4424 4913 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31887 r0 *1 45.08,269.28
X$31887 73 6149 4766 4227 57 73 6150 57 sky130_fd_sc_hd__a21boi_0
* cell instance $31888 r0 *1 47.84,269.28
X$31888 73 6150 73 57 4926 57 sky130_fd_sc_hd__buf_4
* cell instance $31891 r0 *1 55.2,269.28
X$31891 73 5566 5471 5244 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31892 r0 *1 56.58,269.28
X$31892 73 6041 73 57 4223 57 sky130_fd_sc_hd__buf_4
* cell instance $31893 r0 *1 59.34,269.28
X$31893 57 15652 5290 6042 6045 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $31896 r0 *1 65.32,269.28
X$31896 73 6189 4952 5745 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31897 r0 *1 66.7,269.28
X$31897 73 6189 73 57 4292 57 sky130_fd_sc_hd__buf_4
* cell instance $31921 r0 *1 109.94,269.28
X$31921 73 6046 4424 4926 57 73 6193 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31922 r0 *1 111.78,269.28
X$31922 73 6153 4424 4366 6046 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $31923 r0 *1 113.62,269.28
X$31923 57 15641 6153 4290 4227 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $31925 r0 *1 118.68,269.28
X$31925 73 6153 4424 6195 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31938 r0 *1 140.76,269.28
X$31938 73 4366 6196 6112 73 6197 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $31950 r0 *1 160.54,269.28
X$31950 73 2982 4750 73 6199 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $31964 r0 *1 187.68,269.28
X$31964 73 4686 6049 6302 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31965 r0 *1 189.06,269.28
X$31965 73 4540 6049 5197 4717 6154 73 6123 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $31969 r0 *1 195.5,269.28
X$31969 73 4540 5580 6154 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31970 r0 *1 196.88,269.28
X$31970 57 15647 5747 6049 4711 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $31971 r0 *1 201.48,269.28
X$31971 73 5747 4372 5197 6157 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $31972 r0 *1 203.32,269.28
X$31972 73 4374 5966 6156 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $31973 r0 *1 204.7,269.28
X$31973 73 6156 5578 5197 6157 57 73 6206 57 sky130_fd_sc_hd__a31oi_1
* cell instance $31983 r0 *1 212.98,269.28
X$31983 73 6207 5106 5966 57 73 6158 57 sky130_fd_sc_hd__a21oi_1
* cell instance $31989 r0 *1 230.46,269.28
X$31989 73 5587 6866 6211 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $31994 r0 *1 233.68,269.28
X$31994 73 6132 5947 5197 57 73 6210 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32001 r0 *1 245.18,269.28
X$32001 73 5056 6213 4372 4299 57 6212 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $32002 r0 *1 247.94,269.28
X$32002 57 6212 6214 5054 6159 73 73 57 sky130_fd_sc_hd__nor3_2
* cell instance $32003 r0 *1 251.62,269.28
X$32003 73 5940 73 57 5587 57 sky130_fd_sc_hd__buf_4
* cell instance $32006 r0 *1 256.68,269.28
X$32006 57 4540 6159 4782 4372 6216 5823 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $32027 r0 *1 293.48,269.28
X$32027 73 5752 4873 5855 6226 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $32028 r0 *1 296.24,269.28
X$32028 57 5855 6320 4372 6227 6035 6226 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $32029 r0 *1 299.46,269.28
X$32029 57 6762 3766 6055 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $32031 r0 *1 307.74,269.28
X$32031 73 6229 4299 4372 4437 57 6142 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $32043 r0 *1 328.9,269.28
X$32043 57 11469 6033 6145 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $32064 r0 *1 375.36,269.28
X$32064 73 5663 5315 6163 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32069 r0 *1 383.64,269.28
X$32069 73 5944 6220 5548 73 6221 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32082 r0 *1 407.56,269.28
X$32082 73 5281 6065 6163 57 73 6217 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32087 r0 *1 419.52,269.28
X$32087 73 5766 6168 5281 6065 6068 6169 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $32091 r0 *1 423.2,269.28
X$32091 73 5313 6062 6022 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $32093 r0 *1 425.04,269.28
X$32093 73 5976 5308 6071 73 6067 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32104 r0 *1 444.82,269.28
X$32104 73 5772 6208 6169 5600 6171 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $32105 r0 *1 447.58,269.28
X$32105 73 5676 5539 6171 5666 6204 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $32111 r0 *1 455.86,269.28
X$32111 73 5764 6071 5442 73 6201 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32115 r0 *1 462.76,269.28
X$32115 73 5866 5308 5764 6200 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $32127 r0 *1 485.76,269.28
X$32127 73 6119 73 57 6012 57 sky130_fd_sc_hd__buf_4
* cell instance $32140 r0 *1 513.36,269.28
X$32140 73 6178 6076 5211 57 73 6198 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32144 r0 *1 520.26,269.28
X$32144 57 6109 5092 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $32150 r0 *1 533.14,269.28
X$32150 73 5144 5985 6194 57 73 5530 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32158 r0 *1 547.86,269.28
X$32158 73 5525 4906 6179 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32159 r0 *1 549.24,269.28
X$32159 73 6179 73 57 5236 57 sky130_fd_sc_hd__buf_4
* cell instance $32166 r0 *1 558.44,269.28
X$32166 73 5799 73 57 6180 57 sky130_fd_sc_hd__buf_4
* cell instance $32174 r0 *1 569.94,269.28
X$32174 73 5903 6190 4982 5602 57 73 6191 57 sky130_fd_sc_hd__a31oi_1
* cell instance $32177 r0 *1 575,269.28
X$32177 73 5799 73 57 6365 57 sky130_fd_sc_hd__buf_4
* cell instance $32180 r0 *1 580.52,269.28
X$32180 57 5256 6177 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $32188 r0 *1 596.16,269.28
X$32188 57 6647 1619 6098 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $32192 r0 *1 609.5,269.28
X$32192 73 6083 5999 5070 6095 57 6188 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $32193 r0 *1 612.26,269.28
X$32193 73 6188 73 57 6183 57 sky130_fd_sc_hd__buf_4
* cell instance $32203 r0 *1 631.12,269.28
X$32203 73 4902 6185 6181 5500 6089 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $32204 r0 *1 633.88,269.28
X$32204 73 5781 4906 4902 73 6181 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32207 r0 *1 638.48,269.28
X$32207 73 5415 5229 6184 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32223 m0 *1 14.72,274.72
X$32223 57 5266 5994 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $32233 m0 *1 43.7,274.72
X$32233 73 4536 73 57 6148 57 sky130_fd_sc_hd__inv_1
* cell instance $32234 m0 *1 45.08,274.72
X$32234 73 6148 73 57 4287 57 sky130_fd_sc_hd__buf_4
* cell instance $32235 m0 *1 47.84,274.72
X$32235 73 6148 6149 6044 57 73 6287 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32239 m0 *1 55.66,274.72
X$32239 73 5244 6002 5959 73 6291 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32241 m0 *1 57.96,274.72
X$32241 73 5959 73 57 6018 57 sky130_fd_sc_hd__buf_4
* cell instance $32243 m0 *1 62.56,274.72
X$32243 57 15494 6189 4290 6045 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $32245 m0 *1 69,274.72
X$32245 57 15457 6294 4290 4227 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $32254 m0 *1 88.78,274.72
X$32254 73 4766 4952 4364 5439 6151 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $32255 m0 *1 91.54,274.72
X$32255 73 5439 6467 6151 4705 6192 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $32260 m0 *1 103.04,274.72
X$32260 73 4223 5439 4364 57 73 6242 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32266 m0 *1 115,274.72
X$32266 57 15500 5847 6018 5841 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $32274 m0 *1 137.54,274.72
X$32274 73 5439 6020 6382 73 6196 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32292 m0 *1 186.76,274.72
X$32292 73 4438 6302 6390 6122 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $32295 m0 *1 190.9,274.72
X$32295 73 6302 73 57 5392 57 sky130_fd_sc_hd__buf_4
* cell instance $32300 m0 *1 198.26,274.72
X$32300 73 6304 6155 5964 73 5965 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32301 m0 *1 200.1,274.72
X$32301 73 4589 4374 5580 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32302 m0 *1 201.48,274.72
X$32302 73 4708 4781 5934 57 73 6155 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32306 m0 *1 212.52,274.72
X$32306 73 5966 5291 6248 6306 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $32308 m0 *1 214.82,274.72
X$32308 73 4876 4540 6248 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $32328 m0 *1 258.06,274.72
X$32328 73 6251 4782 6216 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $32332 m0 *1 262.66,274.72
X$32332 73 4782 5945 4708 57 73 6921 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32335 m0 *1 269.1,274.72
X$32335 73 6253 4710 4540 5945 57 6317 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $32338 m0 *1 274.62,274.72
X$32338 73 5855 6160 6161 73 6218 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32341 m0 *1 278.76,274.72
X$32341 73 5297 4718 4540 6227 57 6161 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $32343 m0 *1 285.2,274.72
X$32343 73 4782 73 57 6253 57 sky130_fd_sc_hd__buf_4
* cell instance $32348 m0 *1 298.08,274.72
X$32348 73 6319 6320 5587 6228 57 6230 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $32369 m0 *1 356.04,274.72
X$32369 57 5141 6224 5591 6223 6162 6591 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $32370 m0 *1 359.26,274.72
X$32370 73 5281 6254 5406 6223 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $32375 m0 *1 367.54,274.72
X$32375 73 5494 6257 6027 57 73 6162 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32379 m0 *1 372.6,274.72
X$32379 73 6327 73 57 5276 57 sky130_fd_sc_hd__buf_4
* cell instance $32383 m0 *1 378.58,274.72
X$32383 73 5663 73 57 6164 57 sky130_fd_sc_hd__buf_4
* cell instance $32386 m0 *1 383.64,274.72
X$32386 73 6164 6064 6166 73 6220 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32398 m0 *1 408.94,274.72
X$32398 73 6065 6165 6136 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32405 m0 *1 419.06,274.72
X$32405 73 5494 5817 6165 57 73 6167 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32406 m0 *1 420.9,274.72
X$32406 73 6215 6022 6167 6264 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $32409 m0 *1 428.26,274.72
X$32409 73 5676 4746 6166 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $32412 m0 *1 432.4,274.72
X$32412 73 6172 6164 5281 5400 6209 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $32419 m0 *1 445.74,274.72
X$32419 73 6316 5771 6314 73 6205 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32420 m0 *1 447.58,274.72
X$32420 73 6265 6257 6068 57 73 6170 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32421 m0 *1 449.42,274.72
X$32421 73 6058 6203 6266 6204 73 57 6386 57 sky130_fd_sc_hd__o31ai_1
* cell instance $32422 m0 *1 452.18,274.72
X$32422 57 6315 6203 6205 6170 6202 6387 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $32423 m0 *1 455.4,274.72
X$32423 73 5276 6172 6202 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $32426 m0 *1 461.38,274.72
X$32426 73 4746 73 57 6314 57 sky130_fd_sc_hd__buf_4
* cell instance $32427 m0 *1 464.14,274.72
X$32427 73 5308 5764 6200 73 6312 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32432 m0 *1 472.42,274.72
X$32432 57 3431 6311 5666 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $32434 m0 *1 480.24,274.72
X$32434 57 6174 6015 2341 6434 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $32435 m0 *1 488.52,274.72
X$32435 73 5875 6174 6175 73 6308 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32437 m0 *1 490.82,274.72
X$32437 57 2341 6173 6308 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $32445 m0 *1 510.14,274.72
X$32445 73 6076 6177 6176 6303 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $32448 m0 *1 519.34,274.72
X$32448 73 5806 5211 6269 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32456 m0 *1 532.22,274.72
X$32456 73 5143 6004 6271 73 6194 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32460 m0 *1 539.12,274.72
X$32460 73 6178 6176 5144 73 6273 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32469 m0 *1 556.14,274.72
X$32469 73 6271 73 57 4996 57 sky130_fd_sc_hd__buf_4
* cell instance $32470 m0 *1 558.9,274.72
X$32470 57 6300 6299 6180 6273 6366 6191 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $32473 m0 *1 568.1,274.72
X$32473 73 4918 73 57 6277 57 sky130_fd_sc_hd__buf_4
* cell instance $32475 m0 *1 571.32,274.72
X$32475 73 6295 6176 5999 73 5988 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32482 m0 *1 584.2,274.72
X$32482 73 6077 73 57 4998 57 sky130_fd_sc_hd__buf_4
* cell instance $32493 m0 *1 615.48,274.72
X$32493 73 5423 5881 6187 6449 73 57 6186 57 sky130_fd_sc_hd__o31ai_1
* cell instance $32501 m0 *1 633.42,274.72
X$32501 73 5781 5236 6282 73 6185 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32518 r0 *1 16.56,274.72
X$32518 57 5994 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $32521 r0 *1 26.68,274.72
X$32521 73 6233 73 57 4328 57 sky130_fd_sc_hd__buf_4
* cell instance $32522 r0 *1 29.44,274.72
X$32522 73 4424 6234 6233 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $32523 r0 *1 31.74,274.72
X$32523 73 6234 73 57 4658 57 sky130_fd_sc_hd__buf_4
* cell instance $32530 r0 *1 46,274.72
X$32530 73 4913 73 57 6332 57 sky130_fd_sc_hd__buf_4
* cell instance $32531 r0 *1 48.76,274.72
X$32531 73 6287 73 57 6333 57 sky130_fd_sc_hd__buf_4
* cell instance $32533 r0 *1 53.36,274.72
X$32533 73 4227 5745 4191 57 73 6235 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32534 r0 *1 55.2,274.72
X$32534 73 6235 5468 5289 6236 57 6290 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $32536 r0 *1 57.96,274.72
X$32536 57 15636 6234 6018 4223 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $32537 r0 *1 62.56,274.72
X$32537 73 6002 6236 6237 6238 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $32539 r0 *1 64.86,274.72
X$32539 73 4129 5739 6239 6237 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $32545 r0 *1 72.22,274.72
X$32545 73 6294 5471 6239 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32550 r0 *1 80.5,274.72
X$32550 73 5516 6465 4952 73 6240 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32552 r0 *1 82.8,274.72
X$32552 73 6239 6240 6241 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32555 r0 *1 88.32,274.72
X$32555 57 15629 5962 6018 6045 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $32562 r0 *1 101.2,274.72
X$32562 73 4218 4191 6297 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32563 r0 *1 102.58,274.72
X$32563 57 4927 6469 4285 6242 6297 6107 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $32567 r0 *1 111.78,274.72
X$32567 73 6244 4285 4675 6241 73 6017 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $32568 r0 *1 115,274.72
X$32568 57 6244 6243 5045 4675 6245 5439 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $32570 r0 *1 118.68,274.72
X$32570 73 4922 73 57 6243 57 sky130_fd_sc_hd__buf_4
* cell instance $32571 r0 *1 121.44,274.72
X$32571 73 5439 4292 4424 57 73 6245 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32579 r0 *1 129.26,274.72
X$32579 57 6991 5534 3952 6222 73 73 57 sky130_fd_sc_hd__o21ai_4
* cell instance $32583 r0 *1 143.06,274.72
X$32583 57 4427 6246 6222 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $32584 r0 *1 150.42,274.72
X$32584 73 5286 57 73 6385 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32587 r0 *1 154.56,274.72
X$32587 57 6338 6246 6247 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $32591 r0 *1 169.74,274.72
X$32591 57 5963 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $32603 r0 *1 196.42,274.72
X$32603 73 4516 4618 6304 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $32616 r0 *1 230,274.72
X$32616 73 6309 5964 6249 57 73 6310 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32619 r0 *1 232.76,274.72
X$32619 73 4374 6210 6250 73 6249 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32620 r0 *1 234.6,274.72
X$32620 73 4374 5582 5934 6250 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $32635 r0 *1 268.64,274.72
X$32635 73 4540 5855 4718 6317 57 73 6252 57 sky130_fd_sc_hd__a31oi_1
* cell instance $32637 r0 *1 271.4,274.72
X$32637 73 4614 6253 4715 73 6160 57 57 sky130_fd_sc_hd__a21oi_2
* cell instance $32641 r0 *1 276.92,274.72
X$32641 73 4718 5291 5821 73 6318 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32644 r0 *1 281.52,274.72
X$32644 57 57 5756 73 4876 6253 73 sky130_fd_sc_hd__nor2_2
* cell instance $32647 r0 *1 285.2,274.72
X$32647 73 4614 6253 4948 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $32677 r0 *1 355.58,274.72
X$32677 73 6325 6254 5492 6255 5494 6219 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $32681 r0 *1 363.86,274.72
X$32681 73 5663 73 57 6255 57 sky130_fd_sc_hd__buf_4
* cell instance $32685 r0 *1 369.38,274.72
X$32685 73 6222 73 57 6615 57 sky130_fd_sc_hd__clkinv_1
* cell instance $32686 r0 *1 370.76,274.72
X$32686 73 6256 5662 5315 57 73 6326 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32687 r0 *1 372.6,274.72
X$32687 73 6326 5494 6313 6258 6140 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $32689 r0 *1 375.36,274.72
X$32689 57 6257 6259 6348 6163 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $32692 r0 *1 379.04,274.72
X$32692 73 5402 5315 6256 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $32694 r0 *1 381.34,274.72
X$32694 73 6259 5494 6260 57 73 6261 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32695 r0 *1 383.18,274.72
X$32695 73 5976 5308 5861 73 6260 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32698 r0 *1 387.32,274.72
X$32698 73 6258 5308 5861 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32700 r0 *1 389.62,274.72
X$32700 57 6261 6324 6073 7238 6262 5600 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $32702 r0 *1 393.3,274.72
X$32702 73 5141 6322 6323 73 6262 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $32704 r0 *1 396.06,274.72
X$32704 73 5281 6351 5310 57 73 6322 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32710 r0 *1 408.48,274.72
X$32710 73 5281 6256 6321 6168 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $32712 r0 *1 412.16,274.72
X$32712 73 6263 73 57 6215 57 sky130_fd_sc_hd__buf_4
* cell instance $32717 r0 *1 421.82,274.72
X$32717 73 5818 6264 6219 73 6392 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32736 r0 *1 462.3,274.72
X$32736 73 5676 6172 6313 73 6267 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32738 r0 *1 464.6,274.72
X$32738 73 5313 6312 5276 6267 73 6661 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $32749 r0 *1 486.68,274.72
X$32749 73 6174 6268 73 6117 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $32750 r0 *1 489.9,274.72
X$32750 57 6307 6117 6305 5875 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $32757 r0 *1 510.14,274.72
X$32757 73 6269 73 57 6570 57 sky130_fd_sc_hd__buf_4
* cell instance $32763 r0 *1 520.26,274.72
X$32763 73 5806 5906 6076 6303 57 73 6568 57 sky130_fd_sc_hd__a31oi_1
* cell instance $32764 r0 *1 522.56,274.72
X$32764 73 5144 6269 6437 6180 6270 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $32767 r0 *1 526.7,274.72
X$32767 57 6379 4917 6489 6270 5908 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $32776 r0 *1 545.1,274.72
X$32776 73 5412 73 57 6271 57 sky130_fd_sc_hd__buf_4
* cell instance $32777 r0 *1 547.86,274.72
X$32777 73 5147 73 57 5999 57 sky130_fd_sc_hd__buf_4
* cell instance $32783 r0 *1 560.74,274.72
X$32783 73 6274 6275 5500 73 6299 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32784 r0 *1 562.58,274.72
X$32784 57 57 6276 73 5497 4996 73 sky130_fd_sc_hd__nor2_2
* cell instance $32786 r0 *1 565.34,274.72
X$32786 73 6276 73 57 6274 57 sky130_fd_sc_hd__buf_4
* cell instance $32788 r0 *1 568.56,274.72
X$32788 73 6274 6277 4982 73 6298 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32790 r0 *1 571.32,274.72
X$32790 73 4917 6278 6298 6279 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $32791 r0 *1 573.16,274.72
X$32791 73 4998 6279 5905 6296 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $32795 r0 *1 580.06,274.72
X$32795 73 5999 6190 5883 6278 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $32798 r0 *1 585.58,274.72
X$32798 73 5897 4996 6286 57 73 6293 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32801 r0 *1 589.72,274.72
X$32801 73 6276 73 57 5509 57 sky130_fd_sc_hd__buf_4
* cell instance $32810 r0 *1 604.9,274.72
X$32810 73 5886 6288 6292 57 73 6289 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32811 r0 *1 606.74,274.72
X$32811 73 4899 6281 6280 73 6288 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32813 r0 *1 609.5,274.72
X$32813 73 5150 7200 6097 57 73 6280 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32824 r0 *1 633.42,274.72
X$32824 73 6282 6285 5783 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32825 r0 *1 634.8,274.72
X$32825 73 5781 5417 6282 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32829 r0 *1 639.4,274.72
X$32829 73 6184 6365 6283 5886 57 73 6454 57 sky130_fd_sc_hd__a31oi_1
* cell instance $32888 m0 *1 5.06,280.16
X$32888 57 6329 5994 6199 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $32891 m0 *1 17.02,280.16
X$32891 73 6146 57 73 6331 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32893 m0 *1 21.16,280.16
X$32893 73 6370 73 57 6330 57 sky130_fd_sc_hd__buf_4
* cell instance $32896 m0 *1 26.68,280.16
X$32896 73 4227 6233 6370 6373 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $32903 m0 *1 41.4,280.16
X$32903 73 4859 4658 4738 4227 6375 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $32907 m0 *1 46.92,280.16
X$32907 73 5566 6332 6330 5184 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $32915 m0 *1 62.1,280.16
X$32915 73 5290 4859 6236 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $32921 m0 *1 79.12,280.16
X$32921 73 6333 73 57 5432 57 sky130_fd_sc_hd__buf_4
* cell instance $32938 m0 *1 114.54,280.16
X$32938 73 6516 4868 6333 73 6474 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32944 m0 *1 131.56,280.16
X$32944 73 4292 4424 4328 5439 6382 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $32953 m0 *1 155.48,280.16
X$32953 57 6247 6335 6385 6336 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $32955 m0 *1 161.46,280.16
X$32955 73 6337 6048 73 6335 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $32956 m0 *1 164.68,280.16
X$32956 73 6414 6338 73 6337 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $32960 m0 *1 169.74,280.16
X$32960 57 5266 5963 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $32963 m0 *1 186.3,280.16
X$32963 73 4711 4686 6416 57 73 6390 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32964 m0 *1 188.14,280.16
X$32964 73 4373 73 57 6049 57 sky130_fd_sc_hd__buf_4
* cell instance $32970 m0 *1 197.34,280.16
X$32970 73 4438 6049 6339 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $32971 m0 *1 200.56,280.16
X$32971 73 6339 73 57 6129 57 sky130_fd_sc_hd__buf_4
* cell instance $32976 m0 *1 213.44,280.16
X$32976 73 6306 4540 6340 57 73 6393 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32977 m0 *1 215.28,280.16
X$32977 73 5579 5580 6341 57 73 6340 57 sky130_fd_sc_hd__a21oi_1
* cell instance $32979 m0 *1 217.58,280.16
X$32979 73 5759 5106 6341 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $32995 m0 *1 255.3,280.16
X$32995 73 5756 5028 5855 73 6397 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $32996 m0 *1 257.14,280.16
X$32996 57 15515 6251 5106 4711 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $33000 m0 *1 264.96,280.16
X$33000 73 5855 4960 6342 6398 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33004 m0 *1 270.02,280.16
X$33004 57 57 5028 73 4715 5754 73 sky130_fd_sc_hd__nor2_2
* cell instance $33007 m0 *1 273.7,280.16
X$33007 57 5200 6400 4374 4711 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $33011 m0 *1 282.9,280.16
X$33011 73 4876 4875 6227 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33012 m0 *1 284.28,280.16
X$33012 73 5756 5060 6253 57 73 6424 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33017 m0 *1 294.86,280.16
X$33017 73 5028 5855 4622 5759 6343 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $33020 m0 *1 298.54,280.16
X$33020 73 4540 4966 6343 57 73 6319 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33038 m0 *1 340.86,280.16
X$33038 57 4428 2342 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $33041 m0 *1 349.6,280.16
X$33041 73 6345 5492 6347 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33042 m0 *1 350.98,280.16
X$33042 73 6346 73 57 6345 57 sky130_fd_sc_hd__inv_1
* cell instance $33044 m0 *1 352.82,280.16
X$33044 73 6347 73 57 5592 57 sky130_fd_sc_hd__buf_4
* cell instance $33045 m0 *1 355.58,280.16
X$33045 73 6346 73 57 5353 57 sky130_fd_sc_hd__buf_4
* cell instance $33047 m0 *1 358.8,280.16
X$33047 73 6346 5308 6399 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33051 m0 *1 362.02,280.16
X$33051 73 6399 73 57 5551 57 sky130_fd_sc_hd__buf_4
* cell instance $33053 m0 *1 366.62,280.16
X$33053 57 15520 6346 6327 5975 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $33055 m0 *1 373.06,280.16
X$33055 73 6348 6350 6163 57 73 6396 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33066 m0 *1 396.06,280.16
X$33066 73 5141 6323 6394 6025 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $33069 m0 *1 399.28,280.16
X$33069 73 6351 73 57 6027 57 sky130_fd_sc_hd__buf_4
* cell instance $33073 m0 *1 408.48,280.16
X$33073 73 6352 5308 6065 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33077 m0 *1 413.08,280.16
X$33077 73 6061 6316 5276 73 6850 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33084 m0 *1 419.98,280.16
X$33084 73 6352 5494 6391 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33086 m0 *1 421.82,280.16
X$33086 73 6325 73 57 5818 57 sky130_fd_sc_hd__buf_4
* cell instance $33087 m0 *1 424.58,280.16
X$33087 73 6165 6062 6391 5494 5772 73 6432 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $33097 m0 *1 445.74,280.16
X$33097 73 5976 5315 6165 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33100 m0 *1 448.5,280.16
X$33100 73 5670 6386 6389 57 73 6388 57 sky130_fd_sc_hd__a21o_1
* cell instance $33103 m0 *1 454.02,280.16
X$33103 73 6314 6387 6968 57 73 6266 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33107 m0 *1 463.68,280.16
X$33107 73 5772 6165 5315 6354 6265 6384 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $33110 m0 *1 468.28,280.16
X$33110 73 6311 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $33112 m0 *1 471.96,280.16
X$33112 57 6383 6311 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $33115 m0 *1 485.3,280.16
X$33115 57 6268 6173 6307 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $33116 m0 *1 492.66,280.16
X$33116 73 5875 6367 6175 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33122 m0 *1 501.4,280.16
X$33122 73 6272 73 57 6305 57 sky130_fd_sc_hd__inv_1
* cell instance $33137 m0 *1 544.18,280.16
X$33137 73 6178 5212 4980 57 73 6356 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33144 m0 *1 556.14,280.16
X$33144 73 5999 6356 6357 73 6380 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33149 m0 *1 569.48,280.16
X$33149 73 6276 6277 5999 73 6357 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33151 m0 *1 571.78,280.16
X$33151 73 6358 73 57 6190 57 sky130_fd_sc_hd__buf_4
* cell instance $33157 m0 *1 584.66,280.16
X$33157 73 6378 6365 6293 57 73 6360 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33159 m0 *1 587.42,280.16
X$33159 73 6357 73 57 6377 57 sky130_fd_sc_hd__buf_4
* cell instance $33161 m0 *1 590.64,280.16
X$33161 73 6364 6295 5500 73 6376 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33162 m0 *1 592.48,280.16
X$33162 73 5509 73 57 6364 57 sky130_fd_sc_hd__buf_4
* cell instance $33167 m0 *1 604.9,280.16
X$33167 73 6365 6450 6363 6374 73 6292 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $33171 m0 *1 610.42,280.16
X$33171 73 4902 5698 6366 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33175 m0 *1 617.78,280.16
X$33175 73 6372 73 57 5883 57 sky130_fd_sc_hd__buf_4
* cell instance $33177 m0 *1 624.22,280.16
X$33177 73 6369 73 57 5806 57 sky130_fd_sc_hd__buf_4
* cell instance $33187 m0 *1 649.52,280.16
X$33187 73 6452 57 73 6272 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33189 m0 *1 656.88,280.16
X$33189 73 6284 57 73 6367 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33190 r0 *1 2.3,280.16
X$33190 73 6329 57 73 6402 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33203 r0 *1 34.04,280.16
X$33203 73 5566 4424 5374 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33223 r0 *1 74.98,280.16
X$33223 73 4129 6409 6463 5075 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33226 r0 *1 81.42,280.16
X$33226 57 4952 6409 5739 6466 6465 6334 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $33239 r0 *1 108.1,280.16
X$33239 73 4675 5910 6334 6472 4424 73 6014 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $33241 r0 *1 113.16,280.16
X$33241 73 6474 73 57 6411 57 sky130_fd_sc_hd__buf_4
* cell instance $33243 r0 *1 116.84,280.16
X$33243 73 5847 4424 6334 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33254 r0 *1 140.76,280.16
X$33254 73 4466 6477 6336 57 73 6225 57 sky130_fd_sc_hd__o21a_2
* cell instance $33258 r0 *1 149.04,280.16
X$33258 57 6246 15443 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $33264 r0 *1 160.08,280.16
X$33264 57 6336 6487 6246 6331 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $33277 r0 *1 194.58,280.16
X$33277 73 4374 4438 5108 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33279 r0 *1 199.64,280.16
X$33279 73 6339 5024 4372 6486 57 6745 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $33283 r0 *1 206.54,280.16
X$33283 73 5024 4438 6418 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33293 r0 *1 225.86,280.16
X$33293 73 4686 4373 5197 6608 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33295 r0 *1 229.54,280.16
X$33295 73 4516 73 57 5759 57 sky130_fd_sc_hd__buf_4
* cell instance $33296 r0 *1 232.3,280.16
X$33296 73 6419 4622 6490 4372 5458 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $33299 r0 *1 235.52,280.16
X$33299 73 4876 5754 6490 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33302 r0 *1 241.04,280.16
X$33302 73 4876 5579 6395 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33303 r0 *1 242.42,280.16
X$33303 73 4374 5582 6395 6421 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33304 r0 *1 244.26,280.16
X$33304 73 5947 73 57 6419 57 sky130_fd_sc_hd__inv_1
* cell instance $33305 r0 *1 245.64,280.16
X$33305 73 4374 6160 6421 5964 6491 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $33310 r0 *1 255.3,280.16
X$33310 73 4710 5754 6342 4374 6667 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $33317 r0 *1 265.88,280.16
X$33317 57 6493 6419 4717 6253 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $33318 r0 *1 269.56,280.16
X$33318 57 6776 4372 4374 5297 6493 4710 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $33319 r0 *1 273.24,280.16
X$33319 73 4614 5855 6160 73 6401 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33321 r0 *1 276,280.16
X$33321 57 6400 6844 4299 6251 5754 6401 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $33325 r0 *1 284.28,280.16
X$33325 73 4299 6227 6425 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33326 r0 *1 285.66,280.16
X$33326 73 4717 4875 6342 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33334 r0 *1 296.7,280.16
X$33334 57 6228 4372 6869 5829 5955 4540 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $33338 r0 *1 303.6,280.16
X$33338 57 6229 4374 4948 6227 6504 6344 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $33339 r0 *1 307.28,280.16
X$33339 73 4374 6342 6504 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33358 r0 *1 350.52,280.16
X$33358 73 6225 5315 5492 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33359 r0 *1 351.9,280.16
X$33359 73 6225 73 57 5494 57 sky130_fd_sc_hd__buf_4
* cell instance $33361 r0 *1 356.5,280.16
X$33361 73 6225 73 57 6349 57 sky130_fd_sc_hd__buf_4
* cell instance $33362 r0 *1 359.26,280.16
X$33362 73 6225 57 73 6348 57 sky130_fd_sc_hd__inv_2
* cell instance $33364 r0 *1 364.32,280.16
X$33364 73 6225 73 57 5303 57 sky130_fd_sc_hd__buf_4
* cell instance $33365 r0 *1 367.08,280.16
X$33365 73 6222 73 57 6327 57 sky130_fd_sc_hd__buf_4
* cell instance $33369 r0 *1 371.22,280.16
X$33369 73 5662 5308 6350 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33376 r0 *1 383.64,280.16
X$33376 73 6349 6325 6260 6510 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33392 r0 *1 423.2,280.16
X$33392 73 5764 6392 6505 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33401 r0 *1 447.12,280.16
X$33401 73 6265 5817 6068 57 73 6499 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33410 r0 *1 460.92,280.16
X$33410 73 5353 6353 6741 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33412 r0 *1 462.76,280.16
X$33412 73 6394 5540 6494 6495 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $33420 r0 *1 482.08,280.16
X$33420 73 6015 6435 73 6492 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $33424 r0 *1 487.14,280.16
X$33424 57 6436 6492 6301 5875 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $33443 r0 *1 531.3,280.16
X$33443 73 6381 6439 6483 5530 6489 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $33445 r0 *1 534.52,280.16
X$33445 73 6077 73 57 6439 57 sky130_fd_sc_hd__buf_4
* cell instance $33464 r0 *1 576.84,280.16
X$33464 73 5437 5226 5698 57 73 6473 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33468 r0 *1 584.66,280.16
X$33468 73 6359 6362 6360 6470 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33470 r0 *1 586.5,280.16
X$33470 57 5999 6362 6377 6447 6364 6363 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $33471 r0 *1 589.72,280.16
X$33471 73 5991 5505 6376 6363 6464 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $33477 r0 *1 599.84,280.16
X$33477 73 4998 5070 6363 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33485 r0 *1 618.7,280.16
X$33485 73 6371 6451 5500 57 73 6286 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33491 r0 *1 628.36,280.16
X$33491 73 5611 5417 6369 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33495 r0 *1 638.94,280.16
X$33495 73 6454 5421 6456 6455 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33514 m0 *1 22.08,285.6
X$33514 73 5893 6330 6404 4129 5739 73 6407 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $33517 m0 *1 28.06,285.6
X$33517 73 4129 6373 6458 57 73 6404 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33522 m0 *1 35.42,285.6
X$33522 73 4538 5374 6373 4287 6406 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $33530 m0 *1 48.76,285.6
X$33530 73 4675 6411 6406 57 73 6408 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33531 m0 *1 50.6,285.6
X$33531 73 6407 6408 4259 73 5086 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33535 m0 *1 55.66,285.6
X$33535 73 4129 6554 6461 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33546 m0 *1 74.98,285.6
X$33546 73 6462 73 57 6467 57 sky130_fd_sc_hd__buf_4
* cell instance $33551 m0 *1 87.4,285.6
X$33551 57 15530 6410 6018 6045 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $33559 m0 *1 107.64,285.6
X$33559 73 5841 5521 6472 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $33577 m0 *1 149.04,285.6
X$33577 57 5266 6246 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $33580 m0 *1 158.24,285.6
X$33580 73 6336 6413 4046 73 6478 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33581 m0 *1 160.08,285.6
X$33581 57 6414 6246 6478 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $33585 m0 *1 169.28,285.6
X$33585 73 6048 6481 6413 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $33594 m0 *1 188.6,285.6
X$33594 73 4686 4374 5543 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33597 m0 *1 191.36,285.6
X$33597 73 4374 4438 6417 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33602 m0 *1 196.42,285.6
X$33602 73 4717 4374 4438 6485 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33603 m0 *1 198.26,285.6
X$33603 73 4516 6417 6608 73 6486 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33608 m0 *1 205.62,285.6
X$33608 73 6049 6418 5934 6213 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33609 m0 *1 207.46,285.6
X$33609 73 6418 73 57 5582 57 sky130_fd_sc_hd__buf_4
* cell instance $33615 m0 *1 223.56,285.6
X$33615 57 6488 4843 4711 4686 6129 4616 5108 73 73 57 sky130_fd_sc_hd__a222oi_1
* cell instance $33624 m0 *1 246.1,285.6
X$33624 73 4372 6491 6393 6665 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33638 m0 *1 274.62,285.6
X$33638 57 6423 6487 3526 3767 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $33643 m0 *1 283.82,285.6
X$33643 73 6401 6425 6501 6587 4299 6500 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $33673 m0 *1 351.44,285.6
X$33673 73 6345 5315 6426 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33674 m0 *1 352.82,285.6
X$33674 73 6426 73 57 6509 57 sky130_fd_sc_hd__buf_4
* cell instance $33679 m0 *1 362.02,285.6
X$33679 73 6348 5315 6428 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33687 m0 *1 376.74,285.6
X$33687 73 6506 6428 5832 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33688 m0 *1 378.12,285.6
X$33688 73 5281 6256 6254 6429 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $33689 m0 *1 379.96,285.6
X$33689 57 6429 6511 5398 6073 5862 5315 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $33691 m0 *1 384.1,285.6
X$33691 73 6511 73 57 6496 57 sky130_fd_sc_hd__buf_4
* cell instance $33700 m0 *1 400.66,285.6
X$33700 73 6352 5315 6351 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33703 m0 *1 406.64,285.6
X$33703 73 6507 73 57 6352 57 sky130_fd_sc_hd__inv_1
* cell instance $33704 m0 *1 408.02,285.6
X$33704 73 6507 5492 6263 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33707 m0 *1 410.78,285.6
X$33707 73 6428 73 57 6353 57 sky130_fd_sc_hd__buf_4
* cell instance $33712 m0 *1 417.22,285.6
X$33712 73 5315 6506 6068 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $33721 m0 *1 439.76,285.6
X$33721 57 6068 6503 6349 6070 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $33727 m0 *1 447.58,285.6
X$33727 73 5540 6499 6619 6433 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $33730 m0 *1 449.88,285.6
X$33730 73 6073 6502 6433 6497 6498 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $33745 m0 *1 482.54,285.6
X$33745 73 6434 73 57 6435 57 sky130_fd_sc_hd__buf_4
* cell instance $33746 m0 *1 485.3,285.6
X$33746 57 6434 6173 6436 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $33748 m0 *1 493.58,285.6
X$33748 73 6173 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $33761 m0 *1 522.56,285.6
X$33761 73 5143 5680 6437 57 73 6484 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33763 m0 *1 525.32,285.6
X$33763 73 6355 5412 5680 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33769 m0 *1 531.76,285.6
X$33769 73 6438 5500 6629 57 73 6381 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33770 m0 *1 533.6,285.6
X$33770 73 5878 73 57 6557 57 sky130_fd_sc_hd__buf_4
* cell instance $33772 m0 *1 536.82,285.6
X$33772 57 4983 6974 6483 5092 6451 4980 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $33773 m0 *1 540.5,285.6
X$33773 57 6440 4983 5212 6484 6355 5145 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $33780 m0 *1 554.76,285.6
X$33780 73 6441 6442 6380 5437 6443 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $33782 m0 *1 557.52,285.6
X$33782 73 5691 6443 6300 6480 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $33785 m0 *1 559.36,285.6
X$33785 73 5500 5090 5998 6479 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33786 m0 *1 561.2,285.6
X$33786 73 6479 5999 6476 57 73 6441 57 sky130_fd_sc_hd__a21boi_0
* cell instance $33787 m0 *1 563.96,285.6
X$33787 73 5226 4906 5236 73 6476 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33790 m0 *1 570.4,285.6
X$33790 73 6077 6444 6445 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33791 m0 *1 571.78,285.6
X$33791 73 6445 73 57 5708 57 sky130_fd_sc_hd__buf_4
* cell instance $33793 m0 *1 575.46,285.6
X$33793 73 5339 6557 6473 57 73 6446 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33795 m0 *1 579.14,285.6
X$33795 73 5708 73 57 6442 57 sky130_fd_sc_hd__buf_4
* cell instance $33798 m0 *1 583.28,285.6
X$33798 73 5991 5999 5512 73 6471 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33803 m0 *1 586.5,285.6
X$33803 73 6464 6448 6468 6446 73 6449 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $33813 m0 *1 611.8,285.6
X$33813 73 6451 6459 4905 5415 73 6281 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $33819 m0 *1 617.78,285.6
X$33819 73 6451 5417 6372 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33824 m0 *1 629.28,285.6
X$33824 73 6369 73 57 6457 57 sky130_fd_sc_hd__buf_4
* cell instance $33825 m0 *1 632.04,285.6
X$33825 73 5991 5698 6546 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33833 m0 *1 644,285.6
X$33833 73 6453 57 73 6301 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33840 r0 *1 7.82,285.6
X$33840 73 6403 57 73 6547 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33845 r0 *1 16.56,285.6
X$33845 73 3530 57 73 6550 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33852 r0 *1 37.72,285.6
X$33852 73 4538 5188 6553 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33859 r0 *1 46.46,285.6
X$33859 73 4227 6332 6330 6405 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33860 r0 *1 48.3,285.6
X$33860 73 5739 7018 6405 6514 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33861 r0 *1 50.14,285.6
X$33861 73 5739 6515 6514 73 6554 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33862 r0 *1 51.98,285.6
X$33862 73 5745 5566 4952 4538 6515 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $33865 r0 *1 58.42,285.6
X$33865 73 5962 73 57 5370 57 sky130_fd_sc_hd__buf_4
* cell instance $33873 r0 *1 72.22,285.6
X$33873 57 6462 6410 6463 5739 5841 4862 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $33878 r0 *1 82.8,285.6
X$33878 73 6291 6102 4129 6728 57 73 6556 57 sky130_fd_sc_hd__a31oi_1
* cell instance $33879 r0 *1 85.1,285.6
X$33879 73 5739 73 57 4705 57 sky130_fd_sc_hd__buf_4
* cell instance $33884 r0 *1 96.6,285.6
X$33884 73 6410 4227 5571 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $33892 r0 *1 113.16,285.6
X$33892 73 6410 5841 4424 73 6516 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33894 r0 *1 115.46,285.6
X$33894 73 6410 5841 6560 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $33896 r0 *1 117.76,285.6
X$33896 73 6466 6560 5915 73 6412 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33904 r0 *1 130.64,285.6
X$33904 57 6517 6653 6018 4227 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $33906 r0 *1 136.16,285.6
X$33906 73 6517 4424 4366 6111 6518 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $33907 r0 *1 138.92,285.6
X$33907 73 4366 6412 6518 73 6561 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33912 r0 *1 147.66,285.6
X$33912 73 5956 57 73 6563 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33920 r0 *1 160.54,285.6
X$33920 57 6415 6048 6564 6336 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $33923 r0 *1 168.82,285.6
X$33923 73 6414 73 57 6481 57 sky130_fd_sc_hd__buf_4
* cell instance $33925 r0 *1 172.04,285.6
X$33925 57 6034 5963 6415 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $33932 r0 *1 186.76,285.6
X$33932 73 6049 4299 6416 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33935 r0 *1 190.9,285.6
X$33935 73 4616 5579 6565 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33936 r0 *1 192.28,285.6
X$33936 73 4299 6417 4686 73 6566 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33938 r0 *1 195.04,285.6
X$33938 73 6417 73 57 4618 57 sky130_fd_sc_hd__buf_4
* cell instance $33940 r0 *1 201.48,285.6
X$33940 57 5197 4622 6049 73 73 57 sky130_fd_sc_hd__nand2_4
* cell instance $33949 r0 *1 224.94,285.6
X$33949 73 5964 6488 6420 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33959 r0 *1 238.74,285.6
X$33959 73 5106 5759 5579 57 73 6575 57 sky130_fd_sc_hd__a21oi_1
* cell instance $33962 r0 *1 246.1,285.6
X$33962 73 6578 6420 4966 5969 57 73 6666 57 sky130_fd_sc_hd__a31oi_1
* cell instance $33966 r0 *1 254.84,285.6
X$33966 73 4540 5277 6397 6578 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $33968 r0 *1 257.14,285.6
X$33968 73 5964 5277 6581 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $33976 r0 *1 272.32,285.6
X$33976 73 5855 4715 4711 4540 57 6520 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $33977 r0 *1 275.08,285.6
X$33977 73 5754 5855 5759 4299 57 6422 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $33980 r0 *1 278.76,285.6
X$33980 73 4715 4618 5854 73 6670 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $33983 r0 *1 284.74,285.6
X$33983 73 4717 4374 6587 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34013 r0 *1 350.06,285.6
X$34013 57 15622 6524 5762 5494 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $34016 r0 *1 358.8,285.6
X$34016 73 5141 6427 6527 6591 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $34017 r0 *1 360.64,285.6
X$34017 73 6255 6428 6427 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34018 r0 *1 362.02,285.6
X$34018 73 6428 5662 5399 6593 57 6592 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $34021 r0 *1 367.08,285.6
X$34021 73 5303 5594 6027 57 73 6593 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34027 r0 *1 375.36,285.6
X$34027 57 6061 5398 6430 5141 5402 5308 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $34030 r0 *1 380.42,285.6
X$34030 73 5591 6431 6430 6590 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $34031 r0 *1 382.26,285.6
X$34031 73 5141 6528 5492 6506 5303 6431 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $34032 r0 *1 385.48,285.6
X$34032 73 5551 5976 5308 57 73 6528 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34042 r0 *1 407.56,285.6
X$34042 73 5306 6507 6428 57 73 6588 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34044 r0 *1 411.24,285.6
X$34044 73 6066 6353 6529 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34047 r0 *1 414.92,285.6
X$34047 73 5494 6027 6350 57 73 6585 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34051 r0 *1 421.82,285.6
X$34051 73 6166 73 57 6580 57 sky130_fd_sc_hd__buf_4
* cell instance $34055 r0 *1 427.34,285.6
X$34055 73 5666 73 57 6058 57 sky130_fd_sc_hd__buf_4
* cell instance $34060 r0 *1 438.38,285.6
X$34060 73 6432 5772 6531 57 73 6664 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34061 r0 *1 440.22,285.6
X$34061 73 6027 6257 6265 7347 57 73 6531 57 sky130_fd_sc_hd__a31oi_1
* cell instance $34062 r0 *1 442.52,285.6
X$34062 73 6503 6532 6314 73 6576 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34073 r0 *1 463.22,285.6
X$34073 73 6496 6573 5673 6495 57 6572 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $34086 r0 *1 493.58,285.6
X$34086 57 6383 6173 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $34090 r0 *1 510.14,285.6
X$34090 73 6570 6076 4899 6571 57 6569 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $34095 r0 *1 521.18,285.6
X$34095 73 6442 6568 6534 73 7077 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34097 r0 *1 524.86,285.6
X$34097 73 5691 6180 6535 57 73 6534 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34098 r0 *1 526.7,285.6
X$34098 73 6567 5500 4984 6004 6535 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $34102 r0 *1 531.3,285.6
X$34102 73 5143 6004 6271 6438 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34111 r0 *1 554.3,285.6
X$34111 73 4905 6271 6559 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34112 r0 *1 555.68,285.6
X$34112 73 5999 5778 6537 6180 6538 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $34116 r0 *1 560.74,285.6
X$34116 73 6538 73 57 6468 57 sky130_fd_sc_hd__buf_4
* cell instance $34126 r0 *1 584.66,285.6
X$34126 73 6442 6460 5500 5605 6536 6448 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $34130 r0 *1 591.1,285.6
X$34130 73 6444 73 57 5070 57 sky130_fd_sc_hd__buf_4
* cell instance $34137 r0 *1 605.82,285.6
X$34137 73 6539 5500 6540 57 73 6450 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34138 r0 *1 607.66,285.6
X$34138 73 5894 4906 6541 57 73 6540 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34139 r0 *1 609.5,285.6
X$34139 73 4989 73 57 6541 57 sky130_fd_sc_hd__buf_4
* cell instance $34140 r0 *1 612.26,285.6
X$34140 73 5505 6541 5070 73 6552 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34149 r0 *1 628.82,285.6
X$34149 73 6637 6283 6457 57 73 6460 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34151 r0 *1 634.34,285.6
X$34151 73 6894 6546 5781 5070 57 73 6543 57 sky130_fd_sc_hd__a31oi_1
* cell instance $34153 r0 *1 637.56,285.6
X$34153 73 6545 6543 6456 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34215 m0 *1 13.8,291.04
X$34215 73 6512 57 73 6548 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34219 m0 *1 22.54,291.04
X$34219 73 6597 73 57 5739 57 sky130_fd_sc_hd__clkinv_1
* cell instance $34220 m0 *1 23.92,291.04
X$34220 73 4424 6099 6513 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $34224 m0 *1 32.2,291.04
X$34224 73 5839 6513 4227 57 73 6458 57 sky130_fd_sc_hd__a21o_1
* cell instance $34227 m0 *1 37.72,291.04
X$34227 73 6513 73 57 4164 57 sky130_fd_sc_hd__buf_4
* cell instance $34235 m0 *1 57.96,291.04
X$34235 73 4538 4952 5745 73 6648 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34236 m0 *1 59.8,291.04
X$34236 73 4227 5745 4289 57 73 6555 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34240 m0 *1 69.46,291.04
X$34240 73 5566 4424 4862 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34243 m0 *1 73.6,291.04
X$34243 73 5471 5290 4289 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $34250 m0 *1 89.7,291.04
X$34250 73 5962 6602 5185 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34253 m0 *1 96.6,291.04
X$34253 73 5962 6604 6466 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $34258 m0 *1 105.8,291.04
X$34258 73 6410 73 57 5252 57 sky130_fd_sc_hd__buf_4
* cell instance $34264 m0 *1 114.54,291.04
X$34264 73 6466 6516 4129 73 6558 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34267 m0 *1 120.98,291.04
X$34267 73 6602 73 57 5915 57 sky130_fd_sc_hd__buf_4
* cell instance $34272 m0 *1 133.86,291.04
X$34272 73 6653 5915 5535 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34278 m0 *1 144.44,291.04
X$34278 73 6475 57 73 6564 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34281 m0 *1 150.88,291.04
X$34281 73 3989 73 57 6336 57 sky130_fd_sc_hd__buf_4
* cell instance $34283 m0 *1 155.48,291.04
X$34283 73 6682 73 57 4750 57 sky130_fd_sc_hd__buf_4
* cell instance $34286 m0 *1 159.62,291.04
X$34286 57 6829 3286 6563 6336 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $34297 m0 *1 192.28,291.04
X$34297 57 4686 6659 4589 5108 6660 6566 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $34304 m0 *1 206.54,291.04
X$34304 73 6049 4299 5456 4372 73 57 6662 57 sky130_fd_sc_hd__o31ai_1
* cell instance $34312 m0 *1 224.48,291.04
X$34312 73 6519 73 57 6030 57 sky130_fd_sc_hd__buf_4
* cell instance $34316 m0 *1 230.46,291.04
X$34316 73 5964 6608 6609 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34319 m0 *1 235.98,291.04
X$34319 73 6839 4524 5106 4372 57 73 6519 57 sky130_fd_sc_hd__a31oi_1
* cell instance $34320 m0 *1 238.28,291.04
X$34320 73 5964 5582 6575 57 73 6574 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34321 m0 *1 240.12,291.04
X$34321 73 6574 5938 6577 6609 73 6579 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $34324 m0 *1 245.64,291.04
X$34324 73 5855 4960 5582 57 73 6577 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34332 m0 *1 262.2,291.04
X$34332 73 4374 4524 4960 57 73 6582 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34336 m0 *1 269.1,291.04
X$34336 73 4875 73 57 5754 57 sky130_fd_sc_hd__buf_4
* cell instance $34337 m0 *1 271.86,291.04
X$34337 73 6520 6422 5752 6612 73 6584 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $34338 m0 *1 275.08,291.04
X$34338 73 4614 4299 6612 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34341 m0 *1 278.76,291.04
X$34341 73 4540 6670 4614 6318 73 6586 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $34344 m0 *1 284.28,291.04
X$34344 73 4372 5969 6500 6689 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34345 m0 *1 286.12,291.04
X$34345 73 6344 6521 5964 73 6673 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34347 m0 *1 288.88,291.04
X$34347 73 4614 4622 4781 57 73 6521 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34349 m0 *1 294.4,291.04
X$34349 73 6674 73 57 4967 57 sky130_fd_sc_hd__buf_4
* cell instance $34352 m0 *1 301.76,291.04
X$34352 73 5456 73 57 6522 57 sky130_fd_sc_hd__buf_4
* cell instance $34358 m0 *1 307.74,291.04
X$34358 73 5947 4374 6523 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34359 m0 *1 309.12,291.04
X$34359 73 4374 6522 6523 73 6589 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34373 m0 *1 352.36,291.04
X$34373 73 6524 5315 6676 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34374 m0 *1 353.74,291.04
X$34374 73 6524 5315 5141 6525 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34377 m0 *1 356.96,291.04
X$34377 73 6613 6614 5315 6525 57 73 6508 57 sky130_fd_sc_hd__a31oi_1
* cell instance $34378 m0 *1 359.26,291.04
X$34378 73 5591 6592 5733 6526 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34384 m0 *1 371.68,291.04
X$34384 73 6506 5494 6613 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34388 m0 *1 376.28,291.04
X$34388 73 5204 5399 6256 57 73 6851 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34397 m0 *1 396.52,291.04
X$34397 73 5494 6321 6672 6323 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34398 m0 *1 398.36,291.04
X$34398 73 5670 6530 6529 5352 6616 73 6668 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $34400 m0 *1 402.5,291.04
X$34400 57 15508 6507 6616 5975 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $34404 m0 *1 410.32,291.04
X$34404 73 5494 6067 6529 73 6701 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34406 m0 *1 413.08,291.04
X$34406 57 5670 6617 5600 6394 6585 6668 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $34410 m0 *1 422.28,291.04
X$34410 73 5666 6505 6617 57 73 6583 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34420 m0 *1 445.28,291.04
X$34420 57 6389 6498 6663 5670 6058 6620 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $34421 m0 *1 448.5,291.04
X$34421 73 6349 5308 6313 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34425 m0 *1 457.7,291.04
X$34425 57 6482 6311 6388 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $34426 m0 *1 465.06,291.04
X$34426 73 5676 6622 6384 57 73 6573 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34428 m0 *1 468.74,291.04
X$34428 73 6656 5673 5818 6572 57 6655 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $34444 m0 *1 508.3,291.04
X$34444 73 6076 6533 6567 6571 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34452 m0 *1 530.84,291.04
X$34452 73 6438 73 57 6533 57 sky130_fd_sc_hd__buf_4
* cell instance $34453 m0 *1 533.6,291.04
X$34453 73 6629 73 57 6628 57 sky130_fd_sc_hd__buf_4
* cell instance $34456 m0 *1 539.12,291.04
X$34456 73 5999 6562 6628 6537 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $34457 m0 *1 540.96,291.04
X$34457 73 6562 73 57 6536 57 sky130_fd_sc_hd__buf_4
* cell instance $34458 m0 *1 543.72,291.04
X$34458 73 4905 4906 6562 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34463 m0 *1 554.76,291.04
X$34463 73 6559 73 57 5090 57 sky130_fd_sc_hd__buf_4
* cell instance $34469 m0 *1 571.32,291.04
X$34469 73 5796 73 57 5881 57 sky130_fd_sc_hd__buf_4
* cell instance $34475 m0 *1 582.82,291.04
X$34475 57 6378 6471 6447 5437 4906 6635 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $34476 m0 *1 586.04,291.04
X$34476 73 5500 5090 5503 57 73 6539 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34488 m0 *1 615.48,291.04
X$34488 73 4902 6459 6551 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34491 m0 *1 618.24,291.04
X$34491 73 6551 6723 6552 6549 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34494 m0 *1 622.84,291.04
X$34494 73 6645 6644 6549 4899 5781 73 6187 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $34496 m0 *1 629.74,291.04
X$34496 73 6637 6457 6642 6542 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $34502 m0 *1 638.94,291.04
X$34502 73 5150 6638 6542 6545 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $34511 r0 *1 3.22,291.04
X$34511 73 5650 57 73 6795 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34514 r0 *1 8.28,291.04
X$34514 73 6328 57 73 6800 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34517 r0 *1 13.34,291.04
X$34517 73 6595 6641 6598 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34524 r0 *1 17.94,291.04
X$34524 73 6595 6547 6596 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34525 r0 *1 19.32,291.04
X$34525 73 6596 6722 6595 73 6597 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $34526 r0 *1 22.08,291.04
X$34526 73 6597 73 57 4675 57 sky130_fd_sc_hd__buf_4
* cell instance $34532 r0 *1 38.64,291.04
X$34532 73 4424 73 57 4952 57 sky130_fd_sc_hd__buf_4
* cell instance $34541 r0 *1 57.04,291.04
X$34541 73 6099 4952 5568 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34544 r0 *1 65.78,291.04
X$34544 73 4952 5290 6681 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $34545 r0 *1 68.08,291.04
X$34545 73 4660 73 57 6599 57 sky130_fd_sc_hd__buf_4
* cell instance $34552 r0 *1 74.98,291.04
X$34552 73 4862 73 57 6601 57 sky130_fd_sc_hd__buf_4
* cell instance $34554 r0 *1 78.66,291.04
X$34554 73 6410 6602 6599 5841 6651 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $34555 r0 *1 81.42,291.04
X$34555 73 4675 6600 6651 5801 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $34556 r0 *1 83.26,291.04
X$34556 73 4227 5185 4328 6600 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $34557 r0 *1 85.1,291.04
X$34557 73 6601 5045 4129 6683 57 6728 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $34559 r0 *1 88.32,291.04
X$34559 73 6603 73 57 4218 57 sky130_fd_sc_hd__buf_4
* cell instance $34561 r0 *1 91.54,291.04
X$34561 73 6603 73 57 5289 57 sky130_fd_sc_hd__clkinv_1
* cell instance $34563 r0 *1 93.84,291.04
X$34563 73 6598 6729 3989 73 6603 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $34566 r0 *1 97.52,291.04
X$34566 73 6018 4227 6683 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34570 r0 *1 103.96,291.04
X$34570 73 6602 6683 5571 5535 73 57 6733 57 sky130_fd_sc_hd__o31ai_1
* cell instance $34574 r0 *1 113.16,291.04
X$34574 73 6018 6604 4927 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34576 r0 *1 115.46,291.04
X$34576 73 6152 5045 6604 57 73 6990 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34579 r0 *1 119.6,291.04
X$34579 73 6018 6604 5915 73 6152 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34581 r0 *1 122.36,291.04
X$34581 73 6018 6602 4660 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34582 r0 *1 123.74,291.04
X$34582 73 6018 4286 4366 4129 6735 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $34589 r0 *1 133.86,291.04
X$34589 57 6116 6246 5915 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $34600 r0 *1 161.46,291.04
X$34600 57 6685 4431 4015 6336 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $34610 r0 *1 185.84,291.04
X$34610 73 6658 6659 6416 6565 6049 73 6657 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $34614 r0 *1 195.04,291.04
X$34614 73 6565 73 57 4873 57 sky130_fd_sc_hd__buf_4
* cell instance $34615 r0 *1 197.8,291.04
X$34615 73 4372 6608 6485 6743 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $34620 r0 *1 205.62,291.04
X$34620 73 5934 6746 4781 73 6605 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34621 r0 *1 207.46,291.04
X$34621 73 6662 6049 6605 57 73 6606 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34627 r0 *1 216.66,291.04
X$34627 57 6607 6747 4966 5057 6606 6130 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $34640 r0 *1 247.02,291.04
X$34640 73 6607 6665 6666 57 73 6752 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34644 r0 *1 258.06,291.04
X$34644 73 6657 6610 6214 5057 6754 6759 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $34646 r0 *1 261.28,291.04
X$34646 73 6669 6581 6582 73 6610 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $34651 r0 *1 269.1,291.04
X$34651 73 4711 6252 6611 73 6052 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34652 r0 *1 270.94,291.04
X$34652 73 4372 5180 6754 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34654 r0 *1 274.16,291.04
X$34654 73 5752 5964 4374 6612 57 6843 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $34657 r0 *1 278.3,291.04
X$34657 73 5947 4540 4875 73 6756 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34660 r0 *1 282.44,291.04
X$34660 73 6586 6673 4966 5126 57 6671 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $34668 r0 *1 293.02,291.04
X$34668 73 4785 4875 6690 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34671 r0 *1 295.78,291.04
X$34671 73 4711 4875 6674 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34672 r0 *1 297.16,291.04
X$34672 73 4711 5934 6344 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34695 r0 *1 353.28,291.04
X$34695 73 5141 6676 6675 57 73 5644 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34703 r0 *1 372.14,291.04
X$34703 73 6615 73 57 5762 57 sky130_fd_sc_hd__buf_4
* cell instance $34717 r0 *1 403.88,291.04
X$34717 73 6616 5308 6062 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34718 r0 *1 405.26,291.04
X$34718 73 6507 5315 6699 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34719 r0 *1 406.64,291.04
X$34719 73 6507 73 57 6877 57 sky130_fd_sc_hd__buf_4
* cell instance $34720 r0 *1 409.4,291.04
X$34720 73 5764 6588 6753 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34730 r0 *1 431.48,291.04
X$34730 73 5492 73 57 6618 57 sky130_fd_sc_hd__buf_4
* cell instance $34735 r0 *1 441.14,291.04
X$34735 57 6314 6663 5764 6750 6748 6576 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $34737 r0 *1 446.2,291.04
X$34737 73 5676 6664 6621 73 6744 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34747 r0 *1 464.6,291.04
X$34747 73 6661 6623 5772 6740 57 73 6656 57 sky130_fd_sc_hd__a31oi_1
* cell instance $34750 r0 *1 469.66,291.04
X$34750 73 6655 5818 6624 57 73 6625 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34752 r0 *1 473.34,291.04
X$34752 57 6738 6654 6625 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $34765 r0 *1 508.3,291.04
X$34765 73 6076 6533 6177 6737 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34771 r0 *1 515.66,291.04
X$34771 73 4917 6626 6828 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34774 r0 *1 518.42,291.04
X$34774 73 6627 6628 6076 5811 57 73 6626 57 sky130_fd_sc_hd__a31oi_1
* cell instance $34776 r0 *1 521.64,291.04
X$34776 73 6076 6628 6627 57 73 6631 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34779 r0 *1 529,291.04
X$34779 73 6732 73 57 5878 57 sky130_fd_sc_hd__buf_4
* cell instance $34783 r0 *1 539.12,291.04
X$34783 73 6355 4980 6630 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34785 r0 *1 540.96,291.04
X$34785 73 6630 73 57 5906 57 sky130_fd_sc_hd__buf_4
* cell instance $34789 r0 *1 551.54,291.04
X$34789 73 5906 5090 5999 6631 57 73 6632 57 sky130_fd_sc_hd__a31oi_1
* cell instance $34793 r0 *1 557.06,291.04
X$34793 73 6105 73 57 6652 57 sky130_fd_sc_hd__buf_4
* cell instance $34795 r0 *1 559.82,291.04
X$34795 73 5881 6652 6633 6812 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34798 r0 *1 563.96,291.04
X$34798 57 6650 6714 4899 5150 5904 6440 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $34804 r0 *1 573.62,291.04
X$34804 73 6725 6634 5437 6632 73 6633 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $34806 r0 *1 580.52,291.04
X$34806 73 6649 73 57 5503 57 sky130_fd_sc_hd__buf_4
* cell instance $34816 r0 *1 598.92,291.04
X$34816 73 4998 4899 6724 57 73 6634 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34824 r0 *1 618.24,291.04
X$34824 73 6636 5605 6361 57 73 6723 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34826 r0 *1 621.92,291.04
X$34826 73 5417 6646 6645 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34829 r0 *1 624.22,291.04
X$34829 73 6358 73 57 6642 57 sky130_fd_sc_hd__buf_4
* cell instance $34834 r0 *1 636.64,291.04
X$34834 57 6636 6797 5150 4906 5229 6638 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $34846 m0 *1 10.58,296.48
X$34846 73 4567 73 57 4408 57 sky130_fd_sc_hd__buf_4
* cell instance $34852 m0 *1 19.78,296.48
X$34852 73 7998 3455 73 6722 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $34861 m0 *1 35.42,296.48
X$34861 73 5506 6678 4129 73 7205 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34864 m0 *1 39.56,296.48
X$34864 73 4218 6553 6679 6678 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $34866 m0 *1 41.86,296.48
X$34866 73 4227 4222 5378 57 73 6679 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34871 m0 *1 46.46,296.48
X$34871 73 6099 5471 6680 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34872 m0 *1 47.84,296.48
X$34872 73 6680 73 57 5839 57 sky130_fd_sc_hd__buf_4
* cell instance $34875 m0 *1 53.36,296.48
X$34875 73 6680 6681 6462 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $34894 m0 *1 93.38,296.48
X$34894 73 6730 6682 73 6729 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $34902 m0 *1 109.02,296.48
X$34902 73 4737 5185 4227 6735 57 73 6734 57 sky130_fd_sc_hd__a31oi_1
* cell instance $34909 m0 *1 119.6,296.48
X$34909 57 3455 6684 4705 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $34919 m0 *1 141.22,296.48
X$34919 57 6682 6246 4366 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $34925 m0 *1 156.86,296.48
X$34925 57 3989 4950 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $34929 m0 *1 168.82,296.48
X$34929 57 6742 5963 6685 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $34940 m0 *1 197.8,296.48
X$34940 73 6743 4589 6686 57 73 6687 57 sky130_fd_sc_hd__a21oi_1
* cell instance $34941 m0 *1 199.64,296.48
X$34941 73 4374 5934 4781 73 57 6686 57 sky130_fd_sc_hd__o21ai_1
* cell instance $34942 m0 *1 201.48,296.48
X$34942 73 6687 6745 4540 73 6688 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34948 m0 *1 206.54,296.48
X$34948 73 4589 4540 6746 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $34951 m0 *1 210.22,296.48
X$34951 73 6688 73 57 6755 57 sky130_fd_sc_hd__buf_4
* cell instance $34958 m0 *1 227.24,296.48
X$34958 73 4878 5854 6838 4374 5964 73 6309 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $34979 m0 *1 276.46,296.48
X$34979 73 4540 4873 6756 73 6757 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34984 m0 *1 283.82,296.48
X$34984 57 6671 6760 6689 6846 6759 73 73 57 sky130_fd_sc_hd__or4_4
* cell instance $34987 m0 *1 287.96,296.48
X$34987 73 6761 6037 4540 73 6669 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $34990 m0 *1 294.4,296.48
X$34990 73 6690 73 57 4878 57 sky130_fd_sc_hd__buf_4
* cell instance $35015 m0 *1 352.36,296.48
X$35015 73 5762 5315 6691 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35017 m0 *1 357.42,296.48
X$35017 73 5673 6526 6692 6765 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $35018 m0 *1 359.26,296.48
X$35018 73 5764 6766 5859 57 73 6692 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35024 m0 *1 368.92,296.48
X$35024 73 6694 6691 6703 73 6527 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35025 m0 *1 370.76,296.48
X$35025 73 5551 6691 6348 73 6764 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35028 m0 *1 373.98,296.48
X$35028 73 6258 5308 6695 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35030 m0 *1 376.28,296.48
X$35030 73 6695 73 57 6694 57 sky130_fd_sc_hd__buf_4
* cell instance $35031 m0 *1 379.04,296.48
X$35031 73 6258 5281 6614 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35032 m0 *1 380.42,296.48
X$35032 73 6763 5315 6672 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35033 m0 *1 381.8,296.48
X$35033 73 6672 73 57 5406 57 sky130_fd_sc_hd__buf_4
* cell instance $35034 m0 *1 384.56,296.48
X$35034 73 5670 6529 6764 7426 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $35040 m0 *1 391.46,296.48
X$35040 57 15553 5976 6615 5975 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $35043 m0 *1 396.06,296.48
X$35043 73 5281 6696 6394 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35045 m0 *1 397.9,296.48
X$35045 73 6615 73 57 6616 57 sky130_fd_sc_hd__buf_4
* cell instance $35047 m0 *1 401.12,296.48
X$35047 73 5666 6590 6697 6758 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $35049 m0 *1 403.88,296.48
X$35049 73 6349 6699 5551 6698 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $35050 m0 *1 405.72,296.48
X$35050 73 6698 73 57 6700 57 sky130_fd_sc_hd__buf_4
* cell instance $35051 m0 *1 408.48,296.48
X$35051 73 5399 6701 6702 5764 6697 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $35052 m0 *1 411.24,296.48
X$35052 73 5860 6700 5399 73 6702 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35066 m0 *1 439.76,296.48
X$35066 73 5281 6751 5831 73 5977 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35067 m0 *1 441.6,296.48
X$35067 73 5400 6703 6749 57 73 6748 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35072 m0 *1 447.12,296.48
X$35072 73 5673 6744 6705 73 6624 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35076 m0 *1 449.88,296.48
X$35076 73 6706 6694 6707 57 73 6623 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35080 m0 *1 457.7,296.48
X$35080 57 6709 6201 6354 6707 6703 6708 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $35082 m0 *1 461.38,296.48
X$35082 73 5772 6709 6740 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35086 m0 *1 467.82,296.48
X$35086 73 5315 5676 6618 73 6708 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35088 m0 *1 470.12,296.48
X$35088 73 6739 73 57 5666 57 sky130_fd_sc_hd__inv_1
* cell instance $35096 m0 *1 482.08,296.48
X$35096 73 6736 73 57 2654 57 sky130_fd_sc_hd__buf_4
* cell instance $35112 m0 *1 521.64,296.48
X$35112 73 6992 73 57 6627 57 sky130_fd_sc_hd__buf_4
* cell instance $35116 m0 *1 527.16,296.48
X$35116 73 6078 4980 6711 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35117 m0 *1 528.54,296.48
X$35117 73 6711 6712 4982 73 6732 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35119 m0 *1 530.84,296.48
X$35119 73 6711 73 57 6178 57 sky130_fd_sc_hd__buf_4
* cell instance $35125 m0 *1 539.58,296.48
X$35125 73 5999 5605 6630 57 73 6818 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35128 m0 *1 542.8,296.48
X$35128 57 6727 4982 6712 4918 6731 4899 73 73 57 sky130_fd_sc_hd__o311ai_1
* cell instance $35140 m0 *1 571.32,296.48
X$35140 73 5518 6727 5339 4998 57 6785 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $35145 m0 *1 582.36,296.48
X$35145 73 6726 73 57 6447 57 sky130_fd_sc_hd__buf_4
* cell instance $35154 m0 *1 602.6,296.48
X$35154 73 6716 6715 5505 5991 6724 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $35156 m0 *1 606.74,296.48
X$35156 73 6715 73 57 5321 57 sky130_fd_sc_hd__buf_4
* cell instance $35160 m0 *1 612.26,296.48
X$35160 73 6716 73 57 6459 57 sky130_fd_sc_hd__buf_4
* cell instance $35167 m0 *1 625.14,296.48
X$35167 57 6637 6719 5781 6533 6295 6721 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $35177 m0 *1 644.92,296.48
X$35177 73 6718 57 73 6639 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35184 r0 *1 5.06,296.48
X$35184 73 4216 57 73 6798 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35185 r0 *1 8.74,296.48
X$35185 73 3952 6795 6799 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $35193 r0 *1 20.7,296.48
X$35193 73 6677 57 73 6897 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35205 r0 *1 53.36,296.48
X$35205 73 4227 4286 5653 57 73 6803 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35209 r0 *1 63.02,296.48
X$35209 73 6769 6410 5653 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $35212 r0 *1 69.46,296.48
X$35212 73 4227 6681 4467 57 73 6809 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35216 r0 *1 72.22,296.48
X$35216 73 5841 5568 4467 57 73 6770 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35220 r0 *1 80.04,296.48
X$35220 73 4328 5185 5841 6770 57 73 6899 57 sky130_fd_sc_hd__a31oi_1
* cell instance $35224 r0 *1 88.78,296.48
X$35224 73 5471 73 57 6602 57 sky130_fd_sc_hd__buf_4
* cell instance $35225 r0 *1 91.54,296.48
X$35225 57 5289 4366 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $35230 r0 *1 101.66,296.48
X$35230 73 4286 4927 4705 73 6811 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35232 r0 *1 105.34,296.48
X$35232 73 6410 4424 5378 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35236 r0 *1 115,296.48
X$35236 73 6410 6602 5185 73 6813 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35241 r0 *1 123.74,296.48
X$35241 73 5845 73 57 6814 57 sky130_fd_sc_hd__buf_4
* cell instance $35247 r0 *1 132.02,296.48
X$35247 57 6821 6684 6814 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $35257 r0 *1 157.78,296.48
X$35257 73 6336 6800 6825 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35260 r0 *1 160.54,296.48
X$35260 57 6830 6827 6829 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $35263 r0 *1 172.5,296.48
X$35263 73 5177 73 57 6832 57 sky130_fd_sc_hd__buf_4
* cell instance $35266 r0 *1 178.94,296.48
X$35266 73 6833 73 57 3286 57 sky130_fd_sc_hd__buf_4
* cell instance $35277 r0 *1 206.54,296.48
X$35277 73 5543 73 57 6836 57 sky130_fd_sc_hd__buf_4
* cell instance $35281 r0 *1 217.12,296.48
X$35281 73 6836 6772 4299 73 6747 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35285 r0 *1 224.94,296.48
X$35285 73 4589 5754 6773 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35286 r0 *1 226.32,296.48
X$35286 73 4589 5854 5821 57 73 6772 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35288 r0 *1 230,296.48
X$35288 73 4374 6773 6839 57 73 6838 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35297 r0 *1 242.42,296.48
X$35297 73 4374 4783 6773 57 73 6869 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35306 r0 *1 262.2,296.48
X$35306 73 5940 6922 6755 57 73 6846 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35311 r0 *1 267.26,296.48
X$35311 73 4372 5940 6611 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35315 r0 *1 276.46,296.48
X$35315 73 5855 6757 6842 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35349 r0 *1 352.82,296.48
X$35349 73 5762 5281 6693 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35353 r0 *1 357.42,296.48
X$35353 73 5315 6693 6959 5762 73 6675 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $35356 r0 *1 363.4,296.48
X$35356 73 6255 5308 6778 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35360 r0 *1 370.3,296.48
X$35360 57 15665 6763 6327 5975 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $35368 r0 *1 394.68,296.48
X$35368 73 6062 5204 6696 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $35372 r0 *1 398.36,296.48
X$35372 73 6615 73 57 6852 57 sky130_fd_sc_hd__buf_4
* cell instance $35373 r0 *1 401.12,296.48
X$35373 73 5313 5204 6779 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35379 r0 *1 412.62,296.48
X$35379 73 5630 6693 6850 73 7013 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35384 r0 *1 423.66,296.48
X$35384 73 6164 5308 6062 73 6780 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35386 r0 *1 425.96,296.48
X$35386 73 6700 5939 5772 73 6847 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35394 r0 *1 442.06,296.48
X$35394 73 6694 6265 6019 6704 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $35395 r0 *1 444.82,296.48
X$35395 73 6749 5630 6265 6704 57 73 6781 57 sky130_fd_sc_hd__a31oi_1
* cell instance $35396 r0 *1 447.12,296.48
X$35396 73 6314 6781 6841 73 6621 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35398 r0 *1 449.42,296.48
X$35398 73 6349 5764 5630 6706 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $35404 r0 *1 458.16,296.48
X$35404 73 6782 7423 5764 73 6497 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35408 r0 *1 463.22,296.48
X$35408 73 5772 6741 6837 57 73 6782 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35425 r0 *1 509.68,296.48
X$35425 73 6737 6710 5092 73 6831 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35434 r0 *1 523.94,296.48
X$35434 73 5500 5995 6567 4899 73 57 6710 57 sky130_fd_sc_hd__o31ai_1
* cell instance $35447 r0 *1 556.14,296.48
X$35447 73 6715 6559 6713 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35450 r0 *1 559.36,296.48
X$35450 73 6713 73 57 6275 57 sky130_fd_sc_hd__buf_4
* cell instance $35459 r0 *1 578.22,296.48
X$35459 73 5687 4906 6649 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35462 r0 *1 580.98,296.48
X$35462 73 5321 4906 6726 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35464 r0 *1 583.28,296.48
X$35464 73 6808 5255 6470 6806 57 73 6807 57 sky130_fd_sc_hd__and4_1
* cell instance $35467 r0 *1 588.34,296.48
X$35467 73 6714 73 57 6805 57 sky130_fd_sc_hd__buf_4
* cell instance $35468 r0 *1 591.1,296.48
X$35468 73 5145 4899 4902 6789 57 73 6802 57 sky130_fd_sc_hd__a31oi_1
* cell instance $35469 r0 *1 593.4,296.48
X$35469 73 4902 5505 5224 57 73 6789 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35484 r0 *1 625.6,296.48
X$35484 73 6792 73 57 6636 57 sky130_fd_sc_hd__buf_4
* cell instance $35485 r0 *1 628.36,296.48
X$35485 73 6637 6801 6642 6721 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $35492 r0 *1 643.54,296.48
X$35492 73 6640 57 73 6796 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35499 m0 *1 4.14,301.92
X$35499 73 6768 57 73 6855 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35506 m0 *1 19.32,301.92
X$35506 73 6856 57 73 5471 57 sky130_fd_sc_hd__inv_2
* cell instance $35514 m0 *1 36.34,301.92
X$35514 73 5370 4424 6898 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35515 m0 *1 37.72,301.92
X$35515 73 5471 6099 4222 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $35522 m0 *1 50.14,301.92
X$35522 73 6599 6681 6803 4227 4218 73 6984 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $35534 m0 *1 75.44,301.92
X$35534 73 5471 73 57 6769 57 sky130_fd_sc_hd__buf_4
* cell instance $35536 m0 *1 79.12,301.92
X$35536 73 6099 73 57 5521 57 sky130_fd_sc_hd__buf_4
* cell instance $35538 m0 *1 82.8,301.92
X$35538 73 5839 4227 4675 5378 73 6902 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $35540 m0 *1 85.56,301.92
X$35540 73 6604 4705 6104 73 6900 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35545 m0 *1 94.3,301.92
X$35545 73 4227 5839 5378 57 73 6771 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35550 m0 *1 103.5,301.92
X$35550 73 4218 4471 6771 6904 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $35558 m0 *1 115.92,301.92
X$35558 73 5841 6243 4328 57 73 6907 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35566 m0 *1 136.16,301.92
X$35566 57 6815 6817 3916 6336 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $35570 m0 *1 142.14,301.92
X$35570 57 6477 6817 6822 4381 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $35574 m0 *1 152.26,301.92
X$35574 73 6336 6824 6823 73 6996 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35583 m0 *1 172.5,301.92
X$35583 57 4474 6832 6834 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $35588 m0 *1 186.76,301.92
X$35588 73 5126 4372 6658 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35593 m0 *1 196.88,301.92
X$35593 73 4299 73 57 5964 57 sky130_fd_sc_hd__buf_4
* cell instance $35596 m0 *1 205.16,301.92
X$35596 57 6660 4540 6840 6584 5392 6836 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $35614 m0 *1 245.64,301.92
X$35614 73 6213 6667 4540 6919 57 73 6774 57 sky130_fd_sc_hd__a31oi_1
* cell instance $35615 m0 *1 247.94,301.92
X$35615 73 6775 6579 6053 6774 73 6920 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $35620 m0 *1 258.98,301.92
X$35620 73 4966 5940 6053 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35626 m0 *1 266.8,301.92
X$35626 73 6053 6840 6923 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35627 m0 *1 268.18,301.92
X$35627 73 6611 73 57 6775 57 sky130_fd_sc_hd__buf_4
* cell instance $35630 m0 *1 275.08,301.92
X$35630 73 6775 6843 5854 5964 6842 6925 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $35633 m0 *1 279.22,301.92
X$35633 73 6926 6844 6924 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35634 m0 *1 280.6,301.92
X$35634 73 4540 6776 6926 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35635 m0 *1 281.98,301.92
X$35635 57 5964 6845 5855 6776 6777 6424 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $35642 m0 *1 292.1,301.92
X$35642 73 5855 5934 6690 57 73 6777 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35643 m0 *1 293.94,301.92
X$35643 73 4374 5934 6690 57 73 6761 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35673 m0 *1 361.56,301.92
X$35673 73 6348 6691 6778 5141 73 57 6933 57 sky130_fd_sc_hd__o31ai_1
* cell instance $35676 m0 *1 365.7,301.92
X$35676 73 5141 6849 6766 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35678 m0 *1 367.54,301.92
X$35678 57 6348 6703 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $35683 m0 *1 379.5,301.92
X$35683 73 5281 6851 6936 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35686 m0 *1 385.48,301.92
X$35686 57 6849 6061 6258 5635 6506 6853 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $35694 m0 *1 399.28,301.92
X$35694 73 6321 6779 5281 73 6530 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35697 m0 *1 403.88,301.92
X$35697 73 6703 6699 6694 6940 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $35706 m0 *1 422.28,301.92
X$35706 73 6349 6780 6878 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35709 m0 *1 423.66,301.92
X$35709 73 5310 5831 6848 6349 6700 73 6938 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $35710 m0 *1 426.88,301.92
X$35710 73 5773 6313 6935 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35720 m0 *1 447.58,301.92
X$35720 73 7004 5831 6314 5764 57 73 6841 57 sky130_fd_sc_hd__a31oi_1
* cell instance $35728 m0 *1 463.22,301.92
X$35728 73 6265 5315 6172 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35729 m0 *1 464.6,301.92
X$35729 73 6316 6783 5315 73 6837 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35730 m0 *1 466.44,301.92
X$35730 73 5313 5866 6783 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35732 m0 *1 468.74,301.92
X$35732 73 6739 73 57 5673 57 sky130_fd_sc_hd__buf_4
* cell instance $35739 m0 *1 478.4,301.92
X$35739 73 6835 73 57 5097 57 sky130_fd_sc_hd__buf_4
* cell instance $35756 m0 *1 513.82,301.92
X$35756 57 6820 6826 6831 6569 6828 5092 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $35768 m0 *1 535.9,301.92
X$35768 73 6816 73 57 6819 57 sky130_fd_sc_hd__buf_4
* cell instance $35769 m0 *1 538.66,301.92
X$35769 57 4917 6816 6451 6818 6713 5146 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $35780 m0 *1 558.9,301.92
X$35780 73 6784 6480 6812 6810 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $35784 m0 *1 569.94,301.92
X$35784 73 6986 6785 6786 6887 5253 6784 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $35790 m0 *1 582.82,301.92
X$35790 73 6975 4997 6787 6786 6808 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $35796 m0 *1 588.8,301.92
X$35796 73 6788 5150 6804 6805 57 73 6806 57 sky130_fd_sc_hd__a31oi_1
* cell instance $35797 m0 *1 591.1,301.92
X$35797 73 5321 6802 6982 73 6787 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35808 m0 *1 614.1,301.92
X$35808 73 5417 6636 6716 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $35810 m0 *1 619.16,301.92
X$35810 73 6715 5417 6791 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35811 m0 *1 620.54,301.92
X$35811 73 6791 73 57 5605 57 sky130_fd_sc_hd__buf_4
* cell instance $35814 m0 *1 624.68,301.92
X$35814 73 6791 73 57 6801 57 sky130_fd_sc_hd__buf_4
* cell instance $35822 m0 *1 638.94,301.92
X$35822 73 4899 6719 6797 6892 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $35833 r0 *1 4.14,301.92
X$35833 73 4358 57 73 6893 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35834 r0 *1 7.82,301.92
X$35834 57 6979 6799 6595 6856 73 73 57 sky130_fd_sc_hd__o21ai_4
* cell instance $35836 r0 *1 14.26,301.92
X$35836 73 6595 4992 6857 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35843 r0 *1 19.78,301.92
X$35843 57 6856 4424 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $35844 r0 *1 27.14,301.92
X$35844 73 6595 6897 6863 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35846 r0 *1 30.36,301.92
X$35846 73 6099 4424 5794 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35858 r0 *1 57.96,301.92
X$35858 73 4658 6601 6332 6243 5566 6858 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $35868 r0 *1 78.2,301.92
X$35868 73 4292 6769 6604 73 6859 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35869 r0 *1 80.04,301.92
X$35869 73 4675 6859 4287 73 6861 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35870 r0 *1 81.88,301.92
X$35870 73 6899 4675 4129 6860 57 73 6901 57 sky130_fd_sc_hd__a31oi_1
* cell instance $35871 r0 *1 84.18,301.92
X$35871 73 6861 6902 6900 57 73 6860 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35873 r0 *1 86.48,301.92
X$35873 73 4218 6238 6903 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35882 r0 *1 107.18,301.92
X$35882 73 4218 6733 6905 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35883 r0 *1 108.56,301.92
X$35883 73 4129 6905 6904 57 73 6906 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35886 r0 *1 115.92,301.92
X$35886 73 6907 5841 6813 57 73 6908 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35887 r0 *1 117.76,301.92
X$35887 73 4424 6909 6862 57 73 7024 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35888 r0 *1 119.6,301.92
X$35888 73 4658 6604 6862 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35890 r0 *1 122.82,301.92
X$35890 73 5521 4227 6909 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $35895 r0 *1 126.96,301.92
X$35895 57 1821 5266 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $35897 r0 *1 136.62,301.92
X$35897 73 6336 6863 6864 73 57 6910 57 sky130_fd_sc_hd__o21ai_1
* cell instance $35898 r0 *1 138.46,301.92
X$35898 57 6948 6827 6815 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $35899 r0 *1 145.82,301.92
X$35899 57 6993 6865 4134 6336 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $35900 r0 *1 149.96,301.92
X$35900 73 6950 6821 73 6865 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $35904 r0 *1 154.56,301.92
X$35904 73 6824 3182 73 6864 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $35907 r0 *1 159.16,301.92
X$35907 73 6594 57 73 6912 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35920 r0 *1 191.82,301.92
X$35920 73 4585 5197 6660 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35930 r0 *1 210.22,301.92
X$35930 73 5126 4299 6206 57 73 6915 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35931 r0 *1 212.06,301.92
X$35931 73 5643 4717 5106 57 73 6916 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35932 r0 *1 213.9,301.92
X$35932 57 6916 7005 5754 5643 6773 6836 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $35941 r0 *1 235.06,301.92
X$35941 73 5106 5934 6490 57 73 6868 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35943 r0 *1 237.36,301.92
X$35943 73 5197 4717 6918 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $35944 r0 *1 239.66,301.92
X$35944 73 4374 6773 6918 57 73 6867 57 sky130_fd_sc_hd__a21oi_1
* cell instance $35945 r0 *1 241.5,301.92
X$35945 73 4540 6868 6867 6919 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $35948 r0 *1 247.94,301.92
X$35948 57 7007 6920 6957 6752 73 73 57 sky130_fd_sc_hd__nand3_2
* cell instance $35949 r0 *1 251.62,301.92
X$35949 73 5754 7089 4966 73 6870 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35951 r0 *1 255.3,301.92
X$35951 73 5106 73 57 5855 57 sky130_fd_sc_hd__buf_4
* cell instance $35953 r0 *1 258.98,301.92
X$35953 73 4540 6870 6158 6871 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $35956 r0 *1 261.74,301.92
X$35956 73 6870 6921 7008 5964 6922 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $35962 r0 *1 274.62,301.92
X$35962 73 6845 6871 5488 73 6872 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $35963 r0 *1 276.46,301.92
X$35963 73 6872 6925 6923 6754 6924 73 6873 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $35973 r0 *1 298.08,301.92
X$35973 73 5064 6873 6927 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $35997 r0 *1 357.42,301.92
X$35997 57 6348 5281 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $35998 r0 *1 364.78,301.92
X$35998 57 6933 6934 6874 6396 5635 5141 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $36002 r0 *1 370.3,301.92
X$36002 57 6875 6258 6327 6959 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $36006 r0 *1 378.12,301.92
X$36006 73 6937 5766 5402 6936 57 73 6876 57 sky130_fd_sc_hd__a31oi_1
* cell instance $36009 r0 *1 382.72,301.92
X$36009 73 6875 73 57 5402 57 sky130_fd_sc_hd__buf_4
* cell instance $36013 r0 *1 391.46,301.92
X$36013 73 5315 5281 6853 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $36017 r0 *1 396.98,301.92
X$36017 73 6258 73 57 6354 57 sky130_fd_sc_hd__buf_4
* cell instance $36027 r0 *1 422.28,301.92
X$36027 73 6938 6325 6848 6878 6939 7012 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $36030 r0 *1 427.8,301.92
X$36030 73 6935 6703 6780 57 73 6931 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36036 r0 *1 433.78,301.92
X$36036 73 5764 6847 7009 57 73 6879 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36037 r0 *1 435.62,301.92
X$36037 73 6959 6932 5768 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36038 r0 *1 437,301.92
X$36038 73 5676 6314 6931 6929 73 57 6930 57 sky130_fd_sc_hd__o31ai_1
* cell instance $36039 r0 *1 439.76,301.92
X$36039 73 6879 6930 5673 73 6705 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36041 r0 *1 442.06,301.92
X$36041 73 6314 5764 6880 6969 5308 73 6929 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $36043 r0 *1 445.74,301.92
X$36043 57 6313 6208 6928 6316 5308 5440 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $36044 r0 *1 448.96,301.92
X$36044 73 5440 6316 5308 73 6880 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36052 r0 *1 459.08,301.92
X$36052 73 5866 5817 6917 6580 6124 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $36054 r0 *1 462.76,301.92
X$36054 73 5866 6313 6917 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36066 r0 *1 488.06,301.92
X$36066 73 6914 3431 6881 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $36067 r0 *1 491.28,301.92
X$36067 73 5875 6881 6913 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36069 r0 *1 493.58,301.92
X$36069 73 6913 5875 6790 57 73 6739 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36071 r0 *1 495.88,301.92
X$36071 73 6793 57 73 6995 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36083 r0 *1 524.86,301.92
X$36083 73 6882 6826 6883 73 6911 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36088 r0 *1 532.68,301.92
X$36088 57 6439 6883 6882 6884 6819 5004 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $36089 r0 *1 535.9,301.92
X$36089 73 4917 6885 6079 73 6884 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $36090 r0 *1 538.66,301.92
X$36090 73 5500 6536 6972 57 73 6885 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36101 r0 *1 562.58,301.92
X$36101 73 6886 73 57 5339 57 sky130_fd_sc_hd__buf_4
* cell instance $36123 r0 *1 613.18,301.92
X$36123 73 6366 6716 5613 6896 6889 6890 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $36124 r0 *1 616.4,301.92
X$36124 73 4899 6890 7063 57 73 6788 57 sky130_fd_sc_hd__a21o_1
* cell instance $36132 r0 *1 630.66,301.92
X$36132 73 6896 6637 4906 73 6894 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36136 r0 *1 635.72,301.92
X$36136 73 6804 6892 6090 6895 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $36146 r0 *1 656.88,301.92
X$36146 73 6891 57 73 6790 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36196 m0 *1 5.98,307.36
X$36196 73 6854 57 73 6980 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36198 m0 *1 10.58,307.36
X$36198 57 6979 9255 6942 6116 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $36208 m0 *1 45.54,307.36
X$36208 73 4222 6332 6943 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36209 m0 *1 46.92,307.36
X$36209 73 5566 6943 6983 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36210 m0 *1 48.3,307.36
X$36210 73 6983 5038 4218 6984 57 73 7307 57 sky130_fd_sc_hd__a31oi_1
* cell instance $36228 m0 *1 86.94,307.36
X$36228 57 7207 6989 6903 4259 4218 6901 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $36232 m0 *1 93.38,307.36
X$36232 73 6946 4705 6811 6556 6989 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $36242 m0 *1 115.92,307.36
X$36242 73 6990 6558 6908 4129 6946 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $36247 m0 *1 129.72,307.36
X$36247 57 6991 7070 6947 4427 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $36252 m0 *1 143.52,307.36
X$36252 73 6336 6548 6823 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36253 m0 *1 144.9,307.36
X$36253 57 6950 6827 6993 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36255 m0 *1 153.18,307.36
X$36255 57 6952 6827 6996 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36256 m0 *1 160.54,307.36
X$36256 57 6997 6999 6912 6336 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $36264 m0 *1 176.64,307.36
X$36264 73 6958 6830 6833 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $36266 m0 *1 180.78,307.36
X$36266 73 4950 7033 7001 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36270 m0 *1 188.14,307.36
X$36270 57 6954 7002 7003 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36273 m0 *1 197.8,307.36
X$36273 73 6954 73 57 5979 57 sky130_fd_sc_hd__buf_4
* cell instance $36277 m0 *1 211.6,307.36
X$36277 73 4299 6955 6915 73 6957 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36278 m0 *1 213.44,307.36
X$36278 73 6956 4372 7005 57 73 6955 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36285 m0 *1 228.16,307.36
X$36285 57 4298 6866 6773 4372 4540 7006 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $36288 m0 *1 235.52,307.36
X$36288 73 4372 6868 6869 6956 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $36351 m0 *1 409.4,307.36
X$36351 73 5400 5308 6321 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36353 m0 *1 412.62,307.36
X$36353 57 7011 7013 6321 6753 5764 6965 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $36358 m0 *1 420.9,307.36
X$36358 73 5670 7011 7012 73 7010 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36363 m0 *1 432.86,307.36
X$36363 73 5315 6349 6932 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $36365 m0 *1 437,307.36
X$36365 57 6932 5313 6968 6315 5773 6937 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $36366 m0 *1 440.68,307.36
X$36366 73 6314 5764 6967 6969 5308 73 5867 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $36369 m0 *1 445.28,307.36
X$36369 73 5313 5866 5308 6965 7004 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $36382 m0 *1 477.94,307.36
X$36382 57 6835 6970 7000 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $36386 m0 *1 488.06,307.36
X$36386 57 6998 6970 6173 6995 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $36396 m0 *1 521.18,307.36
X$36396 73 7079 6971 6911 57 73 6994 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36400 m0 *1 529,307.36
X$36400 73 5500 4899 6888 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36401 m0 *1 530.38,307.36
X$36401 73 5500 6992 6972 6731 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $36404 m0 *1 534.98,307.36
X$36404 73 6973 73 57 6629 57 sky130_fd_sc_hd__buf_4
* cell instance $36405 m0 *1 537.74,307.36
X$36405 73 6974 5412 6973 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36410 m0 *1 548.78,307.36
X$36410 73 6109 73 57 6975 57 sky130_fd_sc_hd__buf_4
* cell instance $36416 m0 *1 556.14,307.36
X$36416 73 5500 5778 6988 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36417 m0 *1 557.52,307.36
X$36417 73 6358 6973 6988 5500 4899 73 6987 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $36422 m0 *1 573.62,307.36
X$36422 73 6985 5339 6975 6987 57 6986 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $36423 m0 *1 575.92,307.36
X$36423 57 4917 6985 6792 6275 6976 6649 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $36430 m0 *1 590.64,307.36
X$36430 73 5415 6889 4998 6888 57 6982 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $36434 m0 *1 599.38,307.36
X$36434 73 6971 6882 5886 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36435 m0 *1 600.76,307.36
X$36435 73 6981 73 57 6567 57 sky130_fd_sc_hd__buf_4
* cell instance $36453 m0 *1 645.38,307.36
X$36453 73 7785 57 73 2838 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36460 r0 *1 3.68,307.36
X$36460 73 5037 57 73 7060 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36463 r0 *1 8.74,307.36
X$36463 57 6942 7134 7059 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36466 r0 *1 16.56,307.36
X$36466 73 6942 73 57 4018 57 sky130_fd_sc_hd__buf_4
* cell instance $36480 r0 *1 51.98,307.36
X$36480 73 5794 6944 5566 73 7018 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36481 r0 *1 53.82,307.36
X$36481 73 6944 73 57 6945 57 sky130_fd_sc_hd__buf_4
* cell instance $36484 r0 *1 62.1,307.36
X$36484 73 5290 6769 6944 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36492 r0 *1 74.52,307.36
X$36492 73 6601 4292 4218 6809 57 7068 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $36493 r0 *1 77.28,307.36
X$36493 73 5289 73 57 7064 57 sky130_fd_sc_hd__buf_4
* cell instance $36510 r0 *1 120.98,307.36
X$36510 57 7025 7026 4564 3952 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $36516 r0 *1 127.42,307.36
X$36516 73 7070 6947 7026 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $36522 r0 *1 143.06,307.36
X$36522 57 6817 6948 6950 6821 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $36525 r0 *1 152.26,307.36
X$36525 73 6336 7028 6857 73 7073 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36528 r0 *1 155.02,307.36
X$36528 73 6949 73 57 3682 57 sky130_fd_sc_hd__buf_4
* cell instance $36529 r0 *1 157.78,307.36
X$36529 73 6951 6952 6824 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $36530 r0 *1 161,307.36
X$36530 57 6953 6827 6997 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36531 r0 *1 168.36,307.36
X$36531 73 6999 7031 7028 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $36534 r0 *1 176.18,307.36
X$36534 73 4950 7032 7082 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36536 r0 *1 178.02,307.36
X$36536 73 7081 7083 73 7032 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $36540 r0 *1 182.16,307.36
X$36540 73 7035 73 57 7084 57 sky130_fd_sc_hd__inv_1
* cell instance $36541 r0 *1 183.54,307.36
X$36541 73 7032 7033 7037 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $36543 r0 *1 187.22,307.36
X$36543 73 7037 4950 7038 7003 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $36559 r0 *1 230.46,307.36
X$36559 73 5106 5947 5197 57 73 7006 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36564 r0 *1 237.36,307.36
X$36564 73 5197 4516 6839 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $36569 r0 *1 251.16,307.36
X$36569 57 3999 7030 6999 3959 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $36572 r0 *1 259.9,307.36
X$36572 73 5106 6674 6839 57 73 7040 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36573 r0 *1 261.74,307.36
X$36573 73 7090 7040 4372 73 7008 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36581 r0 *1 278.3,307.36
X$36581 57 2885 4597 7334 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $36583 r0 *1 284.74,307.36
X$36583 57 7093 7041 2788 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36586 r0 *1 292.56,307.36
X$36586 57 3766 7041 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $36587 r0 *1 301.76,307.36
X$36587 73 5561 73 57 7095 57 sky130_fd_sc_hd__buf_4
* cell instance $36589 r0 *1 304.98,307.36
X$36589 57 7096 7041 6927 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36610 r0 *1 358.34,307.36
X$36610 73 6959 5308 6254 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36611 r0 *1 359.72,307.36
X$36611 73 6959 6348 5308 6614 6960 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $36614 r0 *1 365.24,307.36
X$36614 73 6964 5315 7045 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36615 r0 *1 366.62,307.36
X$36615 73 6349 6254 7045 6874 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $36619 r0 *1 370.76,307.36
X$36619 73 6875 6703 6961 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36620 r0 *1 372.14,307.36
X$36620 73 6961 73 57 5455 57 sky130_fd_sc_hd__buf_4
* cell instance $36623 r0 *1 377.2,307.36
X$36623 73 6751 6254 6349 73 6962 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36625 r0 *1 379.96,307.36
X$36625 73 5308 6614 7046 73 7821 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36627 r0 *1 382.26,307.36
X$36627 73 5141 6506 5308 57 73 7046 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36628 r0 *1 384.1,307.36
X$36628 73 5308 6875 7047 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $36629 r0 *1 386.4,307.36
X$36629 73 6875 73 57 6928 57 sky130_fd_sc_hd__buf_4
* cell instance $36630 r0 *1 389.16,307.36
X$36630 73 6258 5315 7099 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36633 r0 *1 394.68,307.36
X$36633 57 7100 6061 6877 5862 6506 6853 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $36640 r0 *1 404.34,307.36
X$36640 57 15639 6963 6852 6959 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $36641 r0 *1 408.94,307.36
X$36641 73 6963 73 57 6506 57 sky130_fd_sc_hd__buf_4
* cell instance $36642 r0 *1 411.7,307.36
X$36642 73 6964 73 57 6066 57 sky130_fd_sc_hd__buf_4
* cell instance $36648 r0 *1 424.58,307.36
X$36648 73 6964 73 57 5773 57 sky130_fd_sc_hd__buf_4
* cell instance $36654 r0 *1 432.86,307.36
X$36654 73 6064 6164 6618 6959 6966 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $36655 r0 *1 435.16,307.36
X$36655 73 6966 7048 6314 73 7009 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36656 r0 *1 437,307.36
X$36656 73 6928 6932 7048 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36659 r0 *1 442.52,307.36
X$36659 57 6969 6164 5773 6349 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $36660 r0 *1 446.2,307.36
X$36660 73 5310 5313 6172 6928 6619 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $36679 r0 *1 488.06,307.36
X$36679 57 7087 6951 6978 5875 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $36692 r0 *1 519.8,307.36
X$36692 73 7080 5339 7077 7163 7079 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $36694 r0 *1 523.94,307.36
X$36694 73 5212 6076 4899 7075 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $36695 r0 *1 525.78,307.36
X$36695 73 6004 6888 5525 73 7074 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36727 r0 *1 602.6,307.36
X$36727 73 5687 4906 6981 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36728 r0 *1 603.98,307.36
X$36728 73 7141 73 57 5793 57 sky130_fd_sc_hd__buf_4
* cell instance $36735 r0 *1 620.54,307.36
X$36735 73 6451 4906 6295 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36740 r0 *1 625.6,307.36
X$36740 73 6636 6085 6295 7061 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $36757 m0 *1 8.74,312.8
X$36757 57 7059 7058 6893 3952 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $36758 m0 *1 12.88,312.8
X$36758 73 6595 7060 7135 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36763 m0 *1 16.56,312.8
X$36763 73 7014 57 73 7072 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36766 m0 *1 22.54,312.8
X$36766 73 7102 57 73 5566 57 sky130_fd_sc_hd__inv_2
* cell instance $36767 m0 *1 23.92,312.8
X$36767 73 7512 73 57 4051 57 sky130_fd_sc_hd__buf_4
* cell instance $36776 m0 *1 37.26,312.8
X$36776 73 5566 6898 6945 7016 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $36779 m0 *1 40.48,312.8
X$36779 73 7016 5332 7064 73 7065 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36785 m0 *1 50.14,312.8
X$36785 73 4287 7065 7017 7021 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $36788 m0 *1 53.36,312.8
X$36788 73 6803 5797 4218 73 7017 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36790 m0 *1 55.66,312.8
X$36790 73 6290 7019 4129 73 7066 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36792 m0 *1 57.96,312.8
X$36792 73 4218 6332 7020 57 73 7019 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36793 m0 *1 59.8,312.8
X$36793 73 6099 6601 7020 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36801 m0 *1 71.76,312.8
X$36801 73 5566 73 57 5841 57 sky130_fd_sc_hd__buf_4
* cell instance $36802 m0 *1 74.52,312.8
X$36802 73 5566 73 57 6604 57 sky130_fd_sc_hd__buf_4
* cell instance $36803 m0 *1 77.28,312.8
X$36803 73 6099 5841 6465 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36805 m0 *1 79.58,312.8
X$36805 73 5163 4218 4129 7068 57 7022 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $36811 m0 *1 90.16,312.8
X$36811 73 4705 7066 6469 57 73 7311 57 sky130_fd_sc_hd__a21oi_1
* cell instance $36814 m0 *1 96.14,312.8
X$36814 73 7022 73 57 6023 57 sky130_fd_sc_hd__buf_4
* cell instance $36821 m0 *1 107.64,312.8
X$36821 73 4287 6193 7021 73 7209 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36823 m0 *1 110.4,312.8
X$36823 73 6734 6906 4259 7023 57 7144 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $36826 m0 *1 115,312.8
X$36826 73 7064 6558 7024 7023 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $36827 m0 *1 116.84,312.8
X$36827 57 6947 6684 7025 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36830 m0 *1 124.2,312.8
X$36830 57 5266 6684 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $36833 m0 *1 136.16,312.8
X$36833 57 7148 7027 7132 4950 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $36835 m0 *1 140.76,312.8
X$36835 73 6817 7185 73 7027 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $36836 m0 *1 143.98,312.8
X$36836 57 6336 7154 6827 7072 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $36839 m0 *1 155.02,312.8
X$36839 57 7107 6827 7073 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36841 m0 *1 162.84,312.8
X$36841 73 7029 7076 7078 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $36844 m0 *1 168.36,312.8
X$36844 73 7030 6999 73 7106 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $36846 m0 *1 173.42,312.8
X$36846 57 7083 7002 7082 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36849 m0 *1 180.78,312.8
X$36849 73 7160 7035 7034 7081 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $36851 m0 *1 183.54,312.8
X$36851 57 15509 7036 7085 7035 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $36852 m0 *1 188.14,312.8
X$36852 57 7032 7039 7036 7001 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $36858 m0 *1 199.64,312.8
X$36858 57 7166 7002 7039 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36864 m0 *1 210.22,312.8
X$36864 73 7165 73 57 312 57 sky130_fd_sc_hd__buf_4
* cell instance $36880 m0 *1 245.18,312.8
X$36880 57 7089 4516 5947 5106 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $36889 m0 *1 261.28,312.8
X$36889 73 5947 5821 7090 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36894 m0 *1 275.54,312.8
X$36894 73 7167 73 57 188 57 sky130_fd_sc_hd__buf_4
* cell instance $36896 m0 *1 278.76,312.8
X$36896 57 7091 4597 2885 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $36897 m0 *1 284.74,312.8
X$36897 57 7094 7041 7092 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36900 m0 *1 292.1,312.8
X$36900 57 7041 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $36912 m0 *1 323.38,312.8
X$36912 73 7042 73 57 6999 57 sky130_fd_sc_hd__buf_4
* cell instance $36914 m0 *1 327.06,312.8
X$36914 73 6953 7043 73 7042 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $36920 m0 *1 335.8,312.8
X$36920 57 7043 4970 7044 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $36928 m0 *1 353.74,312.8
X$36928 73 6325 6765 7097 7172 73 57 7044 57 sky130_fd_sc_hd__o31ai_1
* cell instance $36933 m0 *1 362.02,312.8
X$36933 73 6058 6221 7503 7097 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $36942 m0 *1 382.72,312.8
X$36942 73 6509 73 57 6751 57 sky130_fd_sc_hd__buf_4
* cell instance $36943 m0 *1 385.48,312.8
X$36943 73 7047 73 57 6257 57 sky130_fd_sc_hd__buf_4
* cell instance $36953 m0 *1 401.58,312.8
X$36953 57 15570 6964 6852 6959 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $36956 m0 *1 407.56,312.8
X$36956 57 15510 7176 6852 6349 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $36957 m0 *1 412.16,312.8
X$36957 73 6852 73 57 5866 57 sky130_fd_sc_hd__buf_4
* cell instance $36966 m0 *1 422.74,312.8
X$36966 73 5673 7010 5766 73 7175 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $36969 m0 *1 425.96,312.8
X$36969 73 7098 73 57 5975 57 sky130_fd_sc_hd__inv_1
* cell instance $36982 m0 *1 455.86,312.8
X$36982 73 6703 5676 6707 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $36986 m0 *1 465.06,312.8
X$36986 73 5308 7170 6967 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $36997 m0 *1 482.08,312.8
X$36997 57 6383 6654 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $36998 m0 *1 491.28,312.8
X$36998 73 7086 73 57 6951 57 sky130_fd_sc_hd__buf_4
* cell instance $37009 m0 *1 511.06,312.8
X$37009 73 6178 6176 7050 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37010 m0 *1 512.44,312.8
X$37010 73 7049 7050 4899 73 7164 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37013 m0 *1 521.64,312.8
X$37013 73 7074 5678 7075 7161 4980 7162 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $37023 m0 *1 537.74,312.8
X$37023 73 7051 73 57 6974 57 sky130_fd_sc_hd__buf_4
* cell instance $37025 m0 *1 541.42,312.8
X$37025 73 7051 5412 6712 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37036 m0 *1 562.58,312.8
X$37036 73 7152 7067 5145 57 73 5986 57 sky130_fd_sc_hd__a21o_1
* cell instance $37048 m0 *1 585.58,312.8
X$37048 73 6971 7069 6804 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37054 m0 *1 600.76,312.8
X$37054 73 4917 6981 7128 73 7053 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37055 m0 *1 602.6,312.8
X$37055 73 6804 4998 7053 5224 7067 73 7883 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $37060 m0 *1 612.26,312.8
X$37060 73 7054 73 57 4902 57 sky130_fd_sc_hd__buf_4
* cell instance $37064 m0 *1 615.48,312.8
X$37064 73 5611 73 57 6889 57 sky130_fd_sc_hd__buf_4
* cell instance $37065 m0 *1 618.24,312.8
X$37065 73 6085 6981 7055 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37068 m0 *1 621,312.8
X$37068 73 7055 6637 4899 7062 57 7063 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $37069 m0 *1 623.76,312.8
X$37069 73 6637 6372 5236 57 73 7062 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37072 m0 *1 628.36,312.8
X$37072 73 4902 7049 5782 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37075 m0 *1 631.12,312.8
X$37075 73 7052 73 57 6285 57 sky130_fd_sc_hd__buf_4
* cell instance $37090 r0 *1 2.76,312.8
X$37090 73 7131 57 73 7132 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37091 r0 *1 6.44,312.8
X$37091 73 6941 57 73 7138 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37092 r0 *1 10.12,312.8
X$37092 57 7134 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $37098 r0 *1 17.02,312.8
X$37098 73 7135 7136 6595 57 73 7102 57 sky130_fd_sc_hd__o21a_2
* cell instance $37099 r0 *1 20.24,312.8
X$37099 57 7102 4227 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $37126 r0 *1 79.58,312.8
X$37126 73 6465 5252 5841 57 73 7142 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37143 r0 *1 118.22,312.8
X$37143 73 3952 5784 7147 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37146 r0 *1 123.74,312.8
X$37146 73 6684 73 57 15427 57 sky130_fd_sc_hd__clkinvlp_4
* cell instance $37153 r0 *1 128.34,312.8
X$37153 73 3952 7070 7147 73 7149 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37154 r0 *1 130.18,312.8
X$37154 57 7151 6684 7149 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37156 r0 *1 138,312.8
X$37156 57 6822 6684 7148 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37159 r0 *1 146.74,312.8
X$37159 73 4765 57 73 7104 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37160 r0 *1 150.42,312.8
X$37160 73 7071 57 73 7217 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37166 r0 *1 155.02,312.8
X$37166 57 7153 7105 7104 6336 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $37167 r0 *1 159.16,312.8
X$37167 57 7158 6827 7156 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37168 r0 *1 166.52,312.8
X$37168 73 7107 7158 73 7030 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $37170 r0 *1 171.58,312.8
X$37170 57 7160 7002 7001 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37175 r0 *1 179.86,312.8
X$37175 73 7002 73 57 57 sky130_fd_sc_hd__clkinv_2
* cell instance $37178 r0 *1 183.08,312.8
X$37178 57 15609 7108 7034 7084 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $37180 r0 *1 188.6,312.8
X$37180 57 7032 7109 7108 7001 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $37181 r0 *1 190.9,312.8
X$37181 73 7034 73 57 7085 57 sky130_fd_sc_hd__inv_1
* cell instance $37182 r0 *1 192.28,312.8
X$37182 73 7111 7110 73 7105 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $37185 r0 *1 198.26,312.8
X$37185 57 7169 7002 7109 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37221 r0 *1 274.62,312.8
X$37221 57 7167 7764 7112 2891 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $37223 r0 *1 283.82,312.8
X$37223 73 4950 7029 7168 73 7092 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37224 r0 *1 285.66,312.8
X$37224 73 4950 62 7168 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37233 r0 *1 294.4,312.8
X$37233 73 7166 3376 73 7113 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $37237 r0 *1 305.9,312.8
X$37237 73 7113 73 57 7088 57 sky130_fd_sc_hd__buf_4
* cell instance $37251 r0 *1 339.48,312.8
X$37251 73 6034 73 57 7171 57 sky130_fd_sc_hd__buf_4
* cell instance $37263 r0 *1 357.42,312.8
X$37263 73 7343 5670 6058 5590 73 7172 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $37271 r0 *1 372.14,312.8
X$37271 73 6763 73 57 5662 57 sky130_fd_sc_hd__buf_4
* cell instance $37283 r0 *1 396.52,312.8
X$37283 73 6959 6853 7173 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37288 r0 *1 403.42,312.8
X$37288 73 6779 6959 6937 57 73 7241 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37291 r0 *1 407.56,312.8
X$37291 73 6963 5315 7177 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37301 r0 *1 423.2,312.8
X$37301 73 6583 7175 7432 5766 7116 57 73 57 sky130_fd_sc_hd__o22a_1
* cell instance $37302 r0 *1 426.42,312.8
X$37302 73 6964 5308 6016 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37308 r0 *1 432.86,312.8
X$37308 73 6064 6877 6618 5866 6750 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $37309 r0 *1 435.16,312.8
X$37309 57 4794 7117 7116 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37313 r0 *1 448.96,312.8
X$37313 73 5866 5315 6749 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37319 r0 *1 453.1,312.8
X$37319 73 5866 6349 6965 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37322 r0 *1 455.86,312.8
X$37322 73 5676 7118 7232 73 7119 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37324 r0 *1 458.16,312.8
X$37324 73 5673 7119 6120 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37327 r0 *1 460.92,312.8
X$37327 73 5976 6265 7120 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37329 r0 *1 464.14,312.8
X$37329 73 6354 6265 7120 73 7170 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37332 r0 *1 470.12,312.8
X$37332 57 7121 6654 7122 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37336 r0 *1 477.48,312.8
X$37336 73 7088 7121 7123 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $37339 r0 *1 482.08,312.8
X$37339 73 6654 57 73 57 sky130_fd_sc_hd__clkinv_4
* cell instance $37341 r0 *1 485.76,312.8
X$37341 73 5875 7123 7133 73 7122 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37342 r0 *1 487.6,312.8
X$37342 57 7124 6654 7087 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37355 r0 *1 517.04,312.8
X$37355 73 7145 7164 7163 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37359 r0 *1 526.7,312.8
X$37359 73 4917 7128 7161 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37361 r0 *1 528.54,312.8
X$37361 73 5497 4980 6992 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37369 r0 *1 538.66,312.8
X$37369 73 6109 4984 7157 73 7159 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37373 r0 *1 542.34,312.8
X$37373 73 6712 73 57 7155 57 sky130_fd_sc_hd__buf_4
* cell instance $37374 r0 *1 545.1,312.8
X$37374 73 7052 73 57 7157 57 sky130_fd_sc_hd__buf_4
* cell instance $37375 r0 *1 547.86,312.8
X$37375 73 5092 4906 7052 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37377 r0 *1 552.92,312.8
X$37377 73 5146 73 57 7143 57 sky130_fd_sc_hd__buf_4
* cell instance $37389 r0 *1 570.86,312.8
X$37389 73 6972 7127 7146 5500 6439 73 7145 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $37390 r0 *1 574.08,312.8
X$37390 73 5998 73 57 7127 57 sky130_fd_sc_hd__buf_4
* cell instance $37411 r0 *1 614.1,312.8
X$37411 73 5687 73 57 6896 57 sky130_fd_sc_hd__buf_4
* cell instance $37412 r0 *1 616.86,312.8
X$37412 57 7140 7055 5991 5995 6636 5415 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $37417 r0 *1 623.76,312.8
X$37417 73 7129 7127 6636 7061 57 73 7137 57 sky130_fd_sc_hd__a31oi_1
* cell instance $37419 r0 *1 629.74,312.8
X$37419 73 7139 6896 7129 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $37422 r0 *1 634.8,312.8
X$37422 73 6636 6283 7129 6638 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $37429 r0 *1 642.62,312.8
X$37429 73 6998 6796 7133 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37437 r0 *1 654.12,312.8
X$37437 73 7057 57 73 7298 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37441 m0 *1 4.14,318.24
X$37441 73 7101 57 73 7299 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37443 m0 *1 8.28,318.24
X$37443 57 6595 7204 7134 6855 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $37446 m0 *1 23.46,318.24
X$37446 73 3952 73 57 6595 57 sky130_fd_sc_hd__buf_4
* cell instance $37460 m0 *1 58.88,318.24
X$37460 73 6555 5910 7064 7020 73 7206 57 57 sky130_fd_sc_hd__nand4b_1
* cell instance $37476 m0 *1 109.48,318.24
X$37476 73 7209 4259 4705 7144 57 7182 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $37479 m0 *1 113.16,318.24
X$37479 57 7103 6684 7210 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37482 m0 *1 124.66,318.24
X$37482 73 7103 7183 73 7212 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $37483 m0 *1 127.88,318.24
X$37483 57 7211 7212 6550 7214 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $37484 m0 *1 132.02,318.24
X$37484 57 7070 7103 7151 7184 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $37486 m0 *1 140.76,318.24
X$37486 73 6822 73 57 7185 57 sky130_fd_sc_hd__buf_4
* cell instance $37488 m0 *1 145.36,318.24
X$37488 73 6948 73 57 7216 57 sky130_fd_sc_hd__buf_4
* cell instance $37489 m0 *1 148.12,318.24
X$37489 57 7215 7078 4807 4950 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $37490 m0 *1 152.26,318.24
X$37490 57 5266 6827 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $37491 m0 *1 161.46,318.24
X$37491 57 7156 7106 7217 6336 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $37495 m0 *1 168.36,318.24
X$37495 73 7107 73 57 7031 57 sky130_fd_sc_hd__buf_4
* cell instance $37496 m0 *1 171.12,318.24
X$37496 73 6950 73 57 7186 57 sky130_fd_sc_hd__buf_4
* cell instance $37499 m0 *1 176.18,318.24
X$37499 73 4950 7034 7218 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37501 m0 *1 178.02,318.24
X$37501 73 7220 7160 7033 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $37502 m0 *1 181.24,318.24
X$37502 57 7187 7038 7085 7084 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $37504 m0 *1 186.76,318.24
X$37504 57 7222 7221 7036 7032 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $37505 m0 *1 190.44,318.24
X$37505 57 7223 7038 7108 7032 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $37511 m0 *1 198.72,318.24
X$37511 57 7165 7111 7110 2627 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $37524 m0 *1 234.14,318.24
X$37524 57 7226 3767 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $37542 m0 *1 284.74,318.24
X$37542 57 7029 7169 7093 7094 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $37570 m0 *1 364.32,318.24
X$37570 57 7233 6707 6964 7114 5662 7189 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $37571 m0 *1 367.54,318.24
X$37571 73 6349 5308 7189 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37572 m0 *1 368.92,318.24
X$37572 73 7189 73 57 6937 57 sky130_fd_sc_hd__buf_4
* cell instance $37573 m0 *1 371.68,318.24
X$37573 73 6703 5308 7190 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37574 m0 *1 373.06,318.24
X$37574 73 5662 7190 7234 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37575 m0 *1 374.44,318.24
X$37575 73 7190 73 57 6061 57 sky130_fd_sc_hd__buf_4
* cell instance $37577 m0 *1 378.12,318.24
X$37577 73 5308 6964 6703 57 73 7191 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37578 m0 *1 379.96,318.24
X$37578 73 5764 5862 7191 7235 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $37581 m0 *1 385.02,318.24
X$37581 73 5455 6964 6703 57 73 7174 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37585 m0 *1 390.08,318.24
X$37585 73 6061 5400 5141 7237 57 7238 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $37586 m0 *1 392.84,318.24
X$37586 73 6349 6848 5310 7114 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $37588 m0 *1 395.14,318.24
X$37588 73 6959 6696 7173 5141 7240 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $37590 m0 *1 398.36,318.24
X$37590 73 7173 5766 7234 6064 6354 73 7115 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $37593 m0 *1 402.96,318.24
X$37593 73 5766 7241 7115 73 7118 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37596 m0 *1 407.1,318.24
X$37596 73 7177 73 57 5451 57 sky130_fd_sc_hd__buf_4
* cell instance $37598 m0 *1 410.32,318.24
X$37598 73 5308 7174 7239 5766 6622 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $37606 m0 *1 422.74,318.24
X$37606 73 6325 5773 6703 57 73 7236 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37608 m0 *1 426.42,318.24
X$37608 73 6964 5308 6019 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37609 m0 *1 427.8,318.24
X$37609 73 6019 73 57 6070 57 sky130_fd_sc_hd__buf_4
* cell instance $37610 m0 *1 430.56,318.24
X$37610 73 7098 73 57 6959 57 sky130_fd_sc_hd__buf_4
* cell instance $37613 m0 *1 435.62,318.24
X$37613 73 7098 73 57 5313 57 sky130_fd_sc_hd__buf_4
* cell instance $37621 m0 *1 454.02,318.24
X$37621 57 7117 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $37622 m0 *1 465.06,318.24
X$37622 73 5308 6965 7120 57 73 7230 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37630 m0 *1 483.46,318.24
X$37630 57 7086 7123 7124 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $37631 m0 *1 489.44,318.24
X$37631 57 7228 2234 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $37646 m0 *1 527.62,318.24
X$37646 73 6992 6078 7192 57 73 7125 57 sky130_fd_sc_hd__a21boi_0
* cell instance $37647 m0 *1 530.38,318.24
X$37647 73 4899 7125 4984 5525 5500 7193 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $37648 m0 *1 533.6,318.24
X$37648 73 7194 73 57 6078 57 sky130_fd_sc_hd__buf_4
* cell instance $37652 m0 *1 541.42,318.24
X$37652 57 6109 7673 4906 6792 7126 7195 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $37653 m0 *1 544.64,318.24
X$37653 73 7195 73 57 4989 57 sky130_fd_sc_hd__buf_4
* cell instance $37654 m0 *1 547.4,318.24
X$37654 73 7126 73 57 7219 57 sky130_fd_sc_hd__buf_4
* cell instance $37656 m0 *1 550.62,318.24
X$37656 73 6792 7219 7155 7150 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $37664 m0 *1 565.34,318.24
X$37664 73 7067 73 57 6635 57 sky130_fd_sc_hd__buf_4
* cell instance $37667 m0 *1 569.48,318.24
X$37667 57 4917 6887 6975 7150 7198 7197 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $37668 m0 *1 572.7,318.24
X$37668 73 7198 73 57 7146 57 sky130_fd_sc_hd__buf_4
* cell instance $37669 m0 *1 575.46,318.24
X$37669 73 6637 6726 7213 7198 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $37671 m0 *1 577.76,318.24
X$37671 73 7213 73 57 5995 57 sky130_fd_sc_hd__buf_4
* cell instance $37677 m0 *1 586.5,318.24
X$37677 73 7143 73 57 7199 57 sky130_fd_sc_hd__buf_4
* cell instance $37678 m0 *1 589.26,318.24
X$37678 73 7054 5415 5222 7199 73 7291 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $37681 m0 *1 596.62,318.24
X$37681 73 4905 6637 7067 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37682 m0 *1 598,318.24
X$37682 73 5417 73 57 7139 57 sky130_fd_sc_hd__buf_4
* cell instance $37685 m0 *1 604.9,318.24
X$37685 73 7054 4906 7141 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37687 m0 *1 606.74,318.24
X$37687 73 7141 73 57 7126 57 sky130_fd_sc_hd__buf_4
* cell instance $37691 m0 *1 617.32,318.24
X$37691 73 5606 73 57 6646 57 sky130_fd_sc_hd__buf_4
* cell instance $37693 m0 *1 621.92,318.24
X$37693 73 7463 4906 6644 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37695 m0 *1 624.22,318.24
X$37695 73 6371 5150 7139 7305 57 7203 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $37698 m0 *1 631.58,318.24
X$37698 73 7203 73 57 5888 57 sky130_fd_sc_hd__buf_4
* cell instance $37704 m0 *1 644.92,318.24
X$37704 73 7130 57 73 7202 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37710 r0 *1 3.22,318.24
X$37710 73 6767 57 73 7297 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37711 r0 *1 6.9,318.24
X$37711 57 5266 7134 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $37715 r0 *1 16.56,318.24
X$37715 73 6595 7299 7178 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37716 r0 *1 17.94,318.24
X$37716 57 7136 7304 7245 5381 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $37723 r0 *1 40.94,318.24
X$37723 73 4287 6375 7308 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37731 r0 *1 48.3,318.24
X$37731 73 7246 4129 7307 57 73 7309 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37735 r0 *1 53.36,318.24
X$37735 73 7018 5910 7247 4259 57 73 7179 57 sky130_fd_sc_hd__a31oi_1
* cell instance $37738 r0 *1 57.04,318.24
X$37738 73 7205 7388 7179 7180 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $37740 r0 *1 60.72,318.24
X$37740 73 4259 7309 7206 7248 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $37754 r0 *1 89.24,318.24
X$37754 73 7207 4259 7315 57 73 7181 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37762 r0 *1 101.2,318.24
X$37762 73 7248 7180 4705 7182 57 73 7210 57 sky130_fd_sc_hd__a31oi_1
* cell instance $37766 r0 *1 106.72,318.24
X$37766 57 5809 6684 7181 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37777 r0 *1 129.26,318.24
X$37777 57 7184 6684 7211 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37780 r0 *1 139.38,318.24
X$37780 73 7184 73 57 7183 57 sky130_fd_sc_hd__buf_4
* cell instance $37781 r0 *1 142.14,318.24
X$37781 73 7151 73 57 7250 57 sky130_fd_sc_hd__buf_4
* cell instance $37783 r0 *1 146.74,318.24
X$37783 57 7251 6827 7215 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37788 r0 *1 155.48,318.24
X$37788 57 7110 6827 7153 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37790 r0 *1 164.68,318.24
X$37790 73 7262 7324 7255 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $37792 r0 *1 168.82,318.24
X$37792 57 7034 7002 7218 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37793 r0 *1 176.18,318.24
X$37793 73 7326 7038 7032 57 73 7257 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37794 r0 *1 178.02,318.24
X$37794 73 7220 7160 73 7258 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $37799 r0 *1 182.16,318.24
X$37799 73 7187 7258 7032 7328 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $37800 r0 *1 184,318.24
X$37800 57 5266 7002 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $37801 r0 *1 193.2,318.24
X$37801 57 7260 7002 4950 73 73 57 sky130_fd_sc_hd__dfxtp_4
* cell instance $37808 r0 *1 210.22,318.24
X$37808 57 7227 7002 5384 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37809 r0 *1 217.58,318.24
X$37809 57 7263 7188 7224 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37813 r0 *1 230.92,318.24
X$37813 73 7188 73 57 15430 57 sky130_fd_sc_hd__clkinvlp_4
* cell instance $37820 r0 *1 237.36,318.24
X$37820 57 7261 7263 2974 7268 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $37835 r0 *1 280.6,318.24
X$37835 73 7334 73 57 7337 57 sky130_fd_sc_hd__buf_4
* cell instance $37844 r0 *1 293.02,318.24
X$37844 57 7340 7333 7539 7541 7341 7339 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $37846 r0 *1 297.16,318.24
X$37846 73 7094 73 57 7229 57 sky130_fd_sc_hd__buf_4
* cell instance $37871 r0 *1 350.52,318.24
X$37871 73 6953 73 57 7909 57 sky130_fd_sc_hd__buf_4
* cell instance $37876 r0 *1 364.78,318.24
X$37876 73 7233 5141 6934 5764 7344 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $37884 r0 *1 377.2,318.24
X$37884 73 6763 6064 6962 73 7425 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37888 r0 *1 385.02,318.24
X$37888 73 6349 7047 7099 57 73 7237 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37899 r0 *1 410.32,318.24
X$37899 73 7176 5308 7239 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37900 r0 *1 411.7,318.24
X$37900 73 6877 6061 7504 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37903 r0 *1 420.44,318.24
X$37903 73 5976 73 57 7455 57 sky130_fd_sc_hd__buf_4
* cell instance $37913 r0 *1 433.32,318.24
X$37913 73 7177 73 57 7280 57 sky130_fd_sc_hd__buf_4
* cell instance $37919 r0 *1 446.66,318.24
X$37919 73 5315 7276 7282 5772 5868 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $37923 r0 *1 451.26,318.24
X$37923 73 5976 5308 7345 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $37927 r0 *1 455.86,318.24
X$37927 73 5676 7231 7342 7232 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $37932 r0 *1 464.14,318.24
X$37932 73 5676 7230 7282 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37937 r0 *1 472.42,318.24
X$37937 57 4002 7117 5313 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $37944 r0 *1 489.44,318.24
X$37944 57 7284 6914 7202 5875 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $37956 r0 *1 517.96,318.24
X$37956 57 7225 7080 7162 7487 6115 5092 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $37960 r0 *1 530.38,318.24
X$37960 73 5525 7196 5092 73 7225 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $37966 r0 *1 537.28,318.24
X$37966 73 7194 7051 7195 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $37970 r0 *1 542.8,318.24
X$37970 57 2390 6383 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $37971 r0 *1 552,318.24
X$37971 57 7327 5412 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $37974 r0 *1 559.36,318.24
X$37974 57 7327 5417 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $37984 r0 *1 582.82,318.24
X$37984 73 7069 7208 7317 6379 6971 73 7303 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $37989 r0 *1 590.64,318.24
X$37989 73 7732 7291 5227 7054 4917 7208 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $37995 r0 *1 605.36,318.24
X$37995 73 5150 7293 7067 57 73 7305 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37998 r0 *1 609.5,318.24
X$37998 73 7200 4917 6085 57 73 7196 57 sky130_fd_sc_hd__a21oi_1
* cell instance $37999 r0 *1 611.34,318.24
X$37999 73 6792 4917 7200 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38010 r0 *1 625.14,318.24
X$38010 73 7294 73 57 6371 57 sky130_fd_sc_hd__buf_4
* cell instance $38013 r0 *1 635.26,318.24
X$38013 57 7303 7301 6895 6455 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $38018 r0 *1 639.86,318.24
X$38018 57 6998 7300 6383 7298 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $38024 m0 *1 2.76,323.68
X$38024 73 7243 57 73 7436 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38026 m0 *1 7.36,323.68
X$38026 57 6595 7302 7134 7297 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $38029 m0 *1 18.86,323.68
X$38029 57 7245 7134 7244 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38031 m0 *1 27.14,323.68
X$38031 73 7245 73 57 7306 57 sky130_fd_sc_hd__buf_4
* cell instance $38054 m0 *1 83.26,323.68
X$38054 73 7308 7313 4218 73 7314 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38058 m0 *1 88.32,323.68
X$38058 73 7311 4705 7314 7312 7315 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $38062 m0 *1 98.9,323.68
X$38062 57 3952 3989 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $38073 m0 *1 126.5,323.68
X$38073 57 7395 7397 5890 7214 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $38076 m0 *1 132.02,323.68
X$38076 73 7316 73 57 3598 57 sky130_fd_sc_hd__buf_4
* cell instance $38078 m0 *1 136.62,323.68
X$38078 73 5181 57 73 7319 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38082 m0 *1 142.14,323.68
X$38082 57 7320 7321 7319 4950 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $38084 m0 *1 148.12,323.68
X$38084 57 7321 7029 7251 7322 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $38086 m0 *1 156.4,323.68
X$38086 57 7323 6827 7253 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38087 m0 *1 163.76,323.68
X$38087 57 7253 7255 6980 7214 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $38089 m0 *1 168.36,323.68
X$38089 57 7035 7002 7256 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38090 m0 *1 175.72,323.68
X$38090 57 15532 7220 7034 7035 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $38092 m0 *1 180.32,323.68
X$38092 73 7032 7258 7221 7328 57 73 7357 57 sky130_fd_sc_hd__a31oi_1
* cell instance $38093 m0 *1 182.62,323.68
X$38093 73 4950 7187 7256 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $38094 m0 *1 184.92,323.68
X$38094 73 7187 7032 7326 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38095 m0 *1 186.3,323.68
X$38095 73 4950 7258 7257 7404 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38097 m0 *1 188.6,323.68
X$38097 73 4950 7258 7223 7445 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38098 m0 *1 190.44,323.68
X$38098 73 4950 7258 7222 7224 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38105 m0 *1 198.72,323.68
X$38105 57 7260 4428 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $38113 m0 *1 220.34,323.68
X$38113 73 7261 73 57 7262 57 sky130_fd_sc_hd__buf_4
* cell instance $38117 m0 *1 226.32,323.68
X$38117 73 7264 7267 7266 73 57 7490 57 sky130_fd_sc_hd__o21bai_1
* cell instance $38119 m0 *1 230.92,323.68
X$38119 57 3766 7188 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $38123 m0 *1 241.5,323.68
X$38123 73 4950 7262 2786 73 7331 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38124 m0 *1 243.34,323.68
X$38124 57 7268 7188 7331 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38139 m0 *1 281.06,323.68
X$38139 73 7996 73 57 7335 57 sky130_fd_sc_hd__buf_4
* cell instance $38140 m0 *1 283.82,323.68
X$38140 73 7338 7335 7333 7336 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38174 m0 *1 364.78,323.68
X$38174 73 7273 6580 6058 7344 57 7343 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $38181 m0 *1 383.18,323.68
X$38181 73 7274 6164 6349 57 73 7276 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38193 m0 *1 410.78,323.68
X$38193 73 7279 73 57 7273 57 sky130_fd_sc_hd__buf_4
* cell instance $38200 m0 *1 424.12,323.68
X$38200 73 6703 7348 6016 7815 73 57 7279 57 sky130_fd_sc_hd__o31ai_1
* cell instance $38203 m0 *1 428.26,323.68
X$38203 73 5676 73 57 6848 57 sky130_fd_sc_hd__buf_4
* cell instance $38207 m0 *1 442.06,323.68
X$38207 73 6265 6694 7280 7347 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38210 m0 *1 444.82,323.68
X$38210 73 6058 5676 7281 57 73 6620 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38211 m0 *1 446.66,323.68
X$38211 73 7282 73 57 7346 57 sky130_fd_sc_hd__buf_4
* cell instance $38215 m0 *1 452.18,323.68
X$38215 73 6349 7424 5676 73 6387 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38216 m0 *1 454.02,323.68
X$38216 57 4970 7117 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $38226 m0 *1 480.7,323.68
X$38226 73 7283 6012 73 5155 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $38230 m0 *1 487.14,323.68
X$38230 57 7286 6654 7284 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38231 m0 *1 494.5,323.68
X$38231 73 7286 73 57 7376 57 sky130_fd_sc_hd__buf_4
* cell instance $38242 m0 *1 523.48,323.68
X$38242 73 7287 73 57 6437 57 sky130_fd_sc_hd__buf_4
* cell instance $38247 m0 *1 529.92,323.68
X$38247 73 7330 73 57 4980 57 sky130_fd_sc_hd__buf_4
* cell instance $38250 m0 *1 533.6,323.68
X$38250 73 7329 73 57 6176 57 sky130_fd_sc_hd__buf_4
* cell instance $38253 m0 *1 537.74,323.68
X$38253 73 5412 73 57 7192 57 sky130_fd_sc_hd__buf_4
* cell instance $38262 m0 *1 556.14,323.68
X$38262 73 7051 7325 7288 5998 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $38264 m0 *1 558.44,323.68
X$38264 73 7289 7325 7288 6361 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $38265 m0 *1 560.74,323.68
X$38265 73 7289 73 57 5212 57 sky130_fd_sc_hd__buf_4
* cell instance $38269 m0 *1 568.56,323.68
X$38269 73 7290 73 57 5497 57 sky130_fd_sc_hd__buf_4
* cell instance $38270 m0 *1 571.32,323.68
X$38270 73 7290 73 57 5611 57 sky130_fd_sc_hd__buf_4
* cell instance $38271 m0 *1 574.08,323.68
X$38271 73 5412 73 57 7318 57 sky130_fd_sc_hd__buf_4
* cell instance $38283 m0 *1 599.84,323.68
X$38283 73 7292 7139 4917 73 7197 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38284 m0 *1 601.68,323.68
X$38284 57 15503 7292 6792 6715 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $38296 m0 *1 624.22,323.68
X$38296 73 5611 6637 7294 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38300 m0 *1 631.58,323.68
X$38300 73 7386 73 57 6283 57 sky130_fd_sc_hd__buf_4
* cell instance $38309 m0 *1 644.46,323.68
X$38309 73 7296 57 73 7285 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38316 r0 *1 3.22,323.68
X$38316 73 5735 57 73 7560 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38318 r0 *1 10.58,323.68
X$38318 73 5462 57 73 7310 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38323 r0 *1 18.4,323.68
X$38323 73 6595 5329 7252 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38324 r0 *1 19.78,323.68
X$38324 57 7244 7350 7138 6595 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $38325 r0 *1 23.92,323.68
X$38325 73 7304 7306 7350 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $38329 r0 *1 38.18,323.68
X$38329 73 4227 4222 5115 57 73 7351 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38330 r0 *1 40.02,323.68
X$38330 57 7064 7246 4227 4129 7351 6648 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $38339 r0 *1 57.5,323.68
X$38339 73 4287 7064 6858 7388 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38342 r0 *1 64.86,323.68
X$38342 73 6769 5252 4227 6945 57 7389 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $38343 r0 *1 67.62,323.68
X$38343 73 4129 5797 7389 7313 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38349 r0 *1 76.36,323.68
X$38349 57 6604 7312 7064 4129 6648 7390 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $38350 r0 *1 79.58,323.68
X$38350 73 6769 7142 5432 73 7390 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38365 r0 *1 115.46,323.68
X$38365 73 4950 7310 7249 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38367 r0 *1 117.3,323.68
X$38367 73 3952 7393 4993 73 7394 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38368 r0 *1 119.14,323.68
X$38368 57 7396 6684 7394 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38372 r0 *1 127.42,323.68
X$38372 57 7354 6684 7395 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38374 r0 *1 135.7,323.68
X$38374 73 7354 73 57 7442 57 sky130_fd_sc_hd__buf_4
* cell instance $38377 r0 *1 140.76,323.68
X$38377 73 4950 7259 7249 73 7400 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38378 r0 *1 142.6,323.68
X$38378 57 7360 6827 7400 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38380 r0 *1 150.88,323.68
X$38380 73 7255 7355 7479 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $38383 r0 *1 154.56,323.68
X$38383 57 7355 6827 7356 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38384 r0 *1 161.92,323.68
X$38384 73 4950 7402 7252 73 7254 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38385 r0 *1 163.76,323.68
X$38385 57 7358 6827 7254 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38388 r0 *1 172.5,323.68
X$38388 73 4950 7357 7484 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38390 r0 *1 175.72,323.68
X$38390 57 15580 7221 7034 7035 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $38395 r0 *1 182.16,323.68
X$38395 73 7221 7033 4950 57 73 7486 57 sky130_fd_sc_hd__a21o_1
* cell instance $38397 r0 *1 185.84,323.68
X$38397 57 7359 7002 7404 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38398 r0 *1 193.2,323.68
X$38398 57 7259 7359 2892 7360 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $38409 r0 *1 226.32,323.68
X$38409 73 7341 7265 7405 57 73 7267 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38414 r0 *1 233.22,323.68
X$38414 73 7336 73 57 7494 57 sky130_fd_sc_hd__buf_4
* cell instance $38425 r0 *1 258.98,323.68
X$38425 73 7339 7264 7363 7332 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38427 r0 *1 260.82,323.68
X$38427 73 7450 7362 7270 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38428 r0 *1 262.2,323.68
X$38428 73 7339 7270 7408 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38431 r0 *1 264.96,323.68
X$38431 73 7270 73 57 7271 57 sky130_fd_sc_hd__buf_4
* cell instance $38432 r0 *1 267.72,323.68
X$38432 73 7341 7362 7366 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38435 r0 *1 270.48,323.68
X$38435 73 7409 7271 7364 57 73 7411 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38440 r0 *1 284.28,323.68
X$38440 73 7362 7413 7410 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $38448 r0 *1 298.54,323.68
X$38448 57 7368 7409 7413 7367 7366 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $38451 r0 *1 303.14,323.68
X$38451 73 7368 7265 7685 7338 57 73 7272 57 sky130_fd_sc_hd__a31oi_1
* cell instance $38454 r0 *1 310.96,323.68
X$38454 73 7268 73 57 7745 57 sky130_fd_sc_hd__buf_4
* cell instance $38458 r0 *1 316.48,323.68
X$38458 73 7416 7272 7415 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38476 r0 *1 357.88,323.68
X$38476 73 7420 73 57 7594 57 sky130_fd_sc_hd__buf_4
* cell instance $38486 r0 *1 377.2,323.68
X$38486 73 6580 7425 6960 7346 5766 7508 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $38488 r0 *1 381.34,323.68
X$38488 73 5766 7234 7235 6960 5600 73 7275 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $38489 r0 *1 384.56,323.68
X$38489 73 6510 7426 5600 7427 57 73 7277 57 sky130_fd_sc_hd__a31oi_1
* cell instance $38503 r0 *1 422.28,323.68
X$38503 73 7234 5450 7236 7434 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38505 r0 *1 424.12,323.68
X$38505 73 6058 7277 7431 73 7432 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38507 r0 *1 426.88,323.68
X$38507 73 6325 6848 6070 7371 6349 73 7433 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $38512 r0 *1 441.6,323.68
X$38512 73 6164 6265 5308 73 7430 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38514 r0 *1 444.36,323.68
X$38514 73 7280 6164 5315 57 73 7428 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38517 r0 *1 447.58,323.68
X$38517 73 6694 7280 6265 73 7421 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38520 r0 *1 449.88,323.68
X$38520 73 6265 6257 6749 7422 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38523 r0 *1 454.02,323.68
X$38523 57 6265 7342 5772 7372 6016 7422 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $38531 r0 *1 473.34,323.68
X$38531 73 3989 7374 7419 57 7098 73 57 sky130_fd_sc_hd__o21ai_2
* cell instance $38532 r0 *1 476.56,323.68
X$38532 57 7374 7418 7375 4002 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $38536 r0 *1 489.44,323.68
X$38536 73 7417 7376 6914 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $38538 r0 *1 493.12,323.68
X$38538 73 5875 7418 7385 73 7584 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38539 r0 *1 494.96,323.68
X$38539 57 7414 1872 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $38549 r0 *1 517.96,323.68
X$38549 57 7377 5147 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $38553 r0 *1 528.54,323.68
X$38553 73 6004 7377 7330 7287 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38557 r0 *1 531.76,323.68
X$38557 73 7193 73 57 7378 57 sky130_fd_sc_hd__buf_4
* cell instance $38559 r0 *1 535.44,323.68
X$38559 57 15599 7194 7406 7407 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $38565 r0 *1 544.18,323.68
X$38565 57 7330 4906 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $38566 r0 *1 551.54,323.68
X$38566 57 7288 7330 7325 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $38569 r0 *1 557.98,323.68
X$38569 73 7290 7325 7288 6358 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $38572 r0 *1 560.74,323.68
X$38572 73 7289 73 57 5226 57 sky130_fd_sc_hd__buf_4
* cell instance $38577 r0 *1 569.02,323.68
X$38577 73 6637 6361 5903 57 73 7401 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38579 r0 *1 571.32,323.68
X$38579 73 5991 7143 7379 6358 6637 7403 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $38580 r0 *1 574.54,323.68
X$38580 73 5226 7318 7379 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38582 r0 *1 576.38,323.68
X$38582 73 7462 7318 7213 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38584 r0 *1 578.68,323.68
X$38584 73 7379 73 57 6972 57 sky130_fd_sc_hd__buf_4
* cell instance $38586 r0 *1 583.28,323.68
X$38586 73 6792 6451 7128 4906 57 7399 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $38588 r0 *1 586.04,323.68
X$38588 73 7399 5896 4906 57 73 7398 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38596 r0 *1 605.36,323.68
X$38596 73 6715 7054 7293 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38597 r0 *1 606.74,323.68
X$38597 73 7292 4906 7391 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38603 r0 *1 617.78,323.68
X$38603 73 7140 73 57 7380 57 sky130_fd_sc_hd__buf_4
* cell instance $38610 r0 *1 626.98,323.68
X$38610 73 6792 6642 6972 7387 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38613 r0 *1 632.96,323.68
X$38613 73 5222 4906 7386 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38618 r0 *1 640.32,323.68
X$38618 73 6998 7382 7385 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38623 r0 *1 651.36,323.68
X$38623 73 7295 57 73 7384 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38624 r0 *1 655.04,323.68
X$38624 73 7383 57 73 7382 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38674 m0 *1 2.3,329.12
X$38674 73 4951 57 73 7441 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38677 m0 *1 7.36,329.12
X$38677 73 7349 57 73 7466 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38678 m0 *1 11.04,329.12
X$38678 73 6595 7466 7352 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38698 m0 *1 59.34,329.12
X$38698 73 7064 5252 6601 57 73 7247 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38699 m0 *1 61.18,329.12
X$38699 73 7352 7471 6595 73 7470 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $38714 m0 *1 105.8,329.12
X$38714 57 7392 7353 7436 3952 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $38715 m0 *1 109.94,329.12
X$38715 73 7473 73 57 3582 57 sky130_fd_sc_hd__buf_4
* cell instance $38719 m0 *1 118.68,329.12
X$38719 73 7474 73 57 3807 57 sky130_fd_sc_hd__buf_4
* cell instance $38720 m0 *1 121.44,329.12
X$38720 73 7397 7440 7393 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $38722 m0 *1 125.12,329.12
X$38722 73 7396 73 57 7440 57 sky130_fd_sc_hd__buf_4
* cell instance $38723 m0 *1 127.88,329.12
X$38723 57 7353 7475 7402 7354 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $38724 m0 *1 136.16,329.12
X$38724 73 7402 7442 7397 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $38729 m0 *1 142.14,329.12
X$38729 73 7321 3005 7471 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $38731 m0 *1 147.2,329.12
X$38731 57 7573 6827 7320 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38732 m0 *1 154.56,329.12
X$38732 73 7214 7479 7178 73 7356 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38734 m0 *1 157.32,329.12
X$38734 57 7443 7480 7483 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38735 m0 *1 164.68,329.12
X$38735 73 7323 73 57 7324 57 sky130_fd_sc_hd__buf_4
* cell instance $38738 m0 *1 168.36,329.12
X$38738 73 7443 73 57 3084 57 sky130_fd_sc_hd__buf_4
* cell instance $38739 m0 *1 171.12,329.12
X$38739 57 7485 7002 7484 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38740 m0 *1 178.48,329.12
X$38740 57 7444 7002 7486 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38741 m0 *1 185.84,329.12
X$38741 57 7402 7444 2794 7358 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $38747 m0 *1 198.26,329.12
X$38747 57 7260 7226 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $38752 m0 *1 215.28,329.12
X$38752 73 7447 7494 7488 7446 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38753 m0 *1 217.12,329.12
X$38753 73 7446 7490 7489 7580 7447 7578 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $38760 m0 *1 230,329.12
X$38760 73 7447 73 57 7491 57 sky130_fd_sc_hd__buf_4
* cell instance $38772 m0 *1 260.36,329.12
X$38772 73 7450 7413 7495 7363 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38782 m0 *1 283.36,329.12
X$38782 73 7450 7341 7362 7365 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38783 m0 *1 285.2,329.12
X$38783 57 7498 7366 7449 7363 7538 7410 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $38785 m0 *1 288.88,329.12
X$38785 73 7588 7411 7498 7500 7412 57 73 57 sky130_fd_sc_hd__o22a_1
* cell instance $38796 m0 *1 316.48,329.12
X$38796 73 7491 7502 7542 7416 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38813 m0 *1 361.56,329.12
X$38813 73 6509 6778 7420 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38818 m0 *1 371.68,329.12
X$38818 73 5673 5761 7508 7507 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38826 m0 *1 389.62,329.12
X$38826 73 6848 7509 5450 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $38829 m0 *1 397.44,329.12
X$38829 73 5766 7453 7275 6058 7593 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $38831 m0 *1 400.66,329.12
X$38831 73 6058 7505 6758 73 7506 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38834 m0 *1 407.1,329.12
X$38834 73 7591 5632 5764 7370 57 73 7453 57 sky130_fd_sc_hd__a31oi_1
* cell instance $38836 m0 *1 411.24,329.12
X$38836 73 5764 7504 7454 57 73 7370 57 sky130_fd_sc_hd__a21oi_1
* cell instance $38843 m0 *1 419.52,329.12
X$38843 73 7371 5406 6703 73 7454 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38844 m0 *1 421.36,329.12
X$38844 73 7455 5308 7371 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $38846 m0 *1 424.58,329.12
X$38846 73 7433 6058 7501 7434 73 7431 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $38851 m0 *1 441.6,329.12
X$38851 73 7430 7234 5772 7499 57 73 7429 57 sky130_fd_sc_hd__a31oi_1
* cell instance $38854 m0 *1 445.28,329.12
X$38854 73 5764 7429 7497 5673 5870 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $38856 m0 *1 449.88,329.12
X$38856 73 6509 73 57 7372 57 sky130_fd_sc_hd__buf_4
* cell instance $38857 m0 *1 452.64,329.12
X$38857 73 7345 5772 7373 57 73 7424 57 sky130_fd_sc_hd__a21boi_0
* cell instance $38860 m0 *1 458.16,329.12
X$38860 57 7423 6265 7372 7373 7421 5772 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $38861 m0 *1 461.84,329.12
X$38861 73 6314 7428 6172 6354 6265 7231 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $38867 m0 *1 475.64,329.12
X$38867 73 3989 7478 7419 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38868 m0 *1 477.02,329.12
X$38868 57 7375 6654 7456 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38869 m0 *1 484.38,329.12
X$38869 57 7456 7492 7285 5875 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $38871 m0 *1 489.44,329.12
X$38871 57 4561 6383 7457 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38887 m0 *1 529.46,329.12
X$38887 57 5143 7329 6355 7192 73 73 57 sky130_fd_sc_hd__nor3_2
* cell instance $38888 m0 *1 533.14,329.12
X$38888 73 7459 73 57 6004 57 sky130_fd_sc_hd__buf_4
* cell instance $38890 m0 *1 536.36,329.12
X$38890 57 7459 4905 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $38892 m0 *1 544.18,329.12
X$38892 73 7460 57 73 7377 57 sky130_fd_sc_hd__inv_2
* cell instance $38894 m0 *1 546.02,329.12
X$38894 57 7460 4982 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $38899 m0 *1 556.14,329.12
X$38899 57 7290 7289 7406 7482 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $38904 m0 *1 567.64,329.12
X$38904 73 7051 73 57 5991 57 sky130_fd_sc_hd__buf_4
* cell instance $38905 m0 *1 570.4,329.12
X$38905 73 7481 7069 5796 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38906 m0 *1 571.78,329.12
X$38906 73 7481 73 57 6971 57 sky130_fd_sc_hd__buf_4
* cell instance $38911 m0 *1 586.04,329.12
X$38911 73 4998 7461 7398 4899 6539 7476 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $38914 m0 *1 590.64,329.12
X$38914 73 6889 5613 4899 73 7461 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38920 m0 *1 604.9,329.12
X$38920 73 7462 6637 7472 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38921 m0 *1 606.28,329.12
X$38921 73 7293 7472 7391 4906 4998 73 7569 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $38924 m0 *1 613.64,329.12
X$38924 73 7469 73 57 6820 57 sky130_fd_sc_hd__buf_4
* cell instance $38926 m0 *1 617.32,329.12
X$38926 57 15551 7463 6637 7462 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $38927 m0 *1 621.92,329.12
X$38927 73 6715 4905 6792 7381 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38928 m0 *1 623.76,329.12
X$38928 73 7139 7294 7381 7468 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $38931 m0 *1 627.9,329.12
X$38931 73 5150 7464 7387 7644 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38932 m0 *1 629.74,329.12
X$38932 73 6637 6801 7386 7464 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $38945 r0 *1 4.6,329.12
X$38945 73 6231 57 73 7561 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38948 r0 *1 9.66,329.12
X$38948 73 6595 7560 7510 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38950 r0 *1 11.5,329.12
X$38950 73 6595 6798 7513 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38952 r0 *1 14.72,329.12
X$38952 73 6595 4179 7437 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $38956 r0 *1 16.56,329.12
X$38956 57 6147 7563 7566 5046 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $38959 r0 *1 30.36,329.12
X$38959 73 7204 73 57 7642 57 sky130_fd_sc_hd__buf_4
* cell instance $38983 r0 *1 74.98,329.12
X$38983 57 7568 7516 7438 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $38995 r0 *1 108.56,329.12
X$38995 73 7519 7520 7473 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $38996 r0 *1 111.78,329.12
X$38996 73 4950 7518 7437 73 7439 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $38997 r0 *1 113.62,329.12
X$38997 57 7474 7525 7392 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39000 r0 *1 123.28,329.12
X$39000 73 7440 3807 73 7475 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39004 r0 *1 126.96,329.12
X$39004 73 7524 6949 73 7658 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39005 r0 *1 130.18,329.12
X$39005 57 7571 7525 7526 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39007 r0 *1 139.38,329.12
X$39007 73 7015 57 73 7477 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39011 r0 *1 146.28,329.12
X$39011 57 7662 7613 7477 4950 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $39012 r0 *1 150.42,329.12
X$39012 73 7527 73 57 7572 57 sky130_fd_sc_hd__buf_4
* cell instance $39017 r0 *1 154.56,329.12
X$39017 73 7573 73 57 7322 57 sky130_fd_sc_hd__buf_4
* cell instance $39020 r0 *1 158.7,329.12
X$39020 73 7251 73 57 7076 57 sky130_fd_sc_hd__buf_4
* cell instance $39021 r0 *1 161.46,329.12
X$39021 57 7616 7574 7439 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39022 r0 *1 168.82,329.12
X$39022 57 7577 7574 7575 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39024 r0 *1 177.1,329.12
X$39024 73 7576 6742 73 7529 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39033 r0 *1 187.22,329.12
X$39033 57 7666 7574 7445 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39035 r0 *1 195.04,329.12
X$39035 73 6742 73 57 7278 57 sky130_fd_sc_hd__buf_4
* cell instance $39038 r0 *1 199.18,329.12
X$39038 73 7358 73 57 7361 57 sky130_fd_sc_hd__buf_4
* cell instance $39046 r0 *1 212.52,329.12
X$39046 73 7360 73 57 7579 57 sky130_fd_sc_hd__buf_4
* cell instance $39050 r0 *1 218.5,329.12
X$39050 73 7578 73 57 7493 57 sky130_fd_sc_hd__buf_4
* cell instance $39054 r0 *1 229.08,329.12
X$39054 73 7405 73 57 7534 57 sky130_fd_sc_hd__buf_4
* cell instance $39055 r0 *1 231.84,329.12
X$39055 73 7449 7531 7448 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39059 r0 *1 234.14,329.12
X$39059 73 7409 7531 7448 7532 7583 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $39063 r0 *1 238.74,329.12
X$39063 73 7341 7534 7585 73 8114 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39089 r0 *1 295.78,329.12
X$39089 73 7451 7409 7539 57 73 7590 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39101 r0 *1 325.68,329.12
X$39101 73 7341 7543 7365 73 7545 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39102 r0 *1 327.52,329.12
X$39102 73 7544 7339 7451 57 73 7543 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39104 r0 *1 330.28,329.12
X$39104 57 2897 5047 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $39115 r0 *1 359.26,329.12
X$39115 73 7594 6349 5141 7452 57 7595 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $39117 r0 *1 362.48,329.12
X$39117 73 5764 7369 7595 7503 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $39120 r0 *1 367.08,329.12
X$39120 73 6778 5141 5452 57 73 7546 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39124 r0 *1 370.76,329.12
X$39124 73 6349 6691 7624 7452 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $39129 r0 *1 376.28,329.12
X$39129 57 7278 7694 5205 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $39130 r0 *1 386.4,329.12
X$39130 73 7596 6960 7547 6325 6848 73 7427 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $39131 r0 *1 389.62,329.12
X$39131 73 6325 7099 7509 57 73 7547 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39132 r0 *1 391.46,329.12
X$39132 73 6928 6349 5308 7509 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $39137 r0 *1 396.06,329.12
X$39137 73 6876 7240 5600 7749 57 73 7505 57 sky130_fd_sc_hd__a31oi_1
* cell instance $39139 r0 *1 399.28,329.12
X$39139 73 6325 7507 7593 7592 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $39159 r0 *1 445.28,329.12
X$39159 73 5772 7587 7499 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $39162 r0 *1 448.96,329.12
X$39162 73 6349 7345 6749 7586 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $39172 r0 *1 459.54,329.12
X$39172 73 5141 73 57 5772 57 sky130_fd_sc_hd__buf_4
* cell instance $39184 r0 *1 486.68,329.12
X$39184 73 7496 4561 7417 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39186 r0 *1 490.36,329.12
X$39186 73 5875 7417 7564 73 7457 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39188 r0 *1 492.66,329.12
X$39188 57 7582 7772 7584 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39199 r0 *1 516.58,329.12
X$39199 73 4917 6635 7458 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39200 r0 *1 517.96,329.12
X$39200 73 7581 6972 7377 7458 57 73 7487 57 sky130_fd_sc_hd__a31oi_1
* cell instance $39204 r0 *1 523.48,329.12
X$39204 57 6074 4899 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $39205 r0 *1 530.84,329.12
X$39205 57 15667 5907 7459 7407 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $39208 r0 *1 535.44,329.12
X$39208 73 7377 6439 7549 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39209 r0 *1 536.82,329.12
X$39209 73 5907 73 57 6451 57 sky130_fd_sc_hd__buf_4
* cell instance $39212 r0 *1 540.96,329.12
X$39212 73 7406 73 57 6355 57 sky130_fd_sc_hd__buf_4
* cell instance $39213 r0 *1 543.72,329.12
X$39213 73 7377 73 57 6792 57 sky130_fd_sc_hd__buf_4
* cell instance $39215 r0 *1 547.4,329.12
X$39215 57 15605 7051 7406 7551 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $39216 r0 *1 552,329.12
X$39216 57 7551 5525 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $39225 r0 *1 569.48,329.12
X$39225 73 7552 7076 73 7481 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39229 r0 *1 581.9,329.12
X$39229 73 6971 5150 7378 7570 7401 73 7317 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $39242 r0 *1 608.12,329.12
X$39242 73 7569 4899 6971 7567 57 7659 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $39249 r0 *1 620.54,329.12
X$39249 73 7139 7463 5150 7468 57 7567 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $39251 r0 *1 623.76,329.12
X$39251 73 5991 6637 7467 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $39258 r0 *1 639.86,329.12
X$39258 57 6998 7556 7555 7384 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $39261 r0 *1 653.2,329.12
X$39261 73 7562 57 73 7465 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39265 m0 *1 4.6,334.56
X$39265 73 7242 57 73 7637 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39266 m0 *1 8.28,334.56
X$39266 73 4535 57 73 7514 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39267 m0 *1 11.96,334.56
X$39267 57 7640 7511 6794 6595 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $39269 m0 *1 16.1,334.56
X$39269 73 7563 7752 73 7511 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39277 m0 *1 34.04,334.56
X$39277 73 7643 73 57 3790 57 sky130_fd_sc_hd__buf_4
* cell instance $39283 m0 *1 43.7,334.56
X$39283 57 7645 7603 6720 3952 73 73 57 sky130_fd_sc_hd__mux2i_4
* cell instance $39291 m0 *1 68.08,334.56
X$39291 57 7438 7515 7514 6595 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $39295 m0 *1 76.82,334.56
X$39295 57 7606 7648 7729 3952 73 73 57 sky130_fd_sc_hd__mux2i_4
* cell instance $39297 m0 *1 85.56,334.56
X$39297 57 7517 7516 7607 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39301 m0 *1 100.28,334.56
X$39301 73 7517 7316 7653 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39304 m0 *1 105.8,334.56
X$39304 73 7518 7654 7515 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39305 m0 *1 109.02,334.56
X$39305 73 7519 7520 73 7521 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39308 m0 *1 113.16,334.56
X$39308 73 7521 73 57 1740 57 sky130_fd_sc_hd__buf_4
* cell instance $39310 m0 *1 117.76,334.56
X$39310 73 3952 7522 7510 73 7657 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39311 m0 *1 119.6,334.56
X$39311 73 7523 7656 7522 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39312 m0 *1 122.82,334.56
X$39312 57 7526 7523 7441 3952 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $39315 m0 *1 127.88,334.56
X$39315 57 7609 7658 7259 7571 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $39317 m0 *1 137.08,334.56
X$39317 73 7259 7611 7523 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39321 m0 *1 146.28,334.56
X$39321 57 7528 7480 7662 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39324 m0 *1 154.1,334.56
X$39324 73 7528 73 57 7614 57 sky130_fd_sc_hd__buf_4
* cell instance $39326 m0 *1 157.78,334.56
X$39326 73 4950 7615 6825 73 7575 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39327 m0 *1 159.62,334.56
X$39327 57 7645 7663 7261 7324 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $39331 m0 *1 171.12,334.56
X$39331 73 7529 73 57 4431 57 sky130_fd_sc_hd__buf_4
* cell instance $39332 m0 *1 173.88,334.56
X$39332 57 5266 7574 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $39348 m0 *1 213.9,334.56
X$39348 73 7617 7668 7530 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39349 m0 *1 215.28,334.56
X$39349 73 7530 73 57 7405 57 sky130_fd_sc_hd__buf_4
* cell instance $39358 m0 *1 230.46,334.56
X$39358 73 7669 7265 7413 57 73 7269 57 sky130_fd_sc_hd__a21o_1
* cell instance $39364 m0 *1 246.1,334.56
X$39364 73 7533 7495 7670 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39372 m0 *1 257.14,334.56
X$39372 73 7535 7495 7536 73 7672 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39376 m0 *1 263.58,334.56
X$39376 73 7339 7617 7340 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39377 m0 *1 264.96,334.56
X$39377 73 7413 7271 7536 7675 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $39381 m0 *1 270.02,334.56
X$39381 73 7413 7271 7536 57 73 7679 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39388 m0 *1 286.12,334.56
X$39388 73 7535 7413 7495 7619 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $39390 m0 *1 287.96,334.56
X$39390 73 7365 7621 7619 7588 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $39393 m0 *1 295.32,334.56
X$39393 73 7538 7590 7540 73 7537 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39394 m0 *1 297.16,334.56
X$39394 73 7620 7409 7541 57 73 7540 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39395 m0 *1 299,334.56
X$39395 73 7451 7450 7366 57 73 7684 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39405 m0 *1 318.32,334.56
X$39405 73 7585 7542 7269 7689 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $39427 m0 *1 369.84,334.56
X$39427 73 5670 73 57 6325 57 sky130_fd_sc_hd__inv_1
* cell instance $39432 m0 *1 379.96,334.56
X$39432 73 5455 7274 5315 73 7596 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39440 m0 *1 390.54,334.56
X$39440 57 7576 7697 7548 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39443 m0 *1 398.36,334.56
X$39443 73 7592 5670 7506 57 73 7548 57 sky130_fd_sc_hd__a21boi_0
* cell instance $39447 m0 *1 407.1,334.56
X$39447 73 5451 7373 6349 73 7591 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39454 m0 *1 419.98,334.56
X$39454 73 6509 7624 6703 73 6939 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39456 m0 *1 422.28,334.56
X$39456 73 7420 6703 6325 7589 57 7701 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $39458 m0 *1 425.04,334.56
X$39458 73 7699 7701 5764 73 7501 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39459 m0 *1 426.88,334.56
X$39459 73 6703 5442 6019 57 73 7589 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39466 m0 *1 444.36,334.56
X$39466 73 6265 7428 7696 73 7587 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39471 m0 *1 452.64,334.56
X$39471 73 5313 6314 6265 73 7692 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39481 m0 *1 474.26,334.56
X$39481 57 7562 7690 7691 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39483 m0 *1 481.62,334.56
X$39483 73 7418 7625 7492 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39488 m0 *1 491.74,334.56
X$39488 57 7250 7686 7414 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $39498 m0 *1 517.96,334.56
X$39498 73 5236 73 57 7581 57 sky130_fd_sc_hd__buf_4
* cell instance $39499 m0 *1 520.72,334.56
X$39499 57 7614 7680 6444 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $39502 m0 *1 527.62,334.56
X$39502 57 6444 4917 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $39504 m0 *1 534.98,334.56
X$39504 73 7549 73 57 7049 57 sky130_fd_sc_hd__buf_4
* cell instance $39506 m0 *1 539.58,334.56
X$39506 73 7407 73 57 5143 57 sky130_fd_sc_hd__buf_4
* cell instance $39509 m0 *1 545.1,334.56
X$39509 57 15450 7550 7459 7407 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $39511 m0 *1 550.16,334.56
X$39511 73 7550 73 57 5222 57 sky130_fd_sc_hd__buf_4
* cell instance $39512 m0 *1 552.92,334.56
X$39512 73 7482 73 57 7551 57 sky130_fd_sc_hd__inv_1
* cell instance $39514 m0 *1 554.76,334.56
X$39514 73 7407 73 57 6715 57 sky130_fd_sc_hd__buf_4
* cell instance $39519 m0 *1 562.58,334.56
X$39519 73 7627 7069 6886 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39522 m0 *1 569.48,334.56
X$39522 73 7552 7076 7627 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39523 m0 *1 572.7,334.56
X$39523 73 7665 2342 7556 57 73 7552 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39531 m0 *1 588.8,334.56
X$39531 73 6889 5613 4917 73 7570 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39541 m0 *1 613.64,334.56
X$39541 73 5226 6792 7553 73 7633 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39542 m0 *1 615.48,334.56
X$39542 73 7554 4906 7633 57 73 7469 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39545 m0 *1 621.46,334.56
X$39545 73 7467 73 57 7726 57 sky130_fd_sc_hd__buf_4
* cell instance $39546 m0 *1 624.22,334.56
X$39546 73 6889 6801 7553 57 73 7646 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39551 m0 *1 637.56,334.56
X$39551 57 6998 7565 7555 7557 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $39553 m0 *1 648.6,334.56
X$39553 73 6998 7558 7564 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39554 m0 *1 649.98,334.56
X$39554 73 7636 57 73 7557 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39558 m0 *1 656.88,334.56
X$39558 73 7639 57 73 7559 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39559 r0 *1 2.3,334.56
X$39559 73 7598 57 73 7600 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39560 r0 *1 5.98,334.56
X$39560 73 7599 57 73 7597 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39561 r0 *1 9.66,334.56
X$39561 73 6595 7561 7638 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39563 r0 *1 11.5,334.56
X$39563 73 6595 7600 7601 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39570 r0 *1 17.02,334.56
X$39570 73 7753 7641 73 7563 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39573 r0 *1 22.54,334.56
X$39573 57 7599 7751 7602 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39574 r0 *1 29.9,334.56
X$39574 57 7641 8498 7643 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $39582 r0 *1 45.54,334.56
X$39582 57 7603 7647 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $39589 r0 *1 69,334.56
X$39589 73 6595 7604 7601 73 7607 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39593 r0 *1 71.76,334.56
X$39593 73 7515 7605 7604 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39594 r0 *1 74.98,334.56
X$39594 73 7705 7706 7649 3952 7650 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $39597 r0 *1 80.5,334.56
X$39597 57 7608 7516 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $39598 r0 *1 89.7,334.56
X$39598 57 7651 7652 7609 7606 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $39599 r0 *1 93.38,334.56
X$39599 73 7517 73 57 7605 57 sky130_fd_sc_hd__buf_4
* cell instance $39606 r0 *1 100.74,334.56
X$39606 57 7606 7653 7610 7568 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $39607 r0 *1 109.02,334.56
X$39607 73 7610 73 57 7518 57 sky130_fd_sc_hd__buf_4
* cell instance $39608 r0 *1 111.78,334.56
X$39608 57 7316 7525 7655 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39609 r0 *1 119.14,334.56
X$39609 57 7524 7525 7657 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39612 r0 *1 126.96,334.56
X$39612 57 7608 7525 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $39615 r0 *1 137.54,334.56
X$39615 73 7571 73 57 7611 57 sky130_fd_sc_hd__buf_4
* cell instance $39617 r0 *1 141.22,334.56
X$39617 73 7214 7612 7513 73 7660 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39618 r0 *1 143.06,334.56
X$39618 57 7527 7480 7660 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39619 r0 *1 150.42,334.56
X$39619 73 7613 7572 7612 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39623 r0 *1 154.56,334.56
X$39623 73 7615 7614 7613 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $39625 r0 *1 161.46,334.56
X$39625 73 7355 7443 73 7663 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39629 r0 *1 173.88,334.56
X$39629 57 7574 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $39634 r0 *1 185.84,334.56
X$39634 73 7577 73 57 8075 57 sky130_fd_sc_hd__buf_4
* cell instance $39637 r0 *1 190.9,334.56
X$39637 57 7610 7666 3201 7616 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $39640 r0 *1 201.94,334.56
X$39640 73 7616 73 57 7667 57 sky130_fd_sc_hd__buf_4
* cell instance $39663 r0 *1 258.06,334.56
X$39663 73 7413 7672 7533 7618 73 7671 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $39672 r0 *1 281.52,334.56
X$39672 73 7617 73 57 7495 57 sky130_fd_sc_hd__buf_4
* cell instance $39674 r0 *1 285.2,334.56
X$39674 73 7679 7814 7621 73 7681 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39687 r0 *1 313.26,334.56
X$39687 73 7622 7491 7621 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $39689 r0 *1 314.64,334.56
X$39689 73 7618 7683 7339 73 7623 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39690 r0 *1 316.48,334.56
X$39690 73 7746 7685 7623 7684 7622 73 7687 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $39696 r0 *1 331.66,334.56
X$39696 73 7621 73 57 7693 57 sky130_fd_sc_hd__buf_4
* cell instance $39711 r0 *1 370.76,334.56
X$39711 73 6763 5308 7624 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $39715 r0 *1 375.36,334.56
X$39715 73 7695 73 57 7694 57 sky130_fd_sc_hd__buf_4
* cell instance $39720 r0 *1 390.08,334.56
X$39720 73 5313 5308 7719 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39729 r0 *1 414,334.56
X$39729 73 6316 6215 5670 7239 57 7699 73 57 sky130_fd_sc_hd__nor4b_1
* cell instance $39738 r0 *1 433.32,334.56
X$39738 73 5772 5442 6019 7700 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $39740 r0 *1 435.62,334.56
X$39740 73 5400 6349 6316 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $39745 r0 *1 443.9,334.56
X$39745 73 7348 7373 6265 73 7696 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39748 r0 *1 448.5,334.56
X$39748 73 6314 7586 7742 57 73 7369 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39751 r0 *1 452.18,334.56
X$39751 73 5452 7373 7692 5764 73 57 6315 57 sky130_fd_sc_hd__o31ai_1
* cell instance $39752 r0 *1 454.94,334.56
X$39752 73 6703 73 57 6265 57 sky130_fd_sc_hd__buf_4
* cell instance $39763 r0 *1 481.62,334.56
X$39763 73 7375 73 57 7625 57 sky130_fd_sc_hd__buf_4
* cell instance $39770 r0 *1 492.66,334.56
X$39770 57 7418 5636 7582 7682 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $39780 r0 *1 516.58,334.56
X$39780 73 2344 73 57 7626 57 sky130_fd_sc_hd__buf_4
* cell instance $39781 r0 *1 519.34,334.56
X$39781 57 6074 7680 7614 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $39783 r0 *1 527.16,334.56
X$39783 57 7680 7565 7678 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $39787 r0 *1 536.36,334.56
X$39787 57 7739 7674 5143 7676 7673 7159 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $39794 r0 *1 549.7,334.56
X$39794 73 7550 7327 7725 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39797 r0 *1 552.46,334.56
X$39797 73 7482 73 57 7407 57 sky130_fd_sc_hd__buf_4
* cell instance $39798 r0 *1 555.22,334.56
X$39798 73 7288 7325 7327 57 73 57 sky130_fd_sc_hd__or2_1
* cell instance $39802 r0 *1 559.82,334.56
X$39802 73 7406 73 57 7054 57 sky130_fd_sc_hd__buf_4
* cell instance $39805 r0 *1 563.96,334.56
X$39805 57 6637 7664 6975 4906 7152 7888 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $39809 r0 *1 570.4,334.56
X$39809 73 6975 7403 7664 73 7628 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39810 r0 *1 572.24,334.56
X$39810 73 8038 7076 73 7629 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39813 r0 *1 578.22,334.56
X$39813 73 7628 4917 6971 6882 57 73 7630 57 sky130_fd_sc_hd__a31oi_1
* cell instance $39822 r0 *1 598,334.56
X$39822 73 7631 7632 7661 7630 57 7869 73 57 sky130_fd_sc_hd__nor4b_1
* cell instance $39824 r0 *1 604.9,334.56
X$39824 73 7659 73 57 7632 57 sky130_fd_sc_hd__buf_4
* cell instance $39827 r0 *1 611.8,334.56
X$39827 73 6971 4917 7634 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $39831 r0 *1 620.54,334.56
X$39831 73 4906 7467 7381 4917 73 57 7554 57 sky130_fd_sc_hd__o31ai_1
* cell instance $39833 r0 *1 623.76,334.56
X$39833 57 7631 5150 7789 7646 7634 7644 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $39838 r0 *1 636.18,334.56
X$39838 57 7948 7555 7301 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39840 r0 *1 643.54,334.56
X$39840 57 7639 7555 7629 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39842 r0 *1 651.36,334.56
X$39842 73 7555 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $39848 m0 *1 9.66,340
X$39848 73 7704 7703 7638 73 7783 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39851 m0 *1 12.88,340
X$39851 57 7641 7751 7640 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39856 m0 *1 23,340
X$39856 73 6595 73 57 7704 57 sky130_fd_sc_hd__buf_4
* cell instance $39857 m0 *1 25.76,340
X$39857 73 7788 7641 73 7602 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39866 m0 *1 45.08,340
X$39866 57 7755 7483 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $39879 m0 *1 76.82,340
X$39879 73 3952 7651 7650 73 7796 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39880 m0 *1 78.66,340
X$39880 73 7706 73 57 7729 57 sky130_fd_sc_hd__inv_1
* cell instance $39882 m0 *1 80.5,340
X$39882 57 7516 15431 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $39886 m0 *1 87.4,340
X$39886 57 7730 7609 7705 3952 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $39893 m0 *1 106.26,340
X$39893 73 7568 73 57 7654 57 sky130_fd_sc_hd__buf_4
* cell instance $39900 m0 *1 122.82,340
X$39900 73 7524 73 57 7656 57 sky130_fd_sc_hd__buf_4
* cell instance $39903 m0 *1 125.58,340
X$39903 57 7525 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $39904 m0 *1 136.62,340
X$39904 73 3952 73 57 7214 57 sky130_fd_sc_hd__buf_4
* cell instance $39908 m0 *1 141.68,340
X$39908 73 7702 57 73 7708 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39909 m0 *1 145.36,340
X$39909 73 7527 2777 73 7707 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $39910 m0 *1 148.58,340
X$39910 57 7734 7707 7615 7614 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $39913 m0 *1 156.86,340
X$39913 57 7112 7480 7736 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $39919 m0 *1 176.18,340
X$39919 57 7615 7485 3600 7577 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $39928 m0 *1 200.56,340
X$39928 73 7449 7709 7710 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39929 m0 *1 201.94,340
X$39929 73 7413 7710 7974 57 73 7741 57 sky130_fd_sc_hd__a21oi_1
* cell instance $39935 m0 *1 207,340
X$39935 73 7535 7709 7710 73 7738 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39936 m0 *1 208.84,340
X$39936 57 7488 7738 7737 7929 7413 7618 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $39939 m0 *1 213.44,340
X$39939 73 7409 7532 7711 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39940 m0 *1 214.82,340
X$39940 73 7711 73 57 7712 57 sky130_fd_sc_hd__buf_4
* cell instance $39942 m0 *1 219.42,340
X$39942 73 7713 7715 7489 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $39943 m0 *1 220.8,340
X$39943 73 7413 7669 7712 7713 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $39952 m0 *1 238.28,340
X$39952 73 7583 7670 7741 7413 7622 73 7740 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $39959 m0 *1 256.68,340
X$39959 73 7714 7341 7534 7677 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $39963 m0 *1 260.36,340
X$39963 73 7491 7671 7716 73 7743 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $39964 m0 *1 262.2,340
X$39964 57 7413 7716 7491 7714 7813 7675 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $39975 m0 *1 287.96,340
X$39975 73 7681 73 57 7747 57 sky130_fd_sc_hd__buf_4
* cell instance $40012 m0 *1 373.06,340
X$40012 73 6349 7546 7698 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40013 m0 *1 374.44,340
X$40013 57 7695 7642 7855 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $40016 m0 *1 380.42,340
X$40016 73 6763 6703 7274 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $40021 m0 *1 389.16,340
X$40021 73 6349 7719 7099 57 73 6532 57 sky130_fd_sc_hd__a21oi_1
* cell instance $40024 m0 *1 393.3,340
X$40024 73 7818 73 57 7497 57 sky130_fd_sc_hd__buf_4
* cell instance $40027 m0 *1 396.06,340
X$40027 73 7100 5766 5600 7718 57 7749 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $40028 m0 *1 398.82,340
X$40028 73 7719 73 57 5817 57 sky130_fd_sc_hd__buf_4
* cell instance $40030 m0 *1 403.42,340
X$40030 73 5766 6940 7720 7718 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $40032 m0 *1 406.18,340
X$40032 73 5451 6349 7721 7720 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $40033 m0 *1 408.94,340
X$40033 73 6928 5315 7721 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40038 m0 *1 416.76,340
X$40038 73 7721 73 57 5442 57 sky130_fd_sc_hd__buf_4
* cell instance $40044 m0 *1 430.56,340
X$40044 73 6928 5308 7348 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $40045 m0 *1 432.86,340
X$40045 73 5772 5665 7700 73 7744 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40047 m0 *1 435.62,340
X$40047 73 6349 7744 7698 73 7281 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40055 m0 *1 449.42,340
X$40055 73 6703 5442 5817 7742 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $40058 m0 *1 451.26,340
X$40058 73 6928 5308 7373 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40075 m0 *1 491.74,340
X$40075 73 5636 7723 73 7722 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $40076 m0 *1 494.96,340
X$40076 57 7811 7722 7724 6998 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $40079 m0 *1 500.02,340
X$40079 73 7682 73 57 7723 57 sky130_fd_sc_hd__buf_4
* cell instance $40094 m0 *1 531.3,340
X$40094 73 7287 73 57 7809 57 sky130_fd_sc_hd__buf_4
* cell instance $40095 m0 *1 534.06,340
X$40095 73 7329 7549 7725 7739 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $40098 m0 *1 539.12,340
X$40098 73 7674 73 57 7735 57 sky130_fd_sc_hd__buf_4
* cell instance $40111 m0 *1 563.5,340
X$40111 73 7627 6882 6650 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40112 m0 *1 564.88,340
X$40112 73 6650 73 57 5691 57 sky130_fd_sc_hd__buf_4
* cell instance $40113 m0 *1 567.64,340
X$40113 73 2342 8032 7665 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40115 m0 *1 572.7,340
X$40115 73 7627 4917 7735 7661 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $40131 m0 *1 609.96,340
X$40131 73 7126 73 57 7731 57 sky130_fd_sc_hd__buf_4
* cell instance $40136 m0 *1 616.86,340
X$40136 73 6715 6792 7128 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40139 m0 *1 620.54,340
X$40139 73 7726 7381 4906 73 7728 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40141 m0 *1 623.3,340
X$40141 73 7726 4899 6637 6372 5236 8086 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $40153 m0 *1 646.3,340
X$40153 57 6383 7555 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $40158 r0 *1 4.14,340
X$40158 73 7750 57 73 7705 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40160 r0 *1 8.74,340
X$40160 57 7753 7751 7783 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40163 r0 *1 16.56,340
X$40163 73 7752 7753 7703 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $40164 r0 *1 19.78,340
X$40164 73 7704 7637 7754 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40167 r0 *1 23.46,340
X$40167 73 7759 4428 7786 57 73 7512 57 sky130_fd_sc_hd__a21oi_1
* cell instance $40177 r0 *1 46.46,340
X$40177 73 7603 57 73 7755 57 sky130_fd_sc_hd__inv_2
* cell instance $40180 r0 *1 50.6,340
X$40180 73 7755 73 57 7791 57 sky130_fd_sc_hd__buf_4
* cell instance $40183 r0 *1 55.66,340
X$40183 73 7648 7755 7790 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40195 r0 *1 78.2,340
X$40195 73 7796 73 57 7797 57 sky130_fd_sc_hd__buf_4
* cell instance $40196 r0 *1 80.96,340
X$40196 73 7648 73 57 7655 57 sky130_fd_sc_hd__buf_4
* cell instance $40201 r0 *1 95.68,340
X$40201 73 7800 7655 7799 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40209 r0 *1 108.1,340
X$40209 73 7802 73 57 7760 57 sky130_fd_sc_hd__buf_4
* cell instance $40219 r0 *1 128.34,340
X$40219 57 6949 7525 7730 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40220 r0 *1 135.7,340
X$40220 57 3005 7525 7803 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40225 r0 *1 152.26,340
X$40225 73 7480 73 57 15678 57 sky130_fd_sc_hd__clkinv_1
* cell instance $40228 r0 *1 154.56,340
X$40228 57 3182 7480 7763 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40229 r0 *1 161.92,340
X$40229 57 7736 7806 7708 4950 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $40240 r0 *1 190.44,340
X$40240 73 7807 73 57 7714 57 sky130_fd_sc_hd__buf_4
* cell instance $40244 r0 *1 201.02,340
X$40244 73 7413 7709 7767 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40266 r0 *1 244.26,340
X$40266 73 7740 73 57 7748 57 sky130_fd_sc_hd__buf_4
* cell instance $40274 r0 *1 263.12,340
X$40274 73 7362 7766 7813 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40281 r0 *1 280.14,340
X$40281 73 7816 73 57 7715 57 sky130_fd_sc_hd__buf_4
* cell instance $40283 r0 *1 284.74,340
X$40283 73 7767 7766 7712 73 7814 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40288 r0 *1 292.56,340
X$40288 57 7817 7768 7617 7539 7340 7620 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $40292 r0 *1 306.82,340
X$40292 57 7717 7685 7677 8215 7819 7622 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $40300 r0 *1 321.54,340
X$40300 57 8217 7990 7689 7769 7747 7822 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $40305 r0 *1 333.5,340
X$40305 73 7768 7685 7622 7824 57 7823 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $40325 r0 *1 381.8,340
X$40325 73 7697 73 57 57 sky130_fd_sc_hd__clkinv_2
* cell instance $40327 r0 *1 384.1,340
X$40327 57 5766 7818 5764 5592 6532 7821 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $40339 r0 *1 415.84,340
X$40339 73 8048 73 57 4093 57 sky130_fd_sc_hd__buf_4
* cell instance $40343 r0 *1 423.2,340
X$40343 73 6703 6257 5665 7815 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $40364 r0 *1 470.58,340
X$40364 73 7056 57 73 7812 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40373 r0 *1 493.58,340
X$40373 57 7682 7772 7811 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40377 r0 *1 505.54,340
X$40377 57 1769 7773 7216 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $40385 r0 *1 522.1,340
X$40385 73 7774 7614 73 7784 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $40386 r0 *1 525.32,340
X$40386 57 7773 7787 7810 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $40388 r0 *1 530.84,340
X$40388 73 3157 73 57 7775 57 sky130_fd_sc_hd__buf_4
* cell instance $40390 r0 *1 533.6,340
X$40390 73 6439 7809 7808 57 73 7676 57 sky130_fd_sc_hd__a21oi_1
* cell instance $40396 r0 *1 541.88,340
X$40396 57 15663 5687 7459 5525 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $40400 r0 *1 551.54,340
X$40400 73 2342 7324 7805 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $40401 r0 *1 553.84,340
X$40401 73 7776 7805 7324 7778 57 7288 73 57 sky130_fd_sc_hd__a22o_1
* cell instance $40402 r0 *1 557.06,340
X$40402 57 7325 7324 7778 2235 7776 73 73 57 sky130_fd_sc_hd__a211oi_2
* cell instance $40406 r0 *1 563.96,340
X$40406 73 7462 7054 7152 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40413 r0 *1 577.76,340
X$40413 73 7627 7069 6786 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40419 r0 *1 589.26,340
X$40419 73 7868 5505 7627 6715 5150 73 7732 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $40429 r0 *1 611.34,340
X$40429 73 5687 73 57 7794 57 sky130_fd_sc_hd__buf_4
* cell instance $40431 r0 *1 614.1,340
X$40431 73 7731 6715 5416 57 73 7793 57 sky130_fd_sc_hd__a21oi_1
* cell instance $40436 r0 *1 624.22,340
X$40436 57 5236 7789 5416 6085 6792 7462 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $40440 r0 *1 632.5,340
X$40440 57 6998 7787 7780 7779 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $40442 r0 *1 643.54,340
X$40442 57 7781 7780 7784 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40444 r0 *1 651.36,340
X$40444 73 7727 57 73 7779 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40446 r0 *1 656.88,340
X$40446 73 7781 57 73 7782 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40448 m0 *1 4.14,345.44
X$40448 73 7825 57 73 7873 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40449 m0 *1 7.82,345.44
X$40449 57 7704 7786 7751 7873 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $40452 m0 *1 18.86,345.44
X$40452 57 7608 7751 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $40458 m0 *1 38.18,345.44
X$40458 57 15463 7876 7756 7757 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $40467 m0 *1 61.64,345.44
X$40467 73 7757 7828 7792 73 7829 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40468 m0 *1 63.48,345.44
X$40468 73 7756 7829 7795 73 7879 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40469 m0 *1 65.32,345.44
X$40469 73 7757 7954 7880 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40477 m0 *1 77.28,345.44
X$40477 73 7706 7758 7649 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40478 m0 *1 78.66,345.44
X$40478 73 7761 7655 7758 7828 73 7795 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $40480 m0 *1 83.72,345.44
X$40480 73 7757 7647 7833 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40490 m0 *1 102.58,345.44
X$40490 73 7655 73 57 7834 57 sky130_fd_sc_hd__buf_4
* cell instance $40491 m0 *1 105.34,345.44
X$40491 57 7885 7801 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $40493 m0 *1 113.16,345.44
X$40493 73 7835 7483 7762 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40494 m0 *1 114.54,345.44
X$40494 73 7762 7926 7802 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40497 m0 *1 117.3,345.44
X$40497 73 7762 73 57 7761 57 sky130_fd_sc_hd__buf_4
* cell instance $40501 m0 *1 123.28,345.44
X$40501 57 7734 7836 7831 7214 73 73 57 sky130_fd_sc_hd__mux2i_4
* cell instance $40507 m0 *1 134.78,345.44
X$40507 73 6910 73 57 7763 57 sky130_fd_sc_hd__buf_4
* cell instance $40515 m0 *1 149.5,345.44
X$40515 73 7838 73 57 7804 57 sky130_fd_sc_hd__buf_4
* cell instance $40518 m0 *1 152.26,345.44
X$40518 57 7608 7480 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $40519 m0 *1 161.46,345.44
X$40519 73 7764 7112 7806 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $40520 m0 *1 164.68,345.44
X$40520 73 7214 7764 7754 73 7765 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40525 m0 *1 168.82,345.44
X$40525 73 7765 73 57 7895 57 sky130_fd_sc_hd__buf_4
* cell instance $40535 m0 *1 191.36,345.44
X$40535 73 7449 7709 7807 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40536 m0 *1 192.74,345.44
X$40536 73 7532 7447 7842 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40549 m0 *1 216.66,345.44
X$40549 73 8107 73 57 7688 57 sky130_fd_sc_hd__buf_4
* cell instance $40550 m0 *1 219.42,345.44
X$40550 73 7668 73 57 7766 57 sky130_fd_sc_hd__buf_4
* cell instance $40556 m0 *1 226.78,345.44
X$40556 73 7341 7842 7844 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40558 m0 *1 229.08,345.44
X$40558 73 7618 7844 7450 73 7898 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40567 m0 *1 247.02,345.44
X$40567 73 7341 7670 7847 57 73 7903 57 sky130_fd_sc_hd__a21oi_1
* cell instance $40578 m0 *1 267.26,345.44
X$40578 73 7366 7409 7622 7845 57 7910 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $40580 m0 *1 273.7,345.44
X$40580 73 6423 73 57 7911 57 sky130_fd_sc_hd__buf_4
* cell instance $40589 m0 *1 291.64,345.44
X$40589 73 7539 7849 7341 57 73 7817 57 sky130_fd_sc_hd__a21oi_1
* cell instance $40598 m0 *1 307.74,345.44
X$40598 73 7491 7683 7852 7915 73 7819 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $40612 m0 *1 340.4,345.44
X$40612 57 7912 7913 7748 7717 7854 7688 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $40628 m0 *1 371.22,345.44
X$40628 57 7771 7697 7895 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40630 m0 *1 379.5,345.44
X$40630 57 7905 7697 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $40635 m0 *1 394.22,345.44
X$40635 73 5929 7770 73 7496 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $40640 m0 *1 404.8,345.44
X$40640 57 7820 7496 7812 4950 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $40642 m0 *1 410.78,345.44
X$40642 73 7980 73 57 3944 57 sky130_fd_sc_hd__buf_4
* cell instance $40651 m0 *1 427.8,345.44
X$40651 57 7764 5926 7771 7856 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $40677 m0 *1 493.12,345.44
X$40677 73 7896 57 73 6368 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40682 m0 *1 500.02,345.44
X$40682 57 7860 1870 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $40688 m0 *1 516.58,345.44
X$40688 73 7969 73 57 6110 57 sky130_fd_sc_hd__buf_4
* cell instance $40689 m0 *1 519.34,345.44
X$40689 57 7774 7772 6994 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40696 m0 *1 533.6,345.44
X$40696 73 7777 7192 7808 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40698 m0 *1 535.44,345.44
X$40698 57 15489 7777 6792 5525 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $40700 m0 *1 540.5,345.44
X$40700 73 7406 57 73 7459 57 sky130_fd_sc_hd__inv_2
* cell instance $40703 m0 *1 544.18,345.44
X$40703 73 5497 6792 4899 7192 7863 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $40708 m0 *1 556.6,345.44
X$40708 73 7894 73 57 6882 57 sky130_fd_sc_hd__buf_4
* cell instance $40711 m0 *1 559.36,345.44
X$40711 73 7892 73 57 7069 57 sky130_fd_sc_hd__buf_4
* cell instance $40714 m0 *1 564.42,345.44
X$40714 73 2342 7865 7778 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $40721 m0 *1 582.36,345.44
X$40721 73 6451 7139 7725 73 7963 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40730 m0 *1 603.06,345.44
X$40730 57 7881 4899 7798 7883 7054 7878 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $40735 m0 *1 611.8,345.44
X$40735 73 7793 7794 6637 7054 7878 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $40739 m0 *1 617.78,345.44
X$40739 73 7554 7139 7953 73 57 6725 57 sky130_fd_sc_hd__o21bai_1
* cell instance $40747 m0 *1 638.48,345.44
X$40747 57 7785 7780 7877 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40750 m0 *1 645.84,345.44
X$40750 73 7870 57 73 7478 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40752 m0 *1 653.2,345.44
X$40752 73 7875 57 73 6977 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40756 r0 *1 5.06,345.44
X$40756 73 7827 57 73 7435 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40757 r0 *1 8.74,345.44
X$40757 57 7827 7751 7874 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40762 r0 *1 18.86,345.44
X$40762 73 7751 73 57 15429 57 sky130_fd_sc_hd__clkinvlp_4
* cell instance $40778 r0 *1 62.1,345.44
X$40778 73 7647 7828 7954 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40781 r0 *1 67.62,345.44
X$40781 73 7879 7880 7830 7832 57 73 7958 57 sky130_fd_sc_hd__a31oi_1
* cell instance $40783 r0 *1 69.92,345.44
X$40783 73 7647 7828 7830 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40791 r0 *1 86.02,345.44
X$40791 57 15651 7922 7834 7757 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $40798 r0 *1 103.04,345.44
X$40798 73 7655 57 73 7885 57 sky130_fd_sc_hd__inv_2
* cell instance $40800 r0 *1 104.88,345.44
X$40800 57 7885 7756 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $40801 r0 *1 112.24,345.44
X$40801 73 7835 73 57 7758 57 sky130_fd_sc_hd__buf_4
* cell instance $40804 r0 *1 117.76,345.44
X$40804 73 7836 73 57 7828 57 sky130_fd_sc_hd__buf_4
* cell instance $40807 r0 *1 124.2,345.44
X$40807 73 7836 73 57 7837 57 sky130_fd_sc_hd__inv_1
* cell instance $40813 r0 *1 130.18,345.44
X$40813 57 7927 7800 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $40815 r0 *1 138,345.44
X$40815 57 2777 7525 7837 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40816 r0 *1 145.36,345.44
X$40816 57 7838 7480 7891 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40821 r0 *1 154.56,345.44
X$40821 73 7214 7840 7733 73 7967 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40822 r0 *1 156.4,345.44
X$40822 73 7893 7804 73 7841 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $40824 r0 *1 160.08,345.44
X$40824 73 7841 73 57 4429 57 sky130_fd_sc_hd__buf_4
* cell instance $40825 r0 *1 162.84,345.44
X$40825 73 4429 4431 73 7839 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $40836 r0 *1 191.36,345.44
X$40836 73 7842 7450 7447 7669 7972 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $40850 r0 *1 226.78,345.44
X$40850 73 7267 7845 7843 73 7982 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40852 r0 *1 229.54,345.44
X$40852 57 7930 7266 7341 7897 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $40853 r0 *1 231.84,345.44
X$40853 73 7531 7340 7901 73 7983 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40855 r0 *1 233.68,345.44
X$40855 73 7532 7531 7901 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40859 r0 *1 238.28,345.44
X$40859 57 7846 7845 7341 7897 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $40863 r0 *1 249.78,345.44
X$40863 73 7846 73 57 7536 57 sky130_fd_sc_hd__buf_4
* cell instance $40865 r0 *1 253.46,345.44
X$40865 73 7903 8276 7843 73 7848 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40866 r0 *1 255.3,345.44
X$40866 73 7989 7848 7906 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40870 r0 *1 260.82,345.44
X$40870 73 7906 7907 7743 57 73 7991 57 sky130_fd_sc_hd__a21oi_1
* cell instance $40877 r0 *1 277.84,345.44
X$40877 73 7849 7341 7851 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40885 r0 *1 293.48,345.44
X$40885 73 7340 73 57 7850 57 sky130_fd_sc_hd__buf_4
* cell instance $40899 r0 *1 323.38,345.44
X$40899 73 7851 7992 7843 73 7822 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $40904 r0 *1 337.18,345.44
X$40904 73 7853 7769 7913 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40905 r0 *1 338.56,345.44
X$40905 73 7913 7914 7823 8266 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $40925 r0 *1 379.5,345.44
X$40925 57 7941 7909 5023 73 73 57 sky130_fd_sc_hd__xnor2_4
* cell instance $40935 r0 *1 405.26,345.44
X$40935 73 7635 57 73 7904 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40936 r0 *1 408.94,345.44
X$40936 57 6998 7978 7905 7904 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $40937 r0 *1 419.98,345.44
X$40937 73 7977 73 57 3023 57 sky130_fd_sc_hd__buf_4
* cell instance $40945 r0 *1 435.62,345.44
X$40945 57 7856 7690 7902 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40946 r0 *1 442.98,345.44
X$40946 73 5926 7856 73 7857 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $40947 r0 *1 446.2,345.44
X$40947 57 7902 7857 7859 6998 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $40963 r0 *1 485.76,345.44
X$40963 57 7896 7690 7899 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $40966 r0 *1 500.48,345.44
X$40966 73 7772 57 73 57 sky130_fd_sc_hd__clkinv_4
* cell instance $40967 r0 *1 503.7,345.44
X$40967 57 6383 7772 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $40972 r0 *1 516.12,345.44
X$40972 73 7861 73 57 3978 57 sky130_fd_sc_hd__buf_4
* cell instance $40974 r0 *1 522.56,345.44
X$40974 73 7775 73 57 4395 57 sky130_fd_sc_hd__buf_4
* cell instance $40983 r0 *1 541.88,345.44
X$40983 73 7948 73 57 6003 57 sky130_fd_sc_hd__buf_4
* cell instance $40986 r0 *1 546.94,345.44
X$40986 73 7460 73 57 6637 57 sky130_fd_sc_hd__buf_4
* cell instance $40988 r0 *1 553.38,345.44
X$40988 73 7862 7124 73 7894 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $40989 r0 *1 556.6,345.44
X$40989 73 7862 7124 7892 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $40992 r0 *1 560.74,345.44
X$40992 73 6439 7863 7868 7890 7864 7866 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $40993 r0 *1 563.96,345.44
X$40993 73 6637 7152 7864 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $40994 r0 *1 565.34,345.44
X$40994 73 7890 4906 7888 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $40999 r0 *1 569.48,345.44
X$40999 73 5508 7866 5780 73 7867 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $41001 r0 *1 571.78,345.44
X$41001 73 4899 4906 7868 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41012 r0 *1 596.62,345.44
X$41012 73 6647 7324 73 7882 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41013 r0 *1 599.84,345.44
X$41013 73 7462 7868 7959 73 7881 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $41031 r0 *1 639.86,345.44
X$41031 57 6998 7865 7780 7871 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $41035 r0 *1 656.88,345.44
X$41035 73 7872 57 73 7871 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41036 m0 *1 2.3,350.88
X$41036 73 7826 57 73 7917 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41038 m0 *1 6.44,350.88
X$41038 73 8120 57 73 7831 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41039 m0 *1 10.12,350.88
X$41039 73 7704 7917 7733 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41040 m0 *1 11.5,350.88
X$41040 73 7918 57 73 7706 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41045 m0 *1 16.56,350.88
X$41045 73 8005 7753 73 7874 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41059 m0 *1 49.22,350.88
X$41059 73 7919 73 57 8282 57 sky130_fd_sc_hd__buf_4
* cell instance $41062 m0 *1 56.12,350.88
X$41062 73 7955 7790 7919 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41068 m0 *1 66.7,350.88
X$41068 73 7919 73 57 7957 57 sky130_fd_sc_hd__buf_4
* cell instance $41072 m0 *1 71.3,350.88
X$41072 73 7920 7757 7791 7960 8091 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $41073 m0 *1 74.06,350.88
X$41073 73 7757 7921 7960 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41075 m0 *1 79.12,350.88
X$41075 73 7922 7830 7923 7961 7832 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $41076 m0 *1 81.88,350.88
X$41076 73 7833 7889 7962 7837 7923 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $41082 m0 *1 94.76,350.88
X$41082 73 7920 8003 7924 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41084 m0 *1 96.6,350.88
X$41084 73 7924 7799 7647 7957 57 73 8004 57 sky130_fd_sc_hd__a31oi_1
* cell instance $41090 m0 *1 102.12,350.88
X$41090 73 7886 7885 7884 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41093 m0 *1 104.88,350.88
X$41093 73 7483 7885 8034 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41094 m0 *1 108.1,350.88
X$41094 57 15479 7925 7730 7392 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $41096 m0 *1 113.16,350.88
X$41096 73 7392 73 57 7920 57 sky130_fd_sc_hd__buf_4
* cell instance $41097 m0 *1 115.92,350.88
X$41097 73 7886 7647 7926 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41098 m0 *1 117.3,350.88
X$41098 73 7926 73 57 7887 57 sky130_fd_sc_hd__buf_4
* cell instance $41102 m0 *1 123.28,350.88
X$41102 57 15448 7886 7927 7920 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $41105 m0 *1 127.88,350.88
X$41105 73 7730 73 57 7927 57 sky130_fd_sc_hd__clkinv_1
* cell instance $41107 m0 *1 130.18,350.88
X$41107 73 7800 7801 7889 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41111 m0 *1 134.78,350.88
X$41111 73 7916 57 73 7965 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41117 m0 *1 147.2,350.88
X$41117 57 7891 7839 7965 7214 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $41121 m0 *1 151.8,350.88
X$41121 57 7893 7480 7967 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41122 m0 *1 159.16,350.88
X$41122 73 7893 73 57 7945 57 sky130_fd_sc_hd__buf_4
* cell instance $41123 m0 *1 161.92,350.88
X$41123 73 4431 7945 7840 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41124 m0 *1 165.14,350.88
X$41124 73 7970 73 57 7759 57 sky130_fd_sc_hd__buf_4
* cell instance $41134 m0 *1 190.44,350.88
X$41134 73 7413 7928 7972 8184 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $41135 m0 *1 192.28,350.88
X$41135 73 7973 7617 7669 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41136 m0 *1 193.66,350.88
X$41136 73 7981 7973 7532 57 73 7974 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41152 m0 *1 227.7,350.88
X$41152 73 7981 73 57 7531 57 sky130_fd_sc_hd__buf_4
* cell instance $41159 m0 *1 245.18,350.88
X$41159 57 8052 7988 7413 7409 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $41162 m0 *1 251.16,350.88
X$41162 73 7737 7931 7937 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41164 m0 *1 253.46,350.88
X$41164 57 7988 7989 7932 8053 7495 7585 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $41167 m0 *1 258.98,350.88
X$41167 73 7409 7413 7933 57 73 7932 57 sky130_fd_sc_hd__a21o_1
* cell instance $41170 m0 *1 261.74,350.88
X$41170 73 7409 7450 7617 73 7933 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $41171 m0 *1 263.58,350.88
X$41171 73 7933 73 57 7930 57 sky130_fd_sc_hd__buf_4
* cell instance $41175 m0 *1 272.78,350.88
X$41175 73 7994 7851 7617 73 7934 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $41176 m0 *1 274.62,350.88
X$41176 73 7934 73 57 7908 57 sky130_fd_sc_hd__buf_4
* cell instance $41180 m0 *1 279.68,350.88
X$41180 73 7449 7997 8129 7996 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $41182 m0 *1 281.98,350.88
X$41182 73 7931 73 57 7362 57 sky130_fd_sc_hd__buf_4
* cell instance $41187 m0 *1 289.34,350.88
X$41187 73 7449 7931 7935 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41190 m0 *1 292.1,350.88
X$41190 73 7935 73 57 7544 57 sky130_fd_sc_hd__buf_4
* cell instance $41191 m0 *1 294.86,350.88
X$41191 73 7339 7936 7997 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41193 m0 *1 297.16,350.88
X$41193 73 7936 7413 7849 7995 57 73 7542 57 sky130_fd_sc_hd__a31oi_1
* cell instance $41204 m0 *1 317.86,350.88
X$41204 73 7993 7937 7938 73 7502 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $41207 m0 *1 322,350.88
X$41207 73 7853 8057 7932 57 73 7990 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41208 m0 *1 323.84,350.88
X$41208 73 7939 7413 7850 7992 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $41219 m0 *1 341.78,350.88
X$41219 73 7938 7987 7940 7843 8055 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $41227 m0 *1 365.24,350.88
X$41227 57 8228 8012 7912 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41232 m0 *1 375.36,350.88
X$41232 57 4950 7986 7697 7985 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $41241 m0 *1 395.6,350.88
X$41241 57 7942 7984 7820 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41242 m0 *1 402.96,350.88
X$41242 73 7942 73 57 7770 57 sky130_fd_sc_hd__buf_4
* cell instance $41245 m0 *1 413.08,350.88
X$41245 73 8013 7856 73 7980 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41248 m0 *1 417.68,350.88
X$41248 73 7979 7944 7977 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41255 m0 *1 427.8,350.88
X$41255 73 7976 7745 73 7899 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41258 m0 *1 435.62,350.88
X$41258 73 7975 73 57 7877 57 sky130_fd_sc_hd__buf_4
* cell instance $41272 m0 *1 463.22,350.88
X$41272 57 7943 7690 7900 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41276 m0 *1 475.64,350.88
X$41276 73 7943 57 73 6544 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41282 m0 *1 483,350.88
X$41282 73 7971 57 73 7859 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41286 m0 *1 493.12,350.88
X$41286 73 8247 73 57 2745 57 sky130_fd_sc_hd__buf_4
* cell instance $41291 m0 *1 499.56,350.88
X$41291 57 7582 7946 7860 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $41297 m0 *1 508.76,350.88
X$41297 73 7947 8152 73 7966 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41299 m0 *1 512.9,350.88
X$41299 73 7966 7968 7969 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41301 m0 *1 519.8,350.88
X$41301 73 8016 8101 6736 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41308 m0 *1 531.3,350.88
X$41308 73 7964 73 57 4202 57 sky130_fd_sc_hd__buf_4
* cell instance $41311 m0 *1 535.44,350.88
X$41311 57 8018 7948 7947 4195 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $41318 m0 *1 554.76,350.88
X$41318 73 8174 2342 7300 57 73 7862 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41320 m0 *1 557.06,350.88
X$41320 73 5525 73 57 7462 57 sky130_fd_sc_hd__buf_4
* cell instance $41324 m0 *1 560.74,350.88
X$41324 57 15536 7890 6637 7462 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $41333 m0 *1 583.74,350.88
X$41333 73 7963 6792 4917 6976 57 7950 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $41337 m0 *1 588.34,350.88
X$41337 73 7462 5613 6976 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41341 m0 *1 600.76,350.88
X$41341 73 7462 4917 7959 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41347 m0 *1 612.26,350.88
X$41347 57 5613 7956 7794 7553 6085 7731 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $41351 m0 *1 616.4,350.88
X$41351 57 4906 8163 4917 6646 7128 7728 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $41353 m0 *1 620.08,350.88
X$41353 73 5606 7794 6637 57 73 7953 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41357 m0 *1 625.14,350.88
X$41357 73 7462 6792 7553 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41368 m0 *1 643.08,350.88
X$41368 57 7875 7780 7952 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41372 m0 *1 653.66,350.88
X$41372 73 8026 57 73 7558 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41392 r0 *1 40.48,350.88
X$41392 73 8027 7999 8001 7757 7921 8338 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $41401 r0 *1 52.9,350.88
X$41401 73 7887 8000 7647 57 73 7999 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41402 r0 *1 54.74,350.88
X$41402 73 7790 73 57 8001 57 sky130_fd_sc_hd__buf_4
* cell instance $41405 r0 *1 60.26,350.88
X$41405 73 8028 7647 7828 8002 8029 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $41407 r0 *1 63.48,350.88
X$41407 73 7955 73 57 7962 57 sky130_fd_sc_hd__buf_4
* cell instance $41409 r0 *1 66.7,350.88
X$41409 57 15624 8059 7756 7800 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $41415 r0 *1 73.6,350.88
X$41415 73 7647 7960 7884 8002 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $41418 r0 *1 77.74,350.88
X$41418 57 7655 7921 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $41421 r0 *1 86.48,350.88
X$41421 73 8003 73 57 7757 57 sky130_fd_sc_hd__buf_4
* cell instance $41423 r0 *1 90.16,350.88
X$41423 73 7730 73 57 8003 57 sky130_fd_sc_hd__buf_4
* cell instance $41424 r0 *1 92.92,350.88
X$41424 73 8035 73 57 7955 57 sky130_fd_sc_hd__buf_4
* cell instance $41426 r0 *1 96.14,350.88
X$41426 73 7799 73 57 8033 57 sky130_fd_sc_hd__buf_4
* cell instance $41433 r0 *1 101.66,350.88
X$41433 73 7884 7925 7834 57 73 8092 57 sky130_fd_sc_hd__a21boi_0
* cell instance $41435 r0 *1 106.26,350.88
X$41435 73 7392 73 57 8035 57 sky130_fd_sc_hd__clkinv_1
* cell instance $41438 r0 *1 110.4,350.88
X$41438 57 7835 8037 7730 7392 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $41447 r0 *1 126.96,350.88
X$41447 57 15574 8040 7801 7730 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $41450 r0 *1 132.94,350.88
X$41450 73 8004 73 57 8041 57 sky130_fd_sc_hd__buf_4
* cell instance $41491 r0 *1 222.18,350.88
X$41491 73 8112 7769 7982 8006 73 8047 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $41492 r0 *1 224.48,350.88
X$41492 73 7450 7981 8050 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41495 r0 *1 228.16,350.88
X$41495 73 7908 7622 7531 8191 73 8006 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $41496 r0 *1 230.46,350.88
X$41496 73 5361 73 57 8051 57 sky130_fd_sc_hd__buf_4
* cell instance $41506 r0 *1 244.26,350.88
X$41506 73 7929 8052 7495 57 73 8130 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41527 r0 *1 289.34,350.88
X$41527 73 7931 73 57 7936 57 sky130_fd_sc_hd__buf_4
* cell instance $41532 r0 *1 295.78,350.88
X$41532 73 7997 73 57 8070 57 sky130_fd_sc_hd__buf_4
* cell instance $41536 r0 *1 303.6,350.88
X$41536 57 7413 7995 7449 7617 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $41539 r0 *1 310.5,350.88
X$41539 73 7852 7413 7936 8007 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $41541 r0 *1 312.8,350.88
X$41541 73 7850 7847 7413 8007 57 73 8009 57 sky130_fd_sc_hd__a31oi_1
* cell instance $41545 r0 *1 315.1,350.88
X$41545 73 7853 7585 8009 57 73 8008 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41546 r0 *1 316.94,350.88
X$41546 73 8008 8055 7412 8010 57 73 8216 57 sky130_fd_sc_hd__a31oi_1
* cell instance $41551 r0 *1 322.46,350.88
X$41551 73 8056 7500 8057 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41557 r0 *1 336.26,350.88
X$41557 73 8011 7413 7685 8850 57 7824 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $41563 r0 *1 341.32,350.88
X$41563 73 7852 7931 8054 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41564 r0 *1 342.7,350.88
X$41564 73 7938 7850 8054 7940 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $41570 r0 *1 350.06,350.88
X$41570 73 7451 7937 8011 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41576 r0 *1 363.86,350.88
X$41576 57 7905 8012 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $41589 r0 *1 387.78,350.88
X$41589 73 7951 57 73 7985 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41602 r0 *1 409.4,350.88
X$41602 73 4950 73 57 6998 57 sky130_fd_sc_hd__buf_4
* cell instance $41604 r0 *1 413.08,350.88
X$41604 73 8013 7856 8048 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41606 r0 *1 417.22,350.88
X$41606 57 7979 7978 8049 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $41616 r0 *1 433.32,350.88
X$41616 57 6998 8046 7690 8014 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $41617 r0 *1 444.36,350.88
X$41617 73 6717 57 73 8014 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41629 r0 *1 463.22,350.88
X$41629 73 7690 73 57 57 sky130_fd_sc_hd__clkinv_2
* cell instance $41630 r0 *1 465.06,350.88
X$41630 57 8104 7690 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $41639 r0 *1 486.68,350.88
X$41639 73 7858 2342 4248 57 73 8045 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41641 r0 *1 490.36,350.88
X$41641 73 6738 7944 73 8044 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41642 r0 *1 493.58,350.88
X$41642 57 7944 7772 8043 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41649 r0 *1 506.92,350.88
X$41649 57 8151 8015 8183 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $41652 r0 *1 513.82,350.88
X$41652 57 7968 7775 8031 7774 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $41654 r0 *1 522.56,350.88
X$41654 57 8016 8038 8017 7947 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $41655 r0 *1 530.84,350.88
X$41655 73 8017 73 57 8020 57 sky130_fd_sc_hd__buf_4
* cell instance $41659 r0 *1 533.6,350.88
X$41659 73 8039 8018 7964 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41663 r0 *1 541.42,350.88
X$41663 73 8038 4395 73 8036 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41665 r0 *1 545.1,350.88
X$41665 73 8020 6003 8021 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41667 r0 *1 548.78,350.88
X$41667 73 8021 8093 8032 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41669 r0 *1 552.92,350.88
X$41669 73 8172 73 57 4573 57 sky130_fd_sc_hd__buf_4
* cell instance $41694 r0 *1 600.3,350.88
X$41694 73 7728 73 57 8030 57 sky130_fd_sc_hd__buf_4
* cell instance $41708 r0 *1 628.82,350.88
X$41708 57 8023 7780 7882 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41711 r0 *1 637.56,350.88
X$41711 57 8024 7780 8022 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41715 r0 *1 644.92,350.88
X$41715 73 8023 57 73 8085 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41716 r0 *1 648.6,350.88
X$41716 73 6998 8025 7949 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41734 m0 *1 38.18,356.32
X$41734 57 7520 7751 8087 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41740 m0 *1 57.96,356.32
X$41740 57 8028 8042 7921 7757 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $41744 m0 *1 67.62,356.32
X$41744 73 8059 7791 7828 8091 8089 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $41752 m0 *1 87.86,356.32
X$41752 73 7837 73 57 8027 57 sky130_fd_sc_hd__buf_4
* cell instance $41757 m0 *1 102.12,356.32
X$41757 73 7483 8092 7828 73 8094 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $41761 m0 *1 107.18,356.32
X$41761 73 7835 7483 8720 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41764 m0 *1 109.94,356.32
X$41764 73 7392 73 57 8062 57 sky130_fd_sc_hd__buf_4
* cell instance $41767 m0 *1 113.62,356.32
X$41767 73 7835 73 57 8060 57 sky130_fd_sc_hd__inv_1
* cell instance $41768 m0 *1 115,356.32
X$41768 73 8060 73 57 7652 57 sky130_fd_sc_hd__buf_4
* cell instance $41769 m0 *1 117.76,356.32
X$41769 73 8063 8061 7828 73 8095 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $41770 m0 *1 119.6,356.32
X$41770 73 8176 8062 7801 57 73 8061 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41773 m0 *1 125.58,356.32
X$41773 73 8098 73 57 8097 57 sky130_fd_sc_hd__buf_4
* cell instance $41776 m0 *1 131.1,356.32
X$41776 73 8040 8063 8179 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41786 m0 *1 153.18,356.32
X$41786 57 2399 7480 8100 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41797 m0 *1 192.28,356.32
X$41797 73 7928 7981 8185 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $41805 m0 *1 209.76,356.32
X$41805 73 7620 8108 8448 8064 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $41808 m0 *1 214.36,356.32
X$41808 57 8064 8107 8210 8188 8065 8047 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $41809 m0 *1 217.58,356.32
X$41809 73 8050 7341 8111 57 73 8108 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41810 m0 *1 219.42,356.32
X$41810 73 7622 8067 8066 8110 8112 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $41814 m0 *1 225.4,356.32
X$41814 73 8111 7413 7981 7536 73 8067 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $41818 m0 *1 236.9,356.32
X$41818 73 7535 7532 7897 7413 8073 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $41822 m0 *1 246.1,356.32
X$41822 57 15538 8053 8068 7409 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $41836 m0 *1 283.36,356.32
X$41836 73 7338 8116 8117 57 73 7816 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41840 m0 *1 290.26,356.32
X$41840 73 8053 7936 8118 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41841 m0 *1 291.64,356.32
X$41841 73 7413 7849 7936 57 73 8117 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41843 m0 *1 297.16,356.32
X$41843 57 7853 8072 8069 7769 7991 8119 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $41844 m0 *1 300.38,356.32
X$41844 73 8071 73 57 7451 57 sky130_fd_sc_hd__buf_4
* cell instance $41864 m0 *1 348.22,356.32
X$41864 57 7413 8115 8073 7451 7544 7693 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $41872 m0 *1 363.86,356.32
X$41872 57 8012 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $41877 m0 *1 385.02,356.32
X$41877 57 7941 7986 8074 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $41881 m0 *1 396.52,356.32
X$41881 73 8076 8075 73 7900 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41882 m0 *1 399.74,356.32
X$41882 73 4809 8076 8077 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41884 m0 *1 404.8,356.32
X$41884 73 8077 8113 8078 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41889 m0 *1 416.76,356.32
X$41889 73 2342 8078 7858 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $41896 m0 *1 432.4,356.32
X$41896 73 8109 7579 73 7975 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41903 m0 *1 448.5,356.32
X$41903 73 8106 7121 73 7861 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41909 m0 *1 468.28,356.32
X$41909 73 8186 7229 73 5409 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41914 m0 *1 480.24,356.32
X$41914 57 6012 8045 8105 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $41915 m0 *1 486.22,356.32
X$41915 57 8105 8253 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $41918 m0 *1 496.34,356.32
X$41918 73 8079 73 57 7686 57 sky130_fd_sc_hd__buf_4
* cell instance $41921 m0 *1 500.48,356.32
X$41921 57 8103 8044 8019 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $41922 m0 *1 506.46,356.32
X$41922 73 8103 73 57 6958 57 sky130_fd_sc_hd__buf_4
* cell instance $41923 m0 *1 509.22,356.32
X$41923 73 6998 6958 7949 73 8102 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $41924 m0 *1 511.06,356.32
X$41924 57 8019 7772 8102 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $41926 m0 *1 518.88,356.32
X$41926 73 8080 4395 8101 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41928 m0 *1 523.02,356.32
X$41928 73 6003 8081 73 8015 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41931 m0 *1 527.16,356.32
X$41931 73 4334 6003 8099 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41934 m0 *1 531.76,356.32
X$41934 73 8031 8081 73 8039 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41937 m0 *1 537.28,356.32
X$41937 73 4395 8082 73 8096 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41938 m0 *1 540.5,356.32
X$41938 73 8096 8018 8083 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $41941 m0 *1 546.02,356.32
X$41941 57 8093 8080 4334 8031 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $41950 m0 *1 571.78,356.32
X$41950 57 5691 8168 7798 6439 5621 7867 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $41952 m0 *1 576.84,356.32
X$41952 73 8082 4650 73 7952 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41956 m0 *1 582.82,356.32
X$41956 73 6439 8084 7476 73 8090 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $41959 m0 *1 586.04,356.32
X$41959 73 7950 4917 8030 57 73 8084 57 sky130_fd_sc_hd__a21oi_1
* cell instance $41962 m0 *1 592.48,356.32
X$41962 73 8031 4800 73 8022 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $41975 m0 *1 622.84,356.32
X$41975 73 4917 7137 8086 5150 8088 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $41983 m0 *1 640.32,356.32
X$41983 57 6383 7780 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $41985 m0 *1 650.44,356.32
X$41985 73 8024 57 73 2543 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41988 m0 *1 656.88,356.32
X$41988 73 8161 57 73 8025 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42003 r0 *1 36.34,356.32
X$42003 57 8087 4679 8164 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $42011 r0 *1 48.3,356.32
X$42011 73 8178 8165 8097 8027 8758 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $42013 r0 *1 51.98,356.32
X$42013 73 8042 7483 8667 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42020 r0 *1 67.62,356.32
X$42020 73 8059 7647 7961 8121 73 57 8240 57 sky130_fd_sc_hd__o31ai_1
* cell instance $42027 r0 *1 82.8,356.32
X$42027 73 8122 8123 7962 73 8170 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42028 r0 *1 84.64,356.32
X$42028 73 7800 7837 8123 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42036 r0 *1 103.04,356.32
X$42036 73 8094 73 57 8173 57 sky130_fd_sc_hd__buf_4
* cell instance $42040 r0 *1 113.62,356.32
X$42040 73 8060 7483 8175 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42042 r0 *1 115.92,356.32
X$42042 73 7647 73 57 8063 57 sky130_fd_sc_hd__buf_4
* cell instance $42050 r0 *1 129.72,356.32
X$42050 57 8063 8098 8178 7889 8126 8179 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $42053 r0 *1 137.54,356.32
X$42053 73 7758 7801 8063 73 8127 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42054 r0 *1 139.38,356.32
X$42054 73 8100 8126 8063 8042 8127 8181 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $42064 r0 *1 160.54,356.32
X$42064 57 8182 5871 8207 2399 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $42066 r0 *1 169.28,356.32
X$42066 73 5871 73 57 8359 57 sky130_fd_sc_hd__buf_4
* cell instance $42076 r0 *1 190.44,356.32
X$42076 57 7449 8188 8010 8187 8185 8184 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $42078 r0 *1 195.5,356.32
X$42078 73 8185 73 57 8128 57 sky130_fd_sc_hd__buf_4
* cell instance $42088 r0 *1 219.88,356.32
X$42088 73 7362 7447 7539 8066 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $42092 r0 *1 227.7,356.32
X$42092 57 8050 8192 8193 7842 7413 7737 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $42101 r0 *1 243.34,356.32
X$42101 73 7447 8131 8130 57 73 8275 57 sky130_fd_sc_hd__a21oi_1
* cell instance $42102 r0 *1 245.18,356.32
X$42102 73 7495 8129 7852 8068 73 8131 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $42124 r0 *1 297.16,356.32
X$42124 73 7450 7617 8071 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42131 r0 *1 312.8,356.32
X$42131 73 7995 8196 7843 73 8140 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42143 r0 *1 337.18,356.32
X$42143 57 8138 7545 7585 8136 7843 8137 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $42148 r0 *1 343.62,356.32
X$42148 73 7853 8010 8138 8195 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $42149 r0 *1 345.46,356.32
X$42149 73 7938 8011 8139 73 8137 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42152 r0 *1 348.22,356.32
X$42152 73 8140 8115 8194 8455 73 7854 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $42156 r0 *1 361.56,356.32
X$42156 57 8017 8012 8072 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42170 r0 *1 399.28,356.32
X$42170 73 8141 8106 8049 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42174 r0 *1 404.34,356.32
X$42174 73 8364 8113 7000 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42178 r0 *1 413.54,356.32
X$42178 73 8262 7856 73 8145 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $42189 r0 *1 439.76,356.32
X$42189 73 2235 8046 8142 73 8144 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42191 r0 *1 443.44,356.32
X$42191 73 8144 7121 8224 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42192 r0 *1 446.66,356.32
X$42192 73 8144 7121 73 8146 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $42202 r0 *1 465.06,356.32
X$42202 57 8109 7690 8147 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $42210 r0 *1 485.76,356.32
X$42210 73 8045 6012 8149 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42213 r0 *1 493.12,356.32
X$42213 57 8149 8150 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $42214 r0 *1 500.48,356.32
X$42214 57 8043 8044 8162 6998 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $42216 r0 *1 504.62,356.32
X$42216 73 8151 73 57 9343 57 sky130_fd_sc_hd__buf_4
* cell instance $42217 r0 *1 507.38,356.32
X$42217 73 7968 73 57 8183 57 sky130_fd_sc_hd__buf_4
* cell instance $42221 r0 *1 513.36,356.32
X$42221 73 8152 73 57 8082 57 sky130_fd_sc_hd__buf_4
* cell instance $42224 r0 *1 517.5,356.32
X$42224 73 8154 73 57 8180 57 sky130_fd_sc_hd__buf_4
* cell instance $42225 r0 *1 520.26,356.32
X$42225 73 8099 8016 8154 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42226 r0 *1 523.48,356.32
X$42226 73 5520 7582 73 8236 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $42228 r0 *1 528.54,356.32
X$42228 57 7678 8177 8155 8227 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $42230 r0 *1 536.82,356.32
X$42230 73 8081 8156 8155 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42236 r0 *1 544.18,356.32
X$42236 73 8036 8093 8171 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42237 r0 *1 547.4,356.32
X$42237 73 8080 8157 8324 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42238 r0 *1 550.62,356.32
X$42238 73 8430 8156 8172 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42240 r0 *1 554.3,356.32
X$42240 73 2342 8238 8174 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42242 r0 *1 556.14,356.32
X$42242 57 8157 8232 6807 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42249 r0 *1 572.7,356.32
X$42249 73 8168 5880 6786 8090 73 8169 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $42260 r0 *1 598,356.32
X$42260 73 8158 6786 7869 8166 57 8167 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $42261 r0 *1 600.76,356.32
X$42261 73 5691 6296 8088 57 73 8166 57 sky130_fd_sc_hd__a21oi_1
* cell instance $42264 r0 *1 609.96,356.32
X$42264 73 5150 8159 8160 73 8158 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42265 r0 *1 611.8,356.32
X$42265 73 6183 4917 7956 57 73 8159 57 sky130_fd_sc_hd__a21oi_1
* cell instance $42268 r0 *1 617.32,356.32
X$42268 73 4917 7380 8163 5150 8160 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $42290 m0 *1 10.58,361.76
X$42290 73 8235 57 73 8124 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42292 m0 *1 15.18,361.76
X$42292 73 8197 57 73 8164 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42312 m0 *1 61.64,361.76
X$42312 73 7889 73 57 8429 57 sky130_fd_sc_hd__buf_4
* cell instance $42313 m0 *1 64.4,361.76
X$42313 73 7791 8125 7792 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $42316 m0 *1 69.46,361.76
X$42316 73 8240 73 57 8241 57 sky130_fd_sc_hd__buf_4
* cell instance $42322 m0 *1 77.28,361.76
X$42322 73 7837 7647 8242 57 73 8121 57 sky130_fd_sc_hd__a21oi_1
* cell instance $42325 m0 *1 80.5,361.76
X$42325 73 7954 8242 8243 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42326 m0 *1 81.88,361.76
X$42326 73 8343 7830 8243 8170 8246 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $42331 m0 *1 87.86,361.76
X$42331 57 8122 7922 8249 7961 7758 7483 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $42334 m0 *1 93.84,361.76
X$42334 57 8125 8035 8003 73 73 57 sky130_fd_sc_hd__ha_2
* cell instance $42337 m0 *1 99.36,361.76
X$42337 73 8204 73 57 7961 57 sky130_fd_sc_hd__buf_4
* cell instance $42341 m0 *1 111.32,361.76
X$42341 73 8037 8063 8202 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42343 m0 *1 113.16,361.76
X$42343 73 7801 8202 8175 57 73 8258 57 sky130_fd_sc_hd__a21oi_1
* cell instance $42344 m0 *1 115,361.76
X$42344 73 8037 73 57 8203 57 sky130_fd_sc_hd__buf_4
* cell instance $42346 m0 *1 119.6,361.76
X$42346 73 8203 7801 8176 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42353 m0 *1 131.1,361.76
X$42353 73 8125 7801 8126 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $42361 m0 *1 142.14,361.76
X$42361 73 7214 8124 8205 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42363 m0 *1 143.98,361.76
X$42363 73 8204 73 57 8100 57 sky130_fd_sc_hd__buf_4
* cell instance $42366 m0 *1 148.12,361.76
X$42366 73 8205 8182 7214 73 8263 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $42372 m0 *1 159.16,361.76
X$42372 57 8207 7480 8206 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42397 m0 *1 215.74,361.76
X$42397 57 8068 7341 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $42399 m0 *1 223.56,361.76
X$42399 73 7617 8129 8270 8191 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $42403 m0 *1 231.84,361.76
X$42403 73 7983 8214 7907 8192 57 8273 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $42410 m0 *1 246.1,361.76
X$42410 73 7852 7907 7495 73 8303 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42412 m0 *1 248.86,361.76
X$42412 73 7409 7341 8208 57 73 8132 57 sky130_fd_sc_hd__a21oi_1
* cell instance $42414 m0 *1 251.16,361.76
X$42414 73 7264 8277 8275 73 8133 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42422 m0 *1 263.58,361.76
X$42422 73 8132 7366 7408 8128 57 8278 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $42424 m0 *1 267.72,361.76
X$42424 73 8212 8211 7338 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42425 m0 *1 269.1,361.76
X$42425 73 8133 8134 8213 73 8069 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42426 m0 *1 270.94,361.76
X$42426 73 8382 8211 7537 57 73 8134 57 sky130_fd_sc_hd__a21oi_1
* cell instance $42437 m0 *1 292.56,361.76
X$42437 73 8117 7850 8128 8214 57 8274 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $42447 m0 *1 312.34,361.76
X$42447 73 8271 7993 8214 7712 8196 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $42450 m0 *1 314.64,361.76
X$42450 73 8211 8272 7914 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42453 m0 *1 317.4,361.76
X$42453 73 7769 8269 7415 57 73 8135 57 sky130_fd_sc_hd__a21oi_1
* cell instance $42457 m0 *1 325.22,361.76
X$42457 73 7847 8116 7413 7685 57 73 8218 57 sky130_fd_sc_hd__a31oi_1
* cell instance $42463 m0 *1 334.88,361.76
X$42463 57 8136 8219 7685 7622 8218 8614 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $42466 m0 *1 340.86,361.76
X$42466 73 8266 8265 8195 8135 57 8264 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $42487 m0 *1 386.4,361.76
X$42487 73 7984 73 57 57 sky130_fd_sc_hd__clkinv_2
* cell instance $42495 m0 *1 397.44,361.76
X$42495 73 7227 73 57 8222 57 sky130_fd_sc_hd__buf_4
* cell instance $42498 m0 *1 402.96,361.76
X$42498 73 2235 8365 8142 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42499 m0 *1 404.34,361.76
X$42499 57 8113 8222 8261 4813 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $42507 m0 *1 421.82,361.76
X$42507 73 8260 8143 8150 8259 57 8190 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $42519 m0 *1 448.96,361.76
X$42519 73 8254 8255 8253 8257 8189 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $42526 m0 *1 458.62,361.76
X$42526 73 8251 73 57 8143 57 sky130_fd_sc_hd__buf_4
* cell instance $42528 m0 *1 465.06,361.76
X$42528 73 8252 73 57 8147 57 sky130_fd_sc_hd__buf_4
* cell instance $42531 m0 *1 471.96,361.76
X$42531 57 8674 7690 8145 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42535 m0 *1 481.16,361.76
X$42535 73 2342 8225 8250 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42537 m0 *1 484.38,361.76
X$42537 73 8148 7229 73 8350 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $42538 m0 *1 487.6,361.76
X$42538 73 8148 7229 8248 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42540 m0 *1 491.28,361.76
X$42540 73 8250 2342 4251 57 73 8148 57 sky130_fd_sc_hd__a21oi_1
* cell instance $42550 m0 *1 507.38,361.76
X$42550 57 8245 8244 8153 8227 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $42551 m0 *1 516.12,361.76
X$42551 73 8228 8316 8318 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42554 m0 *1 523.48,361.76
X$42554 73 6647 4797 8345 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42557 m0 *1 527.62,361.76
X$42557 73 8228 73 57 8230 57 sky130_fd_sc_hd__buf_4
* cell instance $42559 m0 *1 530.84,361.76
X$42559 73 8082 8230 8177 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42563 m0 *1 534.52,361.76
X$42563 73 8229 73 57 8156 57 sky130_fd_sc_hd__buf_4
* cell instance $42565 m0 *1 537.74,361.76
X$42565 57 8227 4730 6647 8157 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $42568 m0 *1 547.4,361.76
X$42568 73 8317 8020 8231 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42569 m0 *1 550.62,361.76
X$42569 73 8231 8239 8238 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42574 m0 *1 557.06,361.76
X$42574 57 8237 8232 6810 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42580 m0 *1 567.64,361.76
X$42580 57 8038 8233 8169 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42615 m0 *1 644,361.76
X$42615 73 8234 57 73 8162 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42623 r0 *1 11.5,361.76
X$42623 57 8331 8334 8198 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $42627 r0 *1 16.56,361.76
X$42627 57 6092 8280 8281 6094 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $42631 r0 *1 28.06,361.76
X$42631 73 4428 8180 8337 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42644 r0 *1 58.88,361.76
X$42644 73 8199 73 57 8000 57 sky130_fd_sc_hd__buf_4
* cell instance $42647 r0 *1 65.78,361.76
X$42647 73 8342 8089 8200 8178 7958 73 8500 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $42655 r0 *1 82.8,361.76
X$42655 73 7800 7756 8343 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42659 r0 *1 90.62,361.76
X$42659 57 8242 8203 8199 7801 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $42667 r0 *1 104.42,361.76
X$42667 73 8035 73 57 8201 57 sky130_fd_sc_hd__buf_4
* cell instance $42668 r0 *1 107.18,361.76
X$42668 73 8284 73 57 8122 57 sky130_fd_sc_hd__buf_4
* cell instance $42669 r0 *1 109.94,361.76
X$42669 57 8256 8204 8258 8201 8284 73 73 57 sky130_fd_sc_hd__a211oi_2
* cell instance $42670 r0 *1 114.54,361.76
X$42670 73 8202 73 57 8391 57 sky130_fd_sc_hd__buf_4
* cell instance $42672 r0 *1 120.98,361.76
X$42672 57 15668 8199 7800 8062 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $42678 r0 *1 128.34,361.76
X$42678 57 15611 8349 7927 8201 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $42680 r0 *1 133.86,361.76
X$42680 73 7803 6910 8200 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42685 r0 *1 145.36,361.76
X$42685 73 8263 73 57 8204 57 sky130_fd_sc_hd__inv_1
* cell instance $42686 r0 *1 146.74,361.76
X$42686 57 8263 8178 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $42691 r0 *1 159.16,361.76
X$42691 73 7214 8289 8598 73 8206 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42695 r0 *1 166.98,361.76
X$42695 73 8207 73 57 8360 57 sky130_fd_sc_hd__buf_4
* cell instance $42696 r0 *1 169.74,361.76
X$42696 73 8359 8360 8289 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42707 r0 *1 192.28,361.76
X$42707 73 8290 73 57 8208 57 sky130_fd_sc_hd__buf_4
* cell instance $42709 r0 *1 195.96,361.76
X$42709 73 8068 73 57 8209 57 sky130_fd_sc_hd__buf_4
* cell instance $42711 r0 *1 200.56,361.76
X$42711 73 7617 73 57 8367 57 sky130_fd_sc_hd__buf_4
* cell instance $42714 r0 *1 207,361.76
X$42714 73 7539 8367 7409 7620 57 8294 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $42718 r0 *1 211.14,361.76
X$42718 73 8294 8114 8370 73 8371 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42721 r0 *1 217.12,361.76
X$42721 73 8297 8295 8209 73 8110 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42722 r0 *1 218.96,361.76
X$42722 73 7450 7362 7447 8295 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $42726 r0 *1 228.62,361.76
X$42726 57 8375 8378 8273 8010 7907 7898 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $42735 r0 *1 246.56,361.76
X$42735 73 7341 8208 8111 8267 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $42736 r0 *1 248.4,361.76
X$42736 73 7408 73 57 8701 57 sky130_fd_sc_hd__buf_4
* cell instance $42737 r0 *1 251.16,361.76
X$42737 73 8380 8302 8277 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42747 r0 *1 271.4,361.76
X$42747 73 8278 73 57 8305 57 sky130_fd_sc_hd__buf_4
* cell instance $42748 r0 *1 274.16,361.76
X$42748 73 7413 8639 8306 8276 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $42750 r0 *1 276.46,361.76
X$42750 73 7409 7450 7362 8306 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $42760 r0 *1 296.7,361.76
X$42760 73 8274 73 57 8545 57 sky130_fd_sc_hd__buf_4
* cell instance $42764 r0 *1 305.9,361.76
X$42764 73 8215 73 57 8380 57 sky130_fd_sc_hd__buf_4
* cell instance $42767 r0 *1 312.8,361.76
X$42767 73 7339 7938 8271 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42771 r0 *1 316.94,361.76
X$42771 73 7685 8942 7687 8216 8377 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $42775 r0 *1 322.92,361.76
X$42775 73 8217 8216 8398 73 8268 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42776 r0 *1 324.76,361.76
X$42776 73 8376 8377 8268 8220 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $42778 r0 *1 327.06,361.76
X$42778 73 7939 8306 7938 73 8219 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42781 r0 *1 331.66,361.76
X$42781 57 7938 8374 7622 8306 8056 8267 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $42782 r0 *1 334.88,361.76
X$42782 73 7622 8219 8374 7685 8373 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $42788 r0 *1 344.54,361.76
X$42788 73 8372 7850 7938 8139 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $42793 r0 *1 356.96,361.76
X$42793 57 8229 8368 8220 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42802 r0 *1 379.04,361.76
X$42802 57 8412 7984 8264 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42803 r0 *1 386.4,361.76
X$42803 57 7905 7984 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $42805 r0 *1 395.6,361.76
X$42805 57 8308 4811 8309 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $42806 r0 *1 399.28,361.76
X$42806 73 8262 7283 8310 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42808 r0 *1 402.96,361.76
X$42808 73 8310 8221 8225 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42820 r0 *1 435.16,361.76
X$42820 73 8362 73 57 8254 57 sky130_fd_sc_hd__buf_4
* cell instance $42824 r0 *1 444.36,361.76
X$42824 73 8150 8224 8408 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $42825 r0 *1 445.74,361.76
X$42825 73 8224 73 57 8410 57 sky130_fd_sc_hd__buf_4
* cell instance $42827 r0 *1 449.42,361.76
X$42827 73 8223 73 57 8255 57 sky130_fd_sc_hd__buf_4
* cell instance $42843 r0 *1 485.76,361.76
X$42843 57 8350 8314 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $42849 r0 *1 504.62,361.76
X$42849 57 8247 8226 8244 8153 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $42852 r0 *1 513.82,361.76
X$42852 57 8226 6005 8081 4797 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $42853 r0 *1 522.56,361.76
X$42853 73 8317 6647 8319 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42856 r0 *1 527.16,361.76
X$42856 57 9058 8345 8320 8321 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $42858 r0 *1 535.44,361.76
X$42858 73 4978 73 57 8323 57 sky130_fd_sc_hd__buf_4
* cell instance $42863 r0 *1 541.42,361.76
X$42863 73 8081 4797 8341 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42866 r0 *1 547.4,361.76
X$42866 73 8317 4334 8416 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42868 r0 *1 551.54,361.76
X$42868 57 8239 6005 8038 8156 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $42870 r0 *1 559.82,361.76
X$42870 73 8232 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $42880 r0 *1 580.98,361.76
X$42880 57 8335 8233 8167 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42901 r0 *1 636.18,361.76
X$42901 57 8332 7780 8236 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42910 m0 *1 4.14,367.2
X$42910 73 8329 57 73 8198 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42912 m0 *1 8.28,367.2
X$42912 73 8330 4018 7058 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $42913 m0 *1 11.5,367.2
X$42913 57 8387 8384 8331 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $42916 m0 *1 18.86,367.2
X$42916 73 8280 8281 73 8334 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $42925 m0 *1 39.1,367.2
X$42925 73 8579 8338 8029 8425 7961 8666 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $42932 m0 *1 51.06,367.2
X$42932 57 8165 8388 8000 8282 8203 8122 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $42938 m0 *1 59.8,367.2
X$42938 73 7921 8624 8340 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42939 m0 *1 61.18,367.2
X$42939 73 8340 8283 8027 73 8342 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $42952 m0 *1 91.54,367.2
X$42952 57 15522 8431 8003 8035 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $42960 m0 *1 106.72,367.2
X$42960 73 7655 7483 8284 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $42962 m0 *1 109.94,367.2
X$42962 73 8346 73 57 8283 57 sky130_fd_sc_hd__buf_4
* cell instance $42966 m0 *1 115.46,367.2
X$42966 73 8175 73 57 8347 57 sky130_fd_sc_hd__buf_4
* cell instance $42972 m0 *1 126.04,367.2
X$42972 57 15474 8436 7927 8201 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $42975 m0 *1 132.94,367.2
X$42975 73 8199 73 57 8285 57 sky130_fd_sc_hd__buf_4
* cell instance $42977 m0 *1 136.62,367.2
X$42977 57 8438 8286 7834 8287 8126 8285 8288 73 73 57 sky130_fd_sc_hd__a222oi_1
* cell instance $42980 m0 *1 141.22,367.2
X$42980 73 8063 8100 8288 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43002 m0 *1 188.14,367.2
X$43002 73 7450 7709 8290 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43003 m0 *1 189.52,367.2
X$43003 73 7409 7450 8291 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43005 m0 *1 191.36,367.2
X$43005 73 7413 8291 8366 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43012 m0 *1 201.94,367.2
X$43012 73 8367 8366 8292 7669 8370 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $43013 m0 *1 204.7,367.2
X$43013 73 8293 73 57 8272 57 sky130_fd_sc_hd__buf_4
* cell instance $43017 m0 *1 211.14,367.2
X$43017 73 8369 73 57 7668 57 sky130_fd_sc_hd__buf_4
* cell instance $43020 m0 *1 218.5,367.2
X$43020 73 7413 8297 7669 8296 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $43021 m0 *1 221.26,367.2
X$43021 73 8296 7413 8299 57 73 8298 57 sky130_fd_sc_hd__a21oi_1
* cell instance $43024 m0 *1 224.02,367.2
X$43024 73 8300 7617 8297 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43026 m0 *1 229.08,367.2
X$43026 73 8453 7491 8298 57 73 8378 57 sky130_fd_sc_hd__a21oi_1
* cell instance $43027 m0 *1 230.92,367.2
X$43027 73 8297 73 57 8301 57 sky130_fd_sc_hd__buf_4
* cell instance $43030 m0 *1 233.68,367.2
X$43030 73 7449 7767 8302 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43035 m0 *1 245.18,367.2
X$43035 73 7907 8111 8303 7413 8459 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $43045 m0 *1 264.04,367.2
X$43045 73 7622 8301 8129 73 8304 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43046 m0 *1 265.88,367.2
X$43046 73 7907 8617 8304 8398 8382 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $43058 m0 *1 288.42,367.2
X$43058 73 8300 73 57 7538 57 sky130_fd_sc_hd__buf_4
* cell instance $43059 m0 *1 291.18,367.2
X$43059 73 7685 8118 8383 8307 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $43060 m0 *1 293.02,367.2
X$43060 73 8300 7617 7367 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $43068 m0 *1 310.04,367.2
X$43068 73 7413 7993 8381 8215 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $43075 m0 *1 323.84,367.2
X$43075 57 8211 8376 8217 8307 8379 8461 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $43105 m0 *1 389.62,367.2
X$43105 57 8075 8308 8450 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $43108 m0 *1 395.6,367.2
X$43108 57 7226 2235 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $43109 m0 *1 402.96,367.2
X$43109 73 7283 8451 73 8364 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $43121 m0 *1 426.42,367.2
X$43121 73 8445 73 57 8363 57 sky130_fd_sc_hd__buf_4
* cell instance $43126 m0 *1 436.08,367.2
X$43126 73 8361 8358 8600 8441 8406 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $43135 m0 *1 450.8,367.2
X$43135 73 8357 8442 8358 8189 57 73 8355 57 sky130_fd_sc_hd__a31oi_1
* cell instance $43139 m0 *1 464.14,367.2
X$43139 73 8355 8356 8351 8352 73 57 8354 57 sky130_fd_sc_hd__o31ai_1
* cell instance $43142 m0 *1 468.28,367.2
X$43142 73 8354 8692 8311 8353 8312 73 8252 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $43150 m0 *1 481.62,367.2
X$43150 73 8313 8352 8311 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43151 m0 *1 483,367.2
X$43151 73 8314 73 57 8313 57 sky130_fd_sc_hd__buf_4
* cell instance $43154 m0 *1 488.52,367.2
X$43154 73 8315 73 57 8312 57 sky130_fd_sc_hd__buf_4
* cell instance $43156 m0 *1 491.74,367.2
X$43156 73 8248 73 57 8315 57 sky130_fd_sc_hd__buf_4
* cell instance $43165 m0 *1 507.38,367.2
X$43165 73 8152 8348 8244 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $43168 m0 *1 511.98,367.2
X$43168 73 8317 7774 73 8153 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $43171 m0 *1 516.58,367.2
X$43171 57 7228 8318 8319 8320 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $43174 m0 *1 527.16,367.2
X$43174 57 7776 8344 8321 8322 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $43178 m0 *1 536.36,367.2
X$43178 57 8415 7774 4730 8230 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $43180 m0 *1 545.56,367.2
X$43180 57 8322 1768 8335 8157 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $43183 m0 *1 554.76,367.2
X$43183 73 8324 8239 8339 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $43184 m0 *1 557.98,367.2
X$43184 57 6383 8232 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $43188 m0 *1 570.86,367.2
X$43188 57 8336 8333 8171 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $43212 m0 *1 626.06,367.2
X$43212 57 6998 8333 7780 8325 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $43220 m0 *1 647.68,367.2
X$43220 73 8326 57 73 8325 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43223 m0 *1 655.5,367.2
X$43223 73 8327 57 73 8328 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43227 r0 *1 4.14,367.2
X$43227 73 8279 57 73 8423 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43229 r0 *1 8.74,367.2
X$43229 57 8386 8384 8422 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $43232 r0 *1 16.56,367.2
X$43232 73 8386 8387 73 8280 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $43247 r0 *1 57.5,367.2
X$43247 57 8427 8388 8000 8428 8467 8122 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $43248 r0 *1 60.72,367.2
X$43248 73 7470 73 57 7803 57 sky130_fd_sc_hd__clkinv_1
* cell instance $43258 r0 *1 78.66,367.2
X$43258 73 7655 7647 8504 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43263 r0 *1 94.76,367.2
X$43263 73 8432 8246 7961 73 8437 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43274 r0 *1 115.46,367.2
X$43274 73 8178 8434 8391 73 8286 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43277 r0 *1 118.68,367.2
X$43277 73 8199 8063 8435 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43284 r0 *1 127.88,367.2
X$43284 73 8436 73 57 8467 57 sky130_fd_sc_hd__buf_4
* cell instance $43287 r0 *1 136.16,367.2
X$43287 73 8392 73 57 8428 57 sky130_fd_sc_hd__buf_4
* cell instance $43288 r0 *1 138.92,367.2
X$43288 73 7758 8001 8392 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43291 r0 *1 141.68,367.2
X$43291 73 7483 8178 8287 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43312 r0 *1 192.28,367.2
X$43312 73 8443 8366 7532 8444 57 73 8293 57 sky130_fd_sc_hd__a31oi_1
* cell instance $43315 r0 *1 197.34,367.2
X$43315 73 7617 8291 8299 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43327 r0 *1 221.26,367.2
X$43327 73 7339 8548 8270 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43328 r0 *1 222.64,367.2
X$43328 73 7362 8129 8270 8525 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $43332 r0 *1 230,367.2
X$43332 73 8394 7712 8454 7413 7491 73 8453 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $43340 r0 *1 247.48,367.2
X$43340 57 8396 7907 8397 8457 8459 8401 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $43349 r0 *1 265.88,367.2
X$43349 73 8212 73 57 8398 57 sky130_fd_sc_hd__buf_4
* cell instance $43350 r0 *1 268.64,367.2
X$43350 57 8213 9210 8399 7910 8397 7769 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $43354 r0 *1 283.36,367.2
X$43354 57 7585 8400 7409 7767 7538 8462 73 73 57 sky130_fd_sc_hd__o221a_2
* cell instance $43361 r0 *1 296.7,367.2
X$43361 73 8071 73 57 8401 57 sky130_fd_sc_hd__buf_4
* cell instance $43362 r0 *1 299.46,367.2
X$43362 73 7622 7995 8401 8547 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $43364 r0 *1 302.22,367.2
X$43364 73 7413 8402 8071 8400 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $43366 r0 *1 304.98,367.2
X$43366 73 8548 7931 8402 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43367 r0 *1 306.36,367.2
X$43367 73 8402 73 57 7541 57 sky130_fd_sc_hd__buf_4
* cell instance $43369 r0 *1 309.58,367.2
X$43369 73 7938 7538 8214 7617 57 8520 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $43379 r0 *1 338.56,367.2
X$43379 73 8400 73 57 8403 57 sky130_fd_sc_hd__buf_4
* cell instance $43381 r0 *1 341.32,367.2
X$43381 57 8517 8265 7693 8460 8305 8458 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $43383 r0 *1 345.46,367.2
X$43383 73 7938 8552 8403 73 8458 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43386 r0 *1 348.22,367.2
X$43386 73 8456 8404 7585 73 8455 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43387 r0 *1 350.06,367.2
X$43387 73 7413 8452 7937 8404 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $43402 r0 *1 389.16,367.2
X$43402 57 8449 8308 8075 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $43403 r0 *1 395.14,367.2
X$43403 57 8450 8557 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $43414 r0 *1 423.66,367.2
X$43414 73 8406 8407 8408 8447 57 8445 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $43417 r0 *1 427.34,367.2
X$43417 73 8510 8257 8405 8356 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $43443 r0 *1 490.36,367.2
X$43443 73 8440 73 57 8352 57 sky130_fd_sc_hd__buf_4
* cell instance $43446 r0 *1 500.48,367.2
X$43446 73 8245 73 57 8411 57 sky130_fd_sc_hd__buf_4
* cell instance $43451 r0 *1 506.46,367.2
X$43451 73 8412 73 57 8414 57 sky130_fd_sc_hd__buf_4
* cell instance $43456 r0 *1 515.66,367.2
X$43456 57 8439 8318 8319 8322 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $43459 r0 *1 525.32,367.2
X$43459 73 8348 8228 8344 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $43461 r0 *1 529,367.2
X$43461 57 8320 6005 8348 4978 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $43463 r0 *1 537.28,367.2
X$43463 73 8414 6481 73 8419 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $43465 r0 *1 540.96,367.2
X$43465 57 9155 8415 8341 8497 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $43466 r0 *1 549.24,367.2
X$43466 73 8324 8416 8430 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $43469 r0 *1 555.22,367.2
X$43469 57 7611 8417 7482 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $43471 r0 *1 561.2,367.2
X$43471 57 8417 8424 8418 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $43501 r0 *1 631.58,367.2
X$43501 57 8327 7780 8419 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $43504 r0 *1 639.86,367.2
X$43504 57 6998 8424 7780 8420 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $43506 r0 *1 651.36,367.2
X$43506 73 8332 57 73 8494 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43508 r0 *1 656.88,367.2
X$43508 73 8421 57 73 8420 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43510 m0 *1 4.14,372.64
X$43510 73 8464 57 73 8495 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43511 m0 *1 7.82,372.64
X$43511 57 7704 8466 8384 8495 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $43514 m0 *1 18.86,372.64
X$43514 73 8387 73 57 8385 57 sky130_fd_sc_hd__buf_4
* cell instance $43515 m0 *1 21.62,372.64
X$43515 73 4428 8466 8577 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43529 m0 *1 47.38,372.64
X$43529 73 8428 8670 8027 73 8425 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43536 m0 *1 60.72,372.64
X$43536 73 7470 73 57 8468 57 sky130_fd_sc_hd__buf_4
* cell instance $43539 m0 *1 66.24,372.64
X$43539 73 8500 73 57 8501 57 sky130_fd_sc_hd__buf_4
* cell instance $43545 m0 *1 72.22,372.64
X$43545 73 8468 7961 8389 8503 7828 73 8502 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $43547 m0 *1 77.28,372.64
X$43547 73 7647 7837 8390 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43553 m0 *1 86.02,372.64
X$43553 73 7756 8469 8391 8470 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $43555 m0 *1 88.32,372.64
X$43555 73 7828 8586 8470 8389 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $43557 m0 *1 91.08,372.64
X$43557 73 7483 7828 8433 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43559 m0 *1 93.38,372.64
X$43559 73 8062 7483 8434 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43561 m0 *1 95.22,372.64
X$43561 73 8390 7924 8433 7800 8432 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $43567 m0 *1 103.96,372.64
X$43567 73 8034 73 57 8388 57 sky130_fd_sc_hd__buf_4
* cell instance $43570 m0 *1 110.86,372.64
X$43570 73 7801 8435 8509 8346 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $43581 m0 *1 131.1,372.64
X$43581 73 8513 8437 7763 8473 57 73 8515 57 sky130_fd_sc_hd__a31oi_1
* cell instance $43582 m0 *1 133.4,372.64
X$43582 57 8473 8689 8475 7763 8596 8438 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $43606 m0 *1 189.06,372.64
X$43606 73 8443 7709 8290 7339 8446 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $43609 m0 *1 193.66,372.64
X$43609 73 8393 7532 7981 8444 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $43612 m0 *1 196.42,372.64
X$43612 57 15527 8393 8209 7409 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $43614 m0 *1 201.94,372.64
X$43614 73 7767 8476 8448 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43615 m0 *1 203.32,372.64
X$43615 73 8478 73 57 7533 57 sky130_fd_sc_hd__buf_4
* cell instance $43619 m0 *1 207.92,372.64
X$43619 73 8477 73 57 7737 57 sky130_fd_sc_hd__buf_4
* cell instance $43621 m0 *1 214.36,372.64
X$43621 73 8523 73 57 8395 57 sky130_fd_sc_hd__buf_4
* cell instance $43625 m0 *1 220.34,372.64
X$43625 73 8393 7617 8525 73 8524 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43631 m0 *1 228.62,372.64
X$43631 57 57 8129 73 7409 8068 73 sky130_fd_sc_hd__nor2_2
* cell instance $43636 m0 *1 236.44,372.64
X$43636 73 8210 8479 8457 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43639 m0 *1 239.2,372.64
X$43639 73 8542 73 57 7264 57 sky130_fd_sc_hd__buf_4
* cell instance $43647 m0 *1 255.76,372.64
X$43647 73 8480 73 57 8394 57 sky130_fd_sc_hd__buf_4
* cell instance $43652 m0 *1 262.66,372.64
X$43652 73 7617 7449 8480 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $43653 m0 *1 264.96,372.64
X$43653 73 8480 73 57 8116 57 sky130_fd_sc_hd__buf_4
* cell instance $43654 m0 *1 267.72,372.64
X$43654 73 8960 8395 7907 7709 8399 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $43658 m0 *1 273.24,372.64
X$43658 73 7617 8129 7449 7938 73 8481 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $43663 m0 *1 281.06,372.64
X$43663 73 8398 8462 8479 8481 8399 8522 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $43669 m0 *1 289.8,372.64
X$43669 73 7413 7852 8521 7617 57 8383 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $43678 m0 *1 311.88,372.64
X$43678 73 8520 7617 8482 57 73 8463 57 sky130_fd_sc_hd__a21oi_1
* cell instance $43679 m0 *1 313.72,372.64
X$43679 73 7852 7938 8271 73 8482 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43691 m0 *1 335.8,372.64
X$43691 73 8381 7938 8518 8456 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $43698 m0 *1 348.68,372.64
X$43698 73 7993 7544 7413 73 8516 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43719 m0 *1 390.54,372.64
X$43719 73 8514 73 57 5140 57 sky130_fd_sc_hd__buf_4
* cell instance $43726 m0 *1 408.02,372.64
X$43726 73 8512 73 57 8405 57 sky130_fd_sc_hd__buf_4
* cell instance $43735 m0 *1 425.96,372.64
X$43735 73 9347 73 57 8510 57 sky130_fd_sc_hd__buf_4
* cell instance $43747 m0 *1 453.56,372.64
X$43747 73 8257 8595 8484 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43750 m0 *1 457.7,372.64
X$43750 73 8484 8485 8409 8363 57 73 8353 57 sky130_fd_sc_hd__a31oi_1
* cell instance $43754 m0 *1 463.22,372.64
X$43754 73 8508 73 57 8251 57 sky130_fd_sc_hd__buf_4
* cell instance $43759 m0 *1 472.42,372.64
X$43759 73 8150 8146 8409 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43767 m0 *1 489.44,372.64
X$43767 57 8440 8507 8251 8410 8486 8591 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $43774 m0 *1 500.94,372.64
X$43774 57 8439 8506 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $43777 m0 *1 508.3,372.64
X$43777 57 8505 8413 8489 8490 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $43780 m0 *1 517.96,372.64
X$43780 73 8317 8237 8490 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $43782 m0 *1 523.02,372.64
X$43782 73 8499 8565 73 7810 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $43787 m0 *1 529.92,372.64
X$43787 73 8491 8229 8321 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $43790 m0 *1 533.14,372.64
X$43790 73 8323 7216 73 8992 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $43791 m0 *1 536.36,372.64
X$43791 57 8413 7626 8492 8157 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $43794 m0 *1 546.94,372.64
X$43794 57 8492 8232 5990 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $43796 m0 *1 554.76,372.64
X$43796 57 7442 8657 7406 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $43801 m0 *1 562.12,372.64
X$43801 73 8237 7611 73 8426 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $43842 r0 *1 2.76,372.64
X$43842 73 8527 57 73 8573 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43844 r0 *1 7.36,372.64
X$43844 73 7704 8573 8465 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43846 r0 *1 9.66,372.64
X$43846 73 7704 8528 8465 73 8422 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43849 r0 *1 12.88,372.64
X$43849 73 8281 8529 8528 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $43853 r0 *1 17.02,372.64
X$43853 73 8386 73 57 8529 57 sky130_fd_sc_hd__buf_4
* cell instance $43856 r0 *1 21.16,372.64
X$43856 73 8577 8563 4428 73 8576 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $43878 r0 *1 72.22,372.64
X$43878 73 8584 7647 8503 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $43888 r0 *1 97.06,372.64
X$43888 73 7828 8033 8471 57 73 8588 57 sky130_fd_sc_hd__a21oi_1
* cell instance $43891 r0 *1 99.82,372.64
X$43891 73 8467 7801 7483 8471 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $43893 r0 *1 103.5,372.64
X$43893 73 8435 8534 7834 73 8586 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43895 r0 *1 107.18,372.64
X$43895 73 8201 8034 8590 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $43900 r0 *1 118.22,372.64
X$43900 73 7836 73 57 8475 57 sky130_fd_sc_hd__buf_4
* cell instance $43906 r0 *1 128.8,372.64
X$43906 73 7837 73 57 8472 57 sky130_fd_sc_hd__buf_4
* cell instance $43907 r0 *1 131.56,372.64
X$43907 73 8472 8428 8474 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43908 r0 *1 132.94,372.64
X$43908 57 8594 8472 8513 8100 8474 8597 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $43913 r0 *1 146.28,372.64
X$43913 73 8125 8001 8538 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43914 r0 *1 147.66,372.64
X$43914 73 8538 8178 8694 8519 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $43915 r0 *1 150.42,372.64
X$43915 73 8475 8519 8181 57 73 8603 57 sky130_fd_sc_hd__a21oi_1
* cell instance $43935 r0 *1 197.34,372.64
X$43935 57 15584 8477 7450 8539 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $43936 r0 *1 201.94,372.64
X$43936 57 15577 8478 7450 7409 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $43940 r0 *1 207.92,372.64
X$43940 73 8478 8477 8369 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $43942 r0 *1 209.76,372.64
X$43942 73 7737 7413 7928 73 8523 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $43946 r0 *1 217.58,372.64
X$43946 73 8212 73 57 8210 57 sky130_fd_sc_hd__buf_4
* cell instance $43950 r0 *1 225.4,372.64
X$43950 73 8375 73 57 8613 57 sky130_fd_sc_hd__buf_4
* cell instance $43959 r0 *1 241.96,372.64
X$43959 73 7737 73 57 8544 57 sky130_fd_sc_hd__buf_4
* cell instance $44000 r0 *1 343.62,372.64
X$44000 73 7938 8116 8054 8553 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $44001 r0 *1 345.46,372.64
X$44001 73 7413 7850 8054 8554 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $44004 r0 *1 349.6,372.64
X$44004 73 7693 8463 8553 8516 7585 8706 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $44016 r0 *1 378.58,372.64
X$44016 57 4950 8606 7984 8607 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $44017 r0 *1 389.62,372.64
X$44017 57 8514 8606 8641 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $44026 r0 *1 408.02,372.64
X$44026 73 8483 8511 8605 57 73 8407 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44030 r0 *1 413.08,372.64
X$44030 73 8449 73 57 8257 57 sky130_fd_sc_hd__buf_4
* cell instance $44034 r0 *1 421.82,372.64
X$44034 73 8358 8604 8600 8602 57 8259 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $44041 r0 *1 436.08,372.64
X$44041 73 8599 8559 8562 73 8361 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $44065 r0 *1 495.88,372.64
X$44065 57 8505 8563 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $44066 r0 *1 503.24,372.64
X$44066 73 8487 8412 8489 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $44070 r0 *1 509.22,372.64
X$44070 57 8079 8488 8589 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $44072 r0 *1 513.36,372.64
X$44072 57 8589 8587 8564 8490 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $44074 r0 *1 522.56,372.64
X$44074 57 8499 8496 8316 8491 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $44075 r0 *1 530.84,372.64
X$44075 57 8418 8681 8565 8566 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $44080 r0 *1 540.96,372.64
X$44080 57 8497 6005 8156 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $44081 r0 *1 546.94,372.64
X$44081 73 8492 73 57 8567 57 sky130_fd_sc_hd__buf_4
* cell instance $44082 r0 *1 549.7,372.64
X$44082 73 8567 7442 73 8581 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $44083 r0 *1 552.92,372.64
X$44083 57 8582 6005 8020 8568 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $44085 r0 *1 561.2,372.64
X$44085 73 8335 73 57 8496 57 sky130_fd_sc_hd__buf_4
* cell instance $44086 r0 *1 563.96,372.64
X$44086 73 8157 73 57 8568 57 sky130_fd_sc_hd__buf_4
* cell instance $44127 m0 *1 4.14,378.08
X$44127 73 8526 57 73 8574 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44129 m0 *1 8.28,378.08
X$44129 57 7704 8575 8384 8574 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $44132 m0 *1 19.32,378.08
X$44132 57 8529 8576 8661 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $44140 m0 *1 40.48,378.08
X$44140 73 7961 8580 8579 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44149 m0 *1 57.96,378.08
X$44149 73 8027 8427 8530 73 8531 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44151 m0 *1 60.72,378.08
X$44151 73 8531 8532 8502 73 8671 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44153 m0 *1 63.48,378.08
X$44153 73 8178 8468 8532 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44156 m0 *1 67.62,378.08
X$44156 73 8027 8533 8530 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44162 m0 *1 72.22,378.08
X$44162 73 8921 7962 7800 57 73 8584 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44169 m0 *1 88.32,378.08
X$44169 57 8676 8678 7922 8428 7961 7647 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $44178 m0 *1 107.64,378.08
X$44178 73 7652 7483 8534 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44180 m0 *1 109.94,378.08
X$44180 73 8685 4428 8575 57 73 7519 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44183 m0 *1 113.16,378.08
X$44183 73 7925 8063 8536 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $44188 m0 *1 122.36,378.08
X$44188 73 8435 8536 7801 73 8688 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44192 m0 *1 127.88,378.08
X$44192 73 8722 8536 7801 73 8594 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44193 m0 *1 129.72,378.08
X$44193 57 7801 8689 8178 8534 8593 8688 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $44195 m0 *1 133.86,378.08
X$44195 73 8475 8100 8537 57 73 8596 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44219 m0 *1 188.6,378.08
X$44219 73 8539 73 57 7339 57 sky130_fd_sc_hd__buf_4
* cell instance $44225 m0 *1 203.32,378.08
X$44225 73 8608 73 57 7539 57 sky130_fd_sc_hd__buf_4
* cell instance $44229 m0 *1 207,378.08
X$44229 73 8609 7112 73 8540 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $44231 m0 *1 210.68,378.08
X$44231 73 8609 7112 8212 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $44234 m0 *1 218.04,378.08
X$44234 73 8394 8111 8296 7413 7981 73 8611 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $44238 m0 *1 227.24,378.08
X$44238 73 8615 73 57 8193 57 sky130_fd_sc_hd__buf_4
* cell instance $44245 m0 *1 238.74,378.08
X$44245 73 8540 8541 8542 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44254 m0 *1 258.52,378.08
X$44254 73 8541 73 57 8211 57 sky130_fd_sc_hd__buf_4
* cell instance $44257 m0 *1 261.28,378.08
X$44257 57 8010 8543 7332 8479 8704 8703 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $44259 m0 *1 266.34,378.08
X$44259 73 8707 7709 8214 57 73 8617 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44261 m0 *1 268.64,378.08
X$44261 73 8540 73 57 7853 57 sky130_fd_sc_hd__buf_4
* cell instance $44274 m0 *1 297.16,378.08
X$44274 73 8070 8546 7767 8544 8619 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $44275 m0 *1 299.46,378.08
X$44275 57 8704 8714 7622 7853 8547 8619 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $44278 m0 *1 304.06,378.08
X$44278 73 8452 7367 7938 73 8714 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44283 m0 *1 309.58,378.08
X$44283 73 8548 7617 8549 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44284 m0 *1 310.96,378.08
X$44284 73 8549 73 57 7993 57 sky130_fd_sc_hd__buf_4
* cell instance $44291 m0 *1 323.38,378.08
X$44291 73 8211 8712 9466 8461 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $44292 m0 *1 325.22,378.08
X$44292 73 7993 7544 7938 73 8713 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44294 m0 *1 327.98,378.08
X$44294 73 7533 8551 7413 73 8550 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44298 m0 *1 334.88,378.08
X$44298 57 8616 8614 8550 7544 7993 7413 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $44303 m0 *1 343.62,378.08
X$44303 73 7852 7938 7693 73 8612 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44304 m0 *1 345.46,378.08
X$44304 73 8544 8551 8116 73 8552 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44306 m0 *1 348.22,378.08
X$44306 73 8544 7413 7843 8554 8705 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $44320 m0 *1 378.58,378.08
X$44320 73 8642 57 73 8607 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44327 m0 *1 390.54,378.08
X$44327 57 8558 8555 8556 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $44333 m0 *1 402.96,378.08
X$44333 73 8558 73 57 8491 57 sky130_fd_sc_hd__buf_4
* cell instance $44348 m0 *1 437,378.08
X$44348 73 8257 8601 8559 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44349 m0 *1 438.38,378.08
X$44349 73 8559 73 57 8600 57 sky130_fd_sc_hd__buf_4
* cell instance $44358 m0 *1 452.64,378.08
X$44358 73 8649 8483 8592 8562 8595 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $44366 m0 *1 472.88,378.08
X$44366 73 8487 73 57 8005 57 sky130_fd_sc_hd__buf_4
* cell instance $44374 m0 *1 490.82,378.08
X$44374 73 8312 8253 9267 57 73 8591 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44386 m0 *1 513.36,378.08
X$44386 73 8489 73 57 8564 57 sky130_fd_sc_hd__buf_4
* cell instance $44387 m0 *1 516.12,378.08
X$44387 57 8587 6005 5520 8745 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $44393 m0 *1 529.92,378.08
X$44393 57 8683 8585 8566 8317 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $44398 m0 *1 542.8,378.08
X$44398 73 8005 8567 73 8583 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $44399 m0 *1 546.02,378.08
X$44399 73 8567 8157 8566 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $44401 m0 *1 551.08,378.08
X$44401 73 8582 8416 73 8578 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $44403 m0 *1 554.76,378.08
X$44403 57 8672 8005 8156 8568 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $44406 m0 *1 563.04,378.08
X$44406 73 8568 7124 73 8569 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $44438 m0 *1 638.02,378.08
X$44438 57 8659 8570 8569 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $44453 r0 *1 16.56,378.08
X$44453 57 7753 8621 8863 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $44454 r0 *1 22.54,378.08
X$44454 57 8621 7302 8640 8663 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $44460 r0 *1 40.02,378.08
X$44460 73 8468 8666 8665 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44461 r0 *1 41.4,378.08
X$44461 73 7961 8667 8622 57 73 8669 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44466 r0 *1 47.84,378.08
X$44466 73 7921 8623 8764 57 73 8670 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44481 r0 *1 83.72,378.08
X$44481 73 8625 8203 8532 8673 57 8675 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $44484 r0 *1 87.86,378.08
X$44484 73 8535 8433 8625 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44485 r0 *1 89.24,378.08
X$44485 73 8678 73 57 8680 57 sky130_fd_sc_hd__buf_4
* cell instance $44488 r0 *1 96.6,378.08
X$44488 73 7924 8033 7483 8682 57 73 8684 57 sky130_fd_sc_hd__a31oi_1
* cell instance $44494 r0 *1 107.64,378.08
X$44494 73 8590 73 57 8686 57 sky130_fd_sc_hd__buf_4
* cell instance $44497 r0 *1 114.54,378.08
X$44497 73 7758 8627 8590 73 8721 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44498 r0 *1 116.38,378.08
X$44498 73 7756 7647 8627 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44499 r0 *1 117.76,378.08
X$44499 73 8627 73 57 8535 57 sky130_fd_sc_hd__buf_4
* cell instance $44507 r0 *1 129.72,378.08
X$44507 73 7833 8791 7801 73 8694 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44508 r0 *1 131.56,378.08
X$44508 73 8688 73 57 8629 57 sky130_fd_sc_hd__buf_4
* cell instance $44511 r0 *1 137.08,378.08
X$44511 73 7837 8178 8691 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44533 r0 *1 190.44,378.08
X$44533 73 7807 7973 7709 57 73 8631 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44534 r0 *1 192.28,378.08
X$44534 73 7973 8209 8443 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44535 r0 *1 193.66,378.08
X$44535 73 8209 8631 8696 73 8632 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44537 r0 *1 195.96,378.08
X$44537 73 8632 73 57 8635 57 sky130_fd_sc_hd__buf_4
* cell instance $44540 r0 *1 200.1,378.08
X$44540 73 8292 73 57 7843 57 sky130_fd_sc_hd__buf_4
* cell instance $44541 r0 *1 202.86,378.08
X$44541 73 8548 8209 8608 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44543 r0 *1 204.7,378.08
X$44543 73 8540 7928 8728 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44555 r0 *1 228.62,378.08
X$44555 73 8479 8698 8446 8699 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $44556 r0 *1 230.46,378.08
X$44556 73 7409 8633 8615 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44557 r0 *1 231.84,378.08
X$44557 73 8634 73 57 8111 57 sky130_fd_sc_hd__buf_4
* cell instance $44559 r0 *1 234.6,378.08
X$44559 73 7413 8637 8636 8454 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $44562 r0 *1 237.36,378.08
X$44562 57 8703 8635 8637 8701 8700 8542 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $44565 r0 *1 245.18,378.08
X$44565 73 8615 73 57 8638 57 sky130_fd_sc_hd__buf_4
* cell instance $44574 r0 *1 265.42,378.08
X$44574 73 8636 73 57 8639 57 sky130_fd_sc_hd__buf_4
* cell instance $44575 r0 *1 268.18,378.08
X$44575 73 8634 73 57 8518 57 sky130_fd_sc_hd__buf_4
* cell instance $44578 r0 *1 275.08,378.08
X$44578 73 8543 73 57 8709 57 sky130_fd_sc_hd__buf_4
* cell instance $44582 r0 *1 286.12,378.08
X$44582 73 8783 8117 8618 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44585 r0 *1 287.96,378.08
X$44585 73 8522 7907 9467 57 73 8711 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44586 r0 *1 289.8,378.08
X$44586 73 9018 7493 8711 8610 8556 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $44590 r0 *1 298.08,378.08
X$44590 73 7450 7938 8546 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44601 r0 *1 324.76,378.08
X$44601 57 7938 8712 8479 8638 7544 8713 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $44602 r0 *1 327.98,378.08
X$44602 73 8550 8618 8710 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44609 r0 *1 344.54,378.08
X$44609 73 8612 7938 8552 57 73 8708 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44612 r0 *1 347.76,378.08
X$44612 57 8610 8776 8705 8010 8398 8706 73 73 57 sky130_fd_sc_hd__a41o_1
* cell instance $44624 r0 *1 375.82,378.08
X$44624 73 7201 57 73 8702 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44638 r0 *1 415.84,378.08
X$44638 73 8257 8644 8645 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44639 r0 *1 417.22,378.08
X$44639 73 8483 8645 8644 8697 73 8646 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $44641 r0 *1 420.44,378.08
X$44641 73 8560 8646 8447 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44644 r0 *1 423.66,378.08
X$44644 73 8647 8601 8362 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44649 r0 *1 430.56,378.08
X$44649 73 8557 73 57 8648 57 sky130_fd_sc_hd__buf_4
* cell instance $44654 r0 *1 442.06,378.08
X$44654 73 8410 8312 8561 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44660 r0 *1 453.1,378.08
X$44660 73 8560 8649 8650 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44661 r0 *1 454.48,378.08
X$44661 57 8651 8687 8483 8650 8647 8695 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $44666 r0 *1 466.44,378.08
X$44666 73 8651 8648 8150 8652 57 8693 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $44667 r0 *1 469.2,378.08
X$44667 73 8561 8654 8693 8692 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $44670 r0 *1 473.8,378.08
X$44670 73 8441 8653 8740 8253 57 73 8690 57 sky130_fd_sc_hd__a31oi_1
* cell instance $44689 r0 *1 516.12,378.08
X$44689 57 8683 8640 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $44691 r0 *1 523.94,378.08
X$44691 57 8643 5520 8585 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $44692 r0 *1 529.92,378.08
X$44692 57 8681 8414 8643 8156 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $44697 r0 *1 540.96,378.08
X$44697 73 8677 8583 8679 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $44698 r0 *1 544.18,378.08
X$44698 57 8677 8317 6005 8643 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $44701 r0 *1 553.84,378.08
X$44701 73 8643 7945 73 8662 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $44706 r0 *1 563.04,378.08
X$44706 73 8156 8019 73 8660 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $44712 r0 *1 576.84,378.08
X$44712 73 8233 73 57 15424 57 sky130_fd_sc_hd__clkinvlp_4
* cell instance $44713 r0 *1 579.6,378.08
X$44713 57 8104 8233 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $44723 r0 *1 603.98,378.08
X$44723 57 6998 8493 8668 8664 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $44725 r0 *1 615.02,378.08
X$44725 73 8572 57 73 8664 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44734 r0 *1 636.18,378.08
X$44734 57 8658 8570 8662 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $44737 r0 *1 647.22,378.08
X$44737 73 8659 57 73 8749 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44740 r0 *1 653.2,378.08
X$44740 73 8658 57 73 8571 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44743 m0 *1 4.14,383.52
X$44743 73 8715 57 73 8752 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44745 m0 *1 8.74,383.52
X$44745 57 8751 7752 8752 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $44750 m0 *1 17.02,383.52
X$44750 73 7566 73 57 7752 57 sky130_fd_sc_hd__buf_4
* cell instance $44751 m0 *1 19.78,383.52
X$44751 73 8753 8754 73 7566 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $44764 m0 *1 46.92,383.52
X$44764 57 8027 8759 8758 8757 8669 8760 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $44767 m0 *1 55.66,383.52
X$44767 73 8467 7483 8717 73 8624 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44778 m0 *1 75.9,383.52
X$44778 73 8831 7756 8027 57 73 8673 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44779 m0 *1 77.74,383.52
X$44779 73 8867 8718 8343 7647 7758 8533 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $44786 m0 *1 93.84,383.52
X$44786 73 7834 8390 8433 8203 8628 8762 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $44790 m0 *1 100.74,383.52
X$44790 73 8626 73 57 8676 57 sky130_fd_sc_hd__buf_4
* cell instance $44792 m0 *1 105.34,383.52
X$44792 73 7834 8719 8720 57 73 8626 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44793 m0 *1 107.18,383.52
X$44793 73 8720 73 57 8717 57 sky130_fd_sc_hd__buf_4
* cell instance $44800 m0 *1 119.6,383.52
X$44800 73 7834 8435 7761 8768 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $44806 m0 *1 124.66,383.52
X$44806 73 8721 73 57 8630 57 sky130_fd_sc_hd__buf_4
* cell instance $44809 m0 *1 130.18,383.52
X$44809 73 7758 8063 8593 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44817 m0 *1 143.52,383.52
X$44817 73 8628 8001 8724 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44820 m0 *1 147.2,383.52
X$44820 73 8630 8724 8178 73 9191 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44821 m0 *1 149.04,383.52
X$44821 73 8538 8630 8178 73 8771 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44840 m0 *1 186.3,383.52
X$44840 57 7709 7617 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $44843 m0 *1 195.96,383.52
X$44843 73 8728 8778 8726 57 73 8696 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44845 m0 *1 198.72,383.52
X$44845 73 8727 7981 8292 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44848 m0 *1 204.24,383.52
X$44848 73 8728 73 57 7929 57 sky130_fd_sc_hd__buf_4
* cell instance $44851 m0 *1 207,383.52
X$44851 73 8726 73 57 7618 57 sky130_fd_sc_hd__buf_4
* cell instance $44854 m0 *1 212.52,383.52
X$44854 73 8300 7413 8633 73 8730 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44857 m0 *1 215.74,383.52
X$44857 73 8730 8779 8611 7981 7622 73 8729 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $44864 m0 *1 228.62,383.52
X$44864 73 8780 8479 7622 8699 57 8065 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $44881 m0 *1 267.72,383.52
X$44881 73 7938 8634 8731 57 73 8698 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44882 m0 *1 269.56,383.52
X$44882 73 8548 7709 8731 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44888 m0 *1 282.9,383.52
X$44888 73 8731 73 57 8783 57 sky130_fd_sc_hd__buf_4
* cell instance $44900 m0 *1 309.12,383.52
X$44900 73 7339 8548 7931 8732 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $44901 m0 *1 310.96,383.52
X$44901 73 8732 73 57 7265 57 sky130_fd_sc_hd__buf_4
* cell instance $44905 m0 *1 317.4,383.52
X$44905 73 7852 7618 8852 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44910 m0 *1 327.52,383.52
X$44910 73 8551 8707 7850 73 8851 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $44913 m0 *1 330.74,383.52
X$44913 73 7617 73 57 8551 57 sky130_fd_sc_hd__buf_4
* cell instance $44915 m0 *1 333.96,383.52
X$44915 73 7535 8551 8372 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44932 m0 *1 371.22,383.52
X$44932 57 4950 8775 8368 8702 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $44938 m0 *1 389.62,383.52
X$44938 73 8773 73 57 8643 57 sky130_fd_sc_hd__buf_4
* cell instance $44946 m0 *1 405.72,383.52
X$44946 73 8150 8735 8736 57 73 8512 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44947 m0 *1 407.56,383.52
X$44947 73 8735 8769 8605 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44950 m0 *1 413.54,383.52
X$44950 73 8737 8648 8511 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $44951 m0 *1 414.92,383.52
X$44951 73 8737 8648 8697 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44956 m0 *1 419.98,383.52
X$44956 73 8735 8601 8695 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $44971 m0 *1 451.72,383.52
X$44971 73 8761 73 57 8649 57 sky130_fd_sc_hd__buf_4
* cell instance $44987 m0 *1 486.22,383.52
X$44987 73 8833 8763 8690 57 73 8486 57 sky130_fd_sc_hd__a21oi_1
* cell instance $44990 m0 *1 490.82,383.52
X$44990 73 8766 8765 8253 73 8507 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45000 m0 *1 505.54,383.52
X$45000 73 8832 73 57 8654 57 sky130_fd_sc_hd__buf_4
* cell instance $45005 m0 *1 517.96,383.52
X$45005 57 8655 8237 8745 7626 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $45009 m0 *1 529.46,383.52
X$45009 57 8898 8323 8491 8237 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $45014 m0 *1 539.12,383.52
X$45014 57 8656 8655 8497 8585 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $45016 m0 *1 547.86,383.52
X$45016 57 8826 8493 8656 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $45020 m0 *1 554.76,383.52
X$45020 73 8672 8585 8748 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $45021 m0 *1 557.98,383.52
X$45021 57 8657 8756 8748 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $45060 m0 *1 645.38,383.52
X$45060 57 8750 8570 8660 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $45067 r0 *1 8.74,383.52
X$45067 57 8754 8384 8751 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $45070 r0 *1 16.56,383.52
X$45070 57 8753 8384 8755 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $45081 r0 *1 45.08,383.52
X$45081 57 8757 8624 8716 8178 7921 8786 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $45086 r0 *1 61.18,383.52
X$45086 73 7961 7803 8827 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45095 r0 *1 77.28,383.52
X$45095 57 8788 7608 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $45100 r0 *1 96.14,383.52
X$45100 73 7833 73 57 8834 57 sky130_fd_sc_hd__buf_4
* cell instance $45104 r0 *1 100.28,383.52
X$45104 73 8719 73 57 8764 57 sky130_fd_sc_hd__buf_4
* cell instance $45107 r0 *1 108.56,383.52
X$45107 73 8062 7647 8719 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45109 r0 *1 113.62,383.52
X$45109 73 8719 73 57 8789 57 sky130_fd_sc_hd__buf_4
* cell instance $45112 r0 *1 119.14,383.52
X$45112 73 8684 73 57 8767 57 sky130_fd_sc_hd__buf_4
* cell instance $45118 r0 *1 127.88,383.52
X$45118 73 8467 8063 8722 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45122 r0 *1 137.08,383.52
X$45122 73 8691 73 57 8839 57 sky130_fd_sc_hd__buf_4
* cell instance $45123 r0 *1 139.84,383.52
X$45123 73 8723 73 57 8628 57 sky130_fd_sc_hd__inv_1
* cell instance $45124 r0 *1 141.22,383.52
X$45124 73 7886 73 57 8723 57 sky130_fd_sc_hd__buf_4
* cell instance $45140 r0 *1 179.4,383.52
X$45140 73 8777 8725 7709 73 57 57 sky130_fd_sc_hd__or2_2
* cell instance $45142 r0 *1 182.16,383.52
X$45142 73 7973 8777 8725 7897 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $45147 r0 *1 194.58,383.52
X$45147 73 7709 73 57 8633 57 sky130_fd_sc_hd__buf_4
* cell instance $45148 r0 *1 197.34,383.52
X$45148 73 7413 7532 8726 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45149 r0 *1 198.72,383.52
X$45149 73 7928 8608 7532 73 8938 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45156 r0 *1 209.76,383.52
X$45156 73 7849 73 57 7535 57 sky130_fd_sc_hd__buf_4
* cell instance $45157 r0 *1 212.52,383.52
X$45157 73 8010 8371 8729 9012 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $45163 r0 *1 230,383.52
X$45163 73 8781 73 57 8780 57 sky130_fd_sc_hd__buf_4
* cell instance $45169 r0 *1 239.2,383.52
X$45169 73 7450 7938 8794 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45170 r0 *1 240.58,383.52
X$45170 73 8794 73 57 8214 57 sky130_fd_sc_hd__buf_4
* cell instance $45174 r0 *1 246.56,383.52
X$45174 73 8782 7709 8636 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45175 r0 *1 247.94,383.52
X$45175 73 8782 73 57 7852 57 sky130_fd_sc_hd__buf_4
* cell instance $45188 r0 *1 278.76,383.52
X$45188 73 8698 73 57 9567 57 sky130_fd_sc_hd__buf_4
* cell instance $45189 r0 *1 281.52,383.52
X$45189 73 8731 73 57 8887 57 sky130_fd_sc_hd__buf_4
* cell instance $45191 r0 *1 286.12,383.52
X$45191 73 7544 8639 7413 73 8859 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45200 r0 *1 302.68,383.52
X$45200 57 8546 8854 8452 8638 7367 7938 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $45202 r0 *1 309.58,383.52
X$45202 73 8802 7937 7413 73 8801 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45205 r0 *1 312.8,383.52
X$45205 73 7533 7617 8802 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45207 r0 *1 314.18,383.52
X$45207 73 8802 73 57 7939 57 sky130_fd_sc_hd__buf_4
* cell instance $45211 r0 *1 320.16,383.52
X$45211 73 7938 7541 8639 8733 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $45216 r0 *1 331.66,383.52
X$45216 73 7535 7617 8616 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $45222 r0 *1 345.46,383.52
X$45222 73 8372 8544 8551 57 73 8849 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45225 r0 *1 348.22,383.52
X$45225 73 8733 8803 8893 73 8776 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45227 r0 *1 350.52,383.52
X$45227 73 7413 7937 8301 8803 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $45238 r0 *1 375.82,383.52
X$45238 57 7171 9460 8774 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $45239 r0 *1 385.94,383.52
X$45239 57 8774 3030 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $45240 r0 *1 393.3,383.52
X$45240 73 8734 73 57 8772 57 sky130_fd_sc_hd__buf_4
* cell instance $45244 r0 *1 398.82,383.52
X$45244 73 8512 8804 9007 8604 8647 8734 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $45249 r0 *1 407.56,383.52
X$45249 73 8770 73 57 8769 57 sky130_fd_sc_hd__buf_4
* cell instance $45250 r0 *1 410.32,383.52
X$45250 73 8511 73 57 8843 57 sky130_fd_sc_hd__buf_4
* cell instance $45253 r0 *1 417.22,383.52
X$45253 73 8697 73 57 8739 57 sky130_fd_sc_hd__buf_4
* cell instance $45255 r0 *1 420.44,383.52
X$45255 73 8483 8807 8600 73 8738 57 57 sky130_fd_sc_hd__a21oi_2
* cell instance $45266 r0 *1 442.98,383.52
X$45266 73 8739 8357 8442 8253 57 73 8840 57 sky130_fd_sc_hd__a31oi_1
* cell instance $45271 r0 *1 451.72,383.52
X$45271 73 8837 73 57 8357 57 sky130_fd_sc_hd__buf_4
* cell instance $45290 r0 *1 490.82,383.52
X$45290 73 8765 8358 8742 57 73 8835 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45291 r0 *1 492.66,383.52
X$45291 73 8743 8741 8815 73 8742 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45293 r0 *1 496.34,383.52
X$45293 73 8740 8744 8741 57 73 8763 57 sky130_fd_sc_hd__a21o_1
* cell instance $45296 r0 *1 500.48,383.52
X$45296 73 8743 8358 8744 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45304 r0 *1 518.88,383.52
X$45304 73 7626 7250 73 8821 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $45307 r0 *1 523.48,383.52
X$45307 73 8745 7626 8565 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $45310 r0 *1 529,383.52
X$45310 57 8830 8496 8323 7626 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $45313 r0 *1 537.74,383.52
X$45313 73 8746 73 57 7946 57 sky130_fd_sc_hd__buf_4
* cell instance $45315 r0 *1 540.96,383.52
X$45315 57 8746 8747 8679 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $45318 r0 *1 546.02,383.52
X$45318 57 8825 8583 8497 5520 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $45356 r0 *1 643.54,383.52
X$45356 73 8674 57 73 8818 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45359 r0 *1 651.36,383.52
X$45359 73 8819 57 73 3143 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45360 r0 *1 655.04,383.52
X$45360 73 8750 57 73 8817 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45366 m0 *1 11.04,388.96
X$45366 57 7608 8384 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $45384 m0 *1 54.74,388.96
X$45384 73 8504 73 57 8786 57 sky130_fd_sc_hd__buf_4
* cell instance $45389 m0 *1 66.24,388.96
X$45389 73 8178 7803 8787 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45395 m0 *1 74.06,388.96
X$45395 73 7954 8864 7756 8534 57 8831 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $45397 m0 *1 77.28,388.96
X$45397 73 7608 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $45401 m0 *1 85.56,388.96
X$45401 73 8343 7647 8787 8062 8588 73 8918 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $45410 m0 *1 108.1,388.96
X$45410 73 8201 7801 8921 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45417 m0 *1 115.46,388.96
X$45417 73 7800 8063 8718 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45420 m0 *1 118.22,388.96
X$45420 73 8434 8718 7834 8768 57 73 8922 57 sky130_fd_sc_hd__a31oi_1
* cell instance $45425 m0 *1 124.66,388.96
X$45425 73 7801 8347 8789 8790 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $45428 m0 *1 127.88,388.96
X$45428 57 7801 8925 8873 8722 8791 8790 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $45429 m0 *1 131.1,388.96
X$45429 73 8285 7483 8791 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45432 m0 *1 136.62,388.96
X$45432 73 8792 7800 8838 57 73 8597 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45433 m0 *1 138.46,388.96
X$45433 73 7834 8717 8928 57 73 8792 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45451 m0 *1 177.1,388.96
X$45451 57 15548 7973 8844 7409 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $45456 m0 *1 184.46,388.96
X$45456 73 8845 57 73 8539 57 sky130_fd_sc_hd__inv_2
* cell instance $45458 m0 *1 187.68,388.96
X$45458 73 8955 73 57 7450 57 sky130_fd_sc_hd__buf_4
* cell instance $45459 m0 *1 190.44,388.96
X$45459 73 8541 73 57 8727 57 sky130_fd_sc_hd__buf_4
* cell instance $45460 m0 *1 193.2,388.96
X$45460 73 8443 8727 8633 8937 57 73 9110 57 sky130_fd_sc_hd__a31oi_1
* cell instance $45463 m0 *1 196.88,388.96
X$45463 57 15566 8793 8844 8539 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $45464 m0 *1 201.48,388.96
X$45464 73 7849 73 57 8778 57 sky130_fd_sc_hd__buf_4
* cell instance $45469 m0 *1 205.62,388.96
X$45469 73 8793 8848 8853 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45470 m0 *1 207,388.96
X$45470 73 8793 73 57 8300 57 sky130_fd_sc_hd__buf_4
* cell instance $45485 m0 *1 237.82,388.96
X$45485 73 7413 8853 8636 8795 73 57 8781 57 sky130_fd_sc_hd__o31ai_1
* cell instance $45486 m0 *1 240.58,388.96
X$45486 73 8544 9039 8779 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45488 m0 *1 243.8,388.96
X$45488 57 15506 8782 8548 7409 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $45489 m0 *1 248.4,388.96
X$45489 73 8782 7617 7846 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45495 m0 *1 254.38,388.96
X$45495 57 8394 8796 7413 8886 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $45496 m0 *1 256.68,388.96
X$45496 73 8796 7938 7930 57 73 8797 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45501 m0 *1 263.12,388.96
X$45501 73 8887 8886 7413 57 73 8856 57 sky130_fd_sc_hd__a21o_1
* cell instance $45502 m0 *1 265.88,388.96
X$45502 73 7938 7930 8856 7843 8857 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $45505 m0 *1 270.02,388.96
X$45505 73 7585 8481 8885 8858 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $45509 m0 *1 275.08,388.96
X$45509 73 8398 8857 8858 8860 7622 73 8888 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $45511 m0 *1 278.76,388.96
X$45511 73 7535 9039 8861 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45514 m0 *1 281.52,388.96
X$45514 73 7685 8798 8799 73 8860 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45515 m0 *1 283.36,388.96
X$45515 73 7685 8800 8861 8799 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $45517 m0 *1 285.66,388.96
X$45517 73 8544 8187 8859 73 8798 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45523 m0 *1 292.56,388.96
X$45523 73 8801 73 57 8800 57 sky130_fd_sc_hd__buf_4
* cell instance $45526 m0 *1 298.08,388.96
X$45526 57 7413 8946 7585 8855 7367 8801 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $45527 m0 *1 301.3,388.96
X$45527 73 7339 7617 8855 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45528 m0 *1 302.68,388.96
X$45528 73 8855 73 57 8452 57 sky130_fd_sc_hd__buf_4
* cell instance $45533 m0 *1 308.66,388.96
X$45533 73 8853 73 57 8381 57 sky130_fd_sc_hd__buf_4
* cell instance $45541 m0 *1 326.6,388.96
X$45541 73 8852 7413 8851 57 73 8941 57 sky130_fd_sc_hd__a21boi_0
* cell instance $45543 m0 *1 331.2,388.96
X$45543 73 7413 8070 8638 8850 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $45561 m0 *1 367.54,388.96
X$45561 57 8773 8368 8847 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $45575 m0 *1 397.44,388.96
X$45575 57 8761 8804 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $45578 m0 *1 407.1,388.96
X$45578 73 8483 8605 8846 57 73 8806 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45581 m0 *1 413.08,388.96
X$45581 73 8449 73 57 8805 57 sky130_fd_sc_hd__buf_4
* cell instance $45584 m0 *1 416.76,388.96
X$45584 73 8897 8805 8483 8645 57 8807 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $45591 m0 *1 431.48,388.96
X$45591 73 8647 8592 8842 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45592 m0 *1 432.86,388.96
X$45592 57 8806 8841 8926 8842 8808 8897 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $45594 m0 *1 437.92,388.96
X$45594 73 8150 8648 8808 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45596 m0 *1 441.14,388.96
X$45596 73 8808 73 57 8814 57 sky130_fd_sc_hd__buf_4
* cell instance $45601 m0 *1 449.42,388.96
X$45601 73 8815 8809 8805 8358 8602 73 8929 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $45608 m0 *1 462.76,388.96
X$45608 73 8805 8927 8810 57 73 8508 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45616 m0 *1 474.72,388.96
X$45616 73 8811 9153 8812 8358 8648 73 8652 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $45619 m0 *1 477.94,388.96
X$45619 73 8358 8811 8813 57 73 8765 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45622 m0 *1 485.3,388.96
X$45622 73 8836 9099 8835 8814 8351 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $45637 m0 *1 523.48,388.96
X$45637 73 8496 8745 73 8920 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $45639 m0 *1 527.16,388.96
X$45639 73 8316 8414 8829 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $45640 m0 *1 530.38,388.96
X$45640 73 8830 8829 73 8828 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $45646 m0 *1 542.8,388.96
X$45646 73 8917 8916 73 7460 57 57 sky130_fd_sc_hd__and2_2
* cell instance $45647 m0 *1 545.56,388.96
X$45647 57 6481 8826 9404 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $45652 m0 *1 555.22,388.96
X$45652 73 8496 7654 73 8816 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $45655 m0 *1 558.44,388.96
X$45655 57 6998 8488 8233 8824 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $45659 m0 *1 574.54,388.96
X$45659 57 8823 7111 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $45662 m0 *1 582.82,388.96
X$45662 57 8913 8233 8822 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $45681 m0 *1 629.74,388.96
X$45681 57 8904 8570 8816 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $45687 m0 *1 639.86,388.96
X$45687 57 8819 8570 8820 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $45695 r0 *1 5.06,388.96
X$45695 73 8784 57 73 8905 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45696 r0 *1 8.74,388.96
X$45696 73 7704 8905 8906 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45697 r0 *1 10.12,388.96
X$45697 73 7704 4408 8906 73 8910 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45698 r0 *1 11.96,388.96
X$45698 57 8907 8281 8423 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $45706 r0 *1 23,388.96
X$45706 73 8754 73 57 8911 57 sky130_fd_sc_hd__buf_4
* cell instance $45712 r0 *1 42.32,388.96
X$45712 73 8864 8122 8622 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45718 r0 *1 44.62,388.96
X$45718 57 9073 7760 7962 8027 7921 8786 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $45734 r0 *1 77.74,388.96
X$45734 73 7758 7921 8867 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45740 r0 *1 89.7,388.96
X$45740 73 8472 8870 8249 8868 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $45748 r0 *1 103.04,388.96
X$45748 73 8062 7483 8343 57 73 8996 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45750 r0 *1 105.8,388.96
X$45750 73 8718 73 57 8872 57 sky130_fd_sc_hd__buf_4
* cell instance $45765 r0 *1 130.18,388.96
X$45765 73 8349 7483 8874 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45767 r0 *1 132.48,388.96
X$45767 73 8349 73 57 8875 57 sky130_fd_sc_hd__buf_4
* cell instance $45769 r0 *1 137.08,388.96
X$45769 73 7801 7483 8838 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45770 r0 *1 138.46,388.96
X$45770 73 8875 8063 8928 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45776 r0 *1 150.42,388.96
X$45776 73 8100 8877 8535 8285 7801 8870 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $45792 r0 *1 180.32,388.96
X$45792 73 8880 8879 8881 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45794 r0 *1 182.16,388.96
X$45794 57 8880 7449 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $45796 r0 *1 189.98,388.96
X$45796 73 8881 73 57 8634 57 sky130_fd_sc_hd__buf_4
* cell instance $45798 r0 *1 193.2,388.96
X$45798 73 7973 73 57 8882 57 sky130_fd_sc_hd__buf_4
* cell instance $45799 r0 *1 195.96,388.96
X$45799 73 7413 8633 8727 8937 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $45800 r0 *1 197.8,388.96
X$45800 57 7532 9032 7339 7928 8883 8938 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $45803 r0 *1 203.32,388.96
X$45803 73 8879 73 57 8848 57 sky130_fd_sc_hd__buf_4
* cell instance $45808 r0 *1 206.54,388.96
X$45808 73 8882 7413 8883 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45816 r0 *1 224.48,388.96
X$45816 73 8300 8943 8884 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45819 r0 *1 227.24,388.96
X$45819 73 8884 73 57 7847 57 sky130_fd_sc_hd__buf_4
* cell instance $45831 r0 *1 240.58,388.96
X$45831 73 8794 8883 8633 73 8885 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45833 r0 *1 242.88,388.96
X$45833 73 7339 7931 8634 7413 8795 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $45843 r0 *1 261.74,388.96
X$45843 73 8544 8943 8886 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45844 r0 *1 263.12,388.96
X$45844 73 7413 8886 8945 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45850 r0 *1 277.84,388.96
X$45850 57 8847 8947 8709 8888 9211 73 73 57 sky130_fd_sc_hd__a211oi_2
* cell instance $45857 r0 *1 290.72,388.96
X$45857 73 7449 7413 8521 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45878 r0 *1 339.02,388.96
X$45878 73 8850 73 57 8940 57 sky130_fd_sc_hd__buf_4
* cell instance $45884 r0 *1 344.08,388.96
X$45884 73 8940 8892 8893 73 8939 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45885 r0 *1 345.92,388.96
X$45885 73 7938 8849 8892 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $45894 r0 *1 365.7,388.96
X$45894 57 7905 8368 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $45904 r0 *1 391.92,388.96
X$45904 73 8647 8645 8936 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $45911 r0 *1 399.74,388.96
X$45911 73 8804 73 57 8935 57 sky130_fd_sc_hd__buf_4
* cell instance $45915 r0 *1 404.34,388.96
X$45915 57 8895 8934 8933 8253 8932 8931 73 73 57 sky130_fd_sc_hd__o2111a_1
* cell instance $45916 r0 *1 408.48,388.96
X$45916 73 8602 8896 8931 73 8933 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $45943 r0 *1 460.46,388.96
X$45943 73 8741 8926 8358 57 73 8810 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45944 r0 *1 462.3,388.96
X$45944 73 9269 73 57 8927 57 sky130_fd_sc_hd__buf_4
* cell instance $45948 r0 *1 476.1,388.96
X$45948 73 8358 8923 8809 57 73 8812 57 sky130_fd_sc_hd__a21oi_1
* cell instance $45972 r0 *1 523.48,388.96
X$45972 57 8919 8920 8898 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $45975 r0 *1 530.84,388.96
X$45975 73 8829 8898 73 8899 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $45980 r0 *1 534.52,388.96
X$45980 73 8491 7031 73 8909 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $45985 r0 *1 541.42,388.96
X$45985 73 2342 8899 8901 7654 8917 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $45987 r0 *1 545.1,388.96
X$45987 73 8900 7654 2235 8899 73 8916 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $45988 r0 *1 548.32,388.96
X$45988 73 2342 8902 8900 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $45989 r0 *1 550.62,388.96
X$45989 73 2342 8902 8901 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $46002 r0 *1 577.76,388.96
X$46002 57 8823 6482 8914 8913 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $46008 r0 *1 587.88,388.96
X$46008 73 8913 73 57 5139 57 sky130_fd_sc_hd__buf_4
* cell instance $46031 r0 *1 634.34,388.96
X$46031 57 8908 8570 8909 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46035 r0 *1 641.7,388.96
X$46035 57 8104 8570 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $46039 r0 *1 654.12,388.96
X$46039 73 8904 57 73 8903 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46046 m0 *1 12.42,394.4
X$46046 57 8912 8384 8907 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46049 m0 *1 22.08,394.4
X$46049 73 9069 73 57 8281 57 sky130_fd_sc_hd__buf_4
* cell instance $46050 m0 *1 24.84,394.4
X$46050 73 8915 73 57 8755 57 sky130_fd_sc_hd__buf_4
* cell instance $46066 m0 *1 62.1,394.4
X$46066 73 8868 8990 8865 8760 8951 73 8915 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $46069 m0 *1 70.84,394.4
X$46069 73 8200 8866 8865 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46072 m0 *1 79.58,394.4
X$46072 73 7758 7756 7954 73 8869 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46077 m0 *1 89.7,394.4
X$46077 73 8952 8869 8178 8871 57 73 8866 57 sky130_fd_sc_hd__a31oi_1
* cell instance $46078 m0 *1 92,394.4
X$46078 73 7834 8994 8762 73 8952 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46083 m0 *1 102.58,394.4
X$46083 73 7886 73 57 8997 57 sky130_fd_sc_hd__buf_4
* cell instance $46090 m0 *1 119.14,394.4
X$46090 57 8871 8999 8475 8178 9092 8922 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $46093 m0 *1 127.88,394.4
X$46093 73 8534 8953 7834 73 8924 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46095 m0 *1 133.4,394.4
X$46095 73 8954 73 57 8953 57 sky130_fd_sc_hd__buf_4
* cell instance $46096 m0 *1 136.16,394.4
X$46096 73 8201 8063 8954 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46097 m0 *1 137.54,394.4
X$46097 73 8954 8201 7801 57 73 8876 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46100 m0 *1 140.76,394.4
X$46100 73 7886 8876 8041 73 8878 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46103 m0 *1 149.96,394.4
X$46103 73 9005 8771 8475 8603 57 73 8930 57 sky130_fd_sc_hd__a31oi_1
* cell instance $46113 m0 *1 176.18,394.4
X$46113 57 8845 7409 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $46114 m0 *1 183.54,394.4
X$46114 73 8955 73 57 8844 57 sky130_fd_sc_hd__inv_1
* cell instance $46115 m0 *1 184.92,394.4
X$46115 57 8880 7849 8955 8845 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $46121 m0 *1 196.42,394.4
X$46121 73 8879 73 57 7532 57 sky130_fd_sc_hd__buf_4
* cell instance $46122 m0 *1 199.18,394.4
X$46122 73 8844 73 57 8548 57 sky130_fd_sc_hd__buf_4
* cell instance $46134 m0 *1 231.84,394.4
X$46134 73 7409 8548 8943 8957 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $46136 m0 *1 234.14,394.4
X$46136 73 8957 73 57 8637 57 sky130_fd_sc_hd__buf_4
* cell instance $46137 m0 *1 236.9,394.4
X$46137 57 8879 7931 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $46145 m0 *1 256.22,394.4
X$46145 73 9464 8958 7685 8797 73 8269 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $46149 m0 *1 262.66,394.4
X$46149 73 7685 8891 8945 57 73 8944 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46160 m0 *1 291.64,394.4
X$46160 73 8889 73 57 9015 57 sky130_fd_sc_hd__buf_4
* cell instance $46163 m0 *1 295.78,394.4
X$46163 73 7849 7915 8963 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46164 m0 *1 297.16,394.4
X$46164 73 7995 8962 8963 8889 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $46165 m0 *1 299,394.4
X$46165 73 7938 7931 7766 57 73 8890 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46170 m0 *1 306.36,394.4
X$46170 73 8891 8890 8887 8518 7938 9214 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $46175 m0 *1 319.7,394.4
X$46175 73 7339 7541 8891 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46176 m0 *1 321.08,394.4
X$46176 73 7541 8452 7413 73 9014 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46179 m0 *1 324.3,394.4
X$46179 73 8887 7847 7987 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46182 m0 *1 327.98,394.4
X$46182 73 8891 7843 8710 9212 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $46187 m0 *1 336.72,394.4
X$46187 73 8966 7685 8893 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46191 m0 *1 347.3,394.4
X$46191 73 8452 7544 7938 73 8894 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46192 m0 *1 349.14,394.4
X$46192 73 9049 8894 8893 8460 57 73 8194 57 sky130_fd_sc_hd__a31oi_1
* cell instance $46203 m0 *1 373.98,394.4
X$46203 57 6718 8368 9011 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46204 m0 *1 381.34,394.4
X$46204 73 9010 73 57 8074 57 sky130_fd_sc_hd__buf_4
* cell instance $46210 m0 *1 396.52,394.4
X$46210 73 9009 73 57 9007 57 sky130_fd_sc_hd__buf_4
* cell instance $46212 m0 *1 399.74,394.4
X$46212 57 8555 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $46213 m0 *1 410.78,394.4
X$46213 73 8968 8969 8970 8739 73 8932 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $46248 m0 *1 501.4,394.4
X$46248 73 8974 73 57 8815 57 sky130_fd_sc_hd__buf_4
* cell instance $46250 m0 *1 507.84,394.4
X$46250 73 8993 7667 73 8820 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $46261 m0 *1 537.28,394.4
X$46261 57 6998 8747 8976 8991 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $46269 m0 *1 559.82,394.4
X$46269 73 8978 57 73 8824 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46274 m0 *1 576.38,394.4
X$46274 57 8989 8823 8985 6998 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $46279 m0 *1 583.28,394.4
X$46279 73 6482 5139 73 8988 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $46280 m0 *1 586.5,394.4
X$46280 57 8822 8988 8987 6998 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $46288 m0 *1 609.96,394.4
X$46288 57 6998 8902 8668 8981 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $46290 m0 *1 624.68,394.4
X$46290 73 8984 57 73 8981 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46299 m0 *1 643.54,394.4
X$46299 57 8983 8570 8821 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46311 r0 *1 16.56,394.4
X$46311 57 9158 8384 8910 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46317 r0 *1 39.1,394.4
X$46317 73 8986 8622 8949 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46320 r0 *1 41.86,394.4
X$46320 73 8282 9074 8949 9076 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $46325 r0 *1 46.92,394.4
X$46325 73 8716 7647 8950 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46326 r0 *1 48.3,394.4
X$46326 73 8950 73 57 9085 57 sky130_fd_sc_hd__buf_4
* cell instance $46331 r0 *1 62.56,394.4
X$46331 73 7803 73 57 9026 57 sky130_fd_sc_hd__buf_4
* cell instance $46343 r0 *1 90.62,394.4
X$46343 73 8027 8434 9085 73 8994 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46351 r0 *1 104.88,394.4
X$46351 73 8996 8998 8953 57 73 9090 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46356 r0 *1 118.22,394.4
X$46356 73 8475 8467 8122 57 73 9092 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46364 r0 *1 131.56,394.4
X$46364 73 8200 73 57 9027 57 sky130_fd_sc_hd__buf_4
* cell instance $46365 r0 *1 134.32,394.4
X$46365 73 7800 8953 9094 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46369 r0 *1 141.68,394.4
X$46369 73 8876 73 57 9100 57 sky130_fd_sc_hd__buf_4
* cell instance $46371 r0 *1 146.28,394.4
X$46371 73 7834 8063 8100 9102 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $46384 r0 *1 177.56,394.4
X$46384 57 8725 8879 8777 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $46390 r0 *1 193.2,394.4
X$46390 73 7409 8541 8476 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46394 r0 *1 199.64,394.4
X$46394 73 8844 73 57 9034 57 sky130_fd_sc_hd__buf_4
* cell instance $46396 r0 *1 202.86,394.4
X$46396 73 7413 7532 9035 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46404 r0 *1 211.14,394.4
X$46404 57 8613 9113 9112 9012 9281 8210 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $46405 r0 *1 214.36,394.4
X$46405 73 8210 8956 9112 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46407 r0 *1 219.42,394.4
X$46407 57 7580 8210 9114 9561 8958 8524 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $46410 r0 *1 224.48,394.4
X$46410 73 8210 7622 8958 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46414 r0 *1 230.92,394.4
X$46414 73 9013 73 57 8031 57 sky130_fd_sc_hd__buf_4
* cell instance $46421 r0 *1 241.04,394.4
X$46421 57 9015 8959 7929 9116 9115 8958 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $46424 r0 *1 251.62,394.4
X$46424 73 7846 73 57 9040 57 sky130_fd_sc_hd__buf_4
* cell instance $46432 r0 *1 265.88,394.4
X$46432 57 8956 8966 8944 9642 9016 8946 73 73 57 sky130_fd_sc_hd__o311ai_1
* cell instance $46436 r0 *1 274.16,394.4
X$46436 73 8960 8633 7938 7766 73 9120 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $46438 r0 *1 279.22,394.4
X$46438 73 8959 8010 7685 9123 57 8947 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $46441 r0 *1 283.82,394.4
X$46441 73 8943 8521 8960 8961 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $46442 r0 *1 285.66,394.4
X$46442 73 8961 9041 8010 73 9018 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46450 r0 *1 297.62,394.4
X$46450 73 7712 8521 8518 8965 73 8964 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $46451 r0 *1 300.84,394.4
X$46451 73 8398 8964 7907 73 9017 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46452 r0 *1 302.68,394.4
X$46452 73 9017 8398 8854 57 73 9123 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46455 r0 *1 306.82,394.4
X$46455 57 7413 9289 8795 8637 7939 7585 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $46463 r0 *1 322,394.4
X$46463 73 9014 7265 8852 9044 57 73 9128 57 sky130_fd_sc_hd__a31oi_1
* cell instance $46472 r0 *1 345.46,394.4
X$46472 73 7853 7843 9121 57 73 8967 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46474 r0 *1 347.76,394.4
X$46474 73 8939 8967 8373 8010 57 73 9122 57 sky130_fd_sc_hd__a31oi_1
* cell instance $46483 r0 *1 370.76,394.4
X$46483 73 9920 7361 73 9011 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $46494 r0 *1 397.9,394.4
X$46494 73 8483 8735 9008 57 73 8896 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46495 r0 *1 399.74,394.4
X$46495 73 9008 73 57 9052 57 sky130_fd_sc_hd__buf_4
* cell instance $46498 r0 *1 403.42,394.4
X$46498 73 9051 73 57 8737 57 sky130_fd_sc_hd__buf_4
* cell instance $46501 r0 *1 408.48,394.4
X$46501 73 8601 73 57 8931 57 sky130_fd_sc_hd__buf_4
* cell instance $46502 r0 *1 411.24,394.4
X$46502 73 8739 8969 9006 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46504 r0 *1 413.54,394.4
X$46504 73 9050 8805 8969 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46508 r0 *1 421.36,394.4
X$46508 73 9108 8737 9109 73 8260 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46511 r0 *1 426.88,394.4
X$46511 57 9004 9107 9235 8895 9106 8561 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $46516 r0 *1 439.76,394.4
X$46516 57 9004 8971 8253 9002 9003 8840 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $46521 r0 *1 451.26,394.4
X$46521 73 8253 9105 8929 9106 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $46527 r0 *1 460.46,394.4
X$46527 73 8810 73 57 9001 57 sky130_fd_sc_hd__buf_4
* cell instance $46530 r0 *1 465.98,394.4
X$46530 73 8253 9000 9399 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46531 r0 *1 467.36,394.4
X$46531 73 8897 9101 8441 8740 8972 9000 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $46539 r0 *1 487.6,394.4
X$46539 73 8648 8766 9095 8971 73 57 57 sky130_fd_sc_hd__or3b_1
* cell instance $46544 r0 *1 497.72,394.4
X$46544 73 8973 9176 8974 57 73 8766 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46546 r0 *1 501.4,394.4
X$46546 73 8968 8975 8974 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46551 r0 *1 506,394.4
X$46551 73 8735 8973 8740 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46557 r0 *1 515.66,394.4
X$46557 57 8919 9154 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $46563 r0 *1 533.14,394.4
X$46563 57 8977 8976 8992 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46567 r0 *1 543.26,394.4
X$46567 73 8339 73 57 9055 57 sky130_fd_sc_hd__buf_4
* cell instance $46568 r0 *1 546.02,394.4
X$46568 57 9067 9086 8825 2235 73 73 57 sky130_fd_sc_hd__mux2i_4
* cell instance $46569 r0 *1 554.3,394.4
X$46569 73 8977 57 73 9077 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46574 r0 *1 561.2,394.4
X$46574 73 8020 7771 73 9060 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $46579 r0 *1 570.86,394.4
X$46579 73 8914 2342 9084 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46582 r0 *1 575,394.4
X$46582 57 8914 8233 8989 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46583 r0 *1 582.36,394.4
X$46583 73 8230 8914 73 8980 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $46587 r0 *1 587.42,394.4
X$46587 73 8979 57 73 8987 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46588 r0 *1 591.1,394.4
X$46588 73 9079 4800 73 9160 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $46603 r0 *1 623.76,394.4
X$46603 57 8104 8668 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $46610 r0 *1 643.54,394.4
X$46610 73 8908 57 73 9064 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46615 r0 *1 655.5,394.4
X$46615 73 8983 57 73 10723 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46667 m0 *1 4.14,399.84
X$46667 73 9129 57 73 9066 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46668 m0 *1 7.82,399.84
X$46668 57 7704 9070 8384 9066 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $46670 m0 *1 22.54,399.84
X$46670 73 9072 8912 73 9069 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $46679 m0 *1 43.7,399.84
X$46679 57 8787 9075 7876 9073 9021 7954 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $46681 m0 *1 47.38,399.84
X$46681 73 8431 73 57 8716 57 sky130_fd_sc_hd__buf_4
* cell instance $46684 m0 *1 51.52,399.84
X$46684 73 9022 7921 8864 73 9021 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $46692 m0 *1 61.18,399.84
X$46692 73 9259 8671 7763 9082 57 8951 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $46695 m0 *1 70.84,399.84
X$46695 73 8921 8390 9022 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46702 m0 *1 86.02,399.84
X$46702 57 9024 7763 9023 8675 9342 73 73 57 sky130_fd_sc_hd__nor4_2
* cell instance $46707 m0 *1 100.28,399.84
X$46707 73 9026 9025 9023 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46711 m0 *1 104.88,399.84
X$46711 73 8873 9090 8839 9089 73 9025 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $46714 m0 *1 109.94,399.84
X$46714 73 8921 73 57 9097 57 sky130_fd_sc_hd__buf_4
* cell instance $46727 m0 *1 141.22,399.84
X$46727 73 9097 8287 9100 8178 7758 9028 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $46729 m0 *1 146.28,399.84
X$46729 73 9102 7834 8287 57 73 9271 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46732 m0 *1 149.5,399.84
X$46732 73 9029 73 57 8995 57 sky130_fd_sc_hd__buf_4
* cell instance $46733 m0 *1 152.26,399.84
X$46733 73 9103 9027 8930 9193 9029 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $46736 m0 *1 155.94,399.84
X$46736 57 6338 9136 8845 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $46737 m0 *1 161.92,399.84
X$46737 57 7804 9195 8955 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $46743 m0 *1 175.26,399.84
X$46743 73 7154 9198 9197 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46748 m0 *1 188.14,399.84
X$46748 73 8955 73 57 9030 57 sky130_fd_sc_hd__buf_4
* cell instance $46752 m0 *1 195.96,399.84
X$46752 73 8882 8726 9201 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46753 m0 *1 197.34,399.84
X$46753 73 9032 9033 9110 7339 9034 9031 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $46754 m0 *1 200.56,399.84
X$46754 73 9030 8726 9036 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46757 m0 *1 203.32,399.84
X$46757 73 7533 9035 9036 73 9115 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46760 m0 *1 210.68,399.84
X$46760 57 9013 9037 9113 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46767 m0 *1 229.08,399.84
X$46767 73 8707 7622 7938 9204 57 73 9114 57 sky130_fd_sc_hd__a31oi_1
* cell instance $46772 m0 *1 240.12,399.84
X$46772 73 9039 8633 8794 57 73 9038 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46773 m0 *1 241.96,399.84
X$46773 73 7409 9038 9116 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $46783 m0 *1 268.18,399.84
X$46783 73 7413 8518 9040 9119 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $46786 m0 *1 272.78,399.84
X$46786 73 7409 9034 7938 8960 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $46796 m0 *1 301.3,399.84
X$46796 73 9042 73 57 7500 57 sky130_fd_sc_hd__buf_4
* cell instance $46797 m0 *1 304.06,399.84
X$46797 73 7939 7938 9040 57 73 9126 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46803 m0 *1 313.26,399.84
X$46803 73 9043 73 57 9127 57 sky130_fd_sc_hd__buf_4
* cell instance $46804 m0 *1 316.02,399.84
X$46804 57 7938 9043 8966 8637 7939 8852 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $46807 m0 *1 320.62,399.84
X$46807 73 9042 73 57 9044 57 sky130_fd_sc_hd__buf_4
* cell instance $46809 m0 *1 324.3,399.84
X$46809 73 7413 8518 9040 57 73 9045 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46815 m0 *1 335.34,399.84
X$46815 73 9045 9046 7585 73 9209 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46816 m0 *1 337.18,399.84
X$46816 73 7938 8637 8301 9046 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $46817 m0 *1 339.02,399.84
X$46817 73 9044 8637 7938 8056 57 9047 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $46818 m0 *1 341.32,399.84
X$46818 73 9048 9047 8708 9125 57 9124 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $46819 m0 *1 343.62,399.84
X$46819 57 9125 7853 8301 9044 8070 7413 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $46821 m0 *1 347.76,399.84
X$46821 73 7413 8301 9049 73 9121 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46830 m0 *1 369.38,399.84
X$46830 57 8152 8368 9118 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46839 m0 *1 398.36,399.84
X$46839 73 9050 9117 9008 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46840 m0 *1 399.74,399.84
X$46840 57 7905 8555 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $46841 m0 *1 408.94,399.84
X$46841 73 8644 9006 9052 8968 8647 9111 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $46847 m0 *1 422.28,399.84
X$46847 73 9053 8737 9101 57 73 9109 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46861 m0 *1 460,399.84
X$46861 73 8741 9054 9104 73 9002 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $46871 m0 *1 484.84,399.84
X$46871 73 9056 8358 9098 57 73 9099 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46873 m0 *1 487.14,399.84
X$46873 73 9096 8973 9093 9095 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $46875 m0 *1 491.74,399.84
X$46875 73 9093 73 57 8809 57 sky130_fd_sc_hd__buf_4
* cell instance $46881 m0 *1 502.32,399.84
X$46881 73 9091 8562 8973 57 73 9054 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46893 m0 *1 533.14,399.84
X$46893 57 9088 9057 7031 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $46894 m0 *1 539.12,399.84
X$46894 57 9057 9087 8828 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $46897 m0 *1 544.18,399.84
X$46897 57 7945 9086 9405 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $46904 m0 *1 568.1,399.84
X$46904 57 9058 9059 9084 9083 73 73 57 sky130_fd_sc_hd__mux2_4
* cell instance $46905 m0 *1 573.62,399.84
X$46905 73 2342 8914 9059 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $46906 m0 *1 575.92,399.84
X$46906 57 4650 9164 9081 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $46910 m0 *1 586.5,399.84
X$46910 57 9079 9061 8083 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $46911 m0 *1 590.18,399.84
X$46911 57 9080 9079 4800 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $46915 m0 *1 602.6,399.84
X$46915 73 9078 57 73 8985 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46924 m0 *1 621.92,399.84
X$46924 73 9062 57 73 9071 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46926 m0 *1 626.06,399.84
X$46926 57 6998 9061 8668 9071 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $46928 m0 *1 637.56,399.84
X$46928 57 6998 9067 8570 9063 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $46929 m0 *1 648.6,399.84
X$46929 57 9068 8570 9060 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $46931 m0 *1 656.88,399.84
X$46931 73 9065 57 73 7724 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46934 r0 *1 5.06,399.84
X$46934 73 8862 57 73 9157 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46943 r0 *1 23.46,399.84
X$46943 73 9158 73 57 9132 57 sky130_fd_sc_hd__buf_4
* cell instance $46944 r0 *1 26.22,399.84
X$46944 73 8912 73 57 9130 57 sky130_fd_sc_hd__buf_4
* cell instance $46949 r0 *1 38.64,399.84
X$46949 73 8995 9165 8665 57 73 10914 57 sky130_fd_sc_hd__a21oi_1
* cell instance $46950 r0 *1 40.48,399.84
X$46950 73 9075 73 57 9167 57 sky130_fd_sc_hd__buf_4
* cell instance $46961 r0 *1 65.32,399.84
X$46961 57 9172 9292 8121 8787 9022 9173 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $46962 r0 *1 68.54,399.84
X$46962 73 9175 9179 9174 9082 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $46968 r0 *1 73.14,399.84
X$46968 73 8864 7756 8998 7954 9177 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $46973 r0 *1 84.64,399.84
X$46973 73 8787 73 57 9175 57 sky130_fd_sc_hd__buf_4
* cell instance $46975 r0 *1 91.08,399.84
X$46975 73 9133 8998 7647 8095 57 73 9179 57 sky130_fd_sc_hd__a31oi_1
* cell instance $46981 r0 *1 103.04,399.84
X$46981 73 8003 7756 8998 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46983 r0 *1 104.88,399.84
X$46983 73 8434 73 57 9183 57 sky130_fd_sc_hd__buf_4
* cell instance $46986 r0 *1 115,399.84
X$46986 73 9135 73 57 9133 57 sky130_fd_sc_hd__buf_4
* cell instance $46995 r0 *1 132.48,399.84
X$46995 73 7834 8875 9135 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $46996 r0 *1 134.78,399.84
X$46996 73 7483 9135 9187 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $46997 r0 *1 136.16,399.84
X$46997 73 9187 8203 7801 57 73 9186 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47002 r0 *1 148.12,399.84
X$47002 73 9190 9191 9192 9189 57 73 9103 57 sky130_fd_sc_hd__a31oi_1
* cell instance $47006 r0 *1 152.72,399.84
X$47006 73 8468 7763 9193 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47013 r0 *1 165.14,399.84
X$47013 57 9195 9070 9661 9196 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $47016 r0 *1 170.2,399.84
X$47016 73 7226 73 57 9196 57 sky130_fd_sc_hd__buf_4
* cell instance $47018 r0 *1 173.42,399.84
X$47018 73 2627 9196 9137 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47020 r0 *1 175.72,399.84
X$47020 73 9197 7154 9137 57 73 9199 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47028 r0 *1 191.36,399.84
X$47028 73 7413 8476 9200 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47031 r0 *1 196.88,399.84
X$47031 73 9201 9035 8727 8476 57 73 9033 57 sky130_fd_sc_hd__a31oi_1
* cell instance $47043 r0 *1 224.94,399.84
X$47043 57 15642 9203 7938 7339 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $47044 r0 *1 229.54,399.84
X$47044 73 9203 7622 8879 73 9204 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $47054 r0 *1 249.78,399.84
X$47054 73 9030 8633 7622 9138 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $47063 r0 *1 267.72,399.84
X$47063 73 7364 9119 7843 7769 57 73 9016 57 sky130_fd_sc_hd__a31oi_1
* cell instance $47065 r0 *1 270.48,399.84
X$47065 73 9034 7938 8633 7364 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $47070 r0 *1 281.98,399.84
X$47070 73 9140 9127 7769 9287 57 9211 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $47071 r0 *1 284.74,399.84
X$47071 73 7585 9213 9041 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47080 r0 *1 301.76,399.84
X$47080 73 7907 7685 9142 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47083 r0 *1 310.5,399.84
X$47083 73 9214 7843 8460 9361 57 9286 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $47091 r0 *1 327.52,399.84
X$47091 73 9142 8941 9143 9212 9207 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $47097 r0 *1 340.86,399.84
X$47097 73 9208 9209 9048 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47100 r0 *1 344.08,399.84
X$47100 73 9122 9207 9124 9206 73 9118 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $47107 r0 *1 361.56,399.84
X$47107 73 8982 57 73 9205 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47120 r0 *1 392.84,399.84
X$47120 73 8449 73 57 9146 57 sky130_fd_sc_hd__buf_4
* cell instance $47122 r0 *1 395.6,399.84
X$47122 73 9108 9146 8644 73 9202 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $47123 r0 *1 397.44,399.84
X$47123 73 8557 73 57 9117 57 sky130_fd_sc_hd__buf_4
* cell instance $47125 r0 *1 401.12,399.84
X$47125 73 8483 9146 9147 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47128 r0 *1 403.88,399.84
X$47128 73 9148 8931 9147 9194 8483 73 9149 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $47130 r0 *1 407.56,399.84
X$47130 73 9051 8601 8770 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47132 r0 *1 409.4,399.84
X$47132 73 9149 9111 8409 9148 9117 73 9188 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $47150 r0 *1 454.94,399.84
X$47150 73 8601 73 57 9150 57 sky130_fd_sc_hd__buf_4
* cell instance $47153 r0 *1 460,399.84
X$47153 73 9001 8741 9151 57 73 9270 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47159 r0 *1 474.26,399.84
X$47159 73 9152 73 57 9153 57 sky130_fd_sc_hd__buf_4
* cell instance $47162 r0 *1 477.94,399.84
X$47162 73 9152 9182 9180 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47168 r0 *1 489.44,399.84
X$47168 73 8743 9150 9093 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47169 r0 *1 490.82,399.84
X$47169 73 8562 9150 9096 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47172 r0 *1 494.5,399.84
X$47172 73 9096 73 57 9178 57 sky130_fd_sc_hd__buf_4
* cell instance $47186 r0 *1 529.46,399.84
X$47186 57 6998 9087 8976 9171 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $47198 r0 *1 564.42,399.84
X$47198 57 9170 9169 8578 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $47202 r0 *1 569.94,399.84
X$47202 73 8336 7771 73 9166 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $47206 r0 *1 576.38,399.84
X$47206 57 9163 9164 4650 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $47207 r0 *1 582.36,399.84
X$47207 57 9081 9161 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $47212 r0 *1 592.94,399.84
X$47212 73 9160 73 57 9244 57 sky130_fd_sc_hd__buf_4
* cell instance $47225 r0 *1 623.76,399.84
X$47225 57 8668 15681 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $47237 r0 *1 656.88,399.84
X$47237 73 9068 57 73 10224 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47239 m0 *1 3.22,405.28
X$47239 73 9215 57 73 9253 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47240 m0 *1 6.9,405.28
X$47240 57 7704 9131 8384 9253 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $47243 m0 *1 17.94,405.28
X$47243 57 4567 9216 9132 9218 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $47245 m0 *1 27.14,405.28
X$47245 73 8337 4428 9131 57 73 9220 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47251 m0 *1 38.18,405.28
X$47251 73 9256 9076 7763 9167 57 9165 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $47265 m0 *1 66.7,405.28
X$47265 73 8997 7921 7791 9222 9173 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $47280 m0 *1 97.06,405.28
X$47280 73 8173 9134 9262 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47281 m0 *1 98.44,405.28
X$47281 73 7647 9222 8998 57 73 9134 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47284 m0 *1 104.42,405.28
X$47284 73 8003 8388 9223 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47286 m0 *1 106.26,405.28
X$47286 73 9223 9224 8535 8203 8201 9089 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $47298 m0 *1 131.56,405.28
X$47298 57 9185 9189 9268 9186 8173 8100 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $47299 m0 *1 134.78,405.28
X$47299 73 9094 7800 9225 57 73 9185 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47306 m0 *1 147.66,405.28
X$47306 73 9225 8100 8875 8475 57 73 9192 57 sky130_fd_sc_hd__a31oi_1
* cell instance $47320 m0 *1 173.42,405.28
X$47320 73 2627 9303 9198 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47343 m0 *1 223.56,405.28
X$47343 73 8778 8943 7847 73 9282 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $47350 m0 *1 237.36,405.28
X$47350 73 8541 73 57 7907 57 sky130_fd_sc_hd__buf_4
* cell instance $47351 m0 *1 240.12,405.28
X$47351 73 8541 8479 9227 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47352 m0 *1 241.5,405.28
X$47352 73 9227 73 57 7585 57 sky130_fd_sc_hd__buf_4
* cell instance $47354 m0 *1 247.94,405.28
X$47354 73 7339 7622 9138 7938 8396 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $47356 m0 *1 251.16,405.28
X$47356 73 9138 7413 8541 57 73 9139 57 sky130_fd_sc_hd__a21boi_0
* cell instance $47358 m0 *1 254.38,405.28
X$47358 73 9139 73 57 9362 57 sky130_fd_sc_hd__buf_4
* cell instance $47366 m0 *1 270.94,405.28
X$47366 73 7853 8479 9210 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47372 m0 *1 282.44,405.28
X$47372 73 7853 9288 8943 57 73 9213 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47379 m0 *1 291.18,405.28
X$47379 73 8398 8479 9645 9140 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $47383 m0 *1 298.08,405.28
X$47383 73 9356 9364 9141 8545 57 9228 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $47386 m0 *1 302.22,405.28
X$47386 57 9126 9141 9142 9362 7685 7339 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $47389 m0 *1 306.36,405.28
X$47389 57 9142 8119 9286 9229 9230 9289 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $47397 m0 *1 324.76,405.28
X$47397 73 9285 9284 9128 7585 8398 73 9143 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $47404 m0 *1 337.18,405.28
X$47404 73 9283 9144 7843 73 9208 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $47405 m0 *1 339.02,405.28
X$47405 73 7413 8070 8056 9144 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $47410 m0 *1 343.16,405.28
X$47410 73 7853 8010 8460 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47411 m0 *1 344.54,405.28
X$47411 73 7853 9228 8010 73 9206 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $47427 m0 *1 385.94,405.28
X$47427 73 9145 9231 9147 9232 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $47431 m0 *1 391.46,405.28
X$47431 73 9202 8936 9231 9232 57 73 9279 57 sky130_fd_sc_hd__a31oi_1
* cell instance $47432 m0 *1 393.76,405.28
X$47432 73 9051 73 57 9231 57 sky130_fd_sc_hd__buf_4
* cell instance $47437 m0 *1 399.28,405.28
X$47437 73 8737 8735 9117 57 73 9194 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47438 m0 *1 401.12,405.28
X$47438 73 8449 9400 9145 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47439 m0 *1 402.5,405.28
X$47439 73 9145 73 57 9234 57 sky130_fd_sc_hd__buf_4
* cell instance $47441 m0 *1 407.1,405.28
X$47441 73 8931 9390 8846 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47446 m0 *1 416.76,405.28
X$47446 73 9394 73 57 9148 57 sky130_fd_sc_hd__buf_4
* cell instance $47453 m0 *1 432.4,405.28
X$47453 57 8561 9275 8253 9184 8841 9274 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $47454 m0 *1 435.62,405.28
X$47454 73 9273 8601 9152 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47467 m0 *1 460,405.28
X$47467 73 9239 9181 9270 9184 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $47470 m0 *1 464.14,405.28
X$47470 73 9051 73 57 8973 57 sky130_fd_sc_hd__buf_4
* cell instance $47478 m0 *1 477.48,405.28
X$47478 73 9182 73 57 8923 57 sky130_fd_sc_hd__buf_4
* cell instance $47482 m0 *1 483.46,405.28
X$47482 73 9239 73 57 8836 57 sky130_fd_sc_hd__buf_4
* cell instance $47483 m0 *1 486.22,405.28
X$47483 73 9180 73 57 9098 57 sky130_fd_sc_hd__buf_4
* cell instance $47484 m0 *1 488.98,405.28
X$47484 73 8358 9098 9446 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47508 m0 *1 534.06,405.28
X$47508 73 9261 57 73 9156 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47509 m0 *1 537.74,405.28
X$47509 57 8104 8976 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $47518 m0 *1 563.96,405.28
X$47518 73 9170 8019 9243 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $47520 m0 *1 567.64,405.28
X$47520 73 9170 8019 73 9168 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $47521 m0 *1 570.86,405.28
X$47521 73 8336 7771 9257 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $47524 m0 *1 578.22,405.28
X$47524 57 9164 9245 9155 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $47533 m0 *1 597.54,405.28
X$47533 73 9080 9161 9162 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47535 m0 *1 599.38,405.28
X$47535 57 9248 8668 9247 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $47536 m0 *1 606.74,405.28
X$47536 73 9248 73 57 4813 57 sky130_fd_sc_hd__buf_4
* cell instance $47545 m0 *1 620.54,405.28
X$47545 57 6998 8756 8668 9250 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $47546 m0 *1 631.58,405.28
X$47546 73 9254 57 73 9250 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47553 m0 *1 643.08,405.28
X$47553 73 9251 57 73 9063 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47561 r0 *1 5.06,405.28
X$47561 73 9019 57 73 9328 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47562 r0 *1 8.74,405.28
X$47562 73 9255 73 57 8330 57 sky130_fd_sc_hd__buf_4
* cell instance $47564 r0 *1 11.96,405.28
X$47564 57 9329 9217 9157 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $47568 r0 *1 20.24,405.28
X$47568 73 9216 9219 73 9217 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $47570 r0 *1 23.92,405.28
X$47570 73 9218 73 57 9219 57 sky130_fd_sc_hd__buf_4
* cell instance $47572 r0 *1 27.6,405.28
X$47572 73 9220 73 57 9331 57 sky130_fd_sc_hd__buf_4
* cell instance $47582 r0 *1 46.92,405.28
X$47582 73 8716 8001 8986 9429 9221 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $47585 r0 *1 51.06,405.28
X$47585 73 9258 9221 9259 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47598 r0 *1 84.64,405.28
X$47598 57 9265 9342 9264 9341 9262 9175 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $47608 r0 *1 109.48,405.28
X$47608 73 8062 7834 9222 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47621 r0 *1 142.6,405.28
X$47621 73 7800 9301 8875 7483 73 9349 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $47622 r0 *1 145.36,405.28
X$47622 73 9348 9271 9349 7801 7758 9272 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $47636 r0 *1 178.94,405.28
X$47636 73 4764 73 57 9304 57 sky130_fd_sc_hd__buf_4
* cell instance $47639 r0 *1 183.08,405.28
X$47639 57 8541 9353 4764 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $47642 r0 *1 191.36,405.28
X$47642 73 7685 9200 9226 57 73 9280 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47644 r0 *1 194.12,405.28
X$47644 73 8727 8068 8778 8879 57 73 9226 57 sky130_fd_sc_hd__a31oi_1
* cell instance $47647 r0 *1 200.56,405.28
X$47647 73 9280 73 57 9356 57 sky130_fd_sc_hd__buf_4
* cell instance $47652 r0 *1 206.54,405.28
X$47652 73 9031 7685 7769 9360 57 9281 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $47660 r0 *1 226.78,405.28
X$47660 73 9282 7938 8541 8302 57 9559 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $47664 r0 *1 234.14,405.28
X$47664 73 8879 73 57 8943 57 sky130_fd_sc_hd__buf_4
* cell instance $47671 r0 *1 247.94,405.28
X$47671 73 8541 7447 9042 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47683 r0 *1 274.62,405.28
X$47683 73 9120 7908 9210 8966 9587 73 9287 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $47708 r0 *1 333.5,405.28
X$47708 73 7938 9359 8616 9283 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $47720 r0 *1 361.1,405.28
X$47720 57 4950 9354 8368 9205 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $47731 r0 *1 394.22,405.28
X$47731 73 9279 73 57 9312 57 sky130_fd_sc_hd__buf_4
* cell instance $47735 r0 *1 399.74,405.28
X$47735 73 8846 73 57 9351 57 sky130_fd_sc_hd__buf_4
* cell instance $47738 r0 *1 404.8,405.28
X$47738 73 9234 9314 8483 73 8934 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $47741 r0 *1 408.02,405.28
X$47741 57 7976 8555 9233 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $47745 r0 *1 422.74,405.28
X$47745 73 9235 9236 8190 9278 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $47746 r0 *1 424.58,405.28
X$47746 73 9152 73 57 9277 57 sky130_fd_sc_hd__buf_4
* cell instance $47747 r0 *1 427.34,405.28
X$47747 73 9275 73 57 9276 57 sky130_fd_sc_hd__buf_4
* cell instance $47755 r0 *1 444.82,405.28
X$47755 73 8814 73 57 9345 57 sky130_fd_sc_hd__buf_4
* cell instance $47756 r0 *1 447.58,405.28
X$47756 73 9266 9345 9237 9238 9236 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $47760 r0 *1 452.18,405.28
X$47760 73 9239 73 57 9238 57 sky130_fd_sc_hd__buf_4
* cell instance $47767 r0 *1 464.6,405.28
X$47767 73 9269 8741 9344 8805 57 73 9104 57 sky130_fd_sc_hd__a31oi_1
* cell instance $47769 r0 *1 467.36,405.28
X$47769 73 8735 8358 9344 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47776 r0 *1 482.54,405.28
X$47776 73 8150 8805 9239 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47777 r0 *1 483.92,405.28
X$47777 73 8973 9180 9448 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47782 r0 *1 491.74,405.28
X$47782 73 9240 9150 9267 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47785 r0 *1 495.88,405.28
X$47785 73 9241 73 57 9266 57 sky130_fd_sc_hd__buf_4
* cell instance $47787 r0 *1 499.56,405.28
X$47787 73 8687 8968 9242 9319 57 9241 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $47791 r0 *1 506.92,405.28
X$47791 73 8735 8973 9176 57 73 9242 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47800 r0 *1 529.92,405.28
X$47800 57 9261 8976 9263 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $47811 r0 *1 551.54,405.28
X$47811 73 9159 57 73 9260 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47812 r0 *1 555.22,405.28
X$47812 57 6998 9169 8976 9260 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $47816 r0 *1 568.56,405.28
X$47816 73 9243 73 57 9246 57 sky130_fd_sc_hd__buf_4
* cell instance $47819 r0 *1 574.08,405.28
X$47819 73 9243 9244 9340 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47827 r0 *1 594.32,405.28
X$47827 73 9080 9161 9335 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47830 r0 *1 596.62,405.28
X$47830 57 9080 9323 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $47833 r0 *1 608.58,405.28
X$47833 73 9244 9161 9249 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47834 r0 *1 609.96,405.28
X$47834 73 9249 73 57 9332 57 sky130_fd_sc_hd__buf_4
* cell instance $47845 r0 *1 632.96,405.28
X$47845 57 9252 8668 8426 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $47857 m0 *1 4.14,410.72
X$47857 73 9419 57 73 9290 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47862 m0 *1 14.72,410.72
X$47862 57 9218 8384 9329 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $47877 m0 *1 47.84,410.72
X$47877 73 8027 8827 8986 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47888 m0 *1 72.68,410.72
X$47888 73 9222 9337 7647 7797 73 9339 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $47889 m0 *1 75.44,410.72
X$47889 73 7647 8875 7756 57 73 9337 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47894 m0 *1 85.56,410.72
X$47894 73 8475 9294 9341 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47896 m0 *1 87.86,410.72
X$47896 73 9437 7652 8388 57 73 9294 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47905 m0 *1 107.18,410.72
X$47905 73 7925 73 57 9296 57 sky130_fd_sc_hd__buf_4
* cell instance $47910 m0 *1 115,410.72
X$47910 73 8431 7801 9297 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47913 m0 *1 120.98,410.72
X$47913 73 7483 9222 9297 57 73 9540 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47919 m0 *1 126.04,410.72
X$47919 73 7483 7797 9298 73 9544 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $47920 m0 *1 127.88,410.72
X$47920 73 9268 9297 9299 57 73 9298 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47921 m0 *1 129.72,410.72
X$47921 73 8063 9297 9296 9300 73 8537 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $47923 m0 *1 133.86,410.72
X$47923 73 8063 9296 7834 57 73 9299 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47927 m0 *1 138.92,410.72
X$47927 73 7483 8100 9301 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47931 m0 *1 145.36,410.72
X$47931 73 8475 9301 9302 57 73 9348 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47933 m0 *1 148.12,410.72
X$47933 73 8285 7834 9302 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47944 m0 *1 172.96,410.72
X$47944 73 7110 9303 9352 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $47946 m0 *1 176.18,410.72
X$47946 73 9378 6830 9305 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $47950 m0 *1 179.86,410.72
X$47950 57 9304 9353 7928 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $47954 m0 *1 189.06,410.72
X$47954 73 9305 73 57 8010 57 sky130_fd_sc_hd__buf_4
* cell instance $47959 m0 *1 201.48,410.72
X$47959 73 7413 9358 7710 57 73 9558 57 sky130_fd_sc_hd__a21oi_1
* cell instance $47960 m0 *1 203.32,410.72
X$47960 73 7533 8879 9358 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $47966 m0 *1 207.92,410.72
X$47966 57 7928 7622 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $47977 m0 *1 235.52,410.72
X$47977 73 8879 8068 9306 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $47978 m0 *1 238.74,410.72
X$47978 73 9030 9306 8700 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48000 m0 *1 284.74,410.72
X$48000 73 9307 73 57 8187 57 sky130_fd_sc_hd__buf_4
* cell instance $48008 m0 *1 298.08,410.72
X$48008 73 9363 8943 9229 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48009 m0 *1 299.46,410.72
X$48009 73 8965 9468 8943 73 9364 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48015 m0 *1 310.96,410.72
X$48015 73 8962 9042 9308 9361 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $48017 m0 *1 313.26,410.72
X$48017 73 8943 7339 9309 57 73 9308 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48020 m0 *1 315.1,410.72
X$48020 73 8633 9309 7683 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48029 m0 *1 334.42,410.72
X$48029 73 9357 73 57 8056 57 sky130_fd_sc_hd__buf_4
* cell instance $48045 m0 *1 369.38,410.72
X$48045 57 9311 9354 9355 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $48046 m0 *1 373.06,410.72
X$48046 73 9311 7361 73 9461 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $48058 m0 *1 395.6,410.72
X$48058 73 9009 73 57 9313 57 sky130_fd_sc_hd__buf_4
* cell instance $48059 m0 *1 398.36,410.72
X$48059 73 8735 9146 8644 73 9459 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48063 m0 *1 408.48,410.72
X$48063 73 9276 9278 9315 9350 57 9233 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $48065 m0 *1 411.7,410.72
X$48065 73 8312 9188 9569 57 73 9315 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48074 m0 *1 425.96,410.72
X$48074 73 9050 9346 9402 57 73 9347 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48080 m0 *1 441.14,410.72
X$48080 73 8805 9799 9316 57 73 9274 57 sky130_fd_sc_hd__a21o_1
* cell instance $48087 m0 *1 450.34,410.72
X$48087 73 8441 9151 9313 8805 57 73 9316 57 sky130_fd_sc_hd__a31oi_1
* cell instance $48103 m0 *1 494.04,410.72
X$48103 73 8743 9313 9318 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48105 m0 *1 496.34,410.72
X$48105 73 9318 73 57 9319 57 sky130_fd_sc_hd__buf_4
* cell instance $48120 m0 *1 529,410.72
X$48120 73 9444 7723 73 9263 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $48125 m0 *1 537.74,410.72
X$48125 57 8976 15679 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $48135 m0 *1 569.48,410.72
X$48135 73 9168 73 57 9412 57 sky130_fd_sc_hd__buf_4
* cell instance $48138 m0 *1 575,410.72
X$48138 73 8914 2342 9432 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48147 m0 *1 587.42,410.72
X$48147 57 9336 9430 9323 9321 9322 9512 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $48148 m0 *1 590.64,410.72
X$48148 73 9257 73 57 9325 57 sky130_fd_sc_hd__buf_4
* cell instance $48151 m0 *1 598.92,410.72
X$48151 73 9244 9324 9334 9333 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $48170 m0 *1 638.48,410.72
X$48170 57 6998 9245 8570 9330 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $48176 r0 *1 2.3,410.72
X$48176 73 9291 57 73 9615 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48178 r0 *1 6.9,410.72
X$48178 73 7704 8330 9366 73 9420 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48179 r0 *1 8.74,410.72
X$48179 57 9367 9471 9420 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $48189 r0 *1 39.1,410.72
X$48189 73 9338 9368 9256 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48191 r0 *1 41.4,410.72
X$48191 73 7962 7921 9369 73 9368 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48197 r0 *1 48.3,410.72
X$48197 73 7756 8764 9370 9429 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $48199 r0 *1 50.6,410.72
X$48199 73 8475 8827 9369 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48200 r0 *1 51.98,410.72
X$48200 73 7792 73 57 9370 57 sky130_fd_sc_hd__buf_4
* cell instance $48204 r0 *1 65.78,410.72
X$48204 73 9293 7756 9292 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48207 r0 *1 68.54,410.72
X$48207 73 8827 73 57 9265 57 sky130_fd_sc_hd__buf_4
* cell instance $48213 r0 *1 77.74,410.72
X$48213 73 9434 8535 8001 8467 7800 9371 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $48216 r0 *1 83.26,410.72
X$48216 73 9435 73 57 9338 57 sky130_fd_sc_hd__buf_4
* cell instance $48217 r0 *1 86.02,410.72
X$48217 73 7756 9295 8062 73 9434 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48218 r0 *1 87.86,410.72
X$48218 73 8535 8062 8001 9293 9437 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $48221 r0 *1 91.54,410.72
X$48221 73 8003 7483 9295 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48228 r0 *1 101.2,410.72
X$48228 73 9296 7756 7483 9441 73 57 9435 57 sky130_fd_sc_hd__o31ai_1
* cell instance $48231 r0 *1 108.1,410.72
X$48231 73 8686 9224 8535 7652 8201 9442 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $48238 r0 *1 124.66,410.72
X$48238 73 9295 8593 7801 73 9541 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48242 r0 *1 131.56,410.72
X$48242 73 8285 8122 9548 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48243 r0 *1 132.94,410.72
X$48243 73 9300 9296 8178 57 73 9450 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48246 r0 *1 137.54,410.72
X$48246 73 9450 8201 9301 57 73 9451 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48251 r0 *1 150.88,410.72
X$48251 73 9374 6338 73 9375 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $48254 r0 *1 154.56,410.72
X$48254 57 9377 9376 9375 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $48255 r0 *1 161.92,410.72
X$48255 73 9377 57 73 9365 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48257 r0 *1 169.28,410.72
X$48257 73 9303 7110 9455 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $48258 r0 *1 171.58,410.72
X$48258 57 8777 9455 9352 11029 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $48259 r0 *1 175.72,410.72
X$48259 57 6830 9378 9457 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $48264 r0 *1 183.54,410.72
X$48264 73 9457 73 57 7769 57 sky130_fd_sc_hd__buf_4
* cell instance $48277 r0 *1 214.82,410.72
X$48277 73 7994 73 57 7620 57 sky130_fd_sc_hd__buf_4
* cell instance $48282 r0 *1 229.08,410.72
X$48282 73 7447 73 57 8479 57 sky130_fd_sc_hd__buf_4
* cell instance $48303 r0 *1 273.7,410.72
X$48303 73 9306 73 57 7915 57 sky130_fd_sc_hd__buf_4
* cell instance $48307 r0 *1 285.66,410.72
X$48307 73 7938 8943 9307 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48309 r0 *1 287.04,410.72
X$48309 73 9307 73 57 9384 57 sky130_fd_sc_hd__buf_4
* cell instance $48310 r0 *1 289.8,410.72
X$48310 73 8882 9384 9383 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48313 r0 *1 292.56,410.72
X$48313 73 9383 73 57 8962 57 sky130_fd_sc_hd__buf_4
* cell instance $48316 r0 *1 299.46,410.72
X$48316 73 9034 7938 8966 57 73 9468 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48323 r0 *1 314.64,410.72
X$48323 73 9034 7413 9309 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48327 r0 *1 320.62,410.72
X$48327 73 8479 8638 9309 57 73 9387 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48328 r0 *1 322.46,410.72
X$48328 73 9388 9387 9466 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48331 r0 *1 325.22,410.72
X$48331 73 8965 9465 8633 73 9388 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48332 r0 *1 327.06,410.72
X$48332 73 7339 7413 8965 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48336 r0 *1 334.88,410.72
X$48336 73 7413 7544 9357 9463 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $48339 r0 *1 340.86,410.72
X$48339 57 9462 7987 8544 8070 7938 9310 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $48342 r0 *1 345.92,410.72
X$48342 73 9030 9310 9049 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48356 r0 *1 377.2,410.72
X$48356 73 9461 73 57 9389 57 sky130_fd_sc_hd__buf_4
* cell instance $48364 r0 *1 397.44,410.72
X$48364 73 9389 73 57 8735 57 sky130_fd_sc_hd__buf_4
* cell instance $48365 r0 *1 400.2,410.72
X$48365 73 9459 8735 9458 57 73 9456 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48369 r0 *1 403.42,410.72
X$48369 73 9458 73 57 9314 57 sky130_fd_sc_hd__buf_4
* cell instance $48370 r0 *1 406.18,410.72
X$48370 73 9390 73 57 9391 57 sky130_fd_sc_hd__buf_4
* cell instance $48371 r0 *1 408.94,410.72
X$48371 73 9391 73 57 8602 57 sky130_fd_sc_hd__buf_4
* cell instance $48374 r0 *1 414.46,410.72
X$48374 73 8735 9392 9390 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48377 r0 *1 418.6,410.72
X$48377 73 8602 8312 9317 9454 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $48379 r0 *1 421.36,410.72
X$48379 73 9392 73 57 9050 57 sky130_fd_sc_hd__buf_4
* cell instance $48398 r0 *1 463.68,410.72
X$48398 73 9399 8253 9398 57 73 9452 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48399 r0 *1 465.52,410.72
X$48399 73 9400 73 57 9449 57 sky130_fd_sc_hd__buf_4
* cell instance $48402 r0 *1 470.58,410.72
X$48402 73 9401 73 57 9317 57 sky130_fd_sc_hd__buf_4
* cell instance $48406 r0 *1 480.7,410.72
X$48406 73 8968 9150 9401 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48407 r0 *1 482.08,410.72
X$48407 73 9402 9401 9448 8973 8315 73 9445 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $48417 r0 *1 505.54,410.72
X$48417 73 9403 73 57 9400 57 sky130_fd_sc_hd__buf_4
* cell instance $48418 r0 *1 508.3,410.72
X$48418 73 8735 8975 9403 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48429 r0 *1 530.84,410.72
X$48429 73 9327 57 73 9443 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48437 r0 *1 543.26,410.72
X$48437 57 9088 9320 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $48442 r0 *1 559.82,410.72
X$48442 73 9336 73 57 9439 57 sky130_fd_sc_hd__buf_4
* cell instance $48448 r0 *1 570.86,410.72
X$48448 73 9168 9166 9438 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48450 r0 *1 572.7,410.72
X$48450 73 8914 9407 2342 9433 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $48451 r0 *1 575.46,410.72
X$48451 73 9407 9432 9433 73 9504 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48452 r0 *1 577.3,410.72
X$48452 73 9320 9413 9410 57 73 9411 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48458 r0 *1 587.88,410.72
X$48458 73 9416 9431 9161 73 9430 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48459 r0 *1 589.72,410.72
X$48459 73 9166 73 57 9409 57 sky130_fd_sc_hd__buf_4
* cell instance $48461 r0 *1 593.4,410.72
X$48461 73 9411 9416 9325 9332 57 9428 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $48465 r0 *1 600.76,410.72
X$48465 57 9247 9326 9428 9426 9427 9412 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $48466 r0 *1 603.98,410.72
X$48466 57 9417 9426 9423 9409 9333 9425 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $48470 r0 *1 610.42,410.72
X$48470 73 9246 9619 9422 9326 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $48491 r0 *1 653.66,410.72
X$48491 73 9252 57 73 9517 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48495 m0 *1 2.3,416.16
X$48495 57 9419 9471 9473 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $48498 m0 *1 11.04,416.16
X$48498 57 9255 9522 9367 9474 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $48509 m0 *1 37.72,416.16
X$48509 57 10037 8986 9436 9172 9369 9371 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $48521 m0 *1 60.26,416.16
X$48521 73 8467 7791 7792 7756 9622 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $48534 m0 *1 90.62,416.16
X$48534 57 7925 9293 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $48541 m0 *1 104.88,416.16
X$48541 73 8201 8834 9441 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48553 m0 *1 125.58,416.16
X$48553 73 9541 9447 9725 9026 57 73 9542 57 sky130_fd_sc_hd__a31oi_1
* cell instance $48554 m0 *1 127.88,416.16
X$48554 73 8201 8838 9447 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48560 m0 *1 141.22,416.16
X$48560 73 8063 8062 8178 57 73 9372 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48561 m0 *1 143.06,416.16
X$48561 73 9451 9372 8178 8723 7801 9373 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $48562 m0 *1 146.28,416.16
X$48562 73 8475 9373 9028 9551 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $48567 m0 *1 155.48,416.16
X$48567 57 9376 15432 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $48579 m0 *1 182.16,416.16
X$48579 57 9379 7413 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $48587 m0 *1 199.18,416.16
X$48587 73 9030 9379 7994 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48599 m0 *1 224.02,416.16
X$48599 57 15550 9380 7413 7339 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $48601 m0 *1 232.3,416.16
X$48601 73 7938 7622 9030 73 9381 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48604 m0 *1 234.14,416.16
X$48604 73 9030 7622 9381 73 9564 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48606 m0 *1 236.9,416.16
X$48606 73 9380 73 57 9363 57 sky130_fd_sc_hd__buf_4
* cell instance $48613 m0 *1 255.3,416.16
X$48613 73 7413 8633 9486 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48614 m0 *1 256.68,416.16
X$48614 73 9486 7449 9382 7685 57 9464 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $48619 m0 *1 260.82,416.16
X$48619 73 8887 7339 9306 9034 9382 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $48622 m0 *1 265.88,416.16
X$48622 73 7622 73 57 8966 57 sky130_fd_sc_hd__buf_4
* cell instance $48633 m0 *1 287.96,416.16
X$48633 73 7685 9488 9568 73 9467 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48638 m0 *1 299.46,416.16
X$48638 73 7907 9384 7915 7409 8544 9385 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $48645 m0 *1 311.88,416.16
X$48645 73 7339 9384 8887 57 73 9386 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48649 m0 *1 314.18,416.16
X$48649 73 9359 9386 8966 73 9489 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48650 m0 *1 316.02,416.16
X$48650 73 9489 73 57 7746 57 sky130_fd_sc_hd__buf_4
* cell instance $48654 m0 *1 329.82,416.16
X$48654 73 8544 7938 9465 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48655 m0 *1 331.2,416.16
X$48655 73 8544 8633 9357 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48661 m0 *1 340.4,416.16
X$48661 73 9462 73 57 9488 57 sky130_fd_sc_hd__buf_4
* cell instance $48680 m0 *1 378.58,416.16
X$48680 73 10170 73 57 9460 57 sky130_fd_sc_hd__buf_4
* cell instance $48689 m0 *1 395.6,416.16
X$48689 73 9051 8644 9009 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48692 m0 *1 401.58,416.16
X$48692 73 9050 9117 9458 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48694 m0 *1 406.64,416.16
X$48694 73 9571 73 57 9350 57 sky130_fd_sc_hd__buf_4
* cell instance $48702 m0 *1 421.36,416.16
X$48702 73 9393 73 57 9392 57 sky130_fd_sc_hd__buf_4
* cell instance $48717 m0 *1 451.72,416.16
X$48717 73 9494 73 57 9151 57 sky130_fd_sc_hd__buf_4
* cell instance $48718 m0 *1 454.48,416.16
X$48718 73 9497 8923 9396 57 73 9395 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48719 m0 *1 456.32,416.16
X$48719 73 8557 9395 9453 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48722 m0 *1 460,416.16
X$48722 57 9104 9882 9453 9552 9234 8973 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $48724 m0 *1 464.14,416.16
X$48724 73 8741 9269 9397 73 9398 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48735 m0 *1 487.6,416.16
X$48735 73 9402 9396 9446 8358 8313 73 9555 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $48742 m0 *1 501.86,416.16
X$48742 73 9393 73 57 8358 57 sky130_fd_sc_hd__buf_4
* cell instance $48754 m0 *1 528.54,416.16
X$48754 73 10789 73 57 9444 57 sky130_fd_sc_hd__buf_4
* cell instance $48761 m0 *1 543.26,416.16
X$48761 73 9088 57 73 9507 57 sky130_fd_sc_hd__inv_2
* cell instance $48766 m0 *1 551.54,416.16
X$48766 73 9404 73 57 9440 57 sky130_fd_sc_hd__buf_4
* cell instance $48768 m0 *1 554.76,416.16
X$48768 57 15485 9415 9405 9440 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $48773 m0 *1 560.74,416.16
X$48773 73 9323 9406 9539 57 73 9322 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48778 m0 *1 572.7,416.16
X$48778 73 9505 9633 9409 73 9526 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48780 m0 *1 575.46,416.16
X$48780 73 9414 9408 9410 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48781 m0 *1 576.84,416.16
X$48781 73 9503 9413 9406 9507 9534 73 9334 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $48782 m0 *1 580.06,416.16
X$48782 73 9415 9414 9508 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48787 m0 *1 583.74,416.16
X$48787 73 9163 73 57 9406 57 sky130_fd_sc_hd__buf_4
* cell instance $48794 m0 *1 596.16,416.16
X$48794 73 9335 73 57 9505 57 sky130_fd_sc_hd__buf_4
* cell instance $48797 m0 *1 600.3,416.16
X$48797 73 9161 9532 9324 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48801 m0 *1 606.74,416.16
X$48801 73 9530 73 57 9423 57 sky130_fd_sc_hd__buf_4
* cell instance $48804 m0 *1 610.42,416.16
X$48804 73 9526 9421 9525 9610 57 9422 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $48807 m0 *1 612.72,416.16
X$48807 73 9527 73 57 9424 57 sky130_fd_sc_hd__buf_4
* cell instance $48808 m0 *1 615.48,416.16
X$48808 73 9515 9423 9424 9513 57 73 9421 57 sky130_fd_sc_hd__a31oi_1
* cell instance $48812 m0 *1 626.06,416.16
X$48812 57 6998 9407 9521 9418 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $48818 m0 *1 640.32,416.16
X$48818 73 9520 57 73 9418 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48821 m0 *1 649.52,416.16
X$48821 73 9519 57 73 9330 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48825 r0 *1 4.14,416.16
X$48825 73 9470 57 73 9518 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48827 r0 *1 8.74,416.16
X$48827 57 9474 9471 9472 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $48830 r0 *1 16.56,416.16
X$48830 73 9474 73 57 9578 57 sky130_fd_sc_hd__buf_4
* cell instance $48834 r0 *1 24.38,416.16
X$48834 73 9367 73 57 9475 57 sky130_fd_sc_hd__buf_4
* cell instance $48845 r0 *1 50.6,416.16
X$48845 73 10235 9476 9369 73 9258 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48846 r0 *1 52.44,416.16
X$48846 73 9477 73 57 9473 57 sky130_fd_sc_hd__buf_4
* cell instance $48852 r0 *1 65.78,416.16
X$48852 57 8682 9533 8027 9292 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $48860 r0 *1 79.12,416.16
X$48860 73 9478 9475 73 9477 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $48863 r0 *1 87.86,416.16
X$48863 73 8348 73 57 9478 57 sky130_fd_sc_hd__buf_4
* cell instance $48871 r0 *1 104.88,416.16
X$48871 73 7925 7483 9538 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48877 r0 *1 121.9,416.16
X$48877 73 8100 8095 9540 9865 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $48882 r0 *1 126.96,416.16
X$48882 73 9544 8925 9542 9543 73 9481 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $48884 r0 *1 130.18,416.16
X$48884 73 8924 9548 8873 9441 73 9547 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $48890 r0 *1 145.82,416.16
X$48890 73 9551 9272 7763 8468 9436 73 9479 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $48891 r0 *1 149.04,416.16
X$48891 73 9481 9480 9482 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $48892 r0 *1 150.42,416.16
X$48892 73 9479 7763 9482 57 73 9553 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48897 r0 *1 155.48,416.16
X$48897 57 7608 9376 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $48908 r0 *1 186.76,416.16
X$48908 57 7981 9483 4968 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $48909 r0 *1 192.74,416.16
X$48909 57 7981 7685 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $48910 r0 *1 200.1,416.16
X$48910 73 8068 8633 9484 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $48914 r0 *1 204.7,416.16
X$48914 73 9484 7409 7622 9558 57 9560 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $48916 r0 *1 207.46,416.16
X$48916 73 7685 9560 9559 9360 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $48921 r0 *1 212.98,416.16
X$48921 73 9484 73 57 9310 57 sky130_fd_sc_hd__buf_4
* cell instance $48924 r0 *1 221.26,416.16
X$48924 57 9561 7409 7622 7620 9485 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $48925 r0 *1 224.48,416.16
X$48925 73 8943 9380 7622 57 73 9485 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48930 r0 *1 232.76,416.16
X$48930 73 8633 7620 7339 73 9563 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48931 r0 *1 234.6,416.16
X$48931 73 9563 8633 9564 57 73 9565 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48941 r0 *1 255.3,416.16
X$48941 73 9486 73 57 9039 57 sky130_fd_sc_hd__buf_4
* cell instance $48943 r0 *1 258.98,416.16
X$48943 57 9566 9486 8544 8479 7852 8633 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $48952 r0 *1 276.46,416.16
X$48952 57 15632 9288 7413 7339 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $48954 r0 *1 284.74,416.16
X$48954 73 9567 9487 7685 73 9568 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $48955 r0 *1 286.58,416.16
X$48955 73 7413 8638 9588 9487 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $48964 r0 *1 307.74,416.16
X$48964 57 8942 9310 7938 9565 7449 8966 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $48978 r0 *1 338.1,416.16
X$48978 73 7685 9648 9385 57 73 8517 57 sky130_fd_sc_hd__a21oi_1
* cell instance $48999 r0 *1 390.54,416.16
X$48999 73 9009 73 57 9574 57 sky130_fd_sc_hd__buf_4
* cell instance $49004 r0 *1 398.36,416.16
X$49004 73 9490 9573 9117 8150 57 9572 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $49010 r0 *1 407.56,416.16
X$49010 73 8770 73 57 9570 57 sky130_fd_sc_hd__buf_4
* cell instance $49015 r0 *1 421.82,416.16
X$49015 73 8926 8644 9493 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49017 r0 *1 423.2,416.16
X$49017 73 8362 9493 9497 73 9490 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49022 r0 *1 430.56,416.16
X$49022 73 8557 9596 9495 9492 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $49024 r0 *1 432.86,416.16
X$49024 57 9394 9495 9053 9494 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $49030 r0 *1 445.74,416.16
X$49030 73 8695 9557 9497 73 9496 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49031 r0 *1 447.58,416.16
X$49031 73 9647 9496 9237 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49036 r0 *1 455.4,416.16
X$49036 73 8483 8735 9494 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49043 r0 *1 468.28,416.16
X$49043 73 9344 73 57 9562 57 sky130_fd_sc_hd__buf_4
* cell instance $49049 r0 *1 479.78,416.16
X$49049 73 8973 9176 9397 9498 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $49053 r0 *1 486.68,416.16
X$49053 73 8358 8809 9402 9556 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $49054 r0 *1 488.52,416.16
X$49054 73 8648 9498 9556 57 73 9554 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49070 r0 *1 529.46,416.16
X$49070 57 6998 9550 8976 9443 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $49075 r0 *1 545.1,416.16
X$49075 57 15575 9499 9320 9546 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $49076 r0 *1 549.7,416.16
X$49076 73 9499 9408 9549 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49077 r0 *1 551.08,416.16
X$49077 73 9499 9408 9500 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49080 r0 *1 553.84,416.16
X$49080 73 9440 73 57 9529 57 sky130_fd_sc_hd__buf_4
* cell instance $49082 r0 *1 557.06,416.16
X$49082 57 9414 9545 9405 73 73 57 sky130_fd_sc_hd__ha_2
* cell instance $49084 r0 *1 562.58,416.16
X$49084 73 9500 9408 9501 57 73 9539 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49087 r0 *1 566.72,416.16
X$49087 73 9502 9408 9503 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49091 r0 *1 572.7,416.16
X$49091 73 9507 9536 9410 57 73 9537 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49092 r0 *1 574.54,416.16
X$49092 57 9504 9506 9083 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $49093 r0 *1 578.68,416.16
X$49093 73 9506 73 57 9408 57 sky130_fd_sc_hd__buf_4
* cell instance $49094 r0 *1 581.44,416.16
X$49094 73 9508 73 57 9509 57 sky130_fd_sc_hd__buf_4
* cell instance $49098 r0 *1 586.5,416.16
X$49098 73 9509 9506 9320 9528 57 9431 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $49105 r0 *1 601.68,416.16
X$49105 73 9531 9510 9532 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49108 r0 *1 604.44,416.16
X$49108 73 9695 9608 9621 73 9512 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49109 r0 *1 606.28,416.16
X$49109 57 9425 9514 9529 9513 9502 9320 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $49110 r0 *1 609.5,416.16
X$49110 73 9507 9536 9423 57 73 9523 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49114 r0 *1 613.64,416.16
X$49114 73 9618 73 57 9510 57 sky130_fd_sc_hd__buf_4
* cell instance $49135 m0 *1 4.14,421.6
X$49135 73 9614 57 73 9575 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49138 m0 *1 9.2,421.6
X$49138 57 9472 9577 9328 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $49144 m0 *1 16.56,421.6
X$49144 73 9522 9578 73 9577 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $49158 m0 *1 44.62,421.6
X$49158 73 7652 7921 7647 73 9620 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49164 m0 *1 59.8,421.6
X$49164 73 7756 9579 9622 73 9727 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49165 m0 *1 61.64,421.6
X$49165 73 8203 7647 8764 73 9579 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49169 m0 *1 69.46,421.6
X$49169 73 7921 9579 9580 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49172 m0 *1 70.84,421.6
X$49172 57 9623 9624 8475 9533 7756 9581 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $49176 m0 *1 77.28,421.6
X$49176 57 9264 8475 9581 9580 9582 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $49184 m0 *1 95.22,421.6
X$49184 73 9296 8390 9627 73 9624 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49189 m0 *1 104.42,421.6
X$49189 73 8997 9300 9629 8475 9582 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $49192 m0 *1 109.94,421.6
X$49192 73 7801 7483 9300 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49198 m0 *1 115.46,421.6
X$49198 73 7652 8001 9632 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49202 m0 *1 120.06,421.6
X$49202 57 9632 9543 8475 9631 9583 8178 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $49203 m0 *1 123.28,421.6
X$49203 73 7834 8789 9625 57 73 9583 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49211 m0 *1 137.54,421.6
X$49211 73 8504 73 57 9225 57 sky130_fd_sc_hd__buf_4
* cell instance $49216 m0 *1 149.04,421.6
X$49216 57 9522 9376 9553 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $49221 m0 *1 160.54,421.6
X$49221 57 9379 10752 7158 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $49222 m0 *1 166.52,421.6
X$49222 73 9303 9636 7970 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49225 m0 *1 168.82,421.6
X$49225 73 7110 9303 9584 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49226 m0 *1 170.2,421.6
X$49226 73 9663 9584 9637 73 8725 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49233 m0 *1 186.76,421.6
X$49233 57 4968 9483 9640 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $49234 m0 *1 192.74,421.6
X$49234 73 9640 73 57 7447 57 sky130_fd_sc_hd__buf_4
* cell instance $49237 m0 *1 196.88,421.6
X$49237 73 9379 57 73 8068 57 sky130_fd_sc_hd__inv_2
* cell instance $49249 m0 *1 223.56,421.6
X$49249 57 8068 7938 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $49268 m0 *1 267.26,421.6
X$49268 57 9642 7938 9359 9588 9566 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $49271 m0 *1 275.08,421.6
X$49271 57 9587 9039 9288 8966 7449 8633 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $49292 m0 *1 319.7,421.6
X$49292 57 15459 9590 9034 7339 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $49294 m0 *1 325.22,421.6
X$49294 73 9590 8943 9284 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49321 m0 *1 384.1,421.6
X$49321 57 8253 9650 9117 9591 9492 9491 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $49332 m0 *1 402.5,421.6
X$49332 57 9591 9571 9314 9572 9651 9652 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $49336 m0 *1 411.7,421.6
X$49336 73 9052 9317 8811 57 73 9592 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49337 m0 *1 413.54,421.6
X$49337 73 8408 9594 9593 9592 9569 73 57 57 sky130_fd_sc_hd__or4_1
* cell instance $49341 m0 *1 419.06,421.6
X$49341 73 8560 9646 9394 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49343 m0 *1 420.9,421.6
X$49343 73 9402 9277 9649 9497 8557 73 9594 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $49346 m0 *1 424.12,421.6
X$49346 73 9497 9595 9493 9649 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $49347 m0 *1 425.96,421.6
X$49347 73 8970 9053 9595 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49350 m0 *1 432.86,421.6
X$49350 73 9053 9394 9494 57 73 9596 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49357 m0 *1 447.12,421.6
X$49357 73 9273 73 57 8560 57 sky130_fd_sc_hd__buf_4
* cell instance $49364 m0 *1 459.54,421.6
X$49364 73 8968 8560 9646 9269 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $49367 m0 *1 462.76,421.6
X$49367 73 9273 9393 8441 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49368 m0 *1 464.14,421.6
X$49368 73 9597 9644 9104 73 9643 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49373 m0 *1 473.8,421.6
X$49373 73 9449 9153 9597 9715 57 73 9598 57 sky130_fd_sc_hd__a31oi_1
* cell instance $49380 m0 *1 488.06,421.6
X$49380 57 8814 9600 8146 9555 9598 9599 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $49381 m0 *1 491.28,421.6
X$49381 73 9600 73 57 9641 57 sky130_fd_sc_hd__buf_4
* cell instance $49384 m0 *1 496.34,421.6
X$49384 73 8973 9178 9557 9601 73 57 9639 57 sky130_fd_sc_hd__o31ai_1
* cell instance $49390 m0 *1 506.92,421.6
X$49390 73 9602 9638 9403 8973 9601 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $49404 m0 *1 537.28,421.6
X$49404 73 9524 57 73 9171 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49410 m0 *1 551.54,421.6
X$49410 73 9545 73 57 9546 57 sky130_fd_sc_hd__buf_4
* cell instance $49414 m0 *1 556.14,421.6
X$49414 73 9404 57 73 9545 57 sky130_fd_sc_hd__inv_2
* cell instance $49418 m0 *1 561.2,421.6
X$49418 57 15559 9535 9635 9545 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $49420 m0 *1 567.64,421.6
X$49420 73 9634 9603 9501 57 73 9633 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49423 m0 *1 572.24,421.6
X$49423 73 9083 9504 57 73 9603 57 sky130_fd_sc_hd__or2_4
* cell instance $49424 m0 *1 575.46,421.6
X$49424 73 9415 9083 9504 9840 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $49425 m0 *1 577.76,421.6
X$49425 73 9535 9083 9504 9630 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $49433 m0 *1 585.58,421.6
X$49433 73 9507 9506 9511 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49437 m0 *1 592.02,421.6
X$49437 73 9320 9628 9605 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49438 m0 *1 593.4,421.6
X$49438 73 9606 9605 9416 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49441 m0 *1 597.08,421.6
X$49441 73 9607 9513 9626 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49442 m0 *1 598.46,421.6
X$49442 73 9415 9603 9531 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49443 m0 *1 599.84,421.6
X$49443 73 9608 73 57 9607 57 sky130_fd_sc_hd__buf_4
* cell instance $49445 m0 *1 603.06,421.6
X$49445 57 9507 9621 9161 9531 9604 9527 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $49446 m0 *1 606.28,421.6
X$49446 73 9609 9514 9527 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49449 m0 *1 609.96,421.6
X$49449 73 9320 9609 9603 57 73 9618 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49453 m0 *1 613.64,421.6
X$49453 57 9606 9525 9529 9618 9617 9611 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $49455 m0 *1 617.78,421.6
X$49455 73 9613 9511 9608 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49458 m0 *1 623.3,421.6
X$49458 73 9692 73 57 9528 57 sky130_fd_sc_hd__buf_4
* cell instance $49459 m0 *1 626.06,421.6
X$49459 73 9528 9616 9320 73 9515 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49470 m0 *1 649.52,421.6
X$49470 73 9688 57 73 9516 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49473 r0 *1 2.3,421.6
X$49473 73 9576 57 73 9653 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49475 r0 *1 7.82,421.6
X$49475 57 9576 9471 9691 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $49489 r0 *1 41.86,421.6
X$49489 73 8027 7791 9694 57 73 8580 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49495 r0 *1 45.54,421.6
X$49495 73 9620 8429 8580 8178 9696 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $49502 r0 *1 65.32,421.6
X$49502 73 9657 73 57 8682 57 sky130_fd_sc_hd__buf_4
* cell instance $49510 r0 *1 75.44,421.6
X$49510 73 8867 73 57 9658 57 sky130_fd_sc_hd__buf_4
* cell instance $49513 r0 *1 79.58,421.6
X$49513 73 8003 7791 9625 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49517 r0 *1 84.18,421.6
X$49517 73 8003 7647 9699 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49522 r0 *1 95.68,421.6
X$49522 73 8834 8682 8475 73 9627 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49531 r0 *1 105.34,421.6
X$49531 73 9538 8834 7921 73 9629 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49537 r0 *1 120.52,421.6
X$49537 73 8062 8872 9631 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49546 r0 *1 135.24,421.6
X$49546 73 7801 8178 7887 9869 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $49549 r0 *1 139.38,421.6
X$49549 73 8178 8723 8504 57 73 10101 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49558 r0 *1 158.24,421.6
X$49558 73 9660 7158 73 9691 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $49562 r0 *1 166.52,421.6
X$49562 73 9662 73 57 9636 57 sky130_fd_sc_hd__buf_4
* cell instance $49563 r0 *1 169.28,421.6
X$49563 73 7110 9663 9303 9637 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $49589 r0 *1 229.08,421.6
X$49589 73 7409 9034 9585 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49590 r0 *1 230.46,421.6
X$49590 73 9585 73 57 8707 57 sky130_fd_sc_hd__buf_4
* cell instance $49598 r0 *1 248.4,421.6
X$49598 73 7409 9034 8633 9586 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $49601 r0 *1 251.62,421.6
X$49601 73 9586 73 57 9359 57 sky130_fd_sc_hd__buf_4
* cell instance $49618 r0 *1 288.88,421.6
X$49618 73 7533 8943 9588 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49619 r0 *1 290.26,421.6
X$49619 73 7938 9359 9588 9589 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $49621 r0 *1 292.56,421.6
X$49621 73 8966 8962 9589 9645 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $49626 r0 *1 307.28,421.6
X$49626 73 8707 7938 8633 9711 57 9230 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $49636 r0 *1 327.52,421.6
X$49636 73 8633 7533 7938 57 73 9712 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49638 r0 *1 333.04,421.6
X$49638 73 7938 8381 9359 9664 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $49639 r0 *1 334.88,421.6
X$49639 73 9664 9463 8966 73 9648 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49663 r0 *1 381.34,421.6
X$49663 73 7905 57 73 57 sky130_fd_sc_hd__clkinv_4
* cell instance $49688 r0 *1 431.94,421.6
X$49688 73 9596 73 57 9722 57 sky130_fd_sc_hd__buf_4
* cell instance $49691 r0 *1 437.46,421.6
X$49691 73 9394 73 57 9797 57 sky130_fd_sc_hd__buf_4
* cell instance $49692 r0 *1 440.22,421.6
X$49692 73 8358 73 57 9497 57 sky130_fd_sc_hd__buf_4
* cell instance $49698 r0 *1 452.18,421.6
X$49698 73 9668 73 57 9396 57 sky130_fd_sc_hd__buf_4
* cell instance $49699 r0 *1 454.94,421.6
X$49699 73 8736 73 57 8687 57 sky130_fd_sc_hd__buf_4
* cell instance $49704 r0 *1 464.6,421.6
X$49704 73 8814 9669 9643 8150 9719 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $49706 r0 *1 467.36,421.6
X$49706 73 9313 8562 9713 9562 9669 57 73 57 sky130_fd_sc_hd__o22a_1
* cell instance $49708 r0 *1 471.04,421.6
X$49708 73 8441 73 57 9667 57 sky130_fd_sc_hd__buf_4
* cell instance $49722 r0 *1 500.02,421.6
X$49722 73 9670 9752 8805 9639 73 9599 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $49723 r0 *1 503.24,421.6
X$49723 73 8815 9396 8805 8973 9671 73 9670 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $49726 r0 *1 506.46,421.6
X$49726 73 10207 73 57 9671 57 sky130_fd_sc_hd__buf_4
* cell instance $49743 r0 *1 543.72,421.6
X$49743 57 9507 9701 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $49744 r0 *1 551.08,421.6
X$49744 73 9507 9408 9679 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49745 r0 *1 552.46,421.6
X$49745 73 9545 73 57 9703 57 sky130_fd_sc_hd__buf_4
* cell instance $49746 r0 *1 555.22,421.6
X$49746 57 9926 9502 9405 9404 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $49749 r0 *1 559.82,421.6
X$49749 73 9405 57 73 9635 57 sky130_fd_sc_hd__inv_2
* cell instance $49750 r0 *1 561.2,421.6
X$49750 73 9405 73 57 9673 57 sky130_fd_sc_hd__buf_4
* cell instance $49753 r0 *1 566.72,421.6
X$49753 73 9674 9603 9634 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49757 r0 *1 571.32,421.6
X$49757 73 9537 9507 9707 57 73 9706 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49760 r0 *1 578.68,421.6
X$49760 73 9603 9508 9762 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49763 r0 *1 584.66,421.6
X$49763 73 9509 9678 9701 9604 57 9764 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $49769 r0 *1 590.64,421.6
X$49769 73 9502 9603 9628 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49773 r0 *1 598,421.6
X$49773 57 9166 9681 9673 9682 9683 9514 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $49774 r0 *1 601.22,421.6
X$49774 73 9529 9511 9684 57 73 9683 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49775 r0 *1 603.06,421.6
X$49775 73 9675 9320 9603 9684 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $49778 r0 *1 610.42,421.6
X$49778 73 9679 73 57 9611 57 sky130_fd_sc_hd__buf_4
* cell instance $49781 r0 *1 613.18,421.6
X$49781 73 9685 73 57 9606 57 sky130_fd_sc_hd__buf_4
* cell instance $49782 r0 *1 615.94,421.6
X$49782 73 9681 73 57 9612 57 sky130_fd_sc_hd__buf_4
* cell instance $49791 r0 *1 636.18,421.6
X$49791 57 9690 9521 8980 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $49804 m0 *1 9.2,427.04
X$49804 57 7704 9663 9471 9689 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $49816 m0 *1 43.24,427.04
X$49816 73 8864 7921 9655 57 73 9694 57 sky130_fd_sc_hd__a21o_1
* cell instance $49818 m0 *1 46.46,427.04
X$49818 73 9696 9697 9656 9776 73 9777 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $49820 m0 *1 49.22,427.04
X$49820 73 8839 9946 8001 9293 7921 9697 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $49826 m0 *1 61.64,427.04
X$49826 73 9726 9339 9656 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49828 m0 *1 66.7,427.04
X$49828 73 8431 7791 9657 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49833 m0 *1 74.06,427.04
X$49833 73 8431 7921 9658 57 73 9659 57 sky130_fd_sc_hd__a21o_1
* cell instance $49840 m0 *1 91.08,427.04
X$49840 73 8095 7647 9659 57 73 9859 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49847 m0 *1 105.34,427.04
X$49847 73 7800 9225 9441 73 9784 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49856 m0 *1 125.12,427.04
X$49856 73 8062 8509 9700 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49858 m0 *1 128.34,427.04
X$49858 73 9700 8062 8838 57 73 9702 57 sky130_fd_sc_hd__a21oi_1
* cell instance $49859 m0 *1 130.18,427.04
X$49859 73 8475 8100 9268 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49867 m0 *1 142.14,427.04
X$49867 73 8062 7800 9704 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49869 m0 *1 143.98,427.04
X$49869 73 9097 9704 8063 73 9705 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $49919 m0 *1 272.32,427.04
X$49919 57 9710 7911 3117 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $49937 m0 *1 307.74,427.04
X$49937 73 7449 7938 9711 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $49944 m0 *1 319.7,427.04
X$49944 73 7449 7938 8633 9285 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $49946 m0 *1 325.22,427.04
X$49946 73 8633 9590 9712 8479 57 8379 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $49967 m0 *1 375.36,427.04
X$49967 73 9716 9235 9717 9718 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $49969 m0 *1 379.5,427.04
X$49969 57 9804 7905 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $49973 m0 *1 393.3,427.04
X$49973 73 9146 10614 8772 9895 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $49978 m0 *1 398.36,427.04
X$49978 73 9108 8935 9665 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $49979 m0 *1 399.74,427.04
X$49979 73 9665 9351 9146 8150 9666 73 9651 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $49980 m0 *1 402.96,427.04
X$49980 73 9667 9053 8483 9456 57 10010 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $49995 m0 *1 439.76,427.04
X$49995 73 9668 9050 8253 8815 73 9800 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $50000 m0 *1 445.74,427.04
X$50000 73 9720 73 57 9557 57 sky130_fd_sc_hd__buf_4
* cell instance $50005 m0 *1 451.72,427.04
X$50005 73 9719 73 57 9716 57 sky130_fd_sc_hd__buf_4
* cell instance $50015 m0 *1 474.26,427.04
X$50015 73 9714 9313 8313 73 9715 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50037 m0 *1 527.62,427.04
X$50037 57 9672 9754 9709 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $50042 m0 *1 538.2,427.04
X$50042 73 9672 57 73 9708 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50046 m0 *1 552.92,427.04
X$50046 73 9673 9701 9534 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50053 m0 *1 567.64,427.04
X$50053 73 9635 73 57 9675 57 sky130_fd_sc_hd__buf_4
* cell instance $50054 m0 *1 570.4,427.04
X$50054 73 9408 9703 9675 57 73 9707 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50058 m0 *1 575.46,427.04
X$50058 73 9703 9603 9413 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50059 m0 *1 576.84,427.04
X$50059 73 9413 73 57 9760 57 sky130_fd_sc_hd__buf_4
* cell instance $50065 m0 *1 583.74,427.04
X$50065 73 9506 73 57 9678 57 sky130_fd_sc_hd__buf_4
* cell instance $50070 m0 *1 594.78,427.04
X$50070 73 9320 9678 9680 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50071 m0 *1 596.16,427.04
X$50071 73 9415 9680 9682 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50073 m0 *1 599.38,427.04
X$50073 73 9682 73 57 9698 57 sky130_fd_sc_hd__buf_4
* cell instance $50075 m0 *1 602.6,427.04
X$50075 73 9778 9698 9604 9332 57 9610 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $50081 m0 *1 612.26,427.04
X$50081 73 9529 9675 9603 9685 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $50084 m0 *1 615.02,427.04
X$50084 73 9685 9772 9686 73 9695 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50087 m0 *1 619.16,427.04
X$50087 73 9323 9686 9617 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50088 m0 *1 620.54,427.04
X$50088 73 9617 73 57 9693 57 sky130_fd_sc_hd__buf_4
* cell instance $50090 m0 *1 624.22,427.04
X$50090 73 9675 9678 9692 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50101 m0 *1 642.16,427.04
X$50101 57 9688 9521 9687 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $50108 r0 *1 4.14,427.04
X$50108 73 9770 57 73 9689 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50111 r0 *1 12.42,427.04
X$50111 73 9940 57 73 9654 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50121 r0 *1 37.26,427.04
X$50121 73 9724 9773 9725 73 9776 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50128 r0 *1 48.3,427.04
X$50128 73 8431 7921 9655 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50133 r0 *1 61.64,427.04
X$50133 73 9026 9726 9727 57 73 9780 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50136 r0 *1 66.24,427.04
X$50136 73 7756 9781 9657 9724 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $50155 r0 *1 106.72,427.04
X$50155 73 8475 9447 9784 9782 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $50158 r0 *1 110.86,427.04
X$50158 73 7800 73 57 9786 57 sky130_fd_sc_hd__buf_4
* cell instance $50167 r0 *1 129.26,427.04
X$50167 73 9268 9702 9732 73 9868 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50168 r0 *1 131.1,427.04
X$50168 73 8203 9788 9725 8629 9732 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $50174 r0 *1 147.66,427.04
X$50174 73 8468 9789 9705 57 73 9790 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50217 r0 *1 255.76,427.04
X$50217 73 4443 9199 10081 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $50218 r0 *1 258.06,427.04
X$50218 73 4443 9199 9974 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50227 r0 *1 270.94,427.04
X$50227 57 3117 7911 9801 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $50231 r0 *1 284.28,427.04
X$50231 73 3091 3375 73 9802 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $50233 r0 *1 287.5,427.04
X$50233 73 3091 3375 9894 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $50272 r0 *1 380.88,427.04
X$50272 73 9805 7909 73 9709 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $50279 r0 *1 397.9,427.04
X$50279 73 8253 9747 9052 9808 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $50286 r0 *1 410.78,427.04
X$50286 73 9646 9748 9317 9806 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $50287 r0 *1 412.62,427.04
X$50287 73 8843 9748 9891 57 73 9593 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50290 r0 *1 419.06,427.04
X$50290 73 8601 73 57 9053 57 sky130_fd_sc_hd__buf_4
* cell instance $50294 r0 *1 427.34,427.04
X$50294 73 8146 73 57 9747 57 sky130_fd_sc_hd__buf_4
* cell instance $50298 r0 *1 436.08,427.04
X$50298 73 9803 9749 8557 73 9721 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50299 r0 *1 437.92,427.04
X$50299 73 8150 8695 8223 9800 73 57 9749 57 sky130_fd_sc_hd__o31ai_1
* cell instance $50311 r0 *1 464.14,427.04
X$50311 73 8146 9752 9798 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50317 r0 *1 477.48,427.04
X$50317 73 9836 8741 9182 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50318 r0 *1 478.86,427.04
X$50318 73 8968 9150 9713 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50324 r0 *1 486.22,427.04
X$50324 73 8973 9794 8442 57 73 9751 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50325 r0 *1 488.06,427.04
X$50325 73 8358 9794 9967 57 73 9181 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50330 r0 *1 499.56,427.04
X$50330 73 9792 9319 9751 9793 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $50339 r0 *1 517.96,427.04
X$50339 57 6998 9791 9754 9753 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $50345 r0 *1 533.14,427.04
X$50345 73 9677 57 73 9753 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50350 r0 *1 546.48,427.04
X$50350 73 9408 9701 9755 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $50352 r0 *1 550.62,427.04
X$50352 73 9404 73 57 9756 57 sky130_fd_sc_hd__buf_4
* cell instance $50353 r0 *1 553.38,427.04
X$50353 57 15626 9674 9758 9546 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $50354 r0 *1 557.98,427.04
X$50354 73 9415 9864 9408 9787 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $50358 r0 *1 561.2,427.04
X$50358 73 9635 73 57 9758 57 sky130_fd_sc_hd__buf_4
* cell instance $50360 r0 *1 565.8,427.04
X$50360 73 9676 9703 9501 9861 9759 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $50365 r0 *1 571.78,427.04
X$50365 57 9706 9783 9505 9759 9785 9332 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $50368 r0 *1 577.76,427.04
X$50368 73 9503 73 57 9766 57 sky130_fd_sc_hd__buf_4
* cell instance $50369 r0 *1 580.52,427.04
X$50369 73 9529 9534 9761 73 9763 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50371 r0 *1 583.28,427.04
X$50371 73 9857 9676 9332 9701 9764 73 9765 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $50373 r0 *1 586.5,427.04
X$50373 73 9765 9763 9626 57 73 9856 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50378 r0 *1 596.62,427.04
X$50378 73 9680 73 57 9779 57 sky130_fd_sc_hd__buf_4
* cell instance $50379 r0 *1 599.38,427.04
X$50379 73 9415 73 57 9767 57 sky130_fd_sc_hd__buf_4
* cell instance $50381 r0 *1 602.6,427.04
X$50381 73 9320 9676 9766 57 73 9778 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50385 r0 *1 610.88,427.04
X$50385 73 9675 9603 9775 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50388 r0 *1 612.72,427.04
X$50388 73 9775 9675 9514 57 73 9774 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50391 r0 *1 618.7,427.04
X$50391 73 9523 9161 9771 9768 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $50393 r0 *1 621.92,427.04
X$50393 73 9244 9686 9513 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50402 r0 *1 642.62,427.04
X$50402 73 9521 73 57 15428 57 sky130_fd_sc_hd__clkinvlp_4
* cell instance $50408 r0 *1 654.12,427.04
X$50408 73 9690 57 73 9846 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50412 m0 *1 4.14,432.48
X$50412 73 9847 57 73 9809 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50414 m0 *1 8.74,432.48
X$50414 57 7704 9850 9471 9518 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $50428 m0 *1 43.24,432.48
X$50428 73 7921 9370 9811 57 73 9773 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50429 m0 *1 45.08,432.48
X$50429 57 9853 9026 7763 9777 9812 8759 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $50432 m0 *1 51.52,432.48
X$50432 73 7756 8764 8717 57 73 9476 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50439 m0 *1 61.18,432.48
X$50439 73 9730 73 57 9726 57 sky130_fd_sc_hd__buf_4
* cell instance $50452 m0 *1 87.86,432.48
X$50452 73 8918 9782 7763 9728 57 73 9858 57 sky130_fd_sc_hd__a31oi_1
* cell instance $50454 m0 *1 90.62,432.48
X$50454 73 10042 9265 7763 9859 57 9728 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $50461 m0 *1 104.42,432.48
X$50461 73 9730 73 57 8873 57 sky130_fd_sc_hd__buf_4
* cell instance $50467 m0 *1 114.54,432.48
X$50467 73 7836 8178 9730 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50470 m0 *1 120.06,432.48
X$50470 73 7836 8178 9731 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50477 m0 *1 131.1,432.48
X$50477 73 7921 8063 9788 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50481 m0 *1 135.7,432.48
X$50481 73 9819 9869 9190 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50489 m0 *1 147.2,432.48
X$50489 73 9820 9871 9547 9790 73 9480 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $50490 m0 *1 149.5,432.48
X$50490 73 9731 8125 9225 57 73 9789 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50517 m0 *1 206.08,432.48
X$50517 73 9733 9877 9735 73 9880 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50518 m0 *1 207.92,432.48
X$50518 73 9736 9734 9824 9733 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $50521 m0 *1 212.52,432.48
X$50521 73 9826 9880 9737 57 73 9795 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50522 m0 *1 214.36,432.48
X$50522 73 9738 9881 9739 57 73 9737 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50523 m0 *1 216.2,432.48
X$50523 73 10314 9824 9741 73 9881 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50525 m0 *1 218.96,432.48
X$50525 73 9883 73 57 9824 57 sky130_fd_sc_hd__buf_4
* cell instance $50529 m0 *1 223.56,432.48
X$50529 73 9735 9827 9740 57 73 9739 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50531 m0 *1 226.32,432.48
X$50531 73 9738 9991 9796 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50532 m0 *1 227.7,432.48
X$50532 73 9736 9885 9796 57 73 9828 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50545 m0 *1 255.76,432.48
X$50545 73 4443 9830 9199 73 9883 57 57 sky130_fd_sc_hd__a21oi_2
* cell instance $50546 m0 *1 258.98,432.48
X$50546 73 9742 73 57 9741 57 sky130_fd_sc_hd__buf_4
* cell instance $50551 m0 *1 264.5,432.48
X$50551 57 4067 9742 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $50554 m0 *1 274.16,432.48
X$50554 73 9801 73 57 9738 57 sky130_fd_sc_hd__buf_4
* cell instance $50560 m0 *1 281.06,432.48
X$50560 73 7337 73 57 9735 57 sky130_fd_sc_hd__buf_4
* cell instance $50566 m0 *1 289.8,432.48
X$50566 57 9894 9743 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $50603 m0 *1 375.36,432.48
X$50603 73 9718 9897 9744 9898 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $50606 m0 *1 384.56,432.48
X$50606 73 9874 9899 9747 9650 57 73 9744 57 sky130_fd_sc_hd__a31oi_1
* cell instance $50610 m0 *1 389.62,432.48
X$50610 73 8313 9895 9745 57 73 9807 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50613 m0 *1 392.84,432.48
X$50613 73 9721 73 57 9745 57 sky130_fd_sc_hd__buf_4
* cell instance $50622 m0 *1 411.7,432.48
X$50622 73 8253 9833 9746 73 9652 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50623 m0 *1 413.54,432.48
X$50623 73 9891 73 57 9833 57 sky130_fd_sc_hd__buf_4
* cell instance $50634 m0 *1 437.92,432.48
X$50634 73 10060 73 57 8599 57 sky130_fd_sc_hd__buf_4
* cell instance $50636 m0 *1 441.6,432.48
X$50636 73 9668 9748 9497 10291 57 73 9799 57 sky130_fd_sc_hd__a31oi_1
* cell instance $50645 m0 *1 459.54,432.48
X$50645 57 9887 9882 8409 9886 9798 9750 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $50646 m0 *1 462.76,432.48
X$50646 73 9836 73 57 8647 57 sky130_fd_sc_hd__buf_4
* cell instance $50664 m0 *1 500.48,432.48
X$50664 73 8315 9793 9876 9750 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $50670 m0 *1 505.54,432.48
X$50670 73 9873 8805 10050 57 73 9874 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50679 m0 *1 530.84,432.48
X$50679 73 9754 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $50686 m0 *1 543.72,432.48
X$50686 73 9701 73 57 9864 57 sky130_fd_sc_hd__buf_4
* cell instance $50687 m0 *1 546.48,432.48
X$50687 73 9758 9755 9785 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50689 m0 *1 548.78,432.48
X$50689 73 9785 73 57 9870 57 sky130_fd_sc_hd__buf_4
* cell instance $50691 m0 *1 552.46,432.48
X$50691 73 9701 9757 10043 73 9866 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50694 m0 *1 555.22,432.48
X$50694 73 9755 73 57 9841 57 sky130_fd_sc_hd__buf_4
* cell instance $50695 m0 *1 557.98,432.48
X$50695 73 9674 9408 9787 9323 10023 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $50701 m0 *1 566.72,432.48
X$50701 73 9603 73 57 9861 57 sky130_fd_sc_hd__buf_4
* cell instance $50706 m0 *1 579.14,432.48
X$50706 73 9860 73 57 9857 57 sky130_fd_sc_hd__buf_4
* cell instance $50713 m0 *1 588.34,432.48
X$50713 73 9163 73 57 9686 57 sky130_fd_sc_hd__buf_4
* cell instance $50716 m0 *1 593.86,432.48
X$50716 73 9769 9603 9760 9701 9843 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $50718 m0 *1 597.54,432.48
X$50718 73 9505 9854 9843 57 73 9950 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50722 m0 *1 604.44,432.48
X$50722 73 9695 73 57 9848 57 sky130_fd_sc_hd__buf_4
* cell instance $50731 m0 *1 613.18,432.48
X$50731 73 9529 9774 9844 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50732 m0 *1 614.56,432.48
X$50732 73 9767 9842 9320 73 9772 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50735 m0 *1 619.16,432.48
X$50735 57 9851 9845 9769 9844 9673 9611 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $50737 m0 *1 622.84,432.48
X$50737 73 9613 9611 9849 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50748 m0 *1 642.62,432.48
X$50748 57 8104 9521 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $50753 r0 *1 2.3,432.48
X$50753 57 9847 9471 9729 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $50754 r0 *1 9.66,432.48
X$50754 73 9723 57 73 9939 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50761 r0 *1 18.86,432.48
X$50761 57 9216 9471 9810 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $50771 r0 *1 46,432.48
X$50771 73 7921 9699 9370 57 73 9945 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50772 r0 *1 47.84,432.48
X$50772 73 9655 73 57 9901 57 sky130_fd_sc_hd__buf_4
* cell instance $50773 r0 *1 50.6,432.48
X$50773 73 7921 9370 9811 9813 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $50774 r0 *1 52.44,432.48
X$50774 73 7921 9855 9813 8839 9814 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $50775 r0 *1 55.2,432.48
X$50775 73 7760 73 57 9855 57 sky130_fd_sc_hd__buf_4
* cell instance $50779 r0 *1 61.18,432.48
X$50779 73 9814 9948 7763 9026 57 73 9815 57 sky130_fd_sc_hd__a31oi_1
* cell instance $50786 r0 *1 72.68,432.48
X$50786 57 9816 9177 8468 9815 9623 8178 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $50789 r0 *1 77.28,432.48
X$50789 73 8467 7791 8469 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50793 r0 *1 86.94,432.48
X$50793 73 9817 9816 10041 9858 9810 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $50798 r0 *1 97.52,432.48
X$50798 73 8467 7756 9953 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50801 r0 *1 99.82,432.48
X$50801 73 9818 9265 7763 9954 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $50804 r0 *1 105.34,432.48
X$50804 73 9538 73 57 9863 57 sky130_fd_sc_hd__buf_4
* cell instance $50805 r0 *1 108.1,432.48
X$50805 73 9625 9862 8472 7756 9097 73 9818 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $50808 r0 *1 112.7,432.48
X$50808 73 8467 7647 9819 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50817 r0 *1 128.8,432.48
X$50817 73 9867 8873 9865 9868 57 9957 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $50819 r0 *1 132.48,432.48
X$50819 73 9026 8515 9956 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50830 r0 *1 158.7,432.48
X$50830 73 9905 7110 73 9729 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $50845 r0 *1 195.5,432.48
X$50845 73 9975 4302 9965 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50849 r0 *1 202.86,432.48
X$50849 57 9821 9823 9735 9966 9822 9825 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $50852 r0 *1 206.54,432.48
X$50852 73 9710 73 57 9821 57 sky130_fd_sc_hd__buf_4
* cell instance $50856 r0 *1 211.14,432.48
X$50856 57 9879 9823 9826 9795 10063 9968 73 73 57 sky130_fd_sc_hd__a32o_1
* cell instance $50858 r0 *1 216.66,432.48
X$50858 73 9710 73 57 9884 57 sky130_fd_sc_hd__buf_4
* cell instance $50861 r0 *1 221.72,432.48
X$50861 73 9827 9884 9885 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50863 r0 *1 223.56,432.48
X$50863 57 15619 9888 9742 9892 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $50864 r0 *1 228.16,432.48
X$50864 73 9828 9907 9743 9972 57 9971 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $50875 r0 *1 252.54,432.48
X$50875 73 9830 9829 9972 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50877 r0 *1 254.38,432.48
X$50877 73 9734 9883 9736 73 9973 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $50880 r0 *1 258.98,432.48
X$50880 73 9736 9738 9829 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50883 r0 *1 261.28,432.48
X$50883 73 4302 9735 9829 10082 9736 73 9890 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $50885 r0 *1 264.96,432.48
X$50885 73 4067 57 73 9917 57 sky130_fd_sc_hd__inv_2
* cell instance $50888 r0 *1 271.86,432.48
X$50888 73 9831 9736 9918 57 73 9911 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50889 r0 *1 273.7,432.48
X$50889 73 7337 9832 9918 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $50890 r0 *1 276.92,432.48
X$50890 73 9892 9742 7091 57 73 9831 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50893 r0 *1 286.12,432.48
X$50893 73 9802 73 57 9975 57 sky130_fd_sc_hd__buf_4
* cell instance $50926 r0 *1 363.4,432.48
X$50926 57 9977 9896 9898 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $50931 r0 *1 375.36,432.48
X$50931 73 9887 73 57 9897 57 sky130_fd_sc_hd__buf_4
* cell instance $50936 r0 *1 389.62,432.48
X$50936 73 9747 8313 9591 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50940 r0 *1 398.36,432.48
X$50940 57 9717 9806 8150 9117 10079 10078 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $50952 r0 *1 424.58,432.48
X$50952 73 9646 8970 8644 57 73 9834 57 sky130_fd_sc_hd__a21oi_1
* cell instance $50953 r0 *1 426.42,432.48
X$50953 73 9834 9893 9397 9891 9646 9491 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $50959 r0 *1 435.62,432.48
X$50959 73 8253 9889 9803 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50970 r0 *1 460,432.48
X$50970 73 9835 73 57 8592 57 sky130_fd_sc_hd__buf_4
* cell instance $50973 r0 *1 464.14,432.48
X$50973 73 9393 8601 9878 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $50974 r0 *1 465.52,432.48
X$50974 73 9878 73 57 9835 57 sky130_fd_sc_hd__buf_4
* cell instance $50982 r0 *1 482.54,432.48
X$50982 73 8926 9835 9837 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $50992 r0 *1 502.78,432.48
X$50992 73 9837 73 57 9875 57 sky130_fd_sc_hd__buf_4
* cell instance $50994 r0 *1 505.54,432.48
X$50994 57 8805 9873 9836 9963 9875 9872 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $51000 r0 *1 516.12,432.48
X$51000 73 8743 8761 9963 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51006 r0 *1 530.84,432.48
X$51006 57 8104 9754 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $51011 r0 *1 542.8,432.48
X$51011 57 15645 9838 9701 9756 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $51014 r0 *1 549.7,432.48
X$51014 57 9952 9838 9323 9408 9866 9161 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $51015 r0 *1 553.38,432.48
X$51015 57 9804 8104 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $51018 r0 *1 563.5,432.48
X$51018 57 15654 9929 9635 9756 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $51023 r0 *1 575,432.48
X$51023 73 9760 9840 9701 9839 57 73 9955 57 sky130_fd_sc_hd__a31oi_1
* cell instance $51024 r0 *1 577.3,432.48
X$51024 73 9769 9701 9839 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51028 r0 *1 584.66,432.48
X$51028 73 9506 73 57 9842 57 sky130_fd_sc_hd__buf_4
* cell instance $51032 r0 *1 590.18,432.48
X$51032 73 9840 9628 9320 10639 57 73 9931 57 sky130_fd_sc_hd__a31oi_1
* cell instance $51041 r0 *1 610.88,432.48
X$51041 73 9320 9536 10220 9942 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $51043 r0 *1 612.72,432.48
X$51043 73 9768 9852 9934 9325 73 9937 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $51047 r0 *1 623.76,432.48
X$51047 73 9673 9845 9771 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51063 m0 *1 10.12,437.92
X$51063 57 7608 9471 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $51081 m0 *1 48.3,437.92
X$51081 73 7791 8429 9901 9947 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51084 m0 *1 54.74,437.92
X$51084 73 10182 8203 7791 57 73 9946 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51089 m0 *1 60.26,437.92
X$51089 73 8997 7756 9730 9949 9948 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $51107 m0 *1 105.8,437.92
X$51107 73 7921 9863 9447 73 10243 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51110 m0 *1 109.94,437.92
X$51110 73 9819 73 57 9862 57 sky130_fd_sc_hd__buf_4
* cell instance $51113 m0 *1 114.08,437.92
X$51113 73 9902 73 57 9781 57 sky130_fd_sc_hd__buf_4
* cell instance $51115 m0 *1 117.3,437.92
X$51115 73 9786 8063 9902 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51122 m0 *1 131.56,437.92
X$51122 73 9625 8062 9788 8875 10047 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $51125 m0 *1 135.24,437.92
X$51125 73 8203 8063 9903 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $51126 m0 *1 137.54,437.92
X$51126 73 9959 73 57 9817 57 sky130_fd_sc_hd__buf_4
* cell instance $51129 m0 *1 144.44,437.92
X$51129 73 7483 7756 7758 9903 57 73 9960 57 sky130_fd_sc_hd__a31oi_1
* cell instance $51130 m0 *1 146.74,437.92
X$51130 73 9904 73 57 9871 57 sky130_fd_sc_hd__buf_4
* cell instance $51149 m0 *1 191.82,437.92
X$51149 73 9965 73 57 9964 57 sky130_fd_sc_hd__buf_4
* cell instance $51156 m0 *1 204.7,437.92
X$51156 73 9907 9906 9908 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51159 m0 *1 206.08,437.92
X$51159 73 9742 9909 9908 9877 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51164 m0 *1 217.58,437.92
X$51164 73 9914 9736 9907 73 9910 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51165 m0 *1 219.42,437.92
X$51165 73 9884 10068 9907 9888 9910 9969 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $51169 m0 *1 224.02,437.92
X$51169 73 9989 9888 9992 57 73 9970 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51172 m0 *1 230,437.92
X$51172 73 9738 9907 9913 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51173 m0 *1 231.38,437.92
X$51173 57 9736 9912 9913 9735 9906 9911 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $51178 m0 *1 238.74,437.92
X$51178 57 15518 10075 9736 9892 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $51184 m0 *1 255.3,437.92
X$51184 73 9738 9736 9916 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $51185 m0 *1 258.52,437.92
X$51185 73 9974 73 57 9915 57 sky130_fd_sc_hd__buf_4
* cell instance $51188 m0 *1 261.28,437.92
X$51188 73 9915 9916 9829 9892 9914 9978 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $51190 m0 *1 265.42,437.92
X$51190 73 9917 73 57 9736 57 sky130_fd_sc_hd__buf_4
* cell instance $51193 m0 *1 270.94,437.92
X$51193 57 9801 9976 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $51197 m0 *1 284.28,437.92
X$51197 57 7091 9989 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $51207 m0 *1 306.36,437.92
X$51207 73 9919 73 57 9734 57 sky130_fd_sc_hd__buf_4
* cell instance $51208 m0 *1 309.12,437.92
X$51208 73 9832 9915 9919 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51251 m0 *1 409.4,437.92
X$51251 73 8604 9646 8644 73 10071 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51265 m0 *1 434.7,437.92
X$51265 73 10296 8815 9646 9921 57 73 9889 57 sky130_fd_sc_hd__a31oi_1
* cell instance $51266 m0 *1 437,437.92
X$51266 73 9108 9646 9053 9921 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51279 m0 *1 460.46,437.92
X$51279 73 9922 73 57 8485 57 sky130_fd_sc_hd__buf_4
* cell instance $51281 m0 *1 464.14,437.92
X$51281 73 8483 8973 9597 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51291 m0 *1 483,437.92
X$51291 73 9837 73 57 10053 57 sky130_fd_sc_hd__buf_4
* cell instance $51294 m0 *1 491.28,437.92
X$51294 73 9967 73 57 10067 57 sky130_fd_sc_hd__buf_4
* cell instance $51295 m0 *1 494.04,437.92
X$51295 73 9923 73 57 9872 57 sky130_fd_sc_hd__buf_4
* cell instance $51307 m0 *1 517.04,437.92
X$51307 73 9962 73 57 8761 57 sky130_fd_sc_hd__buf_4
* cell instance $51322 m0 *1 545.1,437.92
X$51322 73 9756 9758 9864 9961 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51325 m0 *1 548.32,437.92
X$51325 73 9546 9758 9757 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51328 m0 *1 551.08,437.92
X$51328 73 9546 9320 9925 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51329 m0 *1 552.46,437.92
X$51329 73 9408 9501 9925 9924 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $51332 m0 *1 555.22,437.92
X$51332 73 9926 73 57 9958 57 sky130_fd_sc_hd__buf_4
* cell instance $51336 m0 *1 558.44,437.92
X$51336 73 9861 9958 9927 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $51337 m0 *1 560.74,437.92
X$51337 57 15483 9928 9635 9756 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $51338 m0 *1 565.34,437.92
X$51338 73 9928 73 57 9609 57 sky130_fd_sc_hd__buf_4
* cell instance $51340 m0 *1 569.02,437.92
X$51340 73 9927 73 57 9536 57 sky130_fd_sc_hd__buf_4
* cell instance $51341 m0 *1 571.78,437.92
X$51341 73 9929 73 57 9613 57 sky130_fd_sc_hd__buf_4
* cell instance $51344 m0 *1 580.06,437.92
X$51344 73 9952 9930 9951 57 73 9934 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51353 m0 *1 598,437.92
X$51353 73 9950 9930 9931 57 73 9932 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51356 m0 *1 602.6,437.92
X$51356 73 9409 9932 10036 73 9936 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51360 m0 *1 607.66,437.92
X$51360 73 9409 9933 9783 9935 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51363 m0 *1 610.88,437.92
X$51363 73 9935 9944 9936 9937 9943 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $51367 m0 *1 614.1,437.92
X$51367 73 9942 10234 9323 9686 9409 73 9852 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $51372 m0 *1 628.82,437.92
X$51372 73 9320 9692 10033 9941 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51381 m0 *1 641.7,437.92
X$51381 73 11248 5139 73 9938 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $51384 m0 *1 646.3,437.92
X$51384 57 10031 9521 9938 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $51391 r0 *1 5.06,437.92
X$51391 57 7704 9982 9471 10032 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $51396 r0 *1 19.32,437.92
X$51396 73 10139 73 57 4098 57 sky130_fd_sc_hd__buf_4
* cell instance $51403 r0 *1 40.94,437.92
X$51403 73 7760 73 57 10146 57 sky130_fd_sc_hd__buf_4
* cell instance $51413 r0 *1 63.94,437.92
X$51413 73 7756 8623 10038 9983 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $51416 r0 *1 68.54,437.92
X$51416 73 8997 7647 10038 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51422 r0 *1 73.6,437.92
X$51422 73 7921 8997 9658 7791 57 10593 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $51436 r0 *1 109.48,437.92
X$51436 57 7756 9904 9983 7761 9781 9725 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $51445 r0 *1 130.64,437.92
X$51445 73 7921 9183 9819 57 73 10048 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51446 r0 *1 132.48,437.92
X$51446 73 9731 10048 10047 9984 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51450 r0 *1 143.52,437.92
X$51450 57 9984 9959 8839 7763 10051 9960 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $51459 r0 *1 166.52,437.92
X$51459 73 10055 9303 9982 57 73 9378 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51463 r0 *1 174.34,437.92
X$51463 73 11615 9304 73 10158 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $51475 r0 *1 201.94,437.92
X$51475 73 9906 9907 9736 9987 57 9966 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $51479 r0 *1 207.46,437.92
X$51479 73 9742 10065 9987 9988 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51481 r0 *1 209.76,437.92
X$51481 57 9821 10063 9989 10064 9988 9969 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $51485 r0 *1 216.2,437.92
X$51485 73 9990 73 57 9907 57 sky130_fd_sc_hd__buf_4
* cell instance $51487 r0 *1 220.8,437.92
X$51487 73 9742 9991 10068 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51489 r0 *1 222.64,437.92
X$51489 73 9742 9992 9991 9970 73 57 10070 57 sky130_fd_sc_hd__o31ai_1
* cell instance $51490 r0 *1 225.4,437.92
X$51490 73 9892 9993 9991 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51493 r0 *1 229.54,437.92
X$51493 73 9735 10662 10070 9738 10073 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $51494 r0 *1 232.3,437.92
X$51494 73 9912 9986 10073 9994 73 10072 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $51497 r0 *1 235.52,437.92
X$51497 73 9989 9995 10167 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51500 r0 *1 237.82,437.92
X$51500 73 6834 73 57 9997 57 sky130_fd_sc_hd__buf_4
* cell instance $51501 r0 *1 240.58,437.92
X$51501 73 6834 73 57 10077 57 sky130_fd_sc_hd__inv_1
* cell instance $51502 r0 *1 241.96,437.92
X$51502 73 9996 10075 9735 57 73 10076 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51503 r0 *1 243.8,437.92
X$51503 73 4345 73 57 9993 57 sky130_fd_sc_hd__buf_4
* cell instance $51504 r0 *1 246.56,437.92
X$51504 73 9738 9995 9998 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51506 r0 *1 248.86,437.92
X$51506 73 9997 73 57 10091 57 sky130_fd_sc_hd__buf_4
* cell instance $51507 r0 *1 251.62,437.92
X$51507 73 9883 9914 9990 57 73 9995 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51509 r0 *1 257.14,437.92
X$51509 57 10081 10080 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $51516 r0 *1 275.08,437.92
X$51516 73 9801 9915 9742 73 10084 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51517 r0 *1 276.92,437.92
X$51517 73 10084 9738 9995 57 73 10083 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51520 r0 *1 281.52,437.92
X$51520 57 10086 9995 9832 9826 9742 10085 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $51521 r0 *1 284.74,437.92
X$51521 73 10085 73 57 9740 57 sky130_fd_sc_hd__buf_4
* cell instance $51527 r0 *1 293.48,437.92
X$51527 73 9740 9832 10000 57 73 10092 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51528 r0 *1 295.32,437.92
X$51528 73 10001 9740 9993 10000 73 10089 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $51529 r0 *1 298.08,437.92
X$51529 73 9976 10089 10002 73 10090 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51530 r0 *1 299.92,437.92
X$51530 73 10000 10003 10091 73 10002 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51533 r0 *1 306.36,437.92
X$51533 73 10004 9990 10003 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51536 r0 *1 310.04,437.92
X$51536 73 10001 10006 10088 10004 9825 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $51540 r0 *1 317.4,437.92
X$51540 73 9742 9915 10112 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51563 r0 *1 369.38,437.92
X$51563 73 9977 73 57 9920 57 sky130_fd_sc_hd__buf_4
* cell instance $51575 r0 *1 396.52,437.92
X$51575 57 10118 9808 10009 10010 10011 8313 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $51576 r0 *1 400.2,437.92
X$51576 73 9050 10067 10009 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51581 r0 *1 408.48,437.92
X$51581 73 10012 10071 8150 8557 57 73 10013 57 sky130_fd_sc_hd__a31oi_1
* cell instance $51584 r0 *1 412.16,437.92
X$51584 57 10074 10014 8557 9591 10013 9452 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $51585 r0 *1 415.38,437.92
X$51585 73 9923 73 57 8897 57 sky130_fd_sc_hd__buf_4
* cell instance $51593 r0 *1 434.24,437.92
X$51593 73 9050 9397 9893 10061 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $51595 r0 *1 437.92,437.92
X$51595 73 10016 8557 8644 73 10060 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51613 r0 *1 478.86,437.92
X$51613 57 10018 10056 10054 9445 10057 8409 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $51621 r0 *1 488.98,437.92
X$51621 73 9836 10126 9967 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51625 r0 *1 498.64,437.92
X$51625 57 9876 8687 10052 10018 9836 9638 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $51645 r0 *1 548.78,437.92
X$51645 73 10021 9838 9408 57 73 10049 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51646 r0 *1 550.62,437.92
X$51646 73 9408 10022 9925 57 73 10021 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51647 r0 *1 552.46,437.92
X$51647 73 9609 9864 10046 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51648 r0 *1 553.84,437.92
X$51648 73 9408 9925 10046 10044 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $51650 r0 *1 556.14,437.92
X$51650 73 10045 9609 9320 57 73 10263 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51651 r0 *1 557.98,437.92
X$51651 73 9861 9613 9864 57 73 10043 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51655 r0 *1 562.58,437.92
X$51655 73 9927 73 57 10040 57 sky130_fd_sc_hd__buf_4
* cell instance $51656 r0 *1 565.34,437.92
X$51656 73 9928 9861 10149 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51660 r0 *1 568.56,437.92
X$51660 57 9928 10039 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $51663 r0 *1 578.68,437.92
X$51663 73 10024 9769 9701 57 73 10025 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51664 r0 *1 580.52,437.92
X$51664 57 10025 9951 9761 10248 10024 9760 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $51665 r0 *1 583.74,437.92
X$51665 73 9675 9701 10024 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51669 r0 *1 587.42,437.92
X$51669 73 9320 9506 10147 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51677 r0 *1 598.92,437.92
X$51677 73 10026 10034 9320 73 9854 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51681 r0 *1 605.82,437.92
X$51681 73 9943 73 57 10035 57 sky130_fd_sc_hd__buf_4
* cell instance $51685 r0 *1 612.72,437.92
X$51685 73 9502 73 57 10029 57 sky130_fd_sc_hd__buf_4
* cell instance $51689 r0 *1 620.54,437.92
X$51689 73 10029 73 57 9769 57 sky130_fd_sc_hd__buf_4
* cell instance $51693 r0 *1 626.52,437.92
X$51693 57 57 10033 73 9673 9603 73 sky130_fd_sc_hd__nor2_2
* cell instance $51694 r0 *1 628.82,437.92
X$51694 73 10033 73 57 10034 57 sky130_fd_sc_hd__buf_4
* cell instance $51704 r0 *1 653.2,437.92
X$51704 73 10031 57 73 10135 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51707 m0 *1 2.76,443.36
X$51707 73 9979 57 73 10032 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51709 m0 *1 7.36,443.36
X$51709 57 7704 10141 9471 10136 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $51713 m0 *1 18.86,443.36
X$51713 57 10139 10141 10059 8663 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $51715 m0 *1 23.46,443.36
X$51715 73 9850 10095 10142 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51716 m0 *1 24.84,443.36
X$51716 73 9475 8663 10144 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51717 m0 *1 26.22,443.36
X$51717 73 9475 4428 10095 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51724 m0 *1 38.64,443.36
X$51724 73 9811 9980 7756 9981 57 73 10037 57 sky130_fd_sc_hd__a31oi_1
* cell instance $51727 m0 *1 42.32,443.36
X$51727 73 7756 10146 9981 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51731 m0 *1 44.62,443.36
X$51731 73 7962 7791 9980 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51734 m0 *1 50.14,443.36
X$51734 73 10096 73 57 9811 57 sky130_fd_sc_hd__buf_4
* cell instance $51737 m0 *1 55.66,443.36
X$51737 73 9293 7647 10096 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51744 m0 *1 66.7,443.36
X$51744 73 8125 73 57 8864 57 sky130_fd_sc_hd__buf_4
* cell instance $51756 m0 *1 88.78,443.36
X$51756 73 7921 8475 10152 10042 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51759 m0 *1 96.14,443.36
X$51759 73 7763 9175 10099 10100 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $51762 m0 *1 97.98,443.36
X$51762 73 10100 10154 9954 57 73 10041 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51766 m0 *1 110.86,443.36
X$51766 73 7756 9819 9224 10244 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $51774 m0 *1 126.04,443.36
X$51774 73 8347 8872 7921 10361 57 73 9867 57 sky130_fd_sc_hd__a31oi_1
* cell instance $51781 m0 *1 141.22,443.36
X$51781 73 9985 9902 7921 73 10156 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51782 m0 *1 143.06,443.36
X$51782 57 10051 10156 8178 8475 10101 8878 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $51785 m0 *1 150.42,443.36
X$51785 73 9985 8875 7483 57 73 8877 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51796 m0 *1 171.12,443.36
X$51796 57 10058 10553 10158 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $51807 m0 *1 197.8,443.36
X$51807 73 9743 4302 9986 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51810 m0 *1 203.78,443.36
X$51810 73 9915 73 57 9992 57 sky130_fd_sc_hd__buf_4
* cell instance $51814 m0 *1 208.38,443.36
X$51814 73 9735 9734 10103 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51816 m0 *1 210.22,443.36
X$51816 73 10103 10167 9738 9742 10161 73 10160 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $51820 m0 *1 218.5,443.36
X$51820 73 9736 9710 10163 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51822 m0 *1 220.34,443.36
X$51822 73 10163 9883 9991 73 10164 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51828 m0 *1 228.62,443.36
X$51828 73 9993 9907 10102 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51835 m0 *1 241.5,443.36
X$51835 73 4345 73 57 10106 57 sky130_fd_sc_hd__inv_1
* cell instance $51836 m0 *1 242.88,443.36
X$51836 73 10106 73 57 10168 57 sky130_fd_sc_hd__buf_4
* cell instance $51837 m0 *1 245.64,443.36
X$51837 57 15545 10107 10168 9997 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $51841 m0 *1 252.08,443.36
X$51841 73 10107 73 57 9830 57 sky130_fd_sc_hd__inv_1
* cell instance $51845 m0 *1 258.52,443.36
X$51845 73 9914 10080 10082 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51850 m0 *1 264.5,443.36
X$51850 73 10080 73 57 9990 57 sky130_fd_sc_hd__buf_4
* cell instance $51851 m0 *1 267.26,443.36
X$51851 73 9917 9990 10108 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51853 m0 *1 269.1,443.36
X$51853 57 9917 10111 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $51857 m0 *1 279.22,443.36
X$51857 73 10171 73 57 9996 57 sky130_fd_sc_hd__buf_4
* cell instance $51860 m0 *1 284.74,443.36
X$51860 73 9742 9990 10085 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51864 m0 *1 287.04,443.36
X$51864 73 10090 9832 9999 57 73 10173 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51865 m0 *1 288.88,443.36
X$51865 73 10174 10091 9996 57 73 9999 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51873 m0 *1 306.82,443.36
X$51873 73 10111 9990 10006 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $51875 m0 *1 310.04,443.36
X$51875 73 10091 10005 9915 73 10088 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $51876 m0 *1 311.88,443.36
X$51876 73 9993 10111 10005 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51880 m0 *1 315.1,443.36
X$51880 73 10112 73 57 10110 57 sky130_fd_sc_hd__buf_4
* cell instance $51881 m0 *1 317.86,443.36
X$51881 73 10110 9892 9976 10005 57 10087 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $51884 m0 *1 322.92,443.36
X$51884 73 10175 10087 10113 9978 10172 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $51888 m0 *1 328.9,443.36
X$51888 73 10114 9475 10007 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $51890 m0 *1 331.66,443.36
X$51890 73 9475 10114 10008 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51893 m0 *1 333.96,443.36
X$51893 57 10289 10007 10008 8506 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $51902 m0 *1 351.9,443.36
X$51902 57 7905 9896 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $51909 m0 *1 370.76,443.36
X$51909 73 10115 73 57 8106 57 sky130_fd_sc_hd__buf_4
* cell instance $51910 m0 *1 373.52,443.36
X$51910 57 10115 10116 10117 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $51913 m0 *1 383.18,443.36
X$51913 57 8410 10117 10157 9807 10118 10166 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $51919 m0 *1 390.54,443.36
X$51919 73 8647 9574 10169 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $51925 m0 *1 396.98,443.36
X$51925 73 10165 9050 8735 8150 57 73 10079 57 sky130_fd_sc_hd__a31oi_1
* cell instance $51930 m0 *1 406.18,443.36
X$51930 73 10119 10120 8647 8897 73 10078 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $51931 m0 *1 409.4,443.36
X$51931 73 9646 10165 9748 57 73 10119 57 sky130_fd_sc_hd__a21oi_1
* cell instance $51933 m0 *1 413.08,443.36
X$51933 73 8408 10062 10121 73 57 10166 57 sky130_fd_sc_hd__o21bai_1
* cell instance $51937 m0 *1 417.68,443.36
X$51937 73 10015 9454 8557 10069 57 10121 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $51940 m0 *1 421.36,443.36
X$51940 73 9646 10067 9402 10066 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $51943 m0 *1 423.2,443.36
X$51943 73 8253 10162 10066 10014 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $51949 m0 *1 437.46,443.36
X$51949 73 10017 10061 10159 8312 9146 73 10062 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $51960 m0 *1 451.26,443.36
X$51960 73 8973 8923 8809 10017 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $51972 m0 *1 478.4,443.36
X$51972 73 10056 73 57 10157 57 sky130_fd_sc_hd__buf_4
* cell instance $51985 m0 *1 505.08,443.36
X$51985 57 10050 9176 10155 10067 9091 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $51989 m0 *1 513.82,443.36
X$51989 73 10127 7278 73 10019 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $52001 m0 *1 535.9,443.36
X$52001 57 10265 9754 10019 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $52003 m0 *1 545.1,443.36
X$52003 73 9323 10049 10020 73 10998 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52004 m0 *1 546.94,443.36
X$52004 57 9408 10020 9323 10128 9961 9549 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $52006 m0 *1 551.08,443.36
X$52006 73 10045 73 57 10128 57 sky130_fd_sc_hd__buf_4
* cell instance $52010 m0 *1 555.68,443.36
X$52010 73 9958 9320 10045 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52011 m0 *1 557.06,443.36
X$52011 73 9958 9864 9501 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52014 m0 *1 558.44,443.36
X$52014 73 9958 9861 10153 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52018 m0 *1 563.04,443.36
X$52018 73 10149 9861 9502 73 10255 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $52019 m0 *1 565.8,443.36
X$52019 73 10149 73 57 10150 57 sky130_fd_sc_hd__buf_4
* cell instance $52031 m0 *1 590.18,443.36
X$52031 73 10147 73 57 9514 57 sky130_fd_sc_hd__buf_4
* cell instance $52035 m0 *1 601.22,443.36
X$52035 73 9701 10026 10034 10027 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $52036 m0 *1 603.52,443.36
X$52036 57 10036 10027 10434 9246 10218 9409 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $52045 m0 *1 619.16,443.36
X$52045 73 10138 10140 9851 9693 10028 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $52047 m0 *1 625.14,443.36
X$52047 73 9161 9244 10137 57 73 10138 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52063 r0 *1 4.14,443.36
X$52063 73 10094 57 73 10136 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52064 r0 *1 7.82,443.36
X$52064 73 10442 57 73 9900 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52065 r0 *1 11.5,443.36
X$52065 73 10177 10304 10226 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $52074 r0 *1 23.46,443.36
X$52074 73 10142 9850 10144 57 73 10230 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52082 r0 *1 44.16,443.36
X$52082 73 7962 8872 10232 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52083 r0 *1 45.54,443.36
X$52083 73 9981 73 57 10181 57 sky130_fd_sc_hd__buf_4
* cell instance $52088 r0 *1 61.18,443.36
X$52088 73 7756 8717 9085 9949 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $52090 r0 *1 64.86,443.36
X$52090 73 7756 8347 10096 57 73 10097 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52097 r0 *1 74.52,443.36
X$52097 73 8241 10354 10183 9780 7763 73 10459 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $52100 r0 *1 85.1,443.36
X$52100 57 8468 10183 9730 10242 10098 10241 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $52101 r0 *1 88.32,443.36
X$52101 57 8100 10242 7756 8475 10097 10152 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $52109 r0 *1 110.4,443.36
X$52109 73 8472 8256 10184 10098 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52111 r0 *1 114.08,443.36
X$52111 73 8431 7647 10186 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52112 r0 *1 115.46,443.36
X$52112 73 8874 8203 7483 57 73 10152 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52113 r0 *1 117.3,443.36
X$52113 73 9786 7483 8509 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52121 r0 *1 129.72,443.36
X$52121 73 8874 73 57 10246 57 sky130_fd_sc_hd__buf_4
* cell instance $52122 r0 *1 132.48,443.36
X$52122 73 10246 10245 8472 73 10154 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52129 r0 *1 148.58,443.36
X$52129 73 10247 73 57 9005 57 sky130_fd_sc_hd__buf_4
* cell instance $52131 r0 *1 151.34,443.36
X$52131 73 8125 7483 9985 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52137 r0 *1 161.92,443.36
X$52137 73 10058 57 73 10093 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52150 r0 *1 194.12,443.36
X$52150 73 9743 4302 10311 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52153 r0 *1 200.1,443.36
X$52153 73 9906 9915 9736 9909 57 10469 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $52160 r0 *1 210.22,443.36
X$52160 73 10102 9989 9742 10257 57 10161 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $52163 r0 *1 218.5,443.36
X$52163 73 10163 73 57 10192 57 sky130_fd_sc_hd__buf_4
* cell instance $52164 r0 *1 221.26,443.36
X$52164 73 10104 9827 9738 57 73 10105 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52165 r0 *1 223.1,443.36
X$52165 73 10164 73 57 10262 57 sky130_fd_sc_hd__buf_4
* cell instance $52166 r0 *1 225.86,443.36
X$52166 73 9738 9892 9993 57 73 10104 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52168 r0 *1 229.54,443.36
X$52168 73 9735 10193 10264 10076 73 57 9994 57 sky130_fd_sc_hd__o31ai_1
* cell instance $52174 r0 *1 241.04,443.36
X$52174 57 15616 10269 10106 10077 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $52176 r0 *1 247.48,443.36
X$52176 73 10168 73 57 9832 57 sky130_fd_sc_hd__buf_4
* cell instance $52178 r0 *1 252.08,443.36
X$52178 73 10107 73 57 10272 57 sky130_fd_sc_hd__buf_4
* cell instance $52181 r0 *1 257.6,443.36
X$52181 73 9883 73 57 10273 57 sky130_fd_sc_hd__buf_4
* cell instance $52189 r0 *1 276,443.36
X$52189 73 9993 10171 9735 9743 10277 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $52191 r0 *1 279.22,443.36
X$52191 73 10195 9990 10171 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52193 r0 *1 281.06,443.36
X$52193 73 9710 73 57 10195 57 sky130_fd_sc_hd__buf_4
* cell instance $52195 r0 *1 284.28,443.36
X$52195 73 7091 10195 10883 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52197 r0 *1 286.58,443.36
X$52197 73 10108 10195 10091 10281 57 10174 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $52203 r0 *1 296.24,443.36
X$52203 73 9890 9892 10197 57 73 10283 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52206 r0 *1 303.6,443.36
X$52206 73 9832 9976 10198 10109 73 57 10197 57 sky130_fd_sc_hd__o31ai_1
* cell instance $52208 r0 *1 306.82,443.36
X$52208 73 10110 10003 9832 73 10109 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52210 r0 *1 310.5,443.36
X$52210 73 10006 73 57 10320 57 sky130_fd_sc_hd__buf_4
* cell instance $52213 r0 *1 314.18,443.36
X$52213 73 10112 73 57 10286 57 sky130_fd_sc_hd__buf_4
* cell instance $52214 r0 *1 316.94,443.36
X$52214 73 10195 73 57 10004 57 sky130_fd_sc_hd__buf_4
* cell instance $52218 r0 *1 324.3,443.36
X$52218 73 10172 73 57 10287 57 sky130_fd_sc_hd__buf_4
* cell instance $52221 r0 *1 328.44,443.36
X$52221 73 10289 73 57 10288 57 sky130_fd_sc_hd__buf_4
* cell instance $52232 r0 *1 351.9,443.36
X$52232 57 9896 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $52237 r0 *1 369.38,443.36
X$52237 73 9977 10115 10295 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $52243 r0 *1 377.66,443.36
X$52243 57 10170 10223 10514 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $52246 r0 *1 384.1,443.36
X$52246 57 10116 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $52263 r0 *1 434.24,443.36
X$52263 73 10202 9053 9891 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52266 r0 *1 437.92,443.36
X$52266 73 10016 73 57 10202 57 sky130_fd_sc_hd__buf_4
* cell instance $52267 r0 *1 440.68,443.36
X$52267 73 10202 9646 9053 10122 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52268 r0 *1 442.52,443.36
X$52268 73 10122 10123 9150 57 73 10294 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52269 r0 *1 444.36,443.36
X$52269 73 10202 9646 10124 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52272 r0 *1 447.12,443.36
X$52272 57 15585 10123 8560 8968 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $52274 r0 *1 451.72,443.36
X$52274 73 10123 9150 8314 73 10290 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52281 r0 *1 464.6,443.36
X$52281 73 9597 10330 10015 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52284 r0 *1 468.74,443.36
X$52284 73 10125 10126 10204 73 57 9922 57 sky130_fd_sc_hd__o21bai_1
* cell instance $52286 r0 *1 472.42,443.36
X$52286 73 10124 9714 10206 57 73 10204 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52294 r0 *1 488.52,443.36
X$52294 73 9181 73 57 10279 57 sky130_fd_sc_hd__buf_4
* cell instance $52298 r0 *1 496.34,443.36
X$52298 73 9792 73 57 10125 57 sky130_fd_sc_hd__buf_4
* cell instance $52299 r0 *1 499.1,443.36
X$52299 73 8968 10206 10155 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52300 r0 *1 500.48,443.36
X$52300 73 8253 8315 9752 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52303 r0 *1 503.24,443.36
X$52303 73 9638 10270 10207 10018 73 57 9792 57 sky130_fd_sc_hd__o31ai_1
* cell instance $52311 r0 *1 513.82,443.36
X$52311 57 9962 10268 10336 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $52324 r0 *1 548.78,443.36
X$52324 73 10265 57 73 10133 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52327 r0 *1 553.84,443.36
X$52327 57 10252 9161 10023 10210 10261 9323 73 73 57 sky130_fd_sc_hd__o2111a_1
* cell instance $52328 r0 *1 557.98,443.36
X$52328 73 9406 10151 10044 57 73 10260 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52330 r0 *1 559.82,443.36
X$52330 73 10259 9861 10151 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52333 r0 *1 562.58,443.36
X$52333 73 9701 10255 10211 73 10254 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52336 r0 *1 566.72,443.36
X$52336 73 9860 10150 10130 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52339 r0 *1 569.48,443.36
X$52339 73 9703 9707 9701 73 57 10148 57 sky130_fd_sc_hd__o21ai_1
* cell instance $52340 r0 *1 571.32,443.36
X$52340 57 10250 10148 9406 9955 10249 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $52343 r0 *1 576.84,443.36
X$52343 73 9161 10129 10249 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52346 r0 *1 579.6,443.36
X$52346 73 9630 73 57 10213 57 sky130_fd_sc_hd__buf_4
* cell instance $52348 r0 *1 582.82,443.36
X$52348 73 9320 10213 10215 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52349 r0 *1 584.2,443.36
X$52349 73 10214 73 57 10129 57 sky130_fd_sc_hd__buf_4
* cell instance $52351 r0 *1 586.96,443.36
X$52351 57 10131 9701 9604 10215 10130 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $52353 r0 *1 590.64,443.36
X$52353 73 9535 73 57 10132 57 sky130_fd_sc_hd__buf_4
* cell instance $52355 r0 *1 594.32,443.36
X$52355 73 9767 9514 10211 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52358 r0 *1 596.62,443.36
X$52358 73 9406 9323 10131 57 73 10217 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52360 r0 *1 600.3,443.36
X$52360 73 9325 10237 10217 9427 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52361 r0 *1 602.14,443.36
X$52361 73 10219 73 57 9604 57 sky130_fd_sc_hd__buf_4
* cell instance $52366 r0 *1 611.8,443.36
X$52366 73 10132 9842 10220 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52368 r0 *1 613.18,443.36
X$52368 73 9701 10143 10145 10234 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $52369 r0 *1 615.02,443.36
X$52369 73 9767 9842 10143 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52376 r0 *1 624.22,443.36
X$52376 73 9771 9841 10231 10132 10222 10137 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $52383 r0 *1 639.86,443.36
X$52383 57 6998 10223 9521 10134 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $52387 r0 *1 656.88,443.36
X$52387 73 10030 57 73 10134 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52436 m0 *1 2.3,448.8
X$52436 57 10177 9471 10225 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $52437 m0 *1 9.66,448.8
X$52437 73 10178 7704 10179 10225 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $52438 m0 *1 12.42,448.8
X$52438 57 10178 10177 10226 10180 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $52440 m0 *1 16.56,448.8
X$52440 73 10179 10347 10227 57 73 10348 57 sky130_fd_sc_hd__a21boi_0
* cell instance $52441 m0 *1 19.32,448.8
X$52441 73 10228 10394 10180 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52450 m0 *1 45.08,448.8
X$52450 73 10232 9945 8839 73 10240 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52454 m0 *1 54.74,448.8
X$52454 73 7921 10305 10182 10235 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52473 m0 *1 105.8,448.8
X$52473 73 10543 8475 10243 57 73 10099 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52477 m0 *1 110.86,448.8
X$52477 73 8178 10185 10244 57 73 10184 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52481 m0 *1 114.54,448.8
X$52481 73 10186 8789 7921 10185 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $52488 m0 *1 134.32,448.8
X$52488 73 7921 8723 7483 57 73 10245 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52494 m0 *1 144.9,448.8
X$52494 57 7756 10247 8100 7761 9902 10364 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $52495 m0 *1 148.12,448.8
X$52495 57 5047 8788 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $52512 m0 *1 195.96,448.8
X$52512 73 9989 10187 10188 10251 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52514 m0 *1 198.72,448.8
X$52514 73 10371 9742 9906 57 73 10188 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52515 m0 *1 200.56,448.8
X$52515 73 10102 9909 9736 73 10253 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52517 m0 *1 204.24,448.8
X$52517 73 10189 73 57 9909 57 sky130_fd_sc_hd__buf_4
* cell instance $52518 m0 *1 207,448.8
X$52518 73 9914 9915 10189 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52521 m0 *1 212.98,448.8
X$52521 73 10187 73 57 10191 57 sky130_fd_sc_hd__buf_4
* cell instance $52523 m0 *1 219.42,448.8
X$52523 73 10192 10190 10105 9736 10316 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $52529 m0 *1 224.94,448.8
X$52529 73 9992 10193 10264 9738 73 57 10187 57 sky130_fd_sc_hd__o31ai_1
* cell instance $52531 m0 *1 228.62,448.8
X$52531 73 10266 9993 9736 10264 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52533 m0 *1 232.3,448.8
X$52533 73 10194 9736 10193 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $52534 m0 *1 234.6,448.8
X$52534 73 10375 73 57 9906 57 sky130_fd_sc_hd__buf_4
* cell instance $52537 m0 *1 241.5,448.8
X$52537 57 15470 10194 9832 9997 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $52543 m0 *1 255.76,448.8
X$52543 73 9990 9830 9742 10271 57 10379 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $52549 m0 *1 275.08,448.8
X$52549 73 10276 9736 10277 10083 57 10278 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $52553 m0 *1 280.6,448.8
X$52553 73 10485 73 57 10281 57 sky130_fd_sc_hd__buf_4
* cell instance $52559 m0 *1 293.94,448.8
X$52559 73 10282 9989 9743 10283 57 10196 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $52560 m0 *1 296.7,448.8
X$52560 73 10199 10386 10092 10091 10282 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $52567 m0 *1 306.82,448.8
X$52567 73 9734 9892 10004 10285 57 10199 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $52571 m0 *1 312.8,448.8
X$52571 73 9742 9915 10198 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52594 m0 *1 374.9,448.8
X$52594 73 10391 73 57 10267 57 sky130_fd_sc_hd__buf_4
* cell instance $52598 m0 *1 380.88,448.8
X$52598 57 10392 10116 10035 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $52601 m0 *1 389.16,448.8
X$52601 73 9747 8312 9235 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52606 m0 *1 400.66,448.8
X$52606 73 10300 10200 8150 73 10011 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52609 m0 *1 404.8,448.8
X$52609 73 10299 8483 10301 8557 10200 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $52610 m0 *1 407.1,448.8
X$52610 73 10120 8735 8897 57 73 10301 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52611 m0 *1 408.94,448.8
X$52611 73 10201 10268 9391 57 73 10299 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52612 m0 *1 410.78,448.8
X$52612 73 9570 73 57 10201 57 sky130_fd_sc_hd__buf_4
* cell instance $52618 m0 *1 422.28,448.8
X$52618 73 8970 9053 10296 73 10298 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52621 m0 *1 428.26,448.8
X$52621 73 9107 73 57 10297 57 sky130_fd_sc_hd__buf_4
* cell instance $52629 m0 *1 449.88,448.8
X$52629 73 9150 10293 10292 10290 57 73 10159 57 sky130_fd_sc_hd__a31oi_1
* cell instance $52632 m0 *1 456.78,448.8
X$52632 73 10382 73 57 8736 57 sky130_fd_sc_hd__buf_4
* cell instance $52636 m0 *1 465.98,448.8
X$52636 73 10203 73 57 9051 57 sky130_fd_sc_hd__buf_4
* cell instance $52643 m0 *1 483,448.8
X$52643 73 8562 10201 9402 8809 8973 10284 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $52644 m0 *1 486.22,448.8
X$52644 73 10482 73 57 8743 57 sky130_fd_sc_hd__buf_4
* cell instance $52645 m0 *1 488.98,448.8
X$52645 73 8315 10275 10279 10280 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52646 m0 *1 490.82,448.8
X$52646 73 8972 73 57 10205 57 sky130_fd_sc_hd__buf_4
* cell instance $52647 m0 *1 493.58,448.8
X$52647 73 10206 10205 10481 10275 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52649 m0 *1 497.26,448.8
X$52649 73 10205 10155 9836 73 10274 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52655 m0 *1 509.22,448.8
X$52655 57 10208 7667 10203 73 73 57 sky130_fd_sc_hd__xnor2_4
* cell instance $52656 m0 *1 519.34,448.8
X$52656 57 10208 10209 10267 2235 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $52670 m0 *1 555.68,448.8
X$52670 73 9861 10263 10258 73 10261 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52673 m0 *1 558.9,448.8
X$52673 73 10256 9861 10258 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52675 m0 *1 560.74,448.8
X$52675 57 10259 10362 9320 9529 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $52680 m0 *1 576.84,448.8
X$52680 73 9412 9257 10212 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52682 m0 *1 579.14,448.8
X$52682 73 10212 73 57 10210 57 sky130_fd_sc_hd__buf_4
* cell instance $52685 m0 *1 583.28,448.8
X$52685 73 9414 9603 10214 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52686 m0 *1 584.66,448.8
X$52686 57 10216 9673 10551 10214 9320 10147 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $52687 m0 *1 588.34,448.8
X$52687 73 9529 9673 9603 73 10216 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52689 m0 *1 591.1,448.8
X$52689 73 10216 73 57 10145 57 sky130_fd_sc_hd__buf_4
* cell instance $52693 m0 *1 598.92,448.8
X$52693 73 9162 73 57 10218 57 sky130_fd_sc_hd__buf_4
* cell instance $52694 m0 *1 601.68,448.8
X$52694 73 9529 9675 9678 10219 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52700 m0 *1 611.8,448.8
X$52700 73 10239 9701 9323 10238 57 10236 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $52701 m0 *1 614.56,448.8
X$52701 73 9161 10233 10236 10237 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52703 m0 *1 617.32,448.8
X$52703 57 9944 10830 10350 9412 9409 10221 73 73 57 sky130_fd_sc_hd__a41o_1
* cell instance $52708 m0 *1 630.66,448.8
X$52708 73 9941 10229 9930 73 10221 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52721 r0 *1 4.6,448.8
X$52721 57 10304 10303 10345 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $52722 r0 *1 11.96,448.8
X$52722 73 10179 10346 7704 73 10345 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $52727 r0 *1 16.56,448.8
X$52727 57 10228 10303 10348 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $52737 r0 *1 44.16,448.8
X$52737 73 7876 7647 8178 73 10351 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52743 r0 *1 59.8,448.8
X$52743 73 10305 10182 7921 73 10306 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52744 r0 *1 61.64,448.8
X$52744 73 10306 9949 10353 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52748 r0 *1 68.08,448.8
X$52748 73 10038 9625 9731 7921 9901 73 10457 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $52752 r0 *1 73.6,448.8
X$52752 73 8864 7647 10182 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $52758 r0 *1 91.54,448.8
X$52758 73 10307 9725 10357 10354 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $52763 r0 *1 99.36,448.8
X$52763 73 10185 73 57 10307 57 sky130_fd_sc_hd__buf_4
* cell instance $52768 r0 *1 114.08,448.8
X$52768 73 10305 8509 7756 73 10359 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52779 r0 *1 130.18,448.8
X$52779 73 8468 7763 9957 10360 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52783 r0 *1 139.84,448.8
X$52783 73 10101 73 57 10463 57 sky130_fd_sc_hd__buf_4
* cell instance $52786 r0 *1 145.36,448.8
X$52786 73 10309 10246 7756 73 10364 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52789 r0 *1 149.5,448.8
X$52789 73 8125 7483 10309 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $52808 r0 *1 193.2,448.8
X$52808 73 10311 10310 10369 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52810 r0 *1 196.42,448.8
X$52810 73 10251 10370 10160 10310 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52813 r0 *1 201.02,448.8
X$52813 73 10313 9742 9992 73 10371 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $52818 r0 *1 206.08,448.8
X$52818 73 10190 9990 10312 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52819 r0 *1 207.46,448.8
X$52819 73 9742 10189 10312 10315 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52822 r0 *1 210.68,448.8
X$52822 73 10272 73 57 10313 57 sky130_fd_sc_hd__buf_4
* cell instance $52824 r0 *1 214.36,448.8
X$52824 73 10323 9992 10314 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52827 r0 *1 221.26,448.8
X$52827 57 9743 10373 9989 9992 10316 4624 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $52838 r0 *1 242.42,448.8
X$52838 73 10077 73 57 10377 57 sky130_fd_sc_hd__buf_4
* cell instance $52839 r0 *1 245.18,448.8
X$52839 73 10377 73 57 9892 57 sky130_fd_sc_hd__buf_4
* cell instance $52840 r0 *1 247.94,448.8
X$52840 57 9997 10266 73 73 57 sky130_fd_sc_hd__buf_6
* cell instance $52843 r0 *1 254.38,448.8
X$52843 73 10198 10375 9973 10318 10380 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $52844 r0 *1 257.14,448.8
X$52844 73 10194 73 57 10190 57 sky130_fd_sc_hd__buf_4
* cell instance $52848 r0 *1 261.28,448.8
X$52848 73 10381 10318 10379 9742 9738 73 10384 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $52852 r0 *1 272.32,448.8
X$52852 73 10194 9915 10319 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52856 r0 *1 276.92,448.8
X$52856 73 10278 73 57 11629 57 sky130_fd_sc_hd__buf_4
* cell instance $52861 r0 *1 287.5,448.8
X$52861 73 10194 73 57 10001 57 sky130_fd_sc_hd__buf_4
* cell instance $52866 r0 *1 293.94,448.8
X$52866 73 10108 9993 9976 10579 57 10386 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $52871 r0 *1 303.6,448.8
X$52871 73 9734 10111 10102 57 73 10388 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52875 r0 *1 308.66,448.8
X$52875 73 9892 10320 10321 57 73 10285 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52898 r0 *1 368,448.8
X$52898 73 8051 10392 73 10389 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $52901 r0 *1 371.68,448.8
X$52901 73 10389 10390 10391 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $52907 r0 *1 384.1,448.8
X$52907 57 7905 10116 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $52916 r0 *1 408.94,448.8
X$52916 73 8736 73 57 10387 57 sky130_fd_sc_hd__buf_4
* cell instance $52928 r0 *1 437.46,448.8
X$52928 73 10328 73 57 10296 57 sky130_fd_sc_hd__buf_4
* cell instance $52932 r0 *1 446.2,448.8
X$52932 73 9646 8815 10296 57 73 10329 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52940 r0 *1 458.62,448.8
X$52940 73 10331 8975 10382 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52944 r0 *1 466.44,448.8
X$52944 73 10203 73 57 10331 57 sky130_fd_sc_hd__buf_4
* cell instance $52946 r0 *1 470.12,448.8
X$52946 57 10376 10378 10125 10329 10374 10018 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $52947 r0 *1 473.34,448.8
X$52947 73 10331 73 57 10206 57 sky130_fd_sc_hd__buf_4
* cell instance $52950 r0 *1 477.02,448.8
X$52950 73 10124 73 57 10333 57 sky130_fd_sc_hd__buf_4
* cell instance $52951 r0 *1 479.78,448.8
X$52951 73 10372 9794 9713 9797 73 10334 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $52959 r0 *1 497.72,448.8
X$52959 73 10018 10274 10334 57 73 10480 57 sky130_fd_sc_hd__a21oi_1
* cell instance $52960 r0 *1 499.56,448.8
X$52960 73 8562 10206 10207 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52964 r0 *1 506.46,448.8
X$52964 73 9836 8973 10335 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $52965 r0 *1 507.84,448.8
X$52965 73 10126 10473 9091 10368 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $52966 r0 *1 509.68,448.8
X$52966 73 10335 73 57 9091 57 sky130_fd_sc_hd__buf_4
* cell instance $52969 r0 *1 513.36,448.8
X$52969 73 10203 57 73 10367 57 sky130_fd_sc_hd__inv_2
* cell instance $52971 r0 *1 515.2,448.8
X$52971 57 10367 9393 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $52985 r0 *1 549.7,448.8
X$52985 73 10427 9757 9779 73 10470 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $52988 r0 *1 554.76,448.8
X$52988 73 9529 9673 10022 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $52991 r0 *1 557.52,448.8
X$52991 73 10254 73 57 10363 57 sky130_fd_sc_hd__buf_4
* cell instance $52993 r0 *1 560.28,448.8
X$52993 57 15579 10256 9701 9529 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $52994 r0 *1 564.88,448.8
X$52994 57 10362 10762 10338 10256 9861 10148 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $52998 r0 *1 574.08,448.8
X$52998 73 9257 73 57 10338 57 sky130_fd_sc_hd__buf_4
* cell instance $53000 r0 *1 578.68,448.8
X$53000 57 57 9603 10339 9675 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $53002 r0 *1 581.44,448.8
X$53002 73 10339 73 57 9676 57 sky130_fd_sc_hd__buf_4
* cell instance $53007 r0 *1 590.18,448.8
X$53007 73 9535 9678 10356 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53012 r0 *1 597.08,448.8
X$53012 73 9606 9675 9779 57 73 10355 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53014 r0 *1 600.76,448.8
X$53014 73 10219 73 57 10340 57 sky130_fd_sc_hd__buf_4
* cell instance $53019 r0 *1 612.72,448.8
X$53019 73 9701 10340 10129 10238 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53021 r0 *1 615.02,448.8
X$53021 73 9701 9606 10341 10342 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53022 r0 *1 616.86,448.8
X$53022 73 10342 10349 10451 73 10350 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53027 r0 *1 624.22,448.8
X$53027 73 9320 10129 10343 10349 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53028 r0 *1 626.06,448.8
X$53028 73 10222 9842 10343 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53031 r0 *1 628.82,448.8
X$53031 73 10343 73 57 10344 57 sky130_fd_sc_hd__buf_4
* cell instance $53032 r0 *1 631.58,448.8
X$53032 73 9701 10129 10344 10229 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53093 m0 *1 4.14,454.24
X$53093 73 10440 57 73 10302 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53095 m0 *1 8.28,454.24
X$53095 73 10176 57 73 10447 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53096 m0 *1 11.96,454.24
X$53096 57 10346 10228 10394 10177 10304 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $53098 m0 *1 16.1,454.24
X$53098 73 10304 10177 10180 73 10227 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53099 m0 *1 17.94,454.24
X$53099 73 7704 10228 10394 57 73 10347 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53109 m0 *1 39.1,454.24
X$53109 73 8468 7763 8760 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $53111 m0 *1 45.08,454.24
X$53111 73 8027 10351 10452 8178 9947 10352 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $53119 m0 *1 61.18,454.24
X$53119 73 10240 10353 10397 73 10455 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $53122 m0 *1 68.08,454.24
X$53122 73 8468 7763 10457 10458 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53125 m0 *1 74.06,454.24
X$53125 73 9731 73 57 10397 57 sky130_fd_sc_hd__buf_4
* cell instance $53136 m0 *1 103.04,454.24
X$53136 73 9296 7647 10305 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53138 m0 *1 106.26,454.24
X$53138 73 7756 9699 9224 10357 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $53144 m0 *1 114.54,454.24
X$53144 73 10186 73 57 10308 57 sky130_fd_sc_hd__buf_4
* cell instance $53146 m0 *1 120.98,454.24
X$53146 57 8839 10546 8999 10359 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $53149 m0 *1 127.42,454.24
X$53149 73 10401 73 57 8999 57 sky130_fd_sc_hd__buf_4
* cell instance $53150 m0 *1 130.18,454.24
X$53150 73 10308 10246 7921 73 10401 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53152 m0 *1 132.48,454.24
X$53152 73 8723 7483 10402 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53153 m0 *1 133.86,454.24
X$53153 73 7921 10403 10402 10361 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53154 m0 *1 135.7,454.24
X$53154 57 7756 10403 10246 10453 10463 73 73 57 sky130_fd_sc_hd__o31ai_2
* cell instance $53159 m0 *1 145.82,454.24
X$53159 73 10309 73 57 10403 57 sky130_fd_sc_hd__buf_4
* cell instance $53169 m0 *1 171.12,454.24
X$53169 73 4428 73 57 9303 57 sky130_fd_sc_hd__buf_4
* cell instance $53175 m0 *1 186.3,454.24
X$53175 73 10467 10469 10477 73 10468 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53185 m0 *1 214.82,454.24
X$53185 73 10405 10318 9742 10315 57 73 10406 57 sky130_fd_sc_hd__a31oi_1
* cell instance $53190 m0 *1 223.56,454.24
X$53190 57 10474 10472 10477 9826 10317 10406 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $53191 m0 *1 226.78,454.24
X$53191 73 10474 9971 10373 10475 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53194 m0 *1 233.22,454.24
X$53194 73 10477 10323 10286 57 73 10317 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53196 m0 *1 235.52,454.24
X$53196 73 9827 10407 10375 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53199 m0 *1 239.2,454.24
X$53199 57 10486 10479 4345 9997 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $53200 m0 *1 243.8,454.24
X$53200 57 15498 10408 9993 10377 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $53207 m0 *1 257.14,454.24
X$53207 73 9741 9989 10375 10484 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $53210 m0 *1 263.58,454.24
X$53210 73 10409 73 57 10257 57 sky130_fd_sc_hd__buf_4
* cell instance $53213 m0 *1 270.94,454.24
X$53213 73 9742 10409 10319 10413 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $53220 m0 *1 284.74,454.24
X$53220 73 9735 10322 10173 10385 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53226 m0 *1 300.38,454.24
X$53226 73 10486 73 57 9914 57 sky130_fd_sc_hd__buf_4
* cell instance $53227 m0 *1 303.14,454.24
X$53227 73 10487 73 57 10370 57 sky130_fd_sc_hd__buf_4
* cell instance $53232 m0 *1 311.42,454.24
X$53232 73 10416 73 57 10322 57 sky130_fd_sc_hd__buf_4
* cell instance $53235 m0 *1 316.48,454.24
X$53235 73 10001 9915 10417 9742 10488 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $53237 m0 *1 319.7,454.24
X$53237 73 9915 10323 10417 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $53256 m0 *1 370.76,454.24
X$53256 73 10587 10389 9010 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $53259 m0 *1 381.34,454.24
X$53259 73 10492 73 57 9805 57 sky130_fd_sc_hd__buf_4
* cell instance $53265 m0 *1 391.92,454.24
X$53265 73 10169 73 57 10495 57 sky130_fd_sc_hd__buf_4
* cell instance $53267 m0 *1 395.6,454.24
X$53267 73 10495 9050 10298 57 73 10324 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53268 m0 *1 397.44,454.24
X$53268 73 9117 10324 10497 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53270 m0 *1 400.66,454.24
X$53270 73 10418 9573 9146 8150 57 73 10498 57 sky130_fd_sc_hd__a31oi_1
* cell instance $53271 m0 *1 402.96,454.24
X$53271 73 9050 10325 10418 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53274 m0 *1 409.86,454.24
X$53274 73 10421 10387 10012 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53279 m0 *1 416.76,454.24
X$53279 73 10327 73 57 8604 57 sky130_fd_sc_hd__buf_4
* cell instance $53281 m0 *1 421.36,454.24
X$53281 73 9747 73 57 10423 57 sky130_fd_sc_hd__buf_4
* cell instance $53284 m0 *1 428.72,454.24
X$53284 73 10422 9899 10578 10297 57 10490 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $53286 m0 *1 431.94,454.24
X$53286 73 8410 10489 10326 73 10422 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53290 m0 *1 437,454.24
X$53290 73 10327 8601 10328 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53291 m0 *1 438.38,454.24
X$53291 73 9646 10328 8223 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53294 m0 *1 442.06,454.24
X$53294 73 8442 8923 10325 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53299 m0 *1 446.66,454.24
X$53299 73 8410 10378 10326 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53302 m0 *1 449.42,454.24
X$53302 73 8223 10292 8644 57 73 10383 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53304 m0 *1 453.1,454.24
X$53304 73 8837 9668 10383 9497 8805 73 10574 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $53307 m0 *1 458.62,454.24
X$53307 73 10327 73 57 9714 57 sky130_fd_sc_hd__buf_4
* cell instance $53310 m0 *1 462.76,454.24
X$53310 73 9393 10268 9923 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53311 m0 *1 464.14,454.24
X$53311 57 10332 10424 10464 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $53314 m0 *1 472.42,454.24
X$53314 73 8741 10483 9597 73 10376 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $53324 m0 *1 500.02,454.24
X$53324 57 15533 10052 10471 8968 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $53325 m0 *1 504.62,454.24
X$53325 73 10126 10052 8805 10368 57 10476 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $53327 m0 *1 507.84,454.24
X$53327 73 10270 73 57 10473 57 sky130_fd_sc_hd__buf_4
* cell instance $53328 m0 *1 510.6,454.24
X$53328 73 10203 73 57 10471 57 sky130_fd_sc_hd__buf_4
* cell instance $53331 m0 *1 515.66,454.24
X$53331 73 10367 73 57 10336 57 sky130_fd_sc_hd__buf_4
* cell instance $53343 m0 *1 548.32,454.24
X$53343 73 9406 9409 10470 57 73 10366 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53344 m0 *1 550.16,454.24
X$53344 57 10559 10366 10365 9870 10466 9409 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $53347 m0 *1 554.76,454.24
X$53347 73 10429 9757 10365 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53350 m0 *1 560.74,454.24
X$53350 73 10337 73 57 10466 57 sky130_fd_sc_hd__buf_4
* cell instance $53352 m0 *1 563.96,454.24
X$53352 73 10554 10465 10028 73 57 10464 57 sky130_fd_sc_hd__o21ai_1
* cell instance $53356 m0 *1 575,454.24
X$53356 57 9414 10461 9257 9163 10429 9340 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $53358 m0 *1 580.06,454.24
X$53358 73 9529 9673 9408 57 73 10358 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53360 m0 *1 582.36,454.24
X$53360 73 10339 9511 10358 9529 9406 73 10460 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $53362 m0 *1 587.42,454.24
X$53362 73 9414 9511 10337 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53366 m0 *1 595.24,454.24
X$53366 73 9513 10337 9335 9679 10906 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $53369 m0 *1 599.84,454.24
X$53369 73 10356 73 57 10341 57 sky130_fd_sc_hd__buf_4
* cell instance $53370 m0 *1 602.6,454.24
X$53370 73 9414 9842 9766 9320 10454 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $53376 m0 *1 614.56,454.24
X$53376 73 9320 10437 10349 9244 57 10233 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $53380 m0 *1 620.54,454.24
X$53380 73 10539 10449 10140 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53385 m0 *1 630.66,454.24
X$53385 73 9941 9703 9686 10446 57 10444 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $53389 m0 *1 638.48,454.24
X$53389 57 6998 10209 10533 10443 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $53393 r0 *1 2.3,454.24
X$53393 57 10442 10303 10441 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $53394 r0 *1 9.66,454.24
X$53394 73 10179 10632 7704 73 10532 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $53397 r0 *1 13.8,454.24
X$53397 73 10228 10304 10177 10445 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53407 r0 *1 29.44,454.24
X$53407 57 7704 10450 10303 10447 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $53417 r0 *1 46.46,454.24
X$53417 73 7921 9980 8764 57 73 10395 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53418 r0 *1 48.3,454.24
X$53418 73 9085 8717 7921 10395 57 73 10452 57 sky130_fd_sc_hd__a31oi_1
* cell instance $53419 r0 *1 50.6,454.24
X$53419 57 9072 10864 10396 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $53421 r0 *1 59.8,454.24
X$53421 73 8475 10541 10453 8990 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $53422 r0 *1 61.64,454.24
X$53422 73 10455 10352 10456 8760 10398 73 10396 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $53423 r0 *1 64.86,454.24
X$53423 73 10459 73 57 10456 57 sky130_fd_sc_hd__buf_4
* cell instance $53435 r0 *1 87.86,454.24
X$53435 73 7756 10182 10308 10399 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $53436 r0 *1 90.16,454.24
X$53436 73 10399 10357 8100 8680 57 73 10743 57 sky130_fd_sc_hd__a31oi_1
* cell instance $53447 r0 *1 105.8,454.24
X$53447 73 8475 10357 10400 57 73 10543 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53448 r0 *1 107.64,454.24
X$53448 73 10308 7921 9862 10400 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $53450 r0 *1 110.86,454.24
X$53450 73 9786 7483 9224 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53490 r0 *1 185.38,454.24
X$53490 73 10404 73 57 10467 57 sky130_fd_sc_hd__buf_4
* cell instance $53497 r0 *1 205.16,454.24
X$53497 73 10190 9915 10504 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53511 r0 *1 227.7,454.24
X$53511 73 10475 73 57 10938 57 sky130_fd_sc_hd__buf_4
* cell instance $53513 r0 *1 232.3,454.24
X$53513 73 10266 9832 9990 10271 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53517 r0 *1 234.14,454.24
X$53517 73 10408 73 57 10407 57 sky130_fd_sc_hd__buf_4
* cell instance $53522 r0 *1 242.42,454.24
X$53522 73 10479 10080 10478 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53523 r0 *1 243.8,454.24
X$53523 73 10479 73 57 10323 57 sky130_fd_sc_hd__buf_4
* cell instance $53533 r0 *1 262.66,454.24
X$53533 73 9990 10484 10411 57 73 10572 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53535 r0 *1 264.96,454.24
X$53535 73 10190 9735 10411 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53537 r0 *1 268.18,454.24
X$53537 73 10413 73 57 10410 57 sky130_fd_sc_hd__buf_4
* cell instance $53538 r0 *1 270.94,454.24
X$53538 73 10319 73 57 10573 57 sky130_fd_sc_hd__buf_4
* cell instance $53547 r0 *1 288.88,454.24
X$53547 73 10413 10000 10414 57 73 10608 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53548 r0 *1 290.72,454.24
X$53548 73 9892 9832 10414 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53552 r0 *1 298.08,454.24
X$53552 73 10415 73 57 10000 57 sky130_fd_sc_hd__buf_4
* cell instance $53554 r0 *1 301.76,454.24
X$53554 73 10111 9915 10415 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53557 r0 *1 305.44,454.24
X$53557 73 9993 9742 10318 57 73 10511 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53559 r0 *1 308.2,454.24
X$53559 57 10487 10110 10511 10582 10513 9892 73 73 57
+ sky130_fd_sc_hd__a2111oi_1
* cell instance $53560 r0 *1 311.88,454.24
X$53560 73 9989 10416 10113 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53575 r0 *1 339.94,454.24
X$53575 57 10586 9896 7007 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $53596 r0 *1 378.58,454.24
X$53596 73 10392 7171 73 10565 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $53606 r0 *1 398.82,454.24
X$53606 73 10419 10497 10498 57 73 10585 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53612 r0 *1 408.02,454.24
X$53612 73 8897 10496 10420 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53613 r0 *1 409.4,454.24
X$53613 73 10420 8935 8592 10421 8560 10494 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $53615 r0 *1 413.08,454.24
X$53615 73 10493 2342 10436 57 73 8013 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53617 r0 *1 416.76,454.24
X$53617 73 9146 8483 8592 57 73 10581 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53618 r0 *1 418.6,454.24
X$53618 73 10580 8560 8738 57 73 10419 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53620 r0 *1 421.36,454.24
X$53620 57 10491 7905 10490 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $53631 r0 *1 437.46,454.24
X$53631 73 9146 10423 10294 57 73 10576 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53638 r0 *1 450.34,454.24
X$53638 73 10425 73 57 10292 57 sky130_fd_sc_hd__buf_4
* cell instance $53645 r0 *1 463.22,454.24
X$53645 57 10332 10518 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $53646 r0 *1 470.58,454.24
X$53646 73 10518 7944 73 7691 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $53649 r0 *1 476.56,454.24
X$53649 73 9494 73 57 10568 57 sky130_fd_sc_hd__buf_4
* cell instance $53657 r0 *1 485.76,454.24
X$53657 73 10425 10126 10481 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53661 r0 *1 493.58,454.24
X$53661 73 9554 10661 10426 8410 10941 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $53664 r0 *1 497.72,454.24
X$53664 73 10480 10476 10623 73 10426 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53673 r0 *1 510.14,454.24
X$53673 73 10471 9602 10335 8741 57 10566 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $53691 r0 *1 546.94,454.24
X$53691 73 9161 10428 9864 10427 10213 10562 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $53694 r0 *1 554.76,454.24
X$53694 73 9861 9864 9757 57 73 10558 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53701 r0 *1 561.66,454.24
X$53701 73 9673 9320 10248 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53702 r0 *1 563.04,454.24
X$53702 73 10430 9412 10338 57 73 10554 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53703 r0 *1 564.88,454.24
X$53703 57 10431 10465 9409 10522 10252 10430 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $53705 r0 *1 568.56,454.24
X$53705 73 9529 9861 10552 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53708 r0 *1 572.24,454.24
X$53708 73 10627 10250 10522 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53710 r0 *1 574.54,454.24
X$53710 73 9340 73 57 10462 57 sky130_fd_sc_hd__buf_4
* cell instance $53715 r0 *1 584.2,454.24
X$53715 73 10552 9630 10239 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $53726 r0 *1 601.22,454.24
X$53726 73 9511 10132 9775 9701 10432 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $53727 r0 *1 603.52,454.24
X$53727 73 10451 10432 10454 10218 10434 10433 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $53730 r0 *1 611.34,454.24
X$53730 73 10433 10435 10528 9409 57 73 9619 57 sky130_fd_sc_hd__a31oi_1
* cell instance $53734 r0 *1 613.64,454.24
X$53734 73 9323 9686 10451 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53738 r0 *1 620.08,454.24
X$53738 73 10438 10239 10529 10437 9701 10449 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $53740 r0 *1 623.76,454.24
X$53740 73 10535 9849 10438 9511 10222 73 10448 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $53743 r0 *1 629.28,454.24
X$53743 73 9244 9686 10438 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53744 r0 *1 630.66,454.24
X$53744 73 10132 10429 10446 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53751 r0 *1 639.86,454.24
X$53751 57 6998 10436 10533 10439 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $53755 r0 *1 656.88,454.24
X$53755 73 10531 57 73 10439 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53757 m0 *1 4.14,459.68
X$53757 73 10499 57 73 10501 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53758 m0 *1 7.82,459.68
X$53758 57 10394 10303 10532 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $53759 m0 *1 15.18,459.68
X$53759 73 10534 57 73 8948 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53760 m0 *1 18.86,459.68
X$53760 57 7704 10536 10303 10501 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $53763 m0 *1 34.04,459.68
X$53763 73 4428 10536 10537 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53767 m0 *1 41.4,459.68
X$53767 73 4428 10450 10538 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53769 m0 *1 43.7,459.68
X$53769 73 9786 7756 9980 57 73 9074 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53772 m0 *1 50.14,459.68
X$53772 73 9293 7483 10502 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53774 m0 *1 52.44,459.68
X$53774 73 10502 73 57 8623 57 sky130_fd_sc_hd__buf_4
* cell instance $53780 m0 *1 60.26,459.68
X$53780 73 10395 9581 8178 73 10541 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53790 m0 *1 86.48,459.68
X$53790 73 9225 8062 10181 10397 57 10545 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $53796 m0 *1 99.82,459.68
X$53796 73 9296 9225 10544 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53806 m0 *1 122.82,459.68
X$53806 73 10549 10545 10546 10548 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53811 m0 *1 134.32,459.68
X$53811 73 10403 7921 9085 57 73 10646 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53817 m0 *1 146.28,459.68
X$53817 73 7761 10403 7756 73 10550 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53822 m0 *1 157.78,459.68
X$53822 73 10649 57 73 10500 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53824 m0 *1 165.14,459.68
X$53824 73 10537 11612 9303 73 9353 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $53828 m0 *1 173.88,459.68
X$53828 57 9037 10553 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $53838 m0 *1 204.24,459.68
X$53838 73 9742 10507 10504 10556 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53839 m0 *1 206.08,459.68
X$53839 73 10505 73 57 10507 57 sky130_fd_sc_hd__buf_4
* cell instance $53844 m0 *1 220.34,459.68
X$53844 73 10563 73 57 10472 57 sky130_fd_sc_hd__buf_4
* cell instance $53850 m0 *1 235.06,459.68
X$53850 57 10407 10602 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $53852 m0 *1 246.1,459.68
X$53852 73 10269 73 57 10412 57 sky130_fd_sc_hd__buf_4
* cell instance $53859 m0 *1 258.06,459.68
X$53859 73 10693 73 57 10409 57 sky130_fd_sc_hd__buf_4
* cell instance $53860 m0 *1 260.82,459.68
X$53860 73 9989 10410 9742 10082 10381 10571 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $53861 m0 *1 264.5,459.68
X$53861 73 9710 73 57 10508 57 sky130_fd_sc_hd__buf_4
* cell instance $53862 m0 *1 267.26,459.68
X$53862 73 10509 73 57 10657 57 sky130_fd_sc_hd__buf_4
* cell instance $53863 m0 *1 270.02,459.68
X$53863 57 9742 10509 10508 10579 10507 10488 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $53874 m0 *1 297.62,459.68
X$53874 73 9993 10320 10677 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53882 m0 *1 307.74,459.68
X$53882 73 9989 9976 10582 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53885 m0 *1 311.88,459.68
X$53885 73 10323 10198 10513 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53886 m0 *1 313.26,459.68
X$53886 73 10512 4624 10416 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53888 m0 *1 318.32,459.68
X$53888 57 11370 10678 10001 10583 10323 10110 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $53906 m0 *1 365.7,459.68
X$53906 57 10587 8993 10515 10886 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $53907 m0 *1 373.98,459.68
X$53907 57 10390 10515 10492 8109 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $53919 m0 *1 408.94,459.68
X$53919 73 2342 10584 10493 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53924 m0 *1 416.76,459.68
X$53924 73 10516 10581 8150 73 10580 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53925 m0 *1 418.6,459.68
X$53925 73 10673 73 57 10516 57 sky130_fd_sc_hd__buf_4
* cell instance $53929 m0 *1 432.4,459.68
X$53929 73 8253 8312 10517 10578 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53932 m0 *1 437,459.68
X$53932 73 10576 11360 10668 10667 9146 10517 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $53947 m0 *1 474.26,459.68
X$53947 73 10707 73 57 10483 57 sky130_fd_sc_hd__buf_4
* cell instance $53948 m0 *1 477.02,459.68
X$53948 73 10570 73 57 8837 57 sky130_fd_sc_hd__buf_4
* cell instance $53951 m0 *1 484.38,459.68
X$53951 73 8741 10333 10372 10567 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $53960 m0 *1 505.54,459.68
X$53960 73 8975 73 57 9638 57 sky130_fd_sc_hd__buf_4
* cell instance $53972 m0 *1 537.74,459.68
X$53972 73 10520 57 73 8991 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53976 m0 *1 549.7,459.68
X$53976 73 10559 9412 10560 10562 73 10561 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $53980 m0 *1 554.76,459.68
X$53980 73 9161 10558 10555 73 10557 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $53981 m0 *1 556.6,459.68
X$53981 73 11188 10557 10462 10521 57 10430 73 57 sky130_fd_sc_hd__a22o_1
* cell instance $53984 m0 *1 561.2,459.68
X$53984 73 9408 9757 10526 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $53992 m0 *1 582.36,459.68
X$53992 73 10523 10460 9406 10641 73 10521 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $53993 m0 *1 585.58,459.68
X$53993 73 9701 9761 10524 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $53995 m0 *1 587.88,459.68
X$53995 73 9529 10524 10525 57 73 10523 57 sky130_fd_sc_hd__a21oi_1
* cell instance $53996 m0 *1 589.72,459.68
X$53996 73 10524 73 57 10529 57 sky130_fd_sc_hd__buf_4
* cell instance $54001 m0 *1 602.14,459.68
X$54001 73 9841 9703 10547 10720 57 9417 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $54002 m0 *1 604.9,459.68
X$54002 73 10451 10525 10547 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54008 m0 *1 610.42,459.68
X$54008 73 9320 9676 10220 10527 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54009 m0 *1 612.26,459.68
X$54009 73 10451 10542 10527 10539 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54011 m0 *1 615.02,459.68
X$54011 57 9701 10435 10540 10129 10526 10438 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $54014 m0 *1 623.76,459.68
X$54014 73 9675 10529 10525 73 10530 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54015 m0 *1 625.6,459.68
X$54015 73 9703 10530 10535 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54017 m0 *1 627.9,459.68
X$54017 73 10437 9161 9841 10732 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54027 m0 *1 656.88,459.68
X$54027 73 11010 57 73 10443 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54028 r0 *1 2.3,459.68
X$54028 73 10393 57 73 10633 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54030 r0 *1 6.44,459.68
X$54030 73 10588 57 73 10179 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54032 r0 *1 11.96,459.68
X$54032 73 10394 10445 10632 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54039 r0 *1 17.94,459.68
X$54039 57 7704 10592 10303 9939 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $54040 r0 *1 28.98,459.68
X$54040 57 7704 10635 10303 10633 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $54051 r0 *1 66.7,459.68
X$54051 57 15576 10590 7756 9786 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $54055 r0 *1 72.22,459.68
X$54055 73 10590 7647 10591 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54056 r0 *1 73.6,459.68
X$54056 57 10397 10636 8760 10591 10593 10839 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $54062 r0 *1 95.22,459.68
X$54062 73 8203 7483 10637 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54065 r0 *1 97.06,459.68
X$54065 73 10637 9781 7921 73 10638 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54070 r0 *1 104.42,459.68
X$54070 73 7921 9863 9781 10640 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $54072 r0 *1 108.1,459.68
X$54072 73 8062 7483 10595 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54075 r0 *1 110.86,459.68
X$54075 73 7921 8717 9862 10643 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54078 r0 *1 118.22,459.68
X$54078 57 9614 11023 10644 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $54083 r0 *1 127.42,459.68
X$54083 73 10548 10596 10360 9956 57 10503 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $54084 r0 *1 130.18,459.68
X$54084 57 7921 10597 8100 10308 10402 10922 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $54085 r0 *1 133.4,459.68
X$54085 73 8100 10646 10597 8472 10596 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $54087 r0 *1 139.84,459.68
X$54087 73 9903 8285 7483 57 73 10647 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54090 r0 *1 145.82,459.68
X$54090 73 7756 10647 10550 8839 9820 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $54097 r0 *1 159.16,459.68
X$54097 57 10649 10553 10650 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $54107 r0 *1 184.92,459.68
X$54107 73 9735 11392 10468 10660 10477 73 10652 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $54111 r0 *1 196.42,459.68
X$54111 73 9989 9986 10657 10506 9821 73 10658 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $54114 r0 *1 202.4,459.68
X$54114 73 9742 10564 10556 57 73 10660 57 sky130_fd_sc_hd__a21o_1
* cell instance $54117 r0 *1 206.08,459.68
X$54117 73 9914 9990 10505 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54122 r0 *1 215.28,459.68
X$54122 73 10598 73 57 10065 57 sky130_fd_sc_hd__buf_4
* cell instance $54123 r0 *1 218.04,459.68
X$54123 73 10599 10598 9742 73 10563 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54124 r0 *1 219.88,459.68
X$54124 73 9827 9915 10598 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54128 r0 *1 224.48,459.68
X$54128 57 10506 9741 10600 10599 10569 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $54131 r0 *1 229.08,459.68
X$54131 73 10408 10601 10599 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54134 r0 *1 234.14,459.68
X$54134 73 9975 73 57 10663 57 sky130_fd_sc_hd__buf_4
* cell instance $54138 r0 *1 240.12,459.68
X$54138 73 10602 10286 10665 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54141 r0 *1 245.64,459.68
X$54141 73 10412 9742 9915 73 10603 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54142 r0 *1 247.48,459.68
X$54142 73 10603 10665 9989 10477 57 73 10604 57 sky130_fd_sc_hd__a31oi_1
* cell instance $54147 r0 *1 256.68,459.68
X$54147 73 10412 10601 10082 9741 10569 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $54150 r0 *1 259.9,459.68
X$54150 57 10670 10571 10477 10694 10604 10605 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $54156 r0 *1 269.1,459.68
X$54156 73 10384 10477 10672 57 73 10669 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54157 r0 *1 270.94,459.68
X$54157 73 10572 10510 10606 57 73 10605 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54158 r0 *1 272.78,459.68
X$54158 73 9832 10510 10607 73 10672 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54162 r0 *1 285.66,459.68
X$54162 73 9735 9743 10674 10608 9976 73 10775 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $54164 r0 *1 288.88,459.68
X$54164 73 10091 9915 10510 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54165 r0 *1 290.26,459.68
X$54165 73 9832 10415 10607 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54170 r0 *1 298.08,459.68
X$54170 57 10949 10609 10412 10677 9914 10108 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $54173 r0 *1 308.66,459.68
X$54173 73 9914 10198 10583 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54174 r0 *1 310.04,459.68
X$54174 73 9975 73 57 10610 57 sky130_fd_sc_hd__buf_4
* cell instance $54176 r0 *1 313.72,459.68
X$54176 73 10610 73 57 10512 57 sky130_fd_sc_hd__buf_4
* cell instance $54179 r0 *1 316.94,459.68
X$54179 73 10609 73 57 10678 57 sky130_fd_sc_hd__buf_4
* cell instance $54183 r0 *1 324.3,459.68
X$54183 57 10679 9976 10583 10404 10512 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $54185 r0 *1 327.98,459.68
X$54185 73 10113 73 57 10681 57 sky130_fd_sc_hd__buf_4
* cell instance $54195 r0 *1 350.52,459.68
X$54195 57 10586 10683 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $54196 r0 *1 357.88,459.68
X$54196 73 10683 9130 73 10611 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $54199 r0 *1 363.86,459.68
X$54199 73 10611 73 57 9687 57 sky130_fd_sc_hd__buf_4
* cell instance $54200 r0 *1 366.62,459.68
X$54200 57 10514 10682 10788 10786 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $54205 r0 *1 376.74,459.68
X$54205 57 10680 10392 10127 10518 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $54208 r0 *1 392.84,459.68
X$54208 57 7579 10613 10577 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $54212 r0 *1 402.96,459.68
X$54212 73 10676 8221 10584 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $54213 r0 *1 406.18,459.68
X$54213 73 9146 10615 10675 57 73 10300 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54222 r0 *1 430.56,459.68
X$54222 73 10575 73 57 9108 57 sky130_fd_sc_hd__buf_4
* cell instance $54225 r0 *1 437.46,459.68
X$54225 73 9108 9393 8410 10617 10667 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $54228 r0 *1 442.52,459.68
X$54228 73 10293 8923 10666 10617 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54230 r0 *1 448.04,459.68
X$54230 73 10575 8601 9668 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54239 r0 *1 466.44,459.68
X$54239 73 10664 73 57 8442 57 sky130_fd_sc_hd__buf_4
* cell instance $54245 r0 *1 480.7,459.68
X$54245 73 9752 10568 10622 57 73 10519 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54246 r0 *1 482.54,459.68
X$54246 73 10621 10372 10622 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54252 r0 *1 491.28,459.68
X$54252 73 9240 8805 9638 10519 73 57 10661 57 sky130_fd_sc_hd__o31ai_1
* cell instance $54259 r0 *1 509.68,459.68
X$54259 73 10018 10566 10659 8314 10656 10054 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $54263 r0 *1 517.96,459.68
X$54263 57 10655 10654 10565 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $54273 r0 *1 548.32,459.68
X$54273 73 9408 9757 10651 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54274 r0 *1 549.7,459.68
X$54274 73 10651 10338 9864 10648 57 10428 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $54276 r0 *1 556.14,459.68
X$54276 73 10624 10022 10429 9323 57 73 10645 57 sky130_fd_sc_hd__a31oi_1
* cell instance $54278 r0 *1 558.44,459.68
X$54278 73 9406 10248 10624 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54280 r0 *1 560.74,459.68
X$54280 73 10153 10626 10628 73 10555 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54283 r0 *1 564.88,459.68
X$54283 73 10338 10040 9860 57 73 10648 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54288 r0 *1 569.48,459.68
X$54288 73 9707 73 57 10626 57 sky130_fd_sc_hd__buf_4
* cell instance $54293 r0 *1 581.9,459.68
X$54293 73 9675 10429 10642 73 10641 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54305 r0 *1 611.8,459.68
X$54305 73 10145 9701 10143 9930 73 10528 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $54314 r0 *1 628.82,459.68
X$54314 73 10437 9603 9701 73 10634 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54315 r0 *1 630.66,459.68
X$54315 57 10634 10630 10340 10344 9616 9701 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $54318 r0 *1 636.18,459.68
X$54318 57 10631 10533 8581 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $54375 m0 *1 4.14,465.12
X$54375 73 10445 10394 7704 10725 57 73 57 sky130_fd_sc_hd__and3b_1
* cell instance $54376 m0 *1 7.36,465.12
X$54376 57 10440 10303 10726 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $54377 m0 *1 14.72,465.12
X$54377 57 10727 10303 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $54396 m0 *1 66.7,465.12
X$54396 57 9812 10746 10458 8501 10741 10589 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $54406 m0 *1 92,465.12
X$54406 73 7921 10308 9863 10742 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $54408 m0 *1 97.52,465.12
X$54408 73 10688 73 57 10746 57 sky130_fd_sc_hd__buf_4
* cell instance $54409 m0 *1 100.28,465.12
X$54409 73 10638 10544 10594 8100 8475 73 10841 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $54410 m0 *1 103.5,465.12
X$54410 73 10689 10640 9730 73 10688 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54412 m0 *1 107.18,465.12
X$54412 73 7756 10595 7887 10689 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $54413 m0 *1 109.02,465.12
X$54413 57 10594 7921 10595 10308 10643 8178 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $54419 m0 *1 126.04,465.12
X$54419 73 10920 6947 73 10644 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $54429 m0 *1 155.94,465.12
X$54429 73 10751 73 57 9136 57 sky130_fd_sc_hd__buf_4
* cell instance $54432 m0 *1 160.08,465.12
X$54432 73 10753 7112 73 10650 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $54443 m0 *1 191.36,465.12
X$54443 73 10755 10287 10658 10652 73 10653 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $54450 m0 *1 206.08,465.12
X$54450 73 10505 9734 9742 73 10758 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54454 m0 *1 212.98,465.12
X$54454 73 9710 9915 10485 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54457 m0 *1 215.74,465.12
X$54457 73 10314 73 57 10760 57 sky130_fd_sc_hd__buf_4
* cell instance $54464 m0 *1 229.54,465.12
X$54464 73 10602 9740 10692 10381 9741 10662 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $54466 m0 *1 236.44,465.12
X$54466 73 10663 4302 10764 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54467 m0 *1 237.82,465.12
X$54467 73 10663 73 57 9826 57 sky130_fd_sc_hd__buf_4
* cell instance $54470 m0 *1 241.96,465.12
X$54470 73 11039 73 57 10404 57 sky130_fd_sc_hd__buf_4
* cell instance $54477 m0 *1 258.52,465.12
X$54477 73 10198 73 57 10695 57 sky130_fd_sc_hd__buf_4
* cell instance $54480 m0 *1 265.88,465.12
X$54480 73 10670 10696 10771 10385 57 10671 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $54481 m0 *1 268.18,465.12
X$54481 57 10771 10770 10669 9735 4624 9826 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $54483 m0 *1 271.86,465.12
X$54483 73 10111 10510 10507 10772 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $54489 m0 *1 286.12,465.12
X$54489 57 10696 10775 10778 4624 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $54491 m0 *1 293.48,465.12
X$54491 73 9892 9915 10600 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54495 m0 *1 298.08,465.12
X$54495 73 9993 10198 10320 73 10780 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54503 m0 *1 312.8,465.12
X$54503 73 10583 10782 10610 73 10781 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54524 m0 *1 366.62,465.12
X$54524 57 10682 10784 8109 10787 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $54527 m0 *1 376.28,465.12
X$54527 57 10612 10680 10698 10295 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $54529 m0 *1 385.02,465.12
X$54529 57 10613 8775 10612 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $54534 m0 *1 400.2,465.12
X$54534 73 8186 11501 10676 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $54535 m0 *1 403.42,465.12
X$54535 73 8483 10700 9573 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54536 m0 *1 404.8,465.12
X$54536 73 10615 10791 10699 10614 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54538 m0 *1 407.1,465.12
X$54538 73 10496 10616 10791 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54539 m0 *1 408.48,465.12
X$54539 73 8695 10387 8483 73 10675 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54541 m0 *1 410.78,465.12
X$54541 57 10699 10387 8970 8253 8735 9923 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $54546 m0 *1 420.44,465.12
X$54546 57 10673 10616 9389 10018 8926 10700 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $54548 m0 *1 424.58,465.12
X$54548 73 8483 9923 10701 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54549 m0 *1 425.96,465.12
X$54549 73 9346 73 57 9893 57 sky130_fd_sc_hd__buf_4
* cell instance $54551 m0 *1 432.4,465.12
X$54551 73 10701 10423 10618 10615 73 10668 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $54553 m0 *1 435.62,465.12
X$54553 73 10702 73 57 8970 57 sky130_fd_sc_hd__buf_4
* cell instance $54556 m0 *1 441.14,465.12
X$54556 73 10620 73 57 10016 57 sky130_fd_sc_hd__buf_4
* cell instance $54560 m0 *1 445.74,465.12
X$54560 73 10704 73 57 10618 57 sky130_fd_sc_hd__buf_4
* cell instance $54563 m0 *1 452.64,465.12
X$54563 73 10018 10703 10704 57 73 9105 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54565 m0 *1 458.16,465.12
X$54565 73 10793 73 57 9836 57 sky130_fd_sc_hd__buf_4
* cell instance $54566 m0 *1 460.92,465.12
X$54566 73 10706 73 57 8811 57 sky130_fd_sc_hd__buf_4
* cell instance $54567 m0 *1 463.68,465.12
X$54567 73 9051 10664 10706 10619 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54568 m0 *1 465.52,465.12
X$54568 73 10425 8601 10664 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54570 m0 *1 468.74,465.12
X$54570 73 10702 10293 10707 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54575 m0 *1 472.88,465.12
X$54575 73 8815 10703 10293 10707 57 73 10659 57 sky130_fd_sc_hd__a31oi_1
* cell instance $54576 m0 *1 475.18,465.12
X$54576 73 9836 73 57 10620 57 sky130_fd_sc_hd__inv_1
* cell instance $54578 m0 *1 478.4,465.12
X$54578 73 10708 73 57 9176 57 sky130_fd_sc_hd__buf_4
* cell instance $54580 m0 *1 482.08,465.12
X$54580 57 8104 10424 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $54584 m0 *1 497.72,465.12
X$54584 73 8253 8314 10623 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54586 m0 *1 499.56,465.12
X$54586 73 8741 8314 10710 10330 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54587 m0 *1 501.4,465.12
X$54587 73 9836 9393 10126 73 10774 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54590 m0 *1 506,465.12
X$54590 73 10270 10207 9638 73 10711 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54593 m0 *1 509.22,465.12
X$54593 73 8975 73 57 8741 57 sky130_fd_sc_hd__buf_4
* cell instance $54594 m0 *1 511.98,465.12
X$54594 73 10713 10126 8314 73 10656 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54608 m0 *1 551.54,465.12
X$54608 73 10551 73 57 10766 57 sky130_fd_sc_hd__buf_4
* cell instance $54613 m0 *1 557.98,465.12
X$54613 73 10153 73 57 10625 57 sky130_fd_sc_hd__buf_4
* cell instance $54621 m0 *1 578.68,465.12
X$54621 57 10627 10756 9161 10337 10754 10551 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $54626 m0 *1 588.34,465.12
X$54626 73 9675 10628 10714 10525 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54627 m0 *1 590.18,465.12
X$54627 73 9701 10717 9760 10542 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54628 m0 *1 592.02,465.12
X$54628 73 10628 10642 10748 57 73 10639 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54631 m0 *1 596.16,465.12
X$54631 73 9406 10355 10629 9325 10747 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $54644 m0 *1 627.44,465.12
X$54644 73 9686 10525 10732 73 10731 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54645 m0 *1 629.28,465.12
X$54645 73 9686 10630 10629 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54652 m0 *1 643.08,465.12
X$54652 73 10533 57 73 57 sky130_fd_sc_hd__clkinv_4
* cell instance $54660 r0 *1 2.76,465.12
X$54660 57 10724 10303 10686 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $54668 r0 *1 17.94,465.12
X$54668 57 10534 10303 10728 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $54669 r0 *1 25.3,465.12
X$54669 57 10729 1831 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $54678 r0 *1 50.6,465.12
X$54678 73 7756 10502 9699 57 73 10735 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54679 r0 *1 52.44,465.12
X$54679 73 9476 10838 8839 73 10589 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54690 r0 *1 79.12,465.12
X$54690 73 7756 9183 10038 57 73 10687 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54691 r0 *1 80.96,465.12
X$54691 73 10687 10742 9725 73 10741 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54695 r0 *1 91.08,465.12
X$54695 73 10636 8472 10743 57 73 10745 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54707 r0 *1 116.38,465.12
X$54707 73 8475 8100 9725 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54711 r0 *1 120.98,465.12
X$54711 73 9027 73 57 10549 57 sky130_fd_sc_hd__buf_4
* cell instance $54728 r0 *1 158.24,465.12
X$54728 73 10845 6830 73 10686 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $54743 r0 *1 202.4,465.12
X$54743 73 10253 10846 10477 10690 57 73 10757 57 sky130_fd_sc_hd__a31oi_1
* cell instance $54746 r0 *1 206.54,465.12
X$54746 73 10271 73 57 9987 57 sky130_fd_sc_hd__buf_4
* cell instance $54751 r0 *1 214.82,465.12
X$54751 73 10192 10763 9989 73 10690 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54760 r0 *1 237.36,465.12
X$54760 73 10764 73 57 11083 57 sky130_fd_sc_hd__buf_4
* cell instance $54763 r0 *1 242.42,465.12
X$54763 73 10269 10080 10768 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54764 r0 *1 243.8,465.12
X$54764 73 10804 9915 10693 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54773 r0 *1 264.96,465.12
X$54773 57 10691 9037 10671 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $54778 r0 *1 282.44,465.12
X$54778 73 10697 10086 10777 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54781 r0 *1 286.58,465.12
X$54781 73 10777 10781 10779 10776 57 10778 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $54790 r0 *1 304.52,465.12
X$54790 73 9990 9742 10609 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $54803 r0 *1 340.4,465.12
X$54803 73 4428 73 57 10114 57 sky130_fd_sc_hd__buf_4
* cell instance $54814 r0 *1 364.78,465.12
X$54814 73 8993 10683 73 10783 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $54815 r0 *1 368,465.12
X$54815 73 10783 10390 10785 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $54817 r0 *1 371.22,465.12
X$54817 73 10698 73 57 10786 57 sky130_fd_sc_hd__buf_4
* cell instance $54823 r0 *1 378.58,465.12
X$54823 73 10789 10127 73 10788 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $54824 r0 *1 381.8,465.12
X$54824 73 10518 73 57 10787 57 sky130_fd_sc_hd__buf_4
* cell instance $54835 r0 *1 403.88,465.12
X$54835 73 9117 9277 8312 73 10790 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54836 r0 *1 405.72,465.12
X$54836 73 8735 10700 10615 73 10792 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54843 r0 *1 423.2,465.12
X$54843 73 8968 8735 10268 10615 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54851 r0 *1 437,465.12
X$54851 57 10855 8601 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $54858 r0 *1 454.94,465.12
X$54858 73 10705 73 57 8562 57 sky130_fd_sc_hd__buf_4
* cell instance $54862 r0 *1 459.54,465.12
X$54862 73 10705 8741 10706 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54863 r0 *1 460.92,465.12
X$54863 57 10793 10482 9389 10577 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $54864 r0 *1 465.52,465.12
X$54864 73 8483 8601 10708 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54866 r0 *1 468.74,465.12
X$54866 73 10482 73 57 10702 57 sky130_fd_sc_hd__buf_4
* cell instance $54871 r0 *1 479.32,465.12
X$54871 73 10709 73 57 10700 57 sky130_fd_sc_hd__buf_4
* cell instance $54872 r0 *1 482.08,465.12
X$54872 73 10424 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $54874 r0 *1 485.76,465.12
X$54874 73 10620 9638 11620 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54880 r0 *1 499.56,465.12
X$54880 73 8562 10471 10710 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54883 r0 *1 502.32,465.12
X$54883 73 8562 8805 10709 73 10712 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54886 r0 *1 505.08,465.12
X$54886 73 10018 10711 10773 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54888 r0 *1 508.3,465.12
X$54888 57 15630 10713 10336 10769 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $54894 r0 *1 526.24,465.12
X$54894 73 10655 57 73 10818 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54906 r0 *1 551.08,465.12
X$54906 73 9323 10766 10767 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54912 r0 *1 565.34,465.12
X$54912 73 10338 10759 10749 10762 73 57 10761 57 sky130_fd_sc_hd__o31ai_1
* cell instance $54914 r0 *1 568.56,465.12
X$54914 73 9701 10552 9860 57 73 10759 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54918 r0 *1 576.84,465.12
X$54918 73 10715 10714 9860 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54919 r0 *1 578.22,465.12
X$54919 57 10823 10754 10628 10716 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $54920 r0 *1 580.52,465.12
X$54920 73 9926 73 57 10715 57 sky130_fd_sc_hd__buf_4
* cell instance $54921 r0 *1 583.28,465.12
X$54921 73 10039 9842 10716 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54922 r0 *1 584.66,465.12
X$54922 73 10716 73 57 10718 57 sky130_fd_sc_hd__buf_4
* cell instance $54924 r0 *1 587.42,465.12
X$54924 73 10718 73 57 10717 57 sky130_fd_sc_hd__buf_4
* cell instance $54926 r0 *1 592.02,465.12
X$54926 73 9701 10145 10718 10750 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54928 r0 *1 594.32,465.12
X$54928 73 10628 10719 10749 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54933 r0 *1 599.38,465.12
X$54933 73 9675 10552 10720 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54935 r0 *1 601.68,465.12
X$54935 73 10744 10340 10719 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $54938 r0 *1 607.2,465.12
X$54938 73 9767 9603 10739 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54939 r0 *1 608.58,465.12
X$54939 73 9320 10220 10739 10740 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $54941 r0 *1 611.34,465.12
X$54941 73 9332 10738 10842 10721 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $54945 r0 *1 614.56,465.12
X$54945 73 9325 10722 10721 10737 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $54948 r0 *1 618.7,465.12
X$54948 73 9701 9161 10734 9323 73 57 10733 57 sky130_fd_sc_hd__o31ai_1
* cell instance $54949 r0 *1 621.46,465.12
X$54949 73 10625 9767 9603 57 73 10734 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54953 r0 *1 626.06,465.12
X$54953 73 10733 10731 10730 9513 10722 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $54960 r0 *1 641.7,465.12
X$54960 57 8104 10533 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $54964 r0 *1 655.96,465.12
X$54964 73 10631 57 73 10833 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54967 m0 *1 3.22,470.56
X$54967 73 10724 57 73 10684 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54970 m0 *1 8.28,470.56
X$54970 57 7704 10834 10303 9615 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $54974 m0 *1 21.16,470.56
X$54974 73 4428 10736 10835 73 10911 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $54975 m0 *1 23,470.56
X$54975 73 4428 10834 10835 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $54979 m0 *1 30.36,470.56
X$54979 57 10863 10796 10837 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $54986 m0 *1 47.84,470.56
X$54986 73 10797 9980 8475 7756 10735 73 10798 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $54987 m0 *1 51.06,470.56
X$54987 73 10798 73 57 9174 57 sky130_fd_sc_hd__buf_4
* cell instance $54989 m0 *1 55.66,470.56
X$54989 73 7921 8347 10038 57 73 10838 57 sky130_fd_sc_hd__a21oi_1
* cell instance $54992 m0 *1 58.88,470.56
X$54992 73 8864 7647 10797 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55001 m0 *1 74.52,470.56
X$55001 73 8839 10840 10839 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55014 m0 *1 99.82,470.56
X$55014 73 10799 73 57 10398 57 sky130_fd_sc_hd__buf_4
* cell instance $55016 m0 *1 103.04,470.56
X$55016 73 10800 8475 9027 10841 57 10799 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $55028 m0 *1 126.04,470.56
X$55028 73 8100 8767 10843 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55029 m0 *1 127.42,470.56
X$55029 73 9183 9699 10801 7921 8178 73 10923 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $55032 m0 *1 134.78,470.56
X$55032 73 7921 9903 7887 10801 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55048 m0 *1 170.2,470.56
X$55048 57 10845 10553 10802 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $55053 m0 *1 181.7,470.56
X$55053 73 10927 73 57 10805 57 sky130_fd_sc_hd__buf_4
* cell instance $55061 m0 *1 202.4,470.56
X$55061 73 9742 10932 10846 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55077 m0 *1 235.06,470.56
X$55077 57 8788 9037 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $55079 m0 *1 245.18,470.56
X$55079 73 10269 73 57 10804 57 sky130_fd_sc_hd__buf_4
* cell instance $55084 m0 *1 252.08,470.56
X$55084 57 10944 9989 10806 10477 10849 10380 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $55092 m0 *1 271.4,470.56
X$55092 73 9826 10806 4624 73 10807 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55101 m0 *1 285.66,470.56
X$55101 73 10808 73 57 10802 57 sky130_fd_sc_hd__buf_4
* cell instance $55104 m0 *1 288.42,470.56
X$55104 73 10946 73 57 10779 57 sky130_fd_sc_hd__buf_4
* cell instance $55105 m0 *1 291.18,470.56
X$55105 57 10853 10808 10196 10805 10852 10807 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $55107 m0 *1 294.86,470.56
X$55107 73 10948 10809 4302 73 10853 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55110 m0 *1 299,470.56
X$55110 73 10811 10810 10809 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55114 m0 *1 303.6,470.56
X$55114 73 10091 10388 10954 73 10810 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55122 m0 *1 315.56,470.56
X$55122 73 9742 10417 10854 57 73 10782 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55143 m0 *1 362.48,470.56
X$55143 57 11474 10784 10789 10683 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $55146 m0 *1 370.76,470.56
X$55146 73 10683 10885 73 10698 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $55147 m0 *1 373.98,470.56
X$55147 73 10788 73 57 10856 57 sky130_fd_sc_hd__buf_4
* cell instance $55158 m0 *1 397.44,470.56
X$55158 73 8150 8312 9899 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55161 m0 *1 403.42,470.56
X$55161 73 9312 10790 10813 73 10794 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55164 m0 *1 409.4,470.56
X$55164 73 10812 10773 8410 8313 8150 73 10813 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $55169 m0 *1 421.36,470.56
X$55169 73 10814 73 57 10120 57 sky130_fd_sc_hd__buf_4
* cell instance $55172 m0 *1 424.12,470.56
X$55172 73 8735 8644 10814 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55173 m0 *1 425.5,470.56
X$55173 73 8968 10814 9346 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55175 m0 *1 427.8,470.56
X$55175 73 10815 73 57 9397 57 sky130_fd_sc_hd__buf_4
* cell instance $55178 m0 *1 431.94,470.56
X$55178 73 8926 9638 10815 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55179 m0 *1 433.32,470.56
X$55179 57 10816 10855 10891 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $55180 m0 *1 437.46,470.56
X$55180 73 10855 73 57 10268 57 sky130_fd_sc_hd__buf_4
* cell instance $55182 m0 *1 440.68,470.56
X$55182 73 7745 2342 10817 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55183 m0 *1 442.06,470.56
X$55183 73 4566 10817 10952 73 10816 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55191 m0 *1 451.26,470.56
X$55191 73 10425 10891 10816 10703 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $55192 m0 *1 453.56,470.56
X$55192 57 5047 9804 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $55194 m0 *1 463.22,470.56
X$55194 73 10577 73 57 10769 57 sky130_fd_sc_hd__buf_4
* cell instance $55196 m0 *1 469.66,470.56
X$55196 73 10293 11288 10704 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55200 m0 *1 475.64,470.56
X$55200 73 10769 9389 8975 73 10570 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55205 m0 *1 482.08,470.56
X$55205 73 10018 8741 10621 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55207 m0 *1 483.92,470.56
X$55207 73 10769 9638 8972 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55210 m0 *1 487.6,470.56
X$55210 73 10773 10567 9899 10850 10851 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $55221 m0 *1 507.84,470.56
X$55221 57 15481 9240 10336 10769 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $55237 m0 *1 544.64,470.56
X$55237 73 10819 9408 10848 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $55239 m0 *1 548.78,470.56
X$55239 73 9529 9408 10820 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55241 m0 *1 550.62,470.56
X$55241 73 10767 9323 10821 57 73 10847 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55242 m0 *1 552.46,470.56
X$55242 73 9534 9529 9673 57 73 10819 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55245 m0 *1 555.22,470.56
X$55245 73 9676 10820 9320 10822 57 73 10821 57 sky130_fd_sc_hd__a31oi_1
* cell instance $55246 m0 *1 557.52,470.56
X$55246 73 9320 10765 10625 10822 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55249 m0 *1 559.36,470.56
X$55249 73 9613 9408 10765 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55255 m0 *1 577.3,470.56
X$55255 73 10715 9761 10823 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55256 m0 *1 578.68,470.56
X$55256 73 10823 73 57 10748 57 sky130_fd_sc_hd__buf_4
* cell instance $55266 m0 *1 592.94,470.56
X$55266 73 10740 10750 10824 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55270 m0 *1 597.54,470.56
X$55270 73 9701 10552 10844 10434 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $55273 m0 *1 602.14,470.56
X$55273 73 9531 73 57 10744 57 sky130_fd_sc_hd__buf_4
* cell instance $55274 m0 *1 604.9,470.56
X$55274 73 10825 10628 9162 73 10826 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55276 m0 *1 607.66,470.56
X$55276 73 9767 10825 9842 10827 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55280 m0 *1 611.34,470.56
X$55280 73 9701 10625 10827 10842 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55286 m0 *1 619.62,470.56
X$55286 73 10829 10625 9701 73 10540 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55289 m0 *1 626.06,470.56
X$55289 73 10828 9767 9603 57 73 10831 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55290 m0 *1 627.9,470.56
X$55290 73 10828 73 57 9616 57 sky130_fd_sc_hd__buf_4
* cell instance $55292 m0 *1 632.5,470.56
X$55292 73 9320 10344 10836 10832 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55294 m0 *1 635.26,470.56
X$55294 73 10832 9320 10831 57 73 10730 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55307 r0 *1 4.6,470.56
X$55307 73 10685 57 73 11011 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55309 r0 *1 8.74,470.56
X$55309 57 10910 10303 10725 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $55313 r0 *1 17.02,470.56
X$55313 73 8620 57 73 10912 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55316 r0 *1 22.08,470.56
X$55316 73 10911 10859 73 10729 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $55317 r0 *1 25.3,470.56
X$55317 57 11066 10860 10913 10863 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $55319 r0 *1 34.5,470.56
X$55319 57 10860 10796 10914 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $55326 r0 *1 55.2,470.56
X$55326 57 10917 10864 10915 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $55334 r0 *1 72.68,470.56
X$55334 73 8203 7647 10866 73 10840 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55335 r0 *1 74.52,470.56
X$55335 73 8875 7756 7647 10866 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $55338 r0 *1 77.74,470.56
X$55338 73 10797 73 57 10867 57 sky130_fd_sc_hd__buf_4
* cell instance $55343 r0 *1 87.4,470.56
X$55343 73 7647 8875 10966 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $55352 r0 *1 105.8,470.56
X$55352 73 8203 9300 8100 73 11104 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55353 r0 *1 107.64,470.56
X$55353 73 10868 8178 9442 57 73 10800 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55362 r0 *1 126.96,470.56
X$55362 73 8475 10923 10843 10869 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55364 r0 *1 130.64,470.56
X$55364 73 7921 10867 9183 10922 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $55367 r0 *1 139.84,470.56
X$55367 73 7756 10647 10924 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55387 r0 *1 183.54,470.56
X$55387 57 11030 10927 9735 9826 9821 10930 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $55391 r0 *1 197.8,470.56
X$55391 73 9821 10313 10871 10933 57 10931 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $55394 r0 *1 201.94,470.56
X$55394 73 10871 10873 9987 10872 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55397 r0 *1 205.62,470.56
X$55397 73 10873 9915 10874 57 73 10932 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55398 r0 *1 207.46,470.56
X$55398 73 9821 10257 9987 10933 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55404 r0 *1 218.5,470.56
X$55404 73 10935 10563 10477 10876 57 73 10803 57 sky130_fd_sc_hd__a31oi_1
* cell instance $55407 r0 *1 222.18,470.56
X$55407 73 10878 73 57 10873 57 sky130_fd_sc_hd__buf_4
* cell instance $55408 r0 *1 224.94,470.56
X$55408 73 10768 73 57 10877 57 sky130_fd_sc_hd__buf_4
* cell instance $55414 r0 *1 237.36,470.56
X$55414 57 9037 73 73 57 sky130_fd_sc_hd__clkinv_16
* cell instance $55415 r0 *1 248.4,470.56
X$55415 73 9989 10878 10944 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55420 r0 *1 259.44,470.56
X$55420 73 10477 10879 10803 73 10770 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55422 r0 *1 261.28,470.56
X$55422 73 10408 10080 10880 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55423 r0 *1 262.66,470.56
X$55423 73 10271 9742 10880 57 73 10881 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55427 r0 *1 267.26,470.56
X$55427 73 9826 11085 10881 10776 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55439 r0 *1 297.16,470.56
X$55439 57 10947 10948 10949 10951 10953 10582 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $55444 r0 *1 307.28,470.56
X$55444 57 10954 10286 10323 10883 9993 10108 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $55452 r0 *1 322.92,470.56
X$55452 57 10884 11123 7095 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $55467 r0 *1 364.78,470.56
X$55467 57 10885 11054 10887 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $55469 r0 *1 372.14,470.56
X$55469 73 10885 73 57 10886 57 sky130_fd_sc_hd__buf_4
* cell instance $55472 r0 *1 375.82,470.56
X$55472 73 10698 73 57 10958 57 sky130_fd_sc_hd__buf_4
* cell instance $55476 r0 *1 381.8,470.56
X$55476 73 10959 73 57 5175 57 sky130_fd_sc_hd__buf_4
* cell instance $55489 r0 *1 408.02,470.56
X$55489 73 10957 73 57 10496 57 sky130_fd_sc_hd__buf_4
* cell instance $55497 r0 *1 425.04,470.56
X$55497 73 2342 7745 10889 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $55502 r0 *1 431.48,470.56
X$55502 73 7745 2342 10991 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55504 r0 *1 434.7,470.56
X$55504 73 10327 10891 10816 10890 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $55505 r0 *1 437,470.56
X$55505 73 10890 73 57 10945 57 sky130_fd_sc_hd__buf_4
* cell instance $55507 r0 *1 440.68,470.56
X$55507 73 7745 4566 2342 10952 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $55508 r0 *1 443.44,470.56
X$55508 73 10952 10817 4566 73 10955 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $55511 r0 *1 448.5,470.56
X$55511 73 10577 73 57 10892 57 sky130_fd_sc_hd__inv_1
* cell instance $55516 r0 *1 453.1,470.56
X$55516 73 10793 10891 10816 10950 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55521 r0 *1 460,470.56
X$55521 73 10577 73 57 8483 57 sky130_fd_sc_hd__buf_4
* cell instance $55527 r0 *1 476.1,470.56
X$55527 73 9389 10126 8813 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55534 r0 *1 489.44,470.56
X$55534 73 10280 8315 10893 57 73 10894 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55535 r0 *1 491.28,470.56
X$55535 73 8836 10894 10851 73 11048 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55537 r0 *1 493.58,470.56
X$55537 73 10284 73 57 10940 57 sky130_fd_sc_hd__buf_4
* cell instance $55553 r0 *1 533.14,470.56
X$55553 57 10939 10654 10937 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $55558 r0 *1 547.4,470.56
X$55558 73 10901 9406 10848 57 73 11044 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55559 r0 *1 549.24,470.56
X$55559 73 10936 10651 9406 9864 10900 73 10901 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $55562 r0 *1 553.84,470.56
X$55562 73 9864 10765 10934 10900 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55566 r0 *1 558.44,470.56
X$55566 73 9926 73 57 10928 57 sky130_fd_sc_hd__buf_4
* cell instance $55567 r0 *1 561.2,470.56
X$55567 73 9926 9408 10902 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $55575 r0 *1 578.68,470.56
X$55575 73 10759 73 57 10926 57 sky130_fd_sc_hd__buf_4
* cell instance $55576 r0 *1 581.44,470.56
X$55576 73 10715 9679 10925 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55580 r0 *1 585.58,470.56
X$55580 73 10921 10627 9856 9321 11027 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $55583 r0 *1 592.48,470.56
X$55583 73 9686 10824 10919 73 10921 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55590 r0 *1 602.6,470.56
X$55590 73 10720 73 57 10918 57 sky130_fd_sc_hd__buf_4
* cell instance $55595 r0 *1 612.26,470.56
X$55595 73 10906 73 57 10908 57 sky130_fd_sc_hd__buf_4
* cell instance $55597 r0 *1 615.02,470.56
X$55597 73 10826 10828 9703 9514 73 10916 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $55598 r0 *1 617.78,470.56
X$55598 73 9675 10916 10908 11335 10830 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $55599 r0 *1 620.54,470.56
X$55599 73 9926 73 57 10222 57 sky130_fd_sc_hd__buf_4
* cell instance $55602 r0 *1 624.68,470.56
X$55602 73 9673 9842 10829 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55604 r0 *1 627.9,470.56
X$55604 73 9703 9603 10828 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55606 r0 *1 631.12,470.56
X$55606 73 10829 10902 9320 73 10909 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55622 m0 *1 10.12,476
X$55622 57 7704 10865 10303 11011 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $55625 m0 *1 21.16,476
X$55625 73 10858 10859 73 10728 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $55628 m0 *1 25.76,476
X$55628 57 10837 10861 10912 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $55630 m0 *1 30.36,476
X$55630 73 10860 10862 73 10861 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $55631 m0 *1 33.58,476
X$55631 73 10863 73 57 10862 57 sky130_fd_sc_hd__buf_4
* cell instance $55639 m0 *1 50.14,476
X$55639 73 10917 57 73 10795 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55644 m0 *1 62.1,476
X$55644 73 10864 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $55649 m0 *1 69.92,476
X$55649 73 11018 73 57 9581 57 sky130_fd_sc_hd__buf_4
* cell instance $55669 m0 *1 114.08,476
X$55669 73 10924 10643 11021 8100 8472 73 10968 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $55671 m0 *1 119.14,476
X$55671 73 10549 10869 10968 11069 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55678 m0 *1 129.72,476
X$55678 73 10969 73 57 10920 57 sky130_fd_sc_hd__buf_4
* cell instance $55686 m0 *1 145.82,476
X$55686 73 10970 57 73 10857 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55691 m0 *1 151.8,476
X$55691 73 10870 9303 10865 11265 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $55693 m0 *1 154.56,476
X$55693 73 7355 73 57 10870 57 sky130_fd_sc_hd__buf_4
* cell instance $55694 m0 *1 157.32,476
X$55694 73 11026 57 73 57 sky130_fd_sc_hd__clkbuf_1
* cell instance $55697 m0 *1 166.06,476
X$55697 73 9303 11028 10055 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55708 m0 *1 187.22,476
X$55708 73 10882 73 57 11032 57 sky130_fd_sc_hd__buf_4
* cell instance $55711 m0 *1 192.74,476
X$55711 73 11032 10871 10477 10872 57 11033 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $55715 m0 *1 198.26,476
X$55715 73 10871 10977 10929 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55716 m0 *1 199.64,476
X$55716 73 10065 10929 10871 10323 10930 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $55724 m0 *1 215.28,476
X$55724 73 9915 10065 10874 73 10763 57 57 sky130_fd_sc_hd__a21oi_2
* cell instance $55725 m0 *1 218.5,476
X$55725 73 10871 10318 10875 10935 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $55730 m0 *1 224.02,476
X$55730 73 10977 10877 10882 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55736 m0 *1 233.22,476
X$55736 73 10478 73 57 10692 57 sky130_fd_sc_hd__buf_4
* cell instance $55739 m0 *1 238.74,476
X$55739 73 10602 9915 10878 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55740 m0 *1 240.12,476
X$55740 73 10768 73 57 10854 57 sky130_fd_sc_hd__buf_4
* cell instance $55742 m0 *1 243.8,476
X$55742 73 11040 73 57 10875 57 sky130_fd_sc_hd__buf_4
* cell instance $55755 m0 *1 275.08,476
X$55755 73 7337 9710 10982 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55759 m0 *1 279.68,476
X$55759 73 10982 73 57 10947 57 sky130_fd_sc_hd__buf_4
* cell instance $55764 m0 *1 287.96,476
X$55764 57 9743 10946 10091 11046 10947 10415 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $55768 m0 *1 296.24,476
X$55768 73 10111 10882 10951 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55769 m0 *1 297.62,476
X$55769 73 10985 9742 9990 10953 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55801 m0 *1 364.78,476
X$55801 73 6762 10392 10956 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $55802 m0 *1 368,476
X$55802 57 11057 6762 10787 8106 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $55808 m0 *1 382.26,476
X$55808 73 10884 10492 11061 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $55821 m0 *1 408.48,476
X$55821 73 8483 8735 10957 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55829 m0 *1 419.98,476
X$55829 73 10990 11206 10701 9146 10812 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $55834 m0 *1 425.04,476
X$55834 73 10888 73 57 10162 57 sky130_fd_sc_hd__buf_4
* cell instance $55835 m0 *1 427.8,476
X$55835 57 10891 10889 10991 11060 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $55836 m0 *1 431.94,476
X$55836 73 10293 10815 10890 10888 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $55844 m0 *1 448.96,476
X$55844 57 15453 10705 9389 10892 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $55850 m0 *1 460,476
X$55850 73 10705 73 57 10421 57 sky130_fd_sc_hd__buf_4
* cell instance $55851 m0 *1 462.76,476
X$55851 57 15535 10995 9389 10769 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $55853 m0 *1 469.2,476
X$55853 73 10945 8815 10293 11355 57 73 10893 57 sky130_fd_sc_hd__a31oi_1
* cell instance $55856 m0 *1 475.64,476
X$55856 73 9389 73 57 11051 57 sky130_fd_sc_hd__inv_1
* cell instance $55863 m0 *1 491.74,476
X$55863 73 10941 10942 9641 11048 10943 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $55873 m0 *1 505.54,476
X$55873 73 9393 8975 10709 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $55876 m0 *1 508.3,476
X$55876 73 10769 11051 9393 10270 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55880 m0 *1 519.34,476
X$55880 57 10939 10127 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $55887 m0 *1 533.14,476
X$55887 57 8104 10654 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $55889 m0 *1 544.18,476
X$55889 73 9439 10896 10895 10937 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $55890 m0 *1 546.48,476
X$55890 73 10899 11044 10897 10847 10898 10896 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $55892 m0 *1 550.62,476
X$55892 57 10128 10934 11041 10338 10820 11002 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $55896 m0 *1 557.52,476
X$55896 73 9409 10462 10898 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55902 m0 *1 562.12,476
X$55902 73 10902 73 57 10934 57 sky130_fd_sc_hd__buf_4
* cell instance $55906 m0 *1 573.16,476
X$55906 73 9244 9438 10627 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55907 m0 *1 574.54,476
X$55907 73 10552 11004 9161 10461 57 73 11031 57 sky130_fd_sc_hd__a31oi_1
* cell instance $55909 m0 *1 578.68,476
X$55909 73 11005 11031 10903 10756 57 10899 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $55912 m0 *1 582.36,476
X$55912 73 10925 9406 11006 10642 73 11005 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $55913 m0 *1 584.66,476
X$55913 73 9675 10714 10642 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55918 m0 *1 588.8,476
X$55918 73 9703 9678 10904 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $55919 m0 *1 590.18,476
X$55919 73 10356 10904 9701 11006 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $55920 m0 *1 592.94,476
X$55920 73 10904 73 57 10844 57 sky130_fd_sc_hd__buf_4
* cell instance $55921 m0 *1 595.7,476
X$55921 73 10905 11025 9686 73 10919 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55923 m0 *1 599.38,476
X$55923 73 11008 73 57 10026 57 sky130_fd_sc_hd__buf_4
* cell instance $55924 m0 *1 602.14,476
X$55924 57 9701 11019 9161 10744 11008 11006 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $55929 m0 *1 610.42,476
X$55929 73 9320 10907 10827 10905 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $55930 m0 *1 612.26,476
X$55930 73 10902 73 57 10907 57 sky130_fd_sc_hd__buf_4
* cell instance $55933 m0 *1 615.02,476
X$55933 73 9701 10341 10907 11016 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $55937 m0 *1 625.6,476
X$55937 73 10429 73 57 10231 57 sky130_fd_sc_hd__buf_4
* cell instance $55940 m0 *1 629.74,476
X$55940 73 9701 10828 9675 73 11014 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55943 m0 *1 634.34,476
X$55943 73 9320 10831 10909 73 11095 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $55955 r0 *1 2.3,476
X$55955 73 9469 57 73 11012 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55956 r0 *1 5.98,476
X$55956 73 10961 57 73 10963 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55959 r0 *1 12.42,476
X$55959 57 10962 7998 11013 7704 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $55964 r0 *1 16.56,476
X$55964 57 10859 10796 10962 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $55966 r0 *1 27.6,476
X$55966 57 10727 10796 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $55975 r0 *1 44.16,476
X$55975 57 7704 10967 10796 10963 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $55980 r0 *1 62.1,476
X$55980 57 7608 10864 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $55987 r0 *1 76.36,476
X$55987 73 7756 8469 10797 57 73 11018 57 sky130_fd_sc_hd__a21oi_1
* cell instance $55990 r0 *1 85.56,476
X$55990 73 10966 8469 7921 8676 57 73 10241 57 sky130_fd_sc_hd__a31oi_1
* cell instance $55992 r0 *1 88.32,476
X$55992 73 9024 73 57 11101 57 sky130_fd_sc_hd__buf_4
* cell instance $55995 r0 *1 95.68,476
X$55995 73 9625 10966 9953 7756 8100 73 11021 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $56013 r0 *1 126.96,476
X$56013 57 11023 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $56019 r0 *1 146.74,476
X$56019 57 10970 11026 10972 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56025 r0 *1 155.02,476
X$56025 73 10971 10870 73 10972 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $56027 r0 *1 158.7,476
X$56027 73 10973 6952 73 10915 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $56029 r0 *1 162.84,476
X$56029 73 10974 10973 11028 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56040 r0 *1 183.08,476
X$56040 73 9735 11109 11030 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56047 r0 *1 198.72,476
X$56047 73 9735 10931 10975 11766 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $56049 r0 *1 201.48,476
X$56049 73 10065 10871 10976 57 73 11034 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56051 r0 *1 204.24,476
X$56051 73 10313 9915 10976 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56064 r0 *1 227.7,476
X$56064 73 10602 9915 11037 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56069 r0 *1 232.76,476
X$56069 57 11082 11081 9741 10478 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $56070 r0 *1 235.06,476
X$56070 73 9892 9915 10977 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56075 r0 *1 240.12,476
X$56075 73 9832 10080 10978 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56076 r0 *1 241.5,476
X$56076 73 9742 11040 10978 57 73 11039 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56077 r0 *1 243.34,476
X$56077 73 10804 9915 11040 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56080 r0 *1 246.1,476
X$56080 73 9741 9998 10981 57 73 10975 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56081 r0 *1 247.94,476
X$56081 73 10508 10980 10979 10981 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $56084 r0 *1 257.14,476
X$56084 73 10982 73 57 11042 57 sky130_fd_sc_hd__buf_4
* cell instance $56089 r0 *1 261.74,476
X$56089 73 10880 73 57 10979 57 sky130_fd_sc_hd__buf_4
* cell instance $56094 r0 *1 273.24,476
X$56094 57 15610 10983 9993 10266 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $56096 r0 *1 278.3,476
X$56096 73 10983 73 57 9827 57 sky130_fd_sc_hd__buf_4
* cell instance $56098 r0 *1 281.98,476
X$56098 73 10983 10601 10984 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56101 r0 *1 284.74,476
X$56101 73 9742 10984 10980 57 73 11046 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56102 r0 *1 286.58,476
X$56102 73 10883 73 57 11047 57 sky130_fd_sc_hd__buf_4
* cell instance $56113 r0 *1 304.52,476
X$56113 73 10091 9990 11143 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56120 r0 *1 314.18,476
X$56120 73 10984 73 57 10986 57 sky130_fd_sc_hd__buf_4
* cell instance $56122 r0 *1 317.86,476
X$56122 73 10111 10986 10417 57 73 11195 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56125 r0 *1 321.08,476
X$56125 73 9742 10321 10986 57 73 10987 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56128 r0 *1 325.22,476
X$56128 73 11810 73 57 11052 57 sky130_fd_sc_hd__buf_4
* cell instance $56131 r0 *1 329.36,476
X$56131 57 11467 11052 10513 10987 11053 10681 73 73 57
+ sky130_fd_sc_hd__o311ai_1
* cell instance $56143 r0 *1 352.82,476
X$56143 57 11056 11054 6760 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56148 r0 *1 367.08,476
X$56148 73 11057 10856 9355 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56152 r0 *1 370.3,476
X$56152 73 6762 9920 73 10988 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $56156 r0 *1 375.36,476
X$56156 57 7855 10988 11058 10789 73 73 57 sky130_fd_sc_hd__xnor3_2
* cell instance $56157 r0 *1 384.1,476
X$56157 57 11060 11061 11062 11235 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $56159 r0 *1 392.84,476
X$56159 57 11062 11063 10989 8106 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $56173 r0 *1 420.9,476
X$56173 73 10990 8735 8483 10120 57 73 11059 57 sky130_fd_sc_hd__a31oi_1
* cell instance $56182 r0 *1 430.56,476
X$56182 57 10992 10889 10991 11060 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $56185 r0 *1 438.84,476
X$56185 73 10993 73 57 8644 57 sky130_fd_sc_hd__buf_4
* cell instance $56186 r0 *1 441.6,476
X$56186 73 10992 10955 10993 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56187 r0 *1 442.98,476
X$56187 57 10993 8975 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $56191 r0 *1 450.34,476
X$56191 73 10892 73 57 10994 57 sky130_fd_sc_hd__buf_4
* cell instance $56192 r0 *1 453.1,476
X$56192 73 10994 73 57 8968 57 sky130_fd_sc_hd__buf_4
* cell instance $56196 r0 *1 458.62,476
X$56196 73 10995 10705 11055 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56197 r0 *1 460,476
X$56197 73 10995 73 57 10425 57 sky130_fd_sc_hd__buf_4
* cell instance $56202 r0 *1 475.64,476
X$56202 73 8813 73 57 11050 57 sky130_fd_sc_hd__buf_4
* cell instance $56209 r0 *1 481.62,476
X$56209 73 10989 73 57 8993 57 sky130_fd_sc_hd__buf_4
* cell instance $56213 r0 *1 486.22,476
X$56213 57 10989 10424 10943 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56214 r0 *1 493.58,476
X$56214 73 11049 10996 10850 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56218 r0 *1 501.4,476
X$56218 73 10710 73 57 10997 57 sky130_fd_sc_hd__buf_4
* cell instance $56222 r0 *1 504.16,476
X$56222 73 10997 11114 10996 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56236 r0 *1 533.14,476
X$56236 73 10654 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $56242 r0 *1 545.1,476
X$56242 73 9161 9438 10897 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56243 r0 *1 546.48,476
X$56243 73 10897 10998 11036 10999 11045 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $56245 r0 *1 550.16,476
X$56245 73 9438 10218 11043 10999 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $56247 r0 *1 552.46,476
X$56247 73 9409 11000 11041 73 11001 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $56248 r0 *1 554.3,476
X$56248 73 11001 9406 11161 11108 57 10895 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $56253 r0 *1 558.9,476
X$56253 73 10844 11002 11038 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56254 r0 *1 560.28,476
X$56254 73 10928 11038 9676 9320 9703 11003 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $56255 r0 *1 563.5,476
X$56255 73 9438 9930 11003 9534 10552 73 11036 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $56262 r0 *1 571.78,476
X$56262 73 9438 73 57 11035 57 sky130_fd_sc_hd__buf_4
* cell instance $56265 r0 *1 575.92,476
X$56265 73 9758 9320 11004 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56267 r0 *1 577.76,476
X$56267 73 11004 10820 11007 10844 9320 11000 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $56274 r0 *1 586.04,476
X$56274 73 11007 10717 9701 10926 57 73 11107 57 sky130_fd_sc_hd__a31oi_1
* cell instance $56281 r0 *1 599.38,476
X$56281 73 9531 11008 10628 73 11022 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $56282 r0 *1 601.22,476
X$56282 73 9414 9678 11008 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56285 r0 *1 603.98,476
X$56285 73 10628 9775 11008 11105 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $56293 r0 *1 614.56,476
X$56293 57 10628 11017 9161 10828 10026 11016 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $56299 r0 *1 626.52,476
X$56299 73 11014 11099 10438 10231 11009 73 11015 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $56315 m0 *1 4.14,481.44
X$56315 73 11094 57 73 11064 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56317 m0 *1 8.28,481.44
X$56317 57 7704 11068 10303 11012 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $56318 m0 *1 19.32,481.44
X$56318 73 11070 8529 73 11065 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $56320 m0 *1 23,481.44
X$56320 73 11066 10859 73 7998 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $56324 m0 *1 34.04,481.44
X$56324 57 11172 7306 4054 73 73 57 sky130_fd_sc_hd__xnor2_4
* cell instance $56335 m0 *1 64.86,481.44
X$56335 73 11173 73 57 4679 57 sky130_fd_sc_hd__buf_4
* cell instance $56344 m0 *1 89.24,481.44
X$56344 73 10745 11101 11069 11382 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $56350 m0 *1 107.64,481.44
X$56350 73 11071 11104 10868 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56351 m0 *1 109.02,481.44
X$56351 73 7756 8347 9085 57 73 11071 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56357 m0 *1 122.36,481.44
X$56357 57 10752 11106 11072 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $56359 m0 *1 126.5,481.44
X$56359 57 10727 11023 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $56366 m0 *1 145.82,481.44
X$56366 73 11073 11024 11933 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56367 m0 *1 149.04,481.44
X$56367 57 11073 11026 11074 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56368 m0 *1 156.4,481.44
X$56368 57 9037 11026 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $56377 m0 *1 186.76,481.44
X$56377 73 11075 73 57 11109 57 sky130_fd_sc_hd__buf_4
* cell instance $56378 m0 *1 189.52,481.44
X$56378 73 11077 11076 10369 11110 10653 73 11074 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $56379 m0 *1 192.74,481.44
X$56379 73 9989 11110 10876 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56389 m0 *1 218.04,481.44
X$56389 73 10871 11078 10877 57 73 11079 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56390 m0 *1 219.88,481.44
X$56390 73 11079 10871 10763 57 73 11116 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56396 m0 *1 229.08,481.44
X$56396 73 10573 11080 10871 11081 57 73 11075 57 sky130_fd_sc_hd__a31oi_1
* cell instance $56398 m0 *1 235.06,481.44
X$56398 73 11082 73 57 10980 57 sky130_fd_sc_hd__buf_4
* cell instance $56399 m0 *1 237.82,481.44
X$56399 73 10486 9915 11082 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56401 m0 *1 242.88,481.44
X$56401 73 10978 73 57 11084 57 sky130_fd_sc_hd__buf_4
* cell instance $56402 m0 *1 245.64,481.44
X$56402 73 10381 73 57 11078 57 sky130_fd_sc_hd__buf_4
* cell instance $56409 m0 *1 254.38,481.44
X$56409 57 11196 9740 10266 11042 10323 9741 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $56410 m0 *1 257.6,481.44
X$56410 73 11042 73 57 11085 57 sky130_fd_sc_hd__buf_4
* cell instance $56412 m0 *1 261.28,481.44
X$56412 73 11139 9915 10381 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56413 m0 *1 262.66,481.44
X$56413 73 9827 11197 11087 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56417 m0 *1 267.26,481.44
X$56417 73 10272 73 57 10985 57 sky130_fd_sc_hd__buf_4
* cell instance $56418 m0 *1 270.02,481.44
X$56418 73 9801 73 57 10477 57 sky130_fd_sc_hd__buf_4
* cell instance $56422 m0 *1 278.76,481.44
X$56422 57 11086 10609 10108 9710 9993 10874 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $56425 m0 *1 286.12,481.44
X$56425 73 11120 10320 11086 73 10674 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $56430 m0 *1 296.7,481.44
X$56430 57 11122 9740 9892 11087 9993 10780 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $56439 m0 *1 317.86,481.44
X$56439 73 11123 57 73 57 sky130_fd_sc_hd__clkbuf_1
* cell instance $56440 m0 *1 319.24,481.44
X$56440 57 9037 11123 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $56447 m0 *1 341.32,481.44
X$56447 73 8745 73 57 11070 57 sky130_fd_sc_hd__buf_4
* cell instance $56450 m0 *1 346.84,481.44
X$56450 73 11209 73 57 8745 57 sky130_fd_sc_hd__buf_4
* cell instance $56453 m0 *1 351.9,481.44
X$56453 57 7905 11054 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $56459 m0 *1 371.68,481.44
X$56459 57 11212 8993 8051 10492 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $56460 m0 *1 379.96,481.44
X$56460 57 10959 11121 11058 11061 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $56463 m0 *1 389.16,481.44
X$56463 57 11119 11088 10784 10127 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $56464 m0 *1 397.44,481.44
X$56464 73 11089 11118 8365 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56467 m0 *1 402.04,481.44
X$56467 73 11208 73 57 9666 57 sky130_fd_sc_hd__buf_4
* cell instance $56479 m0 *1 434.24,481.44
X$56479 73 9667 11059 9449 8968 10327 11203 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $56486 m0 *1 445.74,481.44
X$56486 73 11090 8975 9720 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56490 m0 *1 453.1,481.44
X$56490 73 11091 10992 10955 57 73 11117 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56491 m0 *1 454.94,481.44
X$56491 57 15529 11090 11051 10994 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $56493 m0 *1 460,481.44
X$56493 73 11051 73 57 9273 57 sky130_fd_sc_hd__buf_4
* cell instance $56494 m0 *1 462.76,481.44
X$56494 57 15465 11091 11051 10769 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $56499 m0 *1 472.88,481.44
X$56499 73 10018 8653 9667 57 73 11049 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56512 m0 *1 504.62,481.44
X$56512 73 8975 11113 9393 57 73 11114 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56514 m0 *1 506.92,481.44
X$56514 73 11112 73 57 9602 57 sky130_fd_sc_hd__buf_4
* cell instance $56515 m0 *1 509.68,481.44
X$56515 57 11112 10575 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $56523 m0 *1 532.68,481.44
X$56523 57 10492 10654 11111 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56527 m0 *1 551.08,481.44
X$56527 73 9412 10560 11108 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56533 m0 *1 563.96,481.44
X$56533 57 15561 11185 9701 9703 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $56536 m0 *1 569.94,481.44
X$56536 73 9320 73 57 10628 57 sky130_fd_sc_hd__buf_4
* cell instance $56544 m0 *1 587.42,481.44
X$56544 73 9161 11107 10645 73 11170 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $56547 m0 *1 596.62,481.44
X$56547 73 11164 11092 11022 11035 57 73 10903 57 sky130_fd_sc_hd__and4_1
* cell instance $56550 m0 *1 602.6,481.44
X$56550 73 9766 10748 11105 10628 9323 73 11102 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $56552 m0 *1 606.74,481.44
X$56552 73 11339 9323 9161 11102 57 9933 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $56555 m0 *1 611.8,481.44
X$56555 73 9320 10936 10220 57 73 11103 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56557 m0 *1 617.32,481.44
X$56557 73 9603 11009 10936 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $56559 m0 *1 621.46,481.44
X$56559 73 10029 11093 11092 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56560 m0 *1 622.84,481.44
X$56560 73 10029 73 57 11009 57 sky130_fd_sc_hd__buf_4
* cell instance $56562 m0 *1 626.52,481.44
X$56562 73 9703 9845 11099 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56564 m0 *1 631.58,481.44
X$56564 73 10909 73 57 11097 57 sky130_fd_sc_hd__buf_4
* cell instance $56565 m0 *1 634.34,481.44
X$56565 73 11095 9686 9244 10444 57 11096 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $56574 r0 *1 2.3,481.44
X$56574 73 10960 57 73 11067 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56576 r0 *1 6.9,481.44
X$56576 57 11094 10796 10964 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56578 r0 *1 14.72,481.44
X$56578 73 7704 11167 8598 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56583 r0 *1 19.32,481.44
X$56583 73 11215 57 73 11168 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56586 r0 *1 27.6,481.44
X$56586 57 10796 73 73 57 sky130_fd_sc_hd__bufinv_16
* cell instance $56587 r0 *1 38.64,481.44
X$56587 73 7704 11255 11171 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56588 r0 *1 40.02,481.44
X$56588 57 11172 11125 11100 8663 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $56593 r0 *1 46.46,481.44
X$56593 57 7704 11020 10796 11067 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $56597 r0 *1 62.56,481.44
X$56597 73 11174 7520 11173 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56603 r0 *1 73.6,481.44
X$56603 73 11126 7605 73 10964 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $56614 r0 *1 103.5,481.44
X$56614 73 11024 73 57 11176 57 sky130_fd_sc_hd__buf_4
* cell instance $56617 r0 *1 111.78,481.44
X$56617 57 11490 11178 7605 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $56621 r0 *1 122.82,481.44
X$56621 73 11128 11127 73 11072 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $56625 r0 *1 126.96,481.44
X$56625 73 11129 11130 11181 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56626 r0 *1 130.18,481.44
X$56626 73 11131 7185 73 10441 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $56629 r0 *1 135.7,481.44
X$56629 57 11182 10967 11181 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $56630 r0 *1 139.38,481.44
X$56630 57 11183 11182 7185 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $56631 r0 *1 145.36,481.44
X$56631 57 11183 11115 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $56636 r0 *1 154.56,481.44
X$56636 73 9303 10870 11184 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $56637 r0 *1 156.86,481.44
X$56637 73 9660 73 57 11132 57 sky130_fd_sc_hd__buf_4
* cell instance $56638 r0 *1 159.62,481.44
X$56638 73 11073 73 57 9905 57 sky130_fd_sc_hd__buf_4
* cell instance $56652 r0 *1 192.74,481.44
X$56652 73 9964 73 57 11110 57 sky130_fd_sc_hd__buf_4
* cell instance $56655 r0 *1 201.02,481.44
X$56655 73 10477 11034 11362 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56657 r0 *1 202.86,481.44
X$56657 73 10876 73 57 11443 57 sky130_fd_sc_hd__buf_4
* cell instance $56660 r0 *1 206.54,481.44
X$56660 73 10111 73 57 10871 57 sky130_fd_sc_hd__buf_4
* cell instance $56662 r0 *1 209.76,481.44
X$56662 73 4302 9879 11272 73 11270 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $56670 r0 *1 229.54,481.44
X$56670 73 9741 11084 11037 57 73 11136 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56671 r0 *1 231.38,481.44
X$56671 73 11081 11136 11138 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56676 r0 *1 237.36,481.44
X$56676 73 11047 11137 11085 11116 11773 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $56679 r0 *1 243.8,481.44
X$56679 73 11194 11078 10111 11195 57 73 11137 57 sky130_fd_sc_hd__a31oi_1
* cell instance $56684 r0 *1 255.76,481.44
X$56684 73 11196 73 57 12699 57 sky130_fd_sc_hd__buf_4
* cell instance $56688 r0 *1 259.9,481.44
X$56688 73 9741 10601 11197 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56690 r0 *1 261.74,481.44
X$56690 73 9993 11197 10977 57 73 11199 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56693 r0 *1 264.96,481.44
X$56693 73 10486 73 57 11139 57 sky130_fd_sc_hd__inv_1
* cell instance $56696 r0 *1 271.86,481.44
X$56696 73 10980 11084 11085 10111 10772 73 11201 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $56698 r0 *1 276.92,481.44
X$56698 73 7337 9801 11141 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56700 r0 *1 278.76,481.44
X$56700 73 11141 73 57 11202 57 sky130_fd_sc_hd__buf_4
* cell instance $56711 r0 *1 301.76,481.44
X$56711 73 10486 73 57 11205 57 sky130_fd_sc_hd__buf_4
* cell instance $56712 r0 *1 304.52,481.44
X$56712 73 11143 73 57 10318 57 sky130_fd_sc_hd__buf_4
* cell instance $56713 r0 *1 307.28,481.44
X$56713 73 11144 73 57 10405 57 sky130_fd_sc_hd__buf_4
* cell instance $56714 r0 *1 310.04,481.44
X$56714 73 11144 73 57 10321 57 sky130_fd_sc_hd__buf_4
* cell instance $56715 r0 *1 312.8,481.44
X$56715 73 10512 4624 11207 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56718 r0 *1 314.64,481.44
X$56718 73 9832 9915 11144 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56723 r0 *1 321.54,481.44
X$56723 73 11290 73 57 10175 57 sky130_fd_sc_hd__buf_4
* cell instance $56736 r0 *1 352.82,481.44
X$56736 73 11054 73 57 57 sky130_fd_sc_hd__clkinv_2
* cell instance $56741 r0 *1 366.62,481.44
X$56741 73 11056 8109 11211 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56744 r0 *1 371.68,481.44
X$56744 73 11212 10958 11500 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56747 r0 *1 376.28,481.44
X$56747 73 11292 11213 11146 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56750 r0 *1 380.88,481.44
X$56750 73 11146 10787 11214 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56753 r0 *1 385.48,481.44
X$56753 57 11121 7976 11063 10515 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $56755 r0 *1 394.68,481.44
X$56755 73 11088 8262 11089 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56757 r0 *1 397.9,481.44
X$56757 73 11210 11089 8141 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56765 r0 *1 409.86,481.44
X$56765 73 8150 11150 11149 11208 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $56768 r0 *1 413.08,481.44
X$56768 73 9646 11151 9277 57 73 11149 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56769 r0 *1 414.92,481.44
X$56769 73 11151 73 57 9748 57 sky130_fd_sc_hd__buf_4
* cell instance $56771 r0 *1 418.14,481.44
X$56771 73 10327 8644 11151 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $56784 r0 *1 444.36,481.44
X$56784 73 11152 8644 10293 11204 57 11150 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $56785 r0 *1 447.12,481.44
X$56785 57 11090 10327 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $56791 r0 *1 458.16,481.44
X$56791 73 11055 73 57 11152 57 sky130_fd_sc_hd__buf_4
* cell instance $56792 r0 *1 460.92,481.44
X$56792 73 11090 73 57 11113 57 sky130_fd_sc_hd__buf_4
* cell instance $56795 r0 *1 466.44,481.44
X$56795 73 11091 73 57 8926 57 sky130_fd_sc_hd__buf_4
* cell instance $56800 r0 *1 478.4,481.44
X$56800 73 8314 11155 11156 10057 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $56801 r0 *1 480.24,481.44
X$56801 73 10570 10769 9646 57 73 11156 57 sky130_fd_sc_hd__a21oi_1
* cell instance $56802 r0 *1 482.08,481.44
X$56802 73 10623 11156 11354 10018 11157 11285 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $56807 r0 *1 488.98,481.44
X$56807 73 10570 73 57 11193 57 sky130_fd_sc_hd__buf_4
* cell instance $56810 r0 *1 494.04,481.44
X$56810 73 10769 11051 11511 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56814 r0 *1 503.7,481.44
X$56814 73 10957 10712 8150 73 11192 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $56816 r0 *1 505.54,481.44
X$56816 57 15666 11112 11051 10769 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $56817 r0 *1 510.14,481.44
X$56817 73 11159 10713 8975 10018 73 57 11157 57 sky130_fd_sc_hd__o31ai_1
* cell instance $56833 r0 *1 548.78,481.44
X$56833 73 9320 10820 10427 11190 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $56837 r0 *1 553.84,481.44
X$56837 73 9679 11189 9406 11108 57 73 11188 57 sky130_fd_sc_hd__a31oi_1
* cell instance $56843 r0 *1 564.88,481.44
X$56843 73 10560 9760 9761 11185 10248 11273 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $56845 r0 *1 568.56,481.44
X$56845 73 10628 10626 11098 11160 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $56852 r0 *1 586.04,481.44
X$56852 73 9701 10040 10717 11177 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $56857 r0 *1 596.16,481.44
X$56857 73 9244 9161 11164 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $56858 r0 *1 597.54,481.44
X$56858 73 11164 73 57 9930 57 sky130_fd_sc_hd__buf_4
* cell instance $56865 r0 *1 618.7,481.44
X$56865 73 10448 11035 11170 11166 73 11169 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $56871 r0 *1 626.52,481.44
X$56871 73 10836 73 57 11098 57 sky130_fd_sc_hd__buf_4
* cell instance $56872 r0 *1 629.28,481.44
X$56872 73 9930 11097 11594 11166 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $56875 r0 *1 635.26,481.44
X$56875 73 11096 73 57 11162 57 sky130_fd_sc_hd__buf_4
* cell instance $56934 m0 *1 4.14,486.88
X$56934 73 11124 57 73 11249 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56937 m0 *1 9.2,486.88
X$56937 57 7704 11106 10796 11249 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $56938 m0 *1 20.24,486.88
X$56938 73 7704 11066 11253 73 11254 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $56940 m0 *1 22.54,486.88
X$56940 57 10913 10796 11254 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56946 m0 *1 39.1,486.88
X$56946 73 7704 11220 11171 73 11256 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $56947 m0 *1 40.94,486.88
X$56947 57 11258 10796 11256 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56950 m0 *1 51.06,486.88
X$56950 73 11222 73 57 11379 57 sky130_fd_sc_hd__buf_4
* cell instance $56952 m0 *1 54.74,486.88
X$56952 73 11223 73 57 6730 57 sky130_fd_sc_hd__buf_4
* cell instance $56958 m0 *1 64.86,486.88
X$56958 57 9940 10864 11180 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56961 m0 *1 77.74,486.88
X$56961 73 7226 73 57 8663 57 sky130_fd_sc_hd__buf_4
* cell instance $56962 m0 *1 80.5,486.88
X$56962 73 11261 11224 11100 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56971 m0 *1 99.36,486.88
X$56971 57 11175 11226 10503 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56976 m0 *1 113.16,486.88
X$56976 57 11178 11068 11179 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $56980 m0 *1 120.06,486.88
X$56980 73 11127 11224 73 11179 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $56982 m0 *1 123.74,486.88
X$56982 57 11128 11126 11131 10920 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $56983 m0 *1 132.02,486.88
X$56983 57 11129 11126 11176 11132 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $56985 m0 *1 140.76,486.88
X$56985 73 11305 73 57 11130 57 sky130_fd_sc_hd__buf_4
* cell instance $56990 m0 *1 150.42,486.88
X$56990 73 10865 11184 11265 73 11267 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $56993 m0 *1 155.02,486.88
X$56993 73 11132 10845 11268 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $56994 m0 *1 158.24,486.88
X$56994 57 11269 10971 9660 10845 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $56998 m0 *1 168.36,486.88
X$56998 57 9660 11227 11133 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $56999 m0 *1 175.72,486.88
X$56999 57 10753 11227 11270 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57013 m0 *1 215.74,486.88
X$57013 73 10064 11134 11135 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57014 m0 *1 217.12,486.88
X$57014 73 9742 10875 11228 57 73 11134 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57016 m0 *1 220.8,486.88
X$57016 73 11085 11135 11274 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57029 m0 *1 251.16,486.88
X$57029 73 4624 11138 11198 10697 11085 11280 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $57033 m0 *1 262.66,486.88
X$57033 57 11198 10286 9993 11199 11139 11140 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $57035 m0 *1 266.8,486.88
X$57035 73 9796 9832 11140 57 73 11200 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57036 m0 *1 268.64,486.88
X$57036 73 10108 73 57 11140 57 sky130_fd_sc_hd__buf_4
* cell instance $57039 m0 *1 272.78,486.88
X$57039 73 11139 10695 11084 73 11229 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57047 m0 *1 291.18,486.88
X$57047 73 11284 12165 9743 11201 57 10852 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $57053 m0 *1 304.06,486.88
X$57053 73 9742 11143 10875 57 73 11142 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57055 m0 *1 306.36,486.88
X$57055 73 11142 11229 10004 73 11286 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57057 m0 *1 308.66,486.88
X$57057 57 11464 11123 11231 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57058 m0 *1 316.02,486.88
X$57058 73 9832 9742 11145 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57060 m0 *1 317.86,486.88
X$57060 73 11145 73 57 11400 57 sky130_fd_sc_hd__buf_4
* cell instance $57069 m0 *1 339.94,486.88
X$57069 57 11209 11054 11291 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57072 m0 *1 351.9,486.88
X$57072 73 7096 73 57 11233 57 sky130_fd_sc_hd__buf_4
* cell instance $57080 m0 *1 369.84,486.88
X$57080 73 7096 8106 73 11213 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57082 m0 *1 373.52,486.88
X$57082 73 11213 11118 11476 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57084 m0 *1 378.58,486.88
X$57084 57 11058 11293 10787 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $57086 m0 *1 385.48,486.88
X$57086 73 11058 8186 73 11118 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57089 m0 *1 389.62,486.88
X$57089 73 11119 10988 11147 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57091 m0 *1 394.68,486.88
X$57091 73 10784 11148 11210 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57094 m0 *1 399.28,486.88
X$57094 57 8221 11233 11148 4809 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57098 m0 *1 412.62,486.88
X$57098 57 11299 9791 11147 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $57101 m0 *1 418.6,486.88
X$57101 73 10990 10120 11236 11298 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $57102 m0 *1 420.44,486.88
X$57102 73 11236 8926 10268 57 73 11206 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57115 m0 *1 450.34,486.88
X$57115 73 10950 73 57 11204 57 sky130_fd_sc_hd__buf_4
* cell instance $57118 m0 *1 457.7,486.88
X$57118 73 10950 73 57 11239 57 sky130_fd_sc_hd__buf_4
* cell instance $57119 m0 *1 460.46,486.88
X$57119 73 11153 73 57 10291 57 sky130_fd_sc_hd__buf_4
* cell instance $57120 m0 *1 463.22,486.88
X$57120 73 10293 11239 11154 11153 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $57121 m0 *1 465.06,486.88
X$57121 73 10769 10126 11154 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57123 m0 *1 468.28,486.88
X$57123 57 9752 11238 8410 10574 11240 11285 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $57125 m0 *1 471.96,486.88
X$57125 73 11154 73 57 8653 57 sky130_fd_sc_hd__buf_4
* cell instance $57132 m0 *1 494.96,486.88
X$57132 73 10769 11461 11158 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57133 m0 *1 496.34,486.88
X$57133 73 11158 73 57 10372 57 sky130_fd_sc_hd__buf_4
* cell instance $57136 m0 *1 503.24,486.88
X$57136 73 11158 11113 9393 57 73 11191 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57140 m0 *1 508.3,486.88
X$57140 73 11282 8975 11283 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57142 m0 *1 510.14,486.88
X$57142 57 11282 11159 10471 10769 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $57155 m0 *1 545.1,486.88
X$57155 73 11045 11244 11277 11279 73 11111 57 57 sky130_fd_sc_hd__nand4b_1
* cell instance $57156 m0 *1 548.32,486.88
X$57156 73 9320 11278 11190 73 11043 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57162 m0 *1 556.14,486.88
X$57162 73 10928 9864 10714 73 11275 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57166 m0 *1 563.96,486.88
X$57166 57 10560 11187 11273 11186 11160 9406 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $57167 m0 *1 567.18,486.88
X$57167 73 9246 10338 11162 11271 11244 73 57 57 sky130_fd_sc_hd__or4_1
* cell instance $57168 m0 *1 569.94,486.88
X$57168 73 9701 9530 9762 57 73 11186 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57172 m0 *1 577.76,486.88
X$57172 73 9161 9703 11163 10714 57 11264 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $57173 m0 *1 580.52,486.88
X$57173 73 9673 9161 11163 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57177 m0 *1 583.74,486.88
X$57177 73 10039 73 57 10437 57 sky130_fd_sc_hd__buf_4
* cell instance $57180 m0 *1 591.1,486.88
X$57180 73 9246 9409 9321 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57182 m0 *1 592.94,486.88
X$57182 73 11257 73 57 11007 57 sky130_fd_sc_hd__buf_4
* cell instance $57183 m0 *1 595.7,486.88
X$57183 73 9701 10034 11260 11025 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $57187 m0 *1 603.52,486.88
X$57187 73 11165 9323 11035 11019 73 11516 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $57188 m0 *1 605.82,486.88
X$57188 57 9845 10825 11165 9848 10437 9603 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $57207 r0 *1 2.3,486.88
X$57207 73 8058 57 73 11334 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57210 r0 *1 7.36,486.88
X$57210 57 11251 10796 11217 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57211 r0 *1 14.72,486.88
X$57211 73 7704 11252 11253 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57217 r0 *1 17.02,486.88
X$57217 57 8385 11218 11219 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $57218 r0 *1 23,486.88
X$57218 57 7704 11125 10796 11168 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $57219 r0 *1 34.04,486.88
X$57219 73 8785 57 73 11255 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57220 r0 *1 37.72,486.88
X$57220 73 11220 4052 73 11223 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57227 r0 *1 44.16,486.88
X$57227 57 11220 11175 11258 11222 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57229 r0 *1 52.9,486.88
X$57229 73 11301 57 73 11259 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57231 r0 *1 57.04,486.88
X$57231 57 7704 10965 10864 11259 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $57242 r0 *1 79.58,486.88
X$57242 73 11126 11221 73 11261 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57246 r0 *1 87.86,486.88
X$57246 73 11225 57 73 11216 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57247 r0 *1 91.54,486.88
X$57247 57 11225 11226 11262 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57255 r0 *1 102.58,486.88
X$57255 57 10727 11226 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $57259 r0 *1 120.06,486.88
X$57259 73 11263 7656 73 11180 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57260 r0 *1 123.28,486.88
X$57260 73 11176 9374 11127 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57265 r0 *1 126.96,486.88
X$57265 57 11430 10592 11348 8663 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $57266 r0 *1 130.64,486.88
X$57266 57 11224 11131 11132 11263 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57267 r0 *1 138.92,486.88
X$57267 73 11221 10969 73 11305 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57269 r0 *1 143.06,486.88
X$57269 57 10751 10965 11350 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $57271 r0 *1 147.2,486.88
X$57271 73 11266 7804 73 11352 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57278 r0 *1 156.4,486.88
X$57278 57 11029 11269 11357 11935 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57281 r0 *1 170.2,486.88
X$57281 73 11359 4968 73 11262 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57292 r0 *1 193.2,486.88
X$57292 73 9735 9964 11308 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57295 r0 *1 198.72,486.88
X$57295 73 10871 10977 10692 11361 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $57301 r0 *1 206.08,486.88
X$57301 73 9742 11078 10692 57 73 11363 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57308 r0 *1 212.98,486.88
X$57308 73 10977 73 57 11310 57 sky130_fd_sc_hd__buf_4
* cell instance $57320 r0 *1 237.36,486.88
X$57320 73 10878 11448 10111 73 11366 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57350 r0 *1 303.6,486.88
X$57350 73 11122 9976 9989 11371 57 11230 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $57353 r0 *1 307.74,486.88
X$57353 73 11287 11286 9989 11230 57 73 11232 57 sky130_fd_sc_hd__a31oi_1
* cell instance $57354 r0 *1 310.04,486.88
X$57354 73 10938 11402 11207 11232 73 11231 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $57359 r0 *1 315.1,486.88
X$57359 73 11145 11289 12041 10091 10195 73 11290 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $57381 r0 *1 361.56,486.88
X$57381 73 11056 73 57 11088 57 sky130_fd_sc_hd__buf_4
* cell instance $57382 r0 *1 364.32,486.88
X$57382 57 11368 10886 9920 8106 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $57388 r0 *1 375.36,486.88
X$57388 73 11088 11148 73 11292 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57389 r0 *1 378.58,486.88
X$57389 73 11234 10787 11235 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57391 r0 *1 382.26,486.88
X$57391 57 8641 11322 11295 11235 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57395 r0 *1 393.76,486.88
X$57395 73 8076 8451 11322 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57405 r0 *1 406.18,486.88
X$57405 73 8253 10792 8557 73 11364 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57409 r0 *1 413.08,486.88
X$57409 73 11299 7723 73 12567 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57412 r0 *1 417.68,486.88
X$57412 73 11237 10990 11297 11298 57 10069 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $57413 r0 *1 420.44,486.88
X$57413 73 8312 10165 11297 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57421 r0 *1 428.72,486.88
X$57421 73 10575 10268 11236 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57425 r0 *1 433.32,486.88
X$57425 73 10990 9891 9449 57 73 11296 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57428 r0 *1 440.68,486.88
X$57428 73 11236 73 57 11325 57 sky130_fd_sc_hd__buf_4
* cell instance $57429 r0 *1 443.44,486.88
X$57429 73 11204 73 57 11294 57 sky130_fd_sc_hd__buf_4
* cell instance $57433 r0 *1 449.42,486.88
X$57433 73 11152 73 57 9101 57 sky130_fd_sc_hd__buf_4
* cell instance $57438 r0 *1 455.86,486.88
X$57438 73 10331 11117 10950 11358 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $57441 r0 *1 460,486.88
X$57441 73 10126 11152 11237 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57445 r0 *1 467.36,486.88
X$57445 73 10331 11239 11237 11356 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $57447 r0 *1 471.04,486.88
X$57447 73 11288 11050 11356 9646 10018 73 11240 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $57458 r0 *1 491.74,486.88
X$57458 73 8926 11510 11193 73 11241 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57462 r0 *1 496.8,486.88
X$57462 73 10471 11241 11353 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57464 r0 *1 500.02,486.88
X$57464 73 9393 9602 10372 8975 57 11351 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $57471 r0 *1 507.84,486.88
X$57471 73 10018 11283 11453 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57488 r0 *1 542.8,486.88
X$57488 73 11187 73 57 11281 57 sky130_fd_sc_hd__buf_4
* cell instance $57489 r0 *1 545.56,486.88
X$57489 73 10210 11281 11242 11279 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $57491 r0 *1 548.32,486.88
X$57491 57 9406 11243 11347 10363 9409 11276 73 73 57 sky130_fd_sc_hd__o221a_2
* cell instance $57493 r0 *1 553.38,486.88
X$57493 73 11275 9864 11189 57 73 11243 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57495 r0 *1 555.68,486.88
X$57495 57 9412 11345 9161 10560 11276 10761 73 73 57 sky130_fd_sc_hd__a2111oi_0
* cell instance $57506 r0 *1 575,486.88
X$57506 73 10039 10714 11330 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57507 r0 *1 576.38,486.88
X$57507 73 11246 9412 10338 11245 73 11277 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $57509 r0 *1 579.14,486.88
X$57509 73 10560 11673 11344 11264 10628 11245 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $57510 r0 *1 582.36,486.88
X$57510 73 10437 9603 9320 73 11344 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57511 r0 *1 584.2,486.88
X$57511 73 9603 73 57 9761 57 sky130_fd_sc_hd__buf_4
* cell instance $57515 r0 *1 586.96,486.88
X$57515 73 9244 11340 9161 11342 11177 11246 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $57525 r0 *1 606.74,486.88
X$57525 73 10132 9603 11257 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57531 r0 *1 615.48,486.88
X$57531 57 11250 9246 10737 11337 11247 11169 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $57537 r0 *1 625.14,486.88
X$57537 57 57 11093 73 9320 9603 73 sky130_fd_sc_hd__nor2_2
* cell instance $57541 r0 *1 635.26,486.88
X$57541 57 11248 10533 11250 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57545 r0 *1 642.62,486.88
X$57545 57 11248 11234 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $57552 m0 *1 4.14,492.32
X$57552 73 11419 57 73 11167 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57553 m0 *1 7.82,492.32
X$57553 73 7704 11520 9366 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57554 m0 *1 9.2,492.32
X$57554 57 7704 11336 11333 11373 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $57556 m0 *1 20.7,492.32
X$57556 73 7704 7304 11421 73 11300 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57557 m0 *1 22.54,492.32
X$57557 57 11341 11376 11300 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57560 m0 *1 30.82,492.32
X$57560 57 11219 3883 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $57562 m0 *1 39.1,492.32
X$57562 73 11424 4018 73 11343 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57564 m0 *1 44.16,492.32
X$57564 57 11222 11376 11377 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57567 m0 *1 53.82,492.32
X$57567 57 11380 11336 8411 8663 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $57575 m0 *1 76.82,492.32
X$57575 57 11024 11302 11303 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57582 m0 *1 94.3,492.32
X$57582 73 11613 73 57 6643 57 sky130_fd_sc_hd__buf_4
* cell instance $57584 m0 *1 100.74,492.32
X$57584 57 11383 4017 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $57586 m0 *1 109.94,492.32
X$57586 73 4428 11384 8685 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57595 m0 *1 123.74,492.32
X$57595 57 7656 11430 13724 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $57596 m0 *1 129.72,492.32
X$57596 57 11348 11304 11130 11387 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57601 m0 *1 141.22,492.32
X$57601 57 11350 11434 11306 11305 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57602 m0 *1 149.5,492.32
X$57602 57 11304 9374 11266 10845 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $57604 m0 *1 159.16,492.32
X$57604 73 11307 11131 73 11357 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57610 m0 *1 171.12,492.32
X$57610 73 10691 73 57 11359 57 sky130_fd_sc_hd__buf_4
* cell instance $57621 m0 *1 199.64,492.32
X$57621 73 11361 11320 11362 10477 9735 73 11767 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $57623 m0 *1 203.78,492.32
X$57623 73 11308 73 57 11393 57 sky130_fd_sc_hd__buf_4
* cell instance $57624 m0 *1 206.54,492.32
X$57624 73 11363 11309 10508 73 11446 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57625 m0 *1 208.38,492.32
X$57625 73 10871 10318 10573 57 73 11309 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57629 m0 *1 215.28,492.32
X$57629 73 10871 11394 11310 57 73 10064 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57631 m0 *1 217.58,492.32
X$57631 73 9741 11394 11311 57 73 9822 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57639 m0 *1 234.14,492.32
X$57639 57 11449 11228 10508 11308 10980 9741 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $57640 m0 *1 237.36,492.32
X$57640 73 10508 11311 11448 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57641 m0 *1 238.74,492.32
X$57641 57 10111 11314 11366 10508 11312 11449 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $57643 m0 *1 242.42,492.32
X$57643 73 9892 10111 11312 73 10849 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57645 m0 *1 245.18,492.32
X$57645 73 11313 73 57 10874 57 sky130_fd_sc_hd__buf_4
* cell instance $57646 m0 *1 247.94,492.32
X$57646 73 10601 11313 11312 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57647 m0 *1 249.32,492.32
X$57647 73 10091 9993 11313 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57650 m0 *1 251.62,492.32
X$57650 73 11312 73 57 11454 57 sky130_fd_sc_hd__buf_4
* cell instance $57651 m0 *1 254.38,492.32
X$57651 73 11314 73 57 11396 57 sky130_fd_sc_hd__buf_4
* cell instance $57656 m0 *1 266.8,492.32
X$57656 73 10080 73 57 11289 57 sky130_fd_sc_hd__buf_4
* cell instance $57657 m0 *1 269.56,492.32
X$57657 73 11315 11200 11316 9743 11318 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $57658 m0 *1 272.32,492.32
X$57658 73 9976 10257 11317 73 11316 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57660 m0 *1 274.62,492.32
X$57660 73 4624 11627 9989 11318 11319 11272 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $57666 m0 *1 288.88,492.32
X$57666 57 11284 11462 10510 11047 9915 11320 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $57667 m0 *1 292.1,492.32
X$57667 73 11400 73 57 11320 57 sky130_fd_sc_hd__buf_4
* cell instance $57674 m0 *1 308.66,492.32
X$57674 57 11464 11266 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $57678 m0 *1 319.24,492.32
X$57678 73 10004 11403 11321 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57679 m0 *1 320.62,492.32
X$57679 73 10004 11370 11321 73 11468 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57691 m0 *1 354.66,492.32
X$57691 73 11471 11369 10114 73 11473 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $57694 m0 *1 361.56,492.32
X$57694 57 11369 11368 10956 11211 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57698 m0 *1 379.04,492.32
X$57698 57 8309 11478 11235 11479 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57705 m0 *1 394.22,492.32
X$57705 73 10491 73 57 8076 57 sky130_fd_sc_hd__buf_4
* cell instance $57706 m0 *1 396.98,492.32
X$57706 73 10169 11149 9146 73 11480 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57708 m0 *1 399.74,492.32
X$57708 57 11477 8186 11323 7227 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57709 m0 *1 408.02,492.32
X$57709 73 11364 8253 10494 57 73 11365 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57710 m0 *1 409.86,492.32
X$57710 73 11323 73 57 8262 57 sky130_fd_sc_hd__buf_4
* cell instance $57715 m0 *1 418.14,492.32
X$57715 73 11407 73 57 10616 57 sky130_fd_sc_hd__buf_4
* cell instance $57722 m0 *1 437,492.32
X$57722 73 11470 11324 8410 73 11360 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57723 m0 *1 438.84,492.32
X$57723 73 10990 11294 11325 11324 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $57724 m0 *1 440.68,492.32
X$57724 73 11294 11236 10990 73 11326 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57729 m0 *1 445.28,492.32
X$57729 73 11326 73 57 9647 57 sky130_fd_sc_hd__buf_4
* cell instance $57733 m0 *1 454.48,492.32
X$57733 57 8186 11820 11408 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57736 m0 *1 465.98,492.32
X$57736 73 8557 73 57 10018 57 sky130_fd_sc_hd__buf_4
* cell instance $57737 m0 *1 468.74,492.32
X$57737 73 10293 11325 11050 11355 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $57740 m0 *1 475.64,492.32
X$57740 73 11237 73 57 11412 57 sky130_fd_sc_hd__buf_4
* cell instance $57742 m0 *1 480.24,492.32
X$57742 73 9646 11771 10425 11407 73 11354 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $57749 m0 *1 497.26,492.32
X$57749 73 11459 10018 11327 57 73 10942 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57751 m0 *1 499.56,492.32
X$57751 73 8253 10940 11686 73 11327 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57755 m0 *1 507.38,492.32
X$57755 73 11328 11192 11618 8832 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $57757 m0 *1 509.68,492.32
X$57757 73 10018 10126 11191 11328 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $57762 m0 *1 518.42,492.32
X$57762 57 11323 11452 11346 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57770 m0 *1 543.72,492.32
X$57770 57 15562 11349 9320 9703 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $57771 m0 *1 548.32,492.32
X$57771 73 11349 10714 9409 73 11347 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57773 m0 *1 551.08,492.32
X$57773 73 11415 73 57 10427 57 sky130_fd_sc_hd__buf_4
* cell instance $57776 m0 *1 554.76,492.32
X$57776 73 11329 11535 11345 11027 57 11346 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $57781 m0 *1 563.96,492.32
X$57781 73 10040 9503 11278 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57784 m0 *1 566.72,492.32
X$57784 73 9929 9761 11415 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57785 m0 *1 568.1,492.32
X$57785 73 9406 9864 9530 11415 11439 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $57788 m0 *1 575.92,492.32
X$57788 73 11330 73 57 11260 57 sky130_fd_sc_hd__buf_4
* cell instance $57796 m0 *1 588.34,492.32
X$57796 73 10628 10642 10748 11342 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $57798 m0 *1 592.02,492.32
X$57798 73 9161 11431 11433 57 73 11340 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57800 m0 *1 594.78,492.32
X$57800 73 9701 9775 11260 11431 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $57805 m0 *1 606.74,492.32
X$57805 73 9703 10429 9530 11331 11339 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $57807 m0 *1 609.96,492.32
X$57807 73 9701 11257 11331 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57809 m0 *1 613.18,492.32
X$57809 73 10628 10143 10748 57 73 11338 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57813 m0 *1 618.24,492.32
X$57813 73 11332 11425 9703 73 11335 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57814 m0 *1 620.08,492.32
X$57814 73 9701 9603 11332 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57817 m0 *1 623.76,492.32
X$57817 73 10222 10429 11592 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57819 m0 *1 626.98,492.32
X$57819 73 9613 9603 10836 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57820 m0 *1 628.36,492.32
X$57820 57 9603 10429 9320 73 73 57 sky130_fd_sc_hd__nand2_4
* cell instance $57831 r0 *1 2.3,492.32
X$57831 73 11251 57 73 11372 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57833 r0 *1 6.44,492.32
X$57833 57 11420 11333 11374 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57835 r0 *1 14.72,492.32
X$57835 73 7704 11334 11421 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57839 r0 *1 17.02,492.32
X$57839 57 11375 11223 11483 7704 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $57840 r0 *1 20.7,492.32
X$57840 73 11221 8385 73 11374 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57842 r0 *1 24.38,492.32
X$57842 73 11423 73 57 4052 57 sky130_fd_sc_hd__buf_4
* cell instance $57843 r0 *1 27.14,492.32
X$57843 73 11176 7306 73 11217 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57844 r0 *1 30.36,492.32
X$57844 57 7304 11341 11598 11426 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57845 r0 *1 38.64,492.32
X$57845 73 11635 11426 73 11703 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57850 r0 *1 45.08,492.32
X$57850 57 11377 11378 11427 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $57851 r0 *1 49.22,492.32
X$57851 73 11175 11379 73 11378 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57853 r0 *1 52.9,492.32
X$57853 57 9132 11380 11524 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $57857 r0 *1 63.94,492.32
X$57857 73 11487 11559 11174 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57868 r0 *1 87.86,492.32
X$57868 57 11526 11302 11382 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57875 r0 *1 102.58,492.32
X$57875 57 11226 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $57878 r0 *1 112.7,492.32
X$57878 57 11381 11429 11352 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $57880 r0 *1 123.74,492.32
X$57880 73 11385 73 57 9374 57 sky130_fd_sc_hd__buf_4
* cell instance $57884 r0 *1 128.8,492.32
X$57884 73 11386 7440 73 10726 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57885 r0 *1 132.02,492.32
X$57885 73 11386 11432 11387 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57887 r0 *1 136.16,492.32
X$57887 73 6947 73 57 11435 57 sky130_fd_sc_hd__buf_4
* cell instance $57890 r0 *1 140.3,492.32
X$57890 57 11434 11263 11437 11266 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $57896 r0 *1 156.4,492.32
X$57896 73 11388 11268 11438 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57897 r0 *1 159.62,492.32
X$57897 73 11307 9905 11388 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $57898 r0 *1 162.84,492.32
X$57898 73 10845 73 57 11389 57 sky130_fd_sc_hd__buf_4
* cell instance $57899 r0 *1 165.6,492.32
X$57899 57 11389 11390 11391 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $57900 r0 *1 171.58,492.32
X$57900 73 11391 73 57 11306 57 sky130_fd_sc_hd__buf_4
* cell instance $57908 r0 *1 190.44,492.32
X$57908 73 11440 73 57 11392 57 sky130_fd_sc_hd__buf_4
* cell instance $57913 r0 *1 203.32,492.32
X$57913 73 11443 11444 11445 11393 11442 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $57916 r0 *1 207.46,492.32
X$57916 73 10508 11568 11446 73 11445 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57921 r0 *1 212.98,492.32
X$57921 73 9742 10405 11228 11541 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $57933 r0 *1 245.64,492.32
X$57933 73 10111 10980 10979 57 73 11450 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57936 r0 *1 251.62,492.32
X$57936 73 10111 11078 10979 57 73 11395 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57937 r0 *1 253.46,492.32
X$57937 73 11395 10111 11454 57 73 11455 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57938 r0 *1 255.3,492.32
X$57938 73 10111 10875 11456 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57941 r0 *1 260.36,492.32
X$57941 73 10080 73 57 10601 57 sky130_fd_sc_hd__buf_4
* cell instance $57942 r0 *1 263.12,492.32
X$57942 73 10985 10080 11397 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57944 r0 *1 264.96,492.32
X$57944 73 11397 10190 10080 57 73 11458 57 sky130_fd_sc_hd__a21oi_1
* cell instance $57948 r0 *1 275.08,492.32
X$57948 73 7337 73 57 11398 57 sky130_fd_sc_hd__buf_4
* cell instance $57959 r0 *1 293.94,492.32
X$57959 73 11398 11399 11400 73 10606 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57963 r0 *1 302.22,492.32
X$57963 73 11572 10875 9742 11401 57 73 11371 57 sky130_fd_sc_hd__a31oi_1
* cell instance $57964 r0 *1 304.52,492.32
X$57964 73 10600 11399 10004 73 11401 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57966 r0 *1 306.82,492.32
X$57966 73 11143 11785 11573 11289 11205 11403 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $57969 r0 *1 312.8,492.32
X$57969 73 10091 10111 11317 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $57975 r0 *1 322,492.32
X$57975 73 10004 11465 10679 73 11319 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $57978 r0 *1 326.14,492.32
X$57978 73 11396 11467 11404 11466 11468 73 11402 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $57981 r0 *1 332.12,492.32
X$57981 73 4428 11553 11471 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $57986 r0 *1 341.78,492.32
X$57986 73 11469 73 57 11405 57 sky130_fd_sc_hd__buf_4
* cell instance $57993 r0 *1 353.74,492.32
X$57993 73 11473 9130 73 11472 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $57996 r0 *1 362.48,492.32
X$57996 57 11475 11474 10956 11211 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58000 r0 *1 372.14,492.32
X$58000 73 11406 9055 11578 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58004 r0 *1 375.36,492.32
X$58004 57 11577 9550 11476 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $58007 r0 *1 380.88,492.32
X$58007 73 11405 4813 11478 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58010 r0 *1 388.7,492.32
X$58010 57 11479 11481 7976 8106 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58013 r0 *1 397.44,492.32
X$58013 73 11480 73 57 11457 57 sky130_fd_sc_hd__buf_4
* cell instance $58020 r0 *1 412.16,492.32
X$58020 57 9570 11407 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $58030 r0 *1 435.16,492.32
X$58030 73 10957 73 57 11410 57 sky130_fd_sc_hd__buf_4
* cell instance $58037 r0 *1 453.56,492.32
X$58037 73 11545 11409 10794 11507 11408 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $58042 r0 *1 458.62,492.32
X$58042 73 11238 73 57 11409 57 sky130_fd_sc_hd__buf_4
* cell instance $58045 r0 *1 463.68,492.32
X$58045 73 10708 73 57 11463 57 sky130_fd_sc_hd__buf_4
* cell instance $58050 r0 *1 477.48,492.32
X$58050 73 11461 11538 11412 11460 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $58059 r0 *1 495.88,492.32
X$58059 57 8836 11459 8314 11460 11353 11619 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $58060 r0 *1 499.1,492.32
X$58060 73 11351 11453 11457 8314 11411 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $58080 r0 *1 544.18,492.32
X$58080 73 9961 11447 11413 73 11414 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58081 r0 *1 546.02,492.32
X$58081 73 9323 11349 9761 57 73 11451 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58083 r0 *1 549.7,492.32
X$58083 73 11513 9320 9161 73 11447 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58085 r0 *1 552,492.32
X$58085 73 9924 11414 11417 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58087 r0 *1 555.22,492.32
X$58087 57 11271 9161 11416 11532 11417 10560 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $58089 r0 *1 558.9,492.32
X$58089 73 9414 73 57 11513 57 sky130_fd_sc_hd__buf_4
* cell instance $58092 r0 *1 564.42,492.32
X$58092 73 9760 10248 11416 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $58093 r0 *1 565.8,492.32
X$58093 73 9503 10748 10628 11439 57 73 11441 57 sky130_fd_sc_hd__a31oi_1
* cell instance $58096 r0 *1 572.24,492.32
X$58096 73 10714 9929 10628 11330 57 11586 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $58101 r0 *1 581.9,492.32
X$58101 73 9630 73 57 11436 57 sky130_fd_sc_hd__buf_4
* cell instance $58105 r0 *1 592.02,492.32
X$58105 73 9701 9760 11436 11433 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $58110 r0 *1 598.46,492.32
X$58110 73 9414 73 57 10825 57 sky130_fd_sc_hd__buf_4
* cell instance $58114 r0 *1 609.04,492.32
X$58114 73 10628 10642 11257 57 73 10738 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58117 r0 *1 612.72,492.32
X$58117 73 10040 10642 9701 11418 57 73 11428 57 sky130_fd_sc_hd__a31oi_1
* cell instance $58121 r0 *1 618.24,492.32
X$58121 73 9320 9323 9842 11425 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $58128 r0 *1 625.14,492.32
X$58128 73 11009 9842 11422 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $58129 r0 *1 626.52,492.32
X$58129 73 9701 11422 10836 11418 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $58193 m0 *1 5.52,497.76
X$58193 73 11482 57 73 11520 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $58194 m0 *1 9.2,497.76
X$58194 57 7704 11484 11333 11521 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $58195 m0 *1 20.24,497.76
X$58195 73 4428 11484 11522 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58196 m0 *1 21.62,497.76
X$58196 57 11423 11376 11375 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $58201 m0 *1 31.74,497.76
X$58201 57 11426 11376 9853 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $58203 m0 *1 39.56,497.76
X$58203 57 11600 11376 11343 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $58205 m0 *1 47.84,497.76
X$58205 57 11675 11596 9154 8663 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $58206 m0 *1 51.52,497.76
X$58206 57 11486 11380 9132 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $58208 m0 *1 57.96,497.76
X$58208 57 11524 11955 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $58210 m0 *1 66.24,497.76
X$58210 57 11488 11302 11525 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $58213 m0 *1 76.36,497.76
X$58213 73 11488 73 57 11489 57 sky130_fd_sc_hd__buf_4
* cell instance $58214 m0 *1 79.12,497.76
X$58214 57 11637 11561 11559 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $58218 m0 *1 87.86,497.76
X$58218 73 11526 11489 73 11487 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $58222 m0 *1 98.9,497.76
X$58222 73 11527 73 57 7788 57 sky130_fd_sc_hd__buf_4
* cell instance $58231 m0 *1 123.28,497.76
X$58231 57 11529 10635 11530 8663 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $58232 m0 *1 126.96,497.76
X$58232 57 11385 11023 11491 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $58235 m0 *1 135.7,497.76
X$58235 73 11533 11387 73 11531 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $58239 m0 *1 140.76,497.76
X$58239 73 11534 73 57 11221 57 sky130_fd_sc_hd__buf_4
* cell instance $58240 m0 *1 143.52,497.76
X$58240 73 11527 11386 73 11492 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $58243 m0 *1 148.12,497.76
X$58243 57 11384 11493 11494 11390 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58245 m0 *1 158.24,497.76
X$58245 73 11432 73 57 10973 57 sky130_fd_sc_hd__buf_4
* cell instance $58247 m0 *1 161.92,497.76
X$58247 73 11389 10973 73 11494 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $58251 m0 *1 168.36,497.76
X$58251 57 9661 11492 11391 11437 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $58256 m0 *1 184,497.76
X$58256 57 9037 11227 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $58258 m0 *1 193.66,497.76
X$58258 73 9743 4624 11440 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $58264 m0 *1 201.94,497.76
X$58264 73 11442 11540 11539 11133 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $58266 m0 *1 204.7,497.76
X$58266 73 10311 11542 11495 10072 73 57 11540 57 sky130_fd_sc_hd__o31ai_1
* cell instance $58271 m0 *1 214.36,497.76
X$58271 73 11541 11496 11543 9735 10477 73 11542 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $58273 m0 *1 219.42,497.76
X$58273 73 10111 11037 10877 11496 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $58274 m0 *1 221.26,497.76
X$58274 73 11274 11893 11497 57 73 11077 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58280 m0 *1 235.06,497.76
X$58280 73 11498 73 57 11466 57 sky130_fd_sc_hd__buf_4
* cell instance $58302 m0 *1 295.78,497.76
X$58302 73 9993 10111 11399 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58305 m0 *1 302.68,497.76
X$58305 73 9976 11575 10695 11120 11399 11287 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $58310 m0 *1 314.64,497.76
X$58310 73 11499 73 57 11444 57 sky130_fd_sc_hd__buf_4
* cell instance $58330 m0 *1 363.86,497.76
X$58330 57 11943 10856 11552 11088 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58331 m0 *1 372.14,497.76
X$58331 57 11295 10784 11469 11063 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58332 m0 *1 380.42,497.76
X$58332 73 4813 10884 11551 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58342 m0 *1 402.5,497.76
X$58342 73 10585 8313 10074 8410 11502 73 11783 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $58343 m0 *1 405.72,497.76
X$58343 57 11503 11502 11550 11365 11549 9235 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $58349 m0 *1 419.52,497.76
X$58349 73 9238 11504 11548 73 11503 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58350 m0 *1 421.36,497.76
X$58350 73 10423 8313 11548 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $58353 m0 *1 430.1,497.76
X$58353 73 11410 11505 10888 8253 11546 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $58362 m0 *1 453.1,497.76
X$58362 73 8312 11506 11544 57 73 11545 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58363 m0 *1 454.94,497.76
X$58363 73 10423 8150 11411 11776 8314 73 11507 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $58365 m0 *1 458.62,497.76
X$58365 73 11463 73 57 10165 57 sky130_fd_sc_hd__buf_4
* cell instance $58367 m0 *1 461.84,497.76
X$58367 73 11508 11463 10331 11358 57 73 11509 57 sky130_fd_sc_hd__a31oi_1
* cell instance $58368 m0 *1 464.14,497.76
X$58368 73 9273 11510 11508 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58373 m0 *1 471.96,497.76
X$58373 73 11155 73 57 9552 57 sky130_fd_sc_hd__buf_4
* cell instance $58376 m0 *1 476.1,497.76
X$58376 73 11510 11410 11538 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $58378 m0 *1 477.94,497.76
X$58378 73 11508 73 57 9794 57 sky130_fd_sc_hd__buf_4
* cell instance $58401 m0 *1 543.26,497.76
X$58401 57 11610 9323 11242 9406 11451 11537 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $58402 m0 *1 546.94,497.76
X$58402 73 11414 9409 11536 11512 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $58405 m0 *1 551.08,497.76
X$58405 73 11108 11849 11512 57 73 11535 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58411 m0 *1 557.52,497.76
X$58411 73 11514 11513 10628 57 73 11532 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58418 m0 *1 576.38,497.76
X$58418 73 9703 9758 9678 9530 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $58421 m0 *1 579.6,497.76
X$58421 73 10714 11515 11514 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58425 m0 *1 582.82,497.76
X$58425 73 10132 9864 11515 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58429 m0 *1 592.02,497.76
X$58429 73 9701 9676 11436 11523 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $58437 m0 *1 610.88,497.76
X$58437 73 11517 73 57 11161 57 sky130_fd_sc_hd__buf_4
* cell instance $58438 m0 *1 613.64,497.76
X$58438 73 11518 11519 9612 9409 9406 73 11517 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $58440 m0 *1 617.78,497.76
X$58440 73 11332 9514 11009 73 11519 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58457 r0 *1 5.06,497.76
X$58457 57 7704 11596 11333 11593 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $58462 r0 *1 16.56,497.76
X$58462 57 7704 11557 11376 11595 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $58463 r0 *1 27.6,497.76
X$58463 73 11522 11558 4428 73 11218 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $58466 r0 *1 31.74,497.76
X$58466 57 11598 11376 11555 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $58468 r0 *1 40.02,497.76
X$58468 57 11599 11557 11528 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $58474 r0 *1 44.62,497.76
X$58474 73 11600 57 73 11633 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $58475 r0 *1 48.3,497.76
X$58475 73 8081 9132 73 11674 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $58479 r0 *1 54.74,497.76
X$58479 57 11602 11556 9343 8663 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $58481 r0 *1 58.88,497.76
X$58481 73 7704 11174 11485 73 11676 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58483 r0 *1 61.64,497.76
X$58483 57 11525 11487 11604 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $58493 r0 *1 78.2,497.76
X$58493 73 8663 11597 11562 73 11561 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58495 r0 *1 80.96,497.76
X$58495 73 11561 73 57 11606 57 sky130_fd_sc_hd__buf_4
* cell instance $58506 r0 *1 101.2,497.76
X$58506 57 11527 11429 11563 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $58507 r0 *1 108.56,497.76
X$58507 73 11531 73 57 11528 57 sky130_fd_sc_hd__buf_4
* cell instance $58519 r0 *1 128.34,497.76
X$58519 57 11020 11805 11564 7226 73 73 57 sky130_fd_sc_hd__mux2i_4
* cell instance $58520 r0 *1 136.62,497.76
X$58520 73 11527 11385 11608 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58523 r0 *1 142.14,497.76
X$58523 57 11754 11527 11437 11266 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58525 r0 *1 150.88,497.76
X$58525 73 11307 73 57 11424 57 sky130_fd_sc_hd__buf_4
* cell instance $58532 r0 *1 155.48,497.76
X$58532 73 11494 73 57 11566 57 sky130_fd_sc_hd__buf_4
* cell instance $58533 r0 *1 158.24,497.76
X$58533 73 11390 10753 11567 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58534 r0 *1 161.46,497.76
X$58534 73 11567 11611 10974 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58537 r0 *1 168.82,497.76
X$58537 73 11613 9905 11614 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58538 r0 *1 172.04,497.76
X$58538 73 11615 11389 11616 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58549 r0 *1 190.44,497.76
X$58549 73 9735 11440 11498 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58557 r0 *1 206.54,497.76
X$58557 73 10871 11228 11078 11696 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $58561 r0 *1 210.22,497.76
X$58561 73 11392 12252 11622 10191 10477 11653 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $58577 r0 *1 240.58,497.76
X$58577 57 11497 11547 10190 11047 10266 10286 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $58578 r0 *1 243.8,497.76
X$58578 73 11311 11084 10111 11450 57 73 11624 57 sky130_fd_sc_hd__a31oi_1
* cell instance $58582 r0 *1 252.08,497.76
X$58582 73 11280 9989 11569 57 73 11655 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58584 r0 *1 254.84,497.76
X$58584 73 10508 11455 11626 73 11569 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58592 r0 *1 264.96,497.76
X$58592 73 9742 11458 11570 73 11571 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58593 r0 *1 266.8,497.76
X$58593 73 9976 10266 10108 57 73 11570 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58596 r0 *1 270.02,497.76
X$58596 73 11139 11289 11394 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58601 r0 *1 278.3,497.76
X$58601 57 11627 11398 11630 11629 9826 11571 73 73 57 sky130_fd_sc_hd__a41o_1
* cell instance $58608 r0 *1 290.26,497.76
X$58608 73 11120 10111 11573 73 11462 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58614 r0 *1 305.44,497.76
X$58614 73 10091 10111 11573 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58615 r0 *1 306.82,497.76
X$58615 73 11572 11573 11574 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58616 r0 *1 308.2,497.76
X$58616 57 11576 11574 11205 10321 11317 11575 11400 73 73 57
+ sky130_fd_sc_hd__a222oi_1
* cell instance $58619 r0 *1 313.26,497.76
X$58619 73 9976 11576 11632 73 11499 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58626 r0 *1 320.16,497.76
X$58626 73 9915 11631 11697 10004 11053 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $58632 r0 *1 333.5,497.76
X$58632 73 11577 11489 12190 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58633 r0 *1 336.72,497.76
X$58633 73 11577 11489 73 11791 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $58642 r0 *1 353.28,497.76
X$58642 73 11088 11489 73 11792 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $58646 r0 *1 359.72,497.76
X$58646 57 11578 11562 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $58653 r0 *1 370.3,497.76
X$58653 73 10295 73 57 11552 57 sky130_fd_sc_hd__buf_4
* cell instance $58658 r0 *1 378.12,497.76
X$58658 57 11628 11551 11579 11479 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58659 r0 *1 386.4,497.76
X$58659 73 11088 7976 11721 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58663 r0 *1 392.84,497.76
X$58663 73 11088 10491 11579 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58677 r0 *1 421.82,497.76
X$58677 57 11625 11549 11580 11546 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $58686 r0 *1 431.02,497.76
X$58686 73 11726 8644 9101 11581 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $58687 r0 *1 432.86,497.76
X$58687 73 11581 9722 11580 11296 57 11582 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $58697 r0 *1 452.64,497.76
X$58697 73 11582 11583 8253 73 11544 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58704 r0 *1 459.54,497.76
X$58704 73 10291 73 57 11623 57 sky130_fd_sc_hd__buf_4
* cell instance $58705 r0 *1 462.3,497.76
X$58705 57 11580 11506 8150 11623 11584 11621 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $58707 r0 *1 466.44,497.76
X$58707 73 10421 11510 11585 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $58710 r0 *1 470.12,497.76
X$58710 73 11585 73 57 11155 57 sky130_fd_sc_hd__buf_4
* cell instance $58713 r0 *1 474.26,497.76
X$58713 57 10331 9646 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $58746 r0 *1 544.64,497.76
X$58746 73 9864 10714 11189 11610 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $58748 r0 *1 546.94,497.76
X$58748 73 11586 11609 9406 73 11536 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58749 r0 *1 548.78,497.76
X$58749 73 11278 9864 11666 10714 11537 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $58761 r0 *1 569.48,497.76
X$58761 73 9534 73 57 11589 57 sky130_fd_sc_hd__buf_4
* cell instance $58763 r0 *1 574.08,497.76
X$58763 73 9762 9530 11586 10628 9406 73 11587 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $58764 r0 *1 577.3,497.76
X$58764 73 11587 11588 10560 73 11590 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58765 r0 *1 579.14,497.76
X$58765 73 9161 11589 11514 11588 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $58767 r0 *1 582.82,497.76
X$58767 73 11590 73 57 11591 57 sky130_fd_sc_hd__buf_4
* cell instance $58771 r0 *1 585.58,497.76
X$58771 73 9678 73 57 10714 57 sky130_fd_sc_hd__buf_4
* cell instance $58775 r0 *1 593.4,497.76
X$58775 73 11523 11603 9930 9409 57 73 11601 57 sky130_fd_sc_hd__a31oi_1
* cell instance $58782 r0 *1 608.58,497.76
X$58782 57 11015 11337 11591 11601 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $58788 r0 *1 613.18,497.76
X$58788 73 9161 11428 11017 73 11741 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58794 r0 *1 624.22,497.76
X$58794 73 11592 9613 11093 57 73 11518 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58795 r0 *1 626.06,497.76
X$58795 73 10918 9613 11093 57 73 11594 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58797 r0 *1 629.74,497.76
X$58797 73 11093 73 57 9845 57 sky130_fd_sc_hd__buf_4
* cell instance $58810 m0 *1 2.3,503.2
X$58810 73 9020 57 73 11671 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $58811 m0 *1 5.98,503.2
X$58811 73 11554 57 73 11521 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $58815 m0 *1 12.88,503.2
X$58815 73 7704 12258 11485 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58816 m0 *1 14.26,503.2
X$58816 57 7704 11597 11376 11634 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $58819 m0 *1 26.68,503.2
X$58819 73 9331 10913 73 11672 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $58821 m0 *1 30.36,503.2
X$58821 57 10727 11376 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $58822 m0 *1 39.56,503.2
X$58822 73 11598 73 57 11635 57 sky130_fd_sc_hd__buf_4
* cell instance $58825 m0 *1 44.62,503.2
X$58825 57 11675 11341 11636 73 73 57 sky130_fd_sc_hd__xnor2_4
* cell instance $58828 m0 *1 56.12,503.2
X$58828 73 11636 57 73 11677 57 sky130_fd_sc_hd__inv_2
* cell instance $58832 m0 *1 59.34,503.2
X$58832 57 11559 11376 11676 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $58834 m0 *1 68.54,503.2
X$58834 73 11560 11638 11641 73 11605 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $58835 m0 *1 70.38,503.2
X$58835 73 11639 73 57 11642 57 sky130_fd_sc_hd__buf_4
* cell instance $58836 m0 *1 73.14,503.2
X$58836 73 11953 11560 11642 11640 73 11643 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $58838 m0 *1 76.36,503.2
X$58838 73 11607 11644 11605 11643 11681 11303 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $58843 m0 *1 86.02,503.2
X$58843 57 11302 15435 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $58845 m0 *1 90.62,503.2
X$58845 73 11645 11682 11646 57 73 11607 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58847 m0 *1 94.3,503.2
X$58847 73 11647 73 57 11645 57 sky130_fd_sc_hd__buf_4
* cell instance $58848 m0 *1 97.06,503.2
X$58848 73 11648 11641 11647 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $58849 m0 *1 98.44,503.2
X$58849 73 11647 73 57 11684 57 sky130_fd_sc_hd__buf_4
* cell instance $58858 m0 *1 119.6,503.2
X$58858 57 11534 11429 11685 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $58859 m0 *1 126.96,503.2
X$58859 57 11558 11846 11608 11650 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58860 m0 *1 135.24,503.2
X$58860 73 11565 11263 11650 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58864 m0 *1 141.22,503.2
X$58864 57 11533 11565 11437 11266 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58865 m0 *1 149.5,503.2
X$58865 73 11689 11492 11651 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58867 m0 *1 153.64,503.2
X$58867 57 11690 11649 11651 7226 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $58869 m0 *1 158.24,503.2
X$58869 73 11611 11566 11652 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58870 m0 *1 161.46,503.2
X$58870 73 11652 10858 11692 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $58875 m0 *1 168.36,503.2
X$58875 57 11612 11937 11614 11306 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58886 m0 *1 207,503.2
X$58886 73 10758 11696 11769 9989 10508 73 11495 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $58890 m0 *1 215.28,503.2
X$58890 73 10976 11084 12464 9742 9735 73 11543 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $58898 m0 *1 235.06,503.2
X$58898 57 11491 9826 11699 11655 11657 11653 73 73 57 sky130_fd_sc_hd__o311ai_2
* cell instance $58906 m0 *1 255.76,503.2
X$58906 73 11658 11456 11659 11626 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $58910 m0 *1 265.42,503.2
X$58910 73 11570 73 57 11659 57 sky130_fd_sc_hd__buf_4
* cell instance $58924 m0 *1 303.14,503.2
X$58924 73 10415 11120 11575 11698 57 11660 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $58929 m0 *1 312.8,503.2
X$58929 73 9892 11289 11575 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $58933 m0 *1 319.24,503.2
X$58933 73 9742 10321 10854 57 73 11698 57 sky130_fd_sc_hd__a21oi_1
* cell instance $58955 m0 *1 372.14,503.2
X$58955 73 10886 7183 73 11695 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $58959 m0 *1 380.42,503.2
X$58959 57 11694 11551 11579 11295 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $58973 m0 *1 422.28,503.2
X$58973 73 9393 73 57 10293 57 sky130_fd_sc_hd__buf_4
* cell instance $58992 m0 *1 473.8,503.2
X$58992 73 11662 73 57 11288 57 sky130_fd_sc_hd__buf_4
* cell instance $58996 m0 *1 485.76,503.2
X$58996 73 11620 73 57 9402 57 sky130_fd_sc_hd__buf_4
* cell instance $58997 m0 *1 488.52,503.2
X$58997 73 11663 73 57 11621 57 sky130_fd_sc_hd__buf_4
* cell instance $58999 m0 *1 493.12,503.2
X$58999 73 9393 73 57 11461 57 sky130_fd_sc_hd__buf_4
* cell instance $59000 m0 *1 495.88,503.2
X$59000 73 11687 11510 11049 8253 11619 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $59003 m0 *1 499.56,503.2
X$59003 57 11620 11617 10471 11688 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $59007 m0 *1 505.08,503.2
X$59007 73 11193 11664 11580 11617 57 11618 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $59008 m0 *1 507.84,503.2
X$59008 73 9393 73 57 11664 57 sky130_fd_sc_hd__buf_4
* cell instance $59011 m0 *1 512.9,503.2
X$59011 73 10268 73 57 10126 57 sky130_fd_sc_hd__buf_4
* cell instance $59022 m0 *1 546.48,503.2
X$59022 73 9864 9529 9761 57 73 11609 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59024 m0 *1 549.24,503.2
X$59024 73 11513 9864 11666 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59026 m0 *1 551.54,503.2
X$59026 73 9161 9761 11667 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $59032 m0 *1 559.36,503.2
X$59032 73 11513 9323 11755 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59038 m0 *1 576.38,503.2
X$59038 73 9244 73 57 10560 57 sky130_fd_sc_hd__buf_4
* cell instance $59043 m0 *1 582.82,503.2
X$59043 57 11673 10825 10132 11667 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $59047 m0 *1 594.32,503.2
X$59047 73 10628 11670 11603 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59049 m0 *1 596.16,503.2
X$59049 73 9161 9678 11668 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $59072 r0 *1 2.3,503.2
X$59072 73 11701 57 73 11700 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $59075 r0 *1 8.74,503.2
X$59075 57 11701 11333 11683 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $59078 r0 *1 16.56,503.2
X$59078 73 11381 57 73 11742 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $59080 r0 *1 20.7,503.2
X$59080 57 7704 11556 11376 11702 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $59081 r0 *1 31.74,503.2
X$59081 57 11672 11641 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $59082 r0 *1 39.1,503.2
X$59082 73 11745 11341 73 11746 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59089 r0 *1 51.52,503.2
X$59089 57 11678 11602 11258 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $59090 r0 *1 57.5,503.2
X$59090 57 11636 11799 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $59092 r0 *1 68.54,503.2
X$59092 73 11637 73 57 11560 57 sky130_fd_sc_hd__buf_4
* cell instance $59095 r0 *1 71.76,503.2
X$59095 73 8317 11559 73 11747 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59099 r0 *1 80.04,503.2
X$59099 73 11606 11559 73 11704 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59100 r0 *1 83.26,503.2
X$59100 73 11704 73 57 11705 57 sky130_fd_sc_hd__buf_4
* cell instance $59101 r0 *1 86.02,503.2
X$59101 57 10727 11302 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $59102 r0 *1 95.22,503.2
X$59102 73 11706 11707 11749 73 11646 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59104 r0 *1 97.06,503.2
X$59104 73 11750 11706 11749 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59108 r0 *1 100.28,503.2
X$59108 73 11637 73 57 11648 57 sky130_fd_sc_hd__buf_4
* cell instance $59110 r0 *1 103.96,503.2
X$59110 73 11565 7520 73 11683 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59114 r0 *1 116.38,503.2
X$59114 57 11753 11429 11752 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $59121 r0 *1 129.72,503.2
X$59121 73 11529 7440 73 12528 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59123 r0 *1 133.4,503.2
X$59123 57 11847 11390 11437 11534 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $59124 r0 *1 141.68,503.2
X$59124 73 11754 11566 11530 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $59126 r0 *1 145.82,503.2
X$59126 57 11689 11565 11390 11266 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $59129 r0 *1 154.56,503.2
X$59129 73 11756 73 57 10971 57 sky130_fd_sc_hd__buf_4
* cell instance $59130 r0 *1 157.32,503.2
X$59130 73 10538 11759 9303 73 11758 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $59131 r0 *1 160.08,503.2
X$59131 73 10858 11359 12169 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $59132 r0 *1 163.3,503.2
X$59132 57 10059 11761 11760 11712 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $59133 r0 *1 172.04,503.2
X$59133 57 11762 11616 11614 11712 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $59143 r0 *1 197.8,503.2
X$59143 73 4624 11766 11765 11767 11764 11853 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $59147 r0 *1 204.24,503.2
X$59147 73 11437 7625 73 11832 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59155 r0 *1 216.66,503.2
X$59155 73 11770 9989 10601 11622 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $59162 r0 *1 235.06,503.2
X$59162 73 11498 11715 11945 73 11539 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59165 r0 *1 238.28,503.2
X$59165 73 11773 11775 4624 11772 57 11699 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $59168 r0 *1 243.34,503.2
X$59168 73 9986 73 57 11859 57 sky130_fd_sc_hd__buf_4
* cell instance $59172 r0 *1 251.16,503.2
X$59172 73 10286 9993 10697 11777 57 11775 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $59173 r0 *1 253.92,503.2
X$59173 73 10111 11658 11078 57 73 11777 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59178 r0 *1 260.82,503.2
X$59178 73 11659 10273 11194 10266 9742 11779 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $59186 r0 *1 280.14,503.2
X$59186 73 9734 10111 10320 10412 11654 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $59187 r0 *1 282.44,503.2
X$59187 73 10408 73 57 11781 57 sky130_fd_sc_hd__buf_4
* cell instance $59198 r0 *1 302.68,503.2
X$59198 73 11660 9976 11630 11782 11715 57 73 57 sky130_fd_sc_hd__o22a_1
* cell instance $59201 r0 *1 311.42,503.2
X$59201 57 11289 11632 9976 11787 11785 11718 73 73 57 sky130_fd_sc_hd__o311ai_0
* cell instance $59205 r0 *1 316.02,503.2
X$59205 73 11719 11289 11718 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59210 r0 *1 320.62,503.2
X$59210 73 11719 9915 11697 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59213 r0 *1 326.6,503.2
X$59213 73 8316 73 57 11745 57 sky130_fd_sc_hd__buf_4
* cell instance $59216 r0 *1 333.96,503.2
X$59216 73 11791 73 57 11790 57 sky130_fd_sc_hd__buf_4
* cell instance $59227 r0 *1 355.58,503.2
X$59227 73 11792 73 57 11793 57 sky130_fd_sc_hd__buf_4
* cell instance $59236 r0 *1 377.2,503.2
X$59236 73 11234 8051 11720 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $59237 r0 *1 380.42,503.2
X$59237 57 11789 11788 11721 11062 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $59241 r0 *1 395.14,503.2
X$59241 57 11903 11786 11783 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $59249 r0 *1 419.52,503.2
X$59249 57 11504 10387 10421 11723 11724 8644 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $59251 r0 *1 422.74,503.2
X$59251 73 9402 10165 10990 8253 57 73 11693 57 sky130_fd_sc_hd__a31oi_1
* cell instance $59254 r0 *1 427.34,503.2
X$59254 73 10575 73 57 11724 57 sky130_fd_sc_hd__buf_4
* cell instance $59261 r0 *1 441.14,503.2
X$59261 73 11726 8695 11661 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59262 r0 *1 442.52,503.2
X$59262 73 11661 11326 8557 11778 57 73 11780 57 sky130_fd_sc_hd__a31oi_1
* cell instance $59265 r0 *1 447.12,503.2
X$59265 73 11688 73 57 10666 57 sky130_fd_sc_hd__buf_4
* cell instance $59269 r0 *1 451.26,503.2
X$59269 57 11776 11203 8968 11729 11580 12150 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $59277 r0 *1 464.6,503.2
X$59277 73 10421 10268 11688 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59280 r0 *1 470.58,503.2
X$59280 73 10268 8968 9797 57 73 11774 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59282 r0 *1 476.1,503.2
X$59282 73 10575 8975 11662 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59284 r0 *1 477.48,503.2
X$59284 73 11821 8975 11662 73 11771 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59285 r0 *1 479.32,503.2
X$59285 73 9797 10621 11729 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $59290 r0 *1 486.22,503.2
X$59290 73 8975 73 57 11510 57 sky130_fd_sc_hd__buf_4
* cell instance $59294 r0 *1 494.96,503.2
X$59294 57 15614 11687 11664 8968 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $59296 r0 *1 500.02,503.2
X$59296 73 11665 11768 8253 73 11686 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59298 r0 *1 502.32,503.2
X$59298 73 10774 11664 11511 57 73 11730 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59300 r0 *1 504.16,503.2
X$59300 73 11665 11730 11580 73 11663 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59301 r0 *1 506,503.2
X$59301 57 15672 11731 10471 8968 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $59302 r0 *1 510.6,503.2
X$59302 73 11731 10126 11665 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $59309 r0 *1 523.48,503.2
X$59309 57 11763 11452 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $59318 r0 *1 546.94,503.2
X$59318 73 9406 9679 11851 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59322 r0 *1 554.76,503.2
X$59322 73 10928 10560 11757 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59323 r0 *1 556.14,503.2
X$59323 73 9529 10560 11757 9864 11680 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $59325 r0 *1 558.9,503.2
X$59325 73 10928 9323 11755 10628 11733 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $59326 r0 *1 561.66,503.2
X$59326 73 11680 10210 11668 11733 73 11669 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $59328 r0 *1 564.88,503.2
X$59328 73 11669 11441 11751 11679 11734 10431 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $59330 r0 *1 568.56,503.2
X$59330 73 10210 11667 11679 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59332 r0 *1 571.78,503.2
X$59332 73 11748 9323 11035 11736 73 11734 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $59335 r0 *1 576.38,503.2
X$59335 73 10820 9406 9864 11260 10034 73 11736 57 57 sky130_fd_sc_hd__o2111ai_1
* cell instance $59336 r0 *1 579.6,503.2
X$59336 73 9406 10820 11589 10210 73 57 11744 57 sky130_fd_sc_hd__o31ai_1
* cell instance $59340 r0 *1 587.88,503.2
X$59340 73 10130 73 57 11670 57 sky130_fd_sc_hd__buf_4
* cell instance $59348 r0 *1 605.36,503.2
X$59348 73 9845 9406 11744 9703 9323 73 11739 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $59350 r0 *1 609.5,503.2
X$59350 73 11743 11739 11741 9323 10210 11247 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $59355 r0 *1 617.78,503.2
X$59355 73 9613 9514 9673 11332 73 11738 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $59421 m0 *1 2.3,508.64
X$59421 73 11831 57 73 11593 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $59422 m0 *1 5.98,508.64
X$59422 73 11794 57 73 11702 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $59424 m0 *1 10.12,508.64
X$59424 57 7704 11649 11333 11671 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $59425 m0 *1 21.16,508.64
X$59425 57 8863 12114 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $59429 m0 *1 30.36,508.64
X$59429 73 11376 73 57 57 sky130_fd_sc_hd__clkinv_2
* cell instance $59430 m0 *1 32.2,508.64
X$59430 57 11555 11703 11795 7704 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $59433 m0 *1 37.72,508.64
X$59433 73 11599 73 57 8498 57 sky130_fd_sc_hd__buf_4
* cell instance $59437 m0 *1 46.46,508.64
X$59437 73 11710 11258 73 11835 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59438 m0 *1 49.68,508.64
X$59438 57 11258 11602 11836 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $59443 m0 *1 60.26,508.64
X$59443 73 11797 73 57 11838 57 sky130_fd_sc_hd__buf_4
* cell instance $59448 m0 *1 75.9,508.64
X$59448 73 11841 11843 11842 11840 57 73 11644 57 sky130_fd_sc_hd__a31oi_1
* cell instance $59454 m0 *1 85.56,508.64
X$59454 57 11677 11802 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $59456 m0 *1 93.38,508.64
X$59456 57 15451 11750 11802 11844 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $59465 m0 *1 116.38,508.64
X$59465 57 10727 11429 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $59468 m0 *1 131.1,508.64
X$59468 57 11564 11650 11608 11847 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $59473 m0 *1 142.14,508.64
X$59473 73 8051 73 57 11708 57 sky130_fd_sc_hd__buf_4
* cell instance $59477 m0 *1 149.96,508.64
X$59477 73 11565 73 57 11709 57 sky130_fd_sc_hd__buf_4
* cell instance $59479 m0 *1 153.18,508.64
X$59479 73 11709 11424 11761 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $59480 m0 *1 156.4,508.64
X$59480 73 11848 11306 11711 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $59481 m0 *1 159.62,508.64
X$59481 73 11711 10753 11759 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $59489 m0 *1 171.58,508.64
X$59489 57 11712 11852 10971 11432 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $59494 m0 *1 192.74,508.64
X$59494 73 9989 11806 11033 9826 73 57 11764 57 sky130_fd_sc_hd__o31ai_1
* cell instance $59500 m0 *1 202.86,508.64
X$59500 73 10757 9735 11713 57 73 11941 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59502 m0 *1 205.62,508.64
X$59502 73 10508 11654 11855 73 11713 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59505 m0 *1 209.76,508.64
X$59505 73 11310 11228 11714 9742 9989 73 11769 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $59507 m0 *1 214.82,508.64
X$59507 57 15501 11770 10111 10266 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $59515 m0 *1 239.2,508.64
X$59515 73 11083 73 57 10694 57 sky130_fd_sc_hd__buf_4
* cell instance $59517 m0 *1 243.8,508.64
X$59517 73 11860 11716 11859 73 11657 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59518 m0 *1 245.64,508.64
X$59518 73 11047 11624 11861 73 11860 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59527 m0 *1 265.88,508.64
X$59527 73 11810 9915 11862 57 73 11806 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59536 m0 *1 281.06,508.64
X$59536 73 11864 10508 11812 57 73 11716 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59538 m0 *1 283.82,508.64
X$59538 73 11120 10320 12044 73 11812 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59540 m0 *1 287.5,508.64
X$59540 73 11814 73 57 11714 57 sky130_fd_sc_hd__buf_4
* cell instance $59542 m0 *1 291.18,508.64
X$59542 73 11781 73 57 11120 57 sky130_fd_sc_hd__buf_4
* cell instance $59545 m0 *1 298.54,508.64
X$59545 73 11717 11400 11947 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59547 m0 *1 300.38,508.64
X$59547 73 10091 9993 11717 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59549 m0 *1 303.6,508.64
X$59549 57 11631 11782 11289 11870 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $59552 m0 *1 307.28,508.64
X$59552 73 9976 11871 11630 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59557 m0 *1 315.56,508.64
X$59557 57 15492 11719 9742 9892 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $59563 m0 *1 330.74,508.64
X$59563 73 7947 73 57 11710 57 sky130_fd_sc_hd__buf_4
* cell instance $59565 m0 *1 333.96,508.64
X$59565 73 12039 73 57 8316 57 sky130_fd_sc_hd__buf_4
* cell instance $59569 m0 *1 339.94,508.64
X$59569 73 11872 73 57 7947 57 sky130_fd_sc_hd__buf_4
* cell instance $59575 m0 *1 355.12,508.64
X$59575 73 7226 73 57 11406 57 sky130_fd_sc_hd__buf_4
* cell instance $59576 m0 *1 357.88,508.64
X$59576 73 6762 8911 73 11816 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59578 m0 *1 361.56,508.64
X$59578 57 11868 11817 11635 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $59580 m0 *1 369.38,508.64
X$59580 57 11817 11865 10785 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $59581 m0 *1 373.06,508.64
X$59581 57 11866 11786 11695 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $59582 m0 *1 380.42,508.64
X$59582 57 11784 11867 11720 11721 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $59584 m0 *1 389.16,508.64
X$59584 57 11727 11786 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $59588 m0 *1 404.8,508.64
X$59588 73 8253 11819 11863 57 73 11722 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59589 m0 *1 406.64,508.64
X$59589 73 11722 8253 11780 57 73 11550 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59592 m0 *1 410.78,508.64
X$59592 73 9748 10165 10293 11580 57 73 11863 57 sky130_fd_sc_hd__a31oi_1
* cell instance $59599 m0 *1 421.36,508.64
X$59599 73 11818 11725 11693 73 11625 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59605 m0 *1 433.78,508.64
X$59605 73 11726 10165 9449 57 73 11905 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59607 m0 *1 437.46,508.64
X$59607 73 11726 11728 11818 11470 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $59613 m0 *1 445.74,508.64
X$59613 73 9720 73 57 11728 57 sky130_fd_sc_hd__buf_4
* cell instance $59616 m0 *1 451.26,508.64
X$59616 57 11727 11820 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $59617 m0 *1 460.46,508.64
X$59617 73 10619 73 57 11819 57 sky130_fd_sc_hd__buf_4
* cell instance $59620 m0 *1 465.98,508.64
X$59620 73 10702 73 57 11821 57 sky130_fd_sc_hd__buf_4
* cell instance $59622 m0 *1 469.66,508.64
X$59622 73 8557 11857 11774 11583 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $59634 m0 *1 499.56,508.64
X$59634 73 8975 11664 11511 57 73 11768 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59641 m0 *1 523.48,508.64
X$59641 73 11452 57 73 57 sky130_fd_sc_hd__clkbuf_1
* cell instance $59650 m0 *1 546.02,508.64
X$59650 73 9161 10714 11413 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59651 m0 *1 547.4,508.64
X$59651 73 11851 11413 9703 11822 57 73 11732 57 sky130_fd_sc_hd__a31oi_1
* cell instance $59653 m0 *1 550.62,508.64
X$59653 73 9703 11667 9758 73 11822 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59655 m0 *1 552.92,508.64
X$59655 73 9529 9864 11002 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59658 m0 *1 555.22,508.64
X$59658 73 9673 11824 10714 73 11825 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59659 m0 *1 557.06,508.64
X$59659 73 11825 11826 11668 11002 10928 11743 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $59663 m0 *1 563.5,508.64
X$59663 73 9673 9864 9323 57 73 11735 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59664 m0 *1 565.34,508.64
X$59664 73 9864 9323 9703 73 11827 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59665 m0 *1 567.18,508.64
X$59665 57 11735 11751 11827 10248 9323 9703 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $59672 m0 *1 586.04,508.64
X$59672 57 11837 11670 10825 9864 9161 11667 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $59674 m0 *1 591.1,508.64
X$59674 73 11737 9244 9321 11732 57 11913 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $59678 m0 *1 601.22,508.64
X$59678 57 11738 11737 9161 11668 9845 9703 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $59686 m0 *1 615.02,508.64
X$59686 73 11338 9529 11332 57 73 11740 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59702 r0 *1 3.22,508.64
X$59702 73 11333 73 57 57 sky130_fd_sc_hd__clkinv_2
* cell instance $59703 r0 *1 5.06,508.64
X$59703 73 14056 57 73 11795 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $59704 r0 *1 8.74,508.64
X$59704 57 11949 11333 11746 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $59709 r0 *1 16.56,508.64
X$59709 73 11796 57 73 11875 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $59712 r0 *1 22.54,508.64
X$59712 57 11914 11376 11832 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $59715 r0 *1 32.2,508.64
X$59715 73 9331 10913 11797 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $59724 r0 *1 44.62,508.64
X$59724 73 11833 73 57 11798 57 sky130_fd_sc_hd__buf_4
* cell instance $59725 r0 *1 47.38,508.64
X$59725 57 11834 11640 11486 11920 12301 11919 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $59726 r0 *1 50.6,508.64
X$59726 73 11708 11635 73 11922 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59727 r0 *1 53.82,508.64
X$59727 57 8788 10727 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $59729 r0 *1 63.94,508.64
X$59729 57 11799 11800 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $59736 r0 *1 73.14,508.64
X$59736 73 11800 12785 11841 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59741 r0 *1 83.26,508.64
X$59741 73 11801 11798 11802 11843 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $59745 r0 *1 91.08,508.64
X$59745 57 15601 11803 11800 11844 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $59747 r0 *1 96.14,508.64
X$59747 73 11803 11845 11929 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59755 r0 *1 99.82,508.64
X$59755 57 11565 11302 11804 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $59760 r0 *1 116.38,508.64
X$59760 57 11429 15445 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $59769 r0 *1 127.88,508.64
X$59769 57 11846 10969 11386 11432 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $59772 r0 *1 138,508.64
X$59772 57 11435 11805 11367 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $59775 r0 *1 150.88,508.64
X$59775 73 11565 11756 73 11890 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59780 r0 *1 154.56,508.64
X$59780 73 11709 11889 11848 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $59781 r0 *1 157.78,508.64
X$59781 73 11709 11850 73 11611 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59782 r0 *1 161,508.64
X$59782 73 11390 11656 73 11935 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59783 r0 *1 164.22,508.64
X$59783 57 11936 11390 11613 11656 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $59790 r0 *1 178.94,508.64
X$59790 73 7226 73 57 11940 57 sky130_fd_sc_hd__buf_4
* cell instance $59795 r0 *1 187.22,508.64
X$59795 57 11615 11227 11807 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $59797 r0 *1 198.26,508.64
X$59797 73 11853 12326 11941 10311 11854 11807 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $59808 r0 *1 218.04,508.64
X$59808 73 11808 11770 10601 57 73 11568 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59818 r0 *1 234.14,508.64
X$59818 73 11858 73 57 11228 57 sky130_fd_sc_hd__buf_4
* cell instance $59820 r0 *1 237.36,508.64
X$59820 73 10272 10601 11858 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $59823 r0 *1 240.12,508.64
X$59823 73 11398 11083 11809 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $59828 r0 *1 253.46,508.64
X$59828 73 11080 73 57 11658 57 sky130_fd_sc_hd__buf_4
* cell instance $59837 r0 *1 265.88,508.64
X$59837 73 10323 10111 11898 73 11862 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59841 r0 *1 275.54,508.64
X$59841 73 9915 10272 10111 57 73 11900 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59845 r0 *1 282.44,508.64
X$59845 73 11810 11811 11398 73 11864 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59850 r0 *1 287.96,508.64
X$59850 73 11813 73 57 11808 57 sky130_fd_sc_hd__buf_4
* cell instance $59851 r0 *1 290.72,508.64
X$59851 73 11781 9742 11814 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $59855 r0 *1 297.16,508.64
X$59855 73 11947 11815 11946 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $59856 r0 *1 300.38,508.64
X$59856 73 11289 11717 11870 57 73 11813 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59859 r0 *1 306.36,508.64
X$59859 57 11815 11787 11814 11810 9976 73 73 57 sky130_fd_sc_hd__o31ai_2
* cell instance $59860 r0 *1 310.96,508.64
X$59860 73 11787 11814 11815 73 11871 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59872 r0 *1 326.14,508.64
X$59872 73 10884 9578 73 11995 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $59876 r0 *1 332.58,508.64
X$59876 57 11872 11902 11873 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $59885 r0 *1 355.12,508.64
X$59885 57 8911 11869 11942 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $59898 r0 *1 378.58,508.64
X$59898 57 11867 10784 10884 10515 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $59900 r0 *1 387.78,508.64
X$59900 57 11786 15440 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $59925 r0 *1 437.92,508.64
X$59925 73 11856 73 57 11818 57 sky130_fd_sc_hd__buf_4
* cell instance $59927 r0 *1 444.36,508.64
X$59927 73 10666 10990 8557 11856 57 11778 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $59933 r0 *1 451.26,508.64
X$59933 57 11820 15439 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $59942 r0 *1 468.74,508.64
X$59942 73 10053 73 57 11857 57 sky130_fd_sc_hd__buf_4
* cell instance $59943 r0 *1 471.5,508.64
X$59943 73 11461 9552 11856 10374 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $59950 r0 *1 482.54,508.64
X$59950 73 11930 73 57 9056 57 sky130_fd_sc_hd__buf_4
* cell instance $59982 r0 *1 550.62,508.64
X$59982 73 9864 11823 11928 73 11849 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $59984 r0 *1 552.92,508.64
X$59984 73 9673 11909 9529 9406 57 11926 73 57 sky130_fd_sc_hd__a22o_1
* cell instance $59985 r0 *1 556.14,508.64
X$59985 73 9864 9406 11824 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $59986 r0 *1 557.52,508.64
X$59986 73 11824 9864 11668 57 73 11826 57 sky130_fd_sc_hd__a21oi_1
* cell instance $59991 r0 *1 561.2,508.64
X$59991 73 11668 9161 10130 57 73 11823 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60000 r0 *1 578.68,508.64
X$60000 73 11436 9864 10248 9406 11921 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $60006 r0 *1 586.5,508.64
X$60006 73 10627 11837 11839 11828 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $60011 r0 *1 596.62,508.64
X$60011 73 11829 9244 11913 10210 11828 73 11912 57 57 sky130_fd_sc_hd__a311oi_1
* cell instance $60019 r0 *1 612.72,508.64
X$60019 73 11830 9406 11740 57 73 11829 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60020 r0 *1 614.56,508.64
X$60020 73 9406 11911 11103 11830 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $60028 r0 *1 626.06,508.64
X$60028 73 11592 73 57 11911 57 sky130_fd_sc_hd__buf_4
* cell instance $60043 m0 *1 5.98,514.08
X$60043 73 11874 57 73 11595 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60044 m0 *1 9.66,514.08
X$60044 57 10727 11333 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $60046 m0 *1 19.32,514.08
X$60046 57 11796 11376 11876 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60051 m0 *1 30.36,514.08
X$60051 73 8080 10913 73 11950 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $60053 m0 *1 34.04,514.08
X$60053 73 12055 4052 73 11876 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $60056 m0 *1 41.86,514.08
X$60056 73 11800 11916 11917 11834 11919 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $60059 m0 *1 46,514.08
X$60059 73 11918 73 57 11927 57 sky130_fd_sc_hd__buf_4
* cell instance $60060 m0 *1 48.76,514.08
X$60060 57 11486 11879 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $60065 m0 *1 58.42,514.08
X$60065 57 11834 11877 11707 11878 11880 11923 73 73 57 sky130_fd_sc_hd__o221a_2
* cell instance $60066 m0 *1 62.56,514.08
X$60066 73 12000 11800 11924 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60067 m0 *1 63.94,514.08
X$60067 73 11924 11881 11845 73 11882 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60069 m0 *1 66.7,514.08
X$60069 73 11883 11882 11972 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60071 m0 *1 68.54,514.08
X$60071 73 12031 11972 11923 57 73 11638 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60072 m0 *1 70.38,514.08
X$60072 73 11952 73 57 11883 57 sky130_fd_sc_hd__buf_4
* cell instance $60074 m0 *1 74.06,514.08
X$60074 73 11884 73 57 11925 57 sky130_fd_sc_hd__buf_4
* cell instance $60077 m0 *1 78.2,514.08
X$60077 73 11885 11834 11879 11927 57 11840 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $60080 m0 *1 82.34,514.08
X$60080 73 11884 11886 11706 11879 57 73 11952 57 sky130_fd_sc_hd__a31oi_1
* cell instance $60084 m0 *1 86.02,514.08
X$60084 73 11844 11800 11884 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60088 m0 *1 93.38,514.08
X$60088 73 11845 11888 11929 73 11885 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60091 m0 *1 96.6,514.08
X$60091 73 11845 11931 11929 11879 11978 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $60092 m0 *1 99.36,514.08
X$60092 73 11888 11802 11932 73 11931 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $60095 m0 *1 106.26,514.08
X$60095 73 12089 73 57 11801 57 sky130_fd_sc_hd__buf_4
* cell instance $60103 m0 *1 123.74,514.08
X$60103 57 11753 11263 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $60108 m0 *1 140.76,514.08
X$60108 57 11981 11390 11307 11131 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $60109 m0 *1 149.5,514.08
X$60109 57 11383 11933 11890 11934 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $60117 m0 *1 170.66,514.08
X$60117 57 11937 11956 11852 11939 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $60127 m0 *1 201.02,514.08
X$60127 73 9735 11892 11891 73 11854 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60132 m0 *1 214.82,514.08
X$60132 73 12051 10976 9735 10694 57 73 11891 57 sky130_fd_sc_hd__a31oi_1
* cell instance $60135 m0 *1 221.26,514.08
X$60135 73 9741 11394 11311 11893 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $60137 m0 *1 223.56,514.08
X$60137 73 9741 10564 11893 10508 11894 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $60138 m0 *1 226.32,514.08
X$60138 73 10600 12273 9915 57 73 10564 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60142 m0 *1 236.44,514.08
X$60142 73 11895 11894 11989 11945 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $60146 m0 *1 241.5,514.08
X$60146 73 11809 73 57 11895 57 sky130_fd_sc_hd__buf_4
* cell instance $60148 m0 *1 246.1,514.08
X$60148 73 9976 11896 11989 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60155 m0 *1 253.46,514.08
X$60155 73 9892 11957 11080 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60159 m0 *1 260.82,514.08
X$60159 73 10508 11897 11779 73 11892 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60160 m0 *1 262.66,514.08
X$60160 57 10695 11896 10412 11898 11547 10579 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $60161 m0 *1 265.88,514.08
X$60161 73 9892 10111 11898 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60172 m0 *1 293.02,514.08
X$60172 57 11899 10579 10323 9742 9892 11815 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $60173 m0 *1 296.24,514.08
X$60173 73 11895 11899 11946 9976 11993 11404 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $60175 m0 *1 301.3,514.08
X$60175 73 9892 9742 11870 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60176 m0 *1 302.68,514.08
X$60176 73 11900 11870 12104 11815 73 11901 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $60181 m0 *1 311.88,514.08
X$60181 73 10091 9832 10111 11787 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $60184 m0 *1 318.32,514.08
X$60184 73 11901 73 57 11465 57 sky130_fd_sc_hd__buf_4
* cell instance $60194 m0 *1 339.94,514.08
X$60194 57 12035 8317 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $60196 m0 *1 348.22,514.08
X$60196 57 11994 11902 11944 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60200 m0 *1 361.56,514.08
X$60200 57 11869 12033 11943 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $60203 m0 *1 366.62,514.08
X$60203 57 12032 11131 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $60206 m0 *1 378.58,514.08
X$60206 57 12029 12018 11475 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $60208 m0 *1 383.18,514.08
X$60208 73 11293 73 57 10784 57 sky130_fd_sc_hd__buf_4
* cell instance $60209 m0 *1 385.94,514.08
X$60209 73 11720 73 57 11788 57 sky130_fd_sc_hd__buf_4
* cell instance $60213 m0 *1 393.76,514.08
X$60213 73 10784 7770 73 11938 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $60216 m0 *1 401.58,514.08
X$60216 73 11903 73 57 7283 57 sky130_fd_sc_hd__buf_4
* cell instance $60220 m0 *1 413.54,514.08
X$60220 73 11724 9570 11904 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60225 m0 *1 418.6,514.08
X$60225 73 11904 73 57 11959 57 sky130_fd_sc_hd__buf_4
* cell instance $60231 m0 *1 431.94,514.08
X$60231 57 10489 11580 9722 11906 11905 11990 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $60233 m0 *1 437.46,514.08
X$60233 73 10293 73 57 11726 57 sky130_fd_sc_hd__buf_4
* cell instance $60239 m0 *1 452.18,514.08
X$60239 73 8557 10702 10387 57 73 11907 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60240 m0 *1 454.02,514.08
X$60240 73 9644 11821 11726 57 73 11906 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60242 m0 *1 457.7,514.08
X$60242 73 11987 73 57 9886 57 sky130_fd_sc_hd__buf_4
* cell instance $60245 m0 *1 461.84,514.08
X$60245 57 11986 10619 8557 8314 11907 11509 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $60254 m0 *1 478.86,514.08
X$60254 73 11510 11821 11461 12079 57 11930 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $60279 m0 *1 546.94,514.08
X$60279 73 9529 9758 11189 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60280 m0 *1 548.32,514.08
X$60280 73 9161 10714 11666 57 73 11915 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60281 m0 *1 550.16,514.08
X$60281 57 11928 11926 9758 9409 9864 11667 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $60284 m0 *1 554.76,514.08
X$60284 73 9406 11189 11980 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60286 m0 *1 557.06,514.08
X$60286 73 10714 11980 11908 57 73 11839 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60287 m0 *1 558.9,514.08
X$60287 73 9161 10248 11908 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60289 m0 *1 561.2,514.08
X$60289 73 9406 10714 11909 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60293 m0 *1 565.8,514.08
X$60293 57 11977 11921 11589 9409 9703 11909 73 73 57 sky130_fd_sc_hd__a221oi_1
* cell instance $60297 m0 *1 572.24,514.08
X$60297 73 9864 9161 10844 9762 73 11748 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $60303 m0 *1 582.82,514.08
X$60303 73 10034 9529 10024 57 73 11910 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60330 r0 *1 2.3,514.08
X$60330 73 11949 57 73 11967 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60332 r0 *1 6.9,514.08
X$60332 57 12075 11333 11950 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60340 r0 *1 23,514.08
X$60340 73 8661 73 57 11998 57 sky130_fd_sc_hd__buf_4
* cell instance $60341 r0 *1 25.76,514.08
X$60341 73 11914 57 73 11948 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60355 r0 *1 52.9,514.08
X$60355 57 11836 11834 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $60358 r0 *1 63.02,514.08
X$60358 73 11882 11834 12028 11951 57 11971 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $60366 r0 *1 74.52,514.08
X$60366 73 11954 11845 12034 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60367 r0 *1 75.9,514.08
X$60367 73 11973 12034 11845 11975 11925 11953 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $60368 r0 *1 79.58,514.08
X$60368 73 12036 73 57 11881 57 sky130_fd_sc_hd__buf_4
* cell instance $60370 r0 *1 86.02,514.08
X$60370 73 11834 11955 11973 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60378 r0 *1 99.36,514.08
X$60378 73 11834 11955 11976 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60395 r0 *1 144.44,514.08
X$60395 57 11982 11981 11933 11890 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $60401 r0 *1 154.56,514.08
X$60401 73 11690 73 57 11691 57 sky130_fd_sc_hd__buf_4
* cell instance $60403 r0 *1 157.78,514.08
X$60403 73 11390 7376 73 11983 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $60405 r0 *1 162.84,514.08
X$60405 57 11984 11936 11761 11760 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $60406 r0 *1 171.12,514.08
X$60406 73 11956 11615 73 11760 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $60414 r0 *1 187.68,514.08
X$60414 73 12175 73 57 9483 57 sky130_fd_sc_hd__buf_4
* cell instance $60431 r0 *1 232.3,514.08
X$60431 73 11988 73 57 11311 57 sky130_fd_sc_hd__buf_4
* cell instance $60438 r0 *1 240.12,514.08
X$60438 73 12047 73 57 10276 57 sky130_fd_sc_hd__buf_4
* cell instance $60443 r0 *1 253,514.08
X$60443 73 9993 9915 11957 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60445 r0 *1 255.3,514.08
X$60445 73 11957 73 57 10579 57 sky130_fd_sc_hd__buf_4
* cell instance $60455 r0 *1 273.24,514.08
X$60455 73 9742 11394 10573 11958 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $60458 r0 *1 277.84,514.08
X$60458 73 10609 73 57 11991 57 sky130_fd_sc_hd__buf_4
* cell instance $60461 r0 *1 286.12,514.08
X$60461 73 11992 9915 11631 57 73 11897 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60468 r0 *1 293.02,514.08
X$60468 73 9976 11958 11993 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60473 r0 *1 309.12,514.08
X$60473 73 11205 10111 11631 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60483 r0 *1 327.98,514.08
X$60483 73 11995 73 57 11887 57 sky130_fd_sc_hd__buf_4
* cell instance $60486 r0 *1 334.88,514.08
X$60486 73 11656 73 57 11939 57 sky130_fd_sc_hd__buf_4
* cell instance $60490 r0 *1 340.86,514.08
X$60490 73 11405 9219 73 11996 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $60493 r0 *1 344.08,514.08
X$60493 73 11939 4895 73 11944 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $60495 r0 *1 347.76,514.08
X$60495 57 11727 11902 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $60509 r0 *1 386.4,514.08
X$60509 57 11367 12022 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $60511 r0 *1 394.22,514.08
X$60511 57 12070 11903 4809 11405 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $60519 r0 *1 411.7,514.08
X$60519 73 9146 73 57 11580 57 sky130_fd_sc_hd__buf_4
* cell instance $60522 r0 *1 419.98,514.08
X$60522 73 11724 8644 10293 73 11725 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60531 r0 *1 433.32,514.08
X$60531 73 11580 11959 9893 11990 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $60544 r0 *1 460.46,514.08
X$60544 73 11961 11960 11986 8408 57 11987 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $60550 r0 *1 476.56,514.08
X$60550 73 11985 73 57 8833 57 sky130_fd_sc_hd__buf_4
* cell instance $60553 r0 *1 479.32,514.08
X$60553 57 7375 11691 12412 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $60555 r0 *1 485.76,514.08
X$60555 73 10709 10425 11580 8315 57 11962 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $60556 r0 *1 488.52,514.08
X$60556 57 11961 9313 11511 11962 11959 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $60587 r0 *1 563.04,514.08
X$60587 73 10260 11963 10462 73 11979 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60588 r0 *1 564.88,514.08
X$60588 73 11979 11974 11977 57 73 11329 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60597 r0 *1 579.14,514.08
X$60597 57 9762 11970 9864 10248 10024 10844 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $60598 r0 *1 582.36,514.08
X$60598 73 10248 10918 11964 9406 73 57 11974 57 sky130_fd_sc_hd__o31ai_1
* cell instance $60599 r0 *1 585.12,514.08
X$60599 73 10132 11910 11964 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60603 r0 *1 586.96,514.08
X$60603 73 10132 10529 11915 73 11965 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60604 r0 *1 588.8,514.08
X$60604 73 9406 11970 11965 9409 11969 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $60610 r0 *1 598.46,514.08
X$60610 73 11516 12024 10561 11912 73 11968 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $60612 r0 *1 604.44,514.08
X$60612 73 11966 73 57 11963 57 sky130_fd_sc_hd__buf_4
* cell instance $60613 r0 *1 607.2,514.08
X$60613 73 12023 73 57 4809 57 sky130_fd_sc_hd__buf_4
* cell instance $60614 r0 *1 609.96,514.08
X$60614 73 9161 11911 10738 9409 73 57 11966 57 sky130_fd_sc_hd__o31ai_1
* cell instance $60641 m0 *1 4.6,519.52
X$60641 57 12025 11333 11887 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60642 m0 *1 11.96,519.52
X$60642 57 12077 11333 11983 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60647 m0 *1 21.62,519.52
X$60647 57 11998 12002 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $60654 m0 *1 41.86,519.52
X$60654 57 11918 11916 12000 11834 11800 12026 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $60658 m0 *1 49.68,519.52
X$60658 73 11880 11999 11834 73 12081 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60662 m0 *1 54.74,519.52
X$60662 73 11999 73 57 11878 57 sky130_fd_sc_hd__buf_4
* cell instance $60664 m0 *1 57.96,519.52
X$60664 73 11641 11955 11951 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60666 m0 *1 63.02,519.52
X$60666 57 12028 11925 12083 11834 12001 11845 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $60667 m0 *1 66.24,519.52
X$60667 73 11845 12084 11802 57 73 12001 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60670 m0 *1 69.46,519.52
X$60670 57 15496 11954 11802 12002 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $60674 m0 *1 78.66,519.52
X$60674 73 12002 12040 11802 12036 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $60680 m0 *1 88.32,519.52
X$60680 73 12002 12040 12003 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60681 m0 *1 89.7,519.52
X$60681 73 11802 12003 11888 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60682 m0 *1 91.08,519.52
X$60682 73 11976 73 57 11842 57 sky130_fd_sc_hd__buf_4
* cell instance $60684 m0 *1 95.68,519.52
X$60684 73 12002 12004 11707 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60686 m0 *1 97.06,519.52
X$60686 73 12056 73 57 11932 57 sky130_fd_sc_hd__buf_4
* cell instance $60687 m0 *1 99.82,519.52
X$60687 73 12043 11879 11877 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60689 m0 *1 102.12,519.52
X$60689 73 11932 11955 12006 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60691 m0 *1 104.42,519.52
X$60691 73 11802 73 57 12005 57 sky130_fd_sc_hd__buf_4
* cell instance $60692 m0 *1 107.18,519.52
X$60692 73 12057 11879 12092 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60693 m0 *1 108.56,519.52
X$60693 73 12006 12092 12005 12007 57 73 12093 57 sky130_fd_sc_hd__a31oi_1
* cell instance $60694 m0 *1 110.86,519.52
X$60694 73 12005 11879 12091 12007 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $60703 m0 *1 132.02,519.52
X$60703 73 12094 73 57 10736 57 sky130_fd_sc_hd__buf_4
* cell instance $60709 m0 *1 142.14,519.52
X$60709 73 12045 73 57 10858 57 sky130_fd_sc_hd__buf_4
* cell instance $60710 m0 *1 144.9,519.52
X$60710 73 11889 12045 73 11493 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $60713 m0 *1 150.42,519.52
X$60713 73 9303 7355 12008 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $60715 m0 *1 152.72,519.52
X$60715 73 7355 9303 12062 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60717 m0 *1 155.02,519.52
X$60717 73 12046 12008 12167 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60719 m0 *1 157.32,519.52
X$60719 57 11934 11656 12049 11432 73 73 57 sky130_fd_sc_hd__xor3_1
* cell instance $60723 m0 *1 170.2,519.52
X$60723 73 12050 11956 12097 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $60738 m0 *1 208.38,519.52
X$60738 73 10111 10318 11310 12102 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $60742 m0 *1 213.44,519.52
X$60742 73 10485 12103 9742 12009 73 12051 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $60744 m0 *1 217.58,519.52
X$60744 73 12011 10323 10485 57 73 12009 57 sky130_fd_sc_hd__a21boi_0
* cell instance $60745 m0 *1 220.34,519.52
X$60745 73 12010 73 57 12011 57 sky130_fd_sc_hd__buf_4
* cell instance $60750 m0 *1 226.78,519.52
X$60750 73 10266 9710 12010 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60753 m0 *1 230.46,519.52
X$60753 73 9993 9915 11988 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60754 m0 *1 231.84,519.52
X$60754 73 9710 73 57 12048 57 sky130_fd_sc_hd__buf_4
* cell instance $60757 m0 *1 235.06,519.52
X$60757 73 12048 11988 12010 73 12047 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60760 m0 *1 239.2,519.52
X$60760 73 12105 73 57 10755 57 sky130_fd_sc_hd__buf_4
* cell instance $60770 m0 *1 258.06,519.52
X$60770 73 10286 10985 12012 12013 57 10879 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $60776 m0 *1 267.72,519.52
X$60776 73 12108 73 57 11076 57 sky130_fd_sc_hd__buf_4
* cell instance $60779 m0 *1 273.24,519.52
X$60779 73 11398 10573 12014 73 12106 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $60780 m0 *1 275.08,519.52
X$60780 73 11398 10579 12014 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60785 m0 *1 283.36,519.52
X$60785 73 9892 12065 12044 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60787 m0 *1 285.66,519.52
X$60787 73 11289 11631 12015 57 73 11811 57 sky130_fd_sc_hd__a21oi_1
* cell instance $60790 m0 *1 288.42,519.52
X$60790 73 11781 11815 12013 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $60799 m0 *1 310.5,519.52
X$60799 73 11205 9742 12067 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60803 m0 *1 314.18,519.52
X$60803 73 10091 12042 12041 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $60809 m0 *1 326.14,519.52
X$60809 57 12039 9037 12099 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60811 m0 *1 333.96,519.52
X$60811 57 12035 11902 12038 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60813 m0 *1 341.32,519.52
X$60813 73 11996 73 57 12037 57 sky130_fd_sc_hd__buf_4
* cell instance $60816 m0 *1 345.46,519.52
X$60816 73 11902 73 57 57 sky130_fd_sc_hd__inv_6
* cell instance $60818 m0 *1 349.6,519.52
X$60818 57 4950 12033 11902 12016 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $60821 m0 *1 361.56,519.52
X$60821 57 12032 11902 12017 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60823 m0 *1 368.92,519.52
X$60823 57 12030 11437 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $60825 m0 *1 377.2,519.52
X$60825 57 7183 12029 12095 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $60831 m0 *1 390.54,519.52
X$60831 73 11481 73 57 8451 57 sky130_fd_sc_hd__buf_4
* cell instance $60832 m0 *1 393.3,519.52
X$60832 57 12071 12019 11938 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60836 m0 *1 402.04,519.52
X$60836 73 8451 5718 73 12088 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $60840 m0 *1 413.54,519.52
X$60840 73 12020 73 57 9746 57 sky130_fd_sc_hd__buf_4
* cell instance $60845 m0 *1 419.98,519.52
X$60845 73 12021 73 57 11723 57 sky130_fd_sc_hd__buf_4
* cell instance $60847 m0 *1 422.74,519.52
X$60847 73 12027 73 57 12021 57 sky130_fd_sc_hd__buf_4
* cell instance $60853 m0 *1 437.92,519.52
X$60853 73 10425 8644 12020 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60866 m0 *1 467.82,519.52
X$60866 73 9146 8314 11985 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60868 m0 *1 469.66,519.52
X$60868 73 12021 11985 10053 11960 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $60920 m0 *1 596.16,519.52
X$60920 73 10462 10747 11969 12024 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $60923 m0 *1 600.3,519.52
X$60923 57 12023 11763 11968 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60946 r0 *1 5.98,519.52
X$60946 73 12025 57 73 12110 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60949 r0 *1 12.42,519.52
X$60949 73 12075 57 73 12052 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60954 r0 *1 19.32,519.52
X$60954 73 12077 57 73 11997 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60955 r0 *1 23,519.52
X$60955 73 8661 73 57 12112 57 sky130_fd_sc_hd__clkinv_1
* cell instance $60958 r0 *1 26.68,519.52
X$60958 57 15606 12054 12053 12002 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $60959 r0 *1 31.28,519.52
X$60959 57 12054 12057 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $60970 r0 *1 57.96,519.52
X$60970 73 12082 11881 11877 12151 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $60973 r0 *1 64.4,519.52
X$60973 57 12083 12152 11800 12002 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $60982 r0 *1 83.26,519.52
X$60982 73 12003 73 57 12085 57 sky130_fd_sc_hd__buf_4
* cell instance $60985 r0 *1 91.54,519.52
X$60985 57 11613 11302 12087 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $60989 r0 *1 101.2,519.52
X$60989 73 11800 11877 12401 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $60990 r0 *1 102.58,519.52
X$60990 57 12119 11932 12043 73 73 57 sky130_fd_sc_hd__nand2b_2
* cell instance $60992 r0 *1 106.26,519.52
X$60992 73 12057 12043 12089 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61007 r0 *1 141.22,519.52
X$61007 73 11889 12055 12058 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61008 r0 *1 144.44,519.52
X$61008 73 12058 12123 12094 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61012 r0 *1 150.88,519.52
X$61012 73 12059 12008 12060 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61014 r0 *1 152.26,519.52
X$61014 73 11438 12060 12061 57 73 12166 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61016 r0 *1 154.56,519.52
X$61016 73 12059 12062 12168 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61018 r0 *1 156.4,519.52
X$61018 57 12059 11656 11126 11432 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $61020 r0 *1 165.14,519.52
X$61020 73 12049 73 57 11126 57 sky130_fd_sc_hd__buf_4
* cell instance $61021 r0 *1 167.9,519.52
X$61021 73 12097 12170 9662 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61024 r0 *1 173.42,519.52
X$61024 57 12171 11850 12050 10691 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $61028 r0 *1 184,519.52
X$61028 57 12124 12055 12050 11615 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $61033 r0 *1 205.16,519.52
X$61033 57 10111 11855 10508 12063 10760 12102 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $61043 r0 *1 226.78,519.52
X$61043 73 9741 11037 11194 12127 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $61046 r0 *1 230,519.52
X$61046 73 9993 10601 11194 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61054 r0 *1 243.34,519.52
X$61054 73 11809 12334 12065 12107 10111 12105 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $61057 r0 *1 251.16,519.52
X$61057 73 12013 73 57 12063 57 sky130_fd_sc_hd__buf_4
* cell instance $61066 r0 *1 268.64,519.52
X$61066 73 9976 12109 12064 12108 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $61069 r0 *1 273.24,519.52
X$61069 73 9742 12106 11785 11289 9989 12064 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $61071 r0 *1 276.92,519.52
X$61071 73 11991 73 57 12065 57 sky130_fd_sc_hd__buf_4
* cell instance $61083 r0 *1 302.68,519.52
X$61083 57 12104 12101 9742 10091 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61084 r0 *1 307.28,519.52
X$61084 73 12101 12163 11815 12187 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $61086 r0 *1 310.04,519.52
X$61086 73 9832 10111 12042 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61087 r0 *1 311.42,519.52
X$61087 73 12067 73 57 11785 57 sky130_fd_sc_hd__buf_4
* cell instance $61094 r0 *1 322.92,519.52
X$61094 73 11852 73 57 12098 57 sky130_fd_sc_hd__buf_4
* cell instance $61096 r0 *1 326.6,519.52
X$61096 73 12098 5874 73 12160 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61101 r0 *1 336.72,519.52
X$61101 73 12068 9219 73 12159 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61105 r0 *1 341.32,519.52
X$61105 57 12096 12068 9219 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $61109 r0 *1 355.12,519.52
X$61109 73 11994 57 73 12157 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61111 r0 *1 360.64,519.52
X$61111 73 12069 11379 73 12066 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61114 r0 *1 366.16,519.52
X$61114 73 7227 73 57 12069 57 sky130_fd_sc_hd__buf_4
* cell instance $61121 r0 *1 375.82,519.52
X$61121 57 12068 15216 11628 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $61123 r0 *1 380.42,519.52
X$61123 73 11866 57 73 12134 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61124 r0 *1 384.1,519.52
X$61124 57 10515 12019 12078 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61125 r0 *1 391.46,519.52
X$61125 73 12069 8451 73 12090 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61126 r0 *1 394.68,519.52
X$61126 73 12090 12070 12086 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61129 r0 *1 398.82,519.52
X$61129 73 12071 57 73 12137 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61131 r0 *1 402.96,519.52
X$61131 57 12153 12019 12088 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61133 r0 *1 410.78,519.52
X$61133 73 8261 73 57 11501 57 sky130_fd_sc_hd__buf_4
* cell instance $61139 r0 *1 422.74,519.52
X$61139 73 10293 12020 12072 57 73 12027 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61141 r0 *1 425.04,519.52
X$61141 73 8483 9273 10268 73 12072 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61147 r0 *1 431.48,519.52
X$61147 73 12138 73 57 11505 57 sky130_fd_sc_hd__buf_4
* cell instance $61153 r0 *1 446.66,519.52
X$61153 73 8483 9273 10268 11856 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $61158 r0 *1 454.48,519.52
X$61158 73 10331 73 57 10990 57 sky130_fd_sc_hd__buf_4
* cell instance $61162 r0 *1 461.84,519.52
X$61162 73 10425 10293 10268 73 12073 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61163 r0 *1 463.68,519.52
X$61163 73 12073 73 57 9644 57 sky130_fd_sc_hd__buf_4
* cell instance $61168 r0 *1 476.1,519.52
X$61168 73 10425 11510 12079 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61188 r0 *1 521.18,519.52
X$61188 57 10789 11452 12074 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $61246 m0 *1 9.2,524.96
X$61246 73 12144 73 57 11013 57 sky130_fd_sc_hd__inv_1
* cell instance $61248 m0 *1 12.42,524.96
X$61248 73 12111 57 73 11427 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61252 m0 *1 16.56,524.96
X$61252 57 15495 12080 12114 12112 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61253 m0 *1 21.16,524.96
X$61253 57 15554 12430 12113 11998 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61254 m0 *1 25.76,524.96
X$61254 73 12114 57 73 12113 57 sky130_fd_sc_hd__inv_2
* cell instance $61255 m0 *1 27.14,524.96
X$61255 73 12080 73 57 12000 57 sky130_fd_sc_hd__buf_4
* cell instance $61257 m0 *1 30.36,524.96
X$61257 73 12113 73 57 12053 57 sky130_fd_sc_hd__buf_4
* cell instance $61265 m0 *1 48.76,524.96
X$61265 73 12076 11955 12081 12151 57 12118 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $61267 m0 *1 52.44,524.96
X$61267 73 12056 12082 12116 73 11920 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $61272 m0 *1 59.8,524.96
X$61272 73 12040 11706 12115 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61275 m0 *1 63.48,524.96
X$61275 57 15525 12226 11802 12002 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61281 m0 *1 77.28,524.96
X$61281 73 12084 11802 12156 73 12117 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61283 m0 *1 79.58,524.96
X$61283 73 12228 12118 11842 12117 73 12227 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $61296 m0 *1 105.34,524.96
X$61296 73 12005 12115 12119 12120 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $61299 m0 *1 109.94,524.96
X$61299 73 12043 12093 12235 11834 12161 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $61303 m0 *1 115.46,524.96
X$61303 57 12005 12236 11879 12089 12447 12120 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $61306 m0 *1 122.82,524.96
X$61306 57 12045 11429 12121 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61316 m0 *1 143.06,524.96
X$61316 73 11233 10862 73 12241 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61317 m0 *1 146.28,524.96
X$61317 57 11982 12122 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $61320 m0 *1 153.64,524.96
X$61320 73 11438 12168 12167 57 73 12182 57 sky130_fd_sc_hd__a21boi_0
* cell instance $61321 m0 *1 156.4,524.96
X$61321 73 12046 12062 12061 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61323 m0 *1 158.7,524.96
X$61323 73 11934 73 57 12046 57 sky130_fd_sc_hd__buf_4
* cell instance $61324 m0 *1 161.46,524.96
X$61324 73 12169 12123 12245 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61329 m0 *1 168.36,524.96
X$61329 57 12170 12100 10691 11613 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $61330 m0 *1 176.64,524.96
X$61330 73 10691 11956 73 12173 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61333 m0 *1 179.86,524.96
X$61333 73 12100 12098 73 12174 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61334 m0 *1 183.08,524.96
X$61334 73 12174 12124 12125 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61335 m0 *1 186.3,524.96
X$61335 57 12175 12126 12125 11940 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $61345 m0 *1 208.84,524.96
X$61345 73 9989 12127 12102 57 73 12250 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61353 m0 *1 224.02,524.96
X$61353 57 11772 9741 12466 10760 12127 12128 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $61359 m0 *1 236.9,524.96
X$61359 73 11398 12048 12129 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61361 m0 *1 238.74,524.96
X$61361 73 12129 73 57 12128 57 sky130_fd_sc_hd__buf_4
* cell instance $61363 m0 *1 245.18,524.96
X$61363 73 10985 9976 12107 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61365 m0 *1 247.48,524.96
X$61365 73 12128 10695 12172 11194 9892 73 11861 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $61375 m0 *1 268.64,524.96
X$61375 73 9892 10695 12042 11194 11398 73 12109 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $61382 m0 *1 281.06,524.96
X$61382 73 10412 9742 12130 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61384 m0 *1 283.36,524.96
X$61384 73 12130 73 57 12015 57 sky130_fd_sc_hd__buf_4
* cell instance $61389 m0 *1 288.42,524.96
X$61389 73 12255 9915 11992 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61392 m0 *1 291.18,524.96
X$61392 73 11398 12254 9976 73 12253 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61393 m0 *1 293.02,524.96
X$61393 73 12253 11398 12131 57 73 12165 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61395 m0 *1 298.54,524.96
X$61395 73 12164 73 57 11572 57 sky130_fd_sc_hd__buf_4
* cell instance $61396 m0 *1 301.3,524.96
X$61396 57 15456 12163 10111 10091 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61398 m0 *1 306.36,524.96
X$61398 73 12163 11289 12162 73 12131 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61400 m0 *1 308.66,524.96
X$61400 73 11815 12067 10985 9742 73 12162 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $61402 m0 *1 312.8,524.96
X$61402 73 9915 73 57 11815 57 sky130_fd_sc_hd__buf_4
* cell instance $61406 m0 *1 319.24,524.96
X$61406 73 12249 73 57 8081 57 sky130_fd_sc_hd__buf_4
* cell instance $61408 m0 *1 322.46,524.96
X$61408 57 12133 12132 12160 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61409 m0 *1 329.82,524.96
X$61409 73 12133 57 73 12246 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61413 m0 *1 338.1,524.96
X$61413 57 12159 12158 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $61428 m0 *1 371.68,524.96
X$61428 73 10114 4895 12239 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $61434 m0 *1 389.16,524.96
X$61434 73 10515 7186 73 12320 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61435 m0 *1 392.38,524.96
X$61435 73 12135 12070 12233 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61438 m0 *1 395.6,524.96
X$61438 73 11501 8076 73 12135 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61440 m0 *1 399.74,524.96
X$61440 73 10114 12136 12232 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61441 m0 *1 401.12,524.96
X$61441 57 12492 12458 11784 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $61442 m0 *1 404.8,524.96
X$61442 73 12154 7283 12155 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61444 m0 *1 408.48,524.96
X$61444 73 12153 57 73 12149 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61455 m0 *1 432.4,524.96
X$61455 73 10990 10268 12138 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61458 m0 *1 435.16,524.96
X$61458 73 8557 11728 12138 9273 10990 12198 73 57 57 sky130_fd_sc_hd__o221ai_1
* cell instance $61459 m0 *1 438.38,524.96
X$61459 73 12198 73 57 9003 57 sky130_fd_sc_hd__buf_4
* cell instance $61465 m0 *1 446.66,524.96
X$61465 73 8557 11728 10990 73 12139 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61466 m0 *1 448.5,524.96
X$61466 73 9273 11580 12139 73 12150 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61474 m0 *1 466.9,524.96
X$61474 73 10331 12140 11584 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61476 m0 *1 470.12,524.96
X$61476 73 12079 11856 12140 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61487 m0 *1 493.12,524.96
X$61487 57 12147 12148 5874 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $61490 m0 *1 503.24,524.96
X$61490 57 12147 12219 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $61497 m0 *1 517.5,524.96
X$61497 73 12141 73 57 12078 57 sky130_fd_sc_hd__buf_4
* cell instance $61499 m0 *1 521.18,524.96
X$61499 73 12146 73 57 12074 57 sky130_fd_sc_hd__buf_4
* cell instance $61510 m0 *1 545.56,524.96
X$61510 57 15528 12142 12282 12204 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61513 m0 *1 552.46,524.96
X$61513 73 12142 12219 12145 12218 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $61562 r0 *1 4.14,524.96
X$61562 57 12290 11333 12037 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61569 r0 *1 19.32,524.96
X$61569 73 12112 73 57 12216 57 sky130_fd_sc_hd__buf_4
* cell instance $61570 r0 *1 22.08,524.96
X$61570 57 15590 12293 12221 12216 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61571 r0 *1 26.68,524.96
X$61571 73 12113 73 57 12221 57 sky130_fd_sc_hd__buf_4
* cell instance $61574 r0 *1 34.04,524.96
X$61574 73 12221 73 57 12040 57 sky130_fd_sc_hd__buf_4
* cell instance $61585 r0 *1 52.9,524.96
X$61585 73 11925 12373 12477 12224 12301 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $61590 r0 *1 65.32,524.96
X$61590 73 12152 12226 11845 12307 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $61593 r0 *1 68.54,524.96
X$61593 73 11845 12226 12310 11973 57 12309 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $61597 r0 *1 73.6,524.96
X$61597 73 11678 11955 12177 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61600 r0 *1 79.12,524.96
X$61600 73 12314 11845 12400 11881 12176 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $61601 r0 *1 81.42,524.96
X$61601 73 12177 12176 12178 73 12228 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61604 r0 *1 87.4,524.96
X$61604 73 11705 11838 12178 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61607 r0 *1 92.92,524.96
X$61607 73 12178 73 57 12263 57 sky130_fd_sc_hd__buf_4
* cell instance $61614 r0 *1 99.82,524.96
X$61614 73 12179 11978 12231 12180 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $61616 r0 *1 102.58,524.96
X$61616 73 12304 12181 12263 12180 12161 12121 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $61618 r0 *1 109.94,524.96
X$61618 73 12224 12234 12043 73 12235 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61631 r0 *1 143.06,524.96
X$61631 57 12323 12240 12241 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61632 r0 *1 150.42,524.96
X$61632 57 12166 12243 12182 11267 73 73 57 sky130_fd_sc_hd__nor3_2
* cell instance $61635 r0 *1 154.56,524.96
X$61635 57 12244 11267 12182 12166 73 73 57 sky130_fd_sc_hd__or3_4
* cell instance $61637 r0 *1 162.38,524.96
X$61637 57 12123 11850 10753 12100 73 73 57 sky130_fd_sc_hd__xnor3_1
* cell instance $61638 r0 *1 170.66,524.96
X$61638 73 12171 11493 12183 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61641 r0 *1 175.26,524.96
X$61641 73 12055 12098 73 12247 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61643 r0 *1 178.48,524.96
X$61643 73 12247 12170 12455 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61646 r0 *1 182.62,524.96
X$61646 73 12173 12124 12460 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61650 r0 *1 190.9,524.96
X$61650 57 8609 12184 12183 11940 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $61659 r0 *1 211.14,524.96
X$61659 73 12250 9989 12329 57 73 12252 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61665 r0 *1 225.4,524.96
X$61665 73 9993 9741 12186 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61674 r0 *1 240.12,524.96
X$61674 73 12256 12185 12187 10849 12129 9968 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $61677 r0 *1 247.94,524.96
X$61677 73 9741 11547 9892 73 12172 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61686 r0 *1 269.56,524.96
X$61686 57 11315 12042 12535 10508 12330 10412 73 73 57
+ sky130_fd_sc_hd__o2111a_1
* cell instance $61691 r0 *1 285.2,524.96
X$61691 57 15646 12255 9832 9892 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61694 r0 *1 290.26,524.96
X$61694 73 12255 11289 12325 73 12254 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61696 r0 *1 292.56,524.96
X$61696 73 9892 11289 12164 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61701 r0 *1 303.6,524.96
X$61701 57 12251 12474 11984 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $61704 r0 *1 309.58,524.96
X$61704 73 12251 73 57 12148 57 sky130_fd_sc_hd__buf_4
* cell instance $61705 r0 *1 312.34,524.96
X$61705 57 12249 12132 12188 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61711 r0 *1 328.44,524.96
X$61711 73 12189 73 57 12248 57 sky130_fd_sc_hd__buf_4
* cell instance $61713 r0 *1 331.66,524.96
X$61713 73 12191 12190 12189 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61724 r0 *1 351.9,524.96
X$61724 73 12192 73 57 12191 57 sky130_fd_sc_hd__buf_4
* cell instance $61725 r0 *1 354.66,524.96
X$61725 73 12193 10862 73 12192 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61727 r0 *1 358.34,524.96
X$61727 73 12193 10862 12468 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61732 r0 *1 369.84,524.96
X$61732 57 12122 12239 12242 73 12194 73 57 sky130_fd_sc_hd__mux2i_2
* cell instance $61734 r0 *1 375.36,524.96
X$61734 73 4895 10114 12242 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61736 r0 *1 377.2,524.96
X$61736 73 12194 73 57 12196 57 sky130_fd_sc_hd__buf_4
* cell instance $61739 r0 *1 382.26,524.96
X$61739 57 4950 12237 12019 12238 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $61740 r0 *1 393.3,524.96
X$61740 57 12279 12237 12233 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $61742 r0 *1 396.98,524.96
X$61742 73 11233 11501 12195 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61743 r0 *1 400.2,524.96
X$61743 73 12232 10114 12197 57 73 12193 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61746 r0 *1 402.96,524.96
X$61746 73 12195 11477 12280 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61747 r0 *1 406.18,524.96
X$61747 57 4950 12229 12019 12230 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $61748 r0 *1 417.22,524.96
X$61748 57 12317 12229 12086 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $61760 r0 *1 447.58,524.96
X$61760 57 12199 11820 12200 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61762 r0 *1 454.94,524.96
X$61762 73 12199 73 57 11656 57 sky130_fd_sc_hd__buf_4
* cell instance $61778 r0 *1 492.2,524.96
X$61778 57 5874 12148 12312 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $61791 r0 *1 529.46,524.96
X$61791 73 12196 12201 12223 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $61793 r0 *1 531.76,524.96
X$61793 73 12223 73 57 12202 57 sky130_fd_sc_hd__buf_4
* cell instance $61794 r0 *1 534.52,524.96
X$61794 57 57 12201 12222 12196 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $61797 r0 *1 540.96,524.96
X$61797 73 12202 73 57 12145 57 sky130_fd_sc_hd__buf_4
* cell instance $61799 r0 *1 544.18,524.96
X$61799 57 15586 12206 12210 12204 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61800 r0 *1 548.78,524.96
X$61800 73 12206 12205 12303 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61802 r0 *1 551.08,524.96
X$61802 73 12220 73 57 12300 57 sky130_fd_sc_hd__buf_4
* cell instance $61803 r0 *1 553.84,524.96
X$61803 73 12218 12302 12298 12217 57 73 12207 57 sky130_fd_sc_hd__a31oi_1
* cell instance $61805 r0 *1 557.06,524.96
X$61805 73 12295 12207 12215 73 12208 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61807 r0 *1 558.9,524.96
X$61807 73 12211 12209 12208 12294 73 12141 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $61815 r0 *1 569.94,524.96
X$61815 57 15664 12291 12210 12204 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61817 r0 *1 575.46,524.96
X$61817 73 12213 12214 12212 73 12209 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61852 m0 *1 4.6,530.4
X$61852 73 12475 57 73 12144 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61855 m0 *1 12.42,530.4
X$61855 73 12257 57 73 11252 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61861 m0 *1 19.32,530.4
X$61861 57 15534 12370 12114 11998 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $61862 m0 *1 23.92,530.4
X$61862 73 12216 73 57 12371 57 sky130_fd_sc_hd__buf_4
* cell instance $61863 m0 *1 26.68,530.4
X$61863 73 12000 11800 12338 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $61868 m0 *1 34.96,530.4
X$61868 73 12259 73 57 12297 57 sky130_fd_sc_hd__buf_4
* cell instance $61871 m0 *1 39.1,530.4
X$61871 73 12260 73 57 12372 57 sky130_fd_sc_hd__buf_4
* cell instance $61872 m0 *1 41.86,530.4
X$61872 73 11800 12372 12297 11917 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $61878 m0 *1 49.68,530.4
X$61878 73 12339 12338 11999 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61879 m0 *1 51.06,530.4
X$61879 73 13210 73 57 12304 57 sky130_fd_sc_hd__buf_4
* cell instance $61881 m0 *1 54.74,530.4
X$61881 73 12260 73 57 12306 57 sky130_fd_sc_hd__buf_4
* cell instance $61883 m0 *1 57.96,530.4
X$61883 73 12224 12306 12374 73 12262 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61887 m0 *1 67.62,530.4
X$61887 73 12225 12084 11800 57 73 12261 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61888 m0 *1 69.46,530.4
X$61888 73 11845 12261 12310 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61892 m0 *1 71.76,530.4
X$61892 57 12309 12340 11682 12377 12262 11842 73 73 57
+ sky130_fd_sc_hd__a221oi_2
* cell instance $61894 m0 *1 79.12,530.4
X$61894 73 11886 12341 11800 57 73 12314 57 sky130_fd_sc_hd__a21boi_0
* cell instance $61896 m0 *1 82.34,530.4
X$61896 73 11678 73 57 12179 57 sky130_fd_sc_hd__buf_4
* cell instance $61901 m0 *1 96.6,530.4
X$61901 73 12264 11800 12004 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61906 m0 *1 100.28,530.4
X$61906 73 12002 12264 11800 12265 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $61907 m0 *1 102.12,530.4
X$61907 73 12319 12266 12382 11971 57 12181 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $61908 m0 *1 104.42,530.4
X$61908 73 12341 12115 12265 57 73 12322 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61910 m0 *1 109.94,530.4
X$61910 73 12004 12267 12322 11879 73 57 12385 57 sky130_fd_sc_hd__o31ai_1
* cell instance $61924 m0 *1 140.76,530.4
X$61924 57 11386 12240 12268 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61925 m0 *1 148.12,530.4
X$61925 57 11756 12240 12345 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $61930 m0 *1 160.08,530.4
X$61930 73 11758 6952 73 12269 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61932 m0 *1 163.76,530.4
X$61932 73 9303 12245 12389 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $61933 m0 *1 165.14,530.4
X$61933 73 12269 73 57 12391 57 sky130_fd_sc_hd__buf_4
* cell instance $61936 m0 *1 168.82,530.4
X$61936 73 12055 12050 73 12270 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $61938 m0 *1 172.5,530.4
X$61938 73 11493 12270 12271 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61940 m0 *1 176.64,530.4
X$61940 73 12271 10753 12272 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $61944 m0 *1 180.32,530.4
X$61944 73 12272 73 57 12392 57 sky130_fd_sc_hd__buf_4
* cell instance $61953 m0 *1 198.26,530.4
X$61953 73 12327 73 57 12326 57 sky130_fd_sc_hd__buf_4
* cell instance $61960 m0 *1 211.14,530.4
X$61960 57 12393 12329 9915 12186 11310 12349 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $61968 m0 *1 225.86,530.4
X$61968 73 9827 73 57 12273 57 sky130_fd_sc_hd__buf_4
* cell instance $61971 m0 *1 230,530.4
X$61971 73 10262 9832 12333 57 73 12332 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61975 m0 *1 235.52,530.4
X$61975 73 9976 10601 9741 73 12333 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $61979 m0 *1 245.18,530.4
X$61979 73 12274 9832 10485 57 73 12334 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61983 m0 *1 251.62,530.4
X$61983 73 9976 11394 12275 57 73 12274 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61985 m0 *1 257.14,530.4
X$61985 73 9827 9915 12275 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $61990 m0 *1 264.04,530.4
X$61990 73 12331 73 57 12185 57 sky130_fd_sc_hd__buf_4
* cell instance $61991 m0 *1 266.8,530.4
X$61991 73 10579 10266 12351 57 73 12330 57 sky130_fd_sc_hd__a21oi_1
* cell instance $61999 m0 *1 280.14,530.4
X$61999 73 11202 12130 11900 57 73 12331 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62000 m0 *1 281.98,530.4
X$62000 73 9827 10111 10601 12325 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $62004 m0 *1 287.5,530.4
X$62004 57 12328 8487 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $62009 m0 *1 306.36,530.4
X$62009 57 12277 12132 12276 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62010 m0 *1 313.72,530.4
X$62010 73 12277 73 57 8080 57 sky130_fd_sc_hd__buf_4
* cell instance $62021 m0 *1 334.42,530.4
X$62021 57 11291 12388 12278 12324 12470 12190 73 73 57 sky130_fd_sc_hd__o41a_1
* cell instance $62022 m0 *1 338.56,530.4
X$62022 73 12158 12191 12949 12324 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $62023 m0 *1 340.4,530.4
X$62023 73 12353 12191 12354 12278 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $62030 m0 *1 355.12,530.4
X$62030 57 12387 12279 11379 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $62033 m0 *1 363.4,530.4
X$62033 57 11379 12279 12355 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $62039 m0 *1 375.82,530.4
X$62039 73 12321 73 57 10969 57 sky130_fd_sc_hd__buf_4
* cell instance $62047 m0 *1 391.46,530.4
X$62047 57 12381 12019 12320 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62050 m0 *1 398.82,530.4
X$62050 73 10114 12280 12540 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62051 m0 *1 400.2,530.4
X$62051 57 4950 12318 12019 12380 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $62052 m0 *1 411.24,530.4
X$62052 57 12379 12318 11694 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $62058 m0 *1 419.06,530.4
X$62058 73 12317 73 57 12316 57 sky130_fd_sc_hd__buf_4
* cell instance $62059 m0 *1 421.82,530.4
X$62059 57 12378 12316 4644 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $62074 m0 *1 452.64,530.4
X$62074 73 12357 73 57 11850 57 sky130_fd_sc_hd__buf_4
* cell instance $62075 m0 *1 455.4,530.4
X$62075 57 12357 11763 12315 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62093 m0 *1 499.56,530.4
X$62093 57 12312 12281 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $62101 m0 *1 517.5,530.4
X$62101 57 11148 12359 12311 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62106 m0 *1 528.54,530.4
X$62106 57 12223 12754 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $62109 m0 *1 535.9,530.4
X$62109 57 12222 12376 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $62110 m0 *1 543.26,530.4
X$62110 73 12308 73 57 12305 57 sky130_fd_sc_hd__buf_4
* cell instance $62111 m0 *1 546.02,530.4
X$62111 73 12203 12210 12283 12219 57 12375 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $62113 m0 *1 548.78,530.4
X$62113 73 12361 12282 12145 12220 12435 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $62114 m0 *1 551.54,530.4
X$62114 73 12303 12300 12299 57 73 12302 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62117 m0 *1 554.76,530.4
X$62117 73 12285 12284 12300 12298 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $62118 m0 *1 556.6,530.4
X$62118 73 12281 13209 12296 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62122 m0 *1 558.44,530.4
X$62122 73 12286 12296 12362 12295 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $62125 m0 *1 561.66,530.4
X$62125 73 12360 73 57 12286 57 sky130_fd_sc_hd__buf_4
* cell instance $62126 m0 *1 564.42,530.4
X$62126 73 12433 12203 12286 73 12364 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $62127 m0 *1 566.26,530.4
X$62127 73 12204 12210 12284 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62129 m0 *1 568.1,530.4
X$62129 73 12284 12423 12203 12364 57 73 12287 57 sky130_fd_sc_hd__a31oi_1
* cell instance $62130 m0 *1 570.4,530.4
X$62130 73 12219 12292 12287 12214 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $62133 m0 *1 573.62,530.4
X$62133 73 12145 12291 12360 12365 57 12292 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $62134 m0 *1 576.38,530.4
X$62134 73 12210 12305 12288 12145 57 12365 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $62135 m0 *1 579.14,530.4
X$62135 73 12366 73 57 12288 57 sky130_fd_sc_hd__buf_4
* cell instance $62170 r0 *1 2.3,530.4
X$62170 57 12510 11333 11922 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62171 r0 *1 9.66,530.4
X$62171 73 12394 57 73 11604 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62178 r0 *1 19.32,530.4
X$62178 57 12395 12428 12114 11998 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $62179 r0 *1 23.92,530.4
X$62179 73 11998 12335 12429 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62180 r0 *1 25.3,530.4
X$62180 73 12430 73 57 12336 57 sky130_fd_sc_hd__buf_4
* cell instance $62181 r0 *1 28.06,530.4
X$62181 73 12370 73 57 12337 57 sky130_fd_sc_hd__buf_4
* cell instance $62182 r0 *1 30.82,530.4
X$62182 73 12056 11800 12225 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62184 r0 *1 35.88,530.4
X$62184 73 12335 73 57 12398 57 sky130_fd_sc_hd__buf_4
* cell instance $62186 r0 *1 39.56,530.4
X$62186 73 12002 12264 12398 73 11833 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $62196 r0 *1 54.74,530.4
X$62196 73 12371 11800 12082 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62198 r0 *1 57.04,530.4
X$62198 73 12082 12434 12335 73 12374 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $62201 r0 *1 61.64,530.4
X$62201 73 12293 73 57 12341 57 sky130_fd_sc_hd__buf_4
* cell instance $62202 r0 *1 64.4,530.4
X$62202 73 12336 73 57 12084 57 sky130_fd_sc_hd__buf_4
* cell instance $62209 r0 *1 77.28,530.4
X$62209 73 12084 11800 12335 73 12400 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $62212 r0 *1 83.26,530.4
X$62212 73 12335 73 57 11845 57 sky130_fd_sc_hd__buf_4
* cell instance $62221 r0 *1 104.88,530.4
X$62221 57 12382 11834 12383 11648 11838 12439 73 73 57 sky130_fd_sc_hd__a41o_1
* cell instance $62222 r0 *1 108.56,530.4
X$62222 73 12040 12342 11879 12383 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $62224 r0 *1 110.86,530.4
X$62224 73 12385 12386 11834 12445 11641 73 12319 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $62225 r0 *1 114.08,530.4
X$62225 73 12002 12264 12343 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62226 r0 *1 115.46,530.4
X$62226 73 12343 73 57 11975 57 sky130_fd_sc_hd__buf_4
* cell instance $62227 r0 *1 118.22,530.4
X$62227 73 12342 12343 12267 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62235 r0 *1 127.88,530.4
X$62235 73 12323 57 73 13434 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62239 r0 *1 142.6,530.4
X$62239 57 12585 12240 12066 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62245 r0 *1 155.48,530.4
X$62245 73 11889 7322 73 12686 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $62247 r0 *1 159.16,530.4
X$62247 73 11758 6952 12530 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $62249 r0 *1 162.84,530.4
X$62249 73 12344 7322 73 12452 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $62250 r0 *1 166.06,530.4
X$62250 73 12389 9303 12346 57 73 12344 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62252 r0 *1 168.36,530.4
X$62252 73 11692 73 57 12604 57 sky130_fd_sc_hd__buf_4
* cell instance $62253 r0 *1 171.12,530.4
X$62253 57 11432 12402 12347 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $62255 r0 *1 178.94,530.4
X$62255 73 12457 73 57 12347 57 sky130_fd_sc_hd__buf_4
* cell instance $62257 r0 *1 182.16,530.4
X$62257 73 12402 73 57 15426 57 sky130_fd_sc_hd__clkinvlp_4
* cell instance $62258 r0 *1 184.92,530.4
X$62258 57 12348 12461 12460 11940 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $62269 r0 *1 210.22,530.4
X$62269 57 9989 12327 10485 12332 12403 12463 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $62270 r0 *1 213.44,530.4
X$62270 73 12349 10323 10111 57 73 12393 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62271 r0 *1 215.28,530.4
X$62271 73 12103 10323 10111 57 73 12463 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62275 r0 *1 223.1,530.4
X$62275 73 12351 73 57 12349 57 sky130_fd_sc_hd__buf_4
* cell instance $62278 r0 *1 228.16,530.4
X$62278 73 10693 73 57 12467 57 sky130_fd_sc_hd__buf_4
* cell instance $62287 r0 *1 242.42,530.4
X$62287 73 12455 73 57 12350 57 sky130_fd_sc_hd__buf_4
* cell instance $62288 r0 *1 245.18,530.4
X$62288 73 9976 12390 12405 57 73 12403 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62293 r0 *1 258.98,530.4
X$62293 73 10111 12275 12471 57 73 12012 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62296 r0 *1 262.66,530.4
X$62296 73 10579 12164 12351 57 73 12405 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62303 r0 *1 280.14,530.4
X$62303 73 11202 73 57 10697 57 sky130_fd_sc_hd__buf_4
* cell instance $62313 r0 *1 304.52,530.4
X$62313 73 12132 57 73 57 sky130_fd_sc_hd__clkbuf_1
* cell instance $62314 r0 *1 305.9,530.4
X$62314 57 12352 12132 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $62316 r0 *1 315.1,530.4
X$62316 57 12449 12473 12392 11406 73 73 57 sky130_fd_sc_hd__mux2_2
* cell instance $62320 r0 *1 322,530.4
X$62320 73 12096 73 57 12353 57 sky130_fd_sc_hd__buf_4
* cell instance $62323 r0 *1 329.36,530.4
X$62323 73 12353 12248 12614 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62326 r0 *1 332.12,530.4
X$62326 73 12408 73 57 12388 57 sky130_fd_sc_hd__buf_4
* cell instance $62336 r0 *1 355.12,530.4
X$62336 73 12468 73 57 12487 57 sky130_fd_sc_hd__buf_4
* cell instance $62340 r0 *1 367.08,530.4
X$62340 57 12355 12384 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $62346 r0 *1 379.5,530.4
X$62346 73 11850 6268 73 12465 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $62352 r0 *1 390.54,530.4
X$62352 57 4950 12458 12019 12462 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $62356 r0 *1 402.96,530.4
X$62356 73 12155 11477 12136 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $62357 r0 *1 406.18,530.4
X$62357 73 12154 6435 73 12454 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $62358 r0 *1 409.4,530.4
X$62358 73 11148 73 57 12154 57 sky130_fd_sc_hd__buf_4
* cell instance $62361 r0 *1 416.3,530.4
X$62361 73 11501 4644 73 12313 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $62363 r0 *1 420.44,530.4
X$62363 57 4644 12316 12411 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $62365 r0 *1 426.42,530.4
X$62365 73 12379 73 57 12356 57 sky130_fd_sc_hd__buf_4
* cell instance $62368 r0 *1 430.56,530.4
X$62368 57 5718 12356 12496 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $62384 r0 *1 477.48,530.4
X$62384 73 12449 6268 73 12448 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $62392 r0 *1 497.26,530.4
X$62392 57 12358 12494 4559 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $62395 r0 *1 504.16,530.4
X$62395 57 12358 12217 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $62405 r0 *1 529.46,530.4
X$62405 73 12442 12360 12440 57 73 12443 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62407 r0 *1 531.3,530.4
X$62407 57 9804 11763 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $62409 r0 *1 540.96,530.4
X$62409 73 12222 73 57 12203 57 sky130_fd_sc_hd__buf_4
* cell instance $62411 r0 *1 544.64,530.4
X$62411 73 12360 12375 12418 12210 12285 12438 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $62412 r0 *1 548.32,530.4
X$62412 73 12305 12282 12220 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62413 r0 *1 549.7,530.4
X$62413 73 12206 12145 12435 12217 12289 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $62418 r0 *1 560.28,530.4
X$62418 73 12282 12418 12217 57 73 12363 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62419 r0 *1 562.12,530.4
X$62419 73 12286 12210 12361 12203 57 73 12421 57 sky130_fd_sc_hd__a31oi_1
* cell instance $62420 r0 *1 564.42,530.4
X$62420 73 12421 12363 12431 12286 12420 12432 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $62424 r0 *1 569.48,530.4
X$62424 73 12420 12418 12423 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62428 r0 *1 574.08,530.4
X$62428 73 12424 12145 12360 12288 73 12422 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $62429 r0 *1 577.3,530.4
X$62429 73 12360 12367 12423 57 73 12424 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62430 r0 *1 579.14,530.4
X$62430 73 12361 12368 12366 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62432 r0 *1 580.98,530.4
X$62432 73 11115 73 57 12368 57 sky130_fd_sc_hd__buf_4
* cell instance $62433 r0 *1 583.74,530.4
X$62433 73 12203 12288 12427 12369 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $62437 r0 *1 588.8,530.4
X$62437 57 12426 12305 12418 12145 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $62519 m0 *1 11.96,535.84
X$62519 73 12511 73 57 11483 57 sky130_fd_sc_hd__inv_1
* cell instance $62522 m0 *1 20.7,535.84
X$62522 73 12395 73 57 12056 57 sky130_fd_sc_hd__buf_4
* cell instance $62523 m0 *1 23.46,535.84
X$62523 73 12114 73 57 12397 57 sky130_fd_sc_hd__buf_4
* cell instance $62526 m0 *1 27.6,535.84
X$62526 57 10288 12396 12428 10230 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $62528 m0 *1 30.36,535.84
X$62528 73 10288 10230 12513 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62531 m0 *1 36.34,535.84
X$62531 73 12398 12057 12259 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $62534 m0 *1 40.02,535.84
X$62534 73 12399 12396 11916 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62537 m0 *1 46.92,535.84
X$62537 73 12397 73 57 12264 57 sky130_fd_sc_hd__buf_4
* cell instance $62538 m0 *1 49.68,535.84
X$62538 73 12293 11677 12339 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $62540 m0 *1 55.66,535.84
X$62540 73 12000 12478 12434 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62546 m0 *1 65.78,535.84
X$62546 73 12225 73 57 12518 57 sky130_fd_sc_hd__buf_4
* cell instance $62547 m0 *1 68.54,535.84
X$62547 57 12622 11639 12520 12518 11881 12521 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $62556 m0 *1 91.08,535.84
X$62556 73 12371 73 57 11844 57 sky130_fd_sc_hd__buf_4
* cell instance $62557 m0 *1 93.84,535.84
X$62557 73 12335 73 57 12043 57 sky130_fd_sc_hd__buf_4
* cell instance $62562 m0 *1 106.26,535.84
X$62562 73 11844 11955 12005 73 12522 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $62563 m0 *1 108.1,535.84
X$62563 73 12522 12444 12401 12523 12439 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $62565 m0 *1 111.32,535.84
X$62565 73 12224 12524 12445 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62569 m0 *1 115.92,535.84
X$62569 73 12525 12342 12447 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62575 m0 *1 132.94,535.84
X$62575 57 11889 12240 12481 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62579 m0 *1 145.36,535.84
X$62579 57 12352 12240 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $62582 m0 *1 156.86,535.84
X$62582 57 12049 12240 12529 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62584 m0 *1 164.68,535.84
X$62584 73 12344 7322 12531 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $62587 m0 *1 168.82,535.84
X$62587 57 7572 12483 12453 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $62590 m0 *1 176.18,535.84
X$62590 57 12628 12348 8360 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $62591 m0 *1 182.16,535.84
X$62591 57 12352 12402 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $62592 m0 *1 191.36,535.84
X$62592 73 12100 8360 73 12459 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $62602 m0 *1 218.96,535.84
X$62602 73 10111 12467 12466 73 12464 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $62611 m0 *1 240.12,535.84
X$62611 73 10854 73 57 12484 57 sky130_fd_sc_hd__buf_4
* cell instance $62614 m0 *1 245.64,535.84
X$62614 73 12404 12186 10985 73 12390 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $62623 m0 *1 259.9,535.84
X$62623 73 10266 9832 10601 73 12471 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $62626 m0 *1 266.34,535.84
X$62626 73 9826 12331 12485 57 73 10811 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62639 m0 *1 293.94,535.84
X$62639 57 4950 12474 12132 12538 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $62642 m0 *1 306.36,535.84
X$62642 57 4950 12473 12132 12486 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $62644 m0 *1 319.24,535.84
X$62644 73 12487 12542 12406 57 73 12470 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62645 m0 *1 321.08,535.84
X$62645 73 12353 12407 12472 12384 13026 12542 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $62652 m0 *1 338.56,535.84
X$62652 73 12384 12407 12469 12545 73 57 12354 57 sky130_fd_sc_hd__o31ai_1
* cell instance $62663 m0 *1 363.86,535.84
X$62663 73 4895 10114 12488 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62664 m0 *1 365.24,535.84
X$62664 73 12546 12488 12547 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62666 m0 *1 367.08,535.84
X$62666 73 12547 12546 12489 57 73 12490 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62667 m0 *1 368.92,535.84
X$62667 73 4895 11406 12489 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62668 m0 *1 370.3,535.84
X$62668 73 12490 73 57 12201 57 sky130_fd_sc_hd__buf_4
* cell instance $62672 m0 *1 381.34,535.84
X$62672 57 11293 12019 12409 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62675 m0 *1 389.62,535.84
X$62675 73 12410 57 73 12462 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62676 m0 *1 393.3,535.84
X$62676 57 11727 12019 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $62677 m0 *1 402.5,535.84
X$62677 73 12381 57 73 12541 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62678 m0 *1 406.18,535.84
X$62678 73 12540 10114 12611 57 73 12456 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62681 m0 *1 410.32,535.84
X$62681 57 12536 12493 4795 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $62684 m0 *1 417.22,535.84
X$62684 73 12451 73 57 12494 57 sky130_fd_sc_hd__buf_4
* cell instance $62687 m0 *1 422.74,535.84
X$62687 57 12411 12450 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $62688 m0 *1 430.1,535.84
X$62688 57 12534 12356 5718 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $62709 m0 *1 486.22,535.84
X$62709 57 11481 12359 12413 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62710 m0 *1 493.58,535.84
X$62710 73 12448 73 57 12414 57 sky130_fd_sc_hd__buf_4
* cell instance $62717 m0 *1 502.78,535.84
X$62717 57 4559 12494 12569 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $62718 m0 *1 508.76,535.84
X$62718 73 12412 73 57 12682 57 sky130_fd_sc_hd__clkinv_1
* cell instance $62721 m0 *1 514.74,535.84
X$62721 57 11115 12210 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $62722 m0 *1 522.1,535.84
X$62722 73 12415 12414 12441 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $62723 m0 *1 524.4,535.84
X$62723 73 12415 12414 12442 73 57 57 sky130_fd_sc_hd__or2_2
* cell instance $62726 m0 *1 528.08,535.84
X$62726 73 12527 12442 12441 12416 12498 12146 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $62729 m0 *1 532.68,535.84
X$62729 57 11763 73 73 57 sky130_fd_sc_hd__clkinv_16
* cell instance $62731 m0 *1 544.64,535.84
X$62731 73 12438 12506 12419 57 73 12437 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62732 m0 *1 546.48,535.84
X$62732 73 12204 12205 12436 73 12419 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $62733 m0 *1 548.32,535.84
X$62733 73 12417 12202 12502 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62734 m0 *1 549.7,535.84
X$62734 73 12219 12203 12299 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62740 m0 *1 556.6,535.84
X$62740 57 15519 12433 12282 12420 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $62743 m0 *1 565.34,535.84
X$62743 73 12422 12432 12219 12665 57 73 12498 57 sky130_fd_sc_hd__a31oi_1
* cell instance $62752 m0 *1 582.82,535.84
X$62752 57 12514 12145 12361 12515 12427 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $62754 m0 *1 586.5,535.84
X$62754 73 12581 12368 12427 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62757 m0 *1 590.64,535.84
X$62757 73 12212 12512 12508 12584 57 73 12425 57 sky130_fd_sc_hd__a31oi_1
* cell instance $62759 m0 *1 594.78,535.84
X$62759 73 12425 73 57 12527 57 sky130_fd_sc_hd__buf_4
* cell instance $62782 r0 *1 2.3,535.84
X$62782 73 12290 57 73 12548 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62783 r0 *1 5.98,535.84
X$62783 73 12510 57 73 12509 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62786 r0 *1 12.42,535.84
X$62786 73 12585 57 73 12549 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62790 r0 *1 17.48,535.84
X$62790 73 12395 12476 12586 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62793 r0 *1 26.22,535.84
X$62793 73 12429 73 57 12477 57 sky130_fd_sc_hd__buf_4
* cell instance $62794 r0 *1 28.98,535.84
X$62794 73 10288 10230 12476 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $62797 r0 *1 38.64,535.84
X$62797 73 12478 12398 12588 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62800 r0 *1 42.32,535.84
X$62800 73 12337 12080 12480 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62807 r0 *1 58.88,535.84
X$62807 73 12082 12620 12592 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62815 r0 *1 74.06,535.84
X$62815 73 12479 73 57 12673 57 sky130_fd_sc_hd__buf_4
* cell instance $62817 r0 *1 77.28,535.84
X$62817 73 12400 11800 12480 57 73 12479 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62821 r0 *1 82.34,535.84
X$62821 73 11845 12057 11802 57 73 12595 57 sky130_fd_sc_hd__a21oi_1
* cell instance $62822 r0 *1 84.18,535.84
X$62822 73 12056 11845 12553 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62825 r0 *1 88.32,535.84
X$62825 73 12480 73 57 12091 57 sky130_fd_sc_hd__buf_4
* cell instance $62826 r0 *1 91.08,535.84
X$62826 73 12091 11845 11802 12553 57 12598 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $62832 r0 *1 99.36,535.84
X$62832 73 11706 73 57 12342 57 sky130_fd_sc_hd__buf_4
* cell instance $62836 r0 *1 108.56,535.84
X$62836 73 12040 12342 11879 12444 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $62849 r0 *1 133.86,535.84
X$62849 73 12528 73 57 12601 57 sky130_fd_sc_hd__buf_4
* cell instance $62861 r0 *1 163.76,535.84
X$62861 73 12530 73 57 12605 57 sky130_fd_sc_hd__buf_4
* cell instance $62863 r0 *1 166.98,535.84
X$62863 73 12531 73 57 12482 57 sky130_fd_sc_hd__buf_4
* cell instance $62864 r0 *1 169.74,535.84
X$62864 57 12556 12483 7572 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $62865 r0 *1 175.72,535.84
X$62865 57 8360 12348 12629 73 73 57 sky130_fd_sc_hd__xor2_2
* cell instance $62869 r0 *1 185.84,535.84
X$62869 57 12100 12402 12533 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62882 r0 *1 221.72,535.84
X$62882 73 10266 10601 12466 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62886 r0 *1 226.32,535.84
X$62886 73 12273 10111 12103 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62891 r0 *1 233.68,535.84
X$62891 73 12103 12484 11858 10874 10111 12256 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $62895 r0 *1 239.66,535.84
X$62895 73 12484 12351 11858 10111 10266 12485 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $62898 r0 *1 245.18,535.84
X$62898 73 9832 10601 12404 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62899 r0 *1 246.56,535.84
X$62899 73 12404 73 57 11547 57 sky130_fd_sc_hd__buf_4
* cell instance $62902 r0 *1 252.08,535.84
X$62902 73 9832 10111 12351 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62911 r0 *1 270.94,535.84
X$62911 73 10266 11547 12535 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62912 r0 *1 272.32,535.84
X$62912 73 10266 11991 12535 10607 12612 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $62924 r0 *1 293.48,535.84
X$62924 57 4950 12539 12132 12537 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $62925 r0 *1 304.52,535.84
X$62925 57 12451 12539 12350 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $62935 r0 *1 329.36,535.84
X$62935 73 12487 11790 12562 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $62938 r0 *1 335.34,535.84
X$62938 73 12615 12544 12384 73 12545 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $62957 r0 *1 375.82,535.84
X$62957 73 12050 4559 73 12713 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $62958 r0 *1 379.04,535.84
X$62958 57 12613 12019 12465 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62961 r0 *1 390.54,535.84
X$62961 73 11500 11406 7186 12543 57 73 12637 57 sky130_fd_sc_hd__a31oi_1
* cell instance $62964 r0 *1 395.14,535.84
X$62964 57 12702 12019 12491 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $62967 r0 *1 402.96,535.84
X$62967 73 12492 73 57 12493 57 sky130_fd_sc_hd__buf_4
* cell instance $62968 r0 *1 405.72,535.84
X$62968 73 11063 4795 73 12491 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $62969 r0 *1 408.94,535.84
X$62969 57 4795 12493 12565 73 73 57 sky130_fd_sc_hd__xor2_4
* cell instance $62971 r0 *1 419.52,535.84
X$62971 73 12567 73 57 12495 57 sky130_fd_sc_hd__buf_4
* cell instance $62975 r0 *1 425.04,535.84
X$62975 73 12495 12534 12609 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $62982 r0 *1 440.22,535.84
X$62982 57 12496 12608 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $62992 r0 *1 464.6,535.84
X$62992 73 12446 73 57 12409 57 sky130_fd_sc_hd__buf_4
* cell instance $63009 r0 *1 503.7,535.84
X$63009 57 11763 12359 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $63013 r0 *1 517.04,535.84
X$63013 73 12412 73 57 12532 57 sky130_fd_sc_hd__buf_4
* cell instance $63014 r0 *1 519.8,535.84
X$63014 73 12281 73 57 12499 57 sky130_fd_sc_hd__buf_4
* cell instance $63015 r0 *1 522.56,535.84
X$63015 73 13405 12497 12443 57 73 12571 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63017 r0 *1 525.32,535.84
X$63017 73 12571 12572 12143 12653 12441 12446 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $63018 r0 *1 528.54,535.84
X$63018 73 12526 73 57 12599 57 sky130_fd_sc_hd__buf_4
* cell instance $63020 r0 *1 531.3,535.84
X$63020 73 12022 73 57 12526 57 sky130_fd_sc_hd__clkinvlp_4
* cell instance $63021 r0 *1 534.06,535.84
X$63021 73 12022 73 57 12420 57 sky130_fd_sc_hd__buf_4
* cell instance $63023 r0 *1 537.74,535.84
X$63023 73 12417 73 57 12361 57 sky130_fd_sc_hd__buf_4
* cell instance $63025 r0 *1 540.96,535.84
X$63025 73 12579 12217 12500 57 73 12572 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63026 r0 *1 542.8,535.84
X$63026 73 12420 12597 12437 73 12497 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63028 r0 *1 545.1,535.84
X$63028 73 12577 12210 12299 57 73 12597 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63030 r0 *1 547.4,535.84
X$63030 73 12499 12203 12501 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63031 r0 *1 548.78,535.84
X$63031 73 12501 73 57 12205 57 sky130_fd_sc_hd__buf_4
* cell instance $63032 r0 *1 551.54,535.84
X$63032 73 12219 12145 12436 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63035 r0 *1 554.3,535.84
X$63035 73 12420 12282 12299 12594 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $63037 r0 *1 556.6,535.84
X$63037 73 12283 12210 12519 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63038 r0 *1 557.98,535.84
X$63038 73 12145 12517 12519 12516 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $63040 r0 *1 559.82,535.84
X$63040 57 12433 12591 12499 12217 12145 12516 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $63048 r0 *1 571.78,535.84
X$63048 57 12504 12503 12291 12281 12361 12203 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $63050 r0 *1 575.46,535.84
X$63050 73 12366 12505 12368 57 73 12589 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63054 r0 *1 582.36,535.84
X$63054 57 12507 12514 12505 12217 12219 12503 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $63056 r0 *1 585.58,535.84
X$63056 73 12506 12368 12367 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63057 r0 *1 586.96,535.84
X$63057 73 12499 12426 12515 12505 12368 12582 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $63058 r0 *1 590.18,535.84
X$63058 73 12219 12578 12507 73 12512 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63060 r0 *1 592.94,535.84
X$63060 73 12499 13480 12582 12217 12659 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $63136 m0 *1 4.14,541.28
X$63136 73 12718 57 73 12511 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63143 m0 *1 23.92,541.28
X$63143 73 12476 73 57 12550 57 sky130_fd_sc_hd__buf_4
* cell instance $63144 m0 *1 26.68,541.28
X$63144 73 12225 12338 12550 73 12661 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63150 m0 *1 34.96,541.28
X$63150 73 12336 12335 12621 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63152 m0 *1 40.02,541.28
X$63152 73 12264 12588 12057 12026 73 12587 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $63153 m0 *1 42.78,541.28
X$63153 73 12476 73 57 12551 57 sky130_fd_sc_hd__buf_4
* cell instance $63157 m0 *1 53.36,541.28
X$63157 73 11706 11486 12619 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63161 m0 *1 57.96,541.28
X$63161 73 11486 12620 12621 57 73 12523 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63162 m0 *1 59.8,541.28
X$63162 73 12592 12617 12225 57 73 12593 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63164 m0 *1 62.1,541.28
X$63164 73 12551 73 57 11706 57 sky130_fd_sc_hd__buf_4
* cell instance $63167 m0 *1 66.24,541.28
X$63167 73 12480 73 57 13347 57 sky130_fd_sc_hd__buf_4
* cell instance $63171 m0 *1 74.98,541.28
X$63171 73 11973 12673 12552 12676 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $63173 m0 *1 81.42,541.28
X$63173 73 11802 12678 12595 73 12552 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63182 m0 *1 103.04,541.28
X$63182 73 11844 12040 12678 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63184 m0 *1 108.1,541.28
X$63184 73 12555 12554 11844 73 12386 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63185 m0 *1 109.94,541.28
X$63185 73 12444 73 57 12600 57 sky130_fd_sc_hd__buf_4
* cell instance $63188 m0 *1 116.84,541.28
X$63188 73 12040 11879 12555 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63200 m0 *1 149.5,541.28
X$63200 57 12243 12687 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $63204 m0 *1 165.14,541.28
X$63204 73 12452 73 57 12627 57 sky130_fd_sc_hd__buf_4
* cell instance $63209 m0 *1 174.8,541.28
X$63209 57 12483 12557 11762 11940 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $63231 m0 *1 236.44,541.28
X$63231 73 12696 73 57 11765 57 sky130_fd_sc_hd__buf_4
* cell instance $63239 m0 *1 255.3,541.28
X$63239 73 9826 11658 12699 57 73 12698 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63251 m0 *1 287.96,541.28
X$63251 73 12558 57 73 12538 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63252 m0 *1 291.64,541.28
X$63252 73 12559 57 73 12537 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63254 m0 *1 295.78,541.28
X$63254 73 12921 73 57 12406 57 sky130_fd_sc_hd__buf_4
* cell instance $63265 m0 *1 328.9,541.28
X$63265 73 12708 12614 12561 12562 12560 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $63266 m0 *1 331.2,541.28
X$63266 73 12560 12707 12829 11873 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $63275 m0 *1 350.06,541.28
X$63275 73 12387 73 57 12616 57 sky130_fd_sc_hd__buf_4
* cell instance $63278 m0 *1 355.12,541.28
X$63278 73 12096 12387 12717 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63281 m0 *1 357.88,541.28
X$63281 73 12563 12716 12715 57 73 12469 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63286 m0 *1 362.48,541.28
X$63286 73 11868 73 57 12633 57 sky130_fd_sc_hd__inv_1
* cell instance $63289 m0 *1 365.24,541.28
X$63289 57 11868 12563 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $63292 m0 *1 373.98,541.28
X$63292 57 12712 14345 12604 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $63294 m0 *1 381.34,541.28
X$63294 73 12712 73 57 12603 57 sky130_fd_sc_hd__buf_4
* cell instance $63295 m0 *1 384.1,541.28
X$63295 73 12613 57 73 12709 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63299 m0 *1 390.08,541.28
X$63299 57 10114 12543 7186 12635 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $63300 m0 *1 392.38,541.28
X$63300 73 7186 10114 12635 57 73 12636 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63301 m0 *1 394.22,541.28
X$63301 57 4950 12611 12019 12704 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $63302 m0 *1 405.26,541.28
X$63302 73 12456 6435 12957 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $63303 m0 *1 408.48,541.28
X$63303 73 12456 6435 73 12564 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $63304 m0 *1 411.7,541.28
X$63304 73 12564 73 57 12606 57 sky130_fd_sc_hd__buf_4
* cell instance $63306 m0 *1 414.92,541.28
X$63306 73 12495 12536 12641 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63308 m0 *1 416.76,541.28
X$63308 73 12565 73 57 12566 57 sky130_fd_sc_hd__buf_4
* cell instance $63309 m0 *1 419.52,541.28
X$63309 73 12641 73 57 12642 57 sky130_fd_sc_hd__buf_4
* cell instance $63312 m0 *1 423.66,541.28
X$63312 57 12700 12610 12697 12411 12643 12609 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $63313 m0 *1 426.88,541.28
X$63313 57 12697 13582 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $63315 m0 *1 435.16,541.28
X$63315 73 12534 73 57 12568 57 sky130_fd_sc_hd__buf_4
* cell instance $63321 m0 *1 448.04,541.28
X$63321 73 12450 12568 12649 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63325 m0 *1 452.64,541.28
X$63325 73 12693 12804 12694 13007 57 12692 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $63328 m0 *1 456.32,541.28
X$63328 73 12650 12691 12606 12802 57 73 12315 57 sky130_fd_sc_hd__a31oi_1
* cell instance $63330 m0 *1 459.08,541.28
X$63330 57 12378 12607 12652 12688 12690 12685 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $63342 m0 *1 492.66,541.28
X$63342 73 12603 7376 12683 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $63343 m0 *1 495.88,541.28
X$63343 73 12603 7376 73 12602 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $63346 m0 *1 503.24,541.28
X$63346 73 12684 73 57 12413 57 sky130_fd_sc_hd__buf_4
* cell instance $63349 m0 *1 508.76,541.28
X$63349 57 12682 12874 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $63350 m0 *1 516.12,541.28
X$63350 73 12602 12414 12570 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63351 m0 *1 517.5,541.28
X$63351 73 12022 73 57 12681 57 sky130_fd_sc_hd__buf_4
* cell instance $63352 m0 *1 520.26,541.28
X$63352 73 12569 73 57 12360 57 sky130_fd_sc_hd__buf_4
* cell instance $63354 m0 *1 523.48,541.28
X$63354 73 12570 73 57 12653 57 sky130_fd_sc_hd__buf_4
* cell instance $63358 m0 *1 528.08,541.28
X$63358 57 12417 12680 12532 12022 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $63360 m0 *1 533.6,541.28
X$63360 57 12308 12599 12532 73 73 57 sky130_fd_sc_hd__ha_2
* cell instance $63361 m0 *1 539.12,541.28
X$63361 73 12532 73 57 12418 57 sky130_fd_sc_hd__buf_4
* cell instance $63362 m0 *1 541.88,541.28
X$63362 73 12677 73 57 12505 57 sky130_fd_sc_hd__buf_4
* cell instance $63364 m0 *1 545.1,541.28
X$63364 73 12591 73 57 12596 57 sky130_fd_sc_hd__buf_4
* cell instance $63365 m0 *1 547.86,541.28
X$63365 73 12418 12436 12501 73 12655 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63366 m0 *1 549.7,541.28
X$63366 57 12573 12671 12204 12360 12418 12655 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $63370 m0 *1 554.76,541.28
X$63370 73 12573 12594 12574 12670 57 73 13605 57 sky130_fd_sc_hd__a31oi_1
* cell instance $63372 m0 *1 557.52,541.28
X$63372 73 12517 12285 12519 12574 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $63373 m0 *1 559.36,541.28
X$63373 73 12575 73 57 12282 57 sky130_fd_sc_hd__buf_4
* cell instance $63374 m0 *1 562.12,541.28
X$63374 73 12217 12361 12575 12590 57 12667 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $63375 m0 *1 564.88,541.28
X$63375 73 12420 12217 12590 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63378 m0 *1 568.56,541.28
X$63378 57 12362 12576 12505 12219 12210 12577 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $63379 m0 *1 571.78,541.28
X$63379 73 12765 73 57 12503 57 sky130_fd_sc_hd__buf_4
* cell instance $63380 m0 *1 574.54,541.28
X$63380 73 12203 12589 12578 12281 12662 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $63383 m0 *1 578.68,541.28
X$63383 57 12658 12656 12499 12570 12578 12360 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $63388 m0 *1 587.42,541.28
X$63388 73 12657 12580 12203 73 12578 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63389 m0 *1 589.26,541.28
X$63389 73 12283 12575 12580 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63390 m0 *1 590.64,541.28
X$63390 73 12418 12210 12657 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63393 m0 *1 593.4,541.28
X$63393 57 12583 12584 12658 12659 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $63420 r0 *1 8.74,541.28
X$63420 57 12773 12660 11674 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $63424 r0 *1 18.4,541.28
X$63424 73 12586 73 57 12775 57 sky130_fd_sc_hd__buf_4
* cell instance $63425 r0 *1 21.16,541.28
X$63425 73 12661 73 57 12719 57 sky130_fd_sc_hd__buf_4
* cell instance $63428 r0 *1 25.3,541.28
X$63428 73 12293 73 57 12776 57 sky130_fd_sc_hd__buf_4
* cell instance $63429 r0 *1 28.06,541.28
X$63429 73 12002 12550 12617 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63434 r0 *1 39.1,541.28
X$63434 73 11641 12664 12780 12587 11955 73 13649 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $63439 r0 *1 44.16,541.28
X$63439 73 12986 12720 12040 73 12664 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63442 r0 *1 47.38,541.28
X$63442 73 12371 11880 12720 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63443 r0 *1 48.76,541.28
X$63443 73 11637 11641 12618 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63444 r0 *1 50.14,541.28
X$63444 57 12666 12618 12619 12339 12674 12782 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $63445 r0 *1 53.36,541.28
X$63445 73 12619 73 57 11880 57 sky130_fd_sc_hd__buf_4
* cell instance $63448 r0 *1 57.5,541.28
X$63448 73 11800 12783 11955 73 12554 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $63449 r0 *1 60.26,541.28
X$63449 73 12621 12669 11800 12721 57 73 12668 57 sky130_fd_sc_hd__a31oi_1
* cell instance $63450 r0 *1 62.56,541.28
X$63450 73 12264 12622 12669 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63451 r0 *1 63.94,541.28
X$63451 73 12623 73 57 12622 57 sky130_fd_sc_hd__buf_4
* cell instance $63452 r0 *1 66.7,541.28
X$63452 73 11799 12672 12553 12721 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $63453 r0 *1 68.54,541.28
X$63453 73 12672 12622 12624 57 73 12785 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63459 r0 *1 75.9,541.28
X$63459 57 11954 12791 12552 12623 12674 11955 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $63463 r0 *1 82.34,541.28
X$63463 73 12678 73 57 12624 57 sky130_fd_sc_hd__buf_4
* cell instance $63467 r0 *1 91.08,541.28
X$63467 57 12005 12231 11955 12793 12553 12679 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $63469 r0 *1 94.76,541.28
X$63469 73 11973 12794 12598 12625 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $63470 r0 *1 96.6,541.28
X$63470 73 12625 11838 11648 12796 57 12626 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $63477 r0 *1 108.1,541.28
X$63477 73 11844 12005 12724 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63478 r0 *1 109.48,541.28
X$63478 73 11844 12040 12800 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63481 r0 *1 116.38,541.28
X$63481 73 12724 12555 12723 12224 13044 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $63490 r0 *1 132.02,541.28
X$63490 57 11490 12807 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $63493 r0 *1 142.14,541.28
X$63493 73 11490 73 57 12808 57 sky130_fd_sc_hd__clkinv_1
* cell instance $63503 r0 *1 159.16,541.28
X$63503 73 12556 12628 13664 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63505 r0 *1 161,541.28
X$63505 73 12556 73 57 12689 57 sky130_fd_sc_hd__buf_4
* cell instance $63506 r0 *1 163.76,541.28
X$63506 73 12556 73 57 12809 57 sky130_fd_sc_hd__buf_4
* cell instance $63507 r0 *1 166.52,541.28
X$63507 73 12391 12627 12728 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63508 r0 *1 167.9,541.28
X$63508 73 12628 73 57 12810 57 sky130_fd_sc_hd__buf_4
* cell instance $63511 r0 *1 172.96,541.28
X$63511 73 11956 7572 73 12821 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $63512 r0 *1 176.18,541.28
X$63512 73 12556 12629 12811 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63513 r0 *1 177.56,541.28
X$63513 73 12629 73 57 12812 57 sky130_fd_sc_hd__buf_4
* cell instance $63518 r0 *1 182.16,541.28
X$63518 73 12628 12687 12814 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63520 r0 *1 184.46,541.28
X$63520 73 12628 73 57 12729 57 sky130_fd_sc_hd__buf_4
* cell instance $63545 r0 *1 253.92,541.28
X$63545 73 10697 12612 12698 73 12696 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63558 r0 *1 281.06,541.28
X$63558 73 12191 11790 12630 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63559 r0 *1 282.44,541.28
X$63559 73 12630 73 57 12631 57 sky130_fd_sc_hd__buf_4
* cell instance $63572 r0 *1 311.42,541.28
X$63572 73 12616 12827 12701 12828 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $63573 r0 *1 313.26,541.28
X$63573 73 12738 12616 12631 12828 57 12703 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $63580 r0 *1 323.38,541.28
X$63580 73 12830 12825 12703 12099 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $63581 r0 *1 325.22,541.28
X$63581 73 12632 12705 12706 57 73 12407 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63585 r0 *1 334.88,541.28
X$63585 73 12632 12711 13865 57 73 12615 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63587 r0 *1 338.56,541.28
X$63587 73 12633 73 57 12632 57 sky130_fd_sc_hd__buf_4
* cell instance $63589 r0 *1 341.32,541.28
X$63589 73 12824 12616 12634 57 73 12708 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63591 r0 *1 344.08,541.28
X$63591 73 12858 12823 12711 12948 12563 12634 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $63593 r0 *1 347.76,541.28
X$63593 73 12563 12714 12823 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63597 r0 *1 357.42,541.28
X$63597 57 12954 10114 11789 12745 9578 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $63601 r0 *1 367.54,541.28
X$63601 57 12916 12822 12713 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $63607 r0 *1 383.18,541.28
X$63607 73 12095 73 57 12710 57 sky130_fd_sc_hd__inv_1
* cell instance $63608 r0 *1 384.56,541.28
X$63608 57 12710 12644 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $63609 r0 *1 391.92,541.28
X$63609 73 12636 11406 11500 73 57 12638 57 sky130_fd_sc_hd__a21bo_2
* cell instance $63616 r0 *1 402.96,541.28
X$63616 73 12702 57 73 12820 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63619 r0 *1 411.24,541.28
X$63619 73 12638 12637 73 12639 57 57 sky130_fd_sc_hd__and2_2
* cell instance $63620 r0 *1 414,541.28
X$63620 73 12637 73 57 12818 57 sky130_fd_sc_hd__buf_4
* cell instance $63621 r0 *1 416.76,541.28
X$63621 73 12639 12565 12640 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63622 r0 *1 418.14,541.28
X$63622 73 12640 73 57 12959 57 sky130_fd_sc_hd__buf_4
* cell instance $63624 r0 *1 421.36,541.28
X$63624 73 12640 73 57 12806 57 sky130_fd_sc_hd__buf_4
* cell instance $63628 r0 *1 425.5,541.28
X$63628 73 12639 73 57 12645 57 sky130_fd_sc_hd__buf_4
* cell instance $63629 r0 *1 428.26,541.28
X$63629 73 12644 12566 12697 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63632 r0 *1 430.56,541.28
X$63632 73 12610 73 57 13143 57 sky130_fd_sc_hd__buf_4
* cell instance $63633 r0 *1 433.32,541.28
X$63633 73 12566 73 57 12695 57 sky130_fd_sc_hd__buf_4
* cell instance $63634 r0 *1 436.08,541.28
X$63634 73 12646 73 57 12750 57 sky130_fd_sc_hd__buf_4
* cell instance $63636 r0 *1 439.76,541.28
X$63636 57 15633 12646 12495 12644 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $63638 r0 *1 445.28,541.28
X$63638 73 12646 73 57 12751 57 sky130_fd_sc_hd__buf_4
* cell instance $63640 r0 *1 448.5,541.28
X$63640 73 12642 12647 12645 73 12648 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63642 r0 *1 450.34,541.28
X$63642 73 12649 12803 12648 57 73 12804 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63645 r0 *1 454.48,541.28
X$63645 57 12692 12802 12801 12651 12607 12799 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $63649 r0 *1 462.3,541.28
X$63649 73 12568 12797 13225 12690 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $63650 r0 *1 464.14,541.28
X$63650 73 12496 12695 12685 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63654 r0 *1 473.34,541.28
X$63654 57 15600 12652 12795 12644 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $63668 r0 *1 510.14,541.28
X$63668 73 12683 73 57 12415 57 sky130_fd_sc_hd__buf_4
* cell instance $63671 r0 *1 515.2,541.28
X$63671 73 12602 12414 12789 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63673 r0 *1 520.26,541.28
X$63673 73 12532 73 57 12788 57 sky130_fd_sc_hd__buf_4
* cell instance $63676 r0 *1 528.54,541.28
X$63676 73 12526 73 57 12758 57 sky130_fd_sc_hd__buf_4
* cell instance $63678 r0 *1 531.3,541.28
X$63678 57 15675 12677 12532 12526 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $63679 r0 *1 535.9,541.28
X$63679 57 15635 12759 12532 12420 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $63683 r0 *1 542.34,541.28
X$63683 73 12282 12994 12784 12675 12440 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $63684 r0 *1 545.1,541.28
X$63684 73 12654 12205 12762 57 73 12784 57 sky130_fd_sc_hd__a21o_1
* cell instance $63686 r0 *1 549.7,541.28
X$63686 73 12420 12219 12654 73 12671 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63692 r0 *1 560.28,541.28
X$63692 73 12360 12575 12436 12764 12667 73 12781 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $63694 r0 *1 564.42,541.28
X$63694 73 12506 12575 12431 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63698 r0 *1 568.56,541.28
X$63698 73 12778 12145 12886 12779 57 12665 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $63701 r0 *1 575.92,541.28
X$63701 73 12662 73 57 12663 57 sky130_fd_sc_hd__buf_4
* cell instance $63704 r0 *1 581.44,541.28
X$63704 57 15612 12768 12575 12420 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $63706 r0 *1 586.04,541.28
X$63706 73 12369 12774 12772 73 12579 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63710 r0 *1 592.94,541.28
X$63710 73 13197 73 57 12311 57 sky130_fd_sc_hd__buf_4
* cell instance $63785 m0 *1 2.3,546.72
X$63785 73 12831 57 73 12016 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63789 m0 *1 11.96,546.72
X$63789 57 10727 12660 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $63792 m0 *1 23.92,546.72
X$63792 73 12674 11955 12833 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63795 m0 *1 26.68,546.72
X$63795 73 11800 12776 12550 57 73 12777 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63800 m0 *1 31.28,546.72
X$63800 73 12477 12777 12621 12115 11800 12884 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $63803 m0 *1 40.02,546.72
X$63803 73 12588 12929 12002 73 12780 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63806 m0 *1 47.38,546.72
X$63806 73 12371 12623 12260 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63809 m0 *1 51.52,546.72
X$63809 73 12929 73 57 12524 57 sky130_fd_sc_hd__buf_4
* cell instance $63811 m0 *1 54.74,546.72
X$63811 73 12056 12623 12620 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63812 m0 *1 56.12,546.72
X$63812 73 12293 12335 12783 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63818 m0 *1 67.62,546.72
X$63818 73 12623 13347 12672 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63821 m0 *1 74.52,546.72
X$63821 73 12676 12888 12786 12666 57 12722 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $63824 m0 *1 80.96,546.72
X$63824 73 12002 12551 12793 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63831 m0 *1 92,546.72
X$63831 73 13304 73 57 12794 57 sky130_fd_sc_hd__buf_4
* cell instance $63832 m0 *1 94.76,546.72
X$63832 73 12722 73 57 12725 57 sky130_fd_sc_hd__buf_4
* cell instance $63837 m0 *1 106.26,546.72
X$63837 73 12002 11955 12723 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63843 m0 *1 116.84,546.72
X$63843 73 12725 12891 12626 57 73 12726 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63846 m0 *1 121.44,546.72
X$63846 73 12726 13121 12805 11684 13005 12727 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $63848 m0 *1 125.58,546.72
X$63848 57 11307 12240 12727 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $63853 m0 *1 144.44,546.72
X$63853 57 12808 12841 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $63863 m0 *1 171.12,546.72
X$63863 57 12453 12848 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $63864 m0 *1 178.48,546.72
X$63864 73 12901 73 57 12849 57 sky130_fd_sc_hd__buf_4
* cell instance $63866 m0 *1 183.08,546.72
X$63866 57 12817 12812 12849 12850 12904 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $63870 m0 *1 189.52,546.72
X$63870 73 12906 12809 12482 12817 57 12730 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $63872 m0 *1 192.74,546.72
X$63872 73 12851 12809 12729 12819 57 12907 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $63874 m0 *1 195.96,546.72
X$63874 73 12728 12731 12908 12732 12268 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $63875 m0 *1 198.72,546.72
X$63875 73 12907 12729 12733 57 73 12731 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63879 m0 *1 211.6,546.72
X$63879 73 12848 12734 13133 73 12733 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63880 m0 *1 213.44,546.72
X$63880 73 13028 12687 12734 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $63890 m0 *1 238.74,546.72
X$63890 57 12915 12854 12686 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $63907 m0 *1 286.58,546.72
X$63907 57 12737 12917 12384 12353 12735 12855 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $63908 m0 *1 289.8,546.72
X$63908 73 12856 12736 12918 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63909 m0 *1 291.18,546.72
X$63909 73 12919 73 57 12701 57 sky130_fd_sc_hd__buf_4
* cell instance $63913 m0 *1 297.16,546.72
X$63913 73 12920 12826 12737 12825 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $63914 m0 *1 299,546.72
X$63914 73 12158 13033 12826 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63920 m0 *1 311.88,546.72
X$63920 73 12858 12948 12739 12563 12096 73 12827 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $63921 m0 *1 315.1,546.72
X$63921 73 12563 12705 12740 57 73 12739 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63923 m0 *1 317.4,546.72
X$63923 73 12923 73 57 12705 57 sky130_fd_sc_hd__buf_4
* cell instance $63927 m0 *1 323.38,546.72
X$63927 73 12632 12705 12716 57 73 12924 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63929 m0 *1 328.9,546.72
X$63929 73 13023 12353 12859 57 73 12829 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63931 m0 *1 331.66,546.72
X$63931 73 12616 12742 12741 73 12859 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63934 m0 *1 335.8,546.72
X$63934 73 12711 12740 12563 12743 57 73 12742 57 sky130_fd_sc_hd__a31oi_1
* cell instance $63937 m0 *1 339.48,546.72
X$63937 73 13177 12563 12616 12743 57 12824 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $63942 m0 *1 355.12,546.72
X$63942 73 12744 9578 11406 11789 73 12860 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $63943 m0 *1 358.34,546.72
X$63943 73 10114 11789 12745 9578 12861 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $63945 m0 *1 361.56,546.72
X$63945 57 12955 9578 12744 11406 11789 73 73 57 sky130_fd_sc_hd__a211oi_2
* cell instance $63946 m0 *1 366.16,546.72
X$63946 73 10114 12746 12744 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $63949 m0 *1 369.84,546.72
X$63949 73 10114 12746 12745 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $63959 m0 *1 398.36,546.72
X$63959 57 12913 12914 11214 11406 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $63962 m0 *1 406.64,546.72
X$63962 73 12566 12863 12864 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $63964 m0 *1 411.7,546.72
X$63964 73 12638 73 57 12911 57 sky130_fd_sc_hd__buf_4
* cell instance $63965 m0 *1 414.46,546.72
X$63965 73 12865 12911 12818 57 73 12816 57 sky130_fd_sc_hd__a21oi_1
* cell instance $63967 m0 *1 416.76,546.72
X$63967 57 12815 12747 12567 12095 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $63970 m0 *1 425.96,546.72
X$63970 73 12536 12748 12909 12534 57 12700 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $63971 m0 *1 428.26,546.72
X$63971 57 13075 12643 12867 12749 12536 12534 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $63975 m0 *1 434.7,546.72
X$63975 73 12750 12748 12863 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $63978 m0 *1 438.84,546.72
X$63978 73 12536 73 57 12798 57 sky130_fd_sc_hd__buf_4
* cell instance $63986 m0 *1 459.08,546.72
X$63986 73 12863 12798 12496 12752 57 12688 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $63993 m0 *1 475.64,546.72
X$63993 73 12752 12873 12695 73 12895 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $63994 m0 *1 477.48,546.72
X$63994 73 12895 12893 12568 12606 57 13127 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $63999 m0 *1 491.74,546.72
X$63999 57 11063 12359 12753 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $64004 m0 *1 505.54,546.72
X$64004 73 12683 12414 12892 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $64005 m0 *1 507.84,546.72
X$64005 73 12892 73 57 12212 57 sky130_fd_sc_hd__buf_4
* cell instance $64008 m0 *1 512.9,546.72
X$64008 57 12758 12792 12754 12219 12875 12890 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $64009 m0 *1 516.12,546.72
X$64009 73 12754 12755 12792 73 12790 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64011 m0 *1 518.42,546.72
X$64011 73 12681 12675 12787 73 12755 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64012 m0 *1 520.26,546.72
X$64012 73 12210 12219 12787 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64015 m0 *1 523.94,546.72
X$64015 73 12789 73 57 12215 57 sky130_fd_sc_hd__buf_4
* cell instance $64018 m0 *1 527.62,546.72
X$64018 73 12757 12756 12210 73 12889 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64019 m0 *1 529.46,546.72
X$64019 57 15473 12760 12874 12599 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64020 m0 *1 534.06,546.72
X$64020 73 12680 73 57 12878 57 sky130_fd_sc_hd__buf_4
* cell instance $64022 m0 *1 537.28,546.72
X$64022 73 12599 73 57 12204 57 sky130_fd_sc_hd__buf_4
* cell instance $64023 m0 *1 540.04,546.72
X$64023 73 12759 12677 12761 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64026 m0 *1 543.72,546.72
X$64026 73 12760 73 57 12762 57 sky130_fd_sc_hd__inv_1
* cell instance $64027 m0 *1 545.1,546.72
X$64027 73 12762 12376 12756 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64031 m0 *1 551.54,546.72
X$64031 73 12874 73 57 12506 57 sky130_fd_sc_hd__buf_4
* cell instance $64036 m0 *1 560.74,546.72
X$64036 73 12763 73 57 12764 57 sky130_fd_sc_hd__inv_1
* cell instance $64037 m0 *1 562.12,546.72
X$64037 73 12763 12575 12517 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64039 m0 *1 565.34,546.72
X$64039 57 12779 12985 12764 12515 12361 12766 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $64040 m0 *1 568.56,546.72
X$64040 57 12517 12778 12766 12767 12575 12361 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $64042 m0 *1 572.24,546.72
X$64042 73 12757 12878 12145 57 73 12576 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64050 m0 *1 585.58,546.72
X$64050 73 12768 12145 12767 73 12774 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64051 m0 *1 587.42,546.72
X$64051 73 12770 12768 12203 12769 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64052 m0 *1 589.26,546.72
X$64052 57 12882 12770 12368 12420 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64053 m0 *1 593.86,546.72
X$64053 73 12217 12219 12771 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64055 m0 *1 597.08,546.72
X$64055 73 12771 73 57 12767 57 sky130_fd_sc_hd__buf_4
* cell instance $64080 r0 *1 5.06,546.72
X$64080 73 12832 57 73 12925 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64081 r0 *1 8.74,546.72
X$64081 57 12832 12660 11793 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $64084 r0 *1 16.56,546.72
X$64084 57 12660 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $64085 r0 *1 22.54,546.72
X$64085 73 12775 73 57 12399 57 sky130_fd_sc_hd__buf_4
* cell instance $64087 r0 *1 25.76,546.72
X$64087 73 12833 73 57 11682 57 sky130_fd_sc_hd__buf_4
* cell instance $64090 r0 *1 31.28,546.72
X$64090 73 12927 12884 12885 73 13207 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64091 r0 *1 33.12,546.72
X$64091 73 12983 11682 12835 57 73 12984 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64093 r0 *1 35.88,546.72
X$64093 73 12834 12588 12624 57 73 12835 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64096 r0 *1 40.02,546.72
X$64096 73 12618 73 57 12885 57 sky130_fd_sc_hd__buf_4
* cell instance $64103 r0 *1 50.14,546.72
X$64103 73 12621 73 57 12991 57 sky130_fd_sc_hd__buf_4
* cell instance $64106 r0 *1 54.28,546.72
X$64106 73 11678 11486 12990 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64107 r0 *1 55.66,546.72
X$64107 73 12783 73 57 12992 57 sky130_fd_sc_hd__buf_4
* cell instance $64112 r0 *1 68.54,546.72
X$64112 73 11678 73 57 12674 57 sky130_fd_sc_hd__buf_4
* cell instance $64122 r0 *1 92.46,546.72
X$64122 73 12933 12996 12998 12177 12031 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $64123 r0 *1 94.76,546.72
X$64123 57 12998 12836 12837 12724 12341 13000 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $64133 r0 *1 118.22,546.72
X$64133 73 11879 12838 12236 73 12839 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64134 r0 *1 120.06,546.72
X$64134 73 11834 12839 13004 73 12805 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64146 r0 *1 149.5,546.72
X$64146 73 12840 73 57 12896 57 sky130_fd_sc_hd__buf_4
* cell instance $64148 r0 *1 152.26,546.72
X$64148 73 12843 12910 12894 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64151 r0 *1 154.56,546.72
X$64151 73 12894 13011 12810 13010 57 13355 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $64152 r0 *1 156.86,546.72
X$64152 73 12841 12897 12842 57 73 13010 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64155 r0 *1 161.46,546.72
X$64155 73 12846 12687 12898 57 73 13008 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64157 r0 *1 163.76,546.72
X$64157 73 12807 12897 12842 57 73 13014 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64158 r0 *1 165.6,546.72
X$64158 73 12843 12841 12844 73 12898 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64159 r0 *1 167.44,546.72
X$64159 73 12846 13014 12845 12899 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64162 r0 *1 170.66,546.72
X$64162 73 12453 12687 12840 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64163 r0 *1 172.04,546.72
X$64163 73 12903 12841 12852 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $64164 r0 *1 175.26,546.72
X$64164 73 12901 13017 12848 73 12846 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64165 r0 *1 177.1,546.72
X$64165 73 12847 12934 12841 12901 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64167 r0 *1 178.94,546.72
X$64167 73 12244 73 57 12903 57 sky130_fd_sc_hd__buf_4
* cell instance $64170 r0 *1 182.62,546.72
X$64170 73 12905 12807 12814 73 12850 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64172 r0 *1 185.38,546.72
X$64172 73 12903 13019 12848 73 12904 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64175 r0 *1 189.52,546.72
X$64175 73 12852 12847 12910 12905 12906 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $64179 r0 *1 195.04,546.72
X$64179 73 12899 12729 12391 13020 57 12937 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $64180 r0 *1 197.34,546.72
X$64180 57 12908 13021 13427 12853 12937 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $64181 r0 *1 200.56,546.72
X$64181 73 12841 12244 12910 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64182 r0 *1 201.94,546.72
X$64182 73 12601 12910 12840 57 73 13022 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64186 r0 *1 206.08,546.72
X$64186 73 12730 73 57 13032 57 sky130_fd_sc_hd__buf_4
* cell instance $64202 r0 *1 242.88,546.72
X$64202 57 12352 12854 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $64216 r0 *1 285.2,546.72
X$64216 57 15634 12856 12633 12950 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64218 r0 *1 289.8,546.72
X$64218 73 13784 12918 12855 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64221 r0 *1 292.56,546.72
X$64221 73 12856 12616 12944 12946 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64222 r0 *1 294.4,546.72
X$64222 73 13251 12946 12158 73 12921 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64227 r0 *1 303.14,546.72
X$64227 73 12563 12922 13031 12384 73 57 13026 57 sky130_fd_sc_hd__o31ai_1
* cell instance $64237 r0 *1 322.92,546.72
X$64237 73 12924 13026 12952 12384 13027 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $64249 r0 *1 355.58,546.72
X$64249 57 57 12860 12953 12861 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $64254 r0 *1 367.54,546.72
X$64254 73 12916 57 73 14050 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64264 r0 *1 394.22,546.72
X$64264 73 12095 73 57 12862 57 sky130_fd_sc_hd__buf_4
* cell instance $64268 r0 *1 398.36,546.72
X$64268 73 12862 12495 13371 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64272 r0 *1 402.96,546.72
X$64272 57 12815 12866 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $64273 r0 *1 410.32,546.72
X$64273 57 15618 12865 12495 12644 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64274 r0 *1 414.92,546.72
X$64274 73 12865 73 57 13018 57 sky130_fd_sc_hd__buf_4
* cell instance $64277 r0 *1 419.98,546.72
X$64277 73 12567 73 57 12960 57 sky130_fd_sc_hd__clkinv_1
* cell instance $64281 r0 *1 422.74,546.72
X$64281 73 12095 73 57 12867 57 sky130_fd_sc_hd__buf_4
* cell instance $64282 r0 *1 425.5,546.72
X$64282 73 12639 73 57 12748 57 sky130_fd_sc_hd__buf_4
* cell instance $64284 r0 *1 428.72,546.72
X$64284 73 12644 12748 12749 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64287 r0 *1 434.24,546.72
X$64287 57 15603 12871 12495 12867 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64288 r0 *1 438.84,546.72
X$64288 73 12495 73 57 13016 57 sky130_fd_sc_hd__buf_4
* cell instance $64290 r0 *1 442.06,546.72
X$64290 57 12963 12868 12748 12867 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64291 r0 *1 446.66,546.72
X$64291 73 12868 13013 12798 12902 12869 73 57 57 sky130_fd_sc_hd__or4_1
* cell instance $64292 r0 *1 449.42,546.72
X$64292 73 12378 13012 13009 12869 73 57 12694 57 sky130_fd_sc_hd__o31ai_1
* cell instance $64294 r0 *1 452.18,546.72
X$64294 73 12495 12795 12752 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64296 r0 *1 454.48,546.72
X$64296 57 12797 12693 12871 13006 12900 12870 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $64302 r0 *1 471.04,546.72
X$64302 73 12866 12645 12496 13003 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64304 r0 *1 473.8,546.72
X$64304 73 12644 12645 12872 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64305 r0 *1 475.18,546.72
X$64305 73 12872 12873 12798 73 12967 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64308 r0 *1 477.48,546.72
X$64308 73 12751 12870 12893 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64309 r0 *1 478.86,546.72
X$64309 73 12652 12695 12568 73 13001 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64321 r0 *1 506.46,546.72
X$64321 73 12602 73 57 12968 57 sky130_fd_sc_hd__buf_4
* cell instance $64325 r0 *1 513.82,546.72
X$64325 73 12874 12219 12876 12758 12890 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $64327 r0 *1 517.04,546.72
X$64327 73 12788 12876 12875 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64328 r0 *1 518.42,546.72
X$64328 73 12875 73 57 12972 57 sky130_fd_sc_hd__buf_4
* cell instance $64330 r0 *1 523.02,546.72
X$64330 73 12360 73 57 12877 57 sky130_fd_sc_hd__buf_4
* cell instance $64331 r0 *1 525.78,546.72
X$64331 73 12874 12654 12889 12877 13838 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $64334 r0 *1 530.84,546.72
X$64334 57 15623 12995 12874 12599 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64338 r0 *1 537.74,546.72
X$64338 73 12759 73 57 12880 57 sky130_fd_sc_hd__buf_4
* cell instance $64342 r0 *1 542.34,546.72
X$64342 73 12760 73 57 12283 57 sky130_fd_sc_hd__buf_4
* cell instance $64343 r0 *1 545.1,546.72
X$64343 73 12502 73 57 12989 57 sky130_fd_sc_hd__buf_4
* cell instance $64344 r0 *1 547.86,546.72
X$64344 73 12506 12210 13115 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64349 r0 *1 560.28,546.72
X$64349 57 12414 12988 12285 12987 12781 12879 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $64354 r0 *1 570.4,546.72
X$64354 73 12766 12767 12977 73 12886 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64357 r0 *1 575,546.72
X$64357 73 12366 12360 12880 12881 73 12879 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $64358 r0 *1 577.76,546.72
X$64358 73 12575 12576 13106 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64363 r0 *1 585.58,546.72
X$64363 73 12420 12575 12982 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64364 r0 *1 586.96,546.72
X$64364 73 12575 12581 12982 12203 57 12883 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $64366 r0 *1 590.18,546.72
X$64366 73 12883 12882 12203 57 73 12981 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64442 m0 *1 2.3,552.16
X$64442 57 13096 12660 11835 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $64446 m0 *1 12.88,552.16
X$64446 57 13098 12660 11747 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $64449 m0 *1 22.54,552.16
X$64449 73 13099 12926 12833 73 13100 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64450 m0 *1 24.38,552.16
X$64450 73 11800 12260 12429 57 73 12926 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64454 m0 *1 30.82,552.16
X$64454 73 12119 12617 13393 11800 12927 73 12983 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $64456 m0 *1 34.5,552.16
X$64456 73 11800 13102 12259 57 73 12834 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64458 m0 *1 37.26,552.16
X$64458 73 12990 73 57 12927 57 sky130_fd_sc_hd__buf_4
* cell instance $64461 m0 *1 42.32,552.16
X$64461 73 12928 13037 12002 12929 57 12986 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $64464 m0 *1 46.46,552.16
X$64464 73 12623 12928 12929 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64470 m0 *1 57.96,552.16
X$64470 73 12337 73 57 12930 57 sky130_fd_sc_hd__buf_4
* cell instance $64471 m0 *1 60.72,552.16
X$64471 57 11677 12478 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $64473 m0 *1 68.54,552.16
X$64473 73 13111 73 57 12838 57 sky130_fd_sc_hd__buf_4
* cell instance $64476 m0 *1 78.66,552.16
X$64476 73 12056 12478 11886 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64483 m0 *1 88.32,552.16
X$64483 73 12930 12551 12005 73 12931 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64485 m0 *1 92,552.16
X$64485 73 12116 12931 12996 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64488 m0 *1 96.14,552.16
X$64488 73 12932 73 57 13000 57 sky130_fd_sc_hd__buf_4
* cell instance $64490 m0 *1 100.74,552.16
X$64490 73 12264 13000 11976 13043 12933 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $64491 m0 *1 103.5,552.16
X$64491 73 11637 11838 13002 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64494 m0 *1 109.48,552.16
X$64494 57 13117 11834 12004 12800 11879 13118 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $64498 m0 *1 115.92,552.16
X$64498 73 12342 12005 12933 13261 12267 73 13119 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $64499 m0 *1 119.14,552.16
X$64499 73 12342 13122 13228 11834 13004 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $64500 m0 *1 121.9,552.16
X$64500 73 13002 73 57 13005 57 sky130_fd_sc_hd__buf_4
* cell instance $64516 m0 *1 166.06,552.16
X$64516 73 12843 12813 12627 73 12845 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64518 m0 *1 168.36,552.16
X$64518 73 12453 73 57 13123 57 sky130_fd_sc_hd__buf_4
* cell instance $64521 m0 *1 173.88,552.16
X$64521 73 13124 12807 12903 73 13017 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64524 m0 *1 177.1,552.16
X$64524 73 12807 12903 13048 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64526 m0 *1 179.4,552.16
X$64526 73 12903 13125 12849 12935 73 57 13126 57 sky130_fd_sc_hd__o31ai_1
* cell instance $64528 m0 *1 183.08,552.16
X$64528 73 12812 13129 12903 57 73 12935 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64530 m0 *1 185.38,552.16
X$64530 73 13124 73 57 12905 57 sky130_fd_sc_hd__buf_4
* cell instance $64536 m0 *1 197.34,552.16
X$64536 57 13020 13130 13129 12936 13170 12687 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $64537 m0 *1 200.56,552.16
X$64537 73 12627 12809 12936 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64540 m0 *1 206.08,552.16
X$64540 73 12912 12841 12844 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64541 m0 *1 207.46,552.16
X$64541 73 12934 12848 12813 12938 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64542 m0 *1 209.3,552.16
X$64542 73 12938 13022 12912 73 13132 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64545 m0 *1 213.9,552.16
X$64545 73 12601 13049 12807 12848 73 13025 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $64546 m0 *1 216.66,552.16
X$64546 73 13050 13051 13028 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64548 m0 *1 218.5,552.16
X$64548 73 12912 12934 13050 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64554 m0 *1 224.02,552.16
X$64554 73 12813 13170 12809 57 73 13030 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64556 m0 *1 226.78,552.16
X$64556 73 12391 13032 13137 13136 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64563 m0 *1 242.88,552.16
X$64563 73 12854 73 57 15423 57 sky130_fd_sc_hd__clkinvlp_4
* cell instance $64566 m0 *1 247.02,552.16
X$64566 73 12915 57 73 13139 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64575 m0 *1 275.08,552.16
X$64575 73 12922 12940 13034 73 13058 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64583 m0 *1 285.66,552.16
X$64583 57 12857 12919 12943 12158 12942 12941 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $64584 m0 *1 288.88,552.16
X$64584 73 12384 13141 12944 57 73 12735 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64585 m0 *1 290.72,552.16
X$64585 73 12563 13142 12945 57 73 12942 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64589 m0 *1 298.54,552.16
X$64589 73 13250 13058 12616 13059 57 73 13033 57 sky130_fd_sc_hd__a31oi_1
* cell instance $64591 m0 *1 301.3,552.16
X$64591 73 13031 73 57 12857 57 sky130_fd_sc_hd__buf_4
* cell instance $64592 m0 *1 304.06,552.16
X$64592 73 13055 12944 13031 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64596 m0 *1 307.28,552.16
X$64596 73 12158 12616 13060 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64600 m0 *1 315.1,552.16
X$64600 73 13060 73 57 12947 57 sky130_fd_sc_hd__buf_4
* cell instance $64601 m0 *1 317.86,552.16
X$64601 73 12947 12939 13029 73 13023 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64604 m0 *1 321.08,552.16
X$64604 73 12631 13144 13029 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64608 m0 *1 328.44,552.16
X$64608 73 12947 13146 13339 57 73 13024 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64611 m0 *1 331.66,552.16
X$64611 73 12563 12706 12711 13146 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $64616 m0 *1 339.02,552.16
X$64616 73 12563 13065 12945 57 73 12743 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64617 m0 *1 340.86,552.16
X$64617 73 12950 12944 12948 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64619 m0 *1 342.7,552.16
X$64619 73 12951 12952 13147 57 73 12949 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64621 m0 *1 346.38,552.16
X$64621 73 12953 73 57 12944 57 sky130_fd_sc_hd__buf_4
* cell instance $64625 m0 *1 355.12,552.16
X$64625 73 13034 12861 12860 13148 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $64626 m0 *1 356.96,552.16
X$64626 57 12955 13067 12954 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $64630 m0 *1 362.94,552.16
X$64630 73 13872 12563 12384 13239 57 12951 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $64640 m0 *1 392.84,552.16
X$64640 73 13068 73 57 13237 57 sky130_fd_sc_hd__buf_4
* cell instance $64642 m0 *1 396.06,552.16
X$64642 57 12956 12913 7770 73 73 57 sky130_fd_sc_hd__xnor2_2
* cell instance $64645 m0 *1 404.34,552.16
X$64645 73 12815 12566 13068 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64648 m0 *1 407.1,552.16
X$64648 73 12957 12956 13015 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64649 m0 *1 408.48,552.16
X$64649 73 13068 73 57 13138 57 sky130_fd_sc_hd__buf_4
* cell instance $64650 m0 *1 411.24,552.16
X$64650 73 12958 12815 13071 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $64656 m0 *1 419.52,552.16
X$64656 73 12959 73 57 12870 57 sky130_fd_sc_hd__buf_4
* cell instance $64657 m0 *1 422.28,552.16
X$64657 57 15462 12909 12960 12644 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64658 m0 *1 426.88,552.16
X$64658 73 12909 73 57 13074 57 sky130_fd_sc_hd__buf_4
* cell instance $64659 m0 *1 429.64,552.16
X$64659 73 12749 73 57 13374 57 sky130_fd_sc_hd__buf_4
* cell instance $64665 m0 *1 444.36,552.16
X$64665 57 15572 13013 12795 12867 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64666 m0 *1 448.96,552.16
X$64666 73 12378 12608 12902 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64668 m0 *1 450.8,552.16
X$64668 73 12695 12962 12797 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64671 m0 *1 453.56,552.16
X$64671 73 13185 12961 13007 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64672 m0 *1 454.94,552.16
X$64672 73 13077 12964 12798 13006 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64674 m0 *1 457.7,552.16
X$64674 73 12378 12568 12900 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64677 m0 *1 460.46,552.16
X$64677 73 12871 12964 12965 73 13134 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64678 m0 *1 462.3,552.16
X$64678 73 12866 12378 12795 73 12965 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64681 m0 *1 465.52,552.16
X$64681 73 12967 73 57 12961 57 sky130_fd_sc_hd__buf_4
* cell instance $64684 m0 *1 469.66,552.16
X$64684 73 12866 12964 12568 12966 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64686 m0 *1 471.96,552.16
X$64686 57 12695 13131 12496 13003 12966 12872 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $64687 m0 *1 475.18,552.16
X$64687 73 12872 73 57 13070 57 sky130_fd_sc_hd__buf_4
* cell instance $64689 m0 *1 478.4,552.16
X$64689 73 12867 13079 12873 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64701 m0 *1 509.22,552.16
X$64701 73 12877 12212 12969 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64702 m0 *1 510.6,552.16
X$64702 73 12999 12969 12970 73 13083 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64704 m0 *1 512.9,552.16
X$64704 73 12887 13219 12997 12968 13083 73 12753 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $64705 m0 *1 516.12,552.16
X$64705 73 12790 12877 12215 12971 73 12970 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $64706 m0 *1 518.42,552.16
X$64706 73 12219 12972 12675 13085 12974 12971 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $64712 m0 *1 529,552.16
X$64712 73 12417 12196 12201 57 73 12973 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64713 m0 *1 530.84,552.16
X$64713 73 12973 73 57 12975 57 sky130_fd_sc_hd__buf_4
* cell instance $64715 m0 *1 535.44,552.16
X$64715 73 12417 73 57 12974 57 sky130_fd_sc_hd__buf_4
* cell instance $64717 m0 *1 538.66,552.16
X$64717 73 12876 12499 13088 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64718 m0 *1 540.04,552.16
X$64718 73 13088 73 57 12675 57 sky130_fd_sc_hd__buf_4
* cell instance $64721 m0 *1 544.18,552.16
X$64721 73 12989 12993 12285 57 73 12994 57 sky130_fd_sc_hd__a21boi_0
* cell instance $64722 m0 *1 546.94,552.16
X$64722 73 12761 73 57 13089 57 sky130_fd_sc_hd__inv_1
* cell instance $64723 m0 *1 548.32,552.16
X$64723 73 13115 12989 13090 12767 12976 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $64724 m0 *1 551.08,552.16
X$64724 73 12980 12976 12988 73 12887 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64730 m0 *1 559.36,552.16
X$64730 73 12761 73 57 12979 57 sky130_fd_sc_hd__buf_4
* cell instance $64732 m0 *1 565.8,552.16
X$64732 73 12763 13208 12985 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64734 m0 *1 569.02,552.16
X$64734 73 13086 12283 12765 57 73 12766 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64735 m0 *1 570.86,552.16
X$64735 73 12577 13110 12878 73 12977 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64739 m0 *1 575.92,552.16
X$64739 73 13109 73 57 12575 57 sky130_fd_sc_hd__buf_4
* cell instance $64740 m0 *1 578.68,552.16
X$64740 73 13106 13107 13205 12360 12499 73 12213 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $64744 m0 *1 583.74,552.16
X$64744 73 12515 73 57 12978 57 sky130_fd_sc_hd__buf_4
* cell instance $64745 m0 *1 586.5,552.16
X$64745 73 12217 13094 12981 12219 12980 13201 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $64746 m0 *1 589.72,552.16
X$64746 73 12361 12978 12219 73 13094 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64773 r0 *1 5.98,552.16
X$64773 73 13096 57 73 13035 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64775 r0 *1 11.5,552.16
X$64775 73 12773 57 73 13036 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64786 r0 *1 31.74,552.16
X$64786 73 12885 73 57 13101 57 sky130_fd_sc_hd__buf_4
* cell instance $64795 r0 *1 44.62,552.16
X$64795 73 12932 73 57 13037 57 sky130_fd_sc_hd__buf_4
* cell instance $64796 r0 *1 47.38,552.16
X$64796 73 11486 73 57 12928 57 sky130_fd_sc_hd__buf_4
* cell instance $64799 r0 *1 52.44,552.16
X$64799 73 13104 73 57 13105 57 sky130_fd_sc_hd__buf_4
* cell instance $64801 r0 *1 55.66,552.16
X$64801 73 11486 73 57 13038 57 sky130_fd_sc_hd__buf_4
* cell instance $64802 r0 *1 58.42,552.16
X$64802 73 13039 12668 13212 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64803 r0 *1 59.8,552.16
X$64803 73 11834 13038 13039 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64804 r0 *1 61.18,552.16
X$64804 73 13039 11838 13214 57 73 13040 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64805 r0 *1 63.02,552.16
X$64805 73 11838 12593 13040 73 13300 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64816 r0 *1 80.04,552.16
X$64816 73 13041 11705 13100 12791 73 13404 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $64819 r0 *1 84.64,552.16
X$64819 73 11886 73 57 13042 57 sky130_fd_sc_hd__buf_4
* cell instance $64827 r0 *1 97.06,552.16
X$64827 73 13116 13158 11976 73 13041 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64830 r0 *1 99.82,552.16
X$64830 73 13002 73 57 13259 57 sky130_fd_sc_hd__buf_4
* cell instance $64834 r0 *1 109.02,552.16
X$64834 73 13117 11879 13105 57 73 13045 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64838 r0 *1 115.92,552.16
X$64838 73 12342 13044 12040 13120 73 13228 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $64839 r0 *1 118.68,552.16
X$64839 73 13045 14772 13119 13121 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64865 r0 *1 172.96,552.16
X$64865 73 12934 12807 12903 13046 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $64866 r0 *1 174.8,552.16
X$64866 73 12847 13046 13047 57 73 13235 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64867 r0 *1 176.64,552.16
X$64867 73 13048 12814 12601 73 13047 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $64871 r0 *1 178.48,552.16
X$64871 73 13048 73 57 13049 57 sky130_fd_sc_hd__buf_4
* cell instance $64879 r0 *1 192.74,552.16
X$64879 73 12905 12841 13128 13052 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64880 r0 *1 194.58,552.16
X$64880 57 15659 13129 12807 12912 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64892 r0 *1 214.82,552.16
X$64892 73 12601 12841 13051 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64894 r0 *1 216.66,552.16
X$64894 73 13049 13135 13051 57 73 13245 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64895 r0 *1 218.5,552.16
X$64895 73 13050 13135 12812 12848 12482 73 13173 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $64898 r0 *1 224.02,552.16
X$64898 73 13052 13030 13053 13137 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64900 r0 *1 226.32,552.16
X$64900 73 12847 13025 13518 13173 13053 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $64912 r0 *1 246.1,552.16
X$64912 57 13054 12854 12821 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $64914 r0 *1 254.38,552.16
X$64914 73 13054 57 73 14040 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64925 r0 *1 276,552.16
X$64925 73 13055 12563 12940 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64928 r0 *1 282.9,552.16
X$64928 73 12384 13056 13433 13057 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $64929 r0 *1 284.74,552.16
X$64929 57 15625 13141 12563 13055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $64942 r0 *1 306.82,552.16
X$64942 73 13060 73 57 13570 57 sky130_fd_sc_hd__buf_4
* cell instance $64944 r0 *1 313.26,552.16
X$64944 73 13057 12353 13027 57 73 13249 57 sky130_fd_sc_hd__a21oi_1
* cell instance $64950 r0 *1 316.48,552.16
X$64950 73 12943 12736 12923 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $64954 r0 *1 322,552.16
X$64954 57 13144 13063 13061 13247 12941 12736 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $64955 r0 *1 325.22,552.16
X$64955 73 12950 13062 13063 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64957 r0 *1 327.06,552.16
X$64957 57 12830 13145 13024 13242 13243 12562 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $64958 r0 *1 330.28,552.16
X$64958 73 12736 13063 13177 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $64962 r0 *1 334.88,552.16
X$64962 57 13067 12736 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $64966 r0 *1 342.24,552.16
X$64966 73 12945 12711 12563 13064 57 73 13147 57 sky130_fd_sc_hd__a31oi_1
* cell instance $64971 r0 *1 349.6,552.16
X$64971 73 12616 73 57 13064 57 sky130_fd_sc_hd__buf_4
* cell instance $64973 r0 *1 352.82,552.16
X$64973 73 13061 12954 12955 13065 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $64974 r0 *1 355.12,552.16
X$64974 73 13149 12954 12955 13066 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $64975 r0 *1 357.42,552.16
X$64975 73 13066 73 57 12711 57 sky130_fd_sc_hd__buf_4
* cell instance $64976 r0 *1 360.18,552.16
X$64976 73 11942 73 57 13062 57 sky130_fd_sc_hd__buf_4
* cell instance $64983 r0 *1 370.76,552.16
X$64983 57 12822 15442 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $64992 r0 *1 393.3,552.16
X$64992 73 12568 13150 13237 13070 13069 13238 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $64998 r0 *1 399.28,552.16
X$64998 73 12913 7770 73 13236 57 57 sky130_fd_sc_hd__xor2_1
* cell instance $65002 r0 *1 405.72,552.16
X$65002 73 12956 73 57 13329 57 sky130_fd_sc_hd__buf_4
* cell instance $65004 r0 *1 409.4,552.16
X$65004 73 13071 73 57 13069 57 sky130_fd_sc_hd__buf_4
* cell instance $65006 r0 *1 412.62,552.16
X$65006 73 12962 13071 13072 12566 13073 73 13271 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $65007 r0 *1 415.84,552.16
X$65007 73 13015 73 57 12801 57 sky130_fd_sc_hd__buf_4
* cell instance $65010 r0 *1 419.98,552.16
X$65010 73 13018 12870 13234 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65011 r0 *1 421.36,552.16
X$65011 73 12639 73 57 13181 57 sky130_fd_sc_hd__buf_4
* cell instance $65015 r0 *1 424.12,552.16
X$65015 73 12639 73 57 13076 57 sky130_fd_sc_hd__inv_1
* cell instance $65017 r0 *1 425.96,552.16
X$65017 73 12960 73 57 13079 57 sky130_fd_sc_hd__buf_4
* cell instance $65018 r0 *1 428.72,552.16
X$65018 73 13076 12536 13075 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65022 r0 *1 432.86,552.16
X$65022 73 13075 73 57 13078 57 sky130_fd_sc_hd__buf_4
* cell instance $65023 r0 *1 435.62,552.16
X$65023 73 13076 73 57 12795 57 sky130_fd_sc_hd__buf_4
* cell instance $65026 r0 *1 439.76,552.16
X$65026 73 12747 73 57 13077 57 sky130_fd_sc_hd__buf_4
* cell instance $65029 r0 *1 443.9,552.16
X$65029 73 13013 12695 13072 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65032 r0 *1 446.66,552.16
X$65032 73 12798 13140 12496 73 13012 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65034 r0 *1 449.42,552.16
X$65034 73 12964 13074 13183 12695 57 13009 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $65038 r0 *1 452.18,552.16
X$65038 73 12963 12798 13229 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65043 r0 *1 460,552.16
X$65043 73 13226 12685 13134 57 73 13227 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65045 r0 *1 462.3,552.16
X$65045 73 13078 13079 13224 12964 13225 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $65047 r0 *1 465.06,552.16
X$65047 73 12795 73 57 12964 57 sky130_fd_sc_hd__buf_4
* cell instance $65050 r0 *1 473.34,552.16
X$65050 57 13081 13222 13079 13131 12695 13080 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $65051 r0 *1 476.56,552.16
X$65051 73 13081 12606 13187 13127 57 13379 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $65056 r0 *1 479.78,552.16
X$65056 73 13082 12496 12606 13220 57 13187 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $65071 r0 *1 505.54,552.16
X$65071 57 13109 12876 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $65075 r0 *1 518.88,552.16
X$65075 73 13084 12763 13085 57 73 13218 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65076 r0 *1 520.72,552.16
X$65076 73 12376 73 57 13085 57 sky130_fd_sc_hd__buf_4
* cell instance $65078 r0 *1 523.94,552.16
X$65078 73 12217 12281 13086 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65079 r0 *1 525.32,552.16
X$65079 73 12756 73 57 13084 57 sky130_fd_sc_hd__buf_4
* cell instance $65084 r0 *1 531.76,552.16
X$65084 73 12760 12196 12201 57 73 13217 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65085 r0 *1 533.6,552.16
X$65085 73 12760 12196 12201 13087 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $65086 r0 *1 535.44,552.16
X$65086 73 12995 12196 12201 57 73 13188 57 sky130_fd_sc_hd__and3_2
* cell instance $65088 r0 *1 539.12,552.16
X$65088 73 12505 13088 13213 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65090 r0 *1 540.96,552.16
X$65090 73 12975 73 57 12757 57 sky130_fd_sc_hd__buf_4
* cell instance $65093 r0 *1 546.48,552.16
X$65093 73 13089 73 57 13113 57 sky130_fd_sc_hd__buf_4
* cell instance $65094 r0 *1 549.24,552.16
X$65094 73 12210 13114 13113 13090 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $65096 r0 *1 551.54,552.16
X$65096 73 13090 13112 12654 12763 12283 13209 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $65107 r0 *1 569.02,552.16
X$65107 73 12281 13091 12203 12361 13108 73 13110 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $65111 r0 *1 581.44,552.16
X$65111 73 12360 13204 13092 57 73 13205 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65113 r0 *1 585.12,552.16
X$65113 73 13103 12982 12367 13093 73 13092 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $65117 r0 *1 587.88,552.16
X$65117 73 12515 73 57 13097 57 sky130_fd_sc_hd__buf_4
* cell instance $65118 r0 *1 590.64,552.16
X$65118 73 13091 13200 12289 12219 13198 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $65119 r0 *1 593.4,552.16
X$65119 57 13198 13196 12215 13095 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $65152 m0 *1 4.6,557.6
X$65152 73 13252 57 73 12258 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65157 m0 *1 23,557.6
X$65157 73 13292 11955 13151 57 73 13203 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65158 m0 *1 24.84,557.6
X$65158 73 12674 13152 13203 73 57 11681 57 sky130_fd_sc_hd__o21ai_1
* cell instance $65159 m0 *1 26.68,557.6
X$65159 73 13392 13151 11955 13207 57 73 13152 57 sky130_fd_sc_hd__a31oi_1
* cell instance $65163 m0 *1 34.04,557.6
X$65163 73 12119 13153 12834 11800 12674 73 13295 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $65168 m0 *1 46,557.6
X$65168 73 12477 13153 11800 13154 57 73 13104 57 sky130_fd_sc_hd__a31oi_1
* cell instance $65171 m0 *1 50.6,557.6
X$65171 73 13155 13211 13259 13212 57 13210 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $65174 m0 *1 54.28,557.6
X$65174 73 12620 73 57 13153 57 sky130_fd_sc_hd__buf_4
* cell instance $65177 m0 *1 57.96,557.6
X$65177 73 13297 12617 12260 13818 11800 13214 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $65181 m0 *1 67.16,557.6
X$65181 73 13402 73 57 12266 57 sky130_fd_sc_hd__buf_4
* cell instance $65190 m0 *1 87.86,557.6
X$65190 73 13157 13156 12005 73 12679 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65194 m0 *1 96.14,557.6
X$65194 57 13221 13116 12793 13159 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $65195 m0 *1 98.44,557.6
X$65195 73 12043 13657 13159 57 73 13158 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65197 m0 *1 103.96,557.6
X$65197 73 12002 12005 13306 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65212 m0 *1 141.68,557.6
X$65212 57 12807 13160 12812 13230 13262 13309 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $65213 m0 *1 144.9,557.6
X$65213 73 12807 14231 13309 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65216 m0 *1 149.04,557.6
X$65216 73 12812 13262 12910 13161 12841 13231 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $65218 m0 *1 152.72,557.6
X$65218 73 13162 12810 13163 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65219 m0 *1 154.1,557.6
X$65219 73 12847 12810 13232 13163 13164 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $65220 m0 *1 156.86,557.6
X$65220 73 13164 13419 12807 13165 57 73 13233 57 sky130_fd_sc_hd__a31oi_1
* cell instance $65221 m0 *1 159.16,557.6
X$65221 57 13622 13160 12809 12728 13166 13233 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $65224 m0 *1 163.76,557.6
X$65224 73 12807 13263 13167 57 73 13165 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65225 m0 *1 165.6,557.6
X$65225 73 12810 13314 13232 57 73 13167 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65230 m0 *1 172.96,557.6
X$65230 73 13168 13169 12810 12809 57 73 13166 57 sky130_fd_sc_hd__a31oi_1
* cell instance $65231 m0 *1 175.26,557.6
X$65231 73 13046 73 57 13169 57 sky130_fd_sc_hd__buf_4
* cell instance $65235 m0 *1 184.46,557.6
X$65235 57 13019 13162 13161 12807 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $65239 m0 *1 194.12,557.6
X$65239 73 12843 12852 13240 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65241 m0 *1 195.96,557.6
X$65241 57 12809 12819 13170 13240 13241 13172 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $65245 m0 *1 202.4,557.6
X$65245 73 12391 12812 13318 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65247 m0 *1 207.46,557.6
X$65247 73 12841 12687 13319 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65250 m0 *1 211.6,557.6
X$65250 57 13320 13319 12841 12729 13170 12848 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $65251 m0 *1 214.82,557.6
X$65251 73 13431 13171 13245 12847 12848 13322 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $65252 m0 *1 218.04,557.6
X$65252 73 13246 12601 13172 57 73 13171 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65253 m0 *1 219.88,557.6
X$65253 73 12244 73 57 13135 57 sky130_fd_sc_hd__buf_4
* cell instance $65272 m0 *1 268.64,557.6
X$65272 73 12616 13056 13174 13325 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $65274 m0 *1 270.94,557.6
X$65274 73 13326 73 57 12561 57 sky130_fd_sc_hd__buf_4
* cell instance $65282 m0 *1 293.48,557.6
X$65282 57 13251 13331 13061 12736 13055 12633 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $65283 m0 *1 296.7,557.6
X$65283 73 13758 13142 12857 13175 73 13250 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $65284 m0 *1 299.46,557.6
X$65284 73 12736 13175 13176 57 73 13174 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65289 m0 *1 307.28,557.6
X$65289 73 12943 12632 13176 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65293 m0 *1 319.7,557.6
X$65293 73 13248 73 57 13247 57 sky130_fd_sc_hd__buf_4
* cell instance $65296 m0 *1 324.76,557.6
X$65296 73 13337 12563 13244 13247 57 13243 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $65297 m0 *1 327.52,557.6
X$65297 73 12943 12563 13244 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65304 m0 *1 345,557.6
X$65304 73 13540 73 57 13242 57 sky130_fd_sc_hd__buf_4
* cell instance $65308 m0 *1 353.74,557.6
X$65308 73 13149 73 57 13034 57 sky130_fd_sc_hd__buf_4
* cell instance $65309 m0 *1 356.5,557.6
X$65309 73 11472 73 57 13335 57 sky130_fd_sc_hd__buf_4
* cell instance $65310 m0 *1 359.26,557.6
X$65310 73 12353 12384 13333 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65315 m0 *1 364.32,557.6
X$65315 73 12563 13332 12711 57 73 13239 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65318 m0 *1 370.76,557.6
X$65318 57 11727 12822 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $65330 m0 *1 403.42,557.6
X$65330 73 13236 73 57 13179 57 sky130_fd_sc_hd__buf_4
* cell instance $65331 m0 *1 406.18,557.6
X$65331 73 12957 13236 13180 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65332 m0 *1 407.56,557.6
X$65332 73 12957 73 57 13328 57 sky130_fd_sc_hd__buf_4
* cell instance $65333 m0 *1 410.32,557.6
X$65333 73 13180 73 57 12799 57 sky130_fd_sc_hd__buf_4
* cell instance $65340 m0 *1 419.06,557.6
X$65340 73 13274 13181 12962 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65341 m0 *1 420.44,557.6
X$65341 73 13076 73 57 12958 57 sky130_fd_sc_hd__buf_4
* cell instance $65342 m0 *1 423.2,557.6
X$65342 73 13018 13182 12961 73 13275 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65345 m0 *1 426.42,557.6
X$65345 73 12536 73 57 13182 57 sky130_fd_sc_hd__buf_4
* cell instance $65352 m0 *1 446.2,557.6
X$65352 73 12695 13140 13415 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65353 m0 *1 447.58,557.6
X$65353 73 12902 73 57 13185 57 sky130_fd_sc_hd__buf_4
* cell instance $65355 m0 *1 450.8,557.6
X$65355 73 12871 12964 13183 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65359 m0 *1 455.4,557.6
X$65359 73 13179 13510 12691 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65360 m0 *1 456.78,557.6
X$65360 57 13226 12752 13186 13185 12695 13184 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $65367 m0 *1 473.8,557.6
X$65367 57 13280 13222 13223 12752 12568 12644 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $65380 m0 *1 515.2,557.6
X$65380 57 12877 13219 12414 13313 13395 13311 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $65381 m0 *1 518.42,557.6
X$65381 73 13218 73 57 13310 57 sky130_fd_sc_hd__buf_4
* cell instance $65387 m0 *1 531.3,557.6
X$65387 73 13217 73 57 13216 57 sky130_fd_sc_hd__buf_4
* cell instance $65390 m0 *1 536.36,557.6
X$65390 73 12995 73 57 13189 57 sky130_fd_sc_hd__buf_4
* cell instance $65391 m0 *1 539.12,557.6
X$65391 57 12210 13202 12360 12499 13215 13190 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $65392 m0 *1 542.34,557.6
X$65392 73 13213 13191 13114 73 13190 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65393 m0 *1 544.18,557.6
X$65393 73 13192 73 57 12285 57 sky130_fd_sc_hd__buf_4
* cell instance $65394 m0 *1 546.94,557.6
X$65394 73 12376 73 57 13114 57 sky130_fd_sc_hd__buf_4
* cell instance $65401 m0 *1 559.82,557.6
X$65401 73 12754 12418 13108 12975 57 13298 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $65405 m0 *1 569.02,557.6
X$65405 73 12360 12499 13208 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65408 m0 *1 575.92,557.6
X$65408 73 11115 73 57 12881 57 sky130_fd_sc_hd__buf_4
* cell instance $65409 m0 *1 578.68,557.6
X$65409 73 12204 12881 13193 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65410 m0 *1 580.06,557.6
X$65410 73 13206 13193 12361 73 13204 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65413 m0 *1 583.28,557.6
X$65413 73 13387 73 57 13093 57 sky130_fd_sc_hd__buf_4
* cell instance $65415 m0 *1 586.96,557.6
X$65415 73 13194 13093 13108 73 13195 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65416 m0 *1 588.8,557.6
X$65416 57 13201 13199 13389 13202 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $65417 m0 *1 591.1,557.6
X$65417 73 12993 13097 13195 73 13200 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65418 m0 *1 592.94,557.6
X$65418 73 13481 13196 13596 13199 57 13197 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $65453 r0 *1 23,557.6
X$65453 73 11955 13253 13703 13292 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $65454 r0 *1 24.84,557.6
X$65454 73 11834 12793 11800 12000 13391 13151 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $65457 r0 *1 30.36,557.6
X$65457 73 12478 12837 13344 13253 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $65458 r0 *1 32.2,557.6
X$65458 73 12513 73 57 12335 57 sky130_fd_sc_hd__buf_4
* cell instance $65467 r0 *1 46.46,557.6
X$65467 73 12056 13037 13254 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65470 r0 *1 51.98,557.6
X$65470 73 11800 13256 12617 13255 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $65471 r0 *1 54.74,557.6
X$65471 73 13399 13153 11800 13255 57 73 13111 57 sky130_fd_sc_hd__a31oi_1
* cell instance $65473 r0 *1 57.96,557.6
X$65473 73 12053 11800 13297 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65475 r0 *1 63.02,557.6
X$65475 73 12617 73 57 13257 57 sky130_fd_sc_hd__buf_4
* cell instance $65482 r0 *1 73.14,557.6
X$65482 73 13300 73 57 13717 57 sky130_fd_sc_hd__buf_4
* cell instance $65483 r0 *1 75.9,557.6
X$65483 73 12264 11799 13257 57 73 13303 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65484 r0 *1 77.74,557.6
X$65484 73 12177 13303 13258 12888 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $65487 r0 *1 81.88,557.6
X$65487 73 11799 12335 12932 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65492 r0 *1 95.22,557.6
X$65492 73 13118 12091 13159 13221 12116 13260 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $65497 r0 *1 100.28,557.6
X$65497 73 12264 11799 13159 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65500 r0 *1 103.96,557.6
X$65500 57 13305 12836 13261 12179 13306 12043 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $65502 r0 *1 107.64,557.6
X$65502 73 12043 11834 13307 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65526 r0 *1 166.06,557.6
X$65526 73 13162 12687 13263 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65529 r0 *1 172.96,557.6
X$65529 57 12809 13315 13051 13316 13235 12814 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $65530 r0 *1 176.18,557.6
X$65530 73 12812 13425 13316 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65531 r0 *1 177.56,557.6
X$65531 73 13314 12910 13241 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65541 r0 *1 197.8,557.6
X$65541 57 13241 12853 13318 13317 12936 13264 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $65548 r0 *1 211.6,557.6
X$65548 57 13265 13132 12729 12605 13320 13322 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $65549 r0 *1 214.82,557.6
X$65549 73 13162 73 57 13170 57 sky130_fd_sc_hd__buf_4
* cell instance $65550 r0 *1 217.58,557.6
X$65550 73 13246 12807 13050 57 73 13323 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65573 r0 *1 270.02,557.6
X$65573 73 13325 13327 13750 57 73 13326 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65576 r0 *1 274.62,557.6
X$65576 73 13062 12563 12948 57 73 13751 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65590 r0 *1 308.66,557.6
X$65590 73 12944 13176 13267 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65594 r0 *1 314.18,557.6
X$65594 73 13178 13266 13267 13064 12741 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $65595 r0 *1 316.94,557.6
X$65595 73 12158 12384 13248 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65602 r0 *1 328.44,557.6
X$65602 73 13338 12736 13269 12632 13339 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $65606 r0 *1 337.64,557.6
X$65606 73 13178 12944 12945 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65611 r0 *1 344.08,557.6
X$65611 73 13065 13370 13340 12563 13064 73 13059 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $65613 r0 *1 347.76,557.6
X$65613 57 13340 13270 13067 13269 12632 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $65614 r0 *1 351.44,557.6
X$65614 73 13148 73 57 13269 57 sky130_fd_sc_hd__buf_4
* cell instance $65615 r0 *1 354.2,557.6
X$65615 73 11472 73 57 13336 57 sky130_fd_sc_hd__inv_1
* cell instance $65617 r0 *1 356.5,557.6
X$65617 57 13149 13270 11942 13335 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $65618 r0 *1 361.1,557.6
X$65618 73 13333 73 57 13334 57 sky130_fd_sc_hd__buf_4
* cell instance $65633 r0 *1 396.98,557.6
X$65633 57 15608 13330 12958 12644 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $65639 r0 *1 410.78,557.6
X$65639 73 13271 73 57 13272 57 sky130_fd_sc_hd__buf_4
* cell instance $65641 r0 *1 414,557.6
X$65641 73 12536 73 57 13375 57 sky130_fd_sc_hd__buf_4
* cell instance $65643 r0 *1 417.22,557.6
X$65643 73 13076 12536 13273 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65644 r0 *1 418.6,557.6
X$65644 73 12959 13273 13276 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65647 r0 *1 423.66,557.6
X$65647 57 15595 13278 12960 12644 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $65648 r0 *1 428.26,557.6
X$65648 73 13181 12536 13277 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65653 r0 *1 432.86,557.6
X$65653 73 13277 73 57 13324 57 sky130_fd_sc_hd__buf_4
* cell instance $65654 r0 *1 435.62,557.6
X$65654 73 13276 73 57 13184 57 sky130_fd_sc_hd__buf_4
* cell instance $65659 r0 *1 445.28,557.6
X$65659 57 13140 13278 13321 12795 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $65663 r0 *1 450.34,557.6
X$65663 73 13183 12695 13280 13279 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $65669 r0 *1 463.68,557.6
X$65669 73 13138 73 57 13224 57 sky130_fd_sc_hd__buf_4
* cell instance $65671 r0 *1 470.12,557.6
X$65671 73 13079 12568 13223 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65672 r0 *1 471.5,557.6
X$65672 73 12644 12795 13281 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65673 r0 *1 472.88,557.6
X$65673 73 13281 73 57 13280 57 sky130_fd_sc_hd__buf_4
* cell instance $65677 r0 *1 478.4,557.6
X$65677 73 12795 12496 13080 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65694 r0 *1 516.12,557.6
X$65694 73 12499 13312 13283 73 13313 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $65695 r0 *1 518.88,557.6
X$65695 73 12877 13499 13282 13311 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $65698 r0 *1 525.32,557.6
X$65698 73 12654 12681 12515 12878 13283 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $65703 r0 *1 533.6,557.6
X$65703 73 13284 12763 13308 57 73 13215 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65704 r0 *1 535.44,557.6
X$65704 73 12581 13308 13284 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65705 r0 *1 536.82,557.6
X$65705 73 12210 13215 13285 12499 13282 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $65709 r0 *1 541.42,557.6
X$65709 73 12281 12754 13192 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65711 r0 *1 543.72,557.6
X$65711 73 12876 13286 13287 57 73 13191 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65712 r0 *1 545.56,557.6
X$65712 73 12420 12219 13287 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65713 r0 *1 546.94,557.6
X$65713 73 12754 13089 13288 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65715 r0 *1 549.24,557.6
X$65715 73 12756 13288 12210 73 13302 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65716 r0 *1 551.08,557.6
X$65716 73 13302 73 57 13285 57 sky130_fd_sc_hd__buf_4
* cell instance $65721 r0 *1 560.28,557.6
X$65721 73 13091 12504 13301 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65730 r0 *1 577.3,557.6
X$65730 73 13296 13206 12210 73 13107 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65734 r0 *1 582.36,557.6
X$65734 73 12506 12203 13289 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65735 r0 *1 583.74,557.6
X$65735 73 13289 73 57 13103 57 sky130_fd_sc_hd__buf_4
* cell instance $65737 r0 *1 586.5,557.6
X$65737 57 13208 13291 12212 13293 13290 13294 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $65738 r0 *1 589.72,557.6
X$65738 73 12203 12880 13108 13390 57 13290 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $65820 m0 *1 9.2,563.04
X$65820 73 13341 57 73 11634 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65825 m0 *1 24.38,563.04
X$65825 73 11800 13342 13391 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65827 m0 *1 26.68,563.04
X$65827 73 13343 73 57 13342 57 sky130_fd_sc_hd__buf_4
* cell instance $65831 m0 *1 31.28,563.04
X$65831 73 11800 13156 13344 13393 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $65836 m0 *1 41.86,563.04
X$65836 73 11833 12002 11800 57 73 13394 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65839 m0 *1 45.08,563.04
X$65839 73 11834 13394 12307 13345 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $65840 m0 *1 46.92,563.04
X$65840 73 12928 13346 13345 13211 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $65844 m0 *1 55.2,563.04
X$65844 73 12335 12293 13399 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $65847 m0 *1 58.42,563.04
X$65847 73 12478 12260 13399 14359 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $65850 m0 *1 64.4,563.04
X$65850 73 13304 13254 13348 57 73 57 sky130_fd_sc_hd__or2_0
* cell instance $65851 m0 *1 66.7,563.04
X$65851 73 13401 12674 13348 57 73 13402 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65853 m0 *1 69,563.04
X$65853 73 13349 73 57 12026 57 sky130_fd_sc_hd__buf_4
* cell instance $65858 m0 *1 78.66,563.04
X$65858 73 13403 73 57 12836 57 sky130_fd_sc_hd__buf_4
* cell instance $65859 m0 *1 81.42,563.04
X$65859 57 11705 13406 11641 13407 13408 13404 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $65864 m0 *1 91.08,563.04
X$65864 73 13349 12836 12002 73 13493 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65866 m0 *1 94.76,563.04
X$65866 73 13305 12179 13260 57 73 13409 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65876 m0 *1 114.54,563.04
X$65876 73 11799 12342 12179 13350 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $65877 m0 *1 116.38,563.04
X$65877 73 13350 11799 13307 57 73 13412 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65887 m0 *1 143.06,563.04
X$65887 73 13161 13351 13230 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65889 m0 *1 145.36,563.04
X$65889 73 13162 13445 12687 13417 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $65890 m0 *1 147.2,563.04
X$65890 73 12812 13417 13353 57 73 13352 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65891 m0 *1 149.04,563.04
X$65891 73 13354 13351 13420 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65893 m0 *1 150.88,563.04
X$65893 73 13355 13352 13123 73 13418 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65896 m0 *1 155.48,563.04
X$65896 73 13351 13445 13420 13357 12812 73 13422 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $65897 m0 *1 158.7,563.04
X$65897 73 12244 73 57 13232 57 sky130_fd_sc_hd__buf_4
* cell instance $65899 m0 *1 162.38,563.04
X$65899 73 13162 12807 13358 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65905 m0 *1 172.96,563.04
X$65905 73 13356 12852 13168 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65908 m0 *1 175.72,563.04
X$65908 73 13232 13358 13314 13172 73 13425 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $65909 m0 *1 178.48,563.04
X$65909 73 13358 73 57 13125 57 sky130_fd_sc_hd__buf_4
* cell instance $65912 m0 *1 186.76,563.04
X$65912 57 12482 12457 13428 13265 13505 13426 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $65917 m0 *1 196.42,563.04
X$65917 73 13559 73 57 13427 57 sky130_fd_sc_hd__buf_4
* cell instance $65918 m0 *1 199.18,563.04
X$65918 73 12841 13359 13448 13317 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $65921 m0 *1 203.78,563.04
X$65921 73 12912 12910 13360 57 73 13361 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65923 m0 *1 207.46,563.04
X$65923 73 13359 13361 12848 73 13431 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65927 m0 *1 214.36,563.04
X$65927 73 13162 13135 13432 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65930 m0 *1 218.04,563.04
X$65930 73 12601 12687 13246 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65950 m0 *1 273.7,563.04
X$65950 73 13034 13362 13452 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $65951 m0 *1 275.08,563.04
X$65951 73 13142 12948 13526 12563 12353 73 13754 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $65954 m0 *1 279.22,563.04
X$65954 73 12736 73 57 13362 57 sky130_fd_sc_hd__buf_4
* cell instance $65957 m0 *1 284.28,563.04
X$65957 73 13362 13364 13365 57 73 13433 57 sky130_fd_sc_hd__a21oi_1
* cell instance $65958 m0 *1 286.12,563.04
X$65958 73 12943 12563 13365 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $65959 m0 *1 287.5,563.04
X$65959 73 13362 13367 13364 12917 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $65962 m0 *1 293.94,563.04
X$65962 73 13055 13062 12563 13367 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $65976 m0 *1 327.98,563.04
X$65976 73 13338 13266 13327 73 13430 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $65982 m0 *1 343.16,563.04
X$65982 73 13335 73 57 12950 57 sky130_fd_sc_hd__buf_4
* cell instance $65983 m0 *1 345.92,563.04
X$65983 57 15540 13178 13369 13336 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $65984 m0 *1 350.52,563.04
X$65984 73 13336 73 57 13055 57 sky130_fd_sc_hd__buf_4
* cell instance $65986 m0 *1 355.12,563.04
X$65986 73 12953 13270 12716 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $65988 m0 *1 357.88,563.04
X$65988 73 13066 13370 13239 12563 13334 73 13537 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $65990 m0 *1 361.56,563.04
X$65990 73 11942 57 73 13369 57 sky130_fd_sc_hd__inv_2
* cell instance $66001 m0 *1 393.76,563.04
X$66001 57 15466 13424 12958 12862 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $66002 m0 *1 398.36,563.04
X$66002 73 12644 13375 13150 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66005 m0 *1 404.34,563.04
X$66005 73 13372 12750 12958 57 73 13421 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66006 m0 *1 406.18,563.04
X$66006 57 13423 13374 13330 13373 13421 13372 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $66009 m0 *1 412.16,563.04
X$66009 73 13273 73 57 13790 57 sky130_fd_sc_hd__buf_4
* cell instance $66016 m0 *1 419.98,563.04
X$66016 73 13321 73 57 13274 57 sky130_fd_sc_hd__buf_4
* cell instance $66017 m0 *1 422.74,563.04
X$66017 57 15531 13321 12960 12867 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $66020 m0 *1 432.86,563.04
X$66020 57 13416 13517 12378 13180 13414 12568 73 73 57
+ sky130_fd_sc_hd__a2111oi_1
* cell instance $66026 m0 *1 445.74,563.04
X$66026 73 12568 13415 13376 57 73 13414 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66028 m0 *1 448.04,563.04
X$66028 73 13321 73 57 13186 57 sky130_fd_sc_hd__buf_4
* cell instance $66031 m0 *1 455.4,563.04
X$66031 73 13377 13378 13859 57 73 12200 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66033 m0 *1 457.7,563.04
X$66033 73 13413 12606 13508 13227 73 13378 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $66036 m0 *1 461.38,563.04
X$66036 57 12378 13377 13410 13179 13379 13411 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $66043 m0 *1 472.88,563.04
X$66043 73 12798 13466 13281 13376 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66047 m0 *1 480.7,563.04
X$66047 73 13502 73 57 13382 57 sky130_fd_sc_hd__buf_4
* cell instance $66061 m0 *1 517.5,563.04
X$66061 73 12788 12210 13913 57 73 13312 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66062 m0 *1 519.34,563.04
X$66062 73 13384 73 57 13405 57 sky130_fd_sc_hd__buf_4
* cell instance $66067 m0 *1 528.08,563.04
X$66067 73 12754 73 57 13308 57 sky130_fd_sc_hd__buf_4
* cell instance $66073 m0 *1 543.26,563.04
X$66073 73 13400 73 57 13286 57 sky130_fd_sc_hd__buf_4
* cell instance $66075 m0 *1 547.86,563.04
X$66075 57 13398 12756 12763 12217 12210 13114 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $66082 m0 *1 557.52,563.04
X$66082 73 13385 73 57 12515 57 sky130_fd_sc_hd__buf_4
* cell instance $66086 m0 *1 565.34,563.04
X$66086 73 13396 73 57 13395 57 sky130_fd_sc_hd__buf_4
* cell instance $66091 m0 *1 575,563.04
X$66091 73 12420 12203 13386 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66092 m0 *1 576.38,563.04
X$66092 73 13386 73 57 13206 57 sky130_fd_sc_hd__buf_4
* cell instance $66093 m0 *1 579.14,563.04
X$66093 73 13206 13387 13108 73 13299 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66097 m0 *1 583.28,563.04
X$66097 73 12204 13388 13387 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66100 m0 *1 586.04,563.04
X$66100 73 13388 12581 12881 13216 57 13293 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $66103 m0 *1 590.18,563.04
X$66103 73 13188 73 57 13390 57 sky130_fd_sc_hd__buf_4
* cell instance $66128 r0 *1 5.98,563.04
X$66128 73 13098 57 73 13482 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66130 r0 *1 10.12,563.04
X$66130 73 11420 57 73 13483 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66139 r0 *1 23.92,563.04
X$66139 73 12478 13343 13435 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66140 r0 *1 25.3,563.04
X$66140 73 12399 13435 13437 73 13392 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66142 r0 *1 27.6,563.04
X$66142 73 12336 13436 13343 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66143 r0 *1 28.98,563.04
X$66143 73 12053 13436 12837 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66145 r0 *1 30.82,563.04
X$66145 73 12397 12513 13403 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66146 r0 *1 32.2,563.04
X$66146 73 12513 73 57 13546 57 sky130_fd_sc_hd__buf_4
* cell instance $66150 r0 *1 40.02,563.04
X$66150 73 12674 12478 11833 13343 13440 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $66158 r0 *1 45.54,563.04
X$66158 73 13102 13441 11800 13440 57 73 13346 57 sky130_fd_sc_hd__a31oi_1
* cell instance $66173 r0 *1 74.06,563.04
X$66173 73 13441 73 57 13488 57 sky130_fd_sc_hd__buf_4
* cell instance $66175 r0 *1 77.28,563.04
X$66175 73 12674 13257 13488 73 13554 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66178 r0 *1 81.88,563.04
X$66178 73 13406 73 57 13489 57 sky130_fd_sc_hd__buf_4
* cell instance $66179 r0 *1 84.64,563.04
X$66179 73 13491 13492 11834 13490 57 13407 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $66183 r0 *1 90.16,563.04
X$66183 73 11879 13221 13493 57 73 13492 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66186 r0 *1 93.38,563.04
X$66186 73 13409 73 57 13601 57 sky130_fd_sc_hd__buf_4
* cell instance $66194 r0 *1 103.04,563.04
X$66194 73 13494 11799 12342 13043 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66197 r0 *1 109.02,563.04
X$66197 73 12040 13659 13443 73 12234 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66198 r0 *1 110.86,563.04
X$66198 73 12264 11879 12002 73 13443 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66201 r0 *1 116.84,563.04
X$66201 73 13494 13412 13497 73 12891 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66214 r0 *1 142.6,563.04
X$66214 73 12807 13230 13262 13444 73 57 13931 57 sky130_fd_sc_hd__o31ai_1
* cell instance $66217 r0 *1 147.66,563.04
X$66217 73 13354 13351 13353 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66218 r0 *1 149.04,563.04
X$66218 73 13162 13445 13351 13444 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $66223 r0 *1 152.26,563.04
X$66223 73 13446 13351 13501 73 13500 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66225 r0 *1 154.56,563.04
X$66225 73 12687 13358 13356 12807 73 13501 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $66226 r0 *1 157.78,563.04
X$66226 73 13357 12687 13419 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66227 r0 *1 159.16,563.04
X$66227 73 13500 12812 12809 13422 57 13504 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $66230 r0 *1 164.68,563.04
X$66230 73 12605 12627 12809 13503 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66244 r0 *1 194.12,563.04
X$66244 73 12905 12910 14149 12809 13447 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $66245 r0 *1 196.88,563.04
X$66245 73 12809 13509 13447 12482 13021 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $66248 r0 *1 201.02,563.04
X$66248 73 12934 12687 13360 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66251 r0 *1 204.7,563.04
X$66251 73 13170 13130 13450 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66255 r0 *1 206.08,563.04
X$66255 73 13450 13360 12852 12934 12912 13514 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $66259 r0 *1 213.9,563.04
X$66259 73 13161 13323 13515 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66261 r0 *1 217.12,563.04
X$66261 73 13170 12852 13516 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66264 r0 *1 220.8,563.04
X$66264 73 13246 13451 12841 12809 13518 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $66265 r0 *1 223.56,563.04
X$66265 57 12812 13519 13170 13246 13520 13172 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $66289 r0 *1 270.48,563.04
X$66289 73 12616 13452 13363 13362 73 13525 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $66293 r0 *1 276.46,563.04
X$66293 73 12563 13429 13452 13526 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $66301 r0 *1 287.04,563.04
X$66301 73 13365 13366 13362 13453 57 73 13530 57 sky130_fd_sc_hd__a31oi_1
* cell instance $66302 r0 *1 289.34,563.04
X$66302 73 13370 13331 13535 73 13453 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66311 r0 *1 308.66,563.04
X$66311 73 13055 12632 13366 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66312 r0 *1 310.04,563.04
X$66312 73 12353 13456 13536 13455 73 57 12738 57 sky130_fd_sc_hd__o31ai_1
* cell instance $66321 r0 *1 320.16,563.04
X$66321 57 13539 13368 12563 12945 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $66322 r0 *1 322.46,563.04
X$66322 73 13368 12353 12632 13337 73 13538 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $66323 r0 *1 325.68,563.04
X$66323 73 13458 13338 12944 57 73 13337 57 sky130_fd_sc_hd__a21boi_0
* cell instance $66324 r0 *1 328.44,563.04
X$66324 73 12945 13458 12563 13430 57 73 13459 57 sky130_fd_sc_hd__a31oi_1
* cell instance $66325 r0 *1 330.74,563.04
X$66325 57 12562 13541 12384 13459 13542 13460 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $66328 r0 *1 335.34,563.04
X$66328 73 13055 13067 13458 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66329 r0 *1 336.72,563.04
X$66329 73 12563 13065 12740 13755 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66338 r0 *1 347.76,563.04
X$66338 73 13461 12944 13429 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66339 r0 *1 349.14,563.04
X$66339 73 12563 13429 13177 13749 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $66341 r0 *1 351.9,563.04
X$66341 73 13461 73 57 13061 57 sky130_fd_sc_hd__buf_4
* cell instance $66343 r0 *1 358.34,563.04
X$66343 73 13537 73 57 13268 57 sky130_fd_sc_hd__buf_4
* cell instance $66359 r0 *1 394.68,563.04
X$66359 73 12566 12450 13424 13462 57 73 13534 57 sky130_fd_sc_hd__a31oi_1
* cell instance $66363 r0 *1 396.98,563.04
X$66363 73 12568 13534 13532 57 73 13531 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66364 r0 *1 398.82,563.04
X$66364 73 13374 13371 12566 13373 57 13462 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $66369 r0 *1 405.72,563.04
X$66369 57 13529 13463 13423 13528 12608 13328 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $66373 r0 *1 414,563.04
X$66373 73 12608 13524 13527 13382 13073 73 13463 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $66374 r0 *1 417.22,563.04
X$66374 73 12606 73 57 13524 57 sky130_fd_sc_hd__buf_4
* cell instance $66375 r0 *1 419.98,563.04
X$66375 73 13321 12958 13375 13523 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66376 r0 *1 421.82,563.04
X$66376 57 15649 13522 12960 12867 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $66383 r0 *1 431.48,563.04
X$66383 73 13076 73 57 13521 57 sky130_fd_sc_hd__buf_4
* cell instance $66384 r0 *1 434.24,563.04
X$66384 73 13464 13276 13465 13278 12866 13517 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $66385 r0 *1 437.46,563.04
X$66385 73 13016 13324 13464 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66394 r0 *1 452.18,563.04
X$66394 73 13185 13229 13512 57 73 13511 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66401 r0 *1 467.82,563.04
X$66401 73 13380 13507 13506 73 12651 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66404 r0 *1 471.96,563.04
X$66404 73 13079 12645 13466 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66405 r0 *1 473.34,563.04
X$66405 73 13466 73 57 13725 57 sky130_fd_sc_hd__buf_4
* cell instance $66410 r0 *1 477.94,563.04
X$66410 73 12867 12795 13381 57 73 13380 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66413 r0 *1 482.54,563.04
X$66413 73 12751 13324 13467 12798 73 13502 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $66430 r0 *1 515.66,563.04
X$66430 73 13383 73 57 13499 57 sky130_fd_sc_hd__buf_4
* cell instance $66432 r0 *1 518.88,563.04
X$66432 73 13397 73 57 13614 57 sky130_fd_sc_hd__buf_4
* cell instance $66434 r0 *1 522.1,563.04
X$66434 73 13468 73 57 12654 57 sky130_fd_sc_hd__buf_4
* cell instance $66436 r0 *1 525.32,563.04
X$66436 73 12876 13308 13468 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66439 r0 *1 529,563.04
X$66439 73 13216 12880 13308 57 73 13498 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66444 r0 *1 531.76,563.04
X$66444 73 13301 13589 13469 13496 12217 12416 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $66445 r0 *1 534.98,563.04
X$66445 73 12763 12654 13603 73 13469 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66446 r0 *1 536.82,563.04
X$66446 57 13612 12361 13471 11115 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $66448 r0 *1 540.96,563.04
X$66448 73 12993 12281 13400 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66449 r0 *1 542.34,563.04
X$66449 73 12876 12204 12219 57 73 13609 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66451 r0 *1 545.1,563.04
X$66451 73 13189 73 57 13471 57 sky130_fd_sc_hd__buf_4
* cell instance $66452 r0 *1 547.86,563.04
X$66452 73 12376 13189 13479 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $66453 r0 *1 550.16,563.04
X$66453 73 12219 13398 12217 13302 13487 13486 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $66459 r0 *1 558.44,563.04
X$66459 57 13472 13714 13389 13486 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $66462 r0 *1 562.12,563.04
X$66462 73 11115 12203 13385 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66463 r0 *1 563.5,563.04
X$66463 73 13109 13485 13288 14015 73 57 13473 57 sky130_fd_sc_hd__o31ai_1
* cell instance $66464 r0 *1 566.26,563.04
X$66464 73 13474 12217 13473 57 73 13397 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66469 r0 *1 575,563.04
X$66469 73 13386 73 57 13485 57 sky130_fd_sc_hd__buf_4
* cell instance $66472 r0 *1 583.28,563.04
X$66472 73 13484 13476 13475 12203 12217 73 13474 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $66476 r0 *1 586.5,563.04
X$66476 73 12420 12881 13476 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66477 r0 *1 587.88,563.04
X$66477 73 13476 73 57 13478 57 sky130_fd_sc_hd__buf_4
* cell instance $66478 r0 *1 590.64,563.04
X$66478 73 13291 12219 14210 57 73 13481 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66515 m0 *1 5.52,568.48
X$66515 73 13647 57 73 11373 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66520 m0 *1 20.7,568.48
X$66520 73 12775 13438 12478 73 13543 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66522 m0 *1 24.38,568.48
X$66522 73 13600 73 57 12377 57 sky130_fd_sc_hd__buf_4
* cell instance $66523 m0 *1 27.14,568.48
X$66523 73 12399 13545 11800 73 13437 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66527 m0 *1 30.82,568.48
X$66527 73 13438 73 57 13545 57 sky130_fd_sc_hd__buf_4
* cell instance $66528 m0 *1 33.58,568.48
X$66528 73 12053 13546 13438 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66529 m0 *1 34.96,568.48
X$66529 73 13547 73 57 13344 57 sky130_fd_sc_hd__buf_4
* cell instance $66530 m0 *1 37.72,568.48
X$66530 73 13438 73 57 13439 57 sky130_fd_sc_hd__buf_4
* cell instance $66531 m0 *1 40.48,568.48
X$66531 73 11800 13548 13547 13154 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $66534 m0 *1 45.08,568.48
X$66534 73 13549 73 57 13548 57 sky130_fd_sc_hd__buf_4
* cell instance $66536 m0 *1 48.3,568.48
X$66536 73 12293 12623 13549 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66540 m0 *1 52.9,568.48
X$66540 73 11800 12620 12991 13551 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66545 m0 *1 59.8,568.48
X$66545 57 12674 13401 11641 13766 13604 13038 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $66546 m0 *1 63.02,568.48
X$66546 73 13546 12336 13606 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $66547 m0 *1 65.32,568.48
X$66547 73 11800 13606 13552 57 73 13604 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66549 m0 *1 67.62,568.48
X$66549 73 12057 12623 13552 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66550 m0 *1 69,568.48
X$66550 73 11800 13549 13439 13304 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $66554 m0 *1 76.82,568.48
X$66554 73 13610 13439 12723 57 73 13442 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66555 m0 *1 78.66,568.48
X$66555 73 13553 73 57 12156 57 sky130_fd_sc_hd__buf_4
* cell instance $66558 m0 *1 83.72,568.48
X$66558 73 11799 13442 13490 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66571 m0 *1 113.62,568.48
X$66571 73 13769 13494 11975 11955 13495 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $66574 m0 *1 117.3,568.48
X$66574 73 13617 11799 13554 57 73 13497 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66585 m0 *1 142.14,568.48
X$66585 73 12689 13351 13128 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66589 m0 *1 151.34,568.48
X$66589 73 12841 73 57 13445 57 sky130_fd_sc_hd__buf_4
* cell instance $66600 m0 *1 183.08,568.48
X$66600 73 13556 12807 13558 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66601 m0 *1 184.46,568.48
X$66601 57 12851 13628 13558 13625 13125 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $66602 m0 *1 187.68,568.48
X$66602 73 13626 13504 12391 13629 57 13505 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $66607 m0 *1 199.64,568.48
X$66607 73 13357 13232 13448 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66610 m0 *1 202.4,568.48
X$66610 73 12729 13560 13631 73 13449 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66611 m0 *1 204.24,568.48
X$66611 73 12809 12729 13561 57 73 13631 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66612 m0 *1 206.08,568.48
X$66612 73 13562 13633 13449 12732 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66613 m0 *1 207.92,568.48
X$66613 73 12605 12627 13562 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66617 m0 *1 217.58,568.48
X$66617 73 12847 12687 13563 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66619 m0 *1 219.88,568.48
X$66619 73 12912 12244 13564 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66623 m0 *1 224.48,568.48
X$66623 73 13637 13519 12809 73 13633 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66640 m0 *1 269.1,568.48
X$66640 73 12616 13565 13643 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66644 m0 *1 276.92,568.48
X$66644 73 13338 12941 13642 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66649 m0 *1 285.2,568.48
X$66649 73 12487 11790 13565 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66652 m0 *1 290.72,568.48
X$66652 73 13565 73 57 13454 57 sky130_fd_sc_hd__buf_4
* cell instance $66653 m0 *1 293.48,568.48
X$66653 73 13530 13268 13646 13454 57 13569 73 57 sky130_fd_sc_hd__nor4b_1
* cell instance $66654 m0 *1 296.7,568.48
X$66654 73 13539 73 57 13142 57 sky130_fd_sc_hd__buf_4
* cell instance $66661 m0 *1 310.5,568.48
X$66661 73 13366 13539 12706 57 73 13536 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66662 m0 *1 312.34,568.48
X$66662 73 13677 12944 12945 73 13645 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66663 m0 *1 314.18,568.48
X$66663 73 13645 12632 13457 13248 57 13761 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $66666 m0 *1 321.54,568.48
X$66666 57 13460 13538 13644 13456 12544 12158 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $66670 m0 *1 327.98,568.48
X$66670 73 13458 73 57 13572 57 sky130_fd_sc_hd__buf_4
* cell instance $66671 m0 *1 330.74,568.48
X$66671 73 13639 13569 13641 13541 57 12038 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $66675 m0 *1 334.88,568.48
X$66675 73 13572 73 57 12715 57 sky130_fd_sc_hd__buf_4
* cell instance $66680 m0 *1 347.3,568.48
X$66680 57 15556 13640 13062 13336 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $66681 m0 *1 351.9,568.48
X$66681 57 15547 13461 13369 13335 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $66688 m0 *1 366.62,568.48
X$66688 57 12030 12822 13636 73 73 57 sky130_fd_sc_hd__dfxtp_2
* cell instance $66699 m0 *1 395.6,568.48
X$66699 73 13373 13574 13573 13532 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66700 m0 *1 397.44,568.48
X$66700 73 13575 13533 13524 13531 57 13576 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $66702 m0 *1 400.66,568.48
X$66702 73 13375 13069 13634 13573 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66703 m0 *1 402.5,568.48
X$66703 57 12017 13179 13529 13576 13632 13630 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $66706 m0 *1 411.7,568.48
X$66706 73 12450 13869 13528 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66707 m0 *1 413.08,568.48
X$66707 57 12958 13527 13073 13577 13578 13234 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $66711 m0 *1 422.28,568.48
X$66711 73 12747 12566 13578 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $66712 m0 *1 424.58,568.48
X$66712 73 12867 13182 13580 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66714 m0 *1 426.88,568.48
X$66714 73 13580 13582 13521 73 13991 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66718 m0 *1 434.7,568.48
X$66718 73 13464 73 57 13579 57 sky130_fd_sc_hd__buf_4
* cell instance $66720 m0 *1 438.38,568.48
X$66720 73 13582 73 57 13583 57 sky130_fd_sc_hd__buf_4
* cell instance $66726 m0 *1 446.66,568.48
X$66726 73 12568 13735 13465 12644 12645 13513 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $66728 m0 *1 451.72,568.48
X$66728 73 13513 13619 13511 12450 14035 73 13510 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $66737 m0 *1 474.72,568.48
X$66737 73 13016 12798 13381 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66738 m0 *1 476.1,568.48
X$66738 73 13618 73 57 13619 57 sky130_fd_sc_hd__buf_4
* cell instance $66745 m0 *1 497.72,568.48
X$66745 73 11115 57 73 13616 57 sky130_fd_sc_hd__inv_2
* cell instance $66747 m0 *1 499.56,568.48
X$66747 57 13616 13109 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $66751 m0 *1 516.12,568.48
X$66751 57 13384 13614 13587 13615 13586 13588 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $66752 m0 *1 519.34,568.48
X$66752 73 13086 12876 13310 57 73 13588 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66761 m0 *1 537.74,568.48
X$66761 57 13470 13590 13591 13612 13192 13592 73 73 57
+ sky130_fd_sc_hd__a221oi_2
* cell instance $66763 m0 *1 544.18,568.48
X$66763 73 13609 13400 13608 13114 57 13470 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $66765 m0 *1 547.4,568.48
X$66765 73 12993 11115 13716 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66770 m0 *1 558.44,568.48
X$66770 57 8261 11763 13593 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $66774 m0 *1 569.02,568.48
X$66774 73 12281 13809 13603 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66778 m0 *1 576.38,568.48
X$66778 73 12881 12993 12203 57 73 13602 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66781 m0 *1 582.36,568.48
X$66781 73 12505 12376 13475 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66782 m0 *1 583.74,568.48
X$66782 73 12204 12506 13484 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66784 m0 *1 585.58,568.48
X$66784 73 13477 12769 12203 13478 13484 13294 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $66785 m0 *1 589.26,568.48
X$66785 73 12993 13388 13595 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66786 m0 *1 590.64,568.48
X$66786 73 13595 13479 13108 13298 57 73 13480 57 sky130_fd_sc_hd__a31oi_1
* cell instance $66787 m0 *1 592.94,568.48
X$66787 73 13595 73 57 13597 57 sky130_fd_sc_hd__buf_4
* cell instance $66819 r0 *1 20.24,568.48
X$66819 73 12478 13544 12399 13543 73 57 13600 57 sky130_fd_sc_hd__o31ai_1
* cell instance $66820 r0 *1 23,568.48
X$66820 73 12080 12550 13648 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66821 r0 *1 24.38,568.48
X$66821 73 12550 73 57 13436 57 sky130_fd_sc_hd__buf_4
* cell instance $66825 r0 *1 33.58,568.48
X$66825 73 13601 12928 13705 13295 13912 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $66826 r0 *1 35.88,568.48
X$66826 73 13544 73 57 12116 57 sky130_fd_sc_hd__buf_4
* cell instance $66829 r0 *1 40.02,568.48
X$66829 73 12116 13548 12478 73 13708 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66830 r0 *1 41.86,568.48
X$66830 73 13550 12335 13547 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66836 r0 *1 46.46,568.48
X$66836 73 13254 73 57 13816 57 sky130_fd_sc_hd__buf_4
* cell instance $66840 r0 *1 52.44,568.48
X$66840 73 12990 13551 13650 57 73 12786 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66841 r0 *1 54.28,568.48
X$66841 73 12551 73 57 12623 57 sky130_fd_sc_hd__buf_4
* cell instance $66844 r0 *1 61.18,568.48
X$66844 73 12336 73 57 13550 57 sky130_fd_sc_hd__buf_4
* cell instance $66851 r0 *1 74.52,568.48
X$66851 73 13606 73 57 13613 57 sky130_fd_sc_hd__buf_4
* cell instance $66853 r0 *1 77.74,568.48
X$66853 73 13549 13719 11800 73 13611 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66855 r0 *1 80.04,568.48
X$66855 73 13553 13611 11955 13720 57 73 13408 57 sky130_fd_sc_hd__a31oi_1
* cell instance $66862 r0 *1 96.6,568.48
X$66862 73 13307 13613 13722 57 73 57 sky130_fd_sc_hd__nor2b_1
* cell instance $66868 r0 *1 105.34,568.48
X$66868 73 13043 73 57 13827 57 sky130_fd_sc_hd__buf_4
* cell instance $66869 r0 *1 108.1,568.48
X$66869 73 13654 12264 13659 12678 13658 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $66872 r0 *1 113.16,568.48
X$66872 73 13658 13495 13307 11641 14323 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $66883 r0 *1 135.24,568.48
X$66883 73 13724 57 73 13661 57 sky130_fd_sc_hd__inv_2
* cell instance $66884 r0 *1 136.62,568.48
X$66884 73 13661 73 57 13556 57 sky130_fd_sc_hd__buf_4
* cell instance $66888 r0 *1 145.36,568.48
X$66888 57 15588 13354 13555 13556 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $66889 r0 *1 149.96,568.48
X$66889 73 13555 12687 13262 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $66891 r0 *1 151.34,568.48
X$66891 73 13555 73 57 12934 57 sky130_fd_sc_hd__buf_4
* cell instance $66894 r0 *1 156.4,568.48
X$66894 73 13357 13351 12842 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66896 r0 *1 159.62,568.48
X$66896 73 13665 13667 13622 13731 57 12345 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $66899 r0 *1 167.44,568.48
X$66899 73 13241 13668 12812 73 13623 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66900 r0 *1 169.28,568.48
X$66900 73 13232 13556 13671 57 73 13668 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66903 r0 *1 173.42,568.48
X$66903 73 13669 13315 13737 13733 57 13667 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $66906 r0 *1 178.02,568.48
X$66906 57 13011 13669 13314 13738 13670 13130 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $66911 r0 *1 183.08,568.48
X$66911 73 13558 12905 12841 73 57 13557 57 sky130_fd_sc_hd__o21bai_1
* cell instance $66912 r0 *1 185.84,568.48
X$66912 57 13626 13557 13627 13670 12687 13671 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $66916 r0 *1 192.28,568.48
X$66916 73 13661 73 57 12912 57 sky130_fd_sc_hd__buf_4
* cell instance $66919 r0 *1 197.34,568.48
X$66919 73 13360 73 57 12897 57 sky130_fd_sc_hd__buf_4
* cell instance $66923 r0 *1 205.62,568.48
X$66923 57 13561 12934 12807 13743 12905 12813 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $66926 r0 *1 213.44,568.48
X$66926 73 13563 73 57 13627 57 sky130_fd_sc_hd__buf_4
* cell instance $66927 r0 *1 216.2,568.48
X$66927 57 12352 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $66928 r0 *1 222.18,568.48
X$66928 73 13564 73 57 13743 57 sky130_fd_sc_hd__buf_4
* cell instance $66930 r0 *1 225.4,568.48
X$66930 73 12807 13628 14451 57 73 13520 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66952 r0 *1 273.7,568.48
X$66952 57 13570 13752 13055 13751 13675 13566 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $66953 r0 *1 276.92,568.48
X$66953 73 12353 13642 13269 13753 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $66957 r0 *1 286.58,568.48
X$66957 57 13566 13141 13567 12158 13034 12736 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $66959 r0 *1 290.26,568.48
X$66959 73 12563 13142 13568 57 73 13756 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66963 r0 *1 293.94,568.48
X$66963 73 13363 12944 13568 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $66966 r0 *1 298.08,568.48
X$66966 73 12616 12487 11790 13759 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $66969 r0 *1 304.52,568.48
X$66969 73 12944 13366 13571 57 73 13760 57 sky130_fd_sc_hd__a21oi_1
* cell instance $66980 r0 *1 328.44,568.48
X$66980 73 13677 12944 12632 73 13757 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $66981 r0 *1 330.28,568.48
X$66981 73 13177 13757 13064 13755 13864 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $66985 r0 *1 338.1,568.48
X$66985 73 12563 13677 13571 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $66992 r0 *1 347.76,568.48
X$66992 73 13270 73 57 13677 57 sky130_fd_sc_hd__buf_4
* cell instance $66994 r0 *1 351.44,568.48
X$66994 73 12716 13066 13749 12563 12384 73 13638 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $66995 r0 *1 354.66,568.48
X$66995 57 13639 13746 13747 13638 12920 12353 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $66996 r0 *1 357.88,568.48
X$66996 73 13064 13571 14051 57 73 13747 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67010 r0 *1 391.46,568.48
X$67010 73 13371 13635 13584 13745 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $67012 r0 *1 395.14,568.48
X$67012 73 12608 13375 13584 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67021 r0 *1 406.18,568.48
X$67021 73 12799 13741 13682 73 57 13630 57 sky130_fd_sc_hd__o21bai_1
* cell instance $67023 r0 *1 409.4,568.48
X$67023 73 13375 13069 13684 57 73 13740 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67029 r0 *1 421.82,568.48
X$67029 73 13018 13181 13684 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67033 r0 *1 427.34,568.48
X$67033 73 13580 73 57 13581 57 sky130_fd_sc_hd__buf_4
* cell instance $67037 r0 *1 432.86,568.48
X$67037 73 12566 73 57 13621 57 sky130_fd_sc_hd__buf_4
* cell instance $67038 r0 *1 435.62,568.48
X$67038 73 12695 13624 13684 57 73 13686 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67042 r0 *1 442.52,568.48
X$67042 73 12568 13686 13734 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67046 r0 *1 447.12,568.48
X$67046 73 13279 12450 13734 73 13693 57 57 sky130_fd_sc_hd__a21oi_2
* cell instance $67050 r0 *1 455.86,568.48
X$67050 73 12608 13621 13070 13687 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $67052 r0 *1 458.16,568.48
X$67052 73 12378 13579 13687 13730 12867 73 14033 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $67054 r0 *1 461.84,568.48
X$67054 73 13223 13079 13584 57 73 13730 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67057 r0 *1 465.98,568.48
X$67057 73 12900 13620 13689 57 73 13533 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67058 r0 *1 467.82,568.48
X$67058 73 13070 13581 13727 73 13620 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67061 r0 *1 471.04,568.48
X$67061 73 13725 13583 14467 13585 73 13689 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $67062 r0 *1 473.8,568.48
X$67062 73 12867 12795 13585 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67063 r0 *1 475.18,568.48
X$67063 73 13080 12568 13381 73 57 13692 57 sky130_fd_sc_hd__o21bai_1
* cell instance $67065 r0 *1 477.94,568.48
X$67065 73 12816 12751 12645 57 73 13691 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67066 r0 *1 479.78,568.48
X$67066 73 12695 13691 12496 73 13618 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67071 r0 *1 487.14,568.48
X$67071 73 12816 73 57 13844 57 sky130_fd_sc_hd__buf_4
* cell instance $67072 r0 *1 489.9,568.48
X$67072 73 13721 73 57 10887 57 sky130_fd_sc_hd__buf_4
* cell instance $67089 r0 *1 535.9,568.48
X$67089 57 15660 13592 13109 12204 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $67093 r0 *1 542.34,568.48
X$67093 73 13592 13114 13607 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67094 r0 *1 543.72,568.48
X$67094 73 12308 73 57 12993 57 sky130_fd_sc_hd__buf_4
* cell instance $67095 r0 *1 546.48,568.48
X$67095 57 13114 13713 12360 12972 13716 13607 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $67097 r0 *1 550.16,568.48
X$67097 57 13114 12972 13594 13383 12219 73 73 57 sky130_fd_sc_hd__o31ai_2
* cell instance $67101 r0 *1 558.9,568.48
X$67101 73 13714 13711 13697 13605 13593 73 57 57 sky130_fd_sc_hd__or4_1
* cell instance $67104 r0 *1 563.04,568.48
X$67104 73 13471 13109 13594 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $67106 r0 *1 566.26,568.48
X$67106 73 13594 12505 11115 57 73 13709 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67110 r0 *1 573.16,568.48
X$67110 73 12219 13698 13707 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67112 r0 *1 575,568.48
X$67112 73 13602 12505 12754 57 73 13698 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67114 r0 *1 578.68,568.48
X$67114 73 12360 73 57 13704 57 sky130_fd_sc_hd__buf_4
* cell instance $67115 r0 *1 581.44,568.48
X$67115 73 13475 73 57 13598 57 sky130_fd_sc_hd__buf_4
* cell instance $67118 r0 *1 587.88,568.48
X$67118 73 13702 13811 12978 12418 12420 13700 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $67119 r0 *1 591.1,568.48
X$67119 73 13091 13700 13599 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67120 r0 *1 592.48,568.48
X$67120 73 13812 13599 13701 12499 12653 73 13596 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $67202 m0 *1 22.08,573.92
X$67202 73 11800 13648 13403 73 13099 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $67204 m0 *1 26.68,573.92
X$67204 73 11800 13814 12992 13703 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $67210 m0 *1 34.5,573.92
X$67210 73 12399 13547 11800 73 13706 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67214 m0 *1 45.54,573.92
X$67214 73 13655 12623 13102 73 13764 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67215 m0 *1 47.38,573.92
X$67215 73 13816 12478 13764 57 73 13712 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67222 m0 *1 62.56,573.92
X$67222 73 12930 12623 13819 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67223 m0 *1 63.94,573.92
X$67223 73 11799 13819 13651 57 73 13715 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67224 m0 *1 65.78,573.92
X$67224 73 13652 73 57 13651 57 sky130_fd_sc_hd__buf_4
* cell instance $67228 m0 *1 74.98,573.92
X$67228 73 12000 12623 13653 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67230 m0 *1 77.28,573.92
X$67230 73 12478 13652 13653 13553 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $67234 m0 *1 82.34,573.92
X$67234 73 11955 13822 11834 73 13720 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67239 m0 *1 86.94,573.92
X$67239 73 13654 13652 13653 57 73 13491 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67242 m0 *1 90.16,573.92
X$67242 73 12053 13656 13221 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67244 m0 *1 93.38,573.92
X$67244 73 13655 13656 13657 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67253 m0 *1 113.16,573.92
X$67253 73 11799 11955 13769 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67256 m0 *1 117.3,573.92
X$67256 73 12002 13660 13654 73 13830 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67258 m0 *1 120.06,573.92
X$67258 73 13830 13494 13660 57 73 13122 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67263 m0 *1 134.78,573.92
X$67263 57 15549 13770 13555 13661 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $67268 m0 *1 142.14,573.92
X$67268 73 12601 73 57 13555 57 sky130_fd_sc_hd__inv_1
* cell instance $67270 m0 *1 143.98,573.92
X$67270 73 13770 73 57 13161 57 sky130_fd_sc_hd__buf_4
* cell instance $67273 m0 *1 149.04,573.92
X$67273 73 13662 13351 13728 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67274 m0 *1 150.42,573.92
X$67274 73 13772 13445 13836 57 73 13663 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67275 m0 *1 152.26,573.92
X$67275 73 13728 13663 12810 73 13666 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67279 m0 *1 157.32,573.92
X$67279 73 13664 73 57 13670 57 sky130_fd_sc_hd__buf_4
* cell instance $67282 m0 *1 164.22,573.92
X$67282 73 13503 13666 13623 57 73 13732 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67285 m0 *1 168.36,573.92
X$67285 57 15478 13736 12601 13661 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $67293 m0 *1 194.12,573.92
X$67293 73 12934 13232 13739 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67296 m0 *1 196.88,573.92
X$67296 73 13739 73 57 13451 57 sky130_fd_sc_hd__buf_4
* cell instance $67301 m0 *1 209.3,573.92
X$67301 57 13428 13562 14153 13742 13672 13847 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $67304 m0 *1 213.9,573.92
X$67304 57 8788 12352 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $67308 m0 *1 224.94,573.92
X$67308 73 13564 13563 12841 73 13744 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67324 m0 *1 269.1,573.92
X$67324 73 13748 12922 13673 73 13750 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67326 m0 *1 272.78,573.92
X$67326 73 13677 13674 13675 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67327 m0 *1 274.16,573.92
X$67327 73 13056 13753 13852 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67328 m0 *1 275.54,573.92
X$67328 73 13676 12353 12384 13754 57 13854 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $67330 m0 *1 278.76,573.92
X$67330 57 12328 12352 13855 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $67332 m0 *1 289.8,573.92
X$67332 73 13677 13566 13957 13568 12563 13676 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $67336 m0 *1 301.3,573.92
X$67336 73 12943 12736 12858 12563 13858 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $67341 m0 *1 308.66,573.92
X$67341 73 12563 13568 13269 57 73 13678 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67343 m0 *1 311.42,573.92
X$67343 73 12941 12950 13678 13334 57 13762 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $67344 m0 *1 314.18,573.92
X$67344 73 13786 13535 13761 13762 57 13787 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $67347 m0 *1 321.08,573.92
X$67347 73 13178 13679 13456 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67349 m0 *1 323.38,573.92
X$67349 73 13861 73 57 12544 57 sky130_fd_sc_hd__buf_4
* cell instance $67352 m0 *1 328.9,573.92
X$67352 73 12487 13327 13863 57 73 13680 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67354 m0 *1 331.66,573.92
X$67354 73 13952 13680 13787 57 73 12707 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67360 m0 *1 340.86,573.92
X$67360 73 13640 73 57 12943 57 sky130_fd_sc_hd__buf_4
* cell instance $67361 m0 *1 343.62,573.92
X$67361 57 15524 13681 13369 13335 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $67362 m0 *1 348.22,573.92
X$67362 73 13369 73 57 13748 57 sky130_fd_sc_hd__buf_4
* cell instance $67369 m0 *1 362.48,573.92
X$67369 73 13332 73 57 12706 57 sky130_fd_sc_hd__buf_4
* cell instance $67373 m0 *1 371.68,573.92
X$67373 73 13873 73 57 13636 57 sky130_fd_sc_hd__buf_4
* cell instance $67379 m0 *1 386.86,573.92
X$67379 73 11727 73 57 57 sky130_fd_sc_hd__clkbuf_2
* cell instance $67381 m0 *1 389.16,573.92
X$67381 57 9804 11727 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $67382 m0 *1 398.36,573.92
X$67382 73 13683 13372 13574 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67385 m0 *1 407.1,573.92
X$67385 73 13876 13373 12568 13723 57 13741 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $67393 m0 *1 421.82,573.92
X$67393 57 13685 13584 13635 13524 13624 12450 73 73 57 sky130_fd_sc_hd__a41oi_1
* cell instance $67394 m0 *1 425.04,573.92
X$67394 73 13725 73 57 13635 57 sky130_fd_sc_hd__buf_4
* cell instance $67396 m0 *1 428.26,573.92
X$67396 73 13181 13182 13792 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67397 m0 *1 429.64,573.92
X$67397 73 13792 73 57 13793 57 sky130_fd_sc_hd__buf_4
* cell instance $67399 m0 *1 433.32,573.92
X$67399 73 13278 13521 13624 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67402 m0 *1 436.08,573.92
X$67402 73 13792 73 57 13465 57 sky130_fd_sc_hd__buf_4
* cell instance $67410 m0 *1 447.58,573.92
X$67410 73 12647 13729 13621 57 73 13735 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67417 m0 *1 463.68,573.92
X$67417 57 13729 13508 13856 12645 13688 13584 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $67418 m0 *1 466.9,573.92
X$67418 73 12867 13688 13690 73 13856 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67419 m0 *1 468.74,573.92
X$67419 73 12795 13727 13688 57 73 13690 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67422 m0 *1 471.96,573.92
X$67422 73 13079 12795 12496 57 73 13726 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67423 m0 *1 473.8,573.92
X$67423 73 12867 13726 13725 12695 13795 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $67424 m0 *1 476.56,573.92
X$67424 57 13796 13794 12867 13015 13795 13692 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $67426 m0 *1 481.62,573.92
X$67426 73 13845 73 57 13723 57 sky130_fd_sc_hd__buf_4
* cell instance $67437 m0 *1 512.9,573.92
X$67437 73 13586 13797 14128 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67440 m0 *1 516.58,573.92
X$67440 73 13694 13799 13468 12878 12876 13797 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $67443 m0 *1 521.18,573.92
X$67443 73 12681 12788 13695 13694 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $67444 m0 *1 523.02,573.92
X$67444 57 13799 12880 12874 13695 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $67447 m0 *1 528.08,573.92
X$67447 73 13838 14325 12499 12653 57 73 13835 57 sky130_fd_sc_hd__a31oi_1
* cell instance $67449 m0 *1 531.3,573.92
X$67449 73 13696 13799 12978 12878 12210 13589 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $67450 m0 *1 534.52,573.92
X$67450 73 13591 73 57 13696 57 sky130_fd_sc_hd__buf_4
* cell instance $67452 m0 *1 537.74,573.92
X$67452 73 12281 13718 13923 73 13591 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $67453 m0 *1 540.5,573.92
X$67453 73 12308 12210 12376 57 73 13718 57 sky130_fd_sc_hd__a21o_1
* cell instance $67454 m0 *1 543.26,573.92
X$67454 73 12308 73 57 13803 57 sky130_fd_sc_hd__buf_4
* cell instance $67455 m0 *1 546.02,573.92
X$67455 73 13803 13804 13487 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67465 m0 *1 561.66,573.92
X$67465 73 12281 13713 13820 57 73 13701 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67468 m0 *1 567.64,573.92
X$67468 73 12212 13810 13808 73 13711 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $67469 m0 *1 570.4,573.92
X$67469 73 12754 13709 12656 12281 13710 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $67470 m0 *1 573.16,573.92
X$67470 73 12204 13108 13699 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67472 m0 *1 575,573.92
X$67472 73 12880 13109 12754 13699 12656 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $67475 m0 *1 579.14,573.92
X$67475 73 13086 73 57 13477 57 sky130_fd_sc_hd__buf_4
* cell instance $67478 m0 *1 582.82,573.92
X$67478 73 13487 73 57 13702 57 sky130_fd_sc_hd__buf_4
* cell instance $67514 r0 *1 23,573.92
X$67514 73 13648 73 57 13814 57 sky130_fd_sc_hd__buf_4
* cell instance $67517 r0 *1 29.9,573.92
X$67517 57 12119 13815 13120 13102 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $67520 r0 *1 33.58,573.92
X$67520 73 12293 13436 13763 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67521 r0 *1 34.96,573.92
X$67521 73 13763 73 57 13102 57 sky130_fd_sc_hd__buf_4
* cell instance $67524 r0 *1 40.02,573.92
X$67524 73 12293 73 57 13765 57 sky130_fd_sc_hd__buf_4
* cell instance $67532 r0 *1 52.9,573.92
X$67532 73 13551 73 57 14010 57 sky130_fd_sc_hd__buf_4
* cell instance $67535 r0 *1 57.96,573.92
X$67535 73 13765 13546 13818 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67537 r0 *1 60.26,573.92
X$67537 73 12371 12932 13766 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67539 r0 *1 63.48,573.92
X$67539 73 13652 73 57 14319 57 sky130_fd_sc_hd__buf_4
* cell instance $67547 r0 *1 74.52,573.92
X$67547 73 13653 73 57 13821 57 sky130_fd_sc_hd__buf_4
* cell instance $67550 r0 *1 79.58,573.92
X$67550 73 13546 11799 13823 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $67551 r0 *1 82.8,573.92
X$67551 73 13823 12002 13824 12000 13822 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $67553 r0 *1 86.02,573.92
X$67553 73 11677 73 57 13656 57 sky130_fd_sc_hd__buf_4
* cell instance $67554 r0 *1 88.78,573.92
X$67554 73 13494 13546 13652 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67556 r0 *1 90.62,573.92
X$67556 73 13655 73 57 12525 57 sky130_fd_sc_hd__buf_4
* cell instance $67557 r0 *1 93.38,573.92
X$67557 73 13767 73 57 13768 57 sky130_fd_sc_hd__buf_4
* cell instance $67563 r0 *1 103.04,573.92
X$67563 73 13656 11955 13659 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67564 r0 *1 104.42,573.92
X$67564 73 11637 11838 13767 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67565 r0 *1 105.8,573.92
X$67565 73 13660 13827 13767 13826 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $67567 r0 *1 109.48,573.92
X$67567 73 13657 73 57 13828 57 sky130_fd_sc_hd__buf_4
* cell instance $67568 r0 *1 112.24,573.92
X$67568 73 13828 11955 13769 12002 13829 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $67570 r0 *1 115,573.92
X$67570 73 13659 73 57 13660 57 sky130_fd_sc_hd__buf_4
* cell instance $67571 r0 *1 117.76,573.92
X$67571 73 11799 11879 13654 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67579 r0 *1 132.94,573.92
X$67579 73 13724 73 57 13831 57 sky130_fd_sc_hd__buf_4
* cell instance $67582 r0 *1 137.08,573.92
X$67582 73 13555 73 57 13832 57 sky130_fd_sc_hd__buf_4
* cell instance $67584 r0 *1 140.3,573.92
X$67584 57 15598 13771 13555 13834 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $67586 r0 *1 145.36,573.92
X$67586 57 15650 13662 12807 13556 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $67587 r0 *1 149.96,573.92
X$67587 73 13773 13445 13351 73 13772 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67594 r0 *1 157.32,573.92
X$67594 73 13162 73 57 13773 57 sky130_fd_sc_hd__buf_4
* cell instance $67600 r0 *1 170.66,573.92
X$67600 73 13628 12844 13839 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67603 r0 *1 173.42,573.92
X$67603 73 13771 73 57 13314 57 sky130_fd_sc_hd__buf_4
* cell instance $67606 r0 *1 177.56,573.92
X$67606 73 12811 73 57 13780 57 sky130_fd_sc_hd__buf_4
* cell instance $67614 r0 *1 193.2,573.92
X$67614 73 12841 13774 13739 13738 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $67615 r0 *1 195.04,573.92
X$67615 73 13738 73 57 13776 57 sky130_fd_sc_hd__buf_4
* cell instance $67616 r0 *1 197.8,573.92
X$67616 73 13776 13775 13843 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67617 r0 *1 199.18,573.92
X$67617 73 12807 13627 13448 13775 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $67618 r0 *1 201.02,573.92
X$67618 73 13771 13232 13778 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67619 r0 *1 202.4,573.92
X$67619 73 13360 13628 13777 12807 12809 73 13943 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $67621 r0 *1 205.62,573.92
X$67621 73 12807 13778 13774 13777 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $67625 r0 *1 210.68,573.92
X$67625 57 13945 13672 12843 13670 13779 13172 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $67628 r0 *1 215.28,573.92
X$67628 57 12813 13848 13161 12844 13451 13246 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $67629 r0 *1 218.5,573.92
X$67629 73 13516 13780 13779 13849 57 13847 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $67630 r0 *1 220.8,573.92
X$67630 73 13161 12813 13849 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67650 r0 *1 266.34,573.92
X$67650 73 13781 73 57 13457 57 sky130_fd_sc_hd__buf_4
* cell instance $67652 r0 *1 269.56,573.92
X$67652 73 13034 13674 13781 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67654 r0 *1 272.78,573.92
X$67654 73 13851 73 57 13679 57 sky130_fd_sc_hd__buf_4
* cell instance $67655 r0 *1 275.54,573.92
X$67655 73 13890 13852 13854 12384 12920 73 13853 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $67656 r0 *1 278.76,573.92
X$67656 73 14046 13853 13783 13782 13855 73 57 57 sky130_fd_sc_hd__or4_1
* cell instance $67659 r0 *1 284.28,573.92
X$67659 73 13643 13892 13857 73 13783 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67663 r0 *1 288.42,573.92
X$67663 57 13785 13857 13759 13675 13756 13567 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $67670 r0 *1 301.3,573.92
X$67670 57 12563 13954 12353 12857 13860 13858 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $67681 r0 *1 329.36,573.92
X$67681 73 13055 13566 13865 73 13863 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67683 r0 *1 332.12,573.92
X$67683 73 13681 73 57 13338 57 sky130_fd_sc_hd__buf_4
* cell instance $67692 r0 *1 348.68,573.92
X$67692 73 13640 73 57 13867 57 sky130_fd_sc_hd__buf_4
* cell instance $67694 r0 *1 352.36,573.92
X$67694 73 13067 73 57 13868 57 sky130_fd_sc_hd__buf_4
* cell instance $67696 r0 *1 356.96,573.92
X$67696 73 13270 13868 13788 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67697 r0 *1 358.34,573.92
X$67697 73 13788 73 57 13871 57 sky130_fd_sc_hd__buf_4
* cell instance $67699 r0 *1 361.56,573.92
X$67699 73 13870 13067 13871 73 13872 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67712 r0 *1 391.46,573.92
X$67712 73 13371 13635 13875 57 73 13948 57 sky130_fd_sc_hd__a21o_1
* cell instance $67713 r0 *1 394.22,573.92
X$67713 57 15653 13683 13877 12644 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $67715 r0 *1 398.82,573.92
X$67715 73 13877 13789 13987 73 13876 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67716 r0 *1 400.66,573.92
X$67716 73 13577 13274 13372 57 73 13789 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67719 r0 *1 404.8,573.92
X$67719 73 12750 13877 13634 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67722 r0 *1 408.94,573.92
X$67722 73 13372 13635 13874 13893 13507 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $67725 r0 *1 413.08,573.92
X$67725 73 13634 13182 13793 13018 13944 57 73 57 sky130_fd_sc_hd__o22a_1
* cell instance $67726 r0 *1 416.3,573.92
X$67726 57 14245 13181 14150 13578 12608 13725 73 73 57
+ sky130_fd_sc_hd__o311ai_1
* cell instance $67731 r0 *1 422.74,573.92
X$67731 73 13181 73 57 13877 57 sky130_fd_sc_hd__buf_4
* cell instance $67732 r0 *1 425.5,573.92
X$67732 57 13869 14291 13181 13074 13791 13729 13866 73 73 57
+ sky130_fd_sc_hd__a222oi_1
* cell instance $67736 r0 *1 432.4,573.92
X$67736 73 13862 73 57 13791 57 sky130_fd_sc_hd__buf_4
* cell instance $67741 r0 *1 448.04,573.92
X$67741 73 13186 13621 12647 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67745 r0 *1 453.56,573.92
X$67745 73 13939 13685 13933 13329 57 73 13859 57 sky130_fd_sc_hd__a31oi_1
* cell instance $67750 r0 *1 462.76,573.92
X$67750 73 12378 73 57 13688 57 sky130_fd_sc_hd__buf_4
* cell instance $67753 r0 *1 469.66,573.92
X$67753 73 12866 73 57 13727 57 sky130_fd_sc_hd__buf_4
* cell instance $67754 r0 *1 472.42,573.92
X$67754 57 13585 13077 13794 12695 12496 13850 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $67757 r0 *1 477.02,573.92
X$67757 73 12695 13691 12568 57 73 13846 57 sky130_fd_sc_hd__a21o_1
* cell instance $67759 r0 *1 480.7,573.92
X$67759 73 12798 13844 13585 14412 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $67775 r0 *1 513.82,573.92
X$67775 73 13926 13798 13694 13841 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $67776 r0 *1 516.58,573.92
X$67776 73 13842 12758 13112 57 73 13798 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67779 r0 *1 521.18,573.92
X$67779 73 12376 73 57 13695 57 sky130_fd_sc_hd__buf_4
* cell instance $67780 r0 *1 523.94,573.92
X$67780 73 12878 13109 13699 73 13840 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67781 r0 *1 525.78,573.92
X$67781 73 13925 12968 13800 13801 13721 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $67782 r0 *1 528.54,573.92
X$67782 73 12499 13924 13835 73 13800 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67784 r0 *1 530.84,573.92
X$67784 73 13389 12596 13837 13801 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $67789 r0 *1 537.74,573.92
X$67789 73 13590 73 57 13802 57 sky130_fd_sc_hd__buf_4
* cell instance $67793 r0 *1 545.1,573.92
X$67793 73 12210 12376 13804 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67795 r0 *1 547.4,573.92
X$67795 73 13804 73 57 12765 57 sky130_fd_sc_hd__buf_4
* cell instance $67796 r0 *1 550.16,573.92
X$67796 73 13805 73 57 13112 57 sky130_fd_sc_hd__buf_4
* cell instance $67798 r0 *1 553.38,573.92
X$67798 73 13383 12376 13806 57 73 13825 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67799 r0 *1 555.22,573.92
X$67799 73 12581 13109 13699 73 13806 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67803 r0 *1 559.82,573.92
X$67803 73 13805 12581 13477 13919 57 12987 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $67804 r0 *1 562.58,573.92
X$67804 73 12431 13091 13694 14203 13807 73 13820 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $67810 r0 *1 569.94,573.92
X$67810 57 13808 12281 13809 13817 13710 13091 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $67811 r0 *1 573.62,573.92
X$67811 57 13916 13810 13704 13707 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $67818 r0 *1 588.34,573.92
X$67818 73 13388 12993 13108 13813 57 13809 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $67819 r0 *1 591.1,573.92
X$67819 73 13910 13811 13704 73 13812 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67903 m0 *1 26.22,579.36
X$67903 73 11879 13878 13880 57 73 13911 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67904 m0 *1 28.06,579.36
X$67904 73 12399 13879 11800 73 13880 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67908 m0 *1 33.12,579.36
X$67908 73 13768 13912 12984 13915 13101 14006 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $67911 m0 *1 37.72,579.36
X$67911 57 12055 13914 13881 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $67915 m0 *1 52.9,579.36
X$67915 73 14011 13920 11834 13712 11951 73 13918 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $67916 m0 *1 56.12,579.36
X$67916 73 11641 13038 13882 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67919 m0 *1 58.42,579.36
X$67919 73 13818 73 57 14013 57 sky130_fd_sc_hd__buf_4
* cell instance $67921 m0 *1 62.1,579.36
X$67921 73 13038 13715 13922 11641 14213 13920 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $67924 m0 *1 70.84,579.36
X$67924 73 13156 11799 13821 57 73 13922 57 sky130_fd_sc_hd__a21oi_1
* cell instance $67927 m0 *1 78.2,579.36
X$67927 57 11685 13259 14016 13489 13883 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $67929 m0 *1 82.34,579.36
X$67929 73 13823 73 57 13884 57 sky130_fd_sc_hd__buf_4
* cell instance $67933 m0 *1 86.94,579.36
X$67933 73 13656 13885 13824 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67935 m0 *1 88.78,579.36
X$67935 57 12796 13884 13885 12177 13550 12224 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $67944 m0 *1 113.16,579.36
X$67944 73 11879 12800 14025 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67947 m0 *1 115.92,579.36
X$67947 73 13261 11955 13928 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $67955 m0 *1 135.24,579.36
X$67955 73 13831 73 57 13834 57 sky130_fd_sc_hd__buf_4
* cell instance $67956 m0 *1 138,579.36
X$67956 73 13834 13832 13836 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $67960 m0 *1 141.68,579.36
X$67960 57 15560 13356 13832 13834 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $67963 m0 *1 149.04,579.36
X$67963 73 12807 13773 13833 12812 57 13932 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $67964 m0 *1 151.8,579.36
X$67964 73 13051 13836 13351 73 13886 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67966 m0 *1 154.1,579.36
X$67966 73 13831 73 57 12847 57 sky130_fd_sc_hd__buf_4
* cell instance $67967 m0 *1 156.86,579.36
X$67967 73 13886 13839 13935 13556 13773 13934 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $67970 m0 *1 162.38,579.36
X$67970 73 12810 13934 13937 14030 13887 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $67972 m0 *1 166.06,579.36
X$67972 73 13503 13938 13887 73 13665 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67979 m0 *1 184,579.36
X$67979 73 13627 13558 13773 73 13941 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $67989 m0 *1 202.86,579.36
X$67989 73 13889 13888 13943 12809 12627 73 13559 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $67992 m0 *1 211.6,579.36
X$67992 73 12847 14244 13945 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68015 m0 *1 269.1,579.36
X$68015 73 13851 73 57 13674 57 sky130_fd_sc_hd__buf_4
* cell instance $68016 m0 *1 271.86,579.36
X$68016 73 12563 12736 13851 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68017 m0 *1 273.24,579.36
X$68017 73 14043 12857 13674 12943 13953 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $68018 m0 *1 275.54,579.36
X$68018 73 13752 73 57 13891 57 sky130_fd_sc_hd__buf_4
* cell instance $68026 m0 *1 293.02,579.36
X$68026 73 12943 12563 13367 73 13956 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68029 m0 *1 300.38,579.36
X$68029 57 13955 12384 13954 12191 13760 13785 73 73 57
+ sky130_fd_sc_hd__o2111a_1
* cell instance $68044 m0 *1 334.42,579.36
X$68044 73 14169 73 57 13952 57 sky130_fd_sc_hd__buf_4
* cell instance $68047 m0 *1 339.94,579.36
X$68047 73 13269 13951 12563 13949 57 73 13950 57 sky130_fd_sc_hd__a31oi_1
* cell instance $68051 m0 *1 347.3,579.36
X$68051 73 13870 73 57 13363 57 sky130_fd_sc_hd__buf_4
* cell instance $68055 m0 *1 356.04,579.36
X$68055 57 15487 13870 13062 13335 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $68070 m0 *1 390.54,579.36
X$68070 73 14794 13948 13745 13947 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $68074 m0 *1 395.6,579.36
X$68074 57 13424 13946 12608 13373 12566 13897 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $68078 m0 *1 402.04,579.36
X$68078 73 12566 73 57 13942 57 sky130_fd_sc_hd__buf_4
* cell instance $68081 m0 *1 410.32,579.36
X$68081 73 12750 13866 13893 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68089 m0 *1 426.42,579.36
X$68089 73 12645 12566 13895 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68090 m0 *1 427.8,579.36
X$68090 73 13079 13895 13894 12608 14144 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $68091 m0 *1 430.56,579.36
X$68091 73 13895 73 57 13896 57 sky130_fd_sc_hd__buf_4
* cell instance $68093 m0 *1 434.24,579.36
X$68093 73 13078 13896 13862 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68094 m0 *1 435.62,579.36
X$68094 73 13324 73 57 13866 57 sky130_fd_sc_hd__buf_4
* cell instance $68102 m0 *1 453.1,579.36
X$68102 73 13940 13897 13898 57 73 13939 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68104 m0 *1 455.4,579.36
X$68104 73 13621 13899 13897 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68106 m0 *1 457.7,579.36
X$68106 73 12867 12568 13900 73 13936 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68107 m0 *1 459.54,579.36
X$68107 73 12568 13899 13900 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68108 m0 *1 460.92,579.36
X$68108 57 13899 13729 13074 12645 73 73 57 sky130_fd_sc_hd__mux2i_1
* cell instance $68117 m0 *1 479.78,579.36
X$68117 73 13901 13930 13902 57 73 13082 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68120 m0 *1 483,579.36
X$68120 73 13902 13929 13688 13901 13844 73 13845 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $68129 m0 *1 505.54,579.36
X$68129 73 12968 12877 13927 13996 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68130 m0 *1 507.38,579.36
X$68130 57 14027 12414 14994 13903 13904 13841 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $68133 m0 *1 513.82,579.36
X$68133 73 13921 73 57 13926 57 sky130_fd_sc_hd__buf_4
* cell instance $68137 m0 *1 523.02,579.36
X$68137 73 13696 13695 13840 57 73 13903 57 sky130_fd_sc_hd__a21boi_0
* cell instance $68143 m0 *1 532.22,579.36
X$68143 73 12876 13906 14101 12499 13496 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $68147 m0 *1 543.26,579.36
X$68147 73 12505 12210 13923 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68148 m0 *1 544.64,579.36
X$68148 73 12505 13109 13608 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $68151 m0 *1 549.24,579.36
X$68151 73 13905 73 57 12670 57 sky130_fd_sc_hd__buf_4
* cell instance $68156 m0 *1 555.22,579.36
X$68156 73 13704 13825 14019 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68157 m0 *1 556.6,579.36
X$68157 73 13471 73 57 13807 57 sky130_fd_sc_hd__buf_4
* cell instance $68158 m0 *1 559.36,579.36
X$68158 73 13921 73 57 13919 57 sky130_fd_sc_hd__buf_4
* cell instance $68161 m0 *1 569.48,579.36
X$68161 73 13998 73 57 13906 57 sky130_fd_sc_hd__buf_4
* cell instance $68162 m0 *1 572.24,579.36
X$68162 73 12418 13907 13917 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68164 m0 *1 574.08,579.36
X$68164 73 13908 13917 12281 73 13916 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68166 m0 *1 576.38,579.36
X$68166 73 13909 73 57 13913 57 sky130_fd_sc_hd__buf_4
* cell instance $68169 m0 *1 580.52,579.36
X$68169 73 12420 13388 13909 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68173 m0 *1 586.5,579.36
X$68173 73 13908 73 57 13910 57 sky130_fd_sc_hd__buf_4
* cell instance $68174 m0 *1 589.26,579.36
X$68174 73 12881 14107 13811 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68209 r0 *1 20.7,579.36
X$68209 57 14111 13101 13815 14004 13911 12674 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $68210 r0 *1 23.92,579.36
X$68210 57 10727 13914 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $68213 r0 *1 37.26,579.36
X$68213 73 14116 14006 14009 73 57 13881 57 sky130_fd_sc_hd__o21ai_1
* cell instance $68214 r0 *1 39.1,579.36
X$68214 73 13708 13882 14007 11834 57 73 14008 57 sky130_fd_sc_hd__a31oi_1
* cell instance $68223 r0 *1 47.38,579.36
X$68223 73 13958 13918 14009 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68224 r0 *1 48.76,579.36
X$68224 73 11637 73 57 13958 57 sky130_fd_sc_hd__buf_4
* cell instance $68225 r0 *1 51.52,579.36
X$68225 73 12264 14012 14010 13882 14011 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $68228 r0 *1 58.42,579.36
X$68228 73 14013 12478 13766 13879 57 14121 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $68238 r0 *1 74.52,579.36
X$68238 73 13821 12119 14124 11799 11834 73 14122 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $68240 r0 *1 79.58,579.36
X$68240 73 14018 11879 13959 57 73 14016 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68244 r0 *1 87.86,579.36
X$68244 73 12551 73 57 13885 57 sky130_fd_sc_hd__buf_4
* cell instance $68245 r0 *1 90.62,579.36
X$68245 73 11799 13885 13349 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68257 r0 *1 109.48,579.36
X$68257 73 11838 13885 11834 13962 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68259 r0 *1 112.24,579.36
X$68259 73 13961 13962 14025 13659 12525 73 14268 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $68261 r0 *1 115.92,579.36
X$68261 73 12040 11955 13928 11799 13961 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $68273 r0 *1 137.54,579.36
X$68273 73 13123 13836 14028 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68276 r0 *1 141.68,579.36
X$68276 73 13834 13832 12812 73 13963 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68278 r0 *1 143.98,579.36
X$68278 57 13964 13963 12843 12687 13445 12810 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $68280 r0 *1 147.66,579.36
X$68280 73 13964 12687 13965 57 73 13967 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68282 r0 *1 149.96,579.36
X$68282 73 13932 13662 12812 57 73 13965 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68291 r0 *1 163.76,579.36
X$68291 73 13967 14030 13969 13503 73 13968 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $68296 r0 *1 173.88,579.36
X$68296 57 12529 13968 13970 14234 13971 73 73 57 sky130_fd_sc_hd__nor4_2
* cell instance $68299 r0 *1 178.48,579.36
X$68299 73 13966 13126 14145 12848 13737 73 13971 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $68303 r0 *1 184.92,579.36
X$68303 73 12812 13941 13972 57 73 14034 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68306 r0 *1 188.14,579.36
X$68306 73 13743 13671 12897 12807 13556 13972 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $68314 r0 *1 207,579.36
X$68314 73 13973 12848 13975 57 73 13970 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68319 r0 *1 213.9,579.36
X$68319 73 14037 12729 13848 57 73 13975 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68323 r0 *1 221.72,579.36
X$68323 73 12627 14039 14158 13976 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68324 r0 *1 223.56,579.36
X$68324 57 11752 13136 14593 13976 14341 73 73 57 sky130_fd_sc_hd__a2bb2oi_2
* cell instance $68345 r0 *1 266.34,579.36
X$68345 73 13327 13953 14042 14167 57 14046 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $68347 r0 *1 269.56,579.36
X$68347 73 13977 73 57 13327 57 sky130_fd_sc_hd__buf_4
* cell instance $68350 r0 *1 274.62,579.36
X$68350 73 13062 12633 14043 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68352 r0 *1 276.92,579.36
X$68352 73 12384 14168 14045 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68354 r0 *1 279.22,579.36
X$68354 73 13864 14045 14254 12158 12631 73 13782 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $68367 r0 *1 307.74,579.36
X$68367 73 14053 14052 12353 73 13455 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68374 r0 *1 316.48,579.36
X$68374 73 12563 13539 13979 57 73 14054 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68378 r0 *1 320.16,579.36
X$68378 73 13055 12353 13981 73 13979 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68384 r0 *1 335.8,579.36
X$68384 73 12096 12384 13977 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68386 r0 *1 339.02,579.36
X$68386 73 15115 13950 13334 73 14055 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $68391 r0 *1 344.54,579.36
X$68391 73 12953 73 57 13982 57 sky130_fd_sc_hd__buf_4
* cell instance $68394 r0 *1 348.68,579.36
X$68394 73 13983 13984 13985 73 12952 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68395 r0 *1 350.52,579.36
X$68395 73 12563 13984 12714 13986 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68396 r0 *1 352.36,579.36
X$68396 73 13335 13062 13982 13984 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68398 r0 *1 357.88,579.36
X$68398 73 13983 13985 12715 14051 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $68414 r0 *1 392.84,579.36
X$68414 73 12450 14049 13947 14163 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68415 r0 *1 394.68,579.36
X$68415 73 12568 14036 13238 73 14048 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68418 r0 *1 396.52,579.36
X$68418 57 14047 13866 13683 12608 12866 13375 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $68419 r0 *1 399.74,579.36
X$68419 73 13988 12864 13987 12608 57 73 14044 57 sky130_fd_sc_hd__a31oi_1
* cell instance $68427 r0 *1 410.78,579.36
X$68427 73 13893 73 57 14041 57 sky130_fd_sc_hd__buf_4
* cell instance $68429 r0 *1 415.38,579.36
X$68429 57 13793 14092 13018 12642 13989 13877 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $68430 r0 *1 418.6,579.36
X$68430 73 12750 13372 13989 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68432 r0 *1 421.82,579.36
X$68432 73 12750 13182 14038 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68437 r0 *1 425.5,579.36
X$68437 73 13182 73 57 13990 57 sky130_fd_sc_hd__buf_4
* cell instance $68438 r0 *1 428.26,579.36
X$68438 73 13278 13990 13521 73 13894 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68442 r0 *1 434.7,579.36
X$68442 57 14036 13862 13729 13992 13077 13866 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $68444 r0 *1 441.6,579.36
X$68444 73 13278 73 57 13993 57 sky130_fd_sc_hd__buf_4
* cell instance $68445 r0 *1 444.36,579.36
X$68445 73 12866 13465 13992 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68450 r0 *1 451.26,579.36
X$68450 73 13992 73 57 13994 57 sky130_fd_sc_hd__buf_4
* cell instance $68451 r0 *1 454.02,579.36
X$68451 73 14859 12900 13994 13988 57 14035 73 57 sky130_fd_sc_hd__nor4b_1
* cell instance $68454 r0 *1 458.16,579.36
X$68454 73 14033 12798 13936 57 73 14131 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68455 r0 *1 460,579.36
X$68455 73 14099 12900 14032 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68456 r0 *1 461.38,579.36
X$68456 73 13993 13896 14031 14032 13506 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $68458 r0 *1 465.98,579.36
X$68458 73 13850 73 57 14029 57 sky130_fd_sc_hd__buf_4
* cell instance $68461 r0 *1 470.12,579.36
X$68461 73 13901 12496 13850 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68467 r0 *1 479.32,579.36
X$68467 73 13993 12798 13930 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68477 r0 *1 503.24,579.36
X$68477 57 14027 12684 14129 13995 13996 73 73 57 sky130_fd_sc_hd__nor4_4
* cell instance $68483 r0 *1 515.2,579.36
X$68483 73 14225 14103 12217 14026 12968 73 13904 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $68484 r0 *1 518.42,579.36
X$68484 73 12878 12577 14026 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68486 r0 *1 520.26,579.36
X$68486 73 13997 12663 12414 14024 57 73 14102 57 sky130_fd_sc_hd__a31oi_1
* cell instance $68490 r0 *1 527.62,579.36
X$68490 73 12876 13586 13498 13997 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $68491 r0 *1 529.46,579.36
X$68491 73 13087 73 57 14023 57 sky130_fd_sc_hd__buf_4
* cell instance $68500 r0 *1 545.56,579.36
X$68500 73 13923 73 57 14022 57 sky130_fd_sc_hd__buf_4
* cell instance $68504 r0 *1 553.38,579.36
X$68504 73 13298 14021 12281 73 14020 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68505 r0 *1 555.22,579.36
X$68505 57 14020 13704 12294 12653 14019 14017 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $68511 r0 *1 565.34,579.36
X$68511 73 14215 13388 13087 13108 14015 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $68515 r0 *1 571.32,579.36
X$68515 73 12420 14000 14014 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68516 r0 *1 572.7,579.36
X$68516 73 13999 12880 14000 57 73 13998 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68517 r0 *1 574.54,579.36
X$68517 57 14000 13999 12993 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $68518 r0 *1 578.68,579.36
X$68518 73 13485 73 57 14001 57 sky130_fd_sc_hd__buf_4
* cell instance $68519 r0 *1 581.44,579.36
X$68519 73 13998 13108 13086 14005 57 14002 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $68524 r0 *1 588.8,579.36
X$68524 73 12880 13388 13813 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68526 r0 *1 591.1,579.36
X$68526 73 13813 14001 13108 73 14003 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68587 m0 *1 18.4,584.8
X$68587 73 13543 73 57 14058 57 sky130_fd_sc_hd__buf_4
* cell instance $68588 m0 *1 21.16,584.8
X$68588 73 12674 14112 14111 57 73 13883 57 sky130_fd_sc_hd__a21o_1
* cell instance $68589 m0 *1 23.92,584.8
X$68589 57 13914 73 73 57 sky130_fd_sc_hd__clkinv_8
* cell instance $68591 m0 *1 30.36,584.8
X$68591 73 14115 73 57 13156 57 sky130_fd_sc_hd__buf_4
* cell instance $68592 m0 *1 33.12,584.8
X$68592 73 12397 14064 13878 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68594 m0 *1 36.34,584.8
X$68594 73 11800 13763 14118 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68595 m0 *1 37.72,584.8
X$68595 57 14116 11641 11955 14117 14008 13649 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $68599 m0 *1 52.44,584.8
X$68599 73 12782 73 57 12224 57 sky130_fd_sc_hd__buf_4
* cell instance $68605 m0 *1 59.34,584.8
X$68605 73 11834 14121 14120 73 13959 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68610 m0 *1 75.9,584.8
X$68610 73 14123 13546 12624 57 73 14124 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68612 m0 *1 78.66,584.8
X$68612 73 14125 11834 11879 14122 57 14018 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $68614 m0 *1 81.88,584.8
X$68614 73 11834 14060 13960 12000 12624 14061 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $68618 m0 *1 86.94,584.8
X$68618 73 14060 12525 13960 12002 13258 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $68622 m0 *1 97.52,584.8
X$68622 73 14064 13118 12179 57 73 14063 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68624 m0 *1 100.28,584.8
X$68624 73 14064 12524 12040 73 14130 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68629 m0 *1 110.86,584.8
X$68629 73 12224 14065 13885 73 14133 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68631 m0 *1 113.16,584.8
X$68631 73 12002 12264 13659 57 73 14065 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68633 m0 *1 115.92,584.8
X$68633 73 13261 13960 12179 11879 73 57 13617 57 sky130_fd_sc_hd__o31ai_1
* cell instance $68641 m0 *1 136.62,584.8
X$68641 73 13123 14066 12807 73 14136 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68644 m0 *1 140.76,584.8
X$68644 73 13832 12807 13671 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68647 m0 *1 143.52,584.8
X$68647 73 14138 73 57 14066 57 sky130_fd_sc_hd__buf_4
* cell instance $68661 m0 *1 181.24,584.8
X$68661 73 14236 12812 12848 14034 57 14145 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $68666 m0 *1 193.66,584.8
X$68666 73 14070 14074 12807 73 14149 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68669 m0 *1 197.8,584.8
X$68669 73 14148 73 57 14037 57 sky130_fd_sc_hd__buf_4
* cell instance $68672 m0 *1 203.32,584.8
X$68672 73 14151 14072 13843 13670 13780 13973 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $68673 m0 *1 206.54,584.8
X$68673 57 14072 13974 12905 13743 12841 13319 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $68674 m0 *1 209.76,584.8
X$68674 57 14153 12841 13974 14073 14155 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $68675 m0 *1 213.44,584.8
X$68675 73 13743 14074 12841 73 14073 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68681 m0 *1 224.48,584.8
X$68681 73 12809 14156 14161 57 73 14158 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68687 m0 *1 239.66,584.8
X$68687 57 4950 12557 14740 14164 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $68696 m0 *1 270.94,584.8
X$68696 73 13064 13056 14253 14167 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68699 m0 *1 274.16,584.8
X$68699 73 12563 12736 13978 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68700 m0 *1 275.54,584.8
X$68700 73 13978 73 57 13566 57 sky130_fd_sc_hd__buf_4
* cell instance $68703 m0 *1 279.22,584.8
X$68703 57 14168 14076 13061 13457 13677 13978 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $68707 m0 *1 290.72,584.8
X$68707 73 14078 73 57 14076 57 sky130_fd_sc_hd__buf_4
* cell instance $68710 m0 *1 297.62,584.8
X$68710 73 12736 12158 13956 73 57 13785 57 sky130_fd_sc_hd__o21ai_1
* cell instance $68711 m0 *1 299.46,584.8
X$68711 73 12633 12736 14079 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68712 m0 *1 300.84,584.8
X$68712 73 14080 14079 14078 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $68713 m0 *1 303.14,584.8
X$68713 73 14079 73 57 12941 57 sky130_fd_sc_hd__buf_4
* cell instance $68716 m0 *1 308.2,584.8
X$68716 73 13985 13868 14080 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68717 m0 *1 309.58,584.8
X$68717 73 14080 73 57 13266 57 sky130_fd_sc_hd__buf_4
* cell instance $68719 m0 *1 313.26,584.8
X$68719 73 14081 14082 14054 12563 13643 73 14083 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $68722 m0 *1 319.24,584.8
X$68722 57 12408 14256 13759 14083 13980 14055 14170 73 73 57
+ sky130_fd_sc_hd__a222oi_1
* cell instance $68725 m0 *1 324.3,584.8
X$68725 73 12563 12922 14287 14052 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68727 m0 *1 327.98,584.8
X$68727 73 14084 73 57 12922 57 sky130_fd_sc_hd__buf_4
* cell instance $68733 m0 *1 336.72,584.8
X$68733 73 12950 13067 14084 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68736 m0 *1 342.7,584.8
X$68736 73 12563 14085 13981 13949 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68739 m0 *1 351.9,584.8
X$68739 73 13461 13067 13066 73 14165 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68742 m0 *1 357.88,584.8
X$68742 73 13870 13067 13983 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68756 m0 *1 389.62,584.8
X$68756 73 14159 14163 14162 14250 57 13873 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $68757 m0 *1 391.92,584.8
X$68757 73 14049 13373 14048 14162 57 73 57 sky130_fd_sc_hd__nor3b_1
* cell instance $68759 m0 *1 395.6,584.8
X$68759 73 12866 12566 14160 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68761 m0 *1 398.82,584.8
X$68761 73 14089 12642 13877 73 13987 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68762 m0 *1 400.66,584.8
X$68762 73 14091 14044 13373 13179 14154 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $68765 m0 *1 408.94,584.8
X$68765 73 12568 14092 14091 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68770 m0 *1 416.76,584.8
X$68770 73 12862 13942 14150 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68771 m0 *1 418.14,584.8
X$68771 73 14140 73 57 14094 57 sky130_fd_sc_hd__buf_4
* cell instance $68774 m0 *1 426.42,584.8
X$68774 73 14147 13578 13080 73 14097 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68775 m0 *1 428.26,584.8
X$68775 73 12608 13991 14144 14097 14141 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $68776 m0 *1 431.02,584.8
X$68776 73 13894 73 57 14142 57 sky130_fd_sc_hd__buf_4
* cell instance $68785 m0 *1 447.58,584.8
X$68785 73 13279 14140 14135 12608 14098 73 14096 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $68786 m0 *1 450.8,584.8
X$68786 73 12450 13179 14098 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68787 m0 *1 452.18,584.8
X$68787 73 13074 12964 14139 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68794 m0 *1 469.66,584.8
X$68794 73 12867 13016 12798 14031 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $68799 m0 *1 477.02,584.8
X$68799 73 13080 13930 13581 14135 57 73 57 sky130_fd_sc_hd__and3b_1
* cell instance $68800 m0 *1 480.24,584.8
X$68800 73 12867 12695 14134 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68801 m0 *1 481.62,584.8
X$68801 73 12795 14132 13929 57 73 13220 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68811 m0 *1 504.62,584.8
X$68811 57 14129 12877 14200 12968 14127 12414 73 73 57
+ sky130_fd_sc_hd__o2111a_1
* cell instance $68812 m0 *1 508.76,584.8
X$68812 57 12217 13995 12968 14102 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $68815 m0 *1 512.44,584.8
X$68815 57 14127 14101 14103 14128 13586 14126 73 73 57 sky130_fd_sc_hd__a41o_1
* cell instance $68816 m0 *1 516.12,584.8
X$68816 73 12210 14104 14126 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68817 m0 *1 517.5,584.8
X$68817 73 13913 14105 14104 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68820 m0 *1 521.64,584.8
X$68820 73 12974 12876 13695 14223 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $68823 m0 *1 524.86,584.8
X$68823 73 12415 12414 13389 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68839 m0 *1 561.2,584.8
X$68839 73 13091 13907 13608 14204 13807 14214 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $68843 m0 *1 567.64,584.8
X$68843 57 12754 13388 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $68849 m0 *1 582.36,584.8
X$68849 73 13108 14106 14014 14005 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68851 m0 *1 586.04,584.8
X$68851 73 12506 13388 14107 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68853 m0 *1 588.34,584.8
X$68853 73 14107 14106 14114 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68855 m0 *1 590.18,584.8
X$68855 73 13388 12979 14209 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68857 m0 *1 593.4,584.8
X$68857 73 14208 14113 12767 14002 57 73 13095 57 sky130_fd_sc_hd__a31oi_1
* cell instance $68881 r0 *1 2.3,584.8
X$68881 57 14110 13914 11065 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $68882 r0 *1 9.66,584.8
X$68882 73 10910 57 73 14207 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68889 r0 *1 19.32,584.8
X$68889 73 11879 13099 14551 14057 73 57 14112 57 sky130_fd_sc_hd__o31ai_1
* cell instance $68890 r0 *1 22.08,584.8
X$68890 73 12478 14660 14058 11879 14057 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $68894 r0 *1 30.82,584.8
X$68894 73 12002 12053 13436 14115 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $68899 r0 *1 39.56,584.8
X$68899 73 12428 73 57 13655 57 sky130_fd_sc_hd__buf_4
* cell instance $68900 r0 *1 42.32,584.8
X$68900 73 12428 12335 14211 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68905 r0 *1 45.54,584.8
X$68905 73 13882 14118 13435 12793 14059 14119 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $68908 r0 *1 51.06,584.8
X$68908 73 14059 12992 12478 73 13650 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68909 r0 *1 52.9,584.8
X$68909 73 14059 73 57 12373 57 sky130_fd_sc_hd__buf_4
* cell instance $68912 r0 *1 58.42,584.8
X$68912 57 14123 14120 11834 13256 13545 14266 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $68914 r0 *1 62.56,584.8
X$68914 73 11799 73 57 14123 57 sky130_fd_sc_hd__buf_4
* cell instance $68924 r0 *1 80.5,584.8
X$68924 57 14125 12373 13494 14218 12002 14064 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $68925 r0 *1 83.72,584.8
X$68925 73 11955 14061 14220 11834 14218 13915 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $68926 r0 *1 86.94,584.8
X$68926 73 12053 13884 14218 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68929 r0 *1 89.7,584.8
X$68929 73 11834 12224 13546 13719 57 73 14062 57 sky130_fd_sc_hd__a31oi_1
* cell instance $68931 r0 *1 95.68,584.8
X$68931 73 14062 14063 13722 11799 12371 14221 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $68949 r0 *1 135.7,584.8
X$68949 73 14028 14136 12896 13671 13834 14226 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $68952 r0 *1 141.68,584.8
X$68952 73 12896 13832 13123 14326 14228 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $68960 r0 *1 155.02,584.8
X$68960 73 12841 13232 14175 57 73 14176 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68961 r0 *1 156.86,584.8
X$68961 73 14176 14143 12897 13625 12841 14068 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $68963 r0 *1 160.54,584.8
X$68963 73 12812 14068 14069 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68965 r0 *1 162.38,584.8
X$68965 73 14069 14178 14030 13732 57 73 14067 57 sky130_fd_sc_hd__a31oi_1
* cell instance $68972 r0 *1 178.48,584.8
X$68972 73 14143 13628 14235 12807 12810 73 14148 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $68979 r0 *1 197.34,584.8
X$68979 73 12601 13049 14181 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68981 r0 *1 199.64,584.8
X$68981 73 14181 14071 14240 12847 13357 13560 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $68984 r0 *1 204.24,584.8
X$68984 73 13130 12934 14157 57 73 14240 57 sky130_fd_sc_hd__a21oi_1
* cell instance $68988 r0 *1 207.46,584.8
X$68988 73 12601 13319 14242 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $68991 r0 *1 209.76,584.8
X$68991 73 13451 14138 13974 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $68994 r0 *1 213.9,584.8
X$68994 73 13432 73 57 14070 57 sky130_fd_sc_hd__buf_4
* cell instance $68996 r0 *1 218.5,584.8
X$68996 73 13172 73 57 14157 57 sky130_fd_sc_hd__buf_4
* cell instance $68998 r0 *1 222.18,584.8
X$68998 73 13779 14248 12812 73 14156 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $68999 r0 *1 224.02,584.8
X$68999 73 12729 14075 14161 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69024 r0 *1 285.66,584.8
X$69024 57 14077 13055 12943 14184 14076 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $69032 r0 *1 293.94,584.8
X$69032 73 14077 12158 14431 13785 14256 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $69035 r0 *1 297.62,584.8
X$69035 73 14078 13062 13064 14255 57 14257 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $69042 r0 *1 315.56,584.8
X$69042 73 12096 73 57 14082 57 sky130_fd_sc_hd__buf_4
* cell instance $69046 r0 *1 320.16,584.8
X$69046 73 14257 14166 12158 73 14170 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69052 r0 *1 335.34,584.8
X$69052 57 14169 12190 14261 14258 14259 12191 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $69055 r0 *1 340.86,584.8
X$69055 57 14258 13985 14085 13983 14350 13977 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $69057 r0 *1 344.54,584.8
X$69057 73 12563 14086 14186 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69058 r0 *1 345.92,584.8
X$69058 73 13867 13982 14085 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69060 r0 *1 347.76,584.8
X$69060 73 13148 14086 14081 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69062 r0 *1 349.6,584.8
X$69062 73 13867 13982 14086 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69064 r0 *1 351.44,584.8
X$69064 73 14086 13066 14715 12563 12384 73 14166 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $69069 r0 *1 361.56,584.8
X$69069 57 12633 13985 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $69080 r0 *1 391.92,584.8
X$69080 73 12568 13375 13875 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69081 r0 *1 393.3,584.8
X$69081 73 13877 13875 14087 57 73 14188 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69082 r0 *1 395.14,584.8
X$69082 73 13373 14252 14188 14088 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69084 r0 *1 396.98,584.8
X$69084 57 14159 13179 14088 14251 14090 14154 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $69085 r0 *1 400.66,584.8
X$69085 73 14249 12608 14094 57 73 14252 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69090 r0 *1 406.18,584.8
X$69090 73 12608 14094 14093 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69092 r0 *1 408.02,584.8
X$69092 73 13328 13740 14137 12608 14093 14152 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $69093 r0 *1 411.24,584.8
X$69093 73 14247 14152 14189 14095 57 14246 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $69094 r0 *1 414,584.8
X$69094 57 11852 11727 14246 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $69095 r0 *1 421.36,584.8
X$69095 73 13524 14146 14096 57 73 14090 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69097 r0 *1 423.2,584.8
X$69097 73 14029 14243 14146 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69098 r0 *1 424.58,584.8
X$69098 73 14229 73 57 14189 57 sky130_fd_sc_hd__buf_4
* cell instance $69099 r0 *1 427.34,584.8
X$69099 73 13991 73 57 14241 57 sky130_fd_sc_hd__buf_4
* cell instance $69104 r0 *1 435.62,584.8
X$69104 73 13018 13324 13074 13465 73 14237 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $69107 r0 *1 440.22,584.8
X$69107 73 12795 12450 13621 57 73 14238 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69110 r0 *1 447.58,584.8
X$69110 73 13016 12645 14192 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69111 r0 *1 448.96,584.8
X$69111 73 14192 14139 12798 73 14140 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69113 r0 *1 450.8,584.8
X$69113 73 14192 73 57 14099 57 sky130_fd_sc_hd__buf_4
* cell instance $69116 r0 *1 455.86,584.8
X$69116 73 12799 14141 12450 73 14100 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69120 r0 *1 463.68,584.8
X$69120 73 13729 13324 14233 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69124 r0 *1 473.34,584.8
X$69124 73 13077 14195 13280 73 14232 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69126 r0 *1 475.64,584.8
X$69126 57 14229 13796 14100 14411 14196 73 73 57 sky130_fd_sc_hd__nor4_2
* cell instance $69128 r0 *1 480.24,584.8
X$69128 73 12795 73 57 14195 57 sky130_fd_sc_hd__buf_4
* cell instance $69133 r0 *1 489.44,584.8
X$69133 73 12695 13727 14132 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $69140 r0 *1 510.14,584.8
X$69140 73 12219 73 57 13586 57 sky130_fd_sc_hd__buf_4
* cell instance $69144 r0 *1 517.96,584.8
X$69144 73 14224 14101 14222 13586 12414 73 14024 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $69145 r0 *1 521.18,584.8
X$69145 73 13586 14023 14223 57 73 14222 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69148 r0 *1 530.38,584.8
X$69148 73 12569 12219 14197 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69151 r0 *1 532.22,584.8
X$69151 57 14197 13905 12789 14219 14198 14199 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $69152 r0 *1 535.44,584.8
X$69152 73 12758 14203 14198 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69156 r0 *1 541.88,584.8
X$69156 73 14212 14201 14217 73 12500 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69158 r0 *1 544.18,584.8
X$69158 73 13216 12880 12765 57 73 14201 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69161 r0 *1 548.32,584.8
X$69161 57 15621 14215 12874 12681 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $69167 r0 *1 559.82,584.8
X$69167 73 13091 14768 14214 12219 13472 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $69175 r0 *1 578.68,584.8
X$69175 73 12506 14308 14205 12881 14108 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $69178 r0 *1 584.2,584.8
X$69178 73 12219 73 57 14212 57 sky130_fd_sc_hd__buf_4
* cell instance $69182 r0 *1 589.26,584.8
X$69182 73 12881 14106 14209 14108 73 57 14109 57 sky130_fd_sc_hd__o31ai_1
* cell instance $69183 r0 *1 592.02,584.8
X$69183 73 14206 13704 14109 57 73 14210 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69185 r0 *1 594.32,584.8
X$69185 73 13108 14114 14113 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69266 m0 *1 22.54,590.24
X$69266 57 13814 13256 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $69273 m0 *1 44.16,590.24
X$69273 73 14123 14211 14315 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69275 m0 *1 46,590.24
X$69275 73 14316 73 57 12076 57 sky130_fd_sc_hd__buf_4
* cell instance $69283 m0 *1 60.72,590.24
X$69283 73 14172 73 57 14059 57 sky130_fd_sc_hd__buf_4
* cell instance $69284 m0 *1 63.48,590.24
X$69284 73 14319 14318 14266 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69287 m0 *1 66.24,590.24
X$69287 73 12371 14173 11641 73 14213 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69291 m0 *1 74.06,590.24
X$69291 73 14172 73 57 13610 57 sky130_fd_sc_hd__buf_4
* cell instance $69296 m0 *1 85.56,590.24
X$69296 73 13719 12053 14173 57 73 14220 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69298 m0 *1 88.32,590.24
X$69298 73 14267 14674 14263 12227 73 12087 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $69299 m0 *1 90.62,590.24
X$69299 73 13768 14566 14174 14267 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $69301 m0 *1 96.14,590.24
X$69301 73 11879 14221 14174 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69304 m0 *1 104.88,590.24
X$69304 73 12264 13118 11879 14321 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $69318 m0 *1 138.46,590.24
X$69318 73 13832 13445 13123 57 73 14227 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69320 m0 *1 140.76,590.24
X$69320 73 13834 14227 13671 14443 14324 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $69321 m0 *1 143.52,590.24
X$69321 73 13770 12687 14138 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69324 m0 *1 147.2,590.24
X$69324 73 14274 12687 14175 57 73 14231 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69326 m0 *1 150.88,590.24
X$69326 57 14272 14327 12601 13831 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $69327 m0 *1 155.48,590.24
X$69327 57 15449 14179 12601 13831 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $69330 m0 *1 162.84,590.24
X$69330 73 12809 14177 14030 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69332 m0 *1 164.68,590.24
X$69332 73 12605 12627 14177 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69335 m0 *1 168.36,590.24
X$69335 73 14179 73 57 13357 57 sky130_fd_sc_hd__buf_4
* cell instance $69339 m0 *1 174.34,590.24
X$69339 73 13736 13232 14180 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69341 m0 *1 176.18,590.24
X$69341 73 14180 73 57 14331 57 sky130_fd_sc_hd__buf_4
* cell instance $69343 m0 *1 179.4,590.24
X$69343 73 12807 14274 14331 14235 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69346 m0 *1 185.84,590.24
X$69346 73 14335 73 57 13130 57 sky130_fd_sc_hd__buf_4
* cell instance $69355 m0 *1 202.4,590.24
X$69355 73 12843 14335 13889 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69357 m0 *1 205.62,590.24
X$69357 73 13889 73 57 14336 57 sky130_fd_sc_hd__buf_4
* cell instance $69360 m0 *1 209.76,590.24
X$69360 73 12807 14180 14138 14420 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69361 m0 *1 211.6,590.24
X$69361 73 14500 12934 13049 57 73 14244 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69371 m0 *1 238.28,590.24
X$69371 73 14342 57 73 14164 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69384 m0 *1 270.94,590.24
X$69384 57 14253 13363 14182 14183 13366 73 73 57 sky130_fd_sc_hd__o211a_1
* cell instance $69386 m0 *1 275.08,590.24
X$69386 73 14277 73 57 13331 57 sky130_fd_sc_hd__buf_4
* cell instance $69390 m0 *1 279.22,590.24
X$69390 73 12158 14344 14279 57 73 14254 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69391 m0 *1 281.06,590.24
X$69391 73 12384 12740 13364 14280 12940 14279 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $69394 m0 *1 286.58,590.24
X$69394 73 14183 14182 14185 13363 12384 73 14283 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $69395 m0 *1 289.8,590.24
X$69395 73 14374 14183 14185 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69396 m0 *1 291.18,590.24
X$69396 73 14082 14348 14283 13646 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69399 m0 *1 295.32,590.24
X$69399 73 13034 14182 14284 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69401 m0 *1 297.16,590.24
X$69401 73 14284 12736 13539 13055 14255 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $69409 m0 *1 311.42,590.24
X$69409 73 14285 73 57 13860 57 sky130_fd_sc_hd__buf_4
* cell instance $69417 m0 *1 333.96,590.24
X$69417 73 14186 12858 14260 14187 13064 73 14261 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $69420 m0 *1 341.32,590.24
X$69420 73 14351 73 57 14350 57 sky130_fd_sc_hd__buf_4
* cell instance $69421 m0 *1 344.08,590.24
X$69421 73 12563 14085 13860 14349 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69424 m0 *1 351.44,590.24
X$69424 73 13870 12953 14287 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69426 m0 *1 353.74,590.24
X$69426 73 12096 73 57 14187 57 sky130_fd_sc_hd__buf_4
* cell instance $69444 m0 *1 399.28,590.24
X$69444 73 14427 14343 13373 14289 57 73 14250 57 sky130_fd_sc_hd__a31oi_1
* cell instance $69446 m0 *1 402.04,590.24
X$69446 73 13373 14047 14190 14290 73 57 14289 57 sky130_fd_sc_hd__o31ai_1
* cell instance $69449 m0 *1 407.56,590.24
X$69449 73 13328 13179 14290 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69455 m0 *1 420.9,590.24
X$69455 73 13018 13942 14147 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69456 m0 *1 422.28,590.24
X$69456 73 14340 14038 14243 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69462 m0 *1 437,590.24
X$69462 73 12450 14237 13079 14339 73 14239 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $69463 m0 *1 439.76,590.24
X$69463 73 14238 14191 13621 12450 14339 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $69464 m0 *1 442.06,590.24
X$69464 73 12645 12378 12798 14191 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69470 m0 *1 456.32,590.24
X$69470 73 12450 12801 14296 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69472 m0 *1 461.38,590.24
X$69472 73 14296 14333 14193 13411 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $69473 m0 *1 463.22,590.24
X$69473 73 14194 12568 14233 14031 73 14193 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $69475 m0 *1 467.36,590.24
X$69475 73 13077 14298 14031 73 14299 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69482 m0 *1 475.18,590.24
X$69482 73 14330 14299 12496 73 14328 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69484 m0 *1 477.94,590.24
X$69484 73 14195 14134 13381 57 73 14230 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69485 m0 *1 479.78,590.24
X$69485 73 12644 12798 13929 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69499 m0 *1 513.36,590.24
X$69499 73 12414 13586 14300 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69500 m0 *1 514.74,590.24
X$69500 73 14300 12681 12210 57 73 14225 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69501 m0 *1 516.58,590.24
X$69501 73 12758 14301 14103 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69508 m0 *1 528.08,590.24
X$69508 73 14320 12577 14101 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69511 m0 *1 531.76,590.24
X$69511 73 14197 73 57 14304 57 sky130_fd_sc_hd__buf_4
* cell instance $69513 m0 *1 534.98,590.24
X$69513 73 12974 13385 12767 14401 14199 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $69516 m0 *1 541.88,590.24
X$69516 73 12281 14216 14202 12414 14200 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $69517 m0 *1 544.64,590.24
X$69517 73 13299 14322 13109 73 14216 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $69519 m0 *1 547.86,590.24
X$69519 73 12281 14399 14203 12874 12210 14202 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $69521 m0 *1 551.54,590.24
X$69521 73 14215 73 57 14320 57 sky130_fd_sc_hd__buf_4
* cell instance $69525 m0 *1 558.9,590.24
X$69525 73 14215 73 57 12581 57 sky130_fd_sc_hd__buf_4
* cell instance $69526 m0 *1 561.66,590.24
X$69526 73 12376 73 57 14204 57 sky130_fd_sc_hd__buf_4
* cell instance $69528 m0 *1 564.88,590.24
X$69528 73 14215 14204 14307 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69530 m0 *1 566.72,590.24
X$69530 73 14307 73 57 14205 57 sky130_fd_sc_hd__buf_4
* cell instance $69531 m0 *1 569.48,590.24
X$69531 73 12581 12765 14317 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69532 m0 *1 570.86,590.24
X$69532 73 14306 14317 13817 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69536 m0 *1 578.68,590.24
X$69536 57 14206 14314 12880 13704 12210 12577 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $69540 m0 *1 587.88,590.24
X$69540 73 14308 12979 14553 12210 14208 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $69542 m0 *1 591.1,590.24
X$69542 73 13108 14114 14003 14212 14310 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $69567 r0 *1 4.14,590.24
X$69567 73 14110 57 73 14352 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69577 r0 *1 22.08,590.24
X$69577 73 13544 14353 12478 73 14396 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69578 r0 *1 23.92,590.24
X$69578 73 13814 12396 11800 73 14311 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69579 r0 *1 25.76,590.24
X$69579 73 11879 14396 14311 14355 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $69583 r0 *1 30.82,590.24
X$69583 73 12371 13436 14353 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69586 r0 *1 33.58,590.24
X$69586 73 12080 73 57 14397 57 sky130_fd_sc_hd__buf_4
* cell instance $69588 r0 *1 37.26,590.24
X$69588 73 14262 73 57 14263 57 sky130_fd_sc_hd__buf_4
* cell instance $69590 r0 *1 40.94,590.24
X$69590 73 12396 73 57 14265 57 sky130_fd_sc_hd__buf_4
* cell instance $69596 r0 *1 45.08,590.24
X$69596 57 14315 14316 14264 14510 14353 14123 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $69602 r0 *1 63.48,590.24
X$69602 73 12478 14265 14318 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69604 r0 *1 66.7,590.24
X$69604 73 12002 12053 12335 14264 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69612 r0 *1 72.22,590.24
X$69612 73 14264 73 57 13719 57 sky130_fd_sc_hd__buf_4
* cell instance $69616 r0 *1 78.2,590.24
X$69616 73 13824 73 57 14356 57 sky130_fd_sc_hd__buf_4
* cell instance $69620 r0 *1 84.18,590.24
X$69620 73 12932 73 57 14060 57 sky130_fd_sc_hd__buf_4
* cell instance $69621 r0 *1 86.94,590.24
X$69621 73 13824 73 57 13960 57 sky130_fd_sc_hd__buf_4
* cell instance $69629 r0 *1 99.36,590.24
X$69629 73 12525 13884 14405 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69631 r0 *1 104.42,590.24
X$69631 73 12002 14130 14321 57 73 14490 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69634 r0 *1 107.64,590.24
X$69634 57 14406 11641 11834 14398 14268 14323 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $69646 r0 *1 134.32,590.24
X$69646 73 13664 14362 14408 73 14572 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69647 r0 *1 136.16,590.24
X$69647 73 14226 12810 14276 14409 57 14408 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $69649 r0 *1 139.84,590.24
X$69649 57 14270 14228 14324 12810 13834 14269 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $69650 r0 *1 143.06,590.24
X$69650 57 13834 14269 14271 14326 12689 12687 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $69651 r0 *1 146.28,590.24
X$69651 73 12843 14326 12689 14271 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $69654 r0 *1 149.5,590.24
X$69654 73 14272 12687 14273 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69655 r0 *1 150.88,590.24
X$69655 73 14272 73 57 13162 57 sky130_fd_sc_hd__buf_4
* cell instance $69661 r0 *1 154.56,590.24
X$69661 73 14273 73 57 14274 57 sky130_fd_sc_hd__buf_4
* cell instance $69662 r0 *1 157.32,590.24
X$69662 73 14327 73 57 12843 57 sky130_fd_sc_hd__buf_4
* cell instance $69664 r0 *1 161,590.24
X$69664 73 14273 73 57 13774 57 sky130_fd_sc_hd__buf_4
* cell instance $69666 r0 *1 164.22,590.24
X$69666 57 11956 12352 14275 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $69669 r0 *1 174.34,590.24
X$69669 73 14415 13011 13515 14362 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69675 r0 *1 178.48,590.24
X$69675 73 12391 12482 14276 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69678 r0 *1 182.16,590.24
X$69678 73 12605 12482 13737 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69683 r0 *1 193.66,590.24
X$69683 73 13509 13169 14155 14419 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $69685 r0 *1 197.34,590.24
X$69685 73 14181 14334 12687 12905 12841 13509 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $69686 r0 *1 200.56,590.24
X$69686 73 13357 12687 14365 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69687 r0 *1 201.94,590.24
X$69687 73 14180 14365 12807 73 13888 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69694 r0 *1 207,590.24
X$69694 73 14242 14338 14336 13670 57 73 14424 57 sky130_fd_sc_hd__a31oi_1
* cell instance $69699 r0 *1 215.74,590.24
X$69699 73 13432 73 57 14370 57 sky130_fd_sc_hd__buf_4
* cell instance $69700 r0 *1 218.5,590.24
X$69700 73 14180 73 57 14371 57 sky130_fd_sc_hd__buf_4
* cell instance $69703 r0 *1 224.02,590.24
X$69703 57 14341 12391 14424 14423 14366 12482 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $69726 r0 *1 268.64,590.24
X$69726 73 14183 14277 13673 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69729 r0 *1 274.16,590.24
X$69729 73 13062 12633 14277 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69730 r0 *1 275.54,590.24
X$69730 73 12943 14282 14278 14182 13890 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $69731 r0 *1 278.3,590.24
X$69731 73 12633 73 57 14182 57 sky130_fd_sc_hd__buf_4
* cell instance $69732 r0 *1 281.06,590.24
X$69732 73 13064 14346 14373 14344 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $69733 r0 *1 282.9,590.24
X$69733 73 13331 14281 14282 73 14346 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69734 r0 *1 284.74,590.24
X$69734 73 14282 13331 14281 14373 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $69741 r0 *1 290.26,590.24
X$69741 73 14183 14281 13758 13784 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69746 r0 *1 295.78,590.24
X$69746 73 14183 14284 14432 57 73 14431 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69751 r0 *1 304.52,590.24
X$69751 73 12953 73 57 14183 57 sky130_fd_sc_hd__buf_4
* cell instance $69759 r0 *1 316.94,590.24
X$69759 73 14286 73 57 14436 57 sky130_fd_sc_hd__buf_4
* cell instance $69761 r0 *1 320.16,590.24
X$69761 57 13363 14378 14286 12632 13868 12858 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $69764 r0 *1 324.76,590.24
X$69764 73 14187 13064 14286 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69769 r0 *1 335.8,590.24
X$69769 73 12563 14084 14434 14351 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $69779 r0 *1 352.36,590.24
X$69779 73 13985 14287 14285 14430 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69780 r0 *1 354.2,590.24
X$69780 73 13064 14430 13986 14429 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $69784 r0 *1 363.86,590.24
X$69784 57 4950 14345 11727 14347 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $69798 r0 *1 395.6,590.24
X$69798 73 14038 14288 13877 73 14428 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69800 r0 *1 399.28,590.24
X$69800 73 13790 13274 12608 14089 57 14249 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $69806 r0 *1 414,590.24
X$69806 73 14150 73 57 14288 57 sky130_fd_sc_hd__buf_4
* cell instance $69809 r0 *1 420.9,590.24
X$69809 73 14147 73 57 14421 57 sky130_fd_sc_hd__buf_4
* cell instance $69822 r0 *1 446.2,590.24
X$69822 73 12867 14293 14294 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69823 r0 *1 447.58,590.24
X$69823 57 14418 13940 13079 14294 12902 14384 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $69833 r0 *1 460,590.24
X$69833 73 13077 12798 14416 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69834 r0 *1 461.38,590.24
X$69834 73 14584 13080 14416 14295 57 73 14297 57 sky130_fd_sc_hd__a31oi_1
* cell instance $69835 r0 *1 463.68,590.24
X$69835 73 14332 13688 14290 14297 73 13410 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $69837 r0 *1 466.9,590.24
X$69837 73 13521 13621 14298 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69838 r0 *1 468.28,590.24
X$69838 73 14298 73 57 14293 57 sky130_fd_sc_hd__buf_4
* cell instance $69840 r0 *1 472.88,590.24
X$69840 73 14292 73 57 14413 57 sky130_fd_sc_hd__buf_4
* cell instance $69846 r0 *1 477.02,590.24
X$69846 73 14049 14329 14328 57 73 14411 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69868 r0 *1 522.1,590.24
X$69868 73 14302 73 57 14105 57 sky130_fd_sc_hd__buf_4
* cell instance $69871 r0 *1 529.46,590.24
X$69871 73 12217 14303 14403 14325 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $69876 r0 *1 532.22,590.24
X$69876 73 14304 14303 14305 57 73 14402 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69883 r0 *1 542.34,590.24
X$69883 73 14212 14305 14400 14217 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $69884 r0 *1 544.18,590.24
X$69884 73 13299 73 57 14305 57 sky130_fd_sc_hd__buf_4
* cell instance $69892 r0 *1 558.44,590.24
X$69892 73 14306 73 57 14388 57 sky130_fd_sc_hd__buf_4
* cell instance $69894 r0 *1 563.04,590.24
X$69894 73 12505 14204 14306 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $69896 r0 *1 565.34,590.24
X$69896 57 12502 13908 12210 14307 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $69900 r0 *1 569.48,590.24
X$69900 73 14390 14302 13908 13108 12281 73 13396 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $69901 r0 *1 572.7,590.24
X$69901 73 12581 13907 14391 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69902 r0 *1 574.08,590.24
X$69902 73 12878 14308 14205 73 14314 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69904 r0 *1 576.84,590.24
X$69904 73 12376 73 57 14308 57 sky130_fd_sc_hd__buf_4
* cell instance $69907 r0 *1 585.12,590.24
X$69907 73 14312 13389 14394 14313 73 12211 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $69912 r0 *1 589.26,590.24
X$69912 57 14212 14394 13091 14393 14309 14310 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $69914 r0 *1 592.94,590.24
X$69914 73 12217 73 57 13091 57 sky130_fd_sc_hd__buf_4
* cell instance $69952 m0 *1 23,595.68
X$69952 73 14395 14354 13101 73 14262 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69953 m0 *1 24.84,595.68
X$69953 73 12002 14437 13544 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69955 m0 *1 27.14,595.68
X$69955 73 12674 14476 14355 57 73 14354 57 sky130_fd_sc_hd__a21oi_1
* cell instance $69958 m0 *1 30.36,595.68
X$69958 73 11955 13545 14356 13765 12478 14476 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $69959 m0 *1 33.58,595.68
X$69959 73 14397 14356 11834 13706 14477 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $69963 m0 *1 44.16,595.68
X$69963 73 14353 14357 12932 14397 14358 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $69965 m0 *1 48.3,595.68
X$69965 73 14353 12992 14123 73 14481 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69971 m0 *1 63.48,595.68
X$69971 73 14360 14359 11955 14358 73 14398 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $69972 m0 *1 66.24,595.68
X$69972 73 14361 73 57 14360 57 sky130_fd_sc_hd__buf_4
* cell instance $69973 m0 *1 69,595.68
X$69973 73 13118 12397 13403 11955 57 14486 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $69975 m0 *1 72.22,595.68
X$69975 73 14064 13610 12002 73 14484 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $69976 m0 *1 74.06,595.68
X$69976 73 12397 14488 14172 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $69977 m0 *1 75.44,595.68
X$69977 73 14439 12056 13403 11955 57 14361 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $69978 m0 *1 78.2,595.68
X$69978 73 14439 73 57 13118 57 sky130_fd_sc_hd__buf_4
* cell instance $69980 m0 *1 81.88,595.68
X$69980 73 14516 13884 14060 13765 13494 14487 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $69986 m0 *1 95.68,595.68
X$69986 73 12056 73 57 13494 57 sky130_fd_sc_hd__buf_4
* cell instance $69990 m0 *1 103.5,595.68
X$69990 73 11637 73 57 14440 57 sky130_fd_sc_hd__buf_4
* cell instance $70002 m0 *1 136.16,595.68
X$70002 73 13556 12807 14441 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70003 m0 *1 137.54,595.68
X$70003 73 13556 13832 12687 14441 14363 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70005 m0 *1 140.76,595.68
X$70005 73 14442 12687 14363 12812 13966 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70012 m0 *1 161,595.68
X$70012 73 14270 12810 14494 57 73 14414 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70013 m0 *1 162.84,595.68
X$70013 73 13737 14414 14495 14364 14275 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70014 m0 *1 165.6,595.68
X$70014 73 14151 13418 14501 14364 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $70021 m0 *1 178.02,595.68
X$70021 73 14417 12810 14337 14855 13938 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $70024 m0 *1 181.7,595.68
X$70024 73 12807 14583 14242 73 14417 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70030 m0 *1 195.96,595.68
X$70030 73 13262 73 57 14500 57 sky130_fd_sc_hd__buf_4
* cell instance $70032 m0 *1 200.56,595.68
X$70032 73 12848 14365 14449 14448 73 57 14494 57 sky130_fd_sc_hd__o31ai_1
* cell instance $70035 m0 *1 204.7,595.68
X$70035 73 13051 14367 12848 73 14448 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70037 m0 *1 207,595.68
X$70037 73 14369 12843 13232 57 73 14367 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70038 m0 *1 208.84,595.68
X$70038 73 12812 14365 12841 12843 14369 14450 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $70039 m0 *1 212.06,595.68
X$70039 73 13169 14368 12813 12905 14369 14075 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $70042 m0 *1 217.58,595.68
X$70042 73 12807 13246 14370 12729 73 57 14337 57 sky130_fd_sc_hd__o31ai_1
* cell instance $70047 m0 *1 224.02,595.68
X$70047 73 13246 14371 12807 73 14372 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70048 m0 *1 225.86,595.68
X$70048 73 13780 14372 13744 57 73 14423 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70068 m0 *1 279.22,595.68
X$70068 73 13034 14597 13644 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70070 m0 *1 282.44,595.68
X$70070 73 14182 13034 13364 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $70073 m0 *1 287.04,595.68
X$70073 57 15555 14374 13748 13055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $70075 m0 *1 292.1,595.68
X$70075 73 14374 14282 14506 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70078 m0 *1 294.86,595.68
X$70078 73 14506 12736 14284 57 73 14375 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70079 m0 *1 296.7,595.68
X$70079 73 14433 12563 14432 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70085 m0 *1 306.82,595.68
X$70085 73 13062 12563 14183 14377 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70086 m0 *1 308.66,595.68
X$70086 73 14454 73 57 14285 57 sky130_fd_sc_hd__buf_4
* cell instance $70088 m0 *1 312.34,595.68
X$70088 73 12191 14507 13249 57 73 14609 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70091 m0 *1 316.48,595.68
X$70091 73 14436 14376 14507 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70092 m0 *1 317.86,595.68
X$70092 73 13981 12632 14452 13178 14376 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $70095 m0 *1 321.54,595.68
X$70095 73 14455 73 57 12740 57 sky130_fd_sc_hd__buf_4
* cell instance $70096 m0 *1 324.3,595.68
X$70096 73 14379 14455 14377 12563 14187 73 14260 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $70097 m0 *1 327.52,595.68
X$70097 73 14457 73 57 13542 57 sky130_fd_sc_hd__buf_4
* cell instance $70099 m0 *1 330.74,595.68
X$70099 73 13681 13868 14379 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70103 m0 *1 333.96,595.68
X$70103 73 12563 14434 14459 14435 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70104 m0 *1 335.8,595.68
X$70104 73 13178 12953 14434 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70107 m0 *1 342.7,595.68
X$70107 73 13681 13868 14459 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70109 m0 *1 345,595.68
X$70109 73 14459 73 57 12714 57 sky130_fd_sc_hd__buf_4
* cell instance $70128 m0 *1 393.3,595.68
X$70128 73 14428 14380 12568 14460 57 73 14381 57 sky130_fd_sc_hd__a31oi_1
* cell instance $70129 m0 *1 395.6,595.68
X$70129 73 12958 14426 14380 12608 14427 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70130 m0 *1 398.36,595.68
X$70130 73 13523 73 57 14380 57 sky130_fd_sc_hd__buf_4
* cell instance $70133 m0 *1 406.64,595.68
X$70133 73 12450 13329 14381 14247 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70138 m0 *1 416.76,595.68
X$70138 73 14463 73 57 14343 57 sky130_fd_sc_hd__buf_4
* cell instance $70139 m0 *1 419.52,595.68
X$70139 73 13877 14425 12647 14462 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70140 m0 *1 421.36,595.68
X$70140 73 12450 14422 14462 14504 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70141 m0 *1 423.2,595.68
X$70141 73 13521 13581 14291 14422 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70142 m0 *1 425.04,595.68
X$70142 73 12862 14382 13523 73 14292 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70146 m0 *1 430.1,595.68
X$70146 73 13522 73 57 13729 57 sky130_fd_sc_hd__buf_4
* cell instance $70147 m0 *1 432.86,595.68
X$70147 73 12867 14340 12866 13866 73 14383 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $70148 m0 *1 435.62,595.68
X$70148 73 13079 13184 14383 12450 14502 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70154 m0 *1 447.12,595.68
X$70154 73 12644 12798 12645 73 14384 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70158 m0 *1 458.16,595.68
X$70158 73 14499 73 57 14190 57 sky130_fd_sc_hd__buf_4
* cell instance $70166 m0 *1 473.8,595.68
X$70166 73 14195 14466 14467 57 73 14330 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70168 m0 *1 476.1,595.68
X$70168 73 14413 14230 12568 73 14329 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70170 m0 *1 478.86,595.68
X$70170 73 14497 13846 13001 14412 14385 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $70183 m0 *1 511.52,595.68
X$70183 73 14468 12876 14300 14410 57 14496 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $70186 m0 *1 517.04,595.68
X$70186 57 14105 14410 12681 14386 12876 12974 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $70187 m0 *1 520.26,595.68
X$70187 73 12763 13695 14407 73 14468 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70188 m0 *1 522.1,595.68
X$70188 73 14491 73 57 14407 57 sky130_fd_sc_hd__buf_4
* cell instance $70190 m0 *1 525.32,595.68
X$70190 73 12788 13695 14469 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70192 m0 *1 527.16,595.68
X$70192 73 12878 14386 14480 12876 14403 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70194 m0 *1 530.38,595.68
X$70194 73 14404 13586 12217 14402 57 73 13837 57 sky130_fd_sc_hd__a31oi_1
* cell instance $70197 m0 *1 534.06,595.68
X$70197 73 12680 14000 14470 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70198 m0 *1 535.44,595.68
X$70198 73 13188 14470 12876 73 14401 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70202 m0 *1 543.72,595.68
X$70202 73 13803 14387 14388 12210 14400 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70203 m0 *1 546.48,595.68
X$70203 73 12878 14387 14388 73 14322 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70204 m0 *1 548.32,595.68
X$70204 73 13807 14387 14399 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70205 m0 *1 549.7,595.68
X$70205 57 15569 14389 12874 12681 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $70211 m0 *1 563.5,595.68
X$70211 73 14389 73 57 12763 57 sky130_fd_sc_hd__buf_4
* cell instance $70212 m0 *1 566.26,595.68
X$70212 73 13471 13385 14309 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70215 m0 *1 569.94,595.68
X$70215 73 14390 14480 14391 12210 13477 73 14478 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $70216 m0 *1 573.16,595.68
X$70216 73 14389 12754 13296 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70217 m0 *1 574.54,595.68
X$70217 73 12788 14308 14302 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70225 m0 *1 588.8,595.68
X$70225 73 12283 14308 14392 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70226 m0 *1 590.18,595.68
X$70226 73 12210 13597 14392 57 73 14393 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70261 r0 *1 19.78,595.68
X$70261 73 12335 73 57 14437 57 sky130_fd_sc_hd__buf_4
* cell instance $70264 r0 *1 23.92,595.68
X$70264 73 12002 12397 14437 14438 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70266 r0 *1 26.68,595.68
X$70266 73 14438 73 57 13879 57 sky130_fd_sc_hd__buf_4
* cell instance $70279 r0 *1 53.82,595.68
X$70279 73 13550 14012 13882 14481 14514 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70285 r0 *1 67.16,595.68
X$70285 73 12371 13545 14485 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70286 r0 *1 68.54,595.68
X$70286 73 14484 14485 11955 14486 57 73 14560 57 sky130_fd_sc_hd__a31oi_1
* cell instance $70293 r0 *1 76.82,595.68
X$70293 73 11677 12551 14439 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70296 r0 *1 82.34,595.68
X$70296 57 14487 14489 11834 14119 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $70297 r0 *1 84.64,595.68
X$70297 73 12551 73 57 14488 57 sky130_fd_sc_hd__buf_4
* cell instance $70307 r0 *1 102.58,595.68
X$70307 73 14489 14440 13826 14490 14567 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $70311 r0 *1 110.86,595.68
X$70311 73 13120 12600 12002 73 14570 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70321 r0 *1 134.32,595.68
X$70321 57 15587 14442 13445 13834 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $70322 r0 *1 138.92,595.68
X$70322 73 14575 12689 13931 57 73 14574 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70324 r0 *1 141.68,595.68
X$70324 57 14366 14442 12810 14443 14444 73 73 57 sky130_fd_sc_hd__o31a_1
* cell instance $70327 r0 *1 147.66,595.68
X$70327 73 13356 73 57 14445 57 sky130_fd_sc_hd__buf_4
* cell instance $70332 r0 *1 158.24,595.68
X$70332 57 14446 14493 14179 13670 12807 13049 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $70333 r0 *1 161.46,595.68
X$70333 73 13737 14446 14525 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70336 r0 *1 164.22,595.68
X$70336 73 13262 14445 12687 57 73 14582 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70339 r0 *1 173.42,595.68
X$70339 73 13356 12687 14530 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70347 r0 *1 183.08,595.68
X$70347 73 14529 13737 12848 14447 73 13426 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $70352 r0 *1 198.26,595.68
X$70352 73 12848 14586 14917 14501 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $70353 r0 *1 200.56,595.68
X$70353 73 12807 14445 12687 57 73 14449 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70355 r0 *1 203.32,595.68
X$70355 57 14449 14586 12847 13670 13359 14157 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $70357 r0 *1 206.54,595.68
X$70357 73 12847 13232 12841 73 14369 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70360 r0 *1 209.76,595.68
X$70360 73 12627 13514 14155 57 73 14503 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70364 r0 *1 219.42,595.68
X$70364 73 14370 14368 12807 73 14591 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70385 r0 *1 269.1,595.68
X$70385 73 14183 14043 13673 73 14595 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70388 r0 *1 273.24,595.68
X$70388 57 14182 14505 12943 14282 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $70392 r0 *1 283.82,595.68
X$70392 73 14452 73 57 14184 57 sky130_fd_sc_hd__buf_4
* cell instance $70393 r0 *1 286.58,595.68
X$70393 73 14282 13364 14453 57 73 14604 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70395 r0 *1 288.42,595.68
X$70395 73 13338 12563 14453 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70401 r0 *1 296.7,595.68
X$70401 73 12158 14454 13758 73 14608 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70406 r0 *1 307.28,595.68
X$70406 73 13178 12736 14454 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70407 r0 *1 308.66,595.68
X$70407 73 13178 73 57 14433 57 sky130_fd_sc_hd__buf_4
* cell instance $70408 r0 *1 311.42,595.68
X$70408 73 14610 73 57 12188 57 sky130_fd_sc_hd__buf_4
* cell instance $70415 r0 *1 322.92,595.68
X$70415 73 12950 14456 14606 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70416 r0 *1 324.3,595.68
X$70416 73 13981 14377 14456 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70420 r0 *1 330.74,595.68
X$70420 73 14379 73 57 14458 57 sky130_fd_sc_hd__buf_4
* cell instance $70423 r0 *1 337.64,595.68
X$70423 73 13748 13868 13981 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70427 r0 *1 344.54,595.68
X$70427 73 14602 14349 14508 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70431 r0 *1 347.76,595.68
X$70431 73 14508 13334 14716 14599 13540 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $70447 r0 *1 393.76,595.68
X$70447 73 12568 14594 13524 73 14460 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70449 r0 *1 395.6,595.68
X$70449 73 14160 73 57 13577 57 sky130_fd_sc_hd__buf_4
* cell instance $70456 r0 *1 406.18,595.68
X$70456 73 13989 14539 13942 57 73 14426 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70459 r0 *1 412.16,595.68
X$70459 73 13073 14041 14461 14589 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $70461 r0 *1 415.84,595.68
X$70461 73 14425 14291 13877 73 14461 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70464 r0 *1 421.82,595.68
X$70464 73 14504 12450 13275 57 73 14588 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70467 r0 *1 427.34,595.68
X$70467 73 12747 73 57 14464 57 sky130_fd_sc_hd__buf_4
* cell instance $70473 r0 *1 440.22,595.68
X$70473 73 12747 13793 14465 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70475 r0 *1 442.06,595.68
X$70475 73 14465 73 57 14418 57 sky130_fd_sc_hd__buf_4
* cell instance $70478 r0 *1 446.2,595.68
X$70478 73 13185 12867 12642 57 73 14585 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70484 r0 *1 454.94,595.68
X$70484 73 13016 13621 14340 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70492 r0 *1 468.28,595.68
X$70492 73 13846 14498 14418 14499 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70493 r0 *1 470.12,595.68
X$70493 73 13901 14466 14467 57 73 14498 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70494 r0 *1 471.96,595.68
X$70494 73 13186 12695 13902 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70513 r0 *1 514.28,595.68
X$70513 57 12997 14751 14496 14492 12217 12415 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $70515 r0 *1 518.42,595.68
X$70515 73 13310 12210 13842 14578 57 14492 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $70519 r0 *1 529,595.68
X$70519 73 14469 73 57 14301 57 sky130_fd_sc_hd__buf_4
* cell instance $70521 r0 *1 531.76,595.68
X$70521 73 14301 14545 12210 73 14303 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70523 r0 *1 534.06,595.68
X$70523 73 14470 73 57 14543 57 sky130_fd_sc_hd__buf_4
* cell instance $70527 r0 *1 544.64,595.68
X$70527 73 12763 12376 14471 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70528 r0 *1 546.02,595.68
X$70528 73 14471 73 57 13194 57 sky130_fd_sc_hd__buf_4
* cell instance $70529 r0 *1 548.78,595.68
X$70529 73 14320 14387 14302 73 14472 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70530 r0 *1 550.62,595.68
X$70530 73 12210 14545 14399 14474 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $70531 r0 *1 552.92,595.68
X$70531 73 13109 14472 14474 73 14473 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70532 r0 *1 554.76,595.68
X$70532 73 14563 14212 14473 57 73 14017 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70534 r0 *1 557.52,595.68
X$70534 73 14483 14475 14562 13704 12653 73 13697 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $70536 r0 *1 560.74,595.68
X$70536 73 12788 13805 14482 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70538 r0 *1 562.58,595.68
X$70538 73 14482 14558 12281 73 14475 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70540 r0 *1 565.34,595.68
X$70540 73 13385 73 57 14561 57 sky130_fd_sc_hd__buf_4
* cell instance $70544 r0 *1 570.86,595.68
X$70544 73 14479 73 57 12143 57 sky130_fd_sc_hd__buf_4
* cell instance $70632 m0 *1 21.16,601.12
X$70632 73 11800 14509 14659 14551 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70634 m0 *1 24.84,601.12
X$70634 73 12793 73 57 14509 57 sky130_fd_sc_hd__buf_4
* cell instance $70640 m0 *1 32.66,601.12
X$70640 73 13765 11800 12335 73 14661 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70643 m0 *1 36.8,601.12
X$70643 73 14552 73 57 14007 57 sky130_fd_sc_hd__buf_4
* cell instance $70647 m0 *1 45.54,601.12
X$70647 73 14397 12335 14510 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70648 m0 *1 46.92,601.12
X$70648 57 11955 14555 11834 14510 13394 14666 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $70650 m0 *1 51.98,601.12
X$70650 57 14520 13259 14511 14512 14555 73 73 57 sky130_fd_sc_hd__nor4b_2
* cell instance $70654 m0 *1 59.34,601.12
X$70654 57 14266 14512 12520 14557 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $70655 m0 *1 61.64,601.12
X$70655 73 13879 14123 14513 13546 73 14557 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $70656 m0 *1 64.86,601.12
X$70656 73 13545 12478 12373 57 73 14559 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70658 m0 *1 67.62,601.12
X$70658 73 14612 13118 14515 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70660 m0 *1 70.84,601.12
X$70660 73 12002 14559 14516 14515 14668 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70661 m0 *1 73.6,601.12
X$70661 73 14517 12397 11641 11955 57 14516 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $70662 m0 *1 76.36,601.12
X$70662 73 14123 13546 14517 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70663 m0 *1 77.74,601.12
X$70663 73 14517 73 57 14064 57 sky130_fd_sc_hd__buf_4
* cell instance $70664 m0 *1 80.5,601.12
X$70664 57 15499 14565 12053 12371 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $70667 m0 *1 86.02,601.12
X$70667 73 14488 13042 14673 12179 14564 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70669 m0 *1 89.24,601.12
X$70669 73 11955 14519 14564 14566 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $70670 m0 *1 91.08,601.12
X$70670 57 14567 14675 11804 14520 14518 12340 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $70675 m0 *1 104.88,601.12
X$70675 73 12057 73 57 13261 57 sky130_fd_sc_hd__buf_4
* cell instance $70682 m0 *1 115.92,601.12
X$70682 57 4950 11553 12352 14569 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $70686 m0 *1 133.4,601.12
X$70686 73 14521 14573 14572 14067 73 12481 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $70689 m0 *1 137.08,601.12
X$70689 57 14575 14441 14577 12689 14683 12687 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $70691 m0 *1 140.76,601.12
X$70691 57 14577 14522 12807 13834 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $70692 m0 *1 145.36,601.12
X$70692 73 14684 73 57 12813 57 sky130_fd_sc_hd__buf_4
* cell instance $70693 m0 *1 148.12,601.12
X$70693 57 15486 13446 12841 13834 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $70695 m0 *1 153.64,601.12
X$70695 57 14522 14524 12810 13446 12687 14523 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $70696 m0 *1 156.86,601.12
X$70696 73 13123 14524 14579 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70698 m0 *1 158.7,601.12
X$70698 73 14525 14526 14579 14687 13780 14521 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $70699 m0 *1 161.92,601.12
X$70699 73 14580 12807 14582 57 73 14526 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70701 m0 *1 164.22,601.12
X$70701 57 14527 14628 12810 13123 14523 14690 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $70704 m0 *1 168.36,601.12
X$70704 73 13556 12841 14528 73 14523 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70707 m0 *1 171.58,601.12
X$70707 73 14528 73 57 14334 57 sky130_fd_sc_hd__buf_4
* cell instance $70710 m0 *1 178.48,601.12
X$70710 73 14527 73 57 14529 57 sky130_fd_sc_hd__buf_4
* cell instance $70711 m0 *1 181.24,601.12
X$70711 73 14632 73 57 14583 57 sky130_fd_sc_hd__buf_4
* cell instance $70712 m0 *1 184,601.12
X$70712 73 14530 73 57 14074 57 sky130_fd_sc_hd__buf_4
* cell instance $70719 m0 *1 197.8,601.12
X$70719 73 12807 13232 14071 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70724 m0 *1 207.92,601.12
X$70724 73 12812 14587 14450 73 14447 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70729 m0 *1 219.88,601.12
X$70729 57 12807 14532 14591 14371 14500 14590 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $70734 m0 *1 226.78,601.12
X$70734 73 14532 14592 14503 14593 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $70748 m0 *1 270.48,601.12
X$70748 73 14082 14282 14043 14704 13056 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $70750 m0 *1 274.62,601.12
X$70750 73 14596 73 57 14597 57 sky130_fd_sc_hd__buf_4
* cell instance $70755 m0 *1 283.36,601.12
X$70755 73 13061 14184 14082 73 14603 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70758 m0 *1 290.72,601.12
X$70758 73 14282 14605 13064 14604 57 14348 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $70762 m0 *1 299.46,601.12
X$70762 73 14607 14611 14708 13955 57 14533 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $70768 m0 *1 310.5,601.12
X$70768 73 14533 11790 14871 14609 14610 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $70769 m0 *1 312.8,601.12
X$70769 73 12923 73 57 13957 57 sky130_fd_sc_hd__buf_4
* cell instance $70771 m0 *1 319.24,601.12
X$70771 73 13748 14452 13861 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70774 m0 *1 322.92,601.12
X$70774 57 14606 14457 13677 13861 14534 14791 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $70775 m0 *1 326.14,601.12
X$70775 73 14535 73 57 14534 57 sky130_fd_sc_hd__buf_4
* cell instance $70783 m0 *1 345.46,601.12
X$70783 73 13985 14601 12714 14602 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70786 m0 *1 348.68,601.12
X$70786 73 14535 73 57 14599 57 sky130_fd_sc_hd__buf_4
* cell instance $70791 m0 *1 358.34,601.12
X$70791 73 13985 13983 14458 14187 14598 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $70806 m0 *1 392.38,601.12
X$70806 73 13375 12958 12866 14425 57 73 14594 57 sky130_fd_sc_hd__a31oi_1
* cell instance $70812 m0 *1 411.24,601.12
X$70812 73 14538 73 57 14295 57 sky130_fd_sc_hd__buf_4
* cell instance $70813 m0 *1 414,601.12
X$70813 73 13074 13372 14425 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $70817 m0 *1 424.12,601.12
X$70817 73 14539 13018 13372 14291 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70821 m0 *1 429.18,601.12
X$70821 73 13079 13621 14382 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70831 m0 *1 452.64,601.12
X$70831 73 12695 13374 14540 13512 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $70835 m0 *1 460.92,601.12
X$70835 73 13729 14541 14584 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70836 m0 *1 462.3,601.12
X$70836 73 12871 14541 14466 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70845 m0 *1 478.86,601.12
X$70845 57 15504 13467 13901 12644 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $70858 m0 *1 513.82,601.12
X$70858 73 14014 73 57 14581 57 sky130_fd_sc_hd__buf_4
* cell instance $70859 m0 *1 516.58,601.12
X$70859 73 14581 14542 12210 73 14224 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70860 m0 *1 518.42,601.12
X$70860 73 14386 13803 12210 14653 57 14578 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $70861 m0 *1 521.18,601.12
X$70861 73 13803 14386 14542 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70866 m0 *1 529,601.12
X$70866 73 14543 14542 12210 73 14544 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70867 m0 *1 530.84,601.12
X$70867 73 12974 12376 14576 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70868 m0 *1 532.22,601.12
X$70868 73 14544 14571 12281 12569 57 14546 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $70872 m0 *1 540.04,601.12
X$70872 73 13109 14471 14543 14568 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70876 m0 *1 549.7,601.12
X$70876 73 14681 14480 14212 12210 14022 73 14563 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $70884 m0 *1 566.26,601.12
X$70884 73 12283 14561 14556 73 14558 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70887 m0 *1 569.48,601.12
X$70887 73 12505 14547 14556 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70888 m0 *1 570.86,601.12
X$70888 73 14478 14554 14546 14479 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70890 m0 *1 573.62,601.12
X$70890 73 12765 73 57 14547 57 sky130_fd_sc_hd__buf_4
* cell instance $70891 m0 *1 576.38,601.12
X$70891 73 13289 73 57 14491 57 sky130_fd_sc_hd__buf_4
* cell instance $70892 m0 *1 579.14,601.12
X$70892 73 14548 73 57 14553 57 sky130_fd_sc_hd__buf_4
* cell instance $70898 m0 *1 591.1,601.12
X$70898 73 12210 13479 13909 14550 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $70899 m0 *1 592.94,601.12
X$70899 73 14550 14549 14658 12583 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $70931 r0 *1 20.7,601.12
X$70931 73 14612 14437 14659 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70933 r0 *1 23,601.12
X$70933 73 14613 14612 14437 57 73 14660 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70936 r0 *1 27.14,601.12
X$70936 73 14613 13814 11800 73 14552 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70939 r0 *1 33.12,601.12
X$70939 73 11955 12674 14615 14661 13705 73 57 57 sky130_fd_sc_hd__a31o_2
* cell instance $70942 r0 *1 40.48,601.12
X$70942 73 14616 12478 14665 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70946 r0 *1 44.16,601.12
X$70946 73 14665 14617 11955 73 14666 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70947 r0 *1 46,601.12
X$70947 73 14123 13157 14509 14617 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $70955 r0 *1 63.02,601.12
X$70955 73 12057 73 57 14513 57 sky130_fd_sc_hd__buf_4
* cell instance $70956 r0 *1 65.78,601.12
X$70956 73 14171 57 73 14569 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70957 r0 *1 69.46,601.12
X$70957 73 14618 14560 11641 73 14619 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70960 r0 *1 71.76,601.12
X$70960 73 14514 12674 14668 14619 73 14518 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $70963 r0 *1 76.36,601.12
X$70963 73 14123 14488 14173 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70966 r0 *1 82.34,601.12
X$70966 73 14565 14488 14670 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70968 r0 *1 84.64,601.12
X$70968 73 14565 14488 14673 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70972 r0 *1 92.46,601.12
X$70972 73 11684 12520 14671 57 73 14675 57 sky130_fd_sc_hd__a21oi_1
* cell instance $70982 r0 *1 109.94,601.12
X$70982 73 13546 13829 14680 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $70983 r0 *1 111.32,601.12
X$70983 73 14570 14133 14680 12179 57 73 14679 57 sky130_fd_sc_hd__a31oi_1
* cell instance $70993 r0 *1 135.24,601.12
X$70993 73 14622 14682 14151 73 14573 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $70996 r0 *1 139.38,601.12
X$70996 73 12812 14574 14622 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $70997 r0 *1 140.76,601.12
X$70997 73 12687 14445 13445 57 73 14683 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71007 r0 *1 162.38,601.12
X$71007 73 12807 14274 14686 14580 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $71008 r0 *1 164.22,601.12
X$71008 73 12807 14582 14629 73 14690 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71009 r0 *1 166.06,601.12
X$71009 73 14633 12807 14631 57 73 14629 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71011 r0 *1 169.74,601.12
X$71011 73 13232 13556 12934 57 73 14528 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71014 r0 *1 172.96,601.12
X$71014 73 13736 73 57 13124 57 sky130_fd_sc_hd__buf_4
* cell instance $71015 r0 *1 175.72,601.12
X$71015 73 14530 73 57 14777 57 sky130_fd_sc_hd__buf_4
* cell instance $71017 r0 *1 178.48,601.12
X$71017 57 14696 14693 12807 12848 14143 14632 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $71019 r0 *1 182.16,601.12
X$71019 73 14633 14070 14632 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71024 r0 *1 192.28,601.12
X$71024 73 14696 14635 12810 73 14697 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71026 r0 *1 197.8,601.12
X$71026 73 14071 12934 12809 13359 57 14635 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $71027 r0 *1 200.56,601.12
X$71027 73 12847 14637 13359 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71032 r0 *1 209.76,601.12
X$71032 73 12810 14531 14420 14698 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $71033 r0 *1 211.6,601.12
X$71033 73 12807 14637 13779 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71034 r0 *1 212.98,601.12
X$71034 73 12841 13451 14074 14531 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $71056 r0 *1 269.1,601.12
X$71056 73 13673 13338 14596 57 73 14703 57 sky130_fd_sc_hd__a21boi_0
* cell instance $71057 r0 *1 271.86,601.12
X$71057 73 13055 13748 12563 14704 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $71060 r0 *1 276,601.12
X$71060 73 12941 14638 14596 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71061 r0 *1 277.38,601.12
X$71061 73 14638 73 57 14706 57 sky130_fd_sc_hd__buf_4
* cell instance $71063 r0 *1 281.98,601.12
X$71063 73 12563 12953 14638 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71067 r0 *1 287.5,601.12
X$71067 57 15669 14605 14182 12950 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $71070 r0 *1 293.02,601.12
X$71070 73 14182 14082 14639 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71072 r0 *1 295.32,601.12
X$71072 73 13338 14182 12158 14640 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $71074 r0 *1 298.08,601.12
X$71074 73 14081 14639 14640 73 14709 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71076 r0 *1 300.84,601.12
X$71076 73 14709 12487 12384 14712 57 14708 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $71079 r0 *1 305.9,601.12
X$71079 73 14600 12858 14713 12563 14082 73 14712 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $71080 r0 *1 309.12,601.12
X$71080 73 12563 14455 14458 57 73 14713 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71091 r0 *1 328.9,601.12
X$71091 73 14642 14795 12158 14536 57 73 14611 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71092 r0 *1 331.2,601.12
X$71092 73 13566 13681 14718 14717 57 14259 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $71094 r0 *1 334.88,601.12
X$71094 73 13985 13951 12715 14642 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $71103 r0 *1 348.22,601.12
X$71103 73 14600 12715 13985 14537 57 73 14716 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71105 r0 *1 350.98,601.12
X$71105 73 13985 13981 14643 14537 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $71106 r0 *1 352.82,601.12
X$71106 73 12563 14714 14715 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71107 r0 *1 354.2,601.12
X$71107 73 13064 12487 14598 14536 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $71123 r0 *1 395.6,601.12
X$71123 73 14425 14160 13877 73 14644 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71124 r0 *1 397.44,601.12
X$71124 73 14464 13866 14711 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71125 r0 *1 398.82,601.12
X$71125 73 14710 14711 14707 12568 12450 73 14251 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $71128 r0 *1 402.96,601.12
X$71128 73 13942 73 57 13372 57 sky130_fd_sc_hd__buf_4
* cell instance $71131 r0 *1 413.08,601.12
X$71131 73 14646 13073 13074 13790 73 14647 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $71132 r0 *1 416.3,601.12
X$71132 73 14647 14589 12608 14049 57 73 14705 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71137 r0 *1 426.88,601.12
X$71137 73 14382 73 57 14648 57 sky130_fd_sc_hd__buf_4
* cell instance $71140 r0 *1 430.56,601.12
X$71140 73 12871 73 57 14539 57 sky130_fd_sc_hd__buf_4
* cell instance $71142 r0 *1 435.16,601.12
X$71142 73 13522 14293 14701 73 14463 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71147 r0 *1 443.9,601.12
X$71147 73 12798 13374 14540 14702 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $71151 r0 *1 448.96,601.12
X$71151 73 12866 12798 12964 73 14699 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71154 r0 *1 451.72,601.12
X$71154 73 13186 13521 14540 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71158 r0 *1 456.32,601.12
X$71158 73 12644 13896 15375 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71161 r0 *1 460,601.12
X$71161 73 13186 13990 15323 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71164 r0 *1 463.68,601.12
X$71164 73 12871 73 57 14650 57 sky130_fd_sc_hd__buf_4
* cell instance $71167 r0 *1 468.74,601.12
X$71167 73 13729 12798 14695 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71170 r0 *1 474.72,601.12
X$71170 73 13846 12798 14232 57 73 14694 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71174 r0 *1 478.86,601.12
X$71174 73 14651 13374 13618 14541 13688 73 14692 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $71175 r0 *1 482.08,601.12
X$71175 73 14541 14651 14691 57 73 14497 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71176 r0 *1 483.92,601.12
X$71176 73 13727 14195 14651 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71187 r0 *1 510.14,601.12
X$71187 73 14688 73 57 12999 57 sky130_fd_sc_hd__buf_4
* cell instance $71191 r0 *1 516.12,601.12
X$71191 73 14653 14581 12210 73 14689 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71196 r0 *1 524.86,601.12
X$71196 73 14576 73 57 14653 57 sky130_fd_sc_hd__buf_4
* cell instance $71197 r0 *1 527.62,601.12
X$71197 57 14386 14548 13803 73 73 57 sky130_fd_sc_hd__nand2b_4
* cell instance $71200 r0 *1 533.6,601.12
X$71200 73 12680 73 57 14685 57 sky130_fd_sc_hd__buf_4
* cell instance $71205 r0 *1 541.42,601.12
X$71205 73 12788 14755 13921 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71208 r0 *1 547.4,601.12
X$71208 73 14846 73 57 12980 57 sky130_fd_sc_hd__buf_4
* cell instance $71212 r0 *1 553.38,601.12
X$71212 73 14681 73 57 14770 57 sky130_fd_sc_hd__buf_4
* cell instance $71216 r0 *1 558.44,601.12
X$71216 73 14677 12788 14212 13921 57 14676 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $71222 r0 *1 568.56,601.12
X$71222 57 14669 12788 14667 14309 14672 14547 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $71223 r0 *1 572.24,601.12
X$71223 73 14304 14667 14767 73 14554 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71224 r0 *1 574.08,601.12
X$71224 73 13109 73 57 13108 57 sky130_fd_sc_hd__buf_4
* cell instance $71225 r0 *1 576.84,601.12
X$71225 73 12210 13296 14576 14664 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $71227 r0 *1 580.52,601.12
X$71227 73 14576 73 57 14106 57 sky130_fd_sc_hd__buf_4
* cell instance $71228 r0 *1 583.28,601.12
X$71228 73 13289 13909 14664 12210 14212 73 14663 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $71231 r0 *1 587.42,601.12
X$71231 73 14302 73 57 14662 57 sky130_fd_sc_hd__buf_4
* cell instance $71233 r0 *1 593.86,601.12
X$71233 73 13108 13597 14662 14549 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $71315 m0 *1 22.08,606.56
X$71315 73 14719 73 57 14004 57 sky130_fd_sc_hd__buf_4
* cell instance $71317 m0 *1 25.76,606.56
X$71317 73 14720 73 57 14613 57 sky130_fd_sc_hd__buf_4
* cell instance $71322 m0 *1 32.2,606.56
X$71322 73 11955 14552 14614 57 73 14765 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71323 m0 *1 34.04,606.56
X$71323 73 11834 14616 14064 57 73 14614 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71324 m0 *1 35.88,606.56
X$71324 73 14616 73 57 14612 57 sky130_fd_sc_hd__buf_4
* cell instance $71326 m0 *1 39.1,606.56
X$71326 73 13655 73 57 14616 57 sky130_fd_sc_hd__buf_4
* cell instance $71330 m0 *1 49.68,606.56
X$71330 73 12397 11677 14721 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71331 m0 *1 51.06,606.56
X$71331 73 14721 73 57 12782 57 sky130_fd_sc_hd__buf_4
* cell instance $71340 m0 *1 77.28,606.56
X$71340 73 14488 73 57 14726 57 sky130_fd_sc_hd__buf_4
* cell instance $71341 m0 *1 80.04,606.56
X$71341 73 14726 14727 12930 14670 57 73 14671 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71342 m0 *1 82.34,606.56
X$71342 73 11677 73 57 14727 57 sky130_fd_sc_hd__buf_4
* cell instance $71347 m0 *1 88.78,606.56
X$71347 73 13259 14802 14679 14674 73 57 57 sky130_fd_sc_hd__or3_1
* cell instance $71353 m0 *1 101.66,606.56
X$71353 73 14406 13717 14771 14440 57 73 14678 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71355 m0 *1 107.64,606.56
X$71355 73 11834 11879 12520 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71365 m0 *1 133.86,606.56
X$71365 73 14624 14728 14028 57 73 14621 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71366 m0 *1 135.7,606.56
X$71366 73 12810 14623 14621 14682 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $71367 m0 *1 137.54,606.56
X$71367 73 14684 73 57 14624 57 sky130_fd_sc_hd__buf_4
* cell instance $71369 m0 *1 140.76,606.56
X$71369 73 12807 12687 14684 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71375 m0 *1 157.32,606.56
X$71375 73 14625 13419 14626 12807 12810 73 14687 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $71378 m0 *1 165.14,606.56
X$71378 73 12807 14627 14626 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71379 m0 *1 166.52,606.56
X$71379 73 13232 14630 14631 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71382 m0 *1 168.82,606.56
X$71382 73 14179 14734 14630 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71383 m0 *1 170.2,606.56
X$71383 73 14630 73 57 14175 57 sky130_fd_sc_hd__buf_4
* cell instance $71384 m0 *1 172.96,606.56
X$71384 73 14777 14733 14627 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71388 m0 *1 177.56,606.56
X$71388 73 12807 14777 14693 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71390 m0 *1 179.86,606.56
X$71390 73 12605 12482 14151 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71394 m0 *1 186.3,606.56
X$71394 73 14779 14951 14780 14634 73 12533 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $71397 m0 *1 192.74,606.56
X$71397 73 14697 14419 14783 14634 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $71402 m0 *1 197.34,606.56
X$71402 57 14782 12841 13359 13448 14636 12810 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $71403 m0 *1 201.02,606.56
X$71403 73 14739 14445 14335 57 73 14636 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71412 m0 *1 225.4,606.56
X$71412 73 12841 14451 12847 14157 73 14700 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $71432 m0 *1 279.22,606.56
X$71432 73 14280 13055 14791 57 73 14790 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71448 m0 *1 320.62,606.56
X$71448 73 14641 14378 14873 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71449 m0 *1 322,606.56
X$71449 73 12563 13539 13951 57 73 14641 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71453 m0 *1 332.12,606.56
X$71453 73 12923 14742 14718 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71458 m0 *1 345,606.56
X$71458 73 13677 13982 13951 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71460 m0 *1 348.22,606.56
X$71460 73 13681 13982 14643 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71463 m0 *1 352.36,606.56
X$71463 73 12717 73 57 14535 57 sky130_fd_sc_hd__buf_4
* cell instance $71483 m0 *1 401.58,606.56
X$71483 73 12568 14645 14707 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71484 m0 *1 402.96,606.56
X$71484 73 14644 73 57 14792 57 sky130_fd_sc_hd__buf_4
* cell instance $71496 m0 *1 427.34,606.56
X$71496 73 13522 13990 14646 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $71499 m0 *1 434.24,606.56
X$71499 73 14699 14744 14384 14340 14645 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $71502 m0 *1 441.14,606.56
X$71502 73 13993 13896 14702 12608 14789 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $71504 m0 *1 444.36,606.56
X$71504 73 13990 14540 14649 14701 14788 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $71506 m0 *1 448.04,606.56
X$71506 73 13018 13990 14649 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71508 m0 *1 449.88,606.56
X$71508 73 14699 14747 12803 73 57 57 sky130_fd_sc_hd__or2_2
* cell instance $71511 m0 *1 453.56,606.56
X$71511 73 12964 14749 14540 73 14750 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71512 m0 *1 455.4,606.56
X$71512 73 14786 12798 14750 57 73 13898 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71515 m0 *1 461.38,606.56
X$71515 73 14650 13018 14749 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71516 m0 *1 462.76,606.56
X$71516 73 14466 73 57 14784 57 sky130_fd_sc_hd__buf_4
* cell instance $71525 m0 *1 481.62,606.56
X$71525 73 13993 13901 14691 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71538 m0 *1 511.98,606.56
X$71538 73 14652 14778 12892 73 13615 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71541 m0 *1 515.2,606.56
X$71541 73 14752 14689 13586 14852 57 73 14688 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71542 m0 *1 517.5,606.56
X$71542 73 13803 12577 14776 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71543 m0 *1 518.88,606.56
X$71543 73 14685 12876 12767 73 14652 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71548 m0 *1 527.16,606.56
X$71548 73 12876 14469 13216 14849 73 57 14404 57 sky130_fd_sc_hd__o31ai_1
* cell instance $71549 m0 *1 529.92,606.56
X$71549 73 14469 73 57 14754 57 sky130_fd_sc_hd__buf_4
* cell instance $71550 m0 *1 532.68,606.56
X$71550 73 14469 13216 12876 73 14571 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71553 m0 *1 541.88,606.56
X$71553 73 14756 73 57 14203 57 sky130_fd_sc_hd__buf_4
* cell instance $71555 m0 *1 545.1,606.56
X$71555 73 14654 14758 12210 57 73 14752 57 sky130_fd_sc_hd__a21o_1
* cell instance $71557 m0 *1 548.32,606.56
X$71557 73 13807 14387 14758 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71558 m0 *1 549.7,606.56
X$71558 73 14681 73 57 14654 57 sky130_fd_sc_hd__buf_4
* cell instance $71559 m0 *1 552.46,606.56
X$71559 73 12210 14757 14770 57 73 14021 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71561 m0 *1 554.76,606.56
X$71561 73 12876 14548 14770 14759 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $71563 m0 *1 557.52,606.56
X$71563 73 14759 14655 14676 14212 13704 73 14562 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $71566 m0 *1 564.88,606.56
X$71566 73 13108 12376 14656 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71567 m0 *1 566.26,606.56
X$71567 73 14203 14656 14669 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71568 m0 *1 567.64,606.56
X$71568 73 14656 73 57 13907 57 sky130_fd_sc_hd__buf_4
* cell instance $71571 m0 *1 571.78,606.56
X$71571 73 13108 13188 13296 73 14760 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $71577 m0 *1 583.74,606.56
X$71577 57 12210 14312 14763 14106 14657 12767 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $71578 m0 *1 586.96,606.56
X$71578 73 14545 73 57 14657 57 sky130_fd_sc_hd__buf_4
* cell instance $71615 r0 *1 23.46,606.56
X$71615 73 11800 11955 14796 14719 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $71619 r0 *1 28.52,606.56
X$71619 73 14720 12335 14797 57 73 14796 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71620 r0 *1 30.36,606.56
X$71620 73 12337 12335 14720 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71623 r0 *1 34.04,606.56
X$71623 73 14477 14765 14766 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71626 r0 *1 36.8,606.56
X$71626 73 14720 73 57 13157 57 sky130_fd_sc_hd__buf_4
* cell instance $71632 r0 *1 46,606.56
X$71632 73 14123 14509 14265 14723 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $71635 r0 *1 49.22,606.56
X$71635 73 13655 12335 12991 73 14798 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71636 r0 *1 51.06,606.56
X$71636 73 14721 73 57 14722 57 sky130_fd_sc_hd__buf_4
* cell instance $71637 r0 *1 53.82,606.56
X$71637 57 14841 14802 14801 14723 12177 14722 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $71639 r0 *1 60.72,606.56
X$71639 73 12478 13546 14012 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71642 r0 *1 64.86,606.56
X$71642 57 14620 13347 14064 12397 14724 14612 13118 73 73 57
+ sky130_fd_sc_hd__a222oi_1
* cell instance $71643 r0 *1 68.54,606.56
X$71643 73 12002 14173 14012 73 14724 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71648 r0 *1 72.22,606.56
X$71648 73 12002 14012 14725 57 73 14618 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71650 r0 *1 74.98,606.56
X$71650 73 14726 14722 14725 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71653 r0 *1 77.74,606.56
X$71653 73 13349 73 57 14840 57 sky130_fd_sc_hd__buf_4
* cell instance $71654 r0 *1 80.5,606.56
X$71654 73 12373 14265 14727 73 14769 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71667 r0 *1 115,606.56
X$71667 73 14847 73 57 14772 57 sky130_fd_sc_hd__buf_4
* cell instance $71678 r0 *1 135.7,606.56
X$71678 73 13834 12689 14728 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71679 r0 *1 137.08,606.56
X$71679 73 12689 14774 14728 73 14848 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71682 r0 *1 141.22,606.56
X$71682 73 14729 14730 13351 12689 57 73 14444 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71683 r0 *1 143.52,606.56
X$71683 73 13556 13051 14729 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71684 r0 *1 144.9,606.56
X$71684 73 12601 73 57 14731 57 sky130_fd_sc_hd__buf_4
* cell instance $71686 r0 *1 149.5,606.56
X$71686 73 13834 14731 13232 14732 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $71692 r0 *1 155.48,606.56
X$71692 73 14732 73 57 14733 57 sky130_fd_sc_hd__buf_4
* cell instance $71695 r0 *1 162.84,606.56
X$71695 73 14911 14155 13444 14177 57 73 14856 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71696 r0 *1 165.14,606.56
X$71696 73 12807 12842 13263 57 73 14735 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71697 r0 *1 166.98,606.56
X$71697 73 14631 73 57 14686 57 sky130_fd_sc_hd__buf_4
* cell instance $71700 r0 *1 171.12,606.56
X$71700 73 13736 73 57 14734 57 sky130_fd_sc_hd__buf_4
* cell instance $71708 r0 *1 184.92,606.56
X$71708 73 14735 14736 14856 14995 14780 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $71709 r0 *1 187.68,606.56
X$71709 73 12482 12605 14812 15043 12809 73 14779 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $71710 r0 *1 190.9,606.56
X$71710 73 14782 14737 12809 73 14812 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71713 r0 *1 195.5,606.56
X$71713 73 14633 13451 12807 73 14858 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71716 r0 *1 198.72,606.56
X$71716 73 13556 14071 14590 73 14736 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71717 r0 *1 200.56,606.56
X$71717 73 14738 73 57 14739 57 sky130_fd_sc_hd__buf_4
* cell instance $71719 r0 *1 203.78,606.56
X$71719 57 12807 13937 12729 13627 14738 14785 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $71726 r0 *1 214.36,606.56
X$71726 73 14861 12905 12244 57 73 14815 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71728 r0 *1 219.88,606.56
X$71728 73 12807 14334 14862 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71729 r0 *1 221.26,606.56
X$71729 57 12809 14592 12729 14862 14815 14787 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $71730 r0 *1 224.48,606.56
X$71730 73 12809 14813 14700 14787 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $71742 r0 *1 250.24,606.56
X$71742 73 14740 73 57 57 sky130_fd_sc_hd__clkinv_2
* cell instance $71755 r0 *1 278.3,606.56
X$71755 73 13062 14790 14866 73 13786 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71756 r0 *1 280.14,606.56
X$71756 73 13061 14706 13062 12941 73 14866 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $71757 r0 *1 282.9,606.56
X$71757 73 14817 14603 14867 73 13892 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71762 r0 *1 290.72,606.56
X$71762 73 12950 13985 13758 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71766 r0 *1 299.92,606.56
X$71766 73 14741 73 57 13175 57 sky130_fd_sc_hd__buf_4
* cell instance $71769 r0 *1 304.06,606.56
X$71769 73 14793 73 57 14053 57 sky130_fd_sc_hd__buf_4
* cell instance $71770 r0 *1 306.82,606.56
X$71770 73 13748 12563 14741 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71772 r0 *1 308.66,606.56
X$71772 73 14741 73 57 14795 57 sky130_fd_sc_hd__buf_4
* cell instance $71779 r0 *1 322,606.56
X$71779 73 14717 73 57 14817 57 sky130_fd_sc_hd__buf_4
* cell instance $71782 r0 *1 332.12,606.56
X$71782 73 12158 12384 14742 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71783 r0 *1 333.5,606.56
X$71783 73 14742 73 57 13535 57 sky130_fd_sc_hd__buf_4
* cell instance $71788 r0 *1 345.46,606.56
X$71788 73 13983 13055 14880 57 73 14868 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71792 r0 *1 350.52,606.56
X$71792 73 14743 73 57 14816 57 sky130_fd_sc_hd__buf_4
* cell instance $71793 r0 *1 353.28,606.56
X$71793 73 13985 13148 12716 57 73 14743 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71796 r0 *1 359.26,606.56
X$71796 73 13985 12716 14458 57 73 14877 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71809 r0 *1 391,606.56
X$71809 73 14876 73 57 14794 57 sky130_fd_sc_hd__buf_4
* cell instance $71817 r0 *1 403.88,606.56
X$71817 73 13579 14792 14746 12799 57 73 15002 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71828 r0 *1 431.48,606.56
X$71828 73 13522 13621 14744 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71832 r0 *1 436.08,606.56
X$71832 73 14745 14789 12799 12450 57 14864 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $71833 r0 *1 438.84,606.56
X$71833 57 14745 12568 14826 14827 14828 14465 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $71836 r0 *1 443.44,606.56
X$71836 73 12866 13372 14748 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $71837 r0 *1 445.74,606.56
X$71837 73 13990 13877 14828 14650 12608 73 14701 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $71840 r0 *1 452.64,606.56
X$71840 73 13621 14749 14747 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71841 r0 *1 454.02,606.56
X$71841 73 14748 14747 12645 73 14928 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71842 r0 *1 455.86,606.56
X$71842 73 14748 14340 12645 73 14194 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71848 r0 *1 465.06,606.56
X$71848 73 13901 13074 14541 57 73 14925 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71850 r0 *1 468.74,606.56
X$71850 73 12964 14541 14749 57 73 14857 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71852 r0 *1 471.04,606.56
X$71852 73 13621 73 57 14541 57 sky130_fd_sc_hd__buf_4
* cell instance $71855 r0 *1 475.18,606.56
X$71855 73 14650 14541 14781 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71860 r0 *1 479.78,606.56
X$71860 73 13688 12568 14746 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71862 r0 *1 482.08,606.56
X$71862 73 13467 73 57 14919 57 sky130_fd_sc_hd__buf_4
* cell instance $71878 r0 *1 515.66,606.56
X$71878 73 13586 14776 14753 57 73 14852 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71879 r0 *1 517.5,606.56
X$71879 73 12972 14830 14000 73 14753 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71880 r0 *1 519.34,606.56
X$71880 73 12681 12874 14830 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $71884 r0 *1 529,606.56
X$71884 57 14762 12681 14775 13586 12876 14754 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $71889 r0 *1 539.12,606.56
X$71889 73 12210 12754 14755 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71891 r0 *1 540.96,606.56
X$71891 73 14755 73 57 14756 57 sky130_fd_sc_hd__buf_4
* cell instance $71892 r0 *1 543.72,606.56
X$71892 73 14835 73 57 14773 57 sky130_fd_sc_hd__buf_4
* cell instance $71894 r0 *1 546.94,606.56
X$71894 73 12210 14773 14758 57 73 14846 57 sky130_fd_sc_hd__a21oi_1
* cell instance $71896 r0 *1 549.7,606.56
X$71896 73 14320 14000 14681 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $71900 r0 *1 556.14,606.56
X$71900 73 14844 14760 14212 73 14483 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $71903 r0 *1 558.9,606.56
X$71903 73 12502 14757 12210 14760 57 73 14768 57 sky130_fd_sc_hd__a31oi_1
* cell instance $71904 r0 *1 561.2,606.56
X$71904 57 57 14677 14762 14548 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $71908 r0 *1 568.56,606.56
X$71908 73 14761 14480 14681 14837 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $71909 r0 *1 570.4,606.56
X$71909 73 14761 14842 14837 12767 14767 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $71913 r0 *1 582.36,606.56
X$71913 73 14762 73 57 14764 57 sky130_fd_sc_hd__buf_4
* cell instance $71917 r0 *1 587.42,606.56
X$71917 73 12210 14764 14763 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72002 m0 *1 21.62,612
X$72002 73 12719 14903 11834 14719 57 14395 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $72003 m0 *1 24.38,612
X$72003 73 14902 73 57 13120 57 sky130_fd_sc_hd__buf_4
* cell instance $72010 m0 *1 38.64,612
X$72010 73 12002 12397 14797 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72014 m0 *1 45.08,612
X$72014 57 14800 14798 14799 12990 11800 14840 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $72016 m0 *1 49.22,612
X$72016 73 14800 73 57 13155 57 sky130_fd_sc_hd__buf_4
* cell instance $72017 m0 *1 51.98,612
X$72017 73 13157 12478 12991 57 73 14841 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72018 m0 *1 53.82,612
X$72018 73 12990 73 57 14801 57 sky130_fd_sc_hd__buf_4
* cell instance $72026 m0 *1 74.52,612
X$72026 73 12002 14803 14725 57 73 14804 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72027 m0 *1 76.36,612
X$72027 73 14843 14726 12521 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72031 m0 *1 85.56,612
X$72031 57 14727 14845 12179 13157 13156 14906 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $72033 m0 *1 89.24,612
X$72033 73 12179 14620 14845 11955 14907 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $72036 m0 *1 94.76,612
X$72036 73 15032 14907 14805 12263 14678 73 14806 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $72037 m0 *1 97.98,612
X$72037 73 14806 73 57 11563 57 sky130_fd_sc_hd__buf_4
* cell instance $72039 m0 *1 102.58,612
X$72039 73 13261 13960 14908 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72045 m0 *1 113.16,612
X$72045 73 13118 13261 14807 14804 57 14847 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $72047 m0 *1 116.84,612
X$72047 73 13494 13960 12520 73 14807 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72054 m0 *1 137.54,612
X$72054 73 14848 13445 12810 14808 57 14409 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $72056 m0 *1 140.76,612
X$72056 73 14445 12689 13351 14809 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72057 m0 *1 142.6,612
X$72057 57 13128 14808 14731 14809 14850 13445 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $72058 m0 *1 145.82,612
X$72058 73 12687 13162 13123 57 73 14850 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72060 m0 *1 148.12,612
X$72060 73 14443 73 57 13351 57 sky130_fd_sc_hd__buf_4
* cell instance $72061 m0 *1 150.88,612
X$72061 73 13314 13445 14730 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72063 m0 *1 152.72,612
X$72063 73 13556 14774 13011 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72072 m0 *1 169.74,612
X$72072 73 12812 14853 14854 15098 73 57 13969 57 sky130_fd_sc_hd__o31ai_1
* cell instance $72074 m0 *1 172.96,612
X$72074 73 12807 14334 14810 14854 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72075 m0 *1 174.8,612
X$72075 73 13314 12687 14810 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72077 m0 *1 177.1,612
X$72077 73 12841 14811 14810 14855 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72085 m0 *1 196.88,612
X$72085 73 14858 14813 14918 12810 57 73 14917 57 sky130_fd_sc_hd__a31oi_1
* cell instance $72086 m0 *1 199.18,612
X$72086 73 13124 12687 14814 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $72089 m0 *1 203.78,612
X$72089 73 14814 73 57 14738 57 sky130_fd_sc_hd__buf_4
* cell instance $72090 m0 *1 206.54,612
X$72090 73 13778 73 57 14860 57 sky130_fd_sc_hd__buf_4
* cell instance $72092 m0 *1 209.76,612
X$72092 57 14587 12807 14860 14882 14368 14861 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $72104 m0 *1 239.66,612
X$72104 57 4950 12461 14740 14863 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $72106 m0 *1 251.16,612
X$72106 57 12352 14740 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $72110 m0 *1 268.64,612
X$72110 73 14816 14505 13977 73 14818 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72113 m0 *1 271.86,612
X$72113 73 11790 14703 13525 14955 13570 14865 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $72115 m0 *1 275.54,612
X$72115 73 12736 73 57 14282 57 sky130_fd_sc_hd__buf_4
* cell instance $72119 m0 *1 281.52,612
X$72119 57 14706 12563 14867 14082 13338 14868 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $72123 m0 *1 291.18,612
X$72123 73 13055 13748 14281 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72127 m0 *1 300.84,612
X$72127 73 14932 13454 14818 14869 73 13145 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $72128 m0 *1 303.14,612
X$72128 73 14819 73 57 13539 57 sky130_fd_sc_hd__buf_4
* cell instance $72132 m0 *1 307.74,612
X$72132 73 14885 14375 12191 73 14872 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72136 m0 *1 317.86,612
X$72136 57 14871 11790 14872 14937 14873 14886 73 73 57 sky130_fd_sc_hd__o41ai_1
* cell instance $72139 m0 *1 323.84,612
X$72139 73 13985 14287 14874 14717 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72143 m0 *1 332.12,612
X$72143 73 13338 14706 14879 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72145 m0 *1 333.96,612
X$72145 73 14940 13865 14879 13334 57 73 14886 57 sky130_fd_sc_hd__a31oi_1
* cell instance $72149 m0 *1 342.7,612
X$72149 57 13982 14880 13748 73 73 57 sky130_fd_sc_hd__nor2_4
* cell instance $72150 m0 *1 346.84,612
X$72150 73 14880 73 57 14601 57 sky130_fd_sc_hd__buf_4
* cell instance $72151 m0 *1 349.6,612
X$72151 73 13055 13982 13748 73 14714 57 57 sky130_fd_sc_hd__a21oi_2
* cell instance $72155 m0 *1 359.26,612
X$72155 73 14877 13870 14706 57 73 14878 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72169 m0 *1 393.76,612
X$72169 57 13877 14876 12608 14875 14824 14820 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $72170 m0 *1 396.98,612
X$72170 73 14464 13942 14875 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72173 m0 *1 402.5,612
X$72173 73 14421 14870 13877 73 14710 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72176 m0 *1 406.64,612
X$72176 73 14539 13375 14870 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72177 m0 *1 408.02,612
X$72177 73 14892 14539 13866 57 73 14821 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72178 m0 *1 409.86,612
X$72178 73 12450 14821 14822 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72179 m0 *1 411.24,612
X$72179 73 12568 13272 14822 14823 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72180 m0 *1 413.08,612
X$72180 73 13074 13942 14892 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72186 m0 *1 423.2,612
X$72186 73 13522 13942 14930 73 14820 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72189 m0 *1 426.42,612
X$72189 73 13074 13990 14824 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72192 m0 *1 429.18,612
X$72192 73 12450 14646 13896 13074 14142 14825 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $72194 m0 *1 434.24,612
X$72194 73 14934 13416 14864 14936 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72196 m0 *1 437.92,612
X$72196 73 13074 13078 14826 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72197 m0 *1 439.3,612
X$72197 73 12645 14648 14827 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72203 m0 *1 445.28,612
X$72203 73 12751 13521 13990 14828 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72207 m0 *1 452.18,612
X$72207 73 14827 73 57 14859 57 sky130_fd_sc_hd__buf_4
* cell instance $72208 m0 *1 454.94,612
X$72208 73 14786 14859 14927 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72210 m0 *1 460,612
X$72210 73 13074 13990 14829 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72212 m0 *1 465.06,612
X$72212 73 14829 13901 14293 14650 14137 57 73 57 sky130_fd_sc_hd__o22a_1
* cell instance $72219 m0 *1 476.1,612
X$72219 73 13901 14781 13581 14194 73 57 14923 57 sky130_fd_sc_hd__o31ai_1
* cell instance $72232 m0 *1 511.98,612
X$72232 73 14915 73 57 13927 57 sky130_fd_sc_hd__buf_4
* cell instance $72233 m0 *1 514.74,612
X$72233 73 12210 14831 14014 14778 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72234 m0 *1 516.58,612
X$72234 73 12414 14851 14834 14751 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72235 m0 *1 518.42,612
X$72235 73 12414 14831 14832 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72236 m0 *1 519.8,612
X$72236 73 14320 12414 14832 12210 14916 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $72239 m0 *1 523.94,612
X$72239 73 12376 73 57 14386 57 sky130_fd_sc_hd__buf_4
* cell instance $72242 m0 *1 527.62,612
X$72242 73 14901 14386 14913 12876 14849 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $72243 m0 *1 530.38,612
X$72243 73 12876 13498 14914 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72246 m0 *1 536.36,612
X$72246 73 14833 73 57 14834 57 sky130_fd_sc_hd__buf_4
* cell instance $72247 m0 *1 539.12,612
X$72247 73 14835 14757 14568 13109 12281 73 14833 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $72248 m0 *1 542.34,612
X$72248 73 12283 14756 14836 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72251 m0 *1 545.1,612
X$72251 73 12376 73 57 14387 57 sky130_fd_sc_hd__buf_4
* cell instance $72254 m0 *1 550.62,612
X$72254 73 14836 73 57 14844 57 sky130_fd_sc_hd__buf_4
* cell instance $72261 m0 *1 566.72,612
X$72261 73 14685 12765 14839 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72264 m0 *1 570.4,612
X$72264 73 14491 14390 14842 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72266 m0 *1 572.24,612
X$72266 73 12505 14000 14545 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72271 m0 *1 582.36,612
X$72271 73 12880 12376 14838 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72273 m0 *1 584.66,612
X$72273 73 14838 73 57 14831 57 sky130_fd_sc_hd__buf_4
* cell instance $72274 m0 *1 587.42,612
X$72274 73 14545 14838 12210 73 14904 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72276 m0 *1 590.18,612
X$72276 73 13704 14663 14212 14904 14839 12508 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $72313 r0 *1 26.68,612
X$72313 73 12478 11955 14902 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72316 r0 *1 33.58,612
X$72316 73 14397 14064 14615 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72326 r0 *1 46,612
X$72326 73 12337 73 57 14799 57 sky130_fd_sc_hd__buf_4
* cell instance $72327 r0 *1 48.76,612
X$72327 73 12397 12478 14357 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72341 r0 *1 74.52,612
X$72341 73 12397 14840 14803 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72344 r0 *1 80.04,612
X$72344 73 13550 14840 14906 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72373 r0 *1 142.6,612
X$72373 73 14730 13128 15232 73 14623 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72384 r0 *1 158.7,612
X$72384 73 14625 73 57 14910 57 sky130_fd_sc_hd__inv_1
* cell instance $72386 r0 *1 161,612
X$72386 73 14811 14910 14326 73 14911 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72389 r0 *1 168.36,612
X$72389 73 14179 12687 14948 73 14881 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72390 r0 *1 170.2,612
X$72390 73 12841 14882 14686 14853 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72402 r0 *1 185.38,612
X$72402 73 12809 12810 14155 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72407 r0 *1 196.42,612
X$72407 73 14445 13049 14918 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72408 r0 *1 197.8,612
X$72408 73 12848 12627 14918 14881 12841 73 13264 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $72417 r0 *1 210.68,612
X$72417 73 14860 13625 12807 14953 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $72446 r0 *1 274.16,612
X$72446 73 13055 12736 14883 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72447 r0 *1 275.54,612
X$72447 73 14883 14043 12384 73 14929 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72449 r0 *1 277.84,612
X$72449 73 14883 73 57 14280 57 sky130_fd_sc_hd__buf_4
* cell instance $72460 r0 *1 293.94,612
X$72460 57 14956 14601 13061 14793 12950 13566 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $72461 r0 *1 297.16,612
X$72461 73 13338 14082 14884 73 14931 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72462 r0 *1 299,612
X$72462 73 13985 13338 13758 14884 57 14933 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $72463 r0 *1 301.76,612
X$72463 73 13985 14819 14455 57 73 14793 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72464 r0 *1 303.6,612
X$72464 73 12736 73 57 14884 57 sky130_fd_sc_hd__buf_4
* cell instance $72466 r0 *1 307.28,612
X$72466 73 13570 73 57 14885 57 sky130_fd_sc_hd__buf_4
* cell instance $72468 r0 *1 311.88,612
X$72468 57 57 12736 14819 13748 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $72476 r0 *1 320.62,612
X$72476 73 15005 73 57 14937 57 sky130_fd_sc_hd__buf_4
* cell instance $72481 r0 *1 333.04,612
X$72481 73 14280 14601 12563 73 14940 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72492 r0 *1 348.22,612
X$72492 73 13535 14887 14888 13177 14714 14869 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $72493 r0 *1 351.44,612
X$72493 73 13461 13868 13985 73 14887 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72497 r0 *1 359.26,612
X$72497 73 13985 12706 14458 14943 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $72512 r0 *1 387.78,612
X$72512 57 11390 15003 14890 73 73 57 sky130_fd_sc_hd__dfxtp_4
* cell instance $72517 r0 *1 396.98,612
X$72517 57 13988 14889 13373 14942 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $72518 r0 *1 399.28,612
X$72518 73 14824 14288 13877 73 14942 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72524 r0 *1 407.1,612
X$72524 73 14891 73 57 14890 57 sky130_fd_sc_hd__buf_4
* cell instance $72527 r0 *1 412.62,612
X$72527 57 14893 14891 14939 14941 14823 14936 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $72528 r0 *1 415.84,612
X$72528 73 12608 14588 14938 73 14939 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72540 r0 *1 436.08,612
X$72540 57 13521 14333 12608 14824 14744 14894 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $72542 r0 *1 439.76,612
X$72542 73 13993 12806 13988 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72550 r0 *1 455.86,612
X$72550 73 13988 14927 14928 13413 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $72555 r0 *1 463.22,612
X$72555 73 14895 13138 13901 14925 57 73 14926 57 sky130_fd_sc_hd__a31oi_1
* cell instance $72557 r0 *1 469.2,612
X$72557 73 14857 14895 14467 13224 14195 14896 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $72558 r0 *1 472.42,612
X$72558 73 14746 14896 14924 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72566 r0 *1 483.46,612
X$72566 73 14919 12695 14921 73 14920 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72568 r0 *1 485.76,612
X$72568 73 13727 14195 14922 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72582 r0 *1 514.74,612
X$72582 73 14897 14480 13842 12876 12972 73 14898 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $72583 r0 *1 517.96,612
X$72583 73 14685 14000 14897 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72585 r0 *1 520.26,612
X$72585 73 14899 14916 14912 13586 14898 73 14915 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $72586 r0 *1 523.48,612
X$72586 73 14386 12414 14320 14900 57 73 14899 57 sky130_fd_sc_hd__a31oi_1
* cell instance $72588 r0 *1 527.62,612
X$72588 73 14548 73 57 14913 57 sky130_fd_sc_hd__buf_4
* cell instance $72594 r0 *1 533.14,612
X$72594 73 14685 73 57 14901 57 sky130_fd_sc_hd__buf_4
* cell instance $72595 r0 *1 535.9,612
X$72595 73 12210 12754 14992 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72597 r0 *1 537.74,612
X$72597 73 13598 12414 12210 12757 57 14900 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $72602 r0 *1 542.34,612
X$72602 73 14831 14901 14387 57 73 14909 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72612 r0 *1 560.28,612
X$72612 73 12502 73 57 14905 57 sky130_fd_sc_hd__buf_4
* cell instance $72619 r0 *1 569.94,612
X$72619 73 14977 73 57 14390 57 sky130_fd_sc_hd__buf_4
* cell instance $72670 m0 *1 34.04,617.44
X$72670 73 11834 14903 14615 14946 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $72674 m0 *1 41.86,617.44
X$72674 57 14117 14064 14397 14945 13550 12335 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $72677 m0 *1 47.38,617.44
X$72677 73 14946 14982 14766 13259 57 73 14805 57 sky130_fd_sc_hd__a31oi_1
* cell instance $72679 m0 *1 53.36,617.44
X$72679 73 14801 12673 14980 14511 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $72685 m0 *1 62.1,617.44
X$72685 73 12674 11883 14983 14982 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $72699 m0 *1 101.2,617.44
X$72699 73 14984 11834 11955 15033 11838 73 14771 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $72715 m0 *1 142.6,617.44
X$72715 73 13445 14989 13128 13051 57 14990 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $72717 m0 *1 145.82,617.44
X$72717 73 14731 12687 14774 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72723 m0 *1 157.78,617.44
X$72723 73 14991 73 57 14625 57 sky130_fd_sc_hd__buf_4
* cell instance $72724 m0 *1 160.54,617.44
X$72724 73 14327 14443 14811 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72726 m0 *1 163.76,617.44
X$72726 73 12810 14947 14178 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72730 m0 *1 168.36,617.44
X$72730 73 12841 14881 15039 57 73 14947 57 sky130_fd_sc_hd__a21o_1
* cell instance $72731 m0 *1 171.12,617.44
X$72731 73 14327 12687 14954 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72734 m0 *1 174.8,617.44
X$72734 73 14731 12807 14415 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72737 m0 *1 181.7,617.44
X$72737 73 13314 13049 14949 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72738 m0 *1 183.08,617.44
X$72738 73 12809 14242 14949 15042 14731 73 14950 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $72740 m0 *1 186.76,617.44
X$72740 73 12810 14996 14950 14995 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $72741 m0 *1 188.6,617.44
X$72741 73 13556 14335 14813 12848 14996 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $72750 m0 *1 211.14,617.44
X$72750 57 13133 12807 15045 14811 12848 14953 73 73 57
+ sky130_fd_sc_hd__o311ai_1
* cell instance $72751 m0 *1 214.36,617.44
X$72751 73 12847 12244 13628 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72754 m0 *1 217.12,617.44
X$72754 73 14954 73 57 14368 57 sky130_fd_sc_hd__buf_4
* cell instance $72755 m0 *1 219.88,617.44
X$72755 57 12841 15200 12812 14814 14954 13744 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $72758 m0 *1 224.48,617.44
X$72758 73 12810 15103 13637 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72764 m0 *1 239.66,617.44
X$72764 57 4950 12346 14740 15001 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $72772 m0 *1 273.24,617.44
X$72772 73 12563 14082 14955 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72781 m0 *1 300.84,617.44
X$72781 73 13956 14884 12158 15054 57 73 14935 57 sky130_fd_sc_hd__a31oi_1
* cell instance $72782 m0 *1 303.14,617.44
X$72782 73 14933 14959 14884 57 73 14960 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72785 m0 *1 306.36,617.44
X$72785 73 15004 14960 14935 13064 14885 15132 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $72791 m0 *1 322.92,617.44
X$72791 57 14874 15005 13985 14535 14962 14458 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $72792 m0 *1 326.14,617.44
X$72792 73 13055 13679 14962 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72795 m0 *1 328.9,617.44
X$72795 57 14959 14963 12563 12950 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $72798 m0 *1 334.88,617.44
X$72798 73 15078 73 57 13865 57 sky130_fd_sc_hd__buf_4
* cell instance $72803 m0 *1 347.3,617.44
X$72803 73 14963 14605 13868 14964 73 57 15116 57 sky130_fd_sc_hd__o31ai_1
* cell instance $72805 m0 *1 351.9,617.44
X$72805 73 13055 13985 14714 73 14964 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72809 m0 *1 358.8,617.44
X$72809 73 14280 14888 14943 57 73 15063 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72824 m0 *1 393.76,617.44
X$72824 57 11727 15003 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $72826 m0 *1 404.8,617.44
X$72826 73 15002 73 57 15211 57 sky130_fd_sc_hd__buf_4
* cell instance $72827 m0 *1 407.56,617.44
X$72827 73 14968 73 57 13373 57 sky130_fd_sc_hd__buf_4
* cell instance $72839 m0 *1 434.7,617.44
X$72839 73 13016 14968 13581 15000 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $72842 m0 *1 437.92,617.44
X$72842 73 12568 15000 14239 57 73 14999 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72856 m0 *1 471.96,617.44
X$72856 73 14924 13329 14998 15194 73 12650 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $72859 m0 *1 479.78,617.44
X$72859 73 14971 14920 14997 13220 14998 57 73 57 sky130_fd_sc_hd__o22a_1
* cell instance $72861 m0 *1 483.46,617.44
X$72861 73 14195 12751 14922 12798 57 14971 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $72870 m0 *1 507.84,617.44
X$72870 73 12281 14972 14994 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72873 m0 *1 516.58,617.44
X$72873 73 12414 12281 13842 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72879 m0 *1 527.16,617.44
X$72879 73 12758 12376 14973 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72880 m0 *1 528.54,617.44
X$72880 73 14973 73 57 14480 57 sky130_fd_sc_hd__buf_4
* cell instance $72881 m0 *1 531.3,617.44
X$72881 73 13109 14973 14974 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72882 m0 *1 532.68,617.44
X$72882 57 12569 15027 13471 14836 14974 14992 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $72883 m0 *1 535.9,617.44
X$72883 73 14992 73 57 12577 57 sky130_fd_sc_hd__buf_4
* cell instance $72887 m0 *1 543.72,617.44
X$72887 73 14975 73 57 14851 57 sky130_fd_sc_hd__buf_4
* cell instance $72890 m0 *1 551.08,617.44
X$72890 73 14988 73 57 13805 57 sky130_fd_sc_hd__buf_4
* cell instance $72895 m0 *1 557.52,617.44
X$72895 73 14388 14987 14976 14761 14212 73 14975 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $72896 m0 *1 560.74,617.44
X$72896 73 14761 13479 14905 57 73 14976 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72897 m0 *1 562.58,617.44
X$72897 73 14761 14905 14205 14986 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $72899 m0 *1 564.88,617.44
X$72899 57 57 14000 14977 13471 73 73 sky130_fd_sc_hd__nand2_2
* cell instance $72900 m0 *1 567.18,617.44
X$72900 57 14972 14977 14480 14761 14981 73 73 57 sky130_fd_sc_hd__a31oi_2
* cell instance $72946 r0 *1 34.04,617.44
X$72946 73 14944 73 57 14903 57 sky130_fd_sc_hd__buf_4
* cell instance $72953 r0 *1 44.16,617.44
X$72953 73 15006 14357 13546 11879 57 73 14944 57 sky130_fd_sc_hd__a31oi_1
* cell instance $72954 r0 *1 46.46,617.44
X$72954 73 14799 12335 13441 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72955 r0 *1 47.84,617.44
X$72955 73 12371 14722 15006 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $72957 r0 *1 50.14,617.44
X$72957 73 13546 12371 14357 57 73 14980 57 sky130_fd_sc_hd__a21oi_1
* cell instance $72959 r0 *1 52.9,617.44
X$72959 73 15007 73 57 14945 57 sky130_fd_sc_hd__buf_4
* cell instance $72962 r0 *1 61.18,617.44
X$72962 73 14722 15008 13546 73 14983 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $72963 r0 *1 63.02,617.44
X$72963 73 14513 14123 15008 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $72971 r0 *1 72.22,617.44
X$72971 73 14797 13118 12371 14064 73 15030 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $72972 r0 *1 74.98,617.44
X$72972 73 14803 11838 15030 14173 12930 73 14984 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $72973 r0 *1 78.2,617.44
X$72973 73 12085 14173 13441 12478 15007 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $72976 r0 *1 84.64,617.44
X$72976 73 14769 15031 11834 14173 12930 73 14519 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $72980 r0 *1 91.08,617.44
X$72980 57 14064 14843 15090 12179 13494 13546 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $72986 r0 *1 101.2,617.44
X$72986 73 13118 13494 14405 14908 57 15033 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $73000 r0 *1 136.62,617.44
X$73000 73 15035 15036 15037 14276 57 73 13731 57 sky130_fd_sc_hd__a31oi_1
* cell instance $73003 r0 *1 140.3,617.44
X$73003 73 12812 14990 15148 14443 14444 15037 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $73004 r0 *1 143.52,617.44
X$73004 73 13770 73 57 14989 57 sky130_fd_sc_hd__buf_4
* cell instance $73006 r0 *1 146.74,617.44
X$73006 57 13770 15012 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $73010 r0 *1 156.4,617.44
X$73010 73 14731 13935 15038 73 14952 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73013 r0 *1 160.54,617.44
X$73013 73 13556 12687 14633 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73016 r0 *1 164.68,617.44
X$73016 73 13556 14731 12687 14948 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73018 r0 *1 167.44,617.44
X$73018 73 14948 73 57 14143 57 sky130_fd_sc_hd__buf_4
* cell instance $73019 r0 *1 170.2,617.44
X$73019 73 15009 73 57 15039 57 sky130_fd_sc_hd__buf_4
* cell instance $73021 r0 *1 173.42,617.44
X$73021 73 14993 73 57 13733 57 sky130_fd_sc_hd__buf_4
* cell instance $73023 r0 *1 176.64,617.44
X$73023 73 15040 14451 15009 12841 12811 73 14993 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $73029 r0 *1 184.92,617.44
X$73029 73 14633 13556 15010 57 73 15042 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73031 r0 *1 187.22,617.44
X$73031 73 15010 73 57 13172 57 sky130_fd_sc_hd__buf_4
* cell instance $73032 r0 *1 189.98,617.44
X$73032 73 15011 12812 14952 57 73 15043 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73035 r0 *1 195.96,617.44
X$73035 73 14731 12244 14637 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73037 r0 *1 201.02,617.44
X$73037 73 12812 13888 15013 57 73 15011 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73038 r0 *1 202.86,617.44
X$73038 73 12841 13628 14451 15013 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73043 r0 *1 209.76,617.44
X$73043 73 15045 73 57 14882 57 sky130_fd_sc_hd__buf_4
* cell instance $73045 r0 *1 212.98,617.44
X$73045 73 12687 13556 12934 57 73 15045 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73067 r0 *1 269.56,617.44
X$73067 73 15047 13055 14595 57 73 15049 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73071 r0 *1 279.68,617.44
X$73071 57 15014 13061 13034 14452 14791 73 73 57 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $73074 r0 *1 284.28,617.44
X$73074 73 14956 13535 15049 14957 15050 73 15015 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $73081 r0 *1 294.86,617.44
X$73081 73 14281 14791 14082 15053 57 14958 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $73082 r0 *1 297.16,617.44
X$73082 73 14958 12920 13064 15058 57 15050 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $73087 r0 *1 309.12,617.44
X$73087 73 12631 14961 15004 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73091 r0 *1 313.72,617.44
X$73091 73 13457 15057 15017 14961 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $73108 r0 *1 348.22,617.44
X$73108 73 13870 13867 15062 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73111 r0 *1 352.36,617.44
X$73111 73 13867 13868 14964 12384 14965 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $73113 r0 *1 356.96,617.44
X$73113 73 14187 14957 14965 15063 12384 73 13746 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $73124 r0 *1 385.48,617.44
X$73124 57 12321 15003 14966 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $73126 r0 *1 393.76,617.44
X$73126 57 15003 15438 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $73130 r0 *1 400.66,617.44
X$73130 73 14421 12642 13877 73 15069 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73133 r0 *1 403.42,617.44
X$73133 73 12801 15022 14967 57 73 15068 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73135 r0 *1 405.72,617.44
X$73135 73 12958 12642 14892 15066 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $73139 r0 *1 415.38,617.44
X$73139 73 15065 13874 12801 15064 57 14938 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $73140 r0 *1 418.14,617.44
X$73140 57 15061 15065 14969 14744 14824 13877 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $73145 r0 *1 424.58,617.44
X$73145 73 14968 73 57 13073 57 sky130_fd_sc_hd__buf_4
* cell instance $73146 r0 *1 427.34,617.44
X$73146 73 12378 73 57 14968 57 sky130_fd_sc_hd__buf_4
* cell instance $73151 r0 *1 433.78,617.44
X$73151 73 12608 15060 14502 15022 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73154 r0 *1 437,617.44
X$73154 73 15059 13143 14970 14049 57 14934 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $73167 r0 *1 461.38,617.44
X$73167 73 14829 14930 12608 12378 57 73 15025 57 sky130_fd_sc_hd__a31oi_1
* cell instance $73168 r0 *1 463.68,617.44
X$73168 73 15025 14926 12608 73 14970 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $73192 r0 *1 526.24,617.44
X$73192 57 12754 14000 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $73196 r0 *1 539.12,617.44
X$73196 73 12874 14000 14835 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73199 r0 *1 541.88,617.44
X$73199 73 12505 12577 12874 12765 73 15046 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $73202 r0 *1 547.4,617.44
X$73202 73 12754 13109 14988 73 57 57 sky130_fd_sc_hd__xnor2_1
* cell instance $73203 r0 *1 550.62,617.44
X$73203 73 14988 12874 14491 12758 15044 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $73204 r0 *1 552.92,617.44
X$73204 73 12758 12754 14987 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73207 r0 *1 557.06,617.44
X$73207 73 14987 73 57 14677 57 sky130_fd_sc_hd__buf_4
* cell instance $73210 r0 *1 561.66,617.44
X$73210 73 14986 14985 14212 12414 57 14912 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $73211 r0 *1 564.42,617.44
X$73211 73 12210 14548 14977 14985 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73215 r0 *1 569.48,617.44
X$73215 73 14000 12505 14761 13999 57 14981 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $73217 r0 *1 574.08,617.44
X$73217 73 13188 73 57 14978 57 sky130_fd_sc_hd__buf_4
* cell instance $73218 r0 *1 576.84,617.44
X$73218 73 13999 14978 13109 73 14979 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73221 r0 *1 580.06,617.44
X$73221 57 13109 14313 14658 14014 13598 14979 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $73327 m0 *1 75.44,622.88
X$73327 57 15544 14843 14123 12371 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $73329 m0 *1 83.72,622.88
X$73329 73 13546 12085 15031 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73333 m0 *1 92.92,622.88
X$73333 57 11834 15032 11879 14908 15007 15090 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $73348 m0 *1 137.54,622.88
X$73348 73 15091 15070 13664 57 73 15035 57 sky130_fd_sc_hd__a21o_1
* cell instance $73351 m0 *1 141.22,622.88
X$73351 73 14326 14774 14991 15070 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73356 m0 *1 152.72,622.88
X$73356 73 12841 14633 12934 73 15120 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73359 m0 *1 156.86,622.88
X$73359 73 12244 73 57 14443 57 sky130_fd_sc_hd__buf_4
* cell instance $73369 m0 *1 181.7,622.88
X$73369 73 12841 13774 15073 15009 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $73370 m0 *1 183.54,622.88
X$73370 73 12847 12244 15073 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73371 m0 *1 184.92,622.88
X$73371 73 12841 12244 15010 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73373 m0 *1 187.22,622.88
X$73373 73 15073 15074 14338 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73375 m0 *1 192.28,622.88
X$73375 73 15012 12687 15075 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73380 m0 *1 203.32,622.88
X$73380 73 13774 15075 12807 14785 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $73384 m0 *1 212.06,622.88
X$73384 73 15075 73 57 14451 57 sky130_fd_sc_hd__buf_4
* cell instance $73389 m0 *1 223.56,622.88
X$73389 73 15075 73 57 15104 57 sky130_fd_sc_hd__buf_4
* cell instance $73405 m0 *1 270.02,622.88
X$73405 73 13977 15077 15014 15047 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73406 m0 *1 271.86,622.88
X$73406 73 15077 73 57 14957 57 sky130_fd_sc_hd__buf_4
* cell instance $73407 m0 *1 274.62,622.88
X$73407 73 12191 11790 15048 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73416 m0 *1 289.34,622.88
X$73416 73 15051 73 57 13370 57 sky130_fd_sc_hd__buf_4
* cell instance $73424 m0 *1 307.28,622.88
X$73424 73 15055 14433 14600 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $73426 m0 *1 310.5,622.88
X$73426 73 12563 14819 14600 57 73 15056 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73429 m0 *1 313.72,622.88
X$73429 73 15016 73 57 15058 57 sky130_fd_sc_hd__buf_4
* cell instance $73432 m0 *1 317.86,622.88
X$73432 73 14455 15111 14435 12563 12158 73 15016 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $73435 m0 *1 322.46,622.88
X$73435 73 14535 73 57 15057 57 sky130_fd_sc_hd__buf_4
* cell instance $73438 m0 *1 327.52,622.88
X$73438 73 13868 14795 13266 73 15113 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73443 m0 *1 337.64,622.88
X$73443 73 12487 12190 15018 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73444 m0 *1 339.02,622.88
X$73444 73 15018 73 57 15019 57 sky130_fd_sc_hd__buf_4
* cell instance $73446 m0 *1 342.7,622.88
X$73446 73 15019 73 57 12920 57 sky130_fd_sc_hd__buf_4
* cell instance $73450 m0 *1 348.68,622.88
X$73450 73 15062 73 57 15080 57 sky130_fd_sc_hd__buf_4
* cell instance $73468 m0 *1 394.68,622.88
X$73468 73 12866 13375 14089 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $73469 m0 *1 396.98,622.88
X$73469 73 13946 15117 15021 14049 57 73 15020 57 sky130_fd_sc_hd__a31oi_1
* cell instance $73471 m0 *1 399.74,622.88
X$73471 73 14889 15284 12568 73 14967 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73474 m0 *1 402.96,622.88
X$73474 73 15114 15068 15020 14966 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $73476 m0 *1 406.64,622.88
X$73476 73 15066 15067 15023 73 15021 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73479 m0 *1 414,622.88
X$73479 73 13877 14870 14288 15083 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $73484 m0 *1 418.14,622.88
X$73484 73 14786 15024 15083 15064 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $73488 m0 *1 423.2,622.88
X$73488 73 14464 13521 15024 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73492 m0 *1 433.78,622.88
X$73492 73 14826 15234 13073 73 15060 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73509 m0 *1 473.34,622.88
X$73509 73 13993 13793 15085 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73510 m0 *1 474.72,622.88
X$73510 73 13901 15107 14829 57 73 15052 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73511 m0 *1 476.56,622.88
X$73511 73 13185 15052 15085 15106 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $73525 m0 *1 517.96,622.88
X$73525 73 15086 73 57 13587 57 sky130_fd_sc_hd__buf_4
* cell instance $73526 m0 *1 520.72,622.88
X$73526 73 12210 15087 14897 15086 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73529 m0 *1 523.94,622.88
X$73529 73 12880 14000 15026 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73534 m0 *1 529,622.88
X$73534 73 12210 15087 15026 57 73 14219 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73535 m0 *1 530.84,622.88
X$73535 73 15027 12281 13704 15086 15046 15105 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $73538 m0 *1 538.66,622.88
X$73538 57 15028 15102 14212 12757 13598 15101 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $73539 m0 *1 541.88,622.88
X$73539 73 15028 14835 14302 15101 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73543 m0 *1 552,622.88
X$73543 73 15044 15100 12765 57 73 15041 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73548 m0 *1 557.06,622.88
X$73548 73 12210 15095 15029 14655 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73549 m0 *1 558.9,622.88
X$73549 73 14677 73 57 15029 57 sky130_fd_sc_hd__buf_4
* cell instance $73551 m0 *1 565.34,622.88
X$73551 73 12757 12505 14000 57 73 15094 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73552 m0 *1 567.18,622.88
X$73552 73 13109 73 57 14761 57 sky130_fd_sc_hd__buf_4
* cell instance $73558 m0 *1 582.36,622.88
X$73558 73 15089 73 57 14658 57 sky130_fd_sc_hd__buf_4
* cell instance $73560 m0 *1 585.58,622.88
X$73560 73 15034 73 57 12772 57 sky130_fd_sc_hd__buf_4
* cell instance $73641 r0 *1 135.7,622.88
X$73641 73 15119 14624 15120 15147 15036 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $73642 r0 *1 138.46,622.88
X$73642 73 15038 73 57 15091 57 sky130_fd_sc_hd__buf_4
* cell instance $73645 r0 *1 142.6,622.88
X$73645 73 15093 14445 14326 57 73 15148 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73646 r0 *1 144.44,622.88
X$73646 73 12807 12687 14335 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73647 r0 *1 145.82,622.88
X$73647 73 14326 14175 15093 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73656 r0 *1 158.7,622.88
X$73656 73 14327 73 57 15119 57 sky130_fd_sc_hd__buf_4
* cell instance $73658 r0 *1 165.14,622.88
X$73658 73 12810 15096 14628 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73660 r0 *1 166.98,622.88
X$73660 57 15615 15071 12841 13556 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $73661 r0 *1 171.58,622.88
X$73661 73 12812 15097 12687 15071 14415 15098 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $73664 r0 *1 177.56,622.88
X$73664 73 15072 14415 15074 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73666 r0 *1 178.94,622.88
X$73666 73 12934 12841 15072 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73672 r0 *1 184.92,622.88
X$73672 57 14175 13627 15152 12812 15010 15074 73 73 57 sky130_fd_sc_hd__a221o_1
* cell instance $73683 r0 *1 213.44,622.88
X$73683 73 13556 12934 12244 14813 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73684 r0 *1 215.28,622.88
X$73684 73 15199 73 57 14590 57 sky130_fd_sc_hd__buf_4
* cell instance $73687 r0 *1 219.42,622.88
X$73687 73 13556 12244 15076 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73689 r0 *1 221.26,622.88
X$73689 73 12841 15126 14813 57 73 14248 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73691 r0 *1 224.02,622.88
X$73691 73 12934 12807 15155 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73693 r0 *1 225.86,622.88
X$73693 73 13628 15155 15076 15104 12807 15103 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $73713 r0 *1 270.02,622.88
X$73713 73 15048 73 57 15077 57 sky130_fd_sc_hd__buf_4
* cell instance $73715 r0 *1 273.24,622.88
X$73715 73 13055 14278 14955 57 73 15127 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73716 r0 *1 275.08,622.88
X$73716 73 15127 12191 13064 15156 57 14607 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $73722 r0 *1 287.5,622.88
X$73722 73 15051 15108 12563 14929 57 73 15158 57 sky130_fd_sc_hd__a31oi_1
* cell instance $73727 r0 *1 294.4,622.88
X$73727 73 12158 14601 14278 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73729 r0 *1 296.24,622.88
X$73729 73 14082 14455 14931 12563 15209 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $73733 r0 *1 302.22,622.88
X$73733 73 12858 15130 14455 14819 13985 15129 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $73734 r0 *1 305.44,622.88
X$73734 73 13985 15055 15080 57 73 15130 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73736 r0 *1 307.74,622.88
X$73736 73 15057 15133 15213 73 15160 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73737 r0 *1 309.58,622.88
X$73737 73 14458 14455 12563 15056 57 73 15133 57 sky130_fd_sc_hd__a31oi_1
* cell instance $73740 r0 *1 313.26,622.88
X$73740 57 15162 15054 14082 15110 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $73742 r0 *1 315.56,622.88
X$73742 73 12563 15111 15110 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73743 r0 *1 316.94,622.88
X$73743 73 12950 13868 15111 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73749 r0 *1 321.54,622.88
X$73749 73 15053 15134 12158 73 13980 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73750 r0 *1 323.38,622.88
X$73750 73 13055 15112 13266 57 73 15134 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73752 r0 *1 325.68,622.88
X$73752 73 13748 13679 15112 73 15135 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73755 r0 *1 333.04,622.88
X$73755 73 13985 15108 15079 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73757 r0 *1 338.1,622.88
X$73757 73 15079 15078 15136 15019 57 73 15115 57 sky130_fd_sc_hd__a31oi_1
* cell instance $73758 r0 *1 340.4,622.88
X$73758 73 14535 12950 14791 57 73 15136 57 sky130_fd_sc_hd__a21oi_1
* cell instance $73761 r0 *1 342.7,622.88
X$73761 73 13055 13062 13868 15137 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $73762 r0 *1 344.54,622.88
X$73762 73 15137 73 57 12858 57 sky130_fd_sc_hd__buf_4
* cell instance $73766 r0 *1 350.52,622.88
X$73766 73 15055 15080 12563 73 14888 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73768 r0 *1 353.28,622.88
X$73768 73 15116 13064 14187 14429 57 15163 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $73783 r0 *1 392.38,622.88
X$73783 73 15118 73 57 15081 57 sky130_fd_sc_hd__buf_4
* cell instance $73787 r0 *1 397.44,622.88
X$73787 73 15081 15138 15117 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73790 r0 *1 401.12,622.88
X$73790 73 15069 14241 15138 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73795 r0 *1 406.18,622.88
X$73795 73 13877 13989 14969 15067 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $73798 r0 *1 409.4,622.88
X$73798 73 14893 15082 15159 73 15114 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73801 r0 *1 412.62,622.88
X$73801 73 13944 14241 15157 13073 12608 73 14941 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $73802 r0 *1 415.84,622.88
X$73802 73 14968 12608 15118 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73807 r0 *1 425.5,622.88
X$73807 73 13581 15061 12450 73 15204 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73814 r0 *1 433.78,622.88
X$73814 73 13989 13581 13521 73 15084 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73817 r0 *1 441.14,622.88
X$73817 57 15082 15109 15023 14585 15084 12450 14385 73 73 57
+ sky130_fd_sc_hd__a222oi_1
* cell instance $73820 r0 *1 447.58,622.88
X$73820 73 13079 13078 15154 73 15109 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $73827 r0 *1 459.08,622.88
X$73827 73 14921 15153 13933 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73832 r0 *1 471.96,622.88
X$73832 73 13079 12798 14467 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73834 r0 *1 473.8,622.88
X$73834 73 12751 13621 15107 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73838 r0 *1 479.32,622.88
X$73838 73 14921 14923 15150 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73856 r0 *1 521.18,622.88
X$73856 73 12974 12376 15087 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73859 r0 *1 528.08,622.88
X$73859 73 15088 15145 12414 15105 15144 13925 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $73861 r0 *1 531.76,622.88
X$73861 73 14775 15102 13704 12414 57 15145 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $73862 r0 *1 534.52,622.88
X$73862 73 12414 12217 13802 15088 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $73864 r0 *1 537.28,622.88
X$73864 57 15028 15149 13704 12757 14978 14914 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $73868 r0 *1 545.56,622.88
X$73868 73 12974 73 57 15100 57 sky130_fd_sc_hd__buf_4
* cell instance $73871 r0 *1 552.46,622.88
X$73871 73 12217 15041 15146 12281 15144 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $73872 r0 *1 555.22,622.88
X$73872 73 15087 73 57 15095 57 sky130_fd_sc_hd__buf_4
* cell instance $73873 r0 *1 557.98,622.88
X$73873 73 15099 12376 14757 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $73875 r0 *1 559.36,622.88
X$73875 73 15099 73 57 14672 57 sky130_fd_sc_hd__buf_4
* cell instance $73878 r0 *1 564.88,622.88
X$73878 73 12217 15094 13907 12283 14761 15146 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $73884 r0 *1 577.3,622.88
X$73884 73 12217 12281 15089 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $73885 r0 *1 578.68,622.88
X$73885 57 13109 15034 15089 12757 14001 15092 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $74016 m0 *1 141.22,628.32
X$74016 73 15187 13556 14335 57 73 15147 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74022 m0 *1 153.64,628.32
X$74022 73 12807 15165 15121 15038 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $74023 m0 *1 155.48,628.32
X$74023 73 14774 15165 14326 15122 57 73 15189 57 sky130_fd_sc_hd__a31oi_1
* cell instance $74024 m0 *1 157.78,628.32
X$74024 73 15119 12687 15121 73 14493 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74025 m0 *1 159.62,628.32
X$74025 57 14177 15190 12689 12810 13008 15123 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $74026 m0 *1 162.84,628.32
X$74026 73 15124 14143 15125 57 73 15123 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74028 m0 *1 165.14,628.32
X$74028 73 14326 15096 15125 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74033 m0 *1 168.82,628.32
X$74033 73 12807 14991 15097 57 73 15124 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74036 m0 *1 176.18,628.32
X$74036 73 13556 12687 15097 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74048 m0 *1 201.94,628.32
X$74048 73 15196 73 57 13629 57 sky130_fd_sc_hd__buf_4
* cell instance $74053 m0 *1 214.82,628.32
X$74053 73 15173 73 57 14861 57 sky130_fd_sc_hd__buf_4
* cell instance $74056 m0 *1 220.34,628.32
X$74056 73 15200 73 57 15171 57 sky130_fd_sc_hd__buf_4
* cell instance $74064 m0 *1 239.66,628.32
X$74064 57 4950 12126 14740 15202 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $74078 m0 *1 281.06,628.32
X$74078 73 15128 14603 15174 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $74079 m0 *1 283.36,628.32
X$74079 73 12950 13331 14282 73 15128 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74080 m0 *1 285.2,628.32
X$74080 73 12158 15129 15206 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74083 m0 *1 287.96,628.32
X$74083 73 12158 15158 15176 12248 73 57 14042 57 sky130_fd_sc_hd__o31ai_1
* cell instance $74086 m0 *1 293.48,628.32
X$74086 73 13055 12158 14278 13985 15210 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $74091 m0 *1 303.14,628.32
X$74091 73 12248 73 57 15213 57 sky130_fd_sc_hd__buf_4
* cell instance $74094 m0 *1 306.82,628.32
X$74094 73 15212 15131 15214 15132 12276 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $74102 m0 *1 327.52,628.32
X$74102 73 14187 15135 13055 15113 73 15164 57 57 sky130_fd_sc_hd__a22oi_1
* cell instance $74110 m0 *1 340.4,628.32
X$74110 73 15219 73 57 14791 57 sky130_fd_sc_hd__buf_4
* cell instance $74114 m0 *1 352.36,628.32
X$74114 73 15218 14187 12191 15163 57 15212 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $74116 m0 *1 358.8,628.32
X$74116 73 12384 14878 15161 73 15218 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74123 m0 *1 371.22,628.32
X$74123 57 4950 11865 15217 15215 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $74132 m0 *1 400.66,628.32
X$74132 57 13877 15139 15069 14288 14969 13874 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $74134 m0 *1 405.72,628.32
X$74134 73 15211 15208 15182 15139 73 15159 57 57 sky130_fd_sc_hd__nand4_1
* cell instance $74137 m0 *1 410.78,628.32
X$74137 73 15140 73 57 15023 57 sky130_fd_sc_hd__buf_4
* cell instance $74138 m0 *1 413.54,628.32
X$74138 73 15207 73 57 14049 57 sky130_fd_sc_hd__buf_4
* cell instance $74141 m0 *1 417.68,628.32
X$74141 57 15140 14921 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $74142 m0 *1 425.04,628.32
X$74142 73 14648 15203 13521 15204 57 73 15157 57 sky130_fd_sc_hd__a31oi_1
* cell instance $74145 m0 *1 432.86,628.32
X$74145 73 15118 14137 15141 15182 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $74147 m0 *1 436.54,628.32
X$74147 73 13079 13793 14648 73 15183 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74148 m0 *1 438.38,628.32
X$74148 73 12568 15183 15059 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74156 m0 *1 456.32,628.32
X$74156 73 13993 13990 15184 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74157 m0 *1 457.7,628.32
X$74157 73 12751 13990 14895 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74158 m0 *1 459.08,628.32
X$74158 73 14340 15184 13521 73 15142 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74159 m0 *1 460.92,628.32
X$74159 73 15195 15142 15153 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74162 m0 *1 464.6,628.32
X$74162 73 13521 13224 15143 14894 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $74166 m0 *1 469.66,628.32
X$74166 73 14195 14467 13902 57 73 15151 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74170 m0 *1 476.56,628.32
X$74170 73 14049 15106 15186 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74171 m0 *1 477.94,628.32
X$74171 73 15186 15150 15193 13632 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $74174 m0 *1 481.16,628.32
X$74174 73 12798 12751 15143 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $74195 m0 *1 537.28,628.32
X$74195 73 13704 15149 15188 73 57 13924 57 sky130_fd_sc_hd__o21ai_1
* cell instance $74196 m0 *1 539.12,628.32
X$74196 73 13109 73 57 15028 57 sky130_fd_sc_hd__buf_4
* cell instance $74198 m0 *1 542.8,628.32
X$74198 73 15028 15087 14835 15092 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $74205 m0 *1 555.68,628.32
X$74205 73 15100 73 57 15099 57 sky130_fd_sc_hd__inv_1
* cell instance $74305 r0 *1 155.48,628.32
X$74305 73 12812 15189 13231 13123 15191 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $74307 r0 *1 159.16,628.32
X$74307 73 15166 15191 15192 15190 57 14495 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $74308 r0 *1 161.92,628.32
X$74308 73 14326 15096 14733 15122 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $74310 r0 *1 164.68,628.32
X$74310 73 15167 12687 15096 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74314 r0 *1 169.28,628.32
X$74314 73 14734 73 57 15167 57 sky130_fd_sc_hd__buf_4
* cell instance $74317 r0 *1 177.56,628.32
X$74317 73 12810 14143 15237 57 73 14737 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74322 r0 *1 182.16,628.32
X$74322 73 13314 12687 15223 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74325 r0 *1 186.3,628.32
X$74325 73 15313 15168 14151 73 14951 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74326 r0 *1 188.14,628.32
X$74326 73 12809 15152 15169 57 73 15168 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74327 r0 *1 189.98,628.32
X$74327 73 14326 14813 15223 12812 15169 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $74330 r0 *1 195.5,628.32
X$74330 73 14276 15171 15170 57 73 15166 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74333 r0 *1 199.64,628.32
X$74333 73 12848 12810 15172 57 73 15170 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74334 r0 *1 201.48,628.32
X$74334 73 14365 14733 14326 73 15172 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74338 r0 *1 207.46,628.32
X$74338 73 15198 14326 15197 57 73 15196 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74342 r0 *1 213.9,628.32
X$74342 73 13627 15173 15199 73 15198 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74344 r0 *1 216.66,628.32
X$74344 73 12848 12810 15199 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74367 r0 *1 276,628.32
X$74367 73 12563 14082 13062 73 15243 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74369 r0 *1 281.52,628.32
X$74369 73 13064 11790 15175 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74370 r0 *1 282.9,628.32
X$74370 73 15174 15206 15333 15175 14957 73 15131 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $74377 r0 *1 293.02,628.32
X$74377 73 13985 15055 14452 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74380 r0 *1 297.16,628.32
X$74380 73 15210 15209 15255 13062 73 15177 57 57 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $74382 r0 *1 301.3,628.32
X$74382 73 15160 73 57 15254 57 sky130_fd_sc_hd__buf_4
* cell instance $74385 r0 *1 306.36,628.32
X$74385 73 15177 15213 12384 15246 57 73 15214 57 sky130_fd_sc_hd__a31oi_1
* cell instance $74387 r0 *1 310.5,628.32
X$74387 73 15053 12950 14601 57 73 15247 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74389 r0 *1 312.8,628.32
X$74389 73 13055 14819 14452 57 73 15245 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74392 r0 *1 318.32,628.32
X$74392 73 13034 12953 14455 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74397 r0 *1 328.44,628.32
X$74397 73 15178 73 57 15176 57 sky130_fd_sc_hd__buf_4
* cell instance $74400 r0 *1 332.58,628.32
X$74400 73 15112 15179 14351 12384 57 73 15178 57 sky130_fd_sc_hd__a31oi_1
* cell instance $74408 r0 *1 347.76,628.32
X$74408 73 14643 13985 15180 15162 57 73 57 sky130_fd_sc_hd__nand3b_1
* cell instance $74412 r0 *1 353.74,628.32
X$74412 73 13461 15055 15180 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74415 r0 *1 356.5,628.32
X$74415 73 12953 73 57 15055 57 sky130_fd_sc_hd__buf_4
* cell instance $74417 r0 *1 360.18,628.32
X$74417 73 12384 15310 15181 15161 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $74418 r0 *1 362.02,628.32
X$74418 73 12563 13332 14458 15181 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $74439 r0 *1 412.62,628.32
X$74439 73 12606 13179 15207 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74441 r0 *1 414.46,628.32
X$74441 73 14288 14142 15140 73 15236 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74443 r0 *1 416.76,628.32
X$74443 73 15151 15205 15236 15235 13682 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $74452 r0 *1 433.78,628.32
X$74452 73 13521 14087 15201 57 73 15234 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74465 r0 *1 470.12,628.32
X$74465 73 13583 14695 14195 73 15185 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74467 r0 *1 472.88,628.32
X$74467 73 12751 13793 15263 15185 15194 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $74497 r0 *1 541.42,628.32
X$74497 73 15028 14909 15092 73 15188 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74604 m0 *1 141.68,633.76
X$74604 73 14445 12689 15266 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74605 m0 *1 143.06,633.76
X$74605 73 13049 15264 15266 15232 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $74606 m0 *1 144.9,633.76
X$74606 73 15167 13123 15264 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74612 m0 *1 152.26,633.76
X$74612 73 13162 14443 15165 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74615 m0 *1 155.02,633.76
X$74615 73 14445 12687 15121 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74616 m0 *1 156.4,633.76
X$74616 73 15165 73 57 13625 57 sky130_fd_sc_hd__buf_4
* cell instance $74618 m0 *1 159.62,633.76
X$74618 57 14177 15192 12689 12812 15268 15220 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $74620 m0 *1 163.76,633.76
X$74620 73 15221 14445 12807 57 73 15220 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74622 m0 *1 166.06,633.76
X$74622 73 12807 13263 15222 57 73 15221 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74627 m0 *1 174.34,633.76
X$74627 73 15167 13232 15222 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74628 m0 *1 175.72,633.76
X$74628 73 12807 15222 15237 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74633 m0 *1 178.48,633.76
X$74633 73 15119 13232 15239 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74634 m0 *1 179.86,633.76
X$74634 73 15238 15239 15223 13628 12807 14236 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $74636 m0 *1 183.54,633.76
X$74636 73 12807 14070 15238 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74647 m0 *1 202.86,633.76
X$74647 73 14365 14326 15119 12687 73 15251 57 57 sky130_fd_sc_hd__a211o_1
* cell instance $74653 m0 *1 214.36,633.76
X$74653 57 14039 15172 12810 12848 15271 15224 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $74660 m0 *1 226.78,633.76
X$74660 57 4950 12184 15225 15226 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $74670 m0 *1 256.68,633.76
X$74670 73 15410 57 73 15202 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $74678 m0 *1 274.16,633.76
X$74678 73 15277 15055 15227 57 73 15156 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74679 m0 *1 276,633.76
X$74679 73 13331 13055 15243 57 73 15227 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74683 m0 *1 282.44,633.76
X$74683 73 15307 15175 14282 12487 57 73 15279 57 sky130_fd_sc_hd__a31oi_1
* cell instance $74689 m0 *1 293.94,633.76
X$74689 73 15228 14282 13331 57 73 15248 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74690 m0 *1 295.78,633.76
X$74690 73 13064 12248 14608 15248 14082 73 15249 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $74691 m0 *1 299,633.76
X$74691 73 13985 14433 15255 13331 57 15281 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $74692 m0 *1 301.76,633.76
X$74692 73 14433 13868 15108 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74697 m0 *1 307.28,633.76
X$74697 73 15249 14082 15229 57 73 15246 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74699 m0 *1 309.58,633.76
X$74699 73 14433 15358 15247 73 15229 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74706 m0 *1 322.92,633.76
X$74706 73 14874 15245 12158 73 15285 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74708 m0 *1 325.22,633.76
X$74708 73 15244 73 57 13641 57 sky130_fd_sc_hd__buf_4
* cell instance $74714 m0 *1 339.48,633.76
X$74714 73 13034 15219 15179 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74715 m0 *1 340.86,633.76
X$74715 73 13985 15055 15219 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74724 m0 *1 356.5,633.76
X$74724 57 13788 15257 12563 15180 73 73 57 sky130_fd_sc_hd__and3_1
* cell instance $74735 m0 *1 375.36,633.76
X$74735 73 15242 57 73 15215 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $74740 m0 *1 385.94,633.76
X$74740 73 15241 73 57 12050 57 sky130_fd_sc_hd__buf_4
* cell instance $74747 m0 *1 395.6,633.76
X$74747 57 13575 12958 13150 14646 15286 15118 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $74752 m0 *1 406.18,633.76
X$74752 73 15230 15240 15140 73 15208 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74755 m0 *1 409.4,633.76
X$74755 73 12450 12608 15140 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74759 m0 *1 416.76,633.76
X$74759 73 14421 14142 15118 73 15205 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74760 m0 *1 418.6,633.76
X$74760 73 12958 14648 15261 57 73 15235 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74761 m0 *1 420.44,633.76
X$74761 73 13877 15203 14648 57 73 15230 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74767 m0 *1 430.1,633.76
X$74767 73 14646 14142 12450 73 15276 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74769 m0 *1 435.62,633.76
X$74769 73 15231 73 57 14087 57 sky130_fd_sc_hd__buf_4
* cell instance $74779 m0 *1 451.26,633.76
X$74779 73 13621 14099 15231 15262 12645 15154 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $74785 m0 *1 467.82,633.76
X$74785 73 15118 73 57 15263 57 sky130_fd_sc_hd__buf_4
* cell instance $74789 m0 *1 475.64,633.76
X$74789 73 14692 15263 15233 57 73 15193 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74793 m0 *1 479.32,633.76
X$74793 73 12645 73 57 13901 57 sky130_fd_sc_hd__buf_4
* cell instance $74926 r0 *1 140.76,633.76
X$74926 73 13123 12810 15187 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $74934 r0 *1 155.48,633.76
X$74934 73 12807 15165 15121 57 73 15267 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74936 r0 *1 157.78,633.76
X$74936 73 15300 14143 15267 12807 12689 73 15268 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $74941 r0 *1 171.12,633.76
X$74941 73 14991 73 57 15250 57 sky130_fd_sc_hd__buf_4
* cell instance $74952 r0 *1 192.74,633.76
X$74952 73 13780 12807 14882 57 73 15270 57 sky130_fd_sc_hd__a21oi_1
* cell instance $74961 r0 *1 211.14,633.76
X$74961 73 12807 15197 15251 73 15224 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $74962 r0 *1 212.98,633.76
X$74962 73 15250 15126 12807 12810 57 73 15271 57 sky130_fd_sc_hd__a31oi_1
* cell instance $74963 r0 *1 215.28,633.76
X$74963 73 12687 13162 15272 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $74966 r0 *1 218.96,633.76
X$74966 73 15272 73 57 15126 57 sky130_fd_sc_hd__buf_4
* cell instance $74989 r0 *1 276.46,633.76
X$74989 73 13064 15252 15253 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $74990 r0 *1 277.84,633.76
X$74990 57 15280 15253 13891 15254 15015 15331 73 73 57
+ sky130_fd_sc_hd__o311ai_2
* cell instance $74997 r0 *1 293.48,633.76
X$74997 73 14639 15228 13175 14082 12950 15378 57 73 57 sky130_fd_sc_hd__a32oi_1
* cell instance $75002 r0 *1 303.6,633.76
X$75002 73 15281 15162 15282 57 73 15252 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75012 r0 *1 321.08,633.76
X$75012 73 12631 15283 15256 15244 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $75014 r0 *1 323.84,633.76
X$75014 73 12384 15285 15164 57 73 15256 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75027 r0 *1 355.12,633.76
X$75027 73 13332 13148 12717 13985 15257 73 15384 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $75028 r0 *1 358.34,633.76
X$75028 73 13062 15055 13332 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75041 r0 *1 393.76,633.76
X$75041 73 14089 14969 12958 73 15286 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75043 r0 *1 395.6,633.76
X$75043 73 14464 13375 14969 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75044 r0 *1 396.98,633.76
X$75044 73 13577 14969 13877 73 15259 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75045 r0 *1 398.82,633.76
X$75045 57 15284 13877 14421 15258 15259 12450 73 73 57 sky130_fd_sc_hd__o311a_1
* cell instance $75049 r0 *1 405.72,633.76
X$75049 73 15258 12608 13877 14089 57 14538 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $75052 r0 *1 415.38,633.76
X$75052 73 13079 13375 15258 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75054 r0 *1 417.22,633.76
X$75054 73 14245 73 57 15260 57 sky130_fd_sc_hd__buf_4
* cell instance $75064 r0 *1 433.78,633.76
X$75064 73 13018 13866 15278 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75066 r0 *1 435.62,633.76
X$75066 73 15276 15274 15201 57 73 15275 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75068 r0 *1 439.3,633.76
X$75068 57 15273 15274 13079 14786 15261 12806 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $75074 r0 *1 452.64,633.76
X$75074 73 12866 13990 15262 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75075 r0 *1 454.02,633.76
X$75075 73 15262 73 57 15203 57 sky130_fd_sc_hd__buf_4
* cell instance $75078 r0 *1 458.16,633.76
X$75078 73 13521 12866 13621 57 73 14930 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75080 r0 *1 460.46,633.76
X$75080 73 14930 73 57 15297 57 sky130_fd_sc_hd__buf_4
* cell instance $75083 r0 *1 464.6,633.76
X$75083 73 13018 13621 15231 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75086 r0 *1 470.58,633.76
X$75086 73 13621 13018 14195 13583 57 15265 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $75224 m0 *1 143.98,639.2
X$75224 73 13445 73 57 14326 57 sky130_fd_sc_hd__buf_4
* cell instance $75225 m0 *1 146.74,639.2
X$75225 73 14989 14443 14991 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75226 m0 *1 148.12,639.2
X$75226 73 15167 14326 13833 73 57 57 sky130_fd_sc_hd__and2_1
* cell instance $75227 m0 *1 150.42,639.2
X$75227 73 13445 12687 15299 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75230 m0 *1 151.8,639.2
X$75230 73 13833 12687 13935 14989 15269 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $75231 m0 *1 154.1,639.2
X$75231 73 14443 14989 15300 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $75241 m0 *1 175.26,639.2
X$75241 73 15167 12807 14155 73 15326 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75246 m0 *1 179.4,639.2
X$75246 73 15287 15288 14276 15327 57 15339 73 57 sky130_fd_sc_hd__nor4_1
* cell instance $75248 m0 *1 183.54,639.2
X$75248 73 14326 15300 15223 15303 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $75252 m0 *1 191.82,639.2
X$75252 73 14276 15303 15270 57 73 14783 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75262 m0 *1 214.36,639.2
X$75262 73 12807 15272 15173 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75269 m0 *1 231.38,639.2
X$75269 73 15305 57 73 15226 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $75292 m0 *1 281.52,639.2
X$75292 73 15330 13034 15289 13055 15307 57 73 57 sky130_fd_sc_hd__o22ai_1
* cell instance $75293 m0 *1 283.82,639.2
X$75293 73 14868 15289 15290 73 15332 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75294 m0 *1 285.66,639.2
X$75294 73 15318 13572 11790 15308 12384 73 15290 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $75297 m0 *1 288.88,639.2
X$75297 73 13985 12158 15289 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75301 m0 *1 293.48,639.2
X$75301 73 12950 13748 15228 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75304 m0 *1 297.62,639.2
X$75304 73 13985 14455 15289 73 15291 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75309 m0 *1 306.36,639.2
X$75309 73 13064 15341 15291 15283 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $75313 m0 *1 311.42,639.2
X$75313 73 13868 15080 15292 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75314 m0 *1 312.8,639.2
X$75314 73 15292 15078 12563 14082 57 73 15282 57 sky130_fd_sc_hd__a31oi_1
* cell instance $75321 m0 *1 323.84,639.2
X$75321 73 12950 13748 13868 14874 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $75322 m0 *1 325.68,639.2
X$75322 73 13055 13748 15055 15078 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $75333 m0 *1 342.7,639.2
X$75333 73 15055 15080 15308 13985 15310 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $75341 m0 *1 362.48,639.2
X$75341 57 15309 15371 11816 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $75344 m0 *1 369.84,639.2
X$75344 57 4950 15216 15217 15293 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $75346 m0 *1 381.34,639.2
X$75346 57 15241 15217 15294 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $75355 m0 *1 402.96,639.2
X$75355 73 13375 14464 12958 14870 57 15240 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $75364 m0 *1 421.36,639.2
X$75364 73 13877 13150 14421 15296 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $75370 m0 *1 426.42,639.2
X$75370 73 13990 12866 15295 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $75371 m0 *1 428.72,639.2
X$75371 73 13877 15295 15061 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75373 m0 *1 430.56,639.2
X$75373 73 15295 73 57 15201 57 sky130_fd_sc_hd__buf_4
* cell instance $75374 m0 *1 433.32,639.2
X$75374 73 15304 15278 13073 15275 57 73 15306 57 sky130_fd_sc_hd__a31oi_1
* cell instance $75375 m0 *1 435.62,639.2
X$75375 73 13993 13877 13990 73 15304 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75376 m0 *1 437.46,639.2
X$75376 73 14930 73 57 15274 57 sky130_fd_sc_hd__buf_4
* cell instance $75379 m0 *1 441.6,639.2
X$75379 73 13990 14464 15328 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $75387 m0 *1 457.24,639.2
X$75387 73 15301 15296 12608 73 14332 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75388 m0 *1 459.08,639.2
X$75388 73 15297 13621 13993 73 15301 57 57 sky130_fd_sc_hd__o21a_1
* cell instance $75389 m0 *1 461.84,639.2
X$75389 73 15297 15261 15195 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75394 m0 *1 471.96,639.2
X$75394 73 13993 13621 15298 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75397 m0 *1 474.72,639.2
X$75397 73 15298 15143 14195 15265 57 73 15233 57 sky130_fd_sc_hd__a31oi_1
* cell instance $75538 r0 *1 154.56,639.2
X$75538 73 15299 73 57 13935 57 sky130_fd_sc_hd__buf_4
* cell instance $75543 r0 *1 169.28,639.2
X$75543 73 15097 14991 15187 12807 15311 73 15340 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $75545 r0 *1 173.42,639.2
X$75545 73 14445 13232 15040 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75547 r0 *1 175.26,639.2
X$75547 73 15040 15097 12807 15326 57 73 15288 57 sky130_fd_sc_hd__a31oi_1
* cell instance $75548 r0 *1 177.56,639.2
X$75548 57 15327 15238 12807 15187 15040 15315 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $75552 r0 *1 182.16,639.2
X$75552 73 14326 15097 15300 15312 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $75555 r0 *1 185.38,639.2
X$75555 57 15313 15303 12810 12848 15302 15269 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $75557 r0 *1 189.52,639.2
X$75557 73 15312 15314 14698 12810 12848 73 15287 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $75559 r0 *1 193.66,639.2
X$75559 73 14445 13232 14637 12807 15314 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $75562 r0 *1 200.56,639.2
X$75562 73 15316 13625 12807 12810 57 73 15302 57 sky130_fd_sc_hd__a31oi_1
* cell instance $75563 r0 *1 202.86,639.2
X$75563 73 15197 73 57 15315 57 sky130_fd_sc_hd__buf_4
* cell instance $75566 r0 *1 206.54,639.2
X$75566 73 15272 73 57 15316 57 sky130_fd_sc_hd__buf_4
* cell instance $75568 r0 *1 209.76,639.2
X$75568 73 15272 14637 15197 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75591 r0 *1 267.26,639.2
X$75591 57 15280 15350 73 73 57 sky130_fd_sc_hd__buf_12
* cell instance $75592 r0 *1 274.62,639.2
X$75592 57 15277 15317 13055 15055 13677 15318 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $75594 r0 *1 278.3,639.2
X$75594 73 12563 12158 15317 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75596 r0 *1 280.6,639.2
X$75596 73 15318 15317 15330 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75597 r0 *1 281.98,639.2
X$75597 73 15279 14865 15391 11790 15319 15331 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $75598 r0 *1 285.2,639.2
X$75598 73 15332 14082 15353 57 73 15333 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75605 r0 *1 293.48,639.2
X$75605 73 15320 13985 15228 57 73 15334 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75606 r0 *1 295.32,639.2
X$75606 73 13034 13985 15320 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75611 r0 *1 303.6,639.2
X$75611 73 12158 15055 15342 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75623 r0 *1 330.74,639.2
X$75623 57 15338 14165 12950 12158 13985 12941 73 73 57
+ sky130_fd_sc_hd__a221oi_1
* cell instance $75626 r0 *1 338.1,639.2
X$75626 73 15055 13034 15308 57 73 57 sky130_fd_sc_hd__nand2b_1
* cell instance $75642 r0 *1 371.22,639.2
X$75642 73 15309 57 73 15337 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $75648 r0 *1 382.26,639.2
X$75648 57 11727 15217 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $75657 r0 *1 409.4,639.2
X$75657 73 15336 73 57 14997 57 sky130_fd_sc_hd__buf_4
* cell instance $75659 r0 *1 414,639.2
X$75659 73 12608 15321 15260 73 15335 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75660 r0 *1 415.84,639.2
X$75660 73 12958 14870 15261 73 15321 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75670 r0 *1 432.86,639.2
X$75670 73 12608 15306 14705 73 15329 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75673 r0 *1 437,639.2
X$75673 73 13877 15201 15322 15141 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $75677 r0 *1 443.9,639.2
X$75677 73 13877 15328 15322 57 73 15361 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75686 r0 *1 460.92,639.2
X$75686 73 15323 73 57 15261 57 sky130_fd_sc_hd__buf_4
* cell instance $75688 r0 *1 464.14,639.2
X$75688 73 15298 73 57 15322 57 sky130_fd_sc_hd__buf_4
* cell instance $75692 r0 *1 474.72,639.2
X$75692 73 15324 15325 14694 14196 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $75696 r0 *1 477.94,639.2
X$75696 73 14195 15298 13929 15351 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $75836 m0 *1 155.02,644.64
X$75836 73 14445 15299 15311 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75845 m0 *1 174.8,644.64
X$75845 73 15339 73 57 14234 57 sky130_fd_sc_hd__buf_4
* cell instance $75850 m0 *1 178.94,644.64
X$75850 73 15340 73 57 13742 57 sky130_fd_sc_hd__buf_4
* cell instance $75875 m0 *1 238.28,644.64
X$75875 73 15225 57 73 57 sky130_fd_sc_hd__inv_4
* cell instance $75876 m0 *1 240.58,644.64
X$75876 57 12352 15225 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $75886 m0 *1 264.96,644.64
X$75886 57 8348 12352 15350 73 73 57 sky130_fd_sc_hd__dfxtp_4
* cell instance $75896 m0 *1 293.48,644.64
X$75896 73 13868 15334 15355 73 15353 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75897 m0 *1 295.32,644.64
X$75897 73 15356 13868 15355 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75900 m0 *1 304.06,644.64
X$75900 73 13566 15386 13748 73 15359 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75902 m0 *1 306.36,644.64
X$75902 73 12950 15359 15343 57 73 15341 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75903 m0 *1 308.2,644.64
X$75903 73 15360 15342 15343 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75906 m0 *1 312.34,644.64
X$75906 73 15112 12950 15360 57 73 15358 57 sky130_fd_sc_hd__a21boi_0
* cell instance $75910 m0 *1 315.56,644.64
X$75910 73 15344 73 57 15017 57 sky130_fd_sc_hd__buf_4
* cell instance $75911 m0 *1 318.32,644.64
X$75911 73 12563 15108 15112 57 73 15344 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75914 m0 *1 321.54,644.64
X$75914 73 13064 15381 15338 15319 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $75916 m0 *1 324.3,644.64
X$75916 73 13062 12563 15053 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75918 m0 *1 326.14,644.64
X$75918 73 13748 15055 15112 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75932 m0 *1 356.5,644.64
X$75932 57 15371 15434 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $75940 m0 *1 369.38,644.64
X$75940 57 4950 12018 15217 15362 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $75943 m0 *1 381.8,644.64
X$75943 73 15217 57 73 57 sky130_fd_sc_hd__inv_4
* cell instance $75944 m0 *1 384.1,644.64
X$75944 73 15345 57 73 15293 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $75949 m0 *1 390.54,644.64
X$75949 57 4950 12635 15217 15364 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $75954 m0 *1 402.96,644.64
X$75954 73 12450 12568 13874 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75958 m0 *1 409.4,644.64
X$75958 73 14870 15346 13874 73 15336 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75960 m0 *1 413.08,644.64
X$75960 73 13524 15335 15363 73 15365 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75964 m0 *1 416.76,644.64
X$75964 73 15348 12568 13524 12958 13274 73 15363 57 57
+ sky130_fd_sc_hd__o2111ai_1
* cell instance $75965 m0 *1 419.98,644.64
X$75965 73 13274 13375 15382 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $75970 m0 *1 422.74,644.64
X$75970 73 12958 15203 15349 15348 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $75976 m0 *1 438.38,644.64
X$75976 73 15231 73 57 15349 57 sky130_fd_sc_hd__buf_4
* cell instance $75979 m0 *1 442.52,644.64
X$75979 73 12450 12608 14786 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $75987 m0 *1 453.1,644.64
X$75987 73 13994 15361 12608 73 15357 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $75988 m0 *1 454.94,644.64
X$75988 73 13877 15203 14784 57 73 15376 57 sky130_fd_sc_hd__a21oi_1
* cell instance $75991 m0 *1 464.14,644.64
X$75991 73 15298 15143 13901 15373 57 73 15354 57 sky130_fd_sc_hd__a31oi_1
* cell instance $75997 m0 *1 472.42,644.64
X$75997 73 13901 15143 15231 15352 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $75998 m0 *1 474.26,644.64
X$75998 73 12608 15352 15351 57 73 15325 57 sky130_fd_sc_hd__a21oi_1
* cell instance $76201 r0 *1 284.74,644.64
X$76201 73 13985 14082 15318 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $76202 r0 *1 286.12,644.64
X$76202 73 13748 15318 15366 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $76205 r0 *1 287.5,644.64
X$76205 73 12563 15108 15308 15393 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $76206 r0 *1 289.34,644.64
X$76206 73 15378 15366 13868 13064 57 15377 73 57 sky130_fd_sc_hd__a211oi_1
* cell instance $76209 r0 *1 294.4,644.64
X$76209 57 15594 15356 12563 13055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $76210 r0 *1 299,644.64
X$76210 73 15394 15255 15367 15379 14932 73 57 57 sky130_fd_sc_hd__o211ai_1
* cell instance $76212 r0 *1 302.68,644.64
X$76212 73 13055 15342 12563 13062 15368 15367 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $76213 r0 *1 305.9,644.64
X$76213 73 12563 14082 13868 15368 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $76220 r0 *1 314.64,644.64
X$76220 73 15292 15308 15344 12563 14082 73 15381 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $76224 r0 *1 322,644.64
X$76224 73 13748 13985 15369 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $76225 r0 *1 323.38,644.64
X$76225 57 12472 15369 15053 13572 13868 15370 73 73 57 sky130_fd_sc_hd__o32a_1
* cell instance $76226 r0 *1 327.06,644.64
X$76226 73 15360 13677 13985 57 73 15370 57 sky130_fd_sc_hd__a21oi_1
* cell instance $76236 r0 *1 348.22,644.64
X$76236 73 15384 73 57 15383 57 sky130_fd_sc_hd__buf_4
* cell instance $76239 r0 *1 356.5,644.64
X$76239 57 11727 15371 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $76261 r0 *1 412.16,644.64
X$76261 57 14095 12450 13179 15347 15365 73 73 57 sky130_fd_sc_hd__nor4_2
* cell instance $76264 r0 *1 419.06,644.64
X$76264 73 13073 15346 15061 13150 15382 15403 73 57 57
+ sky130_fd_sc_hd__o221ai_1
* cell instance $76271 r0 *1 430.56,644.64
X$76271 73 14999 73 57 15380 57 sky130_fd_sc_hd__buf_4
* cell instance $76276 r0 *1 445.28,644.64
X$76276 73 12649 15349 15346 57 73 15398 57 sky130_fd_sc_hd__a21oi_1
* cell instance $76282 r0 *1 452.18,644.64
X$76282 73 13521 14895 15346 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $76285 r0 *1 455.86,644.64
X$76285 73 15376 15375 12568 73 15374 57 57 sky130_fd_sc_hd__o21ai_0
* cell instance $76289 r0 *1 460.92,644.64
X$76289 73 15354 73 57 15347 57 sky130_fd_sc_hd__buf_4
* cell instance $76291 r0 *1 465.52,644.64
X$76291 73 12606 12608 15390 15373 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $76489 m0 *1 286.58,650.08
X$76489 73 13570 15393 15385 57 73 15392 57 sky130_fd_sc_hd__a21oi_1
* cell instance $76491 m0 *1 288.42,650.08
X$76491 73 15377 15392 15383 15391 57 73 57 sky130_fd_sc_hd__nor3_1
* cell instance $76492 m0 *1 290.26,650.08
X$76492 73 13985 15051 13957 15385 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $76495 m0 *1 294.86,650.08
X$76495 57 15471 15394 13985 13055 73 73 57 sky130_fd_sc_hd__ha_1
* cell instance $76496 m0 *1 299.46,650.08
X$76496 73 14082 15055 15255 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $76497 m0 *1 300.84,650.08
X$76497 73 13064 15356 15386 57 73 15379 57 sky130_fd_sc_hd__a21oi_1
* cell instance $76498 m0 *1 302.68,650.08
X$76498 73 14082 15055 15386 57 73 57 sky130_fd_sc_hd__nor2_1
* cell instance $76506 m0 *1 315.1,650.08
X$76506 73 13055 15055 15051 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $76510 m0 *1 324.3,650.08
X$76510 73 15369 73 57 15360 57 sky130_fd_sc_hd__buf_4
* cell instance $76522 m0 *1 350.06,650.08
X$76522 57 4950 12546 15371 15395 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $76529 m0 *1 371.22,650.08
X$76529 73 15396 57 73 15362 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $76532 m0 *1 377.66,650.08
X$76532 57 4950 12746 15217 15397 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $76536 m0 *1 391.46,650.08
X$76536 57 4950 12914 15217 15399 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $76538 m0 *1 402.5,650.08
X$76538 57 4950 12197 15372 15402 73 73 57 sky130_fd_sc_hd__edfxtp_1
* cell instance $76542 m0 *1 416.76,650.08
X$76542 57 15401 15372 12313 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $76547 m0 *1 429.18,650.08
X$76547 73 14825 15403 15380 12568 13329 73 15400 57 57
+ sky130_fd_sc_hd__a311oi_1
* cell instance $76549 m0 *1 433.32,650.08
X$76549 57 12606 15388 15389 15400 15387 15329 73 73 57
+ sky130_fd_sc_hd__o311ai_0
* cell instance $76550 m0 *1 436.54,650.08
X$76550 73 15388 73 57 15294 57 sky130_fd_sc_hd__buf_4
* cell instance $76554 m0 *1 444.36,650.08
X$76554 57 13179 15387 14788 15273 15398 13693 73 73 57
+ sky130_fd_sc_hd__a2111oi_0
* cell instance $76558 m0 *1 454.94,650.08
X$76558 73 14131 14893 12450 15374 15357 15389 57 73 57 sky130_fd_sc_hd__a311o_1
* cell instance $76561 m0 *1 463.22,650.08
X$76561 73 13521 13224 15323 15390 73 57 57 sky130_fd_sc_hd__nand3_1
* cell instance $76568 m0 *1 473.34,650.08
X$76568 73 15324 73 57 14893 57 sky130_fd_sc_hd__buf_4
* cell instance $76569 m0 *1 476.1,650.08
X$76569 73 12606 13329 15324 73 57 57 sky130_fd_sc_hd__nand2_1
* cell instance $76741 r0 *1 243.8,650.08
X$76741 57 15405 15225 12459 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $76767 r0 *1 313.26,650.08
X$76767 57 15292 12939 13985 15053 15360 15051 73 73 57 sky130_fd_sc_hd__o32ai_1
* cell instance $76807 r0 *1 406.64,650.08
X$76807 57 15406 11727 12454 73 73 57 sky130_fd_sc_hd__dfxtp_1
* cell instance $76809 r0 *1 414.92,650.08
X$76809 57 11727 15372 73 73 57 sky130_fd_sc_hd__clkbuf_16
* cell instance $77122 m0 *1 242.42,655.52
X$77122 73 15407 57 73 14863 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77124 m0 *1 246.1,655.52
X$77124 73 15411 57 73 15001 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77135 r0 *1 257.14,655.52
X$77135 73 15405 57 73 15412 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77185 m0 *1 311.42,655.52
X$77185 73 15413 57 73 12486 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77214 m0 *1 342.24,655.52
X$77214 73 15418 57 73 15395 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77216 m0 *1 345.92,655.52
X$77216 73 15408 57 73 14347 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77247 m0 *1 379.04,655.52
X$77247 73 15409 57 73 15397 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77251 m0 *1 385.02,655.52
X$77251 73 15404 57 73 12238 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77257 m0 *1 389.16,655.52
X$77257 73 15420 57 73 15364 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77264 m0 *1 395.6,655.52
X$77264 73 15419 57 73 12704 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77267 r0 *1 397.9,655.52
X$77267 73 15421 57 73 12380 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77268 m0 *1 399.28,655.52
X$77268 73 15422 57 73 15399 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77275 m0 *1 407.56,655.52
X$77275 73 15417 57 73 12230 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77279 r0 *1 412.62,655.52
X$77279 73 15406 57 73 15416 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77285 m0 *1 416.76,655.52
X$77285 57 15372 15433 73 73 57 sky130_fd_sc_hd__inv_8
* cell instance $77287 m0 *1 420.9,655.52
X$77287 73 15415 57 73 15402 57 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $77288 r0 *1 422.28,655.52
X$77288 73 15401 57 73 15414 57 sky130_fd_sc_hd__clkdlybuf4s50_1
.ENDS aes_cipher_top

* cell sky130_fd_sc_hd__a41oi_2
* pin VGND
* pin Y
* pin B1
* pin A1
* pin A2
* pin A3
* pin A4
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_2 1 2 6 7 8 9 10 12 13 14
* net 1 VGND
* net 2 Y
* net 6 B1
* net 7 A1
* net 8 A2
* net 9 A3
* net 10 A4
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 1.08,1.985 pfet_01v8_hvt
M$1 2 6 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.92,1.985 pfet_01v8_hvt
M$3 12 7 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 2.76,1.985 pfet_01v8_hvt
M$5 12 8 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=280000000000P PS=2540000U PD=2560000U
* device instance $7 r0 *1 3.62,1.985 pfet_01v8_hvt
M$7 12 9 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=530000000000P
+ AD=520000000000P PS=3060000U PD=3040000U
* device instance $9 r0 *1 4.96,1.985 pfet_01v8_hvt
M$9 12 10 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 4.12,0.56 nfet_01v8
M$11 4 9 5 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $13 r0 *1 4.96,0.56 nfet_01v8
M$13 1 10 5 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $15 r0 *1 1.92,0.56 nfet_01v8
M$15 2 7 3 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $17 r0 *1 2.76,0.56 nfet_01v8
M$17 4 8 3 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $19 r0 *1 0.56,0.56 nfet_01v8
M$19 2 6 1 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__a41oi_2

* cell sky130_fd_sc_hd__nor3b_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_2 1 2 3 4 6 9 10 11
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 6 C_N
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 2 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=415000000000P PS=3830000U PD=3830000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 9 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 4.13,1.695 pfet_01v8_hvt
M$7 9 6 5 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $8 r0 *1 4.13,0.675 nfet_01v8
M$8 1 6 5 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=269750000000P
+ PS=2740000U PD=2780000U
* device instance $11 r0 *1 0.49,0.56 nfet_01v8
M$11 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $13 r0 *1 1.33,0.56 nfet_01v8
M$13 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3b_2

* cell sky130_fd_sc_hd__a2111oi_2
* pin VGND
* pin Y
* pin C1
* pin D1
* pin B1
* pin A1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_2 1 2 3 4 5 6 7 10 11 16
* net 1 VGND
* net 2 Y
* net 3 C1
* net 4 D1
* net 5 B1
* net 6 A1
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 3.64,1.985 pfet_01v8_hvt
M$1 11 6 13 10 pfet_01v8_hvt L=150000U W=2000000U AS=420000000000P
+ AD=475000000000P PS=3840000U PD=3950000U
* device instance $2 r0 *1 4.07,1.985 pfet_01v8_hvt
M$2 13 7 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=300000000000P PS=2560000U PD=2600000U
* device instance $5 r0 *1 0.5,1.985 pfet_01v8_hvt
M$5 14 3 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=285000000000P
+ AD=140000000000P PS=2570000U PD=1280000U
* device instance $6 r0 *1 0.93,1.985 pfet_01v8_hvt
M$6 2 4 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $7 r0 *1 1.36,1.985 pfet_01v8_hvt
M$7 15 4 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $8 r0 *1 1.79,1.985 pfet_01v8_hvt
M$8 12 3 15 10 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=160000000000P PS=1280000U PD=1320000U
* device instance $9 r0 *1 2.26,1.985 pfet_01v8_hvt
M$9 13 5 12 10 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=400000000000P PS=2600000U PD=3800000U
* device instance $11 r0 *1 0.5,0.56 nfet_01v8
M$11 1 3 2 16 nfet_01v8 L=150000U W=1300000U AS=312000000000P AD=196625000000P
+ PS=2910000U PD=1905000U
* device instance $12 r0 *1 0.93,0.56 nfet_01v8
M$12 2 4 1 16 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=217750000000P
+ PS=1860000U PD=1970000U
* device instance $15 r0 *1 2.375,0.56 nfet_01v8
M$15 1 5 2 16 nfet_01v8 L=150000U W=1300000U AS=232375000000P AD=217750000000P
+ PS=2015000U PD=1970000U
* device instance $17 r0 *1 3.345,0.56 nfet_01v8
M$17 9 6 2 16 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=178750000000P
+ PS=930000U PD=1200000U
* device instance $18 r0 *1 4.045,0.56 nfet_01v8
M$18 1 7 9 16 nfet_01v8 L=150000U W=650000U AS=178750000000P AD=112125000000P
+ PS=1200000U PD=995000U
* device instance $19 r0 *1 4.54,0.56 nfet_01v8
M$19 8 7 1 16 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=91000000000P
+ PS=995000U PD=930000U
* device instance $20 r0 *1 4.97,0.56 nfet_01v8
M$20 2 6 8 16 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a2111oi_2

* cell sky130_fd_sc_hd__a2111oi_4
* pin VGND
* pin D1
* pin Y
* pin C1
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_4 1 2 3 4 5 7 8 12 13 14
* net 1 VGND
* net 2 D1
* net 3 Y
* net 4 C1
* net 5 B1
* net 7 A1
* net 8 A2
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 4.44,1.985 pfet_01v8_hvt
M$1 11 5 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=680000000000P
+ AD=565000000000P PS=6360000U PD=5130000U
* device instance $5 r0 *1 6.17,1.985 pfet_01v8_hvt
M$5 12 7 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=575000000000P
+ AD=630000000000P PS=5150000U PD=5260000U
* device instance $9 r0 *1 8.03,1.985 pfet_01v8_hvt
M$9 12 8 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=730000000000P PS=5330000U PD=6460000U
* device instance $13 r0 *1 0.48,1.985 pfet_01v8_hvt
M$13 3 2 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $17 r0 *1 2.2,1.985 pfet_01v8_hvt
M$17 11 4 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=560000000000P
+ AD=680000000000P PS=5120000U PD=6360000U
* device instance $21 r0 *1 6.38,0.56 nfet_01v8
M$21 3 7 6 14 nfet_01v8 L=150000U W=2600000U AS=455000000000P AD=394875000000P
+ PS=4650000U PD=3815000U
* device instance $25 r0 *1 8.195,0.56 nfet_01v8
M$25 1 8 6 14 nfet_01v8 L=150000U W=2600000U AS=394875000000P AD=445250000000P
+ PS=3815000U PD=4620000U
* device instance $29 r0 *1 0.49,0.56 nfet_01v8
M$29 3 2 1 14 nfet_01v8 L=150000U W=2600000U AS=451750000000P AD=386750000000P
+ PS=4640000U PD=3790000U
* device instance $33 r0 *1 2.28,0.56 nfet_01v8
M$33 3 4 1 14 nfet_01v8 L=150000U W=2600000U AS=390000000000P AD=399750000000P
+ PS=3800000U PD=3830000U
* device instance $37 r0 *1 4.11,0.56 nfet_01v8
M$37 3 5 1 14 nfet_01v8 L=150000U W=2600000U AS=399750000000P AD=455000000000P
+ PS=3830000U PD=4650000U
.ENDS sky130_fd_sc_hd__a2111oi_4

* cell sky130_fd_sc_hd__clkbuf_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_8 1 2 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 1.335,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.12e+12P AD=1.245e+12P
+ PS=10240000U PD=11490000U
* device instance $11 r0 *1 0.475,0.445 nfet_01v8
M$11 3 2 1 7 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=117600000000P
+ PS=2070000U PD=1400000U
* device instance $13 r0 *1 1.335,0.445 nfet_01v8
M$13 4 3 1 7 nfet_01v8 L=150000U W=3360000U AS=470400000000P AD=525000000000P
+ PS=5600000U PD=6280000U
.ENDS sky130_fd_sc_hd__clkbuf_8

* cell sky130_fd_sc_hd__a311oi_2
* pin VGND
* pin Y
* pin A3
* pin A2
* pin A1
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_2 1 4 5 6 7 8 9 10 13 14
* net 1 VGND
* net 4 Y
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 B1
* net 9 C1
* net 10 VPWR
* net 13 VPB
* device instance $1 r0 *1 3.54,1.985 pfet_01v8_hvt
M$1 11 8 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=2790000U
* device instance $3 r0 *1 4.63,1.985 pfet_01v8_hvt
M$3 4 9 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=2790000U PD=3790000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 11 5 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 11 6 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=275000000000P
+ AD=285000000000P PS=2550000U PD=2570000U
* device instance $9 r0 *1 2.18,1.985 pfet_01v8_hvt
M$9 11 7 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=395000000000P PS=2560000U PD=3790000U
* device instance $11 r0 *1 2.67,0.56 nfet_01v8
M$11 3 7 4 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=185250000000P
+ PS=2740000U PD=1870000U
* device instance $13 r0 *1 3.54,0.56 nfet_01v8
M$13 1 8 4 14 nfet_01v8 L=150000U W=1300000U AS=185250000000P AD=256750000000P
+ PS=1870000U PD=2090000U
* device instance $15 r0 *1 4.63,0.56 nfet_01v8
M$15 1 9 4 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2090000U PD=2740000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 1 5 2 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $19 r0 *1 1.31,0.56 nfet_01v8
M$19 3 6 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a311oi_2

* cell sky130_fd_sc_hd__a22oi_2
* pin VGND
* pin B2
* pin B1
* pin Y
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_2 1 3 4 5 7 8 10 11 12
* net 1 VGND
* net 3 B2
* net 4 B1
* net 5 Y
* net 7 A1
* net 8 A2
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 3.51,1.985 pfet_01v8_hvt
M$3 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 9 3 5 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 9 4 5 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 2.67,0.56 nfet_01v8
M$9 5 7 6 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 3.51,0.56 nfet_01v8
M$11 1 8 6 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 3 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 5 4 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a22oi_2

* cell sky130_fd_sc_hd__inv_12
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__inv_12 1 2 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.635,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=12000000U AS=1.745e+12P AD=2e+12P
+ PS=16490000U PD=17000000U
* device instance $13 r0 *1 0.635,0.56 nfet_01v8
M$13 3 2 1 6 nfet_01v8 L=150000U W=7800000U AS=1.13425e+12P AD=1.3e+12P
+ PS=11940000U PD=12450000U
.ENDS sky130_fd_sc_hd__inv_12

* cell sky130_fd_sc_hd__buf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 2 3 6 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.08e+12P AD=1.205e+12P
+ PS=10160000U PD=11410000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 2 3 7 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $15 r0 *1 1.73,0.56 nfet_01v8
M$15 4 3 1 7 nfet_01v8 L=150000U W=5200000U AS=702000000000P AD=783250000000P
+ PS=7360000U PD=8260000U
.ENDS sky130_fd_sc_hd__buf_8

* cell sky130_fd_sc_hd__o21ai_2
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_2 1 2 3 4 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 7 VGND
* net 8 Y
* net 9 VPWR
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 6 2 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=440000000000P
+ AD=300000000000P PS=3880000U PD=2600000U
* device instance $2 r0 *1 0.915,1.985 pfet_01v8_hvt
M$2 8 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=315000000000P PS=2560000U PD=2630000U
* device instance $5 r0 *1 2.315,1.985 pfet_01v8_hvt
M$5 8 4 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=405000000000P PS=2600000U PD=3810000U
* device instance $7 r0 *1 0.485,0.56 nfet_01v8
M$7 7 2 5 10 nfet_01v8 L=150000U W=1300000U AS=299000000000P AD=182000000000P
+ PS=2870000U PD=1860000U
* device instance $8 r0 *1 0.915,0.56 nfet_01v8
M$8 5 3 7 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=217750000000P
+ PS=1860000U PD=1970000U
* device instance $11 r0 *1 2.315,0.56 nfet_01v8
M$11 8 4 5 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__o21ai_2

* cell sky130_fd_sc_hd__o21ai_4
* pin VGND
* pin A2
* pin B1
* pin A1
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_4 1 2 3 5 6 7 8 10
* net 1 VGND
* net 2 A2
* net 3 B1
* net 5 A1
* net 6 Y
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.5,1.985 pfet_01v8_hvt
M$1 9 5 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=580000000000P PS=6370000U PD=5160000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 2 9 8 pfet_01v8_hvt L=150000U W=4000000U AS=560000000000P
+ AD=560000000000P PS=5120000U PD=5120000U
* device instance $9 r0 *1 3.98,1.985 pfet_01v8_hvt
M$9 6 3 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=580000000000P
+ AD=685000000000P PS=5160000U PD=6370000U
* device instance $13 r0 *1 0.5,0.56 nfet_01v8
M$13 1 5 4 10 nfet_01v8 L=150000U W=2600000U AS=458250000000P AD=364000000000P
+ PS=4660000U PD=3720000U
* device instance $16 r0 *1 1.79,0.56 nfet_01v8
M$16 4 2 1 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=377000000000P
+ PS=3720000U PD=3760000U
* device instance $21 r0 *1 3.98,0.56 nfet_01v8
M$21 6 3 4 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=458250000000P
+ PS=3720000U PD=4660000U
.ENDS sky130_fd_sc_hd__o21ai_4

* cell sky130_fd_sc_hd__o21a_2
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__o21a_2 1 3 4 5 6 7 8 10
* net 1 VPB
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=397500000000P
+ AD=537500000000P PS=3795000U PD=3075000U
* device instance $3 r0 *1 1.845,1.985 pfet_01v8_hvt
M$3 2 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=400000000000P
+ AD=140000000000P PS=1800000U PD=1280000U
* device instance $4 r0 *1 2.275,1.985 pfet_01v8_hvt
M$4 11 4 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=160000000000P PS=1280000U PD=1320000U
* device instance $5 r0 *1 2.745,1.985 pfet_01v8_hvt
M$5 7 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=265000000000P PS=1320000U PD=2530000U
* device instance $6 r0 *1 1.845,0.56 nfet_01v8
M$6 9 3 2 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $7 r0 *1 2.275,0.56 nfet_01v8
M$7 6 4 9 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=104000000000P
+ PS=930000U PD=970000U
* device instance $8 r0 *1 2.745,0.56 nfet_01v8
M$8 9 5 6 10 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=172250000000P
+ PS=970000U PD=1830000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 8 2 6 10 nfet_01v8 L=150000U W=1300000U AS=258375000000P AD=261625000000P
+ PS=2745000U PD=2755000U
.ENDS sky130_fd_sc_hd__o21a_2

* cell sky130_fd_sc_hd__or3b_2
* pin VPB
* pin B
* pin A
* pin C_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or3b_2 1 2 3 5 6 8 9 10
* net 1 VPB
* net 2 B
* net 3 A
* net 5 C_N
* net 6 X
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 1.865,1.695 pfet_01v8_hvt
M$1 12 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=148250000000P AD=56700000000P
+ PS=1340000U PD=690000U
* device instance $2 r0 *1 2.285,1.695 pfet_01v8_hvt
M$2 11 2 12 1 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $3 r0 *1 2.705,1.695 pfet_01v8_hvt
M$3 7 4 11 1 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $4 r0 *1 0.47,2.01 pfet_01v8_hvt
M$4 4 5 9 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $5 r0 *1 0.955,1.985 pfet_01v8_hvt
M$5 6 7 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=280750000000P
+ AD=283250000000P PS=2605000U PD=2610000U
* device instance $7 r0 *1 0.47,0.445 nfet_01v8
M$7 8 5 4 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $8 r0 *1 1.865,0.475 nfet_01v8
M$8 7 3 8 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $9 r0 *1 2.285,0.475 nfet_01v8
M$9 8 2 7 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $10 r0 *1 2.705,0.475 nfet_01v8
M$10 7 4 8 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $11 r0 *1 0.955,0.56 nfet_01v8
M$11 6 7 8 10 nfet_01v8 L=150000U W=1300000U AS=188000000000P AD=189625000000P
+ PS=1905000U PD=1910000U
.ENDS sky130_fd_sc_hd__or3b_2

* cell sky130_fd_sc_hd__and2_0
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_0 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.54,2.275 pfet_01v8_hvt
M$1 4 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=60900000000P
+ PS=1370000U PD=710000U
* device instance $2 r0 *1 0.98,2.275 pfet_01v8_hvt
M$2 4 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=184100000000P AD=60900000000P
+ PS=1260000U PD=710000U
* device instance $3 r0 *1 1.75,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=184100000000P AD=169600000000P
+ PS=1260000U PD=1810000U
* device instance $4 r0 *1 0.54,0.445 nfet_01v8
M$4 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=1370000U PD=630000U
* device instance $5 r0 *1 0.9,0.445 nfet_01v8
M$5 7 3 9 8 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=96600000000P
+ PS=630000U PD=880000U
* device instance $6 r0 *1 1.51,0.445 nfet_01v8
M$6 5 4 7 8 nfet_01v8 L=150000U W=420000U AS=96600000000P AD=111300000000P
+ PS=880000U PD=1370000U
.ENDS sky130_fd_sc_hd__and2_0

* cell sky130_fd_sc_hd__a31o_1
* pin VGND
* pin X
* pin A3
* pin A2
* pin A1
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31o_1 1 2 6 7 8 9 11 12 13
* net 1 VGND
* net 2 X
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 B1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 3 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=172500000000P PS=2530000U PD=1345000U
* device instance $2 r0 *1 0.97,1.985 pfet_01v8_hvt
M$2 10 6 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=160000000000P PS=1345000U PD=1320000U
* device instance $3 r0 *1 1.44,1.985 pfet_01v8_hvt
M$3 11 7 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=165000000000P PS=1320000U PD=1330000U
* device instance $4 r0 *1 1.92,1.985 pfet_01v8_hvt
M$4 10 8 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $5 r0 *1 2.4,1.985 pfet_01v8_hvt
M$5 3 9 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=320000000000P PS=1330000U PD=2640000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=112125000000P
+ PS=1830000U PD=995000U
* device instance $7 r0 *1 0.97,0.56 nfet_01v8
M$7 4 6 1 13 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=104000000000P
+ PS=995000U PD=970000U
* device instance $8 r0 *1 1.44,0.56 nfet_01v8
M$8 5 7 4 13 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=107250000000P
+ PS=970000U PD=980000U
* device instance $9 r0 *1 1.92,0.56 nfet_01v8
M$9 3 8 5 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.4,0.56 nfet_01v8
M$10 1 9 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=208000000000P
+ PS=980000U PD=1940000U
.ENDS sky130_fd_sc_hd__a31o_1

* cell sky130_fd_sc_hd__or4_4
* pin VGND
* pin D
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or4_4 1 2 4 5 6 7 8 9 13
* net 1 VGND
* net 2 D
* net 4 X
* net 5 C
* net 6 B
* net 7 A
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 2 3 9 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=190000000000P PS=2520000U PD=1380000U
* device instance $2 r0 *1 1.025,1.985 pfet_01v8_hvt
M$2 12 5 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $3 r0 *1 1.445,1.985 pfet_01v8_hvt
M$3 11 6 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.865,1.985 pfet_01v8_hvt
M$4 8 7 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=190000000000P PS=1270000U PD=1380000U
* device instance $5 r0 *1 2.395,1.985 pfet_01v8_hvt
M$5 4 3 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=595000000000P
+ AD=675000000000P PS=5190000U PD=6350000U
* device instance $9 r0 *1 0.495,0.56 nfet_01v8
M$9 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=123500000000P
+ PS=1820000U PD=1030000U
* device instance $10 r0 *1 1.025,0.56 nfet_01v8
M$10 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=87750000000P
+ PS=1030000U PD=920000U
* device instance $11 r0 *1 1.445,0.56 nfet_01v8
M$11 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $12 r0 *1 1.865,0.56 nfet_01v8
M$12 1 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $13 r0 *1 2.395,0.56 nfet_01v8
M$13 4 3 1 13 nfet_01v8 L=150000U W=2600000U AS=386750000000P AD=442000000000P
+ PS=3790000U PD=4610000U
.ENDS sky130_fd_sc_hd__or4_4

* cell sky130_fd_sc_hd__nand3_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_2 1 3 5 6 7 8 9 10
* net 1 VGND
* net 3 Y
* net 5 A
* net 6 B
* net 7 C
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 3 7 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=445000000000P PS=3790000U PD=3890000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 3 6 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $7 r0 *1 2.67,0.56 nfet_01v8
M$7 4 7 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=289250000000P
+ PS=2740000U PD=2840000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 5 2 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.31,0.56 nfet_01v8
M$11 4 6 2 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand3_2

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6

* cell sky130_fd_sc_hd__or3_4
* pin VGND
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or3_4 1 3 4 5 6 7 8 11
* net 1 VGND
* net 3 X
* net 4 C
* net 5 B
* net 6 A
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 2 8 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 5 10 8 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 6 9 8 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=400000000000P PS=1270000U PD=1800000U
* device instance $4 r0 *1 2.26,1.985 pfet_01v8_hvt
M$4 3 2 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=805000000000P
+ AD=765000000000P PS=5610000U PD=6530000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 4 2 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $9 r0 *1 0.89,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 1 6 2 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=260000000000P
+ PS=920000U PD=1450000U
* device instance $11 r0 *1 2.26,0.56 nfet_01v8
M$11 3 2 1 11 nfet_01v8 L=150000U W=2600000U AS=523250000000P AD=468000000000P
+ PS=4210000U PD=4690000U
.ENDS sky130_fd_sc_hd__or3_4

* cell sky130_fd_sc_hd__nor3_2
* pin VGND
* pin A
* pin Y
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3_2 1 2 3 4 5 7 9 10
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 B
* net 5 C
* net 7 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 7 2 6 9 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 6 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 3 5 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 3 2 1 10 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $11 r0 *1 1.33,0.56 nfet_01v8
M$11 3 4 1 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3_2

* cell sky130_fd_sc_hd__nand2b_2
* pin VGND
* pin Y
* pin A_N
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_2 1 4 5 6 7 8 9
* net 1 VGND
* net 4 Y
* net 5 A_N
* net 6 B
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 5 2 8 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=146800000000P
+ PS=1360000U PD=1340000U
* device instance $2 r0 *1 0.96,1.985 pfet_01v8_hvt
M$2 4 2 7 8 pfet_01v8_hvt L=150000U W=2000000U AS=311800000000P
+ AD=500000000000P PS=2670000U PD=3000000U
* device instance $4 r0 *1 2.26,1.985 pfet_01v8_hvt
M$4 4 6 7 8 pfet_01v8_hvt L=150000U W=2000000U AS=470000000000P
+ AD=410000000000P PS=2940000U PD=3820000U
* device instance $6 r0 *1 1.48,0.56 nfet_01v8
M$6 4 2 3 9 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $8 r0 *1 2.32,0.56 nfet_01v8
M$8 1 6 3 9 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 2 5 1 9 nfet_01v8 L=150000U W=420000U AS=194000000000P AD=109200000000P
+ PS=1950000U PD=1360000U
.ENDS sky130_fd_sc_hd__nand2b_2

* cell sky130_fd_sc_hd__or2_0
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_0 1 2 3 4 6 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 9 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.985 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=98950000000P
+ PS=630000U PD=975000U
* device instance $3 r0 *1 1.52,2.095 pfet_01v8_hvt
M$3 4 5 7 1 pfet_01v8_hvt L=150000U W=640000U AS=98950000000P AD=217600000000P
+ PS=975000U PD=1960000U
* device instance $4 r0 *1 0.615,0.675 nfet_01v8
M$4 5 2 6 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.675 nfet_01v8
M$5 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=70350000000P
+ PS=690000U PD=755000U
* device instance $6 r0 *1 1.52,0.675 nfet_01v8
M$6 4 5 6 8 nfet_01v8 L=150000U W=420000U AS=70350000000P AD=109200000000P
+ PS=755000U PD=1360000U
.ENDS sky130_fd_sc_hd__or2_0

* cell sky130_fd_sc_hd__nor4b_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_2 1 2 4 5 6 7 11 12 13
* net 1 VGND
* net 2 Y
* net 4 A
* net 5 B
* net 6 C
* net 7 D_N
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 4.905,2.275 pfet_01v8_hvt
M$1 11 7 3 12 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $2 r0 *1 2.705,1.985 pfet_01v8_hvt
M$2 9 6 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $4 r0 *1 3.545,1.985 pfet_01v8_hvt
M$4 2 3 10 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 11 4 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $8 r0 *1 1.31,1.985 pfet_01v8_hvt
M$8 9 5 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $10 r0 *1 4.905,0.675 nfet_01v8
M$10 1 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $11 r0 *1 2.705,0.56 nfet_01v8
M$11 2 6 1 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $13 r0 *1 3.545,0.56 nfet_01v8
M$13 2 3 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $15 r0 *1 0.47,0.56 nfet_01v8
M$15 2 4 1 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $17 r0 *1 1.31,0.56 nfet_01v8
M$17 2 5 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor4b_2

* cell sky130_fd_sc_hd__o31a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31a_1 1 2 5 6 7 8 9 10 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.65,1.985 pfet_01v8_hvt
M$1 9 4 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=360000000000P
+ AD=195000000000P PS=2720000U PD=1390000U
* device instance $2 r0 *1 1.19,1.985 pfet_01v8_hvt
M$2 12 5 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=135000000000P PS=1390000U PD=1270000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 11 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.09,1.985 pfet_01v8_hvt
M$4 4 7 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=212500000000P PS=1330000U PD=1425000U
* device instance $5 r0 *1 2.665,1.985 pfet_01v8_hvt
M$5 9 8 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=345000000000P PS=1425000U PD=2690000U
* device instance $6 r0 *1 0.65,0.56 nfet_01v8
M$6 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=234000000000P AD=126750000000P
+ PS=2020000U PD=1040000U
* device instance $7 r0 *1 1.19,0.56 nfet_01v8
M$7 3 5 1 13 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.61,0.56 nfet_01v8
M$8 1 6 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 2.09,0.56 nfet_01v8
M$9 3 7 1 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.57,0.56 nfet_01v8
M$10 4 8 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=201500000000P
+ PS=980000U PD=1920000U
.ENDS sky130_fd_sc_hd__o31a_1

* cell sky130_fd_sc_hd__a2bb2oi_2
* pin VGND
* pin Y
* pin B1
* pin B2
* pin A1_N
* pin A2_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2bb2oi_2 1 3 5 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 5 B1
* net 6 B2
* net 7 A1_N
* net 8 A2_N
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.645,1.985 pfet_01v8_hvt
M$1 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 4.485,1.985 pfet_01v8_hvt
M$3 4 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $5 r0 *1 0.605,1.985 pfet_01v8_hvt
M$5 10 5 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $6 r0 *1 1.025,1.985 pfet_01v8_hvt
M$6 12 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 2.285,1.985 pfet_01v8_hvt
M$9 3 4 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 0.605,0.56 nfet_01v8
M$11 2 5 1 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $12 r0 *1 1.025,0.56 nfet_01v8
M$12 3 6 2 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $15 r0 *1 2.285,0.56 nfet_01v8
M$15 3 4 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=344500000000P
+ PS=1840000U PD=2360000U
* device instance $17 r0 *1 3.645,0.56 nfet_01v8
M$17 4 7 1 13 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=175500000000P
+ PS=2360000U PD=1840000U
* device instance $19 r0 *1 4.485,0.56 nfet_01v8
M$19 4 8 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__a2bb2oi_2

* cell sky130_fd_sc_hd__o311ai_2
* pin VGND
* pin Y
* pin A1
* pin A2
* pin A3
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_2 1 4 5 6 7 8 9 11 13 14
* net 1 VGND
* net 4 Y
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 C1
* net 11 VPWR
* net 13 VPB
* device instance $1 r0 *1 2.79,1.985 pfet_01v8_hvt
M$1 12 7 4 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 3.63,1.985 pfet_01v8_hvt
M$3 11 8 4 13 pfet_01v8_hvt L=150000U W=2000000U AS=440000000000P
+ AD=510000000000P PS=2880000U PD=3020000U
* device instance $5 r0 *1 4.95,1.985 pfet_01v8_hvt
M$5 11 9 4 13 pfet_01v8_hvt L=150000U W=2000000U AS=340000000000P
+ AD=395000000000P PS=2680000U PD=3790000U
* device instance $7 r0 *1 0.59,1.985 pfet_01v8_hvt
M$7 11 5 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $9 r0 *1 1.43,1.985 pfet_01v8_hvt
M$9 12 6 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 4.97,0.56 nfet_01v8
M$11 3 9 4 14 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=256750000000P
+ PS=2780000U PD=2740000U
* device instance $13 r0 *1 0.61,0.56 nfet_01v8
M$13 1 5 2 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.45,0.56 nfet_01v8
M$15 1 6 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 2.29,0.56 nfet_01v8
M$17 1 7 2 14 nfet_01v8 L=150000U W=1300000U AS=318500000000P AD=318500000000P
+ PS=2280000U PD=2280000U
* device instance $19 r0 *1 3.57,0.56 nfet_01v8
M$19 3 8 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__o311ai_2

* cell sky130_fd_sc_hd__clkinv_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_8 1 3 4 5 6
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 4 5 pfet_01v8_hvt L=150000U W=12000000U AS=1.7475e+12P AD=1.7475e+12P
+ PS=16495000U PD=16495000U
* device instance $13 r0 *1 1.415,0.445 nfet_01v8
M$13 2 3 1 6 nfet_01v8 L=150000U W=3360000U AS=522900000000P AD=522900000000P
+ PS=6270000U PD=6270000U
.ENDS sky130_fd_sc_hd__clkinv_8

* cell sky130_fd_sc_hd__or2_1
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 5 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.695 pfet_01v8_hvt
M$1 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.695 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=145750000000P
+ PS=630000U PD=1335000U
* device instance $3 r0 *1 1.52,1.985 pfet_01v8_hvt
M$3 4 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=340000000000P PS=1335000U PD=2680000U
* device instance $4 r0 *1 0.615,0.445 nfet_01v8
M$4 6 2 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.445 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=100250000000P
+ PS=690000U PD=985000U
* device instance $6 r0 *1 1.52,0.56 nfet_01v8
M$6 4 6 5 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=169000000000P
+ PS=985000U PD=1820000U
.ENDS sky130_fd_sc_hd__or2_1

* cell sky130_fd_sc_hd__mux2i_4
* pin VGND
* pin A0
* pin Y
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_4 1 2 3 7 8 10 11 13
* net 1 VGND
* net 2 A0
* net 3 Y
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.35,1.985 pfet_01v8_hvt
M$1 9 8 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.03,1.985 pfet_01v8_hvt
M$5 12 6 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=567500000000P
+ AD=590000000000P PS=5135000U PD=5180000U
* device instance $9 r0 *1 7.81,1.985 pfet_01v8_hvt
M$9 6 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=157500000000P
+ AD=260000000000P PS=1315000U PD=2520000U
* device instance $10 r0 *1 0.47,1.985 pfet_01v8_hvt
M$10 9 2 3 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $14 r0 *1 2.15,1.985 pfet_01v8_hvt
M$14 12 7 3 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $18 r0 *1 4.35,0.56 nfet_01v8
M$18 5 8 1 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $22 r0 *1 6.03,0.56 nfet_01v8
M$22 4 6 1 13 nfet_01v8 L=150000U W=2600000U AS=368875000000P AD=383500000000P
+ PS=3735000U PD=3780000U
* device instance $26 r0 *1 7.81,0.56 nfet_01v8
M$26 6 8 1 13 nfet_01v8 L=150000U W=650000U AS=102375000000P AD=169000000000P
+ PS=965000U PD=1820000U
* device instance $27 r0 *1 0.47,0.56 nfet_01v8
M$27 4 2 3 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $31 r0 *1 2.15,0.56 nfet_01v8
M$31 5 7 3 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__mux2i_4

* cell sky130_fd_sc_hd__mux2_4
* pin VGND
* pin S
* pin A0
* pin A1
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_4 1 3 4 6 7 10 11 14
* net 1 VGND
* net 3 S
* net 4 A0
* net 6 A1
* net 7 X
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.37,1.985 pfet_01v8_hvt
M$1 10 3 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 3.79,1.985 pfet_01v8_hvt
M$2 7 5 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 1.905,1.985 pfet_01v8_hvt
M$6 5 4 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $7 r0 *1 2.375,1.985 pfet_01v8_hvt
M$7 12 6 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=300000000000P PS=1320000U PD=2600000U
* device instance $8 r0 *1 0.47,1.985 pfet_01v8_hvt
M$8 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=162500000000P PS=2520000U PD=1325000U
* device instance $9 r0 *1 0.945,1.985 pfet_01v8_hvt
M$9 12 2 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=280000000000P PS=1325000U PD=2560000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 3 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=108875000000P
+ PS=1820000U PD=985000U
* device instance $11 r0 *1 0.955,0.56 nfet_01v8
M$11 8 2 1 14 nfet_01v8 L=150000U W=650000U AS=108875000000P AD=260000000000P
+ PS=985000U PD=1450000U
* device instance $12 r0 *1 1.905,0.56 nfet_01v8
M$12 5 4 8 14 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=104000000000P
+ PS=1450000U PD=970000U
* device instance $13 r0 *1 2.375,0.56 nfet_01v8
M$13 9 6 5 14 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=274625000000P
+ PS=970000U PD=1495000U
* device instance $14 r0 *1 3.37,0.56 nfet_01v8
M$14 1 3 9 14 nfet_01v8 L=150000U W=650000U AS=274625000000P AD=87750000000P
+ PS=1495000U PD=920000U
* device instance $15 r0 *1 3.79,0.56 nfet_01v8
M$15 7 5 1 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__mux2_4

* cell sky130_fd_sc_hd__or2_4
* pin VPB
* pin A
* pin B
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or2_4 1 2 3 4 5 6 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 VGND
* net 5 VPWR
* net 6 X
* device instance $1 r0 *1 0.53,1.985 pfet_01v8_hvt
M$1 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=105000000000P PS=2560000U PD=1210000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 5 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=177500000000P PS=1210000U PD=1355000U
* device instance $3 r0 *1 1.395,1.985 pfet_01v8_hvt
M$3 6 7 5 1 pfet_01v8_hvt L=150000U W=4000000U AS=582500000000P
+ AD=685000000000P PS=5165000U PD=6370000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 7 3 4 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 0.89,0.56 nfet_01v8
M$8 4 2 7 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=115375000000P
+ PS=920000U PD=1005000U
* device instance $9 r0 *1 1.395,0.56 nfet_01v8
M$9 6 7 4 8 nfet_01v8 L=150000U W=2600000U AS=378625000000P AD=432250000000P
+ PS=3765000U PD=4580000U
.ENDS sky130_fd_sc_hd__or2_4

* cell sky130_fd_sc_hd__nand4b_1
* pin VPB
* pin A_N
* pin B
* pin C
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_1 1 2 3 4 6 7 8 9 10
* net 1 VPB
* net 2 A_N
* net 3 B
* net 4 C
* net 6 D
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=195000000000P PS=1385000U PD=1390000U
* device instance $5 r0 *1 2.58,1.985 pfet_01v8_hvt
M$5 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $6 r0 *1 0.545,0.675 nfet_01v8
M$6 5 2 9 10 nfet_01v8 L=150000U W=420000U AS=118125000000P AD=111300000000P
+ PS=1040000U PD=1370000U
* device instance $7 r0 *1 1.085,0.56 nfet_01v8
M$7 11 6 9 10 nfet_01v8 L=150000U W=650000U AS=118125000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.505,0.56 nfet_01v8
M$8 13 4 11 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $9 r0 *1 2.04,0.56 nfet_01v8
M$9 12 3 13 10 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=126750000000P
+ PS=1035000U PD=1040000U
* device instance $10 r0 *1 2.58,0.56 nfet_01v8
M$10 8 5 12 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=227500000000P
+ PS=1040000U PD=2000000U
.ENDS sky130_fd_sc_hd__nand4b_1

* cell sky130_fd_sc_hd__o221a_2
* pin VGND
* pin C1
* pin B1
* pin B2
* pin A2
* pin A1
* pin X
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o221a_2 1 2 5 7 8 9 10 11 12 15
* net 1 VGND
* net 2 C1
* net 5 B1
* net 7 B2
* net 8 A2
* net 9 A1
* net 10 X
* net 11 VPB
* net 12 VPWR
* device instance $1 r0 *1 0.63,1.985 pfet_01v8_hvt
M$1 12 2 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=325000000000P
+ AD=165000000000P PS=2650000U PD=1330000U
* device instance $2 r0 *1 1.11,1.985 pfet_01v8_hvt
M$2 13 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=112500000000P PS=1330000U PD=1225000U
* device instance $3 r0 *1 1.485,1.985 pfet_01v8_hvt
M$3 3 7 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=387500000000P PS=1225000U PD=1775000U
* device instance $4 r0 *1 2.41,1.985 pfet_01v8_hvt
M$4 14 8 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=387500000000P
+ AD=105000000000P PS=1775000U PD=1210000U
* device instance $5 r0 *1 2.77,1.985 pfet_01v8_hvt
M$5 12 9 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $6 r0 *1 3.25,1.985 pfet_01v8_hvt
M$6 10 3 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=395000000000P PS=2600000U PD=3790000U
* device instance $8 r0 *1 2.41,0.56 nfet_01v8
M$8 6 8 1 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $9 r0 *1 2.83,0.56 nfet_01v8
M$9 1 9 6 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 3.25,0.56 nfet_01v8
M$10 10 3 1 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $12 r0 *1 0.63,0.56 nfet_01v8
M$12 4 2 3 15 nfet_01v8 L=150000U W=650000U AS=237250000000P AD=87750000000P
+ PS=2030000U PD=920000U
* device instance $13 r0 *1 1.05,0.56 nfet_01v8
M$13 6 5 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $14 r0 *1 1.47,0.56 nfet_01v8
M$14 4 7 6 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221a_2

* cell sky130_fd_sc_hd__a31o_2
* pin VPB
* pin B1
* pin A1
* pin A2
* pin A3
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a31o_2 1 2 3 4 5 6 7 8 11
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 A3
* net 6 X
* net 7 VPWR
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 10 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 7 4 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $5 r0 *1 2.21,1.985 pfet_01v8_hvt
M$5 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $6 r0 *1 2.69,1.985 pfet_01v8_hvt
M$6 10 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=320000000000P PS=1330000U PD=2640000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 6 10 8 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $9 r0 *1 1.31,0.56 nfet_01v8
M$9 13 5 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 1.73,0.56 nfet_01v8
M$10 12 4 13 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $11 r0 *1 2.21,0.56 nfet_01v8
M$11 10 3 12 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=126750000000P
+ PS=980000U PD=1040000U
* device instance $12 r0 *1 2.75,0.56 nfet_01v8
M$12 8 2 10 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=169000000000P
+ PS=1040000U PD=1820000U
.ENDS sky130_fd_sc_hd__a31o_2

* cell sky130_fd_sc_hd__and4_1
* pin VPB
* pin D
* pin C
* pin B
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and4_1 1 3 4 5 6 7 8 9 10
* net 1 VPB
* net 3 D
* net 4 C
* net 5 B
* net 6 A
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 2 6 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=73500000000P
+ PS=1360000U PD=770000U
* device instance $2 r0 *1 0.97,2.275 pfet_01v8_hvt
M$2 8 5 2 1 pfet_01v8_hvt L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $3 r0 *1 1.49,2.275 pfet_01v8_hvt
M$3 2 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=77700000000P AD=58800000000P
+ PS=790000U PD=700000U
* device instance $4 r0 *1 1.92,2.275 pfet_01v8_hvt
M$4 2 3 8 1 pfet_01v8_hvt L=150000U W=420000U AS=312450000000P AD=58800000000P
+ PS=1680000U PD=700000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=312450000000P
+ AD=260000000000P PS=1680000U PD=2520000U
* device instance $6 r0 *1 0.47,0.445 nfet_01v8
M$6 13 6 2 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $7 r0 *1 0.91,0.445 nfet_01v8
M$7 11 5 13 10 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=79800000000P
+ PS=710000U PD=800000U
* device instance $8 r0 *1 1.44,0.445 nfet_01v8
M$8 12 4 11 10 nfet_01v8 L=150000U W=420000U AS=79800000000P AD=69300000000P
+ PS=800000U PD=750000U
* device instance $9 r0 *1 1.92,0.445 nfet_01v8
M$9 7 3 12 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=196275000000P
+ PS=750000U PD=1330000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 9 2 7 10 nfet_01v8 L=150000U W=650000U AS=196275000000P AD=169000000000P
+ PS=1330000U PD=1820000U
.ENDS sky130_fd_sc_hd__and4_1

* cell sky130_fd_sc_hd__nand2_4
* pin VGND
* pin B
* pin Y
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand2_4 1 3 4 5 6 7 8
* net 1 VGND
* net 3 B
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 6 7 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 4 5 6 7 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 1 3 2 8 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $13 r0 *1 2.15,0.56 nfet_01v8
M$13 4 5 2 8 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand2_4

* cell sky130_fd_sc_hd__nor2_2
* pin VGND
* pin
* pin Y
* pin VPB
* pin A
* pin B
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nor2_2 1 2 3 4 5 6 8
* net 1 VGND
* net 3 Y
* net 4 VPB
* net 5 A
* net 6 B
* net 8 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 8 5 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 1.33,1.985 pfet_01v8_hvt
M$3 3 6 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,0.56 nfet_01v8
M$5 3 5 1 2 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $7 r0 *1 1.33,0.56 nfet_01v8
M$7 3 6 1 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor2_2

* cell sky130_fd_sc_hd__a32o_1
* pin VGND
* pin X
* pin A2
* pin A1
* pin B1
* pin A3
* pin B2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a32o_1 1 2 3 4 5 7 8 13 14 15
* net 1 VGND
* net 2 X
* net 3 A2
* net 4 A1
* net 5 B1
* net 7 A3
* net 8 B2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.54,1.985 pfet_01v8_hvt
M$1 13 6 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=330000000000P
+ AD=242500000000P PS=2660000U PD=1485000U
* device instance $2 r0 *1 1.175,1.985 pfet_01v8_hvt
M$2 12 7 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=242500000000P
+ AD=165000000000P PS=1485000U PD=1330000U
* device instance $3 r0 *1 1.655,1.985 pfet_01v8_hvt
M$3 13 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=225000000000P PS=1330000U PD=1450000U
* device instance $4 r0 *1 2.255,1.985 pfet_01v8_hvt
M$4 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=185000000000P PS=1450000U PD=1370000U
* device instance $5 r0 *1 2.775,1.985 pfet_01v8_hvt
M$5 6 5 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=185000000000P
+ AD=140000000000P PS=1370000U PD=1280000U
* device instance $6 r0 *1 3.205,1.985 pfet_01v8_hvt
M$6 12 8 6 14 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $7 r0 *1 0.54,0.56 nfet_01v8
M$7 1 6 2 15 nfet_01v8 L=150000U W=650000U AS=214500000000P AD=167375000000P
+ PS=1960000U PD=1165000U
* device instance $8 r0 *1 1.205,0.56 nfet_01v8
M$8 9 7 1 15 nfet_01v8 L=150000U W=650000U AS=167375000000P AD=97500000000P
+ PS=1165000U PD=950000U
* device instance $9 r0 *1 1.655,0.56 nfet_01v8
M$9 11 3 9 15 nfet_01v8 L=150000U W=650000U AS=97500000000P AD=146250000000P
+ PS=950000U PD=1100000U
* device instance $10 r0 *1 2.255,0.56 nfet_01v8
M$10 6 4 11 15 nfet_01v8 L=150000U W=650000U AS=146250000000P AD=143000000000P
+ PS=1100000U PD=1090000U
* device instance $11 r0 *1 2.845,0.56 nfet_01v8
M$11 10 5 6 15 nfet_01v8 L=150000U W=650000U AS=143000000000P AD=68250000000P
+ PS=1090000U PD=860000U
* device instance $12 r0 *1 3.205,0.56 nfet_01v8
M$12 1 8 10 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=172250000000P
+ PS=860000U PD=1830000U
.ENDS sky130_fd_sc_hd__a32o_1

* cell sky130_fd_sc_hd__or3b_1
* pin VPB
* pin A
* pin B
* pin C_N
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3b_1 1 2 3 5 6 7 8 10
* net 1 VPB
* net 2 A
* net 3 B
* net 5 C_N
* net 6 X
* net 7 VPWR
* net 8 VGND
* device instance $1 r0 *1 1.41,1.695 pfet_01v8_hvt
M$1 11 4 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.77,1.695 pfet_01v8_hvt
M$2 12 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=68250000000P
+ PS=630000U PD=745000U
* device instance $3 r0 *1 2.245,1.695 pfet_01v8_hvt
M$3 7 2 12 1 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=148250000000P
+ PS=745000U PD=1340000U
* device instance $4 r0 *1 2.735,1.985 pfet_01v8_hvt
M$4 6 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=275000000000P PS=1340000U PD=2550000U
* device instance $5 r0 *1 0.47,1.695 pfet_01v8_hvt
M$5 4 5 7 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.41,0.475 nfet_01v8
M$6 8 4 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $7 r0 *1 1.83,0.475 nfet_01v8
M$7 9 3 8 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 2.25,0.475 nfet_01v8
M$8 9 2 8 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=56700000000P
+ PS=985000U PD=690000U
* device instance $9 r0 *1 2.735,0.56 nfet_01v8
M$9 6 9 8 10 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=178750000000P
+ PS=985000U PD=1850000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or3b_1

* cell sky130_fd_sc_hd__xnor2_4
* pin VGND
* pin B
* pin A
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_4 1 2 3 7 8 10 11
* net 1 VGND
* net 2 B
* net 3 A
* net 7 Y
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 4.435,1.985 pfet_01v8_hvt
M$1 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.115,1.985 pfet_01v8_hvt
M$5 7 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 8.335,1.985 pfet_01v8_hvt
M$9 8 5 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $13 r0 *1 0.545,1.985 pfet_01v8_hvt
M$13 8 2 5 10 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $17 r0 *1 2.225,1.985 pfet_01v8_hvt
M$17 8 3 5 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 8.335,0.56 nfet_01v8
M$21 7 5 6 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $25 r0 *1 4.435,0.56 nfet_01v8
M$25 6 3 1 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 6.115,0.56 nfet_01v8
M$29 6 2 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $33 r0 *1 0.545,0.56 nfet_01v8
M$33 5 2 4 11 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $37 r0 *1 2.225,0.56 nfet_01v8
M$37 1 3 4 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__xnor2_4

* cell sky130_fd_sc_hd__clkinv_4
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_4 1 2 3 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 Y
* net 5 VPWR
* device instance $1 r0 *1 0.515,1.985 pfet_01v8_hvt
M$1 4 2 5 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.005e+12P AD=1.045e+12P
+ PS=9010000U PD=9090000U
* device instance $7 r0 *1 0.945,0.445 nfet_01v8
M$7 4 2 3 6 nfet_01v8 L=150000U W=1680000U AS=315000000000P AD=342300000000P
+ PS=3600000U PD=3730000U
.ENDS sky130_fd_sc_hd__clkinv_4

* cell sky130_fd_sc_hd__bufinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__bufinv_16 1 5 6 7 8
* net 1 VGND
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 5 2 7 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 3 2 6 7 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=810000000000P PS=7620000U PD=7620000U
* device instance $10 r0 *1 4.25,1.985 pfet_01v8_hvt
M$10 4 3 6 7 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 5 2 8 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $29 r0 *1 1.73,0.56 nfet_01v8
M$29 3 2 1 8 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=526500000000P
+ PS=5520000U PD=5520000U
* device instance $35 r0 *1 4.25,0.56 nfet_01v8
M$35 4 3 1 8 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__bufinv_16

* cell sky130_fd_sc_hd__clkinv_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_2 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 4 2 3 1 pfet_01v8_hvt L=150000U W=3000000U AS=545000000000P
+ AD=545000000000P PS=5090000U PD=5090000U
* device instance $4 r0 *1 0.94,0.445 nfet_01v8
M$4 3 2 5 6 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=168000000000P
+ PS=2070000U PD=2060000U
.ENDS sky130_fd_sc_hd__clkinv_2

* cell sky130_fd_sc_hd__xnor3_2
* pin VGND
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xnor3_2 1 2 6 11 12 13 14 15
* net 1 VGND
* net 2 X
* net 6 C
* net 11 B
* net 12 A
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 5.915,1.805 pfet_01v8_hvt
M$1 10 9 8 14 pfet_01v8_hvt L=150000U W=640000U AS=243100000000P
+ AD=246000000000P PS=1445000U PD=1525000U
* device instance $2 r0 *1 6.79,1.965 pfet_01v8_hvt
M$2 3 11 10 14 pfet_01v8_hvt L=150000U W=640000U AS=246000000000P
+ AD=145800000000P PS=1525000U PD=1205000U
* device instance $3 r0 *1 5.16,1.905 pfet_01v8_hvt
M$3 8 11 4 14 pfet_01v8_hvt L=150000U W=840000U AS=352800000000P
+ AD=243100000000P PS=2520000U PD=1445000U
* device instance $4 r0 *1 7.305,2.065 pfet_01v8_hvt
M$4 3 9 4 14 pfet_01v8_hvt L=150000U W=840000U AS=171500000000P
+ AD=145800000000P PS=1355000U PD=1205000U
* device instance $5 r0 *1 7.81,1.985 pfet_01v8_hvt
M$5 13 12 4 14 pfet_01v8_hvt L=150000U W=1000000U AS=171500000000P
+ AD=135000000000P PS=1355000U PD=1270000U
* device instance $6 r0 *1 8.23,1.985 pfet_01v8_hvt
M$6 10 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=285000000000P PS=1270000U PD=2570000U
* device instance $7 r0 *1 3,1.905 pfet_01v8_hvt
M$7 8 7 5 14 pfet_01v8_hvt L=150000U W=840000U AS=152950000000P
+ AD=322350000000P PS=1315000U PD=2450000U
* device instance $8 r0 *1 2.515,2.045 pfet_01v8_hvt
M$8 3 6 5 14 pfet_01v8_hvt L=150000U W=840000U AS=152950000000P
+ AD=273000000000P PS=1315000U PD=2330000U
* device instance $9 r0 *1 1.465,1.805 pfet_01v8_hvt
M$9 7 6 13 14 pfet_01v8_hvt L=150000U W=640000U AS=169000000000P
+ AD=179200000000P PS=1365000U PD=1840000U
* device instance $10 r0 *1 0.53,1.985 pfet_01v8_hvt
M$10 2 5 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=455000000000P
+ AD=304000000000P PS=3910000U PD=2635000U
* device instance $12 r0 *1 4.06,1.985 pfet_01v8_hvt
M$12 9 11 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=256550000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $13 r0 *1 5.915,0.455 nfet_01v8
M$13 10 9 3 15 nfet_01v8 L=150000U W=420000U AS=182050000000P AD=192650000000P
+ PS=1245000U PD=1285000U
* device instance $14 r0 *1 7.31,0.535 nfet_01v8
M$14 4 9 8 15 nfet_01v8 L=150000U W=600000U AS=140825000000P AD=110000000000P
+ PS=1100000U PD=990000U
* device instance $15 r0 *1 7.81,0.555 nfet_01v8
M$15 1 12 4 15 nfet_01v8 L=150000U W=640000U AS=110000000000P AD=86400000000P
+ PS=990000U PD=910000U
* device instance $16 r0 *1 8.23,0.555 nfet_01v8
M$16 10 4 1 15 nfet_01v8 L=150000U W=640000U AS=86400000000P AD=182400000000P
+ PS=910000U PD=1850000U
* device instance $17 r0 *1 5.16,0.565 nfet_01v8
M$17 3 11 4 15 nfet_01v8 L=150000U W=640000U AS=162750000000P AD=182050000000P
+ PS=1800000U PD=1245000U
* device instance $18 r0 *1 6.71,0.565 nfet_01v8
M$18 10 11 8 15 nfet_01v8 L=150000U W=640000U AS=140825000000P AD=192650000000P
+ PS=1100000U PD=1285000U
* device instance $19 r0 *1 0.51,0.56 nfet_01v8
M$19 2 5 1 15 nfet_01v8 L=150000U W=1300000U AS=282750000000P AD=204250000000P
+ PS=2820000U PD=1955000U
* device instance $21 r0 *1 1.465,0.675 nfet_01v8
M$21 7 6 1 15 nfet_01v8 L=150000U W=420000U AS=116500000000P AD=178500000000P
+ PS=1035000U PD=1690000U
* device instance $22 r0 *1 4.23,0.56 nfet_01v8
M$22 9 11 1 15 nfet_01v8 L=150000U W=650000U AS=188500000000P AD=165150000000P
+ PS=1880000U PD=1820000U
* device instance $23 r0 *1 2.58,0.565 nfet_01v8
M$23 5 6 8 15 nfet_01v8 L=150000U W=640000U AS=172800000000P AD=92800000000P
+ PS=1820000U PD=930000U
* device instance $24 r0 *1 3.02,0.565 nfet_01v8
M$24 3 7 5 15 nfet_01v8 L=150000U W=640000U AS=92800000000P AD=224000000000P
+ PS=930000U PD=1980000U
.ENDS sky130_fd_sc_hd__xnor3_2

* cell sky130_fd_sc_hd__xor3_1
* pin VGND
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xor3_1 1 2 5 11 12 13 14 15
* net 1 VGND
* net 2 X
* net 5 C
* net 11 B
* net 12 A
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 1.255,1.805 pfet_01v8_hvt
M$1 6 5 13 14 pfet_01v8_hvt L=150000U W=640000U AS=211500000000P
+ AD=179200000000P PS=1450000U PD=1840000U
* device instance $2 r0 *1 0.655,1.985 pfet_01v8_hvt
M$2 13 4 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=211500000000P PS=2560000U PD=1450000U
* device instance $3 r0 *1 2.325,2.045 pfet_01v8_hvt
M$3 4 5 8 14 pfet_01v8_hvt L=150000U W=840000U AS=268800000000P
+ AD=159600000000P PS=2320000U PD=1220000U
* device instance $4 r0 *1 2.855,2.045 pfet_01v8_hvt
M$4 7 6 4 14 pfet_01v8_hvt L=150000U W=840000U AS=159600000000P
+ AD=441000000000P PS=1220000U PD=2730000U
* device instance $5 r0 *1 4.06,1.985 pfet_01v8_hvt
M$5 9 11 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=252600000000P PS=2520000U PD=2520000U
* device instance $6 r0 *1 5.915,1.805 pfet_01v8_hvt
M$6 10 9 8 14 pfet_01v8_hvt L=150000U W=640000U AS=245200000000P
+ AD=246000000000P PS=1450000U PD=1525000U
* device instance $7 r0 *1 6.79,1.965 pfet_01v8_hvt
M$7 7 11 10 14 pfet_01v8_hvt L=150000U W=640000U AS=246000000000P
+ AD=145800000000P PS=1525000U PD=1205000U
* device instance $8 r0 *1 5.155,1.905 pfet_01v8_hvt
M$8 8 11 3 14 pfet_01v8_hvt L=150000U W=840000U AS=353600000000P
+ AD=245200000000P PS=2530000U PD=1450000U
* device instance $9 r0 *1 7.305,2.065 pfet_01v8_hvt
M$9 7 9 3 14 pfet_01v8_hvt L=150000U W=840000U AS=171500000000P
+ AD=145800000000P PS=1355000U PD=1205000U
* device instance $10 r0 *1 7.81,1.985 pfet_01v8_hvt
M$10 13 12 3 14 pfet_01v8_hvt L=150000U W=1000000U AS=171500000000P
+ AD=135000000000P PS=1355000U PD=1270000U
* device instance $11 r0 *1 8.23,1.985 pfet_01v8_hvt
M$11 10 3 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=285000000000P PS=1270000U PD=2570000U
* device instance $12 r0 *1 5.915,0.455 nfet_01v8
M$12 10 9 7 15 nfet_01v8 L=150000U W=420000U AS=183650000000P AD=192650000000P
+ PS=1250000U PD=1285000U
* device instance $13 r0 *1 7.31,0.535 nfet_01v8
M$13 3 9 8 15 nfet_01v8 L=150000U W=600000U AS=140825000000P AD=110000000000P
+ PS=1100000U PD=990000U
* device instance $14 r0 *1 7.81,0.555 nfet_01v8
M$14 1 12 3 15 nfet_01v8 L=150000U W=640000U AS=110000000000P AD=86400000000P
+ PS=990000U PD=910000U
* device instance $15 r0 *1 8.23,0.555 nfet_01v8
M$15 10 3 1 15 nfet_01v8 L=150000U W=640000U AS=86400000000P AD=182400000000P
+ PS=910000U PD=1850000U
* device instance $16 r0 *1 5.155,0.565 nfet_01v8
M$16 7 11 3 15 nfet_01v8 L=150000U W=640000U AS=162800000000P AD=183650000000P
+ PS=1800000U PD=1250000U
* device instance $17 r0 *1 6.71,0.565 nfet_01v8
M$17 10 11 8 15 nfet_01v8 L=150000U W=640000U AS=140825000000P AD=192650000000P
+ PS=1100000U PD=1285000U
* device instance $18 r0 *1 4.225,0.56 nfet_01v8
M$18 9 11 1 15 nfet_01v8 L=150000U W=650000U AS=195000000000P AD=165300000000P
+ PS=1900000U PD=1820000U
* device instance $19 r0 *1 0.635,0.56 nfet_01v8
M$19 1 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=144125000000P
+ PS=1820000U PD=1120000U
* device instance $20 r0 *1 1.255,0.675 nfet_01v8
M$20 6 5 1 15 nfet_01v8 L=150000U W=420000U AS=144125000000P AD=176400000000P
+ PS=1120000U PD=1680000U
* device instance $21 r0 *1 2.365,0.565 nfet_01v8
M$21 4 5 7 15 nfet_01v8 L=150000U W=640000U AS=172800000000P AD=128000000000P
+ PS=1820000U PD=1040000U
* device instance $22 r0 *1 2.915,0.565 nfet_01v8
M$22 8 6 4 15 nfet_01v8 L=150000U W=640000U AS=128000000000P AD=316800000000P
+ PS=1040000U PD=2270000U
.ENDS sky130_fd_sc_hd__xor3_1

* cell sky130_fd_sc_hd__o32a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B2
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32a_1 1 2 5 6 7 8 9 10 11 15
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B2
* net 9 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=335000000000P
+ AD=135000000000P PS=2670000U PD=1270000U
* device instance $2 r0 *1 1.06,1.985 pfet_01v8_hvt
M$2 13 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.54,1.985 pfet_01v8_hvt
M$3 12 6 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=195000000000P PS=1330000U PD=1390000U
* device instance $4 r0 *1 2.08,1.985 pfet_01v8_hvt
M$4 4 7 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $5 r0 *1 2.62,1.985 pfet_01v8_hvt
M$5 14 8 4 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=205000000000P PS=1390000U PD=1410000U
* device instance $6 r0 *1 3.18,1.985 pfet_01v8_hvt
M$6 10 9 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=290000000000P PS=1410000U PD=2580000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 1 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 1.06,0.56 nfet_01v8
M$8 3 5 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 1.54,0.56 nfet_01v8
M$9 1 6 3 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=126750000000P
+ PS=980000U PD=1040000U
* device instance $10 r0 *1 2.08,0.56 nfet_01v8
M$10 3 7 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 2.62,0.56 nfet_01v8
M$11 4 8 3 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=133250000000P
+ PS=1040000U PD=1060000U
* device instance $12 r0 *1 3.18,0.56 nfet_01v8
M$12 3 9 4 15 nfet_01v8 L=150000U W=650000U AS=133250000000P AD=188500000000P
+ PS=1060000U PD=1880000U
.ENDS sky130_fd_sc_hd__o32a_1

* cell sky130_fd_sc_hd__a2111oi_1
* pin VGND
* pin Y
* pin A2
* pin D1
* pin C1
* pin B1
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_1 1 2 3 4 5 6 7 10 11 14
* net 1 VGND
* net 2 Y
* net 3 A2
* net 4 D1
* net 5 C1
* net 6 B1
* net 7 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.01,1.985 pfet_01v8_hvt
M$1 12 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=755000000000P
+ AD=172500000000P PS=3510000U PD=1345000U
* device instance $2 r0 *1 1.505,1.985 pfet_01v8_hvt
M$2 13 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=185000000000P PS=1345000U PD=1370000U
* device instance $3 r0 *1 2.025,1.985 pfet_01v8_hvt
M$3 9 6 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=185000000000P
+ AD=290000000000P PS=1370000U PD=1580000U
* device instance $4 r0 *1 2.755,1.985 pfet_01v8_hvt
M$4 10 7 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=137500000000P PS=1580000U PD=1275000U
* device instance $5 r0 *1 3.18,1.985 pfet_01v8_hvt
M$5 9 3 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=290000000000P PS=1275000U PD=2580000U
* device instance $6 r0 *1 0.97,0.56 nfet_01v8
M$6 2 4 1 14 nfet_01v8 L=150000U W=650000U AS=481000000000P AD=125125000000P
+ PS=2780000U PD=1035000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=120250000000P
+ PS=1035000U PD=1020000U
* device instance $8 r0 *1 2.025,0.56 nfet_01v8
M$8 2 6 1 14 nfet_01v8 L=150000U W=650000U AS=120250000000P AD=191750000000P
+ PS=1020000U PD=1240000U
* device instance $9 r0 *1 2.765,0.56 nfet_01v8
M$9 8 7 2 14 nfet_01v8 L=150000U W=650000U AS=191750000000P AD=84500000000P
+ PS=1240000U PD=910000U
* device instance $10 r0 *1 3.175,0.56 nfet_01v8
M$10 1 3 8 14 nfet_01v8 L=150000U W=650000U AS=84500000000P AD=191750000000P
+ PS=910000U PD=1890000U
.ENDS sky130_fd_sc_hd__a2111oi_1

* cell sky130_fd_sc_hd__inv_6
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__inv_6 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 3 2 4 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.105e+12P AD=945000000000P
+ PS=9210000U PD=8890000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 3 2 5 6 nfet_01v8 L=150000U W=3900000U AS=685750000000P AD=614250000000P
+ PS=6660000U PD=6440000U
.ENDS sky130_fd_sc_hd__inv_6

* cell sky130_fd_sc_hd__o41a_1
* pin VGND
* pin X
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o41a_1 1 2 5 6 7 8 9 10 11 15
* net 1 VGND
* net 2 X
* net 5 B1
* net 6 A4
* net 7 A3
* net 8 A2
* net 9 A1
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 0.8,1.985 pfet_01v8_hvt
M$1 11 3 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=425000000000P
+ AD=135000000000P PS=2850000U PD=1270000U
* device instance $2 r0 *1 1.22,1.985 pfet_01v8_hvt
M$2 3 5 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=1520000U
* device instance $3 r0 *1 1.89,1.985 pfet_01v8_hvt
M$3 12 6 3 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=220000000000P PS=1520000U PD=1440000U
* device instance $4 r0 *1 2.48,1.985 pfet_01v8_hvt
M$4 13 7 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=220000000000P
+ AD=195000000000P PS=1440000U PD=1390000U
* device instance $5 r0 *1 3.02,1.985 pfet_01v8_hvt
M$5 14 8 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $6 r0 *1 3.56,1.985 pfet_01v8_hvt
M$6 11 9 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $7 r0 *1 1.53,0.56 nfet_01v8
M$7 4 5 3 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 1.95,0.56 nfet_01v8
M$8 1 6 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $9 r0 *1 2.48,0.56 nfet_01v8
M$9 4 7 1 15 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=126750000000P
+ PS=1030000U PD=1040000U
* device instance $10 r0 *1 3.02,0.56 nfet_01v8
M$10 1 8 4 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 3.56,0.56 nfet_01v8
M$11 4 9 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=195000000000P
+ PS=1040000U PD=1900000U
* device instance $12 r0 *1 0.59,0.56 nfet_01v8
M$12 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=247000000000P AD=169000000000P
+ PS=2060000U PD=1820000U
.ENDS sky130_fd_sc_hd__o41a_1

* cell sky130_fd_sc_hd__a211oi_2
* pin VGND
* pin Y
* pin C1
* pin B1
* pin A1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_2 1 2 4 5 6 7 10 11 12
* net 1 VGND
* net 2 Y
* net 4 C1
* net 5 B1
* net 6 A1
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.765,1.985 pfet_01v8_hvt
M$1 9 6 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 3.625,1.985 pfet_01v8_hvt
M$3 9 7 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $5 r0 *1 0.525,1.985 pfet_01v8_hvt
M$5 2 4 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $7 r0 *1 1.385,1.985 pfet_01v8_hvt
M$7 9 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $9 r0 *1 2.765,0.56 nfet_01v8
M$9 2 6 3 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $11 r0 *1 3.625,0.56 nfet_01v8
M$11 1 7 3 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
* device instance $13 r0 *1 0.525,0.56 nfet_01v8
M$13 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $15 r0 *1 1.385,0.56 nfet_01v8
M$15 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__a211oi_2

* cell sky130_fd_sc_hd__o211a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211a_1 1 2 5 6 7 8 10 11 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 B1
* net 8 C1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 12 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=162500000000P PS=2520000U PD=1325000U
* device instance $2 r0 *1 1.885,1.985 pfet_01v8_hvt
M$2 4 6 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=220000000000P PS=1325000U PD=1440000U
* device instance $3 r0 *1 2.475,1.985 pfet_01v8_hvt
M$3 10 7 4 11 pfet_01v8_hvt L=150000U W=1000000U AS=220000000000P
+ AD=175000000000P PS=1440000U PD=1350000U
* device instance $4 r0 *1 2.975,1.985 pfet_01v8_hvt
M$4 4 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=300000000000P PS=1350000U PD=2600000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 1.885,0.56 nfet_01v8
M$7 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=143000000000P
+ PS=975000U PD=1090000U
* device instance $8 r0 *1 2.475,0.56 nfet_01v8
M$8 9 7 3 13 nfet_01v8 L=150000U W=650000U AS=143000000000P AD=113750000000P
+ PS=1090000U PD=1000000U
* device instance $9 r0 *1 2.975,0.56 nfet_01v8
M$9 4 8 9 13 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=195000000000P
+ PS=1000000U PD=1900000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o211a_1

* cell sky130_fd_sc_hd__clkbuf_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_2 1 2 3 4 7
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 6 X
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=162500000000P PS=2530000U PD=1325000U
* device instance $2 r0 *1 0.95,1.985 pfet_01v8_hvt
M$2 6 5 3 1 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=395000000000P PS=2595000U PD=3790000U
* device instance $4 r0 *1 0.475,0.445 nfet_01v8
M$4 4 2 5 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=68250000000P
+ PS=1370000U PD=745000U
* device instance $5 r0 *1 0.95,0.445 nfet_01v8
M$5 6 5 4 7 nfet_01v8 L=150000U W=840000U AS=124950000000P AD=165900000000P
+ PS=1435000U PD=2050000U
.ENDS sky130_fd_sc_hd__clkbuf_2

* cell sky130_fd_sc_hd__o21bai_1
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21bai_1 1 2 4 5 7 8 9 10
* net 1 VPB
* net 2 B1_N
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 VGND
* net 9 Y
* device instance $1 r0 *1 0.86,1.97 pfet_01v8_hvt
M$1 3 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=178250000000P AD=109200000000P
+ PS=1400000U PD=1360000U
* device instance $2 r0 *1 1.41,1.985 pfet_01v8_hvt
M$2 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=178250000000P
+ AD=152500000000P PS=1400000U PD=1305000U
* device instance $3 r0 *1 1.865,1.985 pfet_01v8_hvt
M$3 11 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=127500000000P PS=1305000U PD=1255000U
* device instance $4 r0 *1 2.27,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=127500000000P
+ AD=280000000000P PS=1255000U PD=2560000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 5 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.675 nfet_01v8
M$8 3 2 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__o21bai_1

* cell sky130_fd_sc_hd__a21bo_2
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21bo_2 1 2 3 4 6 7 8 11
* net 1 VPB
* net 2 B1_N
* net 3 A1
* net 4 A2
* net 6 VPWR
* net 7 VGND
* net 8 X
* device instance $1 r0 *1 2.35,1.985 pfet_01v8_hvt
M$1 5 9 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.77,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 3.19,1.985 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 1.41,1.695 pfet_01v8_hvt
M$4 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=181500000000P AD=109200000000P
+ PS=1510000U PD=1360000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 10 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=400000000000P
+ AD=321500000000P PS=3800000U PD=2790000U
* device instance $7 r0 *1 2.35,0.56 nfet_01v8
M$7 10 9 7 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $8 r0 *1 2.83,0.56 nfet_01v8
M$8 12 3 10 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=68250000000P
+ PS=980000U PD=860000U
* device instance $9 r0 *1 3.19,0.56 nfet_01v8
M$9 7 4 12 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 8 10 7 11 nfet_01v8 L=150000U W=1300000U AS=260000000000P AD=199375000000P
+ PS=2750000U PD=1940000U
* device instance $12 r0 *1 1.41,0.675 nfet_01v8
M$12 9 2 7 11 nfet_01v8 L=150000U W=420000U AS=108375000000P AD=109200000000P
+ PS=1010000U PD=1360000U
.ENDS sky130_fd_sc_hd__a21bo_2

* cell sky130_fd_sc_hd__mux2i_2
* pin VGND
* pin S
* pin A0
* pin A1
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_2 1 2 6 7 8 11 12 13
* net 1 VGND
* net 2 S
* net 6 A0
* net 7 A1
* net 8 VPWR
* net 11 Y
* net 12 VPB
* device instance $1 r0 *1 3.09,1.985 pfet_01v8_hvt
M$1 9 6 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=290000000000P PS=3790000U PD=2580000U
* device instance $3 r0 *1 3.97,1.985 pfet_01v8_hvt
M$3 10 7 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=292500000000P
+ AD=592500000000P PS=2585000U PD=4185000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $6 r0 *1 0.89,1.985 pfet_01v8_hvt
M$6 9 2 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $8 r0 *1 1.73,1.985 pfet_01v8_hvt
M$8 10 3 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $10 r0 *1 3.09,0.56 nfet_01v8
M$10 5 6 11 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=188500000000P
+ PS=2740000U PD=1880000U
* device instance $12 r0 *1 3.97,0.56 nfet_01v8
M$12 4 7 11 13 nfet_01v8 L=150000U W=1300000U AS=190125000000P AD=385125000000P
+ PS=1885000U PD=3135000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 2 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $15 r0 *1 0.89,0.56 nfet_01v8
M$15 4 2 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 1.73,0.56 nfet_01v8
M$17 5 3 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__mux2i_2

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__dfxtp_4
* pin VGND
* pin Q
* pin CLK
* pin D
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__dfxtp_4 1 9 12 13 14 15 18
* net 1 VGND
* net 9 Q
* net 12 CLK
* net 13 D
* net 14 VPB
* net 15 VPWR
* device instance $1 r0 *1 6.465,1.985 pfet_01v8_hvt
M$1 15 7 8 14 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=162500000000P PS=2560000U PD=1325000U
* device instance $2 r0 *1 6.94,1.985 pfet_01v8_hvt
M$2 9 8 15 14 pfet_01v8_hvt L=150000U W=4000000U AS=575000000000P
+ AD=692500000000P PS=5150000U PD=6385000U
* device instance $6 r0 *1 0.47,2.135 pfet_01v8_hvt
M$6 15 12 2 14 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $7 r0 *1 0.89,2.135 pfet_01v8_hvt
M$7 3 2 15 14 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $8 r0 *1 1.83,2.275 pfet_01v8_hvt
M$8 4 13 15 14 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=67200000000P PS=1360000U PD=740000U
* device instance $9 r0 *1 2.3,2.275 pfet_01v8_hvt
M$9 5 3 4 14 pfet_01v8_hvt L=150000U W=420000U AS=67200000000P AD=66150000000P
+ PS=740000U PD=735000U
* device instance $10 r0 *1 2.765,2.275 pfet_01v8_hvt
M$10 16 2 5 14 pfet_01v8_hvt L=150000U W=420000U AS=66150000000P
+ AD=69300000000P PS=735000U PD=750000U
* device instance $11 r0 *1 3.245,2.275 pfet_01v8_hvt
M$11 16 6 15 14 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=69300000000P PS=1260000U PD=750000U
* device instance $12 r0 *1 3.905,2.11 pfet_01v8_hvt
M$12 6 5 15 14 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=109500000000P PS=1260000U PD=1075000U
* device instance $13 r0 *1 4.38,2.275 pfet_01v8_hvt
M$13 7 2 6 14 pfet_01v8_hvt L=150000U W=420000U AS=109500000000P
+ AD=56700000000P PS=1075000U PD=690000U
* device instance $14 r0 *1 4.8,2.275 pfet_01v8_hvt
M$14 17 3 7 14 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=91350000000P PS=690000U PD=855000U
* device instance $15 r0 *1 5.385,2.275 pfet_01v8_hvt
M$15 15 8 17 14 pfet_01v8_hvt L=150000U W=420000U AS=91350000000P
+ AD=121800000000P PS=855000U PD=1420000U
* device instance $16 r0 *1 6.465,0.56 nfet_01v8
M$16 1 7 8 18 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $17 r0 *1 6.94,0.56 nfet_01v8
M$17 9 8 1 18 nfet_01v8 L=150000U W=2600000U AS=373750000000P AD=453375000000P
+ PS=3750000U PD=4645000U
* device instance $21 r0 *1 0.47,0.445 nfet_01v8
M$21 1 12 2 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $22 r0 *1 0.89,0.445 nfet_01v8
M$22 3 2 1 18 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $23 r0 *1 2.305,0.415 nfet_01v8
M$23 5 2 4 18 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $24 r0 *1 2.785,0.415 nfet_01v8
M$24 11 3 5 18 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=68700000000P
+ PS=690000U PD=760000U
* device instance $25 r0 *1 4.51,0.415 nfet_01v8
M$25 7 3 6 18 nfet_01v8 L=150000U W=360000U AS=98900000000P AD=65700000000P
+ PS=995000U PD=725000U
* device instance $26 r0 *1 5.025,0.415 nfet_01v8
M$26 10 2 7 18 nfet_01v8 L=150000U W=360000U AS=65700000000P AD=66000000000P
+ PS=725000U PD=745000U
* device instance $27 r0 *1 1.83,0.445 nfet_01v8
M$27 4 13 1 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=66000000000P
+ PS=1360000U PD=745000U
* device instance $28 r0 *1 3.275,0.445 nfet_01v8
M$28 1 6 11 18 nfet_01v8 L=150000U W=420000U AS=68700000000P AD=149300000000P
+ PS=760000U PD=1220000U
* device instance $29 r0 *1 5.5,0.445 nfet_01v8
M$29 1 8 10 18 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=119700000000P
+ PS=745000U PD=1410000U
* device instance $30 r0 *1 4.005,0.555 nfet_01v8
M$30 6 5 1 18 nfet_01v8 L=150000U W=640000U AS=149300000000P AD=98900000000P
+ PS=1220000U PD=995000U
.ENDS sky130_fd_sc_hd__dfxtp_4

* cell sky130_fd_sc_hd__a21oi_2
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_2 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=275000000000P PS=3830000U PD=2550000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 6 2 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=275000000000P PS=2560000U PD=2550000U
* device instance $5 r0 *1 2.19,1.985 pfet_01v8_hvt
M$5 7 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=495000000000P PS=2540000U PD=3990000U
* device instance $7 r0 *1 0.495,0.56 nfet_01v8
M$7 10 4 8 9 nfet_01v8 L=150000U W=650000U AS=185250000000P AD=89375000000P
+ PS=1870000U PD=925000U
* device instance $8 r0 *1 0.92,0.56 nfet_01v8
M$8 7 2 10 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $9 r0 *1 1.35,0.56 nfet_01v8
M$9 11 2 7 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=68250000000P
+ PS=930000U PD=860000U
* device instance $10 r0 *1 1.71,0.56 nfet_01v8
M$10 8 4 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=107250000000P
+ PS=860000U PD=980000U
* device instance $11 r0 *1 2.19,0.56 nfet_01v8
M$11 7 3 8 9 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=347750000000P
+ PS=1900000U PD=3020000U
.ENDS sky130_fd_sc_hd__a21oi_2

* cell sky130_fd_sc_hd__inv_4
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__inv_4 1 2 3 4 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 VPWR
* net 5 Y
* device instance $1 r0 *1 0.52,1.985 pfet_01v8_hvt
M$1 5 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=665000000000P PS=6330000U PD=6330000U
* device instance $5 r0 *1 0.52,0.56 nfet_01v8
M$5 5 2 3 6 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=432250000000P
+ PS=4580000U PD=4580000U
.ENDS sky130_fd_sc_hd__inv_4

* cell sky130_fd_sc_hd__and3b_1
* pin VPB
* pin C
* pin B
* pin A_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__and3b_1 1 2 3 5 7 8 9 10
* net 1 VPB
* net 2 C
* net 3 B
* net 5 A_N
* net 7 X
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 2.275,1.695 pfet_01v8_hvt
M$1 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=142225000000P
+ PS=815000U PD=1335000U
* device instance $2 r0 *1 1.38,1.765 pfet_01v8_hvt
M$2 9 4 6 1 pfet_01v8_hvt L=150000U W=420000U AS=108500000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 1.8,1.765 pfet_01v8_hvt
M$3 9 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 2.75,1.985 pfet_01v8_hvt
M$4 7 6 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,2.275 pfet_01v8_hvt
M$5 4 5 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=108700000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.405,0.475 nfet_01v8
M$6 12 4 6 10 nfet_01v8 L=150000U W=420000U AS=107825000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 1.765,0.475 nfet_01v8
M$7 11 3 12 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 2.17,0.475 nfet_01v8
M$8 11 2 8 10 nfet_01v8 L=150000U W=420000U AS=122275000000P AD=53550000000P
+ PS=1080000U PD=675000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 6 8 10 nfet_01v8 L=150000U W=650000U AS=122275000000P AD=169000000000P
+ PS=1080000U PD=1820000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=107850000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and3b_1

* cell sky130_fd_sc_hd__o2bb2ai_1
* pin VPB
* pin A1_N
* pin A2_N
* pin B2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2bb2ai_1 1 2 3 4 5 6 8 10 11
* net 1 VPB
* net 2 A1_N
* net 3 A2_N
* net 4 B2
* net 5 B1
* net 6 VPWR
* net 8 Y
* net 10 VGND
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=275000000000P
+ AD=135000000000P PS=2550000U PD=1270000U
* device instance $2 r0 *1 0.905,1.985 pfet_01v8_hvt
M$2 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=420000000000P PS=1270000U PD=1840000U
* device instance $3 r0 *1 1.895,1.985 pfet_01v8_hvt
M$3 8 7 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=420000000000P
+ AD=135000000000P PS=1840000U PD=1270000U
* device instance $4 r0 *1 2.315,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 6 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=275000000000P PS=1270000U PD=2550000U
* device instance $6 r0 *1 1.895,0.56 nfet_01v8
M$6 9 7 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.315,0.56 nfet_01v8
M$7 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 2.735,0.56 nfet_01v8
M$8 9 5 10 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.485,0.56 nfet_01v8
M$9 13 2 10 11 nfet_01v8 L=150000U W=650000U AS=178750000000P AD=68250000000P
+ PS=1850000U PD=860000U
* device instance $10 r0 *1 0.845,0.56 nfet_01v8
M$10 7 3 13 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=240500000000P
+ PS=860000U PD=2040000U
.ENDS sky130_fd_sc_hd__o2bb2ai_1

* cell sky130_fd_sc_hd__o41ai_1
* pin VGND
* pin Y
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o41ai_1 1 2 4 5 6 7 8 9 10 14
* net 1 VGND
* net 2 Y
* net 4 B1
* net 5 A4
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=312500000000P PS=1270000U PD=1625000U
* device instance $3 r0 *1 1.665,1.985 pfet_01v8_hvt
M$3 13 6 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=312500000000P
+ AD=135000000000P PS=1625000U PD=1270000U
* device instance $4 r0 *1 2.085,1.985 pfet_01v8_hvt
M$4 12 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=175000000000P PS=1270000U PD=1350000U
* device instance $5 r0 *1 2.585,1.985 pfet_01v8_hvt
M$5 9 8 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=280000000000P PS=1350000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 3 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=203125000000P
+ PS=1820000U PD=1275000U
* device instance $7 r0 *1 1.245,0.56 nfet_01v8
M$7 1 5 3 14 nfet_01v8 L=150000U W=650000U AS=203125000000P AD=87750000000P
+ PS=1275000U PD=920000U
* device instance $8 r0 *1 1.665,0.56 nfet_01v8
M$8 3 6 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 2.085,0.56 nfet_01v8
M$9 1 7 3 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $10 r0 *1 2.585,0.56 nfet_01v8
M$10 3 8 1 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=182000000000P
+ PS=1000000U PD=1860000U
.ENDS sky130_fd_sc_hd__o41ai_1

* cell sky130_fd_sc_hd__inv_8
* pin VGND
* pin A
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__inv_8 1 2 3 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.635,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=8000000U AS=1.205e+12P AD=1.205e+12P
+ PS=11410000U PD=11410000U
* device instance $9 r0 *1 0.635,0.56 nfet_01v8
M$9 3 2 1 6 nfet_01v8 L=150000U W=5200000U AS=783250000000P AD=783250000000P
+ PS=8260000U PD=8260000U
.ENDS sky130_fd_sc_hd__inv_8

* cell sky130_fd_sc_hd__nor4b_1
* pin VPB
* pin C
* pin B
* pin A
* pin D_N
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_1 1 2 3 4 5 6 7 8 10
* net 1 VPB
* net 2 C
* net 3 B
* net 4 A
* net 5 D_N
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 2.535,1.89 pfet_01v8_hvt
M$1 9 5 8 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 13 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=520000000000P
+ AD=135000000000P PS=3040000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 12 2 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.63,1.985 pfet_01v8_hvt
M$4 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=135000000000P PS=1330000U PD=1270000U
* device instance $5 r0 *1 2.05,1.985 pfet_01v8_hvt
M$5 8 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $6 r0 *1 0.73,0.56 nfet_01v8
M$6 7 9 6 10 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $7 r0 *1 1.15,0.56 nfet_01v8
M$7 6 2 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.63,0.56 nfet_01v8
M$8 7 3 6 10 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $9 r0 *1 2.05,0.56 nfet_01v8
M$9 6 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $10 r0 *1 2.535,0.675 nfet_01v8
M$10 9 5 6 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor4b_1

* cell sky130_fd_sc_hd__and2_2
* pin VPB
* pin A
* pin B
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_2 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 VPWR
* net 6 X
* net 7 VGND
* device instance $1 r0 *1 0.66,2.065 pfet_01v8_hvt
M$1 4 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $2 r0 *1 1.08,2.065 pfet_01v8_hvt
M$2 4 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=166550000000P AD=56700000000P
+ PS=1390000U PD=690000U
* device instance $3 r0 *1 1.62,1.985 pfet_01v8_hvt
M$3 6 4 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=361550000000P
+ AD=575000000000P PS=2780000U PD=4150000U
* device instance $5 r0 *1 0.66,0.585 nfet_01v8
M$5 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $6 r0 *1 1.08,0.585 nfet_01v8
M$6 9 3 7 8 nfet_01v8 L=150000U W=420000U AS=111800000000P AD=56700000000P
+ PS=1040000U PD=690000U
* device instance $7 r0 *1 1.62,0.56 nfet_01v8
M$7 6 4 7 8 nfet_01v8 L=150000U W=1300000U AS=238550000000P AD=373750000000P
+ PS=2080000U PD=3100000U
.ENDS sky130_fd_sc_hd__and2_2

* cell sky130_fd_sc_hd__nor4_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_2 1 2 3 4 5 6 8 11 12
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 5 C
* net 6 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.57,1.985 pfet_01v8_hvt
M$3 2 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 8 3 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 9 4 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.57,0.56 nfet_01v8
M$11 2 6 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 2 3 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $15 r0 *1 1.33,0.56 nfet_01v8
M$15 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nor4_2

* cell sky130_fd_sc_hd__a222oi_1
* pin VGND
* pin Y
* pin C1
* pin C2
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a222oi_1 1 2 3 4 5 6 7 8 14 15 16
* net 1 VGND
* net 2 Y
* net 3 C1
* net 4 C2
* net 5 B2
* net 6 B1
* net 7 A1
* net 8 A2
* net 14 VPWR
* net 15 VPB
* device instance $1 r0 *1 1.89,1.985 pfet_01v8_hvt
M$1 12 5 13 15 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.31,1.985 pfet_01v8_hvt
M$2 13 6 12 15 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.73,1.985 pfet_01v8_hvt
M$3 14 7 13 15 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 3.21,1.985 pfet_01v8_hvt
M$4 13 8 14 15 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 12 3 2 15 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $6 r0 *1 0.89,1.985 pfet_01v8_hvt
M$6 2 4 12 15 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $7 r0 *1 0.47,0.555 nfet_01v8
M$7 9 3 2 16 nfet_01v8 L=150000U W=640000U AS=166400000000P AD=67200000000P
+ PS=1800000U PD=850000U
* device instance $8 r0 *1 0.83,0.555 nfet_01v8
M$8 1 4 9 16 nfet_01v8 L=150000U W=640000U AS=67200000000P AD=291200000000P
+ PS=850000U PD=1550000U
* device instance $9 r0 *1 1.89,0.555 nfet_01v8
M$9 11 5 1 16 nfet_01v8 L=150000U W=640000U AS=291200000000P AD=67200000000P
+ PS=1550000U PD=850000U
* device instance $10 r0 *1 2.25,0.555 nfet_01v8
M$10 2 6 11 16 nfet_01v8 L=150000U W=640000U AS=67200000000P AD=105600000000P
+ PS=850000U PD=970000U
* device instance $11 r0 *1 2.73,0.555 nfet_01v8
M$11 10 7 2 16 nfet_01v8 L=150000U W=640000U AS=105600000000P AD=105600000000P
+ PS=970000U PD=970000U
* device instance $12 r0 *1 3.21,0.555 nfet_01v8
M$12 1 8 10 16 nfet_01v8 L=150000U W=640000U AS=105600000000P AD=166400000000P
+ PS=970000U PD=1800000U
.ENDS sky130_fd_sc_hd__a222oi_1

* cell sky130_fd_sc_hd__o22a_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22a_1 1 2 3 4 5 6 7 10 11
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 6 X
* net 7 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=372500000000P PS=2560000U PD=1745000U
* device instance $2 r0 *1 1.385,1.985 pfet_01v8_hvt
M$2 13 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=372500000000P
+ AD=117500000000P PS=1745000U PD=1235000U
* device instance $3 r0 *1 1.77,1.985 pfet_01v8_hvt
M$3 8 3 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=117500000000P
+ AD=235000000000P PS=1235000U PD=1470000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=235000000000P
+ AD=105000000000P PS=1470000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 8 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.83,0.56 nfet_01v8
M$7 9 3 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 7 4 9 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=87750000000P
+ PS=1000000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 9 5 7 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 7 8 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22a_1

* cell sky130_fd_sc_hd__nor3b_1
* pin VPB
* pin B
* pin A
* pin C_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 C_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 2.055,1.86 pfet_01v8_hvt
M$1 8 4 7 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 11 8 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=320000000000P
+ AD=135000000000P PS=2640000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 10 2 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.57,1.985 pfet_01v8_hvt
M$4 7 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $5 r0 *1 0.73,0.56 nfet_01v8
M$5 6 8 5 9 nfet_01v8 L=150000U W=650000U AS=221000000000P AD=87750000000P
+ PS=1980000U PD=920000U
* device instance $6 r0 *1 1.15,0.56 nfet_01v8
M$6 5 2 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.57,0.56 nfet_01v8
M$7 6 3 5 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $8 r0 *1 2.055,0.675 nfet_01v8
M$8 8 4 6 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor3b_1

* cell sky130_fd_sc_hd__a41oi_1
* pin VGND
* pin Y
* pin A3
* pin A2
* pin B1
* pin A4
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_1 1 2 3 4 8 9 10 11 12 14
* net 1 VGND
* net 2 Y
* net 3 A3
* net 4 A2
* net 8 B1
* net 9 A4
* net 10 A1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 13 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=212500000000P PS=2520000U PD=1425000U
* device instance $2 r0 *1 1.045,1.985 pfet_01v8_hvt
M$2 11 9 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=205000000000P PS=1425000U PD=1410000U
* device instance $3 r0 *1 1.605,1.985 pfet_01v8_hvt
M$3 13 3 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=155000000000P PS=1410000U PD=1310000U
* device instance $4 r0 *1 2.065,1.985 pfet_01v8_hvt
M$4 11 4 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=212500000000P PS=1310000U PD=1425000U
* device instance $5 r0 *1 2.64,1.985 pfet_01v8_hvt
M$5 13 10 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=370000000000P PS=1425000U PD=2740000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 8 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=169000000000P
+ PS=1175000U PD=1820000U
* device instance $7 r0 *1 1.105,0.56 nfet_01v8
M$7 5 9 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=113750000000P
+ PS=1175000U PD=1000000U
* device instance $8 r0 *1 1.605,0.56 nfet_01v8
M$8 7 3 5 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $9 r0 *1 2.065,0.56 nfet_01v8
M$9 6 4 7 14 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=138125000000P
+ PS=960000U PD=1075000U
* device instance $10 r0 *1 2.64,0.56 nfet_01v8
M$10 2 10 6 14 nfet_01v8 L=150000U W=650000U AS=138125000000P AD=240500000000P
+ PS=1075000U PD=2040000U
.ENDS sky130_fd_sc_hd__a41oi_1

* cell sky130_fd_sc_hd__a2bb2oi_1
* pin VGND
* pin Y
* pin B2
* pin A1_N
* pin A2_N
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2bb2oi_1 1 3 4 5 6 7 10 11 13
* net 1 VGND
* net 3 Y
* net 4 B2
* net 5 A1_N
* net 6 A2_N
* net 7 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.91,1.985 pfet_01v8_hvt
M$1 9 2 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=340000000000P
+ AD=135000000000P PS=2680000U PD=1270000U
* device instance $2 r0 *1 2.33,1.985 pfet_01v8_hvt
M$2 10 4 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 12 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $5 r0 *1 0.83,1.985 pfet_01v8_hvt
M$5 2 6 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 5 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 1 6 2 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=282750000000P
+ PS=920000U PD=1520000U
* device instance $8 r0 *1 1.91,0.56 nfet_01v8
M$8 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=282750000000P AD=87750000000P
+ PS=1520000U PD=920000U
* device instance $9 r0 *1 2.33,0.56 nfet_01v8
M$9 8 4 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 1 7 8 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__a2bb2oi_1

* cell sky130_fd_sc_hd__a22o_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a22o_1 1 2 3 4 5 6 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 VGND
* net 9 X
* net 10 VPWR
* device instance $1 r0 *1 1.82,1.985 pfet_01v8_hvt
M$1 7 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=252900000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $2 r0 *1 2.29,1.985 pfet_01v8_hvt
M$2 10 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=155000000000P PS=1320000U PD=1310000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 8 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=252850000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 1.79,0.56 nfet_01v8
M$6 12 4 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=113750000000P
+ PS=1820000U PD=1000000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 5 12 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $8 r0 *1 2.75,0.56 nfet_01v8
M$8 9 8 6 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=169000000000P
+ PS=960000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 13 2 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $10 r0 *1 0.85,0.56 nfet_01v8
M$10 8 3 13 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22o_1

* cell sky130_fd_sc_hd__a211o_1
* pin VPB
* pin B1
* pin C1
* pin A1
* pin A2
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a211o_1 1 2 3 4 5 7 8 9 11
* net 1 VPB
* net 2 B1
* net 3 C1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 X
* net 9 VGND
* device instance $1 r0 *1 1.425,1.985 pfet_01v8_hvt
M$1 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.855,1.985 pfet_01v8_hvt
M$2 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 2.285,1.985 pfet_01v8_hvt
M$3 12 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 2.745,1.985 pfet_01v8_hvt
M$4 6 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.475,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=265000000000P PS=2530000U PD=2530000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 9 6 8 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=260000000000P
+ PS=1830000U PD=1450000U
* device instance $7 r0 *1 1.425,0.56 nfet_01v8
M$7 13 5 9 11 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=91000000000P
+ PS=1450000U PD=930000U
* device instance $8 r0 *1 1.855,0.56 nfet_01v8
M$8 6 4 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $9 r0 *1 2.285,0.56 nfet_01v8
M$9 9 2 6 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $10 r0 *1 2.745,0.56 nfet_01v8
M$10 6 3 9 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211o_1

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__dfxtp_2
* pin VGND
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfxtp_2 1 9 12 13 14 15 18
* net 1 VGND
* net 9 Q
* net 12 CLK
* net 13 D
* net 14 VPWR
* net 15 VPB
* device instance $1 r0 *1 6.42,1.985 pfet_01v8_hvt
M$1 14 7 8 15 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=135000000000P PS=2540000U PD=1270000U
* device instance $2 r0 *1 6.84,1.985 pfet_01v8_hvt
M$2 9 8 14 15 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $4 r0 *1 1.83,2.275 pfet_01v8_hvt
M$4 4 13 14 15 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=57750000000P PS=1360000U PD=695000U
* device instance $5 r0 *1 2.255,2.275 pfet_01v8_hvt
M$5 5 3 4 15 pfet_01v8_hvt L=150000U W=420000U AS=57750000000P AD=68250000000P
+ PS=695000U PD=745000U
* device instance $6 r0 *1 2.73,2.275 pfet_01v8_hvt
M$6 16 2 5 15 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=76650000000P
+ PS=745000U PD=785000U
* device instance $7 r0 *1 3.245,2.275 pfet_01v8_hvt
M$7 16 6 14 15 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=76650000000P PS=1260000U PD=785000U
* device instance $8 r0 *1 3.905,2.11 pfet_01v8_hvt
M$8 6 5 14 15 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=109500000000P PS=1260000U PD=1075000U
* device instance $9 r0 *1 4.38,2.275 pfet_01v8_hvt
M$9 7 2 6 15 pfet_01v8_hvt L=150000U W=420000U AS=109500000000P AD=56700000000P
+ PS=1075000U PD=690000U
* device instance $10 r0 *1 4.8,2.275 pfet_01v8_hvt
M$10 17 3 7 15 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=88200000000P PS=690000U PD=840000U
* device instance $11 r0 *1 5.37,2.275 pfet_01v8_hvt
M$11 14 8 17 15 pfet_01v8_hvt L=150000U W=420000U AS=88200000000P
+ AD=111300000000P PS=840000U PD=1370000U
* device instance $12 r0 *1 0.47,2.135 pfet_01v8_hvt
M$12 14 12 2 15 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $13 r0 *1 0.89,2.135 pfet_01v8_hvt
M$13 3 2 14 15 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $14 r0 *1 6.43,0.56 nfet_01v8
M$14 1 7 8 18 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $15 r0 *1 6.85,0.56 nfet_01v8
M$15 9 8 1 18 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $17 r0 *1 0.47,0.445 nfet_01v8
M$17 1 12 2 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $18 r0 *1 0.89,0.445 nfet_01v8
M$18 3 2 1 18 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $19 r0 *1 2.39,0.415 nfet_01v8
M$19 5 2 4 18 nfet_01v8 L=150000U W=360000U AS=81300000000P AD=62100000000P
+ PS=830000U PD=705000U
* device instance $20 r0 *1 2.885,0.415 nfet_01v8
M$20 10 3 5 18 nfet_01v8 L=150000U W=360000U AS=62100000000P AD=69600000000P
+ PS=705000U PD=765000U
* device instance $21 r0 *1 4.48,0.415 nfet_01v8
M$21 7 3 6 18 nfet_01v8 L=150000U W=360000U AS=98900000000P AD=68400000000P
+ PS=995000U PD=740000U
* device instance $22 r0 *1 5.01,0.415 nfet_01v8
M$22 11 2 7 18 nfet_01v8 L=150000U W=360000U AS=68400000000P AD=66000000000P
+ PS=740000U PD=745000U
* device instance $23 r0 *1 1.83,0.445 nfet_01v8
M$23 4 13 1 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=81300000000P
+ PS=1360000U PD=830000U
* device instance $24 r0 *1 3.38,0.445 nfet_01v8
M$24 1 6 10 18 nfet_01v8 L=150000U W=420000U AS=69600000000P AD=120950000000P
+ PS=765000U PD=1085000U
* device instance $25 r0 *1 5.485,0.445 nfet_01v8
M$25 1 8 11 18 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=109200000000P
+ PS=745000U PD=1360000U
* device instance $26 r0 *1 3.975,0.555 nfet_01v8
M$26 6 5 1 18 nfet_01v8 L=150000U W=640000U AS=120950000000P AD=98900000000P
+ PS=1085000U PD=995000U
.ENDS sky130_fd_sc_hd__dfxtp_2

* cell sky130_fd_sc_hd__clkinvlp_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__clkinvlp_4 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.525,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=250000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 0.475,0.51 nfet_01v8
M$5 8 2 4 6 nfet_01v8 L=150000U W=550000U AS=145750000000P AD=57750000000P
+ PS=1630000U PD=760000U
* device instance $6 r0 *1 0.835,0.51 nfet_01v8
M$6 5 2 8 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=77000000000P
+ PS=760000U PD=830000U
* device instance $7 r0 *1 1.265,0.51 nfet_01v8
M$7 7 2 5 6 nfet_01v8 L=150000U W=550000U AS=77000000000P AD=57750000000P
+ PS=830000U PD=760000U
* device instance $8 r0 *1 1.625,0.51 nfet_01v8
M$8 4 2 7 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=145750000000P
+ PS=760000U PD=1630000U
.ENDS sky130_fd_sc_hd__clkinvlp_4

* cell sky130_fd_sc_hd__inv_2
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_2 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 VPWR
* net 5 Y
* device instance $1 r0 *1 0.48,1.985 pfet_01v8_hvt
M$1 5 2 4 1 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $3 r0 *1 0.48,0.56 nfet_01v8
M$3 5 2 3 6 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__inv_2

* cell sky130_fd_sc_hd__a221oi_2
* pin VGND
* pin C1
* pin Y
* pin B2
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_2 1 2 3 4 6 7 9 10 11 14
* net 1 VGND
* net 2 C1
* net 3 Y
* net 4 B2
* net 6 B1
* net 7 A2
* net 9 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.84,1.985 pfet_01v8_hvt
M$1 12 4 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=310000000000P PS=3790000U PD=2620000U
* device instance $2 r0 *1 2.26,1.985 pfet_01v8_hvt
M$2 13 6 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 3.6,1.985 pfet_01v8_hvt
M$5 10 7 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $6 r0 *1 4.02,1.985 pfet_01v8_hvt
M$6 13 9 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 0.48,1.985 pfet_01v8_hvt
M$9 3 2 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=395000000000P PS=3810000U PD=3790000U
* device instance $11 r0 *1 0.48,0.56 nfet_01v8
M$11 3 2 1 14 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=344500000000P
+ PS=2760000U PD=2360000U
* device instance $13 r0 *1 1.84,0.56 nfet_01v8
M$13 5 4 1 14 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=201500000000P
+ PS=2360000U PD=1920000U
* device instance $14 r0 *1 2.26,0.56 nfet_01v8
M$14 3 6 5 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 3.6,0.56 nfet_01v8
M$17 8 7 1 14 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $18 r0 *1 4.02,0.56 nfet_01v8
M$18 3 9 8 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
.ENDS sky130_fd_sc_hd__a221oi_2

* cell sky130_fd_sc_hd__o31ai_2
* pin VGND
* pin A1
* pin A2
* pin A3
* pin Y
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_2 1 3 4 5 6 7 9 11 12
* net 1 VGND
* net 3 A1
* net 4 A2
* net 5 A3
* net 6 Y
* net 7 B1
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 10 5 6 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.55,1.985 pfet_01v8_hvt
M$3 9 7 6 11 pfet_01v8_hvt L=150000U W=2000000U AS=330000000000P
+ AD=455000000000P PS=2660000U PD=3910000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 9 3 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 10 4 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 1 3 2 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 1.33,0.56 nfet_01v8
M$11 1 4 2 12 nfet_01v8 L=150000U W=1300000U AS=286000000000P AD=325000000000P
+ PS=2180000U PD=2300000U
* device instance $13 r0 *1 2.63,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=240500000000P AD=201500000000P
+ PS=2040000U PD=1920000U
* device instance $15 r0 *1 3.55,0.56 nfet_01v8
M$15 6 7 2 12 nfet_01v8 L=150000U W=1300000U AS=214500000000P AD=295750000000P
+ PS=1960000U PD=2860000U
.ENDS sky130_fd_sc_hd__o31ai_2

* cell sky130_fd_sc_hd__or4_1
* pin VPB
* pin A
* pin B
* pin C
* pin D
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or4_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 D
* net 7 X
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 13 5 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $2 r0 *1 0.95,1.695 pfet_01v8_hvt
M$2 12 4 13 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $3 r0 *1 1.31,1.695 pfet_01v8_hvt
M$3 11 3 12 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $4 r0 *1 1.79,1.695 pfet_01v8_hvt
M$4 8 2 11 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $5 r0 *1 2.28,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=270000000000P PS=1340000U PD=2540000U
* device instance $6 r0 *1 0.47,0.475 nfet_01v8
M$6 6 5 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $7 r0 *1 0.95,0.475 nfet_01v8
M$7 9 4 6 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $8 r0 *1 1.37,0.475 nfet_01v8
M$8 6 3 9 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $9 r0 *1 1.79,0.475 nfet_01v8
M$9 6 2 9 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $10 r0 *1 2.28,0.56 nfet_01v8
M$10 7 6 9 10 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=175500000000P
+ PS=990000U PD=1840000U
.ENDS sky130_fd_sc_hd__or4_1

* cell sky130_fd_sc_hd__clkinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_16 1 2 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=24000000U AS=3.59e+12P AD=3.58e+12P
+ PS=32180000U PD=32160000U
* device instance $25 r0 *1 2.205,0.445 nfet_01v8
M$25 3 2 1 6 nfet_01v8 L=150000U W=6720000U AS=1.0332e+12P AD=1.0332e+12P
+ PS=12060000U PD=12060000U
.ENDS sky130_fd_sc_hd__clkinv_16

* cell sky130_fd_sc_hd__ha_2
* pin VGND
* pin COUT
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_2 1 6 7 8 10 11 13
* net 1 VGND
* net 2 SUM
* net 6 COUT
* net 7 B
* net 8 A
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=446600000000P PS=3830000U PD=3075000U
* device instance $3 r0 *1 1.845,2.165 pfet_01v8_hvt
M$3 3 5 10 11 pfet_01v8_hvt L=150000U W=640000U AS=291600000000P
+ AD=86400000000P PS=1765000U PD=910000U
* device instance $4 r0 *1 2.265,2.165 pfet_01v8_hvt
M$4 12 7 3 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=128000000000P PS=910000U PD=1040000U
* device instance $5 r0 *1 2.815,2.165 pfet_01v8_hvt
M$5 10 8 12 11 pfet_01v8_hvt L=150000U W=640000U AS=128000000000P
+ AD=227200000000P PS=1040000U PD=1350000U
* device instance $6 r0 *1 3.675,2.165 pfet_01v8_hvt
M$6 5 7 10 11 pfet_01v8_hvt L=150000U W=640000U AS=227200000000P
+ AD=92800000000P PS=1350000U PD=930000U
* device instance $7 r0 *1 4.115,2.165 pfet_01v8_hvt
M$7 5 8 10 11 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P
+ AD=92800000000P PS=1325000U PD=930000U
* device instance $8 r0 *1 4.59,1.985 pfet_01v8_hvt
M$8 6 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=304000000000P
+ AD=415000000000P PS=2635000U PD=3830000U
* device instance $10 r0 *1 3.755,0.445 nfet_01v8
M$10 9 7 5 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $11 r0 *1 4.115,0.445 nfet_01v8
M$11 1 8 9 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $12 r0 *1 4.59,0.56 nfet_01v8
M$12 6 5 1 13 nfet_01v8 L=150000U W=1300000U AS=197750000000P AD=269750000000P
+ PS=1935000U PD=2780000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 2 3 1 13 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=269750000000P
+ PS=2780000U PD=2780000U
* device instance $16 r0 *1 1.87,0.445 nfet_01v8
M$16 4 5 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 2.29,0.445 nfet_01v8
M$17 1 7 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $18 r0 *1 2.71,0.445 nfet_01v8
M$18 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__ha_2

* cell sky130_fd_sc_hd__and3_2
* pin VPB
* pin A
* pin B
* pin C
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and3_2 1 2 3 4 6 7 8 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 1.375,1.695 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=150750000000P
+ PS=815000U PD=1345000U
* device instance $2 r0 *1 0.48,1.765 pfet_01v8_hvt
M$2 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 0.9,1.765 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 1.87,1.985 pfet_01v8_hvt
M$4 8 5 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=285750000000P
+ AD=395000000000P PS=2615000U PD=3790000U
* device instance $6 r0 *1 0.485,0.475 nfet_01v8
M$6 11 2 5 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 0.845,0.475 nfet_01v8
M$7 10 3 11 9 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 1.25,0.475 nfet_01v8
M$8 10 4 6 9 nfet_01v8 L=150000U W=420000U AS=130400000000P AD=53550000000P
+ PS=1105000U PD=675000U
* device instance $9 r0 *1 1.855,0.56 nfet_01v8
M$9 8 5 6 9 nfet_01v8 L=150000U W=1300000U AS=218150000000P AD=266500000000P
+ PS=2025000U PD=2770000U
.ENDS sky130_fd_sc_hd__and3_2

* cell sky130_fd_sc_hd__or2_2
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or2_2 1 2 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 4 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.53,1.695 pfet_01v8_hvt
M$1 9 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.89,1.695 pfet_01v8_hvt
M$2 6 2 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=155750000000P
+ PS=630000U PD=1355000U
* device instance $3 r0 *1 1.395,1.985 pfet_01v8_hvt
M$3 5 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=290750000000P
+ AD=395000000000P PS=2625000U PD=3790000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 3 4 7 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.89,0.445 nfet_01v8
M$6 7 2 3 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=106750000000P
+ PS=690000U PD=1005000U
* device instance $7 r0 *1 1.395,0.56 nfet_01v8
M$7 5 3 7 8 nfet_01v8 L=150000U W=1300000U AS=194500000000P AD=256750000000P
+ PS=1925000U PD=2740000U
.ENDS sky130_fd_sc_hd__or2_2

* cell sky130_fd_sc_hd__clkinv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.47,2.065 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1680000U AS=331800000000P
+ AD=348600000000P PS=3310000U PD=3350000U
* device instance $3 r0 *1 0.885,0.445 nfet_01v8
M$3 4 2 5 6 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=119700000000P
+ PS=1360000U PD=1410000U
.ENDS sky130_fd_sc_hd__clkinv_1

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__o21a_1
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21a_1 1 2 3 4 5 7 8 10
* net 1 VPB
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=327500000000P PS=2560000U PD=1655000U
* device instance $2 r0 *1 1.295,1.985 pfet_01v8_hvt
M$2 9 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=327500000000P
+ AD=195000000000P PS=1655000U PD=1390000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=152500000000P PS=1390000U PD=1305000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 5 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=260000000000P PS=1305000U PD=2520000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 3 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 8 9 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21a_1

* cell sky130_fd_sc_hd__or3_1
* pin VPB
* pin A
* pin B
* pin C
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.48,1.695 pfet_01v8_hvt
M$1 11 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.84,1.695 pfet_01v8_hvt
M$2 10 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $3 r0 *1 1.32,1.695 pfet_01v8_hvt
M$3 6 2 10 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $4 r0 *1 1.81,1.985 pfet_01v8_hvt
M$4 5 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=280000000000P PS=1340000U PD=2560000U
* device instance $5 r0 *1 0.48,0.475 nfet_01v8
M$5 7 4 8 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.9,0.475 nfet_01v8
M$6 8 3 7 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $7 r0 *1 1.32,0.475 nfet_01v8
M$7 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $8 r0 *1 1.81,0.56 nfet_01v8
M$8 5 8 7 9 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=182000000000P
+ PS=990000U PD=1860000U
.ENDS sky130_fd_sc_hd__or3_1

* cell sky130_fd_sc_hd__o32ai_1
* pin VGND
* pin B1
* pin Y
* pin B2
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32ai_1 1 2 4 5 6 7 8 9 10 12
* net 1 VGND
* net 2 B1
* net 4 Y
* net 5 B2
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 4 5 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=305000000000P PS=1210000U PD=1610000U
* device instance $3 r0 *1 1.59,1.985 pfet_01v8_hvt
M$3 13 6 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=245000000000P PS=1610000U PD=1490000U
* device instance $4 r0 *1 2.23,1.985 pfet_01v8_hvt
M$4 14 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=245000000000P
+ AD=135000000000P PS=1490000U PD=1270000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 9 8 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=280000000000P PS=1270000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 4 2 3 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 0.945,0.56 nfet_01v8
M$7 3 5 4 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=100750000000P
+ PS=975000U PD=960000U
* device instance $8 r0 *1 1.405,0.56 nfet_01v8
M$8 1 6 3 12 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=219375000000P
+ PS=960000U PD=1325000U
* device instance $9 r0 *1 2.23,0.56 nfet_01v8
M$9 3 7 1 12 nfet_01v8 L=150000U W=650000U AS=219375000000P AD=87750000000P
+ PS=1325000U PD=920000U
* device instance $10 r0 *1 2.65,0.56 nfet_01v8
M$10 1 8 3 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=234000000000P
+ PS=920000U PD=2020000U
.ENDS sky130_fd_sc_hd__o32ai_1

* cell sky130_fd_sc_hd__nor4_4
* pin VGND
* pin C
* pin Y
* pin A
* pin B
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_4 1 2 3 4 6 7 8 11 12
* net 1 VGND
* net 2 C
* net 3 Y
* net 4 A
* net 6 B
* net 7 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.37,1.985 pfet_01v8_hvt
M$1 9 2 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.05,1.985 pfet_01v8_hvt
M$5 3 7 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 8 4 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $13 r0 *1 2.17,1.985 pfet_01v8_hvt
M$13 9 6 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 3 4 1 12 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $21 r0 *1 2.17,0.56 nfet_01v8
M$21 3 6 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $25 r0 *1 4.37,0.56 nfet_01v8
M$25 3 2 1 12 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $29 r0 *1 6.05,0.56 nfet_01v8
M$29 3 7 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor4_4

* cell sky130_fd_sc_hd__a41o_1
* pin VGND
* pin X
* pin A2
* pin A3
* pin B1
* pin A1
* pin A4
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41o_1 1 2 4 5 6 7 8 12 13 15
* net 1 VGND
* net 2 X
* net 4 A2
* net 5 A3
* net 6 B1
* net 7 A1
* net 8 A4
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 14 6 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 1.83,1.985 pfet_01v8_hvt
M$2 12 7 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.25,1.985 pfet_01v8_hvt
M$3 14 4 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.73,1.985 pfet_01v8_hvt
M$4 12 5 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $5 r0 *1 3.21,1.985 pfet_01v8_hvt
M$5 14 8 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 12 3 2 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=160875000000P
+ PS=1820000U PD=1145000U
* device instance $8 r0 *1 1.115,0.56 nfet_01v8
M$8 3 6 1 15 nfet_01v8 L=150000U W=650000U AS=160875000000P AD=183625000000P
+ PS=1145000U PD=1215000U
* device instance $9 r0 *1 1.83,0.56 nfet_01v8
M$9 10 7 3 15 nfet_01v8 L=150000U W=650000U AS=183625000000P AD=87750000000P
+ PS=1215000U PD=920000U
* device instance $10 r0 *1 2.25,0.56 nfet_01v8
M$10 9 4 10 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $11 r0 *1 2.73,0.56 nfet_01v8
M$11 11 5 9 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 1 8 11 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a41o_1

* cell sky130_fd_sc_hd__o2111a_1
* pin VGND
* pin X
* pin C1
* pin B1
* pin D1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2111a_1 1 2 4 5 7 8 9 12 13 14
* net 1 VGND
* net 2 X
* net 4 C1
* net 5 B1
* net 7 D1
* net 8 A2
* net 9 A1
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 3 2 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=382500000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,1.985 pfet_01v8_hvt
M$2 3 7 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=382500000000P
+ AD=217500000000P PS=1765000U PD=1435000U
* device instance $3 r0 *1 1.97,1.985 pfet_01v8_hvt
M$3 12 4 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=217500000000P
+ AD=305000000000P PS=1435000U PD=1610000U
* device instance $4 r0 *1 2.73,1.985 pfet_01v8_hvt
M$4 3 5 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=212500000000P PS=1610000U PD=1425000U
* device instance $5 r0 *1 3.305,1.985 pfet_01v8_hvt
M$5 15 8 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=105000000000P PS=1425000U PD=1210000U
* device instance $6 r0 *1 3.665,1.985 pfet_01v8_hvt
M$6 12 9 15 13 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=265000000000P PS=1210000U PD=2530000U
* device instance $7 r0 *1 1.455,0.56 nfet_01v8
M$7 11 7 3 14 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=118625000000P
+ PS=1910000U PD=1015000U
* device instance $8 r0 *1 1.97,0.56 nfet_01v8
M$8 10 4 11 14 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=118625000000P
+ PS=1015000U PD=1015000U
* device instance $9 r0 *1 2.485,0.56 nfet_01v8
M$9 6 5 10 14 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=198250000000P
+ PS=1015000U PD=1260000U
* device instance $10 r0 *1 3.245,0.56 nfet_01v8
M$10 1 8 6 14 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=87750000000P
+ PS=1260000U PD=920000U
* device instance $11 r0 *1 3.665,0.56 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=172250000000P
+ PS=920000U PD=1830000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 3 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o2111a_1

* cell sky130_fd_sc_hd__nand2b_4
* pin VGND
* pin B
* pin Y
* pin A_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_4 1 2 5 6 7 8 9
* net 1 VGND
* net 2 B
* net 5 Y
* net 6 A_N
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 5 3 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=547500000000P PS=6330000U PD=5095000U
* device instance $5 r0 *1 3.105,1.985 pfet_01v8_hvt
M$5 5 2 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=547500000000P
+ AD=795000000000P PS=5095000U PD=6590000U
* device instance $9 r0 *1 0.47,1.985 pfet_01v8_hvt
M$9 7 6 3 8 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $10 r0 *1 1.41,0.56 nfet_01v8
M$10 5 3 4 9 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=355875000000P
+ PS=4580000U PD=3695000U
* device instance $14 r0 *1 3.105,0.56 nfet_01v8
M$14 1 2 4 9 nfet_01v8 L=150000U W=2600000U AS=355875000000P AD=516750000000P
+ PS=3695000U PD=4840000U
* device instance $18 r0 *1 0.47,0.56 nfet_01v8
M$18 1 6 3 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_4

* cell sky130_fd_sc_hd__a221o_1
* pin VGND
* pin B1
* pin A1
* pin X
* pin C1
* pin B2
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221o_1 1 3 4 5 8 9 10 13 14 15
* net 1 VGND
* net 3 B1
* net 4 A1
* net 5 X
* net 8 C1
* net 9 B2
* net 10 A2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=165000000000P PS=2520000U PD=1330000U
* device instance $2 r0 *1 2.73,1.985 pfet_01v8_hvt
M$2 13 10 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=157500000000P PS=1330000U PD=1315000U
* device instance $3 r0 *1 3.195,1.985 pfet_01v8_hvt
M$3 5 2 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=157500000000P
+ AD=260000000000P PS=1315000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 11 8 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 12 9 11 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $6 r0 *1 1.31,1.985 pfet_01v8_hvt
M$6 11 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $7 r0 *1 2.25,0.56 nfet_01v8
M$7 7 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $8 r0 *1 2.73,0.56 nfet_01v8
M$8 1 10 7 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=102375000000P
+ PS=980000U PD=965000U
* device instance $9 r0 *1 3.195,0.56 nfet_01v8
M$9 5 2 1 15 nfet_01v8 L=150000U W=650000U AS=102375000000P AD=169000000000P
+ PS=965000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 8 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $11 r0 *1 0.95,0.56 nfet_01v8
M$11 6 9 1 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=68250000000P
+ PS=980000U PD=860000U
* device instance $12 r0 *1 1.31,0.56 nfet_01v8
M$12 2 3 6 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221o_1

* cell sky130_fd_sc_hd__o221ai_1
* pin VPB
* pin C1
* pin B1
* pin A2
* pin A1
* pin B2
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o221ai_1 1 2 3 4 5 6 8 10 11 12
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 B2
* net 8 Y
* net 10 VPWR
* net 11 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=380000000000P PS=2560000U PD=1760000U
* device instance $2 r0 *1 1.4,1.985 pfet_01v8_hvt
M$2 14 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=380000000000P
+ AD=120000000000P PS=1760000U PD=1240000U
* device instance $3 r0 *1 1.79,1.985 pfet_01v8_hvt
M$3 8 6 14 1 pfet_01v8_hvt L=150000U W=1000000U AS=120000000000P
+ AD=225000000000P PS=1240000U PD=1450000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 13 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=105000000000P PS=1450000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.4,0.56 nfet_01v8
M$6 9 3 7 12 nfet_01v8 L=150000U W=650000U AS=165200000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.82,0.56 nfet_01v8
M$7 7 6 9 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=117000000000P
+ PS=920000U PD=1010000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 11 4 7 12 nfet_01v8 L=150000U W=650000U AS=117000000000P AD=87750000000P
+ PS=1010000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 5 11 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 9 2 8 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=165400000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221ai_1

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__a31oi_2
* pin VGND
* pin Y
* pin A3
* pin A2
* pin A1
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_2 1 4 5 6 7 8 10 11 12
* net 1 VGND
* net 4 Y
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=545000000000P
+ AD=590000000000P PS=3090000U PD=3180000U
* device instance $7 r0 *1 3.63,1.985 pfet_01v8_hvt
M$7 4 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=355000000000P
+ AD=435000000000P PS=2710000U PD=3870000U
* device instance $9 r0 *1 2.67,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=214500000000P
+ PS=2770000U PD=1960000U
* device instance $11 r0 *1 3.63,0.56 nfet_01v8
M$11 1 8 4 12 nfet_01v8 L=150000U W=1300000U AS=230750000000P AD=282750000000P
+ PS=2010000U PD=2820000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a31oi_2

* cell sky130_fd_sc_hd__nand2_2
* pin VGND
* pin
* pin B
* pin Y
* pin A
* pin VPB
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nand2_2 1 2 4 5 6 7 8
* net 1 VGND
* net 4 B
* net 5 Y
* net 6 A
* net 7 VPB
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 5 6 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 1 4 3 2 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 5 6 3 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand2_2

* cell sky130_fd_sc_hd__a22oi_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=300000000000P PS=1270000U PD=2600000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 1.83,0.56 nfet_01v8
M$5 11 4 8 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 2.19,0.56 nfet_01v8
M$6 9 5 11 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=234000000000P
+ PS=860000U PD=2020000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 12 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 3 12 10 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22oi_1

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__o21ai_1
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 VGND
* net 8 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 8 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=174000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.37,2.135 pfet_01v8_hvt
M$3 5 3 8 1 pfet_01v8_hvt L=150000U W=700000U AS=174000000000P AD=182000000000P
+ PS=1390000U PD=1920000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $5 r0 *1 0.95,0.56 nfet_01v8
M$5 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 8 3 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21ai_1

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__a311o_1
* pin VPB
* pin C1
* pin B1
* pin A1
* pin A2
* pin A3
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a311o_1 1 2 3 4 5 6 7 8 10 12
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 X
* net 8 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 11 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=285000000000P
+ AD=142500000000P PS=2570000U PD=1285000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 9 6 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=142500000000P
+ AD=165000000000P PS=1285000U PD=1330000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 10 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=305000000000P PS=1330000U PD=1610000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 9 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=162500000000P PS=1610000U PD=1325000U
* device instance $5 r0 *1 2.645,1.985 pfet_01v8_hvt
M$5 13 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=207500000000P PS=1325000U PD=1415000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 11 2 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=207500000000P
+ AD=260000000000P PS=1415000U PD=2520000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 8 11 7 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112125000000P
+ PS=1820000U PD=995000U
* device instance $8 r0 *1 0.965,0.56 nfet_01v8
M$8 15 6 8 12 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=125125000000P
+ PS=995000U PD=1035000U
* device instance $9 r0 *1 1.5,0.56 nfet_01v8
M$9 14 5 15 12 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=169000000000P
+ PS=1035000U PD=1170000U
* device instance $10 r0 *1 2.17,0.56 nfet_01v8
M$10 11 4 14 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1170000U PD=975000U
* device instance $11 r0 *1 2.645,0.56 nfet_01v8
M$11 8 3 11 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=134875000000P
+ PS=975000U PD=1065000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 11 2 8 12 nfet_01v8 L=150000U W=650000U AS=134875000000P AD=169000000000P
+ PS=1065000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311o_1

* cell sky130_fd_sc_hd__nor2_4
* pin VGND
* pin B
* pin Y
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor2_4 1 2 3 4 6 7 8
* net 1 VGND
* net 2 B
* net 3 Y
* net 4 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 4 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $5 r0 *1 2.17,1.985 pfet_01v8_hvt
M$5 3 2 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=675000000000P PS=5080000U PD=6350000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 3 4 1 8 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $13 r0 *1 2.17,0.56 nfet_01v8
M$13 3 2 1 8 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor2_4

* cell sky130_fd_sc_hd__nand3b_1
* pin VPB
* pin A_N
* pin C
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A_N
* net 3 C
* net 4 B
* net 5 Y
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 8 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 8 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 5 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=280000000000P PS=1385000U PD=2560000U
* device instance $5 r0 *1 0.6,0.675 nfet_01v8
M$5 6 2 7 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $6 r0 *1 1.085,0.56 nfet_01v8
M$6 11 3 7 9 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $8 r0 *1 2.04,0.56 nfet_01v8
M$8 5 6 10 9 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=182000000000P
+ PS=1035000U PD=1860000U
.ENDS sky130_fd_sc_hd__nand3b_1

* cell sky130_fd_sc_hd__a21boi_0
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_0 1 2 3 4 6 8 9 10
* net 1 VPB
* net 2 B1_N
* net 3 A1
* net 4 A2
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 1.425,2.165 pfet_01v8_hvt
M$1 5 7 9 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=89600000000P
+ PS=1810000U PD=920000U
* device instance $2 r0 *1 1.855,2.165 pfet_01v8_hvt
M$2 8 3 5 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=89600000000P
+ PS=920000U PD=920000U
* device instance $3 r0 *1 2.285,2.165 pfet_01v8_hvt
M$3 5 4 8 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=169600000000P
+ PS=920000U PD=1810000U
* device instance $4 r0 *1 0.475,2.275 pfet_01v8_hvt
M$4 8 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=111300000000P
+ PS=1370000U PD=1370000U
* device instance $5 r0 *1 0.475,0.445 nfet_01v8
M$5 6 2 7 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=130200000000P
+ PS=1370000U PD=1040000U
* device instance $6 r0 *1 1.245,0.445 nfet_01v8
M$6 9 7 6 10 nfet_01v8 L=150000U W=420000U AS=130200000000P AD=111300000000P
+ PS=1040000U PD=950000U
* device instance $7 r0 *1 1.925,0.445 nfet_01v8
M$7 11 3 9 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=950000U PD=630000U
* device instance $8 r0 *1 2.285,0.445 nfet_01v8
M$8 6 4 11 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=111300000000P
+ PS=630000U PD=1370000U
.ENDS sky130_fd_sc_hd__a21boi_0

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__and2_1
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 X
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.65,2.065 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $2 r0 *1 1.07,2.065 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=166550000000P AD=56700000000P
+ PS=1390000U PD=690000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=166550000000P
+ AD=475000000000P PS=1390000U PD=2950000U
* device instance $4 r0 *1 0.65,0.585 nfet_01v8
M$4 9 2 6 8 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $5 r0 *1 1.07,0.585 nfet_01v8
M$5 9 3 7 8 nfet_01v8 L=150000U W=420000U AS=111800000000P AD=56700000000P
+ PS=1040000U PD=690000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 4 6 7 8 nfet_01v8 L=150000U W=650000U AS=111800000000P AD=182000000000P
+ PS=1040000U PD=1860000U
.ENDS sky130_fd_sc_hd__and2_1

* cell sky130_fd_sc_hd__xor2_2
* pin VGND
* pin A
* pin B
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xor2_2 1 3 4 6 8 10 11
* net 1 VGND
* net 3 A
* net 4 B
* net 6 X
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 4.94,1.985 pfet_01v8_hvt
M$1 6 2 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=415000000000P PS=3790000U PD=3830000U
* device instance $3 r0 *1 2.685,1.985 pfet_01v8_hvt
M$3 8 3 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 3.525,1.985 pfet_01v8_hvt
M$5 8 4 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=422500000000P PS=2595000U PD=3845000U
* device instance $7 r0 *1 0.485,1.985 pfet_01v8_hvt
M$7 8 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=410000000000P
+ AD=270000000000P PS=3820000U PD=2540000U
* device instance $9 r0 *1 1.325,1.985 pfet_01v8_hvt
M$9 2 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 4.94,0.56 nfet_01v8
M$11 6 2 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
* device instance $13 r0 *1 2.685,0.56 nfet_01v8
M$13 1 3 5 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 3.525,0.56 nfet_01v8
M$15 6 4 5 11 nfet_01v8 L=150000U W=1300000U AS=193375000000P AD=274625000000P
+ PS=1895000U PD=2795000U
* device instance $17 r0 *1 0.485,0.56 nfet_01v8
M$17 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $19 r0 *1 1.325,0.56 nfet_01v8
M$19 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__xor2_2

* cell sky130_fd_sc_hd__o311a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311a_1 1 2 5 6 7 8 9 11 12 15
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 C1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.48,1.985 pfet_01v8_hvt
M$1 11 4 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=312500000000P PS=2520000U PD=1625000U
* device instance $2 r0 *1 1.255,1.985 pfet_01v8_hvt
M$2 14 5 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=312500000000P
+ AD=180000000000P PS=1625000U PD=1360000U
* device instance $3 r0 *1 1.765,1.985 pfet_01v8_hvt
M$3 13 6 14 12 pfet_01v8_hvt L=150000U W=1000000U AS=180000000000P
+ AD=210000000000P PS=1360000U PD=1420000U
* device instance $4 r0 *1 2.335,1.985 pfet_01v8_hvt
M$4 4 7 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=210000000000P
+ AD=137500000000P PS=1420000U PD=1275000U
* device instance $5 r0 *1 2.76,1.985 pfet_01v8_hvt
M$5 11 8 4 12 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=150000000000P PS=1275000U PD=1300000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 4 9 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=150000000000P
+ AD=260000000000P PS=1300000U PD=2520000U
* device instance $7 r0 *1 0.48,0.56 nfet_01v8
M$7 1 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=203125000000P
+ PS=1820000U PD=1275000U
* device instance $8 r0 *1 1.255,0.56 nfet_01v8
M$8 3 5 1 15 nfet_01v8 L=150000U W=650000U AS=203125000000P AD=117000000000P
+ PS=1275000U PD=1010000U
* device instance $9 r0 *1 1.765,0.56 nfet_01v8
M$9 1 6 3 15 nfet_01v8 L=150000U W=650000U AS=117000000000P AD=136500000000P
+ PS=1010000U PD=1070000U
* device instance $10 r0 *1 2.335,0.56 nfet_01v8
M$10 3 7 1 15 nfet_01v8 L=150000U W=650000U AS=136500000000P AD=118625000000P
+ PS=1070000U PD=1015000U
* device instance $11 r0 *1 2.85,0.56 nfet_01v8
M$11 10 8 3 15 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=68250000000P
+ PS=1015000U PD=860000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 4 9 10 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__o311a_1

* cell sky130_fd_sc_hd__o311ai_0
* pin VGND
* pin A1
* pin Y
* pin C1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_0 1 2 4 5 7 8 9 10 11 14
* net 1 VGND
* net 2 A1
* net 4 Y
* net 5 C1
* net 7 A2
* net 8 A3
* net 9 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.615,2.165 pfet_01v8_hvt
M$1 12 2 10 11 pfet_01v8_hvt L=150000U W=640000U AS=179200000000P
+ AD=86400000000P PS=1840000U PD=910000U
* device instance $2 r0 *1 1.035,2.165 pfet_01v8_hvt
M$2 13 7 12 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=86400000000P PS=910000U PD=910000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 4 8 13 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=144000000000P PS=910000U PD=1090000U
* device instance $4 r0 *1 2.055,2.165 pfet_01v8_hvt
M$4 10 9 4 11 pfet_01v8_hvt L=150000U W=640000U AS=144000000000P
+ AD=118400000000P PS=1090000U PD=1010000U
* device instance $5 r0 *1 2.575,2.165 pfet_01v8_hvt
M$5 4 5 10 11 pfet_01v8_hvt L=150000U W=640000U AS=118400000000P
+ AD=198400000000P PS=1010000U PD=1900000U
* device instance $6 r0 *1 0.615,0.445 nfet_01v8
M$6 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $7 r0 *1 1.035,0.445 nfet_01v8
M$7 1 7 3 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 1.455,0.445 nfet_01v8
M$8 3 8 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=128100000000P
+ PS=690000U PD=1030000U
* device instance $9 r0 *1 2.215,0.445 nfet_01v8
M$9 6 9 3 14 nfet_01v8 L=150000U W=420000U AS=128100000000P AD=44100000000P
+ PS=1030000U PD=630000U
* device instance $10 r0 *1 2.575,0.445 nfet_01v8
M$10 4 5 6 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=117600000000P
+ PS=630000U PD=1400000U
.ENDS sky130_fd_sc_hd__o311ai_0

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 1.85,0.56 nfet_01v8
M$7 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.27,0.56 nfet_01v8
M$8 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 0.89,0.56 nfet_01v8
M$10 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__xnor2_2
* pin VGND
* pin Y
* pin B
* pin A
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_2 1 5 6 7 8 9 11
* net 1 VGND
* net 5 Y
* net 6 B
* net 7 A
* net 8 VPB
* net 9 VPWR
* device instance $1 r0 *1 4.96,1.985 pfet_01v8_hvt
M$1 5 3 9 8 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=415000000000P PS=3790000U PD=3830000U
* device instance $3 r0 *1 2.725,1.985 pfet_01v8_hvt
M$3 9 7 10 8 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 3.565,1.985 pfet_01v8_hvt
M$5 5 6 10 8 pfet_01v8_hvt L=150000U W=2000000U AS=287500000000P
+ AD=412500000000P PS=2575000U PD=3825000U
* device instance $7 r0 *1 0.485,1.985 pfet_01v8_hvt
M$7 9 6 3 8 pfet_01v8_hvt L=150000U W=2000000U AS=410000000000P
+ AD=270000000000P PS=3820000U PD=2540000U
* device instance $9 r0 *1 1.325,1.985 pfet_01v8_hvt
M$9 9 7 3 8 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $11 r0 *1 4.96,0.56 nfet_01v8
M$11 4 3 5 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
* device instance $13 r0 *1 2.725,0.56 nfet_01v8
M$13 4 7 1 11 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $15 r0 *1 3.565,0.56 nfet_01v8
M$15 4 6 1 11 nfet_01v8 L=150000U W=1300000U AS=186875000000P AD=268125000000P
+ PS=1875000U PD=2775000U
* device instance $17 r0 *1 0.485,0.56 nfet_01v8
M$17 3 6 2 11 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $19 r0 *1 1.325,0.56 nfet_01v8
M$19 1 7 2 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__xnor2_2

* cell sky130_fd_sc_hd__edfxtp_1
* pin VGND
* pin DE
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__edfxtp_1 1 5 11 17 18 19 20 26
* net 1 VGND
* net 5 DE
* net 11 Q
* net 17 CLK
* net 18 D
* net 19 VPWR
* net 20 VPB
* device instance $1 r0 *1 9.925,2.165 pfet_01v8_hvt
M$1 7 10 19 20 pfet_01v8_hvt L=150000U W=640000U AS=154000000000P
+ AD=172800000000P PS=1335000U PD=1820000U
* device instance $2 r0 *1 10.41,1.985 pfet_01v8_hvt
M$2 11 10 19 20 pfet_01v8_hvt L=150000U W=1000000U AS=154000000000P
+ AD=280000000000P PS=1335000U PD=2560000U
* device instance $3 r0 *1 7.425,2.275 pfet_01v8_hvt
M$3 24 9 19 20 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=64050000000P PS=1360000U PD=725000U
* device instance $4 r0 *1 7.88,2.275 pfet_01v8_hvt
M$4 10 2 24 20 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P
+ AD=56700000000P PS=725000U PD=690000U
* device instance $5 r0 *1 8.3,2.275 pfet_01v8_hvt
M$5 25 3 10 20 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=88200000000P PS=690000U PD=840000U
* device instance $6 r0 *1 8.87,2.275 pfet_01v8_hvt
M$6 19 7 25 20 pfet_01v8_hvt L=150000U W=420000U AS=88200000000P
+ AD=111300000000P PS=840000U PD=1370000U
* device instance $7 r0 *1 1.83,2.165 pfet_01v8_hvt
M$7 21 18 4 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=67200000000P PS=1800000U PD=850000U
* device instance $8 r0 *1 2.19,2.165 pfet_01v8_hvt
M$8 19 6 21 20 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=166400000000P PS=850000U PD=1800000U
* device instance $9 r0 *1 0.47,2.135 pfet_01v8_hvt
M$9 19 17 2 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $10 r0 *1 0.89,2.135 pfet_01v8_hvt
M$10 3 2 19 20 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $11 r0 *1 3.13,2.165 pfet_01v8_hvt
M$11 19 5 6 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=92800000000P PS=1800000U PD=930000U
* device instance $12 r0 *1 3.57,2.165 pfet_01v8_hvt
M$12 22 5 19 20 pfet_01v8_hvt L=150000U W=640000U AS=92800000000P
+ AD=115200000000P PS=930000U PD=1000000U
* device instance $13 r0 *1 4.08,2.165 pfet_01v8_hvt
M$13 4 7 22 20 pfet_01v8_hvt L=150000U W=640000U AS=115200000000P
+ AD=159850000000P PS=1000000U PD=1265000U
* device instance $14 r0 *1 4.855,2.275 pfet_01v8_hvt
M$14 8 3 4 20 pfet_01v8_hvt L=150000U W=420000U AS=159850000000P
+ AD=64050000000P PS=1265000U PD=725000U
* device instance $15 r0 *1 5.31,2.275 pfet_01v8_hvt
M$15 23 2 8 20 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P
+ AD=76650000000P PS=725000U PD=785000U
* device instance $16 r0 *1 5.825,2.275 pfet_01v8_hvt
M$16 23 9 19 20 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=76650000000P PS=1260000U PD=785000U
* device instance $17 r0 *1 6.485,2.11 pfet_01v8_hvt
M$17 9 8 19 20 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=195000000000P PS=1260000U PD=2020000U
* device instance $18 r0 *1 9.925,0.445 nfet_01v8
M$18 1 10 7 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $19 r0 *1 10.41,0.56 nfet_01v8
M$19 11 10 1 26 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=182000000000P
+ PS=985000U PD=1860000U
* device instance $20 r0 *1 7.98,0.415 nfet_01v8
M$20 10 3 15 26 nfet_01v8 L=150000U W=360000U AS=67800000000P AD=68400000000P
+ PS=755000U PD=740000U
* device instance $21 r0 *1 8.51,0.415 nfet_01v8
M$21 13 2 10 26 nfet_01v8 L=150000U W=360000U AS=68400000000P AD=66000000000P
+ PS=740000U PD=745000U
* device instance $22 r0 *1 7.495,0.445 nfet_01v8
M$22 15 9 1 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=67800000000P
+ PS=1360000U PD=755000U
* device instance $23 r0 *1 8.985,0.445 nfet_01v8
M$23 1 7 13 26 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=109200000000P
+ PS=745000U PD=1360000U
* device instance $24 r0 *1 0.47,0.445 nfet_01v8
M$24 1 17 2 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $25 r0 *1 0.89,0.445 nfet_01v8
M$25 3 2 1 26 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $26 r0 *1 4.99,0.415 nfet_01v8
M$26 8 2 4 26 nfet_01v8 L=150000U W=360000U AS=144600000000P AD=52200000000P
+ PS=1180000U PD=650000U
* device instance $27 r0 *1 5.43,0.415 nfet_01v8
M$27 16 3 8 26 nfet_01v8 L=150000U W=360000U AS=52200000000P AD=75900000000P
+ PS=650000U PD=800000U
* device instance $28 r0 *1 3.13,0.445 nfet_01v8
M$28 1 5 6 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $29 r0 *1 3.57,0.445 nfet_01v8
M$29 14 6 1 26 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=75600000000P
+ PS=710000U PD=780000U
* device instance $30 r0 *1 4.08,0.445 nfet_01v8
M$30 4 7 14 26 nfet_01v8 L=150000U W=420000U AS=75600000000P AD=144600000000P
+ PS=780000U PD=1180000U
* device instance $31 r0 *1 5.96,0.445 nfet_01v8
M$31 1 9 16 26 nfet_01v8 L=150000U W=420000U AS=75900000000P AD=120950000000P
+ PS=800000U PD=1085000U
* device instance $32 r0 *1 6.555,0.555 nfet_01v8
M$32 9 8 1 26 nfet_01v8 L=150000U W=640000U AS=120950000000P AD=166400000000P
+ PS=1085000U PD=1800000U
* device instance $33 r0 *1 1.83,0.445 nfet_01v8
M$33 12 18 4 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $34 r0 *1 2.19,0.445 nfet_01v8
M$34 1 5 12 26 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=109200000000P
+ PS=630000U PD=1360000U
.ENDS sky130_fd_sc_hd__edfxtp_1

* cell sky130_fd_sc_hd__buf_12
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_12 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 4 3 5 6 pfet_01v8_hvt L=150000U W=12000000U AS=1.62e+12P AD=1.865e+12P
+ PS=15240000U PD=16730000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 3 2 1 7 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 2.15,0.56 nfet_01v8
M$21 4 3 1 7 nfet_01v8 L=150000U W=7800000U AS=1.053e+12P AD=1.21225e+12P
+ PS=11040000U PD=12180000U
.ENDS sky130_fd_sc_hd__buf_12

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4

* cell sky130_fd_sc_hd__clkdlybuf4s50_1
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkdlybuf4s50_1 1 2 4 7 8 9
* net 1 VPB
* net 2 A
* net 4 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 2.465,2.075 pfet_01v8_hvt
M$1 6 5 7 1 pfet_01v8_hvt L=500000U W=820000U AS=155750000000P AD=217300000000P
+ PS=1325000U PD=2170000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=155750000000P
+ AD=355000000000P PS=1325000U PD=2710000U
* device instance $3 r0 *1 0.48,1.985 pfet_01v8_hvt
M$3 7 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=170100000000P PS=2540000U PD=1360000U
* device instance $4 r0 *1 1.165,2.075 pfet_01v8_hvt
M$4 5 3 7 1 pfet_01v8_hvt L=500000U W=820000U AS=170100000000P AD=217300000000P
+ PS=1360000U PD=2170000U
* device instance $5 r0 *1 3.115,0.445 nfet_01v8
M$5 8 6 4 9 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=149100000000P
+ PS=975000U PD=1550000U
* device instance $6 r0 *1 2.465,0.56 nfet_01v8
M$6 4 5 6 9 nfet_01v8 L=500000U W=650000U AS=172250000000P AD=97000000000P
+ PS=1830000U PD=975000U
* device instance $7 r0 *1 0.48,0.445 nfet_01v8
M$7 4 2 3 9 nfet_01v8 L=150000U W=420000U AS=113400000000P AD=104350000000P
+ PS=1380000U PD=1010000U
* device instance $8 r0 *1 1.165,0.56 nfet_01v8
M$8 5 3 4 9 nfet_01v8 L=500000U W=650000U AS=104350000000P AD=169000000000P
+ PS=1010000U PD=1820000U
.ENDS sky130_fd_sc_hd__clkdlybuf4s50_1

* cell sky130_fd_sc_hd__dfxtp_1
* pin VGND
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfxtp_1 1 9 12 13 14 15 18
* net 1 VGND
* net 9 Q
* net 12 CLK
* net 13 D
* net 14 VPWR
* net 15 VPB
* device instance $1 r0 *1 1.83,2.275 pfet_01v8_hvt
M$1 4 13 14 15 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=57750000000P PS=1360000U PD=695000U
* device instance $2 r0 *1 2.255,2.275 pfet_01v8_hvt
M$2 5 3 4 15 pfet_01v8_hvt L=150000U W=420000U AS=57750000000P AD=68250000000P
+ PS=695000U PD=745000U
* device instance $3 r0 *1 2.73,2.275 pfet_01v8_hvt
M$3 16 2 5 15 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=76650000000P
+ PS=745000U PD=785000U
* device instance $4 r0 *1 3.245,2.275 pfet_01v8_hvt
M$4 16 6 14 15 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=76650000000P PS=1260000U PD=785000U
* device instance $5 r0 *1 3.905,2.11 pfet_01v8_hvt
M$5 6 5 14 15 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=109500000000P PS=1260000U PD=1075000U
* device instance $6 r0 *1 4.38,2.275 pfet_01v8_hvt
M$6 7 2 6 15 pfet_01v8_hvt L=150000U W=420000U AS=109500000000P AD=56700000000P
+ PS=1075000U PD=690000U
* device instance $7 r0 *1 4.8,2.275 pfet_01v8_hvt
M$7 17 3 7 15 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=88200000000P
+ PS=690000U PD=840000U
* device instance $8 r0 *1 5.37,2.275 pfet_01v8_hvt
M$8 14 8 17 15 pfet_01v8_hvt L=150000U W=420000U AS=88200000000P
+ AD=111300000000P PS=840000U PD=1370000U
* device instance $9 r0 *1 0.47,2.135 pfet_01v8_hvt
M$9 14 12 2 15 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $10 r0 *1 0.89,2.135 pfet_01v8_hvt
M$10 3 2 14 15 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $11 r0 *1 6.42,1.985 pfet_01v8_hvt
M$11 14 7 8 15 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=135000000000P PS=2540000U PD=1270000U
* device instance $12 r0 *1 6.84,1.985 pfet_01v8_hvt
M$12 9 8 14 15 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $13 r0 *1 6.43,0.56 nfet_01v8
M$13 1 7 8 18 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $14 r0 *1 6.85,0.56 nfet_01v8
M$14 9 8 1 18 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $15 r0 *1 0.47,0.445 nfet_01v8
M$15 1 12 2 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $16 r0 *1 0.89,0.445 nfet_01v8
M$16 3 2 1 18 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $17 r0 *1 2.39,0.415 nfet_01v8
M$17 5 2 4 18 nfet_01v8 L=150000U W=360000U AS=81300000000P AD=62100000000P
+ PS=830000U PD=705000U
* device instance $18 r0 *1 2.885,0.415 nfet_01v8
M$18 11 3 5 18 nfet_01v8 L=150000U W=360000U AS=62100000000P AD=69600000000P
+ PS=705000U PD=765000U
* device instance $19 r0 *1 4.48,0.415 nfet_01v8
M$19 7 3 6 18 nfet_01v8 L=150000U W=360000U AS=98900000000P AD=68400000000P
+ PS=995000U PD=740000U
* device instance $20 r0 *1 5.01,0.415 nfet_01v8
M$20 10 2 7 18 nfet_01v8 L=150000U W=360000U AS=68400000000P AD=66000000000P
+ PS=740000U PD=745000U
* device instance $21 r0 *1 1.83,0.445 nfet_01v8
M$21 4 13 1 18 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=81300000000P
+ PS=1360000U PD=830000U
* device instance $22 r0 *1 3.38,0.445 nfet_01v8
M$22 1 6 11 18 nfet_01v8 L=150000U W=420000U AS=69600000000P AD=120950000000P
+ PS=765000U PD=1085000U
* device instance $23 r0 *1 5.485,0.445 nfet_01v8
M$23 1 8 10 18 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=109200000000P
+ PS=745000U PD=1360000U
* device instance $24 r0 *1 3.975,0.555 nfet_01v8
M$24 6 5 1 18 nfet_01v8 L=150000U W=640000U AS=120950000000P AD=98900000000P
+ PS=1085000U PD=995000U
.ENDS sky130_fd_sc_hd__dfxtp_1

* cell sky130_fd_sc_hd__clkbuf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_16 1 3 4 5 6 7
* net 1 VGND
* net 3 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $5 r0 *1 2.195,1.985 pfet_01v8_hvt
M$5 4 2 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.2375e+12P AD=2.3625e+12P
+ PS=20475000U PD=21725000U
* device instance $21 r0 *1 0.475,0.445 nfet_01v8
M$21 2 3 1 7 nfet_01v8 L=150000U W=1680000U AS=287700000000P AD=235200000000P
+ PS=3470000U PD=2800000U
* device instance $25 r0 *1 2.195,0.445 nfet_01v8
M$25 4 2 1 7 nfet_01v8 L=150000U W=6720000U AS=939750000000P AD=992250000000P
+ PS=11195000U PD=11865000U
.ENDS sky130_fd_sc_hd__clkbuf_16

* cell sky130_fd_sc_hd__ha_1
* pin VGND
* pin SUM
* pin COUT
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_1 1 2 5 8 9 10 11 13
* net 1 VGND
* net 2 SUM
* net 5 COUT
* net 8 A
* net 9 B
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=236050000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,2.275 pfet_01v8_hvt
M$2 3 7 10 11 pfet_01v8_hvt L=150000U W=420000U AS=236050000000P
+ AD=56700000000P PS=1765000U PD=690000U
* device instance $3 r0 *1 1.805,2.275 pfet_01v8_hvt
M$3 12 9 3 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=84000000000P
+ PS=690000U PD=820000U
* device instance $4 r0 *1 2.355,2.275 pfet_01v8_hvt
M$4 10 8 12 11 pfet_01v8_hvt L=150000U W=420000U AS=84000000000P
+ AD=149100000000P PS=820000U PD=1130000U
* device instance $5 r0 *1 3.215,2.275 pfet_01v8_hvt
M$5 7 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=149100000000P
+ AD=60900000000P PS=1130000U PD=710000U
* device instance $6 r0 *1 3.655,2.275 pfet_01v8_hvt
M$6 7 8 10 11 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=60900000000P PS=1325000U PD=710000U
* device instance $7 r0 *1 4.13,1.985 pfet_01v8_hvt
M$7 5 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $8 r0 *1 3.295,0.445 nfet_01v8
M$8 6 9 7 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 3.655,0.445 nfet_01v8
M$9 1 8 6 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $10 r0 *1 4.13,0.56 nfet_01v8
M$10 5 7 1 13 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 1.41,0.445 nfet_01v8
M$11 4 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $12 r0 *1 1.83,0.445 nfet_01v8
M$12 1 9 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $13 r0 *1 2.25,0.445 nfet_01v8
M$13 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__ha_1

* cell sky130_fd_sc_hd__xor2_4
* pin VGND
* pin A
* pin B
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xor2_4 1 2 3 6 8 10 11
* net 1 VGND
* net 2 A
* net 3 B
* net 6 X
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 8.255,1.985 pfet_01v8_hvt
M$1 9 4 6 10 pfet_01v8_hvt L=150000U W=4000000U AS=677450000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 4.365,1.985 pfet_01v8_hvt
M$5 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 6.045,1.985 pfet_01v8_hvt
M$9 8 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=661800000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 0.485,1.985 pfet_01v8_hvt
M$13 8 2 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=680000000000P
+ AD=540000000000P PS=6360000U PD=5080000U
* device instance $17 r0 *1 2.165,1.985 pfet_01v8_hvt
M$17 4 3 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 8.255,0.56 nfet_01v8
M$21 6 4 1 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $25 r0 *1 4.365,0.56 nfet_01v8
M$25 6 3 5 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 6.045,0.56 nfet_01v8
M$29 1 2 5 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $33 r0 *1 0.485,0.56 nfet_01v8
M$33 4 2 1 11 nfet_01v8 L=150000U W=2600000U AS=442000000000P AD=351000000000P
+ PS=4610000U PD=3680000U
* device instance $37 r0 *1 2.165,0.56 nfet_01v8
M$37 4 3 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__xor2_4

* cell sky130_fd_sc_hd__o311ai_1
* pin VGND
* pin Y
* pin A1
* pin A2
* pin A3
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_1 1 3 4 5 6 7 8 10 11 14
* net 1 VGND
* net 3 Y
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 B1
* net 8 C1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.615,1.985 pfet_01v8_hvt
M$1 12 4 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=135000000000P PS=2560000U PD=1270000U
* device instance $2 r0 *1 1.035,1.985 pfet_01v8_hvt
M$2 13 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.455,1.985 pfet_01v8_hvt
M$3 3 6 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=225000000000P PS=1270000U PD=1450000U
* device instance $4 r0 *1 2.055,1.985 pfet_01v8_hvt
M$4 10 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=185000000000P PS=1450000U PD=1370000U
* device instance $5 r0 *1 2.575,1.985 pfet_01v8_hvt
M$5 3 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=185000000000P
+ AD=310000000000P PS=1370000U PD=2620000U
* device instance $6 r0 *1 0.615,0.56 nfet_01v8
M$6 2 4 1 14 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $7 r0 *1 1.035,0.56 nfet_01v8
M$7 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.455,0.56 nfet_01v8
M$8 2 6 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $9 r0 *1 2.215,0.56 nfet_01v8
M$9 9 7 2 14 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=68250000000P
+ PS=1260000U PD=860000U
* device instance $10 r0 *1 2.575,0.56 nfet_01v8
M$10 3 8 9 14 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=182000000000P
+ PS=860000U PD=1860000U
.ENDS sky130_fd_sc_hd__o311ai_1

* cell sky130_fd_sc_hd__a2111oi_0
* pin VGND
* pin D1
* pin Y
* pin A1
* pin C1
* pin B1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_0 1 2 3 4 6 7 8 9 10 14
* net 1 VGND
* net 2 D1
* net 3 Y
* net 4 A1
* net 6 C1
* net 7 B1
* net 8 A2
* net 9 VPB
* net 10 VPWR
* device instance $1 r0 *1 0.77,2.165 pfet_01v8_hvt
M$1 12 2 3 9 pfet_01v8_hvt L=150000U W=640000U AS=188800000000P AD=67200000000P
+ PS=1870000U PD=850000U
* device instance $2 r0 *1 1.13,2.165 pfet_01v8_hvt
M$2 13 6 12 9 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P AD=67200000000P
+ PS=850000U PD=850000U
* device instance $3 r0 *1 1.49,2.165 pfet_01v8_hvt
M$3 11 7 13 9 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P AD=89600000000P
+ PS=850000U PD=920000U
* device instance $4 r0 *1 1.92,2.165 pfet_01v8_hvt
M$4 10 4 11 9 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P
+ AD=121600000000P PS=920000U PD=1020000U
* device instance $5 r0 *1 2.45,2.165 pfet_01v8_hvt
M$5 11 8 10 9 pfet_01v8_hvt L=150000U W=640000U AS=121600000000P
+ AD=195200000000P PS=1020000U PD=1890000U
* device instance $6 r0 *1 0.7,0.445 nfet_01v8
M$6 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=126000000000P AD=58800000000P
+ PS=1440000U PD=700000U
* device instance $7 r0 *1 1.13,0.445 nfet_01v8
M$7 1 6 3 14 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=73500000000P
+ PS=700000U PD=770000U
* device instance $8 r0 *1 1.63,0.445 nfet_01v8
M$8 3 7 1 14 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=58800000000P
+ PS=770000U PD=700000U
* device instance $9 r0 *1 2.06,0.445 nfet_01v8
M$9 5 4 3 14 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=44100000000P
+ PS=700000U PD=630000U
* device instance $10 r0 *1 2.42,0.445 nfet_01v8
M$10 1 8 5 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=119700000000P
+ PS=630000U PD=1410000U
.ENDS sky130_fd_sc_hd__a2111oi_0

* cell sky130_fd_sc_hd__o2111ai_1
* pin VPB
* pin D1
* pin C1
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2111ai_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 D1
* net 3 C1
* net 4 B1
* net 5 A2
* net 6 A1
* net 8 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.67,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.1,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=195000000000P PS=1280000U PD=1390000U
* device instance $3 r0 *1 1.64,1.985 pfet_01v8_hvt
M$3 9 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=202500000000P PS=1390000U PD=1405000U
* device instance $4 r0 *1 2.195,1.985 pfet_01v8_hvt
M$4 12 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=202500000000P
+ AD=195000000000P PS=1405000U PD=1390000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 8 6 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=265000000000P PS=1390000U PD=2530000U
* device instance $6 r0 *1 0.74,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $7 r0 *1 1.1,0.56 nfet_01v8
M$7 13 3 14 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=126750000000P
+ PS=860000U PD=1040000U
* device instance $8 r0 *1 1.64,0.56 nfet_01v8
M$8 7 4 13 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=131625000000P
+ PS=1040000U PD=1055000U
* device instance $9 r0 *1 2.195,0.56 nfet_01v8
M$9 10 5 7 11 nfet_01v8 L=150000U W=650000U AS=131625000000P AD=126750000000P
+ PS=1055000U PD=1040000U
* device instance $10 r0 *1 2.735,0.56 nfet_01v8
M$10 7 6 10 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=172250000000P
+ PS=1040000U PD=1830000U
.ENDS sky130_fd_sc_hd__o2111ai_1

* cell sky130_fd_sc_hd__nor4_1
* pin VPB
* pin D
* pin B
* pin A
* pin C
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 D
* net 3 B
* net 4 A
* net 5 C
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=130000000000P PS=2520000U PD=1260000U
* device instance $2 r0 *1 0.88,1.985 pfet_01v8_hvt
M$2 10 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=130000000000P
+ AD=190000000000P PS=1260000U PD=1380000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 12 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 8 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=118625000000P
+ PS=1820000U PD=1015000U
* device instance $6 r0 *1 0.985,0.56 nfet_01v8
M$6 6 5 7 9 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=89375000000P
+ PS=1015000U PD=925000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 7 3 6 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=87750000000P
+ PS=925000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor4_1

* cell sky130_fd_sc_hd__a32oi_1
* pin VPB
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a32oi_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A3
* net 5 A2
* net 6 A1
* net 8 Y
* net 9 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=215000000000P PS=1270000U PD=1430000U
* device instance $3 r0 *1 1.47,1.985 pfet_01v8_hvt
M$3 10 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=135000000000P PS=1430000U PD=1270000U
* device instance $4 r0 *1 1.89,1.985 pfet_01v8_hvt
M$4 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=140000000000P PS=1270000U PD=1280000U
* device instance $5 r0 *1 2.32,1.985 pfet_01v8_hvt
M$5 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=260000000000P PS=1280000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $7 r0 *1 0.85,0.56 nfet_01v8
M$7 8 3 14 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=152750000000P
+ PS=880000U PD=1120000U
* device instance $8 r0 *1 1.47,0.56 nfet_01v8
M$8 12 6 8 11 nfet_01v8 L=150000U W=650000U AS=152750000000P AD=71500000000P
+ PS=1120000U PD=870000U
* device instance $9 r0 *1 1.84,0.56 nfet_01v8
M$9 13 5 12 11 nfet_01v8 L=150000U W=650000U AS=71500000000P AD=107250000000P
+ PS=870000U PD=980000U
* device instance $10 r0 *1 2.32,0.56 nfet_01v8
M$10 9 4 13 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a32oi_1

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__a221oi_1
* pin VGND
* pin Y
* pin B1
* pin A1
* pin C1
* pin B2
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_1 1 2 3 4 5 6 7 10 11 14
* net 1 VGND
* net 2 Y
* net 3 B1
* net 4 A1
* net 5 C1
* net 6 B2
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 13 4 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=152500000000P PS=2520000U PD=1305000U
* device instance $2 r0 *1 2.705,1.985 pfet_01v8_hvt
M$2 11 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=305000000000P PS=1305000U PD=2610000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 12 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 13 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 12 3 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 2.25,0.56 nfet_01v8
M$6 9 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=99125000000P
+ PS=1820000U PD=955000U
* device instance $7 r0 *1 2.705,0.56 nfet_01v8
M$7 1 7 9 14 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=198250000000P
+ PS=955000U PD=1910000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $9 r0 *1 0.945,0.56 nfet_01v8
M$9 8 6 1 14 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=69875000000P
+ PS=975000U PD=865000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 2 3 8 14 nfet_01v8 L=150000U W=650000U AS=69875000000P AD=169000000000P
+ PS=865000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221oi_1

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__nor3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 6 4 5 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $6 r0 *1 1.31,0.56 nfet_01v8
M$6 6 2 5 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor3_1

* cell sky130_fd_sc_hd__a211oi_1
* pin VPB
* pin A2
* pin A1
* pin C1
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A2
* net 3 A1
* net 4 C1
* net 5 B1
* net 6 VGND
* net 7 Y
* net 9 VPWR
* device instance $1 r0 *1 0.62,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.05,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 1.48,1.985 pfet_01v8_hvt
M$3 11 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 1.94,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.62,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=266500000000P AD=91000000000P
+ PS=2120000U PD=930000U
* device instance $6 r0 *1 1.05,0.56 nfet_01v8
M$6 7 3 12 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $7 r0 *1 1.48,0.56 nfet_01v8
M$7 6 5 7 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $8 r0 *1 1.94,0.56 nfet_01v8
M$8 7 4 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211oi_1

* cell sky130_fd_sc_hd__a311oi_1
* pin VPB
* pin A3
* pin A2
* pin B1
* pin A1
* pin C1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_1 1 2 3 4 5 6 7 9 10 11
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 B1
* net 5 A1
* net 6 C1
* net 7 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 0.895,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 1.325,1.985 pfet_01v8_hvt
M$3 8 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=165000000000P PS=1280000U PD=1330000U
* device instance $4 r0 *1 1.805,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=172500000000P PS=1330000U PD=1345000U
* device instance $5 r0 *1 2.3,1.985 pfet_01v8_hvt
M$5 9 6 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=260000000000P PS=1345000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 10 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=89375000000P
+ PS=1820000U PD=925000U
* device instance $7 r0 *1 0.895,0.56 nfet_01v8
M$7 13 3 14 11 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 1.325,0.56 nfet_01v8
M$8 9 5 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=115375000000P
+ PS=930000U PD=1005000U
* device instance $9 r0 *1 1.83,0.56 nfet_01v8
M$9 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=112125000000P
+ PS=1005000U PD=995000U
* device instance $10 r0 *1 2.325,0.56 nfet_01v8
M$10 9 6 10 11 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=169000000000P
+ PS=995000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311oi_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__mux2_2
* pin VGND
* pin X
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_2 1 2 4 5 6 10 11 14
* net 1 VGND
* net 2 X
* net 4 A0
* net 5 A1
* net 6 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=312800000000P PS=3790000U PD=2685000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 12 9 10 11 pfet_01v8_hvt L=150000U W=640000U AS=177800000000P
+ AD=228800000000P PS=1415000U PD=1355000U
* device instance $4 r0 *1 2.32,2.165 pfet_01v8_hvt
M$4 3 5 12 11 pfet_01v8_hvt L=150000U W=640000U AS=228800000000P
+ AD=131200000000P PS=1355000U PD=1050000U
* device instance $5 r0 *1 2.88,2.165 pfet_01v8_hvt
M$5 13 4 3 11 pfet_01v8_hvt L=150000U W=640000U AS=131200000000P
+ AD=67200000000P PS=1050000U PD=850000U
* device instance $6 r0 *1 3.24,2.165 pfet_01v8_hvt
M$6 10 6 13 11 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=86400000000P PS=850000U PD=910000U
* device instance $7 r0 *1 3.66,2.165 pfet_01v8_hvt
M$7 9 6 10 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=172800000000P PS=910000U PD=1820000U
* device instance $8 r0 *1 1.365,0.445 nfet_01v8
M$8 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=68250000000P
+ PS=975000U PD=745000U
* device instance $9 r0 *1 1.84,0.445 nfet_01v8
M$9 3 4 7 14 nfet_01v8 L=150000U W=420000U AS=68250000000P AD=173250000000P
+ PS=745000U PD=1245000U
* device instance $10 r0 *1 2.815,0.445 nfet_01v8
M$10 8 5 3 14 nfet_01v8 L=150000U W=420000U AS=173250000000P AD=57750000000P
+ PS=1245000U PD=695000U
* device instance $11 r0 *1 3.24,0.445 nfet_01v8
M$11 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=57750000000P AD=56700000000P
+ PS=695000U PD=690000U
* device instance $12 r0 *1 3.66,0.445 nfet_01v8
M$12 9 6 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=113400000000P
+ PS=690000U PD=1380000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 2 3 1 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=184750000000P
+ PS=2740000U PD=1895000U
.ENDS sky130_fd_sc_hd__mux2_2

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__xnor2_1
* pin VPB
* pin B
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_1 1 2 3 4 5 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 Y
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.51,1.985 pfet_01v8_hvt
M$1 8 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=135000000000P PS=2600000U PD=1270000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=365000000000P PS=1270000U PD=1730000U
* device instance $3 r0 *1 1.81,1.985 pfet_01v8_hvt
M$3 10 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=105000000000P PS=1730000U PD=1210000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 4 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 5 8 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=360000000000P PS=1330000U PD=2720000U
* device instance $6 r0 *1 2.29,0.56 nfet_01v8
M$6 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 4 8 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=195000000000P
+ PS=920000U PD=1900000U
* device instance $8 r0 *1 0.57,0.56 nfet_01v8
M$8 11 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $9 r0 *1 0.93,0.56 nfet_01v8
M$9 7 3 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=87750000000P
+ PS=860000U PD=920000U
* device instance $10 r0 *1 1.35,0.56 nfet_01v8
M$10 6 3 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor2_1

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__xor2_1
* pin VPB
* pin B
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xor2_1 1 2 3 6 7 8 9
* net 1 VPB
* net 2 B
* net 3 A
* net 6 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=300000000000P PS=2520000U PD=2600000U
* device instance $2 r0 *1 0.51,1.985 pfet_01v8_hvt
M$2 10 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $3 r0 *1 0.93,1.985 pfet_01v8_hvt
M$3 6 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.35,1.985 pfet_01v8_hvt
M$4 5 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.77,1.985 pfet_01v8_hvt
M$5 6 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.51,0.56 nfet_01v8
M$6 4 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.93,0.56 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.35,0.56 nfet_01v8
M$8 11 3 8 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 1.77,0.56 nfet_01v8
M$9 7 2 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=250250000000P
+ PS=920000U PD=1420000U
* device instance $10 r0 *1 2.69,0.56 nfet_01v8
M$10 8 4 7 9 nfet_01v8 L=150000U W=650000U AS=250250000000P AD=208000000000P
+ PS=1420000U PD=1940000U
.ENDS sky130_fd_sc_hd__xor2_1

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__xnor3_1
* pin VGND
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xnor3_1 1 2 6 11 12 13 14 15
* net 1 VGND
* net 2 X
* net 6 C
* net 11 B
* net 12 A
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 5.455,1.805 pfet_01v8_hvt
M$1 10 9 8 14 pfet_01v8_hvt L=150000U W=640000U AS=243100000000P
+ AD=246000000000P PS=1445000U PD=1525000U
* device instance $2 r0 *1 6.33,1.965 pfet_01v8_hvt
M$2 4 11 10 14 pfet_01v8_hvt L=150000U W=640000U AS=246000000000P
+ AD=145800000000P PS=1525000U PD=1205000U
* device instance $3 r0 *1 4.7,1.905 pfet_01v8_hvt
M$3 8 11 5 14 pfet_01v8_hvt L=150000U W=840000U AS=352800000000P
+ AD=243100000000P PS=2520000U PD=1445000U
* device instance $4 r0 *1 6.845,2.065 pfet_01v8_hvt
M$4 4 9 5 14 pfet_01v8_hvt L=150000U W=840000U AS=171500000000P
+ AD=145800000000P PS=1355000U PD=1205000U
* device instance $5 r0 *1 7.35,1.985 pfet_01v8_hvt
M$5 13 12 5 14 pfet_01v8_hvt L=150000U W=1000000U AS=171500000000P
+ AD=135000000000P PS=1355000U PD=1270000U
* device instance $6 r0 *1 7.77,1.985 pfet_01v8_hvt
M$6 10 5 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=285000000000P PS=1270000U PD=2570000U
* device instance $7 r0 *1 1.005,1.805 pfet_01v8_hvt
M$7 7 6 13 14 pfet_01v8_hvt L=150000U W=640000U AS=169000000000P
+ AD=179200000000P PS=1365000U PD=1840000U
* device instance $8 r0 *1 0.49,1.985 pfet_01v8_hvt
M$8 13 3 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=169000000000P PS=2560000U PD=1365000U
* device instance $9 r0 *1 3.6,1.985 pfet_01v8_hvt
M$9 9 11 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=256550000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $10 r0 *1 2.54,1.905 pfet_01v8_hvt
M$10 8 7 3 14 pfet_01v8_hvt L=150000U W=840000U AS=152950000000P
+ AD=322350000000P PS=1315000U PD=2450000U
* device instance $11 r0 *1 2.055,2.045 pfet_01v8_hvt
M$11 4 6 3 14 pfet_01v8_hvt L=150000U W=840000U AS=152950000000P
+ AD=273000000000P PS=1315000U PD=2330000U
* device instance $12 r0 *1 5.455,0.455 nfet_01v8
M$12 10 9 4 15 nfet_01v8 L=150000U W=420000U AS=182050000000P AD=192650000000P
+ PS=1245000U PD=1285000U
* device instance $13 r0 *1 6.85,0.535 nfet_01v8
M$13 5 9 8 15 nfet_01v8 L=150000U W=600000U AS=140825000000P AD=110000000000P
+ PS=1100000U PD=990000U
* device instance $14 r0 *1 7.35,0.555 nfet_01v8
M$14 1 12 5 15 nfet_01v8 L=150000U W=640000U AS=110000000000P AD=86400000000P
+ PS=990000U PD=910000U
* device instance $15 r0 *1 7.77,0.555 nfet_01v8
M$15 10 5 1 15 nfet_01v8 L=150000U W=640000U AS=86400000000P AD=182400000000P
+ PS=910000U PD=1850000U
* device instance $16 r0 *1 4.7,0.565 nfet_01v8
M$16 4 11 5 15 nfet_01v8 L=150000U W=640000U AS=162750000000P AD=182050000000P
+ PS=1800000U PD=1245000U
* device instance $17 r0 *1 6.25,0.565 nfet_01v8
M$17 10 11 8 15 nfet_01v8 L=150000U W=640000U AS=140825000000P AD=192650000000P
+ PS=1100000U PD=1285000U
* device instance $18 r0 *1 0.47,0.56 nfet_01v8
M$18 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=116500000000P
+ PS=1820000U PD=1035000U
* device instance $19 r0 *1 1.005,0.675 nfet_01v8
M$19 7 6 1 15 nfet_01v8 L=150000U W=420000U AS=116500000000P AD=178500000000P
+ PS=1035000U PD=1690000U
* device instance $20 r0 *1 2.12,0.565 nfet_01v8
M$20 3 6 8 15 nfet_01v8 L=150000U W=640000U AS=172800000000P AD=92800000000P
+ PS=1820000U PD=930000U
* device instance $21 r0 *1 2.56,0.565 nfet_01v8
M$21 4 7 3 15 nfet_01v8 L=150000U W=640000U AS=92800000000P AD=224000000000P
+ PS=930000U PD=1980000U
* device instance $22 r0 *1 3.77,0.56 nfet_01v8
M$22 9 11 1 15 nfet_01v8 L=150000U W=650000U AS=188500000000P AD=165150000000P
+ PS=1880000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor3_1
