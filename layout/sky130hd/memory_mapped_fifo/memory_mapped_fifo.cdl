* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT memory_mapped_fifo clk ext_empty ext_full ext_rd_data[0]
+ ext_rd_data[10] ext_rd_data[11] ext_rd_data[12] ext_rd_data[13]
+ ext_rd_data[14] ext_rd_data[15] ext_rd_data[16] ext_rd_data[17]
+ ext_rd_data[18] ext_rd_data[19] ext_rd_data[1] ext_rd_data[20]
+ ext_rd_data[21] ext_rd_data[22] ext_rd_data[23] ext_rd_data[24]
+ ext_rd_data[25] ext_rd_data[26] ext_rd_data[27] ext_rd_data[28]
+ ext_rd_data[29] ext_rd_data[2] ext_rd_data[30] ext_rd_data[31]
+ ext_rd_data[3] ext_rd_data[4] ext_rd_data[5] ext_rd_data[6]
+ ext_rd_data[7] ext_rd_data[8] ext_rd_data[9] ext_rd_en ext_wr_data[0]
+ ext_wr_data[10] ext_wr_data[11] ext_wr_data[12] ext_wr_data[13]
+ ext_wr_data[14] ext_wr_data[15] ext_wr_data[16] ext_wr_data[17]
+ ext_wr_data[18] ext_wr_data[19] ext_wr_data[1] ext_wr_data[20]
+ ext_wr_data[21] ext_wr_data[22] ext_wr_data[23] ext_wr_data[24]
+ ext_wr_data[25] ext_wr_data[26] ext_wr_data[27] ext_wr_data[28]
+ ext_wr_data[29] ext_wr_data[2] ext_wr_data[30] ext_wr_data[31]
+ ext_wr_data[3] ext_wr_data[4] ext_wr_data[5] ext_wr_data[6]
+ ext_wr_data[7] ext_wr_data[8] ext_wr_data[9] ext_wr_en mem_addr[0]
+ mem_addr[1] mem_addr[2] mem_addr[3] mem_rdata[0] mem_rdata[10]
+ mem_rdata[11] mem_rdata[12] mem_rdata[13] mem_rdata[14] mem_rdata[15]
+ mem_rdata[16] mem_rdata[17] mem_rdata[18] mem_rdata[19] mem_rdata[1]
+ mem_rdata[20] mem_rdata[21] mem_rdata[22] mem_rdata[23] mem_rdata[24]
+ mem_rdata[25] mem_rdata[26] mem_rdata[27] mem_rdata[28] mem_rdata[29]
+ mem_rdata[2] mem_rdata[30] mem_rdata[31] mem_rdata[3] mem_rdata[4]
+ mem_rdata[5] mem_rdata[6] mem_rdata[7] mem_rdata[8] mem_rdata[9]
+ mem_ready mem_valid mem_wdata[0] mem_wdata[10] mem_wdata[11]
+ mem_wdata[12] mem_wdata[13] mem_wdata[14] mem_wdata[15] mem_wdata[16]
+ mem_wdata[17] mem_wdata[18] mem_wdata[19] mem_wdata[1] mem_wdata[20]
+ mem_wdata[21] mem_wdata[22] mem_wdata[23] mem_wdata[24] mem_wdata[25]
+ mem_wdata[26] mem_wdata[27] mem_wdata[28] mem_wdata[29] mem_wdata[2]
+ mem_wdata[30] mem_wdata[31] mem_wdata[3] mem_wdata[4] mem_wdata[5]
+ mem_wdata[6] mem_wdata[7] mem_wdata[8] mem_wdata[9] mem_write
+ rst_n
X_0905_ _0886_ _0874_ _0885_ VSS VSS VDD VDD _0741_ sky130_fd_sc_hd__a21o_1
X_0906_ _0883_ _0741_ _0882_ VSS VSS VDD VDD _0742_ sky130_fd_sc_hd__a21oi_2
X_0907_ wr_ptr\[4\] rd_ptr\[4\] VSS VSS VDD VDD _0743_ sky130_fd_sc_hd__xor2_2
X_0908_ _0742_ _0743_ VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__xnor2_4
X_0909_ _0886_ _0874_ VSS VSS VDD VDD _0745_ sky130_fd_sc_hd__xnor2_1
X_0910_ _0875_ _0745_ _0878_ VSS VSS VDD VDD _0746_ sky130_fd_sc_hd__nand3b_1
X_0911_ _0877_ _0880_ VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__nand2b_1
X_0912_ _0879_ _0885_ VSS VSS VDD VDD _0748_ sky130_fd_sc_hd__nor2_1
X_0913_ _0886_ _0885_ VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__nor2_1
X_0914_ _0747_ _0748_ _0749_ VSS VSS VDD VDD _0750_ sky130_fd_sc_hd__a21oi_4
X_0915_ _0883_ _0750_ VSS VSS VDD VDD _0751_ sky130_fd_sc_hd__xor2_2
X_0916_ _0744_ _0746_ _0751_ VSS VSS VDD VDD net75 sky130_fd_sc_hd__nor3_1
X_0917_ net39 VSS VSS VDD VDD _0752_ sky130_fd_sc_hd__buf_16
X_0918_ mem_addr[3] VSS VSS VDD VDD _0753_ sky130_fd_sc_hd__buf_2
X_0919_ net37 net36 net38 _0753_ VSS VSS VDD VDD _0754_ sky130_fd_sc_hd__nor4_4
X_0920_ _0752_ net72 _0754_ VSS VSS VDD VDD _0755_ sky130_fd_sc_hd__and3_1
X_0921_ _0744_ _0746_ _0751_ _0755_ net35 VSS VSS VDD VDD
+ _0756_ sky130_fd_sc_hd__o32ai_4
X_0922_ _0756_ VSS VSS VDD VDD _0757_ sky130_fd_sc_hd__buf_6
X_0923_ net38 _0753_ VSS VSS VDD VDD _0758_ sky130_fd_sc_hd__nor2b_1
X_0924_ net37 net36 VSS VSS VDD VDD _0759_ sky130_fd_sc_hd__nor2_1
X_0925_ net40 net51 _0759_ VSS VSS VDD VDD _0760_ sky130_fd_sc_hd__o21a_1
X_0926_ _0752_ net72 _0758_ _0760_ VSS VSS VDD VDD _0761_
+ sky130_fd_sc_hd__and4_1
X_0927_ _0761_ VSS VSS VDD VDD _0762_ sky130_fd_sc_hd__buf_2
X_0928_ _0762_ VSS VSS VDD VDD _0763_ sky130_fd_sc_hd__clkbuf_8
X_0929_ _0763_ VSS VSS VDD VDD _0764_ sky130_fd_sc_hd__buf_4
X_0930_ wr_ptr\[2\] net73 VSS VSS VDD VDD _0765_ sky130_fd_sc_hd__nand2b_4
X_0931_ wr_ptr\[3\] VSS VSS VDD VDD _0766_ sky130_fd_sc_hd__buf_2
X_0932_ _0766_ _0897_ VSS VSS VDD VDD _0767_ sky130_fd_sc_hd__nand2_2
X_0933_ _0757_ _0764_ _0765_ _0767_ VSS VSS VDD VDD _0007_
+ sky130_fd_sc_hd__nor4_4
X_0934_ net73 wr_ptr\[2\] VSS VSS VDD VDD _0768_ sky130_fd_sc_hd__nand2_4
X_0935_ _0757_ _0764_ _0767_ _0768_ VSS VSS VDD VDD _0003_
+ sky130_fd_sc_hd__nor4_4
X_0936_ _0766_ _0756_ _0762_ _0765_ VSS VSS VDD VDD _0769_
+ sky130_fd_sc_hd__nor4_2
X_0937_ _0903_ _0769_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__and2_4
X_0938_ _0766_ _0903_ VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__nand2_2
X_0939_ _0757_ _0763_ _0765_ _0770_ VSS VSS VDD VDD _0004_
+ sky130_fd_sc_hd__nor4_4
X_0940_ _0766_ _0756_ _0762_ _0768_ VSS VSS VDD VDD _0771_
+ sky130_fd_sc_hd__nor4_2
X_0941_ _0897_ _0771_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__and2_4
X_0942_ _0766_ _0899_ VSS VSS VDD VDD _0772_ sky130_fd_sc_hd__nand2_1
X_0943_ _0757_ _0763_ _0765_ _0772_ VSS VSS VDD VDD _0005_
+ sky130_fd_sc_hd__nor4_4
X_0944_ _0901_ _0771_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__and2_4
X_0945_ _0766_ _0901_ VSS VSS VDD VDD _0773_ sky130_fd_sc_hd__nand2_2
X_0946_ _0757_ _0763_ _0765_ _0773_ VSS VSS VDD VDD _0006_
+ sky130_fd_sc_hd__nor4_4
X_0947_ _0899_ _0771_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__and2_4
X_0948_ _0757_ _0763_ _0768_ _0773_ VSS VSS VDD VDD _0002_
+ sky130_fd_sc_hd__nor4_4
X_0949_ _0903_ _0771_ VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__and2_4
X_0950_ _0886_ _0874_ VSS VSS VDD VDD _0774_ sky130_fd_sc_hd__xor2_2
X_0951_ _0875_ _0774_ _0878_ VSS VSS VDD VDD _0775_ sky130_fd_sc_hd__nor3b_4
X_0952_ _0883_ _0750_ VSS VSS VDD VDD _0776_ sky130_fd_sc_hd__xnor2_4
X_0953_ _0744_ _0775_ _0776_ VSS VSS VDD VDD _0777_ sky130_fd_sc_hd__nand3_2
X_0954_ _0777_ VSS VSS VDD VDD net74 sky130_fd_sc_hd__inv_1
X_0955_ _0897_ _0769_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__and2_4
X_0956_ _0757_ _0763_ _0768_ _0770_ VSS VSS VDD VDD _0000_
+ sky130_fd_sc_hd__nor4_4
X_0957_ _0757_ _0763_ _0768_ _0772_ VSS VSS VDD VDD _0001_
+ sky130_fd_sc_hd__nor4_2
X_0958_ _0901_ _0769_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__and2_4
X_0959_ _0899_ _0769_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__and2_4
X_0960_ _0752_ VSS VSS VDD VDD _0778_ sky130_fd_sc_hd__buf_8
X_0961_ net33 net70 _0778_ VSS VSS VDD VDD _0046_ sky130_fd_sc_hd__mux2_4
X_0962_ net34 net71 _0778_ VSS VSS VDD VDD _0047_ sky130_fd_sc_hd__mux2_4
X_0963_ net4 net41 _0778_ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__mux2_4
X_0964_ net5 net42 _0778_ VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__mux2_4
X_0965_ net6 net43 _0778_ VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__mux2_8
X_0966_ net7 net44 _0778_ VSS VSS VDD VDD _0020_ sky130_fd_sc_hd__mux2_8
X_0967_ net8 net45 _0778_ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__mux2_4
X_0968_ net9 net46 _0778_ VSS VSS VDD VDD _0022_ sky130_fd_sc_hd__mux2_8
X_0969_ net10 net47 _0778_ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__mux2_4
X_0970_ net11 net48 _0778_ VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__mux2_4
X_0971_ _0752_ VSS VSS VDD VDD _0779_ sky130_fd_sc_hd__buf_16
X_0972_ net12 net49 _0779_ VSS VSS VDD VDD _0025_ sky130_fd_sc_hd__mux2_4
X_0973_ net13 net50 _0779_ VSS VSS VDD VDD _0026_ sky130_fd_sc_hd__mux2_4
X_0974_ net15 net52 _0779_ VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__mux2_8
X_0975_ net16 net53 _0779_ VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__mux2_4
X_0976_ net17 net54 _0779_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__mux2_8
X_0977_ net18 net55 _0779_ VSS VSS VDD VDD _0031_ sky130_fd_sc_hd__mux2_4
X_0978_ net19 net56 _0779_ VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__mux2_8
X_0979_ net20 net57 _0779_ VSS VSS VDD VDD _0033_ sky130_fd_sc_hd__mux2_4
X_0980_ net21 net58 _0779_ VSS VSS VDD VDD _0034_ sky130_fd_sc_hd__mux2_4
X_0981_ net22 net59 _0779_ VSS VSS VDD VDD _0035_ sky130_fd_sc_hd__mux2_8
X_0982_ _0752_ VSS VSS VDD VDD _0780_ sky130_fd_sc_hd__buf_16
X_0983_ net23 net60 _0780_ VSS VSS VDD VDD _0036_ sky130_fd_sc_hd__mux2_4
X_0984_ net24 net61 _0780_ VSS VSS VDD VDD _0037_ sky130_fd_sc_hd__mux2_4
X_0985_ net26 net63 _0780_ VSS VSS VDD VDD _0039_ sky130_fd_sc_hd__mux2_4
X_0986_ net27 net64 _0780_ VSS VSS VDD VDD _0040_ sky130_fd_sc_hd__mux2_8
X_0987_ net3 net40 _0780_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__mux2_8
X_0988_ net14 net51 _0780_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__mux2_8
X_0989_ net25 net62 _0780_ VSS VSS VDD VDD _0038_ sky130_fd_sc_hd__mux2_8
X_0990_ net28 net65 _0780_ VSS VSS VDD VDD _0041_ sky130_fd_sc_hd__mux2_4
X_0991_ net29 net66 _0780_ VSS VSS VDD VDD _0042_ sky130_fd_sc_hd__mux2_4
X_0992_ net30 net67 _0780_ VSS VSS VDD VDD _0043_ sky130_fd_sc_hd__mux2_8
X_0993_ net31 net68 _0752_ VSS VSS VDD VDD _0044_ sky130_fd_sc_hd__mux2_4
X_0994_ net32 net69 _0752_ VSS VSS VDD VDD _0045_ sky130_fd_sc_hd__mux2_4
X_0995_ _0877_ VSS VSS VDD VDD _0873_ sky130_fd_sc_hd__inv_1
X_0996_ rd_ptr\[3\] VSS VSS VDD VDD _0781_ sky130_fd_sc_hd__buf_4
X_0997_ _0781_ VSS VSS VDD VDD _0782_ sky130_fd_sc_hd__inv_1
X_0998_ _0782_ VSS VSS VDD VDD _0783_ sky130_fd_sc_hd__buf_6
X_0999_ _0783_ VSS VSS VDD VDD _0881_ sky130_fd_sc_hd__buf_6
X_1000_ rd_ptr\[2\] VSS VSS VDD VDD _0784_ sky130_fd_sc_hd__buf_6
X_1001_ _0784_ VSS VSS VDD VDD _0785_ sky130_fd_sc_hd__clkinv_4
X_1002_ _0785_ VSS VSS VDD VDD _0884_ sky130_fd_sc_hd__buf_6
X_1003_ rd_ptr\[0\] VSS VSS VDD VDD _0887_ sky130_fd_sc_hd__inv_1
X_1004_ wr_ptr\[0\] VSS VSS VDD VDD _0876_ sky130_fd_sc_hd__inv_1
X_1005_ rd_ptr\[1\] VSS VSS VDD VDD _0872_ sky130_fd_sc_hd__clkinvlp_4
X_1006_ wr_ptr\[1\] VSS VSS VDD VDD _0896_ sky130_fd_sc_hd__inv_1
X_1007_ net72 _0752_ VSS VSS VDD VDD _0786_ sky130_fd_sc_hd__nor2b_2
X_1008_ _0754_ _0786_ net2 VSS VSS VDD VDD _0787_ sky130_fd_sc_hd__a21oi_1
X_1009_ _0744_ _0775_ _0776_ _0787_ VSS VSS VDD VDD _0788_
+ sky130_fd_sc_hd__a31oi_4
X_1010_ _0762_ _0788_ VSS VSS VDD VDD _0789_ sky130_fd_sc_hd__nor2_4
X_1011_ _0789_ VSS VSS VDD VDD _0790_ sky130_fd_sc_hd__buf_4
X_1012_ _0752_ net72 _0758_ _0760_ VSS VSS VDD VDD _0791_
+ sky130_fd_sc_hd__nand4_4
X_1013_ _0791_ _0788_ VSS VSS VDD VDD _0792_ sky130_fd_sc_hd__and2_0
X_1014_ _0792_ VSS VSS VDD VDD _0793_ sky130_fd_sc_hd__clkbuf_4
X_1015_ _0793_ VSS VSS VDD VDD _0794_ sky130_fd_sc_hd__buf_6
X_1016_ _0894_ VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__buf_4
X_1017_ _0795_ VSS VSS VDD VDD _0796_ sky130_fd_sc_hd__buf_6
X_1018_ _0892_ VSS VSS VDD VDD _0797_ sky130_fd_sc_hd__buf_2
X_1019_ _0797_ VSS VSS VDD VDD _0798_ sky130_fd_sc_hd__buf_4
X_1020_ _0781_ rd_ptr\[2\] VSS VSS VDD VDD _0799_ sky130_fd_sc_hd__nand2b_1
X_1021_ _0796_ mem\[7\]\[0\] mem\[5\]\[0\] _0798_ _0799_ VSS
+ VSS VDD VDD _0800_ sky130_fd_sc_hd__a221oi_1
X_1022_ _0888_ VSS VSS VDD VDD _0801_ sky130_fd_sc_hd__buf_6
X_1023_ _0801_ VSS VSS VDD VDD _0802_ sky130_fd_sc_hd__buf_6
X_1024_ _0890_ VSS VSS VDD VDD _0803_ sky130_fd_sc_hd__buf_4
X_1025_ _0803_ VSS VSS VDD VDD _0804_ sky130_fd_sc_hd__buf_6
X_1026_ mem\[4\]\[0\] _0802_ _0804_ mem\[6\]\[0\] VSS VSS
+ VDD VDD _0805_ sky130_fd_sc_hd__a22oi_1
X_1027_ _0781_ VSS VSS VDD VDD _0806_ sky130_fd_sc_hd__buf_6
X_1028_ _0894_ mem\[11\]\[0\] mem\[10\]\[0\] _0890_ _0797_
+ mem\[9\]\[0\] VSS VSS VDD VDD _0807_ sky130_fd_sc_hd__a222oi_1
X_1029_ mem\[8\]\[0\] _0801_ _0784_ VSS VSS VDD VDD _0808_
+ sky130_fd_sc_hd__a21oi_1
X_1030_ _0806_ _0807_ _0808_ VSS VSS VDD VDD _0809_ sky130_fd_sc_hd__and3_1
X_1031_ _0800_ _0805_ _0809_ VSS VSS VDD VDD _0810_ sky130_fd_sc_hd__a21oi_1
X_1032_ rd_ptr\[3\] rd_ptr\[2\] VSS VSS VDD VDD _0811_ sky130_fd_sc_hd__and2_0
X_1033_ _0811_ VSS VSS VDD VDD _0812_ sky130_fd_sc_hd__buf_4
X_1034_ _0796_ mem\[15\]\[0\] mem\[14\]\[0\] _0804_ VSS VSS
+ VDD VDD _0813_ sky130_fd_sc_hd__a22oi_1
X_1035_ _0797_ VSS VSS VDD VDD _0814_ sky130_fd_sc_hd__buf_6
X_1036_ mem\[12\]\[0\] _0802_ _0814_ mem\[13\]\[0\] VSS VSS
+ VDD VDD _0815_ sky130_fd_sc_hd__a22oi_1
X_1037_ _0812_ _0813_ _0815_ VSS VSS VDD VDD _0816_ sky130_fd_sc_hd__nand3_1
X_1038_ _0803_ VSS VSS VDD VDD _0817_ sky130_fd_sc_hd__buf_4
X_1039_ _0796_ mem\[3\]\[0\] mem\[2\]\[0\] _0817_ VSS VSS
+ VDD VDD _0818_ sky130_fd_sc_hd__a22oi_1
X_1040_ _0781_ _0784_ VSS VSS VDD VDD _0819_ sky130_fd_sc_hd__nor2_2
X_1041_ _0797_ VSS VSS VDD VDD _0820_ sky130_fd_sc_hd__buf_4
X_1042_ mem\[1\]\[0\] _0820_ VSS VSS VDD VDD _0821_ sky130_fd_sc_hd__nand2_1
X_1043_ _0818_ _0819_ _0821_ VSS VSS VDD VDD _0822_ sky130_fd_sc_hd__nand3_1
X_1044_ rd_ptr\[3\] rd_ptr\[2\] VSS VSS VDD VDD _0823_ sky130_fd_sc_hd__or2_4
X_1045_ _0888_ _0823_ _0890_ _0894_ _0797_ VSS VSS VDD VDD
+ _0824_ sky130_fd_sc_hd__a2111oi_4
X_1046_ _0810_ _0816_ _0822_ _0824_ mem\[0\]\[0\] VSS VSS
+ VDD VDD _0825_ sky130_fd_sc_hd__a32o_1
X_1047_ net76 _0790_ _0794_ _0825_ VSS VSS VDD VDD _0048_
+ sky130_fd_sc_hd__a22o_1
X_1048_ _0791_ VSS VSS VDD VDD _0826_ sky130_fd_sc_hd__buf_4
X_1049_ _0788_ VSS VSS VDD VDD _0827_ sky130_fd_sc_hd__buf_6
X_1050_ _0826_ _0827_ VSS VSS VDD VDD _0828_ sky130_fd_sc_hd__nand2_1
X_1051_ _0888_ _0823_ _0803_ _0795_ _0797_ VSS VSS VDD VDD
+ _0829_ sky130_fd_sc_hd__a2111o_4
X_1052_ _0829_ VSS VSS VDD VDD _0830_ sky130_fd_sc_hd__buf_8
X_1053_ _0830_ VSS VSS VDD VDD _0831_ sky130_fd_sc_hd__buf_8
X_1054_ _0806_ VSS VSS VDD VDD _0832_ sky130_fd_sc_hd__buf_4
X_1055_ _0832_ VSS VSS VDD VDD _0833_ sky130_fd_sc_hd__buf_6
X_1056_ rd_ptr\[2\] VSS VSS VDD VDD _0834_ sky130_fd_sc_hd__buf_4
X_1057_ _0834_ VSS VSS VDD VDD _0835_ sky130_fd_sc_hd__buf_8
X_1058_ _0835_ VSS VSS VDD VDD _0836_ sky130_fd_sc_hd__buf_6
X_1059_ _0801_ VSS VSS VDD VDD _0837_ sky130_fd_sc_hd__buf_6
X_1060_ _0837_ VSS VSS VDD VDD _0838_ sky130_fd_sc_hd__buf_8
X_1061_ _0784_ VSS VSS VDD VDD _0839_ sky130_fd_sc_hd__buf_8
X_1062_ _0839_ VSS VSS VDD VDD _0840_ sky130_fd_sc_hd__buf_6
X_1063_ _0795_ VSS VSS VDD VDD _0841_ sky130_fd_sc_hd__buf_8
X_1064_ _0801_ VSS VSS VDD VDD _0842_ sky130_fd_sc_hd__buf_6
X_1065_ _0841_ mem\[11\]\[10\] mem\[8\]\[10\] _0842_ VSS VSS
+ VDD VDD _0843_ sky130_fd_sc_hd__a22oi_1
X_1066_ _0840_ _0843_ VSS VSS VDD VDD _0844_ sky130_fd_sc_hd__nor2_1
X_1067_ _0836_ mem\[12\]\[10\] _0838_ _0844_ VSS VSS VDD VDD
+ _0845_ sky130_fd_sc_hd__a31oi_1
X_1068_ rd_ptr\[2\] _0894_ VSS VSS VDD VDD _0846_ sky130_fd_sc_hd__nor2b_1
X_1069_ _0846_ VSS VSS VDD VDD _0847_ sky130_fd_sc_hd__buf_4
X_1070_ _0785_ VSS VSS VDD VDD _0848_ sky130_fd_sc_hd__buf_4
X_1071_ _0795_ VSS VSS VDD VDD _0849_ sky130_fd_sc_hd__buf_6
X_1072_ _0801_ VSS VSS VDD VDD _0850_ sky130_fd_sc_hd__buf_8
X_1073_ _0803_ VSS VSS VDD VDD _0851_ sky130_fd_sc_hd__buf_6
X_1074_ _0849_ mem\[7\]\[10\] mem\[4\]\[10\] _0850_ _0851_
+ mem\[6\]\[10\] VSS VSS VDD VDD _0852_ sky130_fd_sc_hd__a222oi_1
X_1075_ _0848_ _0852_ VSS VSS VDD VDD _0853_ sky130_fd_sc_hd__nor2_1
X_1076_ mem\[3\]\[10\] _0847_ _0853_ _0833_ VSS VSS VDD VDD
+ _0854_ sky130_fd_sc_hd__a211oi_1
X_1077_ _0833_ _0845_ _0854_ VSS VSS VDD VDD _0855_ sky130_fd_sc_hd__a21oi_1
X_1078_ _0781_ _0784_ VSS VSS VDD VDD _0856_ sky130_fd_sc_hd__nand2_1
X_1079_ _0856_ VSS VSS VDD VDD _0857_ sky130_fd_sc_hd__buf_8
X_1080_ _0849_ VSS VSS VDD VDD _0858_ sky130_fd_sc_hd__buf_4
X_1081_ _0803_ VSS VSS VDD VDD _0859_ sky130_fd_sc_hd__buf_6
X_1082_ _0859_ VSS VSS VDD VDD _0860_ sky130_fd_sc_hd__buf_6
X_1083_ _0858_ mem\[15\]\[10\] mem\[14\]\[10\] _0860_ VSS
+ VSS VDD VDD _0861_ sky130_fd_sc_hd__a22oi_1
X_1084_ _0798_ VSS VSS VDD VDD _0862_ sky130_fd_sc_hd__buf_6
X_1085_ _0862_ VSS VSS VDD VDD _0863_ sky130_fd_sc_hd__buf_8
X_1086_ rd_ptr\[3\] rd_ptr\[2\] VSS VSS VDD VDD _0864_ sky130_fd_sc_hd__nor2b_1
X_1087_ _0864_ VSS VSS VDD VDD _0865_ sky130_fd_sc_hd__buf_8
X_1088_ _0865_ VSS VSS VDD VDD _0866_ sky130_fd_sc_hd__buf_8
X_1089_ _0834_ VSS VSS VDD VDD _0867_ sky130_fd_sc_hd__buf_8
X_1090_ mem\[9\]\[10\] mem\[13\]\[10\] _0867_ VSS VSS VDD
+ VDD _0868_ sky130_fd_sc_hd__mux2i_1
X_1091_ _0782_ VSS VSS VDD VDD _0869_ sky130_fd_sc_hd__buf_6
X_1092_ mem\[5\]\[10\] _0866_ _0868_ _0869_ VSS VSS VDD VDD
+ _0870_ sky130_fd_sc_hd__o2bb2ai_1
X_1093_ _0863_ _0870_ VSS VSS VDD VDD _0871_ sky130_fd_sc_hd__nand2_1
X_1094_ _0781_ VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__buf_6
X_1095_ _0122_ VSS VSS VDD VDD _0123_ sky130_fd_sc_hd__buf_6
X_1096_ _0804_ VSS VSS VDD VDD _0124_ sky130_fd_sc_hd__buf_6
X_1097_ mem\[2\]\[10\] _0124_ _0862_ mem\[1\]\[10\] VSS VSS
+ VDD VDD _0125_ sky130_fd_sc_hd__a22oi_1
X_1098_ _0123_ mem\[10\]\[10\] _0860_ VSS VSS VDD VDD _0126_
+ sky130_fd_sc_hd__nand3_1
X_1099_ _0123_ _0125_ _0126_ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__o21ai_0
X_1100_ _0884_ _0127_ VSS VSS VDD VDD _0128_ sky130_fd_sc_hd__nand2_1
X_1101_ _0830_ VSS VSS VDD VDD _0129_ sky130_fd_sc_hd__buf_8
X_1102_ _0857_ _0861_ _0871_ _0128_ _0129_ VSS VSS VDD VDD
+ _0130_ sky130_fd_sc_hd__o2111ai_2
X_1103_ mem\[0\]\[10\] _0831_ _0855_ _0130_ VSS VSS VDD VDD
+ _0131_ sky130_fd_sc_hd__o22ai_4
X_1104_ net77 _0790_ _0828_ _0131_ VSS VSS VDD VDD _0049_
+ sky130_fd_sc_hd__o2bb2ai_1
X_1105_ _0824_ VSS VSS VDD VDD _0132_ sky130_fd_sc_hd__buf_8
X_1106_ _0806_ VSS VSS VDD VDD _0133_ sky130_fd_sc_hd__buf_8
X_1107_ _0801_ VSS VSS VDD VDD _0134_ sky130_fd_sc_hd__buf_6
X_1108_ _0867_ mem\[4\]\[11\] _0134_ _0847_ mem\[3\]\[11\]
+ VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__a32oi_1
X_1109_ _0795_ VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__buf_8
X_1110_ _0798_ VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__buf_6
X_1111_ _0136_ mem\[15\]\[11\] mem\[12\]\[11\] _0850_ _0137_
+ mem\[13\]\[11\] VSS VSS VDD VDD _0138_ sky130_fd_sc_hd__a222oi_1
X_1112_ _0133_ _0135_ _0138_ _0857_ VSS VSS VDD VDD _0139_
+ sky130_fd_sc_hd__o22ai_1
X_1113_ _0798_ VSS VSS VDD VDD _0140_ sky130_fd_sc_hd__buf_6
X_1114_ _0781_ mem\[14\]\[11\] _0803_ VSS VSS VDD VDD _0141_
+ sky130_fd_sc_hd__and3_1
X_1115_ _0782_ mem\[5\]\[11\] _0140_ _0141_ VSS VSS VDD VDD
+ _0142_ sky130_fd_sc_hd__a31oi_2
X_1116_ _0803_ VSS VSS VDD VDD _0143_ sky130_fd_sc_hd__buf_6
X_1117_ rd_ptr\[2\] rd_ptr\[3\] VSS VSS VDD VDD _0144_ sky130_fd_sc_hd__nand2b_1
X_1118_ _0144_ VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__buf_8
X_1119_ mem\[8\]\[11\] _0850_ _0143_ mem\[10\]\[11\] _0145_
+ VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__a221oi_1
X_1120_ mem\[2\]\[11\] _0143_ _0137_ mem\[1\]\[11\] _0823_
+ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__a221oi_1
X_1121_ _0840_ _0142_ _0146_ _0147_ VSS VSS VDD VDD _0148_
+ sky130_fd_sc_hd__a211oi_1
X_1122_ _0796_ VSS VSS VDD VDD _0149_ sky130_fd_sc_hd__buf_6
X_1123_ _0798_ VSS VSS VDD VDD _0150_ sky130_fd_sc_hd__buf_6
X_1124_ _0149_ mem\[11\]\[11\] mem\[9\]\[11\] _0150_ VSS VSS
+ VDD VDD _0151_ sky130_fd_sc_hd__a22oi_1
X_1125_ _0817_ VSS VSS VDD VDD _0152_ sky130_fd_sc_hd__buf_4
X_1126_ _0858_ mem\[7\]\[11\] mem\[6\]\[11\] _0152_ VSS VSS
+ VDD VDD _0153_ sky130_fd_sc_hd__a22oi_1
X_1127_ _0799_ VSS VSS VDD VDD _0154_ sky130_fd_sc_hd__buf_8
X_1128_ _0145_ _0151_ _0153_ _0154_ VSS VSS VDD VDD _0155_
+ sky130_fd_sc_hd__o22ai_1
X_1129_ _0132_ _0139_ _0148_ _0155_ VSS VSS VDD VDD _0156_
+ sky130_fd_sc_hd__nor4_1
X_1130_ _0830_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__buf_16
X_1131_ mem\[0\]\[11\] _0157_ VSS VSS VDD VDD _0158_ sky130_fd_sc_hd__nor2_1
X_1132_ _0156_ _0158_ VSS VSS VDD VDD _0159_ sky130_fd_sc_hd__nor2_2
X_1133_ net78 _0790_ _0794_ _0159_ VSS VSS VDD VDD _0050_
+ sky130_fd_sc_hd__a22o_1
X_1134_ _0784_ _0781_ VSS VSS VDD VDD _0160_ sky130_fd_sc_hd__nor2b_4
X_1135_ mem\[9\]\[12\] _0160_ _0866_ mem\[5\]\[12\] VSS VSS
+ VDD VDD _0161_ sky130_fd_sc_hd__a22o_1
X_1136_ _0122_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__buf_6
X_1137_ _0804_ VSS VSS VDD VDD _0163_ sky130_fd_sc_hd__buf_8
X_1138_ _0835_ mem\[6\]\[12\] _0163_ _0847_ mem\[3\]\[12\]
+ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__a32oi_1
X_1139_ _0785_ _0851_ VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__nand2_8
X_1140_ _0806_ VSS VSS VDD VDD _0166_ sky130_fd_sc_hd__buf_8
X_1141_ mem\[2\]\[12\] mem\[10\]\[12\] _0166_ VSS VSS VDD
+ VDD _0167_ sky130_fd_sc_hd__mux2i_1
X_1142_ mem\[4\]\[12\] _0838_ _0866_ VSS VSS VDD VDD _0168_
+ sky130_fd_sc_hd__nand3_1
X_1143_ _0162_ _0164_ _0165_ _0167_ _0168_ VSS VSS VDD VDD
+ _0169_ sky130_fd_sc_hd__o221ai_2
X_1144_ _0863_ _0161_ _0169_ VSS VSS VDD VDD _0170_ sky130_fd_sc_hd__a21oi_1
X_1145_ _0819_ VSS VSS VDD VDD _0171_ sky130_fd_sc_hd__buf_6
X_1146_ mem\[1\]\[12\] _0150_ _0171_ VSS VSS VDD VDD _0172_
+ sky130_fd_sc_hd__nand3_1
X_1147_ _0802_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__buf_4
X_1148_ _0160_ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__buf_6
X_1149_ mem\[8\]\[12\] _0173_ _0174_ VSS VSS VDD VDD _0175_
+ sky130_fd_sc_hd__nand3_1
X_1150_ _0172_ _0175_ VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__nand2_1
X_1151_ _0858_ mem\[7\]\[12\] _0866_ VSS VSS VDD VDD _0177_
+ sky130_fd_sc_hd__nand3_1
X_1152_ _0812_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__buf_6
X_1153_ mem\[13\]\[12\] _0150_ _0178_ VSS VSS VDD VDD _0179_
+ sky130_fd_sc_hd__nand3_1
X_1154_ _0177_ _0179_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__nand2_1
X_1155_ _0801_ VSS VSS VDD VDD _0181_ sky130_fd_sc_hd__buf_8
X_1156_ _0804_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__buf_6
X_1157_ mem\[12\]\[12\] _0181_ _0182_ mem\[14\]\[12\] VSS
+ VSS VDD VDD _0183_ sky130_fd_sc_hd__a22oi_1
X_1158_ _0133_ _0858_ VSS VSS VDD VDD _0184_ sky130_fd_sc_hd__nand2_1
X_1159_ mem\[11\]\[12\] mem\[15\]\[12\] _0835_ VSS VSS VDD
+ VDD _0185_ sky130_fd_sc_hd__mux2i_1
X_1160_ _0857_ _0183_ _0184_ _0185_ VSS VSS VDD VDD _0186_
+ sky130_fd_sc_hd__o22ai_1
X_1161_ _0132_ _0176_ _0180_ _0186_ VSS VSS VDD VDD _0187_
+ sky130_fd_sc_hd__nor4_1
X_1162_ mem\[0\]\[12\] _0129_ VSS VSS VDD VDD _0188_ sky130_fd_sc_hd__nor2_1
X_1163_ _0170_ _0187_ _0188_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__a21oi_1
X_1164_ net79 _0790_ _0794_ _0189_ VSS VSS VDD VDD _0051_
+ sky130_fd_sc_hd__a22o_1
X_1165_ mem\[14\]\[13\] _0859_ _0137_ mem\[13\]\[13\] mem\[12\]\[13\]
+ _0181_ VSS VSS VDD VDD _0190_ sky130_fd_sc_hd__a222oi_1
X_1166_ _0848_ mem\[8\]\[13\] _0173_ VSS VSS VDD VDD _0191_
+ sky130_fd_sc_hd__nand3_1
X_1167_ _0848_ _0190_ _0191_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__o21ai_0
X_1168_ _0814_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__buf_8
X_1169_ mem\[6\]\[13\] _0182_ _0193_ mem\[5\]\[13\] VSS VSS
+ VDD VDD _0194_ sky130_fd_sc_hd__a22oi_1
X_1170_ _0154_ _0194_ _0830_ VSS VSS VDD VDD _0195_ sky130_fd_sc_hd__o21ai_0
X_1171_ _0833_ _0192_ _0195_ VSS VSS VDD VDD _0196_ sky130_fd_sc_hd__a21oi_1
X_1172_ _0839_ VSS VSS VDD VDD _0197_ sky130_fd_sc_hd__buf_6
X_1173_ _0197_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__clkbuf_8
X_1174_ _0781_ VSS VSS VDD VDD _0199_ sky130_fd_sc_hd__buf_6
X_1175_ _0199_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__clkbuf_8
X_1176_ _0858_ mem\[15\]\[13\] VSS VSS VDD VDD _0201_ sky130_fd_sc_hd__nand2_1
X_1177_ _0841_ mem\[7\]\[13\] mem\[4\]\[13\] _0181_ _0832_
+ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__a221oi_1
X_1178_ _0200_ _0201_ _0202_ VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__a21oi_1
X_1179_ _0796_ mem\[11\]\[13\] mem\[10\]\[13\] _0804_ _0820_
+ mem\[9\]\[13\] VSS VSS VDD VDD _0204_ sky130_fd_sc_hd__a222oi_1
X_1180_ _0841_ mem\[3\]\[13\] mem\[2\]\[13\] _0124_ VSS VSS
+ VDD VDD _0205_ sky130_fd_sc_hd__a22oi_2
X_1181_ mem\[1\]\[13\] _0137_ _0166_ VSS VSS VDD VDD _0206_
+ sky130_fd_sc_hd__a21oi_1
X_1182_ _0834_ VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__buf_16
X_1183_ _0207_ VSS VSS VDD VDD _0208_ sky130_fd_sc_hd__buf_6
X_1184_ _0133_ _0204_ _0205_ _0206_ _0208_ VSS VSS VDD VDD
+ _0209_ sky130_fd_sc_hd__a221oi_4
X_1185_ _0198_ _0203_ _0209_ VSS VSS VDD VDD _0210_ sky130_fd_sc_hd__a21oi_1
X_1186_ mem\[0\]\[13\] _0129_ VSS VSS VDD VDD _0211_ sky130_fd_sc_hd__nor2_1
X_1187_ _0196_ _0210_ _0211_ VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__a21oi_4
X_1188_ net80 _0790_ _0794_ _0212_ VSS VSS VDD VDD _0052_
+ sky130_fd_sc_hd__a22o_1
X_1189_ mem\[0\]\[14\] _0830_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__nor2_1
X_1190_ mem\[9\]\[14\] mem\[13\]\[14\] _0839_ VSS VSS VDD
+ VDD _0214_ sky130_fd_sc_hd__mux2i_1
X_1191_ mem\[5\]\[14\] _0865_ VSS VSS VDD VDD _0215_ sky130_fd_sc_hd__nand2_1
X_1192_ _0783_ _0214_ _0215_ VSS VSS VDD VDD _0216_ sky130_fd_sc_hd__o21ai_0
X_1193_ mem\[15\]\[14\] _0812_ _0171_ mem\[3\]\[14\] VSS VSS
+ VDD VDD _0217_ sky130_fd_sc_hd__a22o_1
X_1194_ _0841_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__buf_6
X_1195_ _0193_ _0216_ _0217_ _0218_ _0132_ VSS VSS VDD VDD
+ _0219_ sky130_fd_sc_hd__a221oi_1
X_1196_ mem\[12\]\[14\] _0842_ _0152_ mem\[14\]\[14\] _0783_
+ VSS VSS VDD VDD _0220_ sky130_fd_sc_hd__a221o_1
X_1197_ mem\[4\]\[14\] _0173_ _0123_ VSS VSS VDD VDD _0221_
+ sky130_fd_sc_hd__a21oi_1
X_1198_ _0858_ mem\[7\]\[14\] mem\[6\]\[14\] _0152_ VSS VSS
+ VDD VDD _0222_ sky130_fd_sc_hd__a22oi_1
X_1199_ _0221_ _0222_ _0884_ VSS VSS VDD VDD _0223_ sky130_fd_sc_hd__a21oi_1
X_1200_ _0795_ VSS VSS VDD VDD _0224_ sky130_fd_sc_hd__buf_4
X_1201_ _0224_ mem\[11\]\[14\] mem\[8\]\[14\] _0837_ _0182_
+ mem\[10\]\[14\] VSS VSS VDD VDD _0225_ sky130_fd_sc_hd__a222oi_1
X_1202_ _0798_ VSS VSS VDD VDD _0226_ sky130_fd_sc_hd__buf_6
X_1203_ mem\[2\]\[14\] _0163_ _0226_ mem\[1\]\[14\] _0832_
+ VSS VSS VDD VDD _0227_ sky130_fd_sc_hd__a221oi_1
X_1204_ _0200_ _0225_ _0227_ _0198_ VSS VSS VDD VDD _0228_
+ sky130_fd_sc_hd__a211oi_1
X_1205_ _0220_ _0223_ _0228_ VSS VSS VDD VDD _0229_ sky130_fd_sc_hd__a21oi_1
X_1206_ _0213_ _0219_ _0229_ VSS VSS VDD VDD _0230_ sky130_fd_sc_hd__o21ai_2
X_1207_ net81 _0790_ _0794_ _0230_ VSS VSS VDD VDD _0053_
+ sky130_fd_sc_hd__a22o_1
X_1208_ _0827_ VSS VSS VDD VDD _0231_ sky130_fd_sc_hd__clkbuf_4
X_1209_ net82 _0826_ VSS VSS VDD VDD _0232_ sky130_fd_sc_hd__nand2_1
X_1210_ mem\[14\]\[15\] _0124_ _0862_ mem\[13\]\[15\] VSS
+ VSS VDD VDD _0233_ sky130_fd_sc_hd__a22oi_1
X_1211_ _0839_ VSS VSS VDD VDD _0234_ sky130_fd_sc_hd__buf_6
X_1212_ _0858_ mem\[11\]\[15\] _0234_ VSS VSS VDD VDD _0235_
+ sky130_fd_sc_hd__a21oi_1
X_1213_ _0836_ _0233_ _0235_ _0881_ VSS VSS VDD VDD _0236_
+ sky130_fd_sc_hd__a211oi_1
X_1214_ _0132_ _0236_ VSS VSS VDD VDD _0237_ sky130_fd_sc_hd__nor2_1
X_1215_ mem\[2\]\[15\] _0152_ VSS VSS VDD VDD _0238_ sky130_fd_sc_hd__nand2_1
X_1216_ _0133_ mem\[8\]\[15\] _0173_ VSS VSS VDD VDD _0239_
+ sky130_fd_sc_hd__nand3_1
X_1217_ _0123_ _0238_ _0239_ VSS VSS VDD VDD _0240_ sky130_fd_sc_hd__o21ai_0
X_1218_ _0218_ mem\[7\]\[15\] _0866_ _0240_ _0884_ VSS VSS
+ VDD VDD _0241_ sky130_fd_sc_hd__a32oi_1
X_1219_ rd_ptr\[3\] _0894_ VSS VSS VDD VDD _0242_ sky130_fd_sc_hd__nor2b_1
X_1220_ _0242_ VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__buf_6
X_1221_ _0122_ mem\[10\]\[15\] _0143_ _0243_ mem\[3\]\[15\]
+ VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__a32oi_1
X_1222_ _0801_ VSS VSS VDD VDD _0245_ sky130_fd_sc_hd__buf_6
X_1223_ mem\[4\]\[15\] _0245_ _0851_ mem\[6\]\[15\] _0154_
+ VSS VSS VDD VDD _0246_ sky130_fd_sc_hd__a221oi_1
X_1224_ _0795_ VSS VSS VDD VDD _0247_ sky130_fd_sc_hd__buf_6
X_1225_ _0247_ mem\[15\]\[15\] mem\[12\]\[15\] _0134_ _0857_
+ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__a221oi_1
X_1226_ _0848_ _0244_ _0246_ _0248_ VSS VSS VDD VDD _0249_
+ sky130_fd_sc_hd__a211o_1
X_1227_ mem\[1\]\[15\] mem\[5\]\[15\] _0835_ VSS VSS VDD VDD
+ _0250_ sky130_fd_sc_hd__mux2i_1
X_1228_ _0162_ _0250_ VSS VSS VDD VDD _0251_ sky130_fd_sc_hd__nor2_1
X_1229_ mem\[9\]\[15\] _0174_ VSS VSS VDD VDD _0252_ sky130_fd_sc_hd__and2_0
X_1230_ _0251_ _0252_ _0863_ VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__o21ai_0
X_1231_ _0237_ _0241_ _0249_ _0253_ VSS VSS VDD VDD _0254_
+ sky130_fd_sc_hd__nand4_1
X_1232_ mem\[0\]\[15\] _0831_ _0254_ _0826_ _0231_ VSS VSS
+ VDD VDD _0255_ sky130_fd_sc_hd__o2111ai_1
X_1233_ _0231_ _0232_ _0255_ VSS VSS VDD VDD _0054_ sky130_fd_sc_hd__o21ai_0
X_1234_ _0136_ mem\[15\]\[16\] mem\[12\]\[16\] _0850_ _0851_
+ mem\[14\]\[16\] VSS VSS VDD VDD _0256_ sky130_fd_sc_hd__a222oi_1
X_1235_ _0208_ _0256_ VSS VSS VDD VDD _0257_ sky130_fd_sc_hd__nand2_1
X_1236_ _0224_ mem\[11\]\[16\] mem\[8\]\[16\] _0837_ VSS VSS
+ VDD VDD _0258_ sky130_fd_sc_hd__a22oi_1
X_1237_ mem\[10\]\[16\] _0143_ _0867_ VSS VSS VDD VDD _0259_
+ sky130_fd_sc_hd__a21oi_1
X_1238_ _0258_ _0259_ _0783_ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__a21oi_1
X_1239_ mem\[9\]\[16\] mem\[13\]\[16\] _0839_ VSS VSS VDD
+ VDD _0261_ sky130_fd_sc_hd__mux2i_1
X_1240_ mem\[5\]\[16\] _0865_ VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__nand2_1
X_1241_ _0783_ _0261_ _0262_ VSS VSS VDD VDD _0263_ sky130_fd_sc_hd__o21ai_0
X_1242_ _0796_ mem\[7\]\[16\] mem\[4\]\[16\] _0801_ _0817_
+ mem\[6\]\[16\] VSS VSS VDD VDD _0264_ sky130_fd_sc_hd__a222oi_1
X_1243_ _0136_ mem\[3\]\[16\] mem\[1\]\[16\] _0820_ VSS VSS
+ VDD VDD _0265_ sky130_fd_sc_hd__a22oi_1
X_1244_ mem\[2\]\[16\] _0143_ _0207_ VSS VSS VDD VDD _0266_
+ sky130_fd_sc_hd__a21oi_1
X_1245_ _0197_ _0264_ _0265_ _0266_ _0133_ VSS VSS VDD VDD
+ _0267_ sky130_fd_sc_hd__a221oi_2
X_1246_ _0257_ _0260_ _0263_ _0193_ _0267_ VSS VSS VDD VDD
+ _0268_ sky130_fd_sc_hd__a221oi_2
X_1247_ mem\[0\]\[16\] _0129_ VSS VSS VDD VDD _0269_ sky130_fd_sc_hd__nor2_1
X_1248_ _0831_ _0268_ _0269_ VSS VSS VDD VDD _0270_ sky130_fd_sc_hd__a21oi_4
X_1249_ net83 _0790_ _0794_ _0270_ VSS VSS VDD VDD _0055_
+ sky130_fd_sc_hd__a22o_1
X_1250_ mem\[8\]\[17\] _0134_ _0124_ mem\[10\]\[17\] VSS VSS
+ VDD VDD _0271_ sky130_fd_sc_hd__a22oi_1
X_1251_ _0834_ _0795_ VSS VSS VDD VDD _0272_ sky130_fd_sc_hd__and2_2
X_1252_ mem\[15\]\[17\] _0272_ VSS VSS VDD VDD _0273_ sky130_fd_sc_hd__nand2_1
X_1253_ _0234_ _0271_ _0273_ VSS VSS VDD VDD _0274_ sky130_fd_sc_hd__o21ai_0
X_1254_ _0234_ mem\[5\]\[17\] _0150_ VSS VSS VDD VDD _0275_
+ sky130_fd_sc_hd__nand3_1
X_1255_ _0785_ VSS VSS VDD VDD _0276_ sky130_fd_sc_hd__buf_4
X_1256_ _0276_ mem\[2\]\[17\] _0182_ VSS VSS VDD VDD _0277_
+ sky130_fd_sc_hd__nand3_1
X_1257_ _0275_ _0277_ _0200_ VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__a21oi_1
X_1258_ _0276_ _0150_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__nand2_1
X_1259_ mem\[1\]\[17\] mem\[9\]\[17\] _0199_ VSS VSS VDD VDD
+ _0280_ sky130_fd_sc_hd__mux2i_1
X_1260_ mem\[3\]\[17\] mem\[11\]\[17\] _0199_ VSS VSS VDD
+ VDD _0281_ sky130_fd_sc_hd__mux2i_1
X_1261_ _0276_ _0149_ VSS VSS VDD VDD _0282_ sky130_fd_sc_hd__nand2_1
X_1262_ _0279_ _0280_ _0281_ _0282_ VSS VSS VDD VDD _0283_
+ sky130_fd_sc_hd__o22ai_1
X_1263_ _0833_ _0274_ _0278_ _0283_ VSS VSS VDD VDD _0284_
+ sky130_fd_sc_hd__a211oi_2
X_1264_ mem\[14\]\[17\] _0163_ _0226_ mem\[13\]\[17\] mem\[12\]\[17\]
+ _0842_ VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__a222oi_1
X_1265_ _0833_ _0285_ VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__nand2_1
X_1266_ _0136_ mem\[7\]\[17\] mem\[4\]\[17\] _0245_ _0124_
+ mem\[6\]\[17\] VSS VSS VDD VDD _0287_ sky130_fd_sc_hd__a222oi_1
X_1267_ _0869_ _0287_ _0884_ VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__a21oi_1
X_1268_ _0286_ _0288_ _0132_ VSS VSS VDD VDD _0289_ sky130_fd_sc_hd__a21oi_1
X_1269_ mem\[0\]\[17\] _0129_ VSS VSS VDD VDD _0290_ sky130_fd_sc_hd__nor2_1
X_1270_ _0284_ _0289_ _0290_ VSS VSS VDD VDD _0291_ sky130_fd_sc_hd__a21oi_4
X_1271_ net84 _0790_ _0794_ _0291_ VSS VSS VDD VDD _0056_
+ sky130_fd_sc_hd__a22o_1
X_1272_ mem\[8\]\[18\] _0134_ _0163_ mem\[10\]\[18\] VSS VSS
+ VDD VDD _0292_ sky130_fd_sc_hd__a22oi_2
X_1273_ _0149_ mem\[3\]\[18\] _0832_ VSS VSS VDD VDD _0293_
+ sky130_fd_sc_hd__a21oi_1
X_1274_ _0123_ _0292_ _0293_ _0208_ VSS VSS VDD VDD _0294_
+ sky130_fd_sc_hd__a211oi_1
X_1275_ mem\[12\]\[18\] _0134_ _0226_ mem\[13\]\[18\] VSS
+ VSS VDD VDD _0295_ sky130_fd_sc_hd__a22oi_1
X_1276_ _0149_ mem\[11\]\[18\] _0197_ VSS VSS VDD VDD _0296_
+ sky130_fd_sc_hd__a21oi_1
X_1277_ _0208_ _0295_ _0296_ _0869_ VSS VSS VDD VDD _0297_
+ sky130_fd_sc_hd__a211oi_1
X_1278_ _0294_ _0297_ VSS VSS VDD VDD _0298_ sky130_fd_sc_hd__nor2_1
X_1279_ mem\[2\]\[18\] mem\[6\]\[18\] _0207_ VSS VSS VDD VDD
+ _0299_ sky130_fd_sc_hd__mux2i_2
X_1280_ mem\[14\]\[18\] _0178_ VSS VSS VDD VDD _0300_ sky130_fd_sc_hd__nand2_1
X_1281_ _0133_ _0299_ _0300_ VSS VSS VDD VDD _0301_ sky130_fd_sc_hd__o21ai_0
X_1282_ _0224_ mem\[7\]\[18\] mem\[4\]\[18\] _0245_ _0226_
+ mem\[5\]\[18\] VSS VSS VDD VDD _0302_ sky130_fd_sc_hd__a222oi_1
X_1283_ _0806_ _0834_ _0796_ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__and3_2
X_1284_ mem\[1\]\[18\] mem\[9\]\[18\] _0781_ VSS VSS VDD VDD
+ _0304_ sky130_fd_sc_hd__mux2_1
X_1285_ _0834_ _0798_ VSS VSS VDD VDD _0305_ sky130_fd_sc_hd__nor2b_2
X_1286_ mem\[15\]\[18\] _0303_ _0304_ _0305_ VSS VSS VDD VDD
+ _0306_ sky130_fd_sc_hd__a22oi_1
X_1287_ _0154_ _0302_ _0306_ VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__o21ai_0
X_1288_ _0860_ _0301_ _0307_ VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__a21oi_1
X_1289_ _0829_ VSS VSS VDD VDD _0309_ sky130_fd_sc_hd__buf_6
X_1290_ mem\[0\]\[18\] _0309_ VSS VSS VDD VDD _0310_ sky130_fd_sc_hd__nor2_1
X_1291_ _0157_ _0298_ _0308_ _0310_ VSS VSS VDD VDD _0311_
+ sky130_fd_sc_hd__a31oi_4
X_1292_ net85 _0790_ _0794_ _0311_ VSS VSS VDD VDD _0057_
+ sky130_fd_sc_hd__a22o_1
X_1293_ mem\[9\]\[19\] mem\[13\]\[19\] _0867_ VSS VSS VDD
+ VDD _0312_ sky130_fd_sc_hd__mux2i_1
X_1294_ mem\[5\]\[19\] _0866_ VSS VSS VDD VDD _0313_ sky130_fd_sc_hd__nand2_1
X_1295_ _0869_ _0312_ _0313_ VSS VSS VDD VDD _0314_ sky130_fd_sc_hd__o21ai_1
X_1296_ mem\[4\]\[19\] _0842_ _0152_ mem\[6\]\[19\] VSS VSS
+ VDD VDD _0315_ sky130_fd_sc_hd__a22oi_1
X_1297_ _0162_ mem\[12\]\[19\] _0173_ VSS VSS VDD VDD _0316_
+ sky130_fd_sc_hd__nand3_1
X_1298_ _0162_ _0315_ _0316_ VSS VSS VDD VDD _0317_ sky130_fd_sc_hd__o21ai_0
X_1299_ _0863_ _0314_ _0317_ _0198_ VSS VSS VDD VDD _0318_
+ sky130_fd_sc_hd__a22oi_1
X_1300_ mem\[15\]\[19\] _0812_ _0171_ mem\[3\]\[19\] VSS VSS
+ VDD VDD _0319_ sky130_fd_sc_hd__a22o_1
X_1301_ _0851_ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__clkinv_4
X_1302_ mem\[10\]\[19\] _0160_ _0812_ mem\[14\]\[19\] VSS
+ VSS VDD VDD _0321_ sky130_fd_sc_hd__a22oi_1
X_1303_ _0858_ mem\[7\]\[19\] _0865_ VSS VSS VDD VDD _0322_
+ sky130_fd_sc_hd__nand3_1
X_1304_ _0320_ _0321_ _0322_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__o21ai_0
X_1305_ mem\[2\]\[19\] _0851_ _0137_ mem\[1\]\[19\] VSS VSS
+ VDD VDD _0324_ sky130_fd_sc_hd__a22oi_1
X_1306_ _0247_ mem\[11\]\[19\] mem\[8\]\[19\] _0181_ VSS VSS
+ VDD VDD _0325_ sky130_fd_sc_hd__a22oi_1
X_1307_ _0823_ _0324_ _0325_ _0145_ _0829_ VSS VSS VDD VDD
+ _0326_ sky130_fd_sc_hd__o221ai_2
X_1308_ _0218_ _0319_ _0323_ _0326_ VSS VSS VDD VDD _0327_
+ sky130_fd_sc_hd__a211oi_1
X_1309_ mem\[0\]\[19\] _0129_ VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__nor2_1
X_1310_ _0318_ _0327_ _0328_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__a21oi_1
X_1311_ net86 _0790_ _0794_ _0329_ VSS VSS VDD VDD _0058_
+ sky130_fd_sc_hd__a22o_1
X_1312_ _0789_ VSS VSS VDD VDD _0330_ sky130_fd_sc_hd__buf_4
X_1313_ _0806_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__buf_6
X_1314_ mem\[10\]\[1\] _0859_ _0140_ mem\[9\]\[1\] VSS VSS
+ VDD VDD _0332_ sky130_fd_sc_hd__a22oi_2
X_1315_ mem\[2\]\[1\] _0163_ _0166_ VSS VSS VDD VDD _0333_
+ sky130_fd_sc_hd__a21oi_1
X_1316_ _0331_ _0332_ _0333_ VSS VSS VDD VDD _0334_ sky130_fd_sc_hd__a21oi_1
X_1317_ _0166_ mem\[14\]\[1\] _0124_ _0243_ mem\[7\]\[1\]
+ VSS VSS VDD VDD _0335_ sky130_fd_sc_hd__a32oi_1
X_1318_ _0836_ _0335_ VSS VSS VDD VDD _0336_ sky130_fd_sc_hd__nand2_1
X_1319_ _0836_ _0334_ _0336_ VSS VSS VDD VDD _0337_ sky130_fd_sc_hd__o21ai_2
X_1320_ mem\[1\]\[1\] mem\[5\]\[1\] _0839_ VSS VSS VDD VDD
+ _0338_ sky130_fd_sc_hd__mux2i_1
X_1321_ mem\[13\]\[1\] _0178_ VSS VSS VDD VDD _0339_ sky130_fd_sc_hd__nand2_1
X_1322_ _0166_ _0338_ _0339_ VSS VSS VDD VDD _0340_ sky130_fd_sc_hd__o21ai_0
X_1323_ _0849_ mem\[11\]\[1\] mem\[8\]\[1\] _0850_ VSS VSS
+ VDD VDD _0341_ sky130_fd_sc_hd__a22oi_2
X_1324_ mem\[4\]\[1\] _0802_ _0859_ mem\[6\]\[1\] VSS VSS
+ VDD VDD _0342_ sky130_fd_sc_hd__a22oi_2
X_1325_ mem\[12\]\[1\] _0181_ _0812_ VSS VSS VDD VDD _0343_
+ sky130_fd_sc_hd__nand3_1
X_1326_ _0145_ _0341_ _0342_ _0154_ _0343_ VSS VSS VDD VDD
+ _0344_ sky130_fd_sc_hd__o221ai_4
X_1327_ _0193_ _0340_ _0344_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__a21oi_1
X_1328_ mem\[15\]\[1\] _0812_ _0819_ mem\[3\]\[1\] VSS VSS
+ VDD VDD _0346_ sky130_fd_sc_hd__a22o_1
X_1329_ _0218_ _0346_ _0824_ VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__a21oi_1
X_1330_ mem\[0\]\[1\] _0830_ VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__nor2_1
X_1331_ _0337_ _0345_ _0347_ _0348_ VSS VSS VDD VDD _0349_
+ sky130_fd_sc_hd__a31oi_4
X_1332_ net87 _0330_ _0794_ _0349_ VSS VSS VDD VDD _0059_
+ sky130_fd_sc_hd__a22o_1
X_1333_ _0793_ VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__buf_6
X_1334_ _0149_ mem\[15\]\[20\] mem\[12\]\[20\] _0842_ VSS
+ VSS VDD VDD _0351_ sky130_fd_sc_hd__a22o_1
X_1335_ mem\[4\]\[20\] _0181_ _0182_ mem\[6\]\[20\] VSS VSS
+ VDD VDD _0352_ sky130_fd_sc_hd__a22oi_1
X_1336_ _0841_ mem\[3\]\[20\] mem\[2\]\[20\] _0182_ VSS VSS
+ VDD VDD _0353_ sky130_fd_sc_hd__a22oi_1
X_1337_ _0154_ _0352_ _0353_ _0823_ VSS VSS VDD VDD _0354_
+ sky130_fd_sc_hd__o22ai_1
X_1338_ _0178_ _0351_ _0354_ VSS VSS VDD VDD _0355_ sky130_fd_sc_hd__a21oi_1
X_1339_ _0122_ mem\[14\]\[20\] _0859_ _0243_ mem\[7\]\[20\]
+ VSS VSS VDD VDD _0356_ sky130_fd_sc_hd__a32o_1
X_1340_ mem\[13\]\[20\] _0812_ _0171_ mem\[1\]\[20\] VSS VSS
+ VDD VDD _0357_ sky130_fd_sc_hd__a22o_1
X_1341_ _0796_ mem\[11\]\[20\] mem\[8\]\[20\] _0802_ _0814_
+ mem\[9\]\[20\] VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__a222oi_1
X_1342_ _0199_ mem\[10\]\[20\] VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__nand2_1
X_1343_ _0783_ _0197_ mem\[5\]\[20\] _0226_ VSS VSS VDD VDD
+ _0360_ sky130_fd_sc_hd__nand4_1
X_1344_ _0145_ _0358_ _0359_ _0165_ _0360_ VSS VSS VDD VDD
+ _0361_ sky130_fd_sc_hd__o221ai_1
X_1345_ _0836_ _0356_ _0357_ _0193_ _0361_ VSS VSS VDD VDD
+ _0362_ sky130_fd_sc_hd__a221oi_2
X_1346_ mem\[0\]\[20\] _0309_ VSS VSS VDD VDD _0363_ sky130_fd_sc_hd__nor2_1
X_1347_ _0157_ _0355_ _0362_ _0363_ VSS VSS VDD VDD _0364_
+ sky130_fd_sc_hd__a31oi_2
X_1348_ net88 _0330_ _0350_ _0364_ VSS VSS VDD VDD _0060_
+ sky130_fd_sc_hd__a22o_1
X_1349_ mem\[6\]\[21\] _0804_ _0814_ mem\[5\]\[21\] VSS VSS
+ VDD VDD _0365_ sky130_fd_sc_hd__a22oi_1
X_1350_ _0836_ _0365_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__nand2_1
X_1351_ mem\[13\]\[21\] _0178_ _0171_ mem\[1\]\[21\] VSS VSS
+ VDD VDD _0367_ sky130_fd_sc_hd__a22o_1
X_1352_ mem\[3\]\[21\] _0243_ _0366_ _0367_ _0863_ VSS VSS
+ VDD VDD _0368_ sky130_fd_sc_hd__a32oi_4
X_1353_ mem\[14\]\[21\] _0851_ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__nand2_1
X_1354_ mem\[4\]\[21\] _0245_ _0122_ VSS VSS VDD VDD _0370_
+ sky130_fd_sc_hd__a21oi_1
X_1355_ _0832_ _0369_ _0370_ _0365_ _0276_ VSS VSS VDD VDD
+ _0371_ sky130_fd_sc_hd__a221oi_1
X_1356_ mem\[8\]\[21\] _0838_ _0174_ _0824_ _0371_ VSS VSS
+ VDD VDD _0372_ sky130_fd_sc_hd__a311oi_2
X_1357_ _0276_ mem\[2\]\[21\] _0124_ _0272_ mem\[7\]\[21\]
+ VSS VSS VDD VDD _0373_ sky130_fd_sc_hd__a32o_1
X_1358_ _0849_ mem\[11\]\[21\] mem\[10\]\[21\] _0817_ _0140_
+ mem\[9\]\[21\] VSS VSS VDD VDD _0374_ sky130_fd_sc_hd__a222oi_1
X_1359_ _0224_ mem\[15\]\[21\] mem\[12\]\[21\] _0245_ _0785_
+ VSS VSS VDD VDD _0375_ sky130_fd_sc_hd__a221oi_1
X_1360_ _0848_ _0374_ _0375_ _0869_ VSS VSS VDD VDD _0376_
+ sky130_fd_sc_hd__a211oi_1
X_1361_ _0881_ _0373_ _0376_ VSS VSS VDD VDD _0377_ sky130_fd_sc_hd__a21oi_1
X_1362_ mem\[0\]\[21\] _0309_ VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__nor2_1
X_1363_ _0368_ _0372_ _0377_ _0378_ VSS VSS VDD VDD _0379_
+ sky130_fd_sc_hd__a31oi_4
X_1364_ net89 _0330_ _0350_ _0379_ VSS VSS VDD VDD _0061_
+ sky130_fd_sc_hd__a22o_1
X_1365_ mem\[10\]\[22\] _0152_ VSS VSS VDD VDD _0380_ sky130_fd_sc_hd__nand2_1
X_1366_ _0247_ mem\[3\]\[22\] mem\[2\]\[22\] _0851_ _0166_
+ VSS VSS VDD VDD _0381_ sky130_fd_sc_hd__a221oi_1
X_1367_ _0162_ _0380_ _0381_ VSS VSS VDD VDD _0382_ sky130_fd_sc_hd__a21oi_1
X_1368_ _0331_ mem\[12\]\[22\] _0173_ _0243_ mem\[7\]\[22\]
+ VSS VSS VDD VDD _0383_ sky130_fd_sc_hd__a32oi_1
X_1369_ _0198_ _0383_ VSS VSS VDD VDD _0384_ sky130_fd_sc_hd__nand2_1
X_1370_ _0198_ _0382_ _0384_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__o21ai_1
X_1371_ _0207_ mem\[13\]\[22\] _0814_ _0847_ mem\[11\]\[22\]
+ VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__a32o_1
X_1372_ mem\[4\]\[22\] _0837_ _0226_ mem\[5\]\[22\] VSS VSS
+ VDD VDD _0387_ sky130_fd_sc_hd__a22o_1
X_1373_ mem\[8\]\[22\] _0802_ _0814_ mem\[9\]\[22\] _0145_
+ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__a221oi_1
X_1374_ _0849_ mem\[15\]\[22\] mem\[14\]\[22\] _0859_ _0856_
+ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__a221oi_1
X_1375_ _0834_ mem\[6\]\[22\] _0803_ VSS VSS VDD VDD _0390_
+ sky130_fd_sc_hd__and3_1
X_1376_ _0785_ mem\[1\]\[22\] _0820_ _0390_ _0122_ VSS VSS
+ VDD VDD _0391_ sky130_fd_sc_hd__a311oi_1
X_1377_ _0388_ _0389_ _0391_ VSS VSS VDD VDD _0392_ sky130_fd_sc_hd__nor3_1
X_1378_ _0200_ _0386_ _0387_ _0866_ _0392_ VSS VSS VDD VDD
+ _0393_ sky130_fd_sc_hd__a221oi_2
X_1379_ mem\[0\]\[22\] _0309_ VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__nor2_1
X_1380_ _0157_ _0385_ _0393_ _0394_ VSS VSS VDD VDD _0395_
+ sky130_fd_sc_hd__a31oi_4
X_1381_ net90 _0330_ _0350_ _0395_ VSS VSS VDD VDD _0062_
+ sky130_fd_sc_hd__a22o_1
X_1382_ _0234_ mem\[14\]\[23\] _0152_ _0847_ mem\[11\]\[23\]
+ VSS VSS VDD VDD _0396_ sky130_fd_sc_hd__a32oi_1
X_1383_ _0849_ mem\[15\]\[23\] mem\[12\]\[23\] _0802_ _0820_
+ mem\[13\]\[23\] VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__a222oi_1
X_1384_ _0840_ _0397_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__nand2_1
X_1385_ mem\[10\]\[23\] _0804_ _0814_ mem\[9\]\[23\] mem\[8\]\[23\]
+ _0850_ VSS VSS VDD VDD _0399_ sky130_fd_sc_hd__a222oi_1
X_1386_ _0848_ _0399_ VSS VSS VDD VDD _0400_ sky130_fd_sc_hd__nand2_1
X_1387_ _0398_ _0400_ VSS VSS VDD VDD _0401_ sky130_fd_sc_hd__nand2_1
X_1388_ _0785_ mem\[1\]\[23\] _0798_ VSS VSS VDD VDD _0402_
+ sky130_fd_sc_hd__and3_1
X_1389_ mem\[5\]\[23\] _0798_ VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__nand2_1
X_1390_ mem\[4\]\[23\] _0801_ _0804_ mem\[6\]\[23\] VSS VSS
+ VDD VDD _0404_ sky130_fd_sc_hd__a22oi_1
X_1391_ _0795_ mem\[3\]\[23\] mem\[2\]\[23\] _0803_ _0834_
+ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__a221oi_1
X_1392_ _0839_ _0403_ _0404_ _0405_ VSS VSS VDD VDD _0406_
+ sky130_fd_sc_hd__a31oi_1
X_1393_ mem\[7\]\[23\] _0272_ _0402_ _0406_ _0331_ VSS VSS
+ VDD VDD _0407_ sky130_fd_sc_hd__a2111oi_0
X_1394_ _0833_ _0396_ _0401_ _0407_ VSS VSS VDD VDD _0408_
+ sky130_fd_sc_hd__a31oi_1
X_1395_ mem\[0\]\[23\] _0132_ _0408_ VSS VSS VDD VDD _0409_
+ sky130_fd_sc_hd__a21o_1
X_1396_ net91 _0330_ _0350_ _0409_ VSS VSS VDD VDD _0063_
+ sky130_fd_sc_hd__a22o_1
X_1397_ mem\[11\]\[24\] mem\[15\]\[24\] _0839_ VSS VSS VDD
+ VDD _0410_ sky130_fd_sc_hd__mux2i_1
X_1398_ mem\[7\]\[24\] _0865_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__nand2_1
X_1399_ _0783_ _0410_ _0411_ VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__o21ai_1
X_1400_ _0247_ mem\[3\]\[24\] mem\[2\]\[24\] _0163_ VSS VSS
+ VDD VDD _0413_ sky130_fd_sc_hd__a22oi_1
X_1401_ mem\[1\]\[24\] _0137_ _0166_ VSS VSS VDD VDD _0414_
+ sky130_fd_sc_hd__a21oi_1
X_1402_ _0413_ _0414_ _0840_ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__a21oi_2
X_1403_ mem\[10\]\[24\] _0817_ _0820_ mem\[9\]\[24\] mem\[8\]\[24\]
+ _0837_ VSS VSS VDD VDD _0416_ sky130_fd_sc_hd__a222oi_1
X_1404_ _0162_ _0416_ VSS VSS VDD VDD _0417_ sky130_fd_sc_hd__nand2_1
X_1405_ mem\[6\]\[24\] _0817_ _0820_ mem\[5\]\[24\] mem\[4\]\[24\]
+ _0837_ VSS VSS VDD VDD _0418_ sky130_fd_sc_hd__a222oi_1
X_1406_ mem\[14\]\[24\] _0817_ _0820_ mem\[13\]\[24\] mem\[12\]\[24\]
+ _0837_ VSS VSS VDD VDD _0419_ sky130_fd_sc_hd__a222oi_1
X_1407_ _0154_ _0418_ _0419_ _0857_ VSS VSS VDD VDD _0420_
+ sky130_fd_sc_hd__o22ai_2
X_1408_ _0218_ _0412_ _0415_ _0417_ _0420_ VSS VSS VDD VDD
+ _0421_ sky130_fd_sc_hd__a221oi_4
X_1409_ mem\[0\]\[24\] _0129_ VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__nor2_1
X_1410_ _0831_ _0421_ _0422_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__a21oi_4
X_1411_ net92 _0330_ _0350_ _0423_ VSS VSS VDD VDD _0064_
+ sky130_fd_sc_hd__a22o_1
X_1412_ mem\[14\]\[25\] _0182_ VSS VSS VDD VDD _0424_ sky130_fd_sc_hd__nand2_1
X_1413_ mem\[12\]\[25\] _0134_ _0137_ mem\[13\]\[25\] VSS
+ VSS VDD VDD _0425_ sky130_fd_sc_hd__a22oi_1
X_1414_ mem\[4\]\[25\] _0245_ _0851_ mem\[6\]\[25\] _0199_
+ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__a221oi_1
X_1415_ _0123_ _0424_ _0425_ _0426_ VSS VSS VDD VDD _0427_
+ sky130_fd_sc_hd__a31oi_1
X_1416_ mem\[3\]\[25\] mem\[11\]\[25\] _0122_ VSS VSS VDD
+ VDD _0428_ sky130_fd_sc_hd__mux2i_1
X_1417_ mem\[2\]\[25\] mem\[10\]\[25\] _0199_ VSS VSS VDD
+ VDD _0429_ sky130_fd_sc_hd__mux2i_1
X_1418_ _0282_ _0428_ _0429_ _0165_ VSS VSS VDD VDD _0430_
+ sky130_fd_sc_hd__o22ai_1
X_1419_ _0198_ _0427_ _0430_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__a21oi_1
X_1420_ mem\[8\]\[25\] _0181_ _0226_ mem\[9\]\[25\] VSS VSS
+ VDD VDD _0432_ sky130_fd_sc_hd__a22oi_1
X_1421_ mem\[15\]\[25\] _0272_ VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__nand2_1
X_1422_ _0840_ _0432_ _0433_ VSS VSS VDD VDD _0434_ sky130_fd_sc_hd__o21ai_0
X_1423_ _0149_ mem\[7\]\[25\] mem\[5\]\[25\] _0862_ VSS VSS
+ VDD VDD _0435_ sky130_fd_sc_hd__a22oi_1
X_1424_ mem\[1\]\[25\] _0305_ _0123_ VSS VSS VDD VDD _0436_
+ sky130_fd_sc_hd__a21oi_1
X_1425_ _0848_ _0435_ _0436_ VSS VSS VDD VDD _0437_ sky130_fd_sc_hd__o21ai_0
X_1426_ _0881_ _0434_ _0437_ VSS VSS VDD VDD _0438_ sky130_fd_sc_hd__o21ai_1
X_1427_ mem\[0\]\[25\] _0309_ VSS VSS VDD VDD _0439_ sky130_fd_sc_hd__nor2_1
X_1428_ _0157_ _0431_ _0438_ _0439_ VSS VSS VDD VDD _0440_
+ sky130_fd_sc_hd__a31oi_4
X_1429_ net93 _0330_ _0350_ _0440_ VSS VSS VDD VDD _0065_
+ sky130_fd_sc_hd__a22o_1
X_1430_ mem\[3\]\[26\] mem\[7\]\[26\] _0197_ VSS VSS VDD VDD
+ _0441_ sky130_fd_sc_hd__mux2i_1
X_1431_ _0200_ _0208_ mem\[15\]\[26\] VSS VSS VDD VDD _0442_
+ sky130_fd_sc_hd__nand3_1
X_1432_ _0200_ _0441_ _0442_ VSS VSS VDD VDD _0443_ sky130_fd_sc_hd__o21ai_0
X_1433_ _0218_ _0443_ VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__nand2_1
X_1434_ mem\[10\]\[26\] mem\[14\]\[26\] _0207_ VSS VSS VDD
+ VDD _0445_ sky130_fd_sc_hd__mux2i_1
X_1435_ _0783_ _0320_ _0445_ _0830_ VSS VSS VDD VDD _0446_
+ sky130_fd_sc_hd__o31ai_1
X_1436_ mem\[8\]\[26\] _0838_ _0174_ _0446_ VSS VSS VDD VDD
+ _0447_ sky130_fd_sc_hd__a31oi_2
X_1437_ mem\[5\]\[26\] _0862_ VSS VSS VDD VDD _0448_ sky130_fd_sc_hd__nand2_1
X_1438_ mem\[4\]\[26\] _0134_ _0124_ mem\[6\]\[26\] VSS VSS
+ VDD VDD _0449_ sky130_fd_sc_hd__a22oi_1
X_1439_ mem\[2\]\[26\] _0143_ _0140_ mem\[1\]\[26\] _0835_
+ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__a221oi_1
X_1440_ _0208_ _0448_ _0449_ _0450_ VSS VSS VDD VDD _0451_
+ sky130_fd_sc_hd__a31oi_1
X_1441_ _0247_ mem\[11\]\[26\] mem\[9\]\[26\] _0140_ _0835_
+ VSS VSS VDD VDD _0452_ sky130_fd_sc_hd__a221oi_1
X_1442_ mem\[12\]\[26\] _0134_ _0226_ mem\[13\]\[26\] _0276_
+ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__a221oi_1
X_1443_ _0452_ _0453_ _0200_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__o21ai_0
X_1444_ _0833_ _0451_ _0454_ VSS VSS VDD VDD _0455_ sky130_fd_sc_hd__o21ai_1
X_1445_ mem\[0\]\[26\] _0309_ VSS VSS VDD VDD _0456_ sky130_fd_sc_hd__nor2_1
X_1446_ _0444_ _0447_ _0455_ _0456_ VSS VSS VDD VDD _0457_
+ sky130_fd_sc_hd__a31oi_4
X_1447_ net94 _0330_ _0350_ _0457_ VSS VSS VDD VDD _0066_
+ sky130_fd_sc_hd__a22o_1
X_1448_ net95 _0826_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__nand2_1
X_1449_ mem\[14\]\[27\] _0163_ _0862_ mem\[13\]\[27\] VSS
+ VSS VDD VDD _0459_ sky130_fd_sc_hd__a22oi_1
X_1450_ _0247_ mem\[11\]\[27\] mem\[8\]\[27\] _0134_ _0197_
+ VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__a221oi_1
X_1451_ _0208_ _0459_ _0460_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__a21oi_1
X_1452_ _0247_ mem\[7\]\[27\] mem\[4\]\[27\] _0181_ VSS VSS
+ VDD VDD _0462_ sky130_fd_sc_hd__a22oi_1
X_1453_ mem\[2\]\[27\] _0859_ _0140_ mem\[1\]\[27\] _0835_
+ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__a221oi_1
X_1454_ _0208_ _0462_ _0463_ _0200_ VSS VSS VDD VDD _0464_
+ sky130_fd_sc_hd__a211oi_1
X_1455_ _0833_ _0461_ _0464_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__a21oi_2
X_1456_ mem\[9\]\[27\] _0160_ _0865_ mem\[5\]\[27\] VSS VSS
+ VDD VDD _0466_ sky130_fd_sc_hd__a22o_1
X_1457_ mem\[15\]\[27\] _0178_ _0171_ mem\[3\]\[27\] VSS VSS
+ VDD VDD _0467_ sky130_fd_sc_hd__a22o_1
X_1458_ _0863_ _0466_ _0467_ _0218_ VSS VSS VDD VDD _0468_
+ sky130_fd_sc_hd__a22oi_1
X_1459_ mem\[10\]\[27\] _0160_ _0865_ mem\[6\]\[27\] VSS VSS
+ VDD VDD _0469_ sky130_fd_sc_hd__a22o_1
X_1460_ mem\[12\]\[27\] _0838_ _0178_ _0469_ _0860_ VSS VSS
+ VDD VDD _0470_ sky130_fd_sc_hd__a32oi_1
X_1461_ _0157_ _0465_ _0468_ _0470_ VSS VSS VDD VDD _0471_
+ sky130_fd_sc_hd__nand4_1
X_1462_ mem\[0\]\[27\] _0831_ _0471_ _0826_ _0231_ VSS VSS
+ VDD VDD _0472_ sky130_fd_sc_hd__o2111ai_1
X_1463_ _0231_ _0458_ _0472_ VSS VSS VDD VDD _0067_ sky130_fd_sc_hd__o21ai_0
X_1464_ _0136_ mem\[15\]\[28\] mem\[12\]\[28\] _0850_ VSS
+ VSS VDD VDD _0473_ sky130_fd_sc_hd__a22oi_1
X_1465_ _0849_ mem\[7\]\[28\] mem\[4\]\[28\] _0802_ _0140_
+ mem\[5\]\[28\] VSS VSS VDD VDD _0474_ sky130_fd_sc_hd__a222oi_1
X_1466_ _0331_ _0473_ _0474_ VSS VSS VDD VDD _0475_ sky130_fd_sc_hd__a21oi_1
X_1467_ _0224_ mem\[3\]\[28\] mem\[2\]\[28\] _0143_ _0199_
+ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__a221o_1
X_1468_ mem\[8\]\[28\] _0842_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__nand2_1
X_1469_ _0133_ _0477_ _0840_ VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__a21oi_1
X_1470_ mem\[6\]\[28\] mem\[14\]\[28\] _0806_ VSS VSS VDD
+ VDD _0479_ sky130_fd_sc_hd__mux2i_1
X_1471_ mem\[1\]\[28\] mem\[9\]\[28\] _0122_ VSS VSS VDD VDD
+ _0480_ sky130_fd_sc_hd__mux2i_1
X_1472_ _0276_ _0320_ _0479_ _0480_ _0279_ VSS VSS VDD VDD
+ _0481_ sky130_fd_sc_hd__o32ai_1
X_1473_ _0836_ _0475_ _0476_ _0478_ _0481_ VSS VSS VDD VDD
+ _0482_ sky130_fd_sc_hd__a221oi_2
X_1474_ mem\[13\]\[28\] _0150_ VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__nand2_1
X_1475_ _0841_ mem\[11\]\[28\] mem\[10\]\[28\] _0163_ _0197_
+ VSS VSS VDD VDD _0484_ sky130_fd_sc_hd__a221oi_1
X_1476_ _0208_ _0473_ _0483_ _0484_ VSS VSS VDD VDD _0485_
+ sky130_fd_sc_hd__a31oi_1
X_1477_ _0833_ _0485_ _0132_ VSS VSS VDD VDD _0486_ sky130_fd_sc_hd__a21oi_1
X_1478_ mem\[0\]\[28\] _0129_ VSS VSS VDD VDD _0487_ sky130_fd_sc_hd__nor2_1
X_1479_ _0482_ _0486_ _0487_ VSS VSS VDD VDD _0488_ sky130_fd_sc_hd__a21oi_4
X_1480_ net96 _0330_ _0350_ _0488_ VSS VSS VDD VDD _0068_
+ sky130_fd_sc_hd__a22o_1
X_1481_ mem\[2\]\[29\] _0152_ VSS VSS VDD VDD _0489_ sky130_fd_sc_hd__nand2_1
X_1482_ _0133_ mem\[8\]\[29\] _0173_ VSS VSS VDD VDD _0490_
+ sky130_fd_sc_hd__nand3_1
X_1483_ _0123_ _0489_ _0490_ VSS VSS VDD VDD _0491_ sky130_fd_sc_hd__o21ai_0
X_1484_ _0149_ mem\[15\]\[29\] mem\[14\]\[29\] _0152_ VSS
+ VSS VDD VDD _0492_ sky130_fd_sc_hd__a22oi_1
X_1485_ mem\[13\]\[29\] _0862_ _0857_ VSS VSS VDD VDD _0493_
+ sky130_fd_sc_hd__a21oi_1
X_1486_ mem\[4\]\[29\] _0181_ _0182_ mem\[6\]\[29\] _0154_
+ VSS VSS VDD VDD _0494_ sky130_fd_sc_hd__a221oi_1
X_1487_ _0492_ _0493_ _0494_ VSS VSS VDD VDD _0495_ sky130_fd_sc_hd__a21oi_1
X_1488_ _0198_ _0491_ _0495_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__o21ai_0
X_1489_ mem\[1\]\[29\] mem\[5\]\[29\] _0207_ VSS VSS VDD VDD
+ _0497_ sky130_fd_sc_hd__mux2i_1
X_1490_ mem\[9\]\[29\] _0174_ VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__nand2_1
X_1491_ _0133_ _0497_ _0498_ VSS VSS VDD VDD _0499_ sky130_fd_sc_hd__o21ai_0
X_1492_ _0832_ _0842_ VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__nand2_1
X_1493_ _0234_ mem\[12\]\[29\] VSS VSS VDD VDD _0501_ sky130_fd_sc_hd__nand2_1
X_1494_ mem\[3\]\[29\] mem\[7\]\[29\] _0784_ VSS VSS VDD VDD
+ _0502_ sky130_fd_sc_hd__mux2_1
X_1495_ _0849_ mem\[11\]\[29\] mem\[10\]\[29\] _0817_ VSS
+ VSS VDD VDD _0503_ sky130_fd_sc_hd__a22o_1
X_1496_ _0243_ _0502_ _0503_ _0174_ VSS VSS VDD VDD _0504_
+ sky130_fd_sc_hd__a22oi_1
X_1497_ _0500_ _0501_ _0504_ VSS VSS VDD VDD _0505_ sky130_fd_sc_hd__o21ai_1
X_1498_ _0863_ _0499_ _0505_ VSS VSS VDD VDD _0506_ sky130_fd_sc_hd__a21oi_1
X_1499_ mem\[0\]\[29\] _0309_ VSS VSS VDD VDD _0507_ sky130_fd_sc_hd__nor2_1
X_1500_ _0157_ _0496_ _0506_ _0507_ VSS VSS VDD VDD _0508_
+ sky130_fd_sc_hd__a31oi_1
X_1501_ net97 _0330_ _0350_ _0508_ VSS VSS VDD VDD _0069_
+ sky130_fd_sc_hd__a22o_1
X_1502_ net98 _0826_ VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__nand2_1
X_1503_ mem\[2\]\[2\] mem\[6\]\[2\] _0867_ VSS VSS VDD VDD
+ _0510_ sky130_fd_sc_hd__mux2i_1
X_1504_ _0162_ _0510_ VSS VSS VDD VDD _0511_ sky130_fd_sc_hd__nor2_1
X_1505_ mem\[10\]\[2\] _0174_ _0511_ VSS VSS VDD VDD _0512_
+ sky130_fd_sc_hd__a21oi_1
X_1506_ mem\[0\]\[2\] _0830_ VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__nor2_1
X_1507_ _0136_ mem\[7\]\[2\] mem\[4\]\[2\] _0837_ VSS VSS
+ VDD VDD _0514_ sky130_fd_sc_hd__a22oi_2
X_1508_ mem\[8\]\[2\] mem\[12\]\[2\] _0839_ VSS VSS VDD VDD
+ _0515_ sky130_fd_sc_hd__mux2i_2
X_1509_ _0154_ _0514_ _0515_ _0500_ VSS VSS VDD VDD _0516_
+ sky130_fd_sc_hd__o22ai_4
X_1510_ mem\[1\]\[2\] _0193_ _0171_ _0824_ _0516_ VSS VSS
+ VDD VDD _0517_ sky130_fd_sc_hd__a311oi_4
X_1511_ _0149_ mem\[11\]\[2\] mem\[9\]\[2\] _0862_ _0145_
+ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__a221o_1
X_1512_ _0858_ mem\[15\]\[2\] mem\[13\]\[2\] _0193_ VSS VSS
+ VDD VDD _0519_ sky130_fd_sc_hd__a22oi_1
X_1513_ mem\[14\]\[2\] _0860_ VSS VSS VDD VDD _0520_ sky130_fd_sc_hd__nand2_1
X_1514_ _0178_ _0519_ _0520_ VSS VSS VDD VDD _0521_ sky130_fd_sc_hd__nand3_1
X_1515_ mem\[5\]\[2\] _0150_ VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__nand2_1
X_1516_ _0858_ mem\[3\]\[2\] VSS VSS VDD VDD _0523_ sky130_fd_sc_hd__nand2_1
X_1517_ _0866_ _0522_ _0523_ _0171_ VSS VSS VDD VDD _0524_
+ sky130_fd_sc_hd__a22oi_1
X_1518_ _0518_ _0521_ _0524_ VSS VSS VDD VDD _0525_ sky130_fd_sc_hd__nand3_1
X_1519_ _0320_ _0512_ _0513_ _0517_ _0525_ VSS VSS VDD VDD
+ _0526_ sky130_fd_sc_hd__o221ai_4
X_1520_ _0826_ _0231_ _0526_ VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__nand3_1
X_1521_ _0231_ _0509_ _0527_ VSS VSS VDD VDD _0070_ sky130_fd_sc_hd__o21ai_0
X_1522_ _0841_ mem\[15\]\[30\] mem\[12\]\[30\] _0181_ VSS
+ VSS VDD VDD _0528_ sky130_fd_sc_hd__a22o_1
X_1523_ _0247_ mem\[11\]\[30\] mem\[8\]\[30\] _0134_ _0835_
+ VSS VSS VDD VDD _0529_ sky130_fd_sc_hd__a221o_1
X_1524_ _0884_ _0528_ _0529_ VSS VSS VDD VDD _0530_ sky130_fd_sc_hd__o21ai_0
X_1525_ mem\[10\]\[30\] mem\[14\]\[30\] _0834_ VSS VSS VDD
+ VDD _0531_ sky130_fd_sc_hd__mux2_1
X_1526_ mem\[9\]\[30\] mem\[13\]\[30\] _0834_ VSS VSS VDD
+ VDD _0532_ sky130_fd_sc_hd__mux2_1
X_1527_ _0860_ _0531_ _0532_ _0193_ _0869_ VSS VSS VDD VDD
+ _0533_ sky130_fd_sc_hd__a221oi_1
X_1528_ _0136_ mem\[7\]\[30\] mem\[5\]\[30\] _0820_ VSS VSS
+ VDD VDD _0534_ sky130_fd_sc_hd__a22oi_1
X_1529_ mem\[4\]\[30\] _0850_ _0143_ mem\[6\]\[30\] VSS VSS
+ VDD VDD _0535_ sky130_fd_sc_hd__a22oi_1
X_1530_ _0849_ mem\[3\]\[30\] mem\[2\]\[30\] _0817_ _0207_
+ VSS VSS VDD VDD _0536_ sky130_fd_sc_hd__a221oi_1
X_1531_ _0234_ _0534_ _0535_ _0536_ VSS VSS VDD VDD _0537_
+ sky130_fd_sc_hd__a31oi_1
X_1532_ mem\[1\]\[30\] _0305_ _0537_ _0200_ VSS VSS VDD VDD
+ _0538_ sky130_fd_sc_hd__a211oi_1
X_1533_ _0530_ _0533_ _0538_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__a21oi_1
X_1534_ mem\[0\]\[30\] _0132_ _0539_ VSS VSS VDD VDD _0540_
+ sky130_fd_sc_hd__a21oi_4
X_1535_ net99 _0827_ VSS VSS VDD VDD _0541_ sky130_fd_sc_hd__nor2_1
X_1536_ _0231_ _0540_ _0541_ _0764_ VSS VSS VDD VDD _0071_
+ sky130_fd_sc_hd__a211oi_1
X_1537_ mem\[8\]\[31\] mem\[12\]\[31\] _0207_ VSS VSS VDD
+ VDD _0542_ sky130_fd_sc_hd__mux2i_2
X_1538_ _0162_ _0542_ VSS VSS VDD VDD _0543_ sky130_fd_sc_hd__nand2_1
X_1539_ _0234_ mem\[4\]\[31\] VSS VSS VDD VDD _0544_ sky130_fd_sc_hd__nand2_1
X_1540_ _0869_ _0544_ VSS VSS VDD VDD _0545_ sky130_fd_sc_hd__nand2_1
X_1541_ _0122_ mem\[14\]\[31\] _0143_ _0243_ mem\[7\]\[31\]
+ VSS VSS VDD VDD _0546_ sky130_fd_sc_hd__a32oi_2
X_1542_ mem\[10\]\[31\] _0803_ _0797_ mem\[9\]\[31\] VSS VSS
+ VDD VDD _0547_ sky130_fd_sc_hd__a22o_1
X_1543_ mem\[3\]\[31\] _0242_ _0547_ _0806_ _0867_ VSS VSS
+ VDD VDD _0548_ sky130_fd_sc_hd__a221oi_1
X_1544_ _0840_ _0546_ _0548_ VSS VSS VDD VDD _0549_ sky130_fd_sc_hd__a21oi_1
X_1545_ mem\[2\]\[31\] mem\[6\]\[31\] _0784_ VSS VSS VDD VDD
+ _0550_ sky130_fd_sc_hd__mux2_1
X_1546_ mem\[1\]\[31\] mem\[5\]\[31\] _0784_ VSS VSS VDD VDD
+ _0551_ sky130_fd_sc_hd__mux2_1
X_1547_ _0163_ _0550_ _0551_ _0137_ _0166_ VSS VSS VDD VDD
+ _0552_ sky130_fd_sc_hd__a221oi_1
X_1548_ _0795_ mem\[15\]\[31\] mem\[13\]\[31\] _0798_ VSS
+ VSS VDD VDD _0553_ sky130_fd_sc_hd__a22o_1
X_1549_ mem\[11\]\[31\] _0847_ _0553_ _0867_ _0783_ VSS VSS
+ VDD VDD _0554_ sky130_fd_sc_hd__a221oi_1
X_1550_ _0552_ _0554_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__nor2_1
X_1551_ _0838_ _0543_ _0545_ _0549_ _0555_ VSS VSS VDD VDD
+ _0556_ sky130_fd_sc_hd__a311oi_1
X_1552_ mem\[0\]\[31\] _0129_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__nor2_1
X_1553_ _0831_ _0556_ _0557_ VSS VSS VDD VDD _0558_ sky130_fd_sc_hd__a21oi_1
X_1554_ net100 _0789_ _0350_ _0558_ VSS VSS VDD VDD _0072_
+ sky130_fd_sc_hd__a22o_1
X_1555_ mem\[10\]\[3\] mem\[14\]\[3\] _0839_ VSS VSS VDD VDD
+ _0559_ sky130_fd_sc_hd__mux2i_1
X_1556_ mem\[6\]\[3\] _0865_ _0559_ _0783_ VSS VSS VDD VDD
+ _0560_ sky130_fd_sc_hd__o2bb2ai_1
X_1557_ mem\[4\]\[3\] _0850_ _0140_ mem\[5\]\[3\] VSS VSS
+ VDD VDD _0561_ sky130_fd_sc_hd__a22oi_1
X_1558_ _0841_ mem\[7\]\[3\] VSS VSS VDD VDD _0562_ sky130_fd_sc_hd__nand2_1
X_1559_ _0234_ _0561_ _0562_ VSS VSS VDD VDD _0563_ sky130_fd_sc_hd__nand3_1
X_1560_ _0136_ mem\[3\]\[3\] mem\[2\]\[3\] _0859_ VSS VSS
+ VDD VDD _0564_ sky130_fd_sc_hd__a22oi_1
X_1561_ mem\[1\]\[3\] _0814_ _0207_ VSS VSS VDD VDD _0565_
+ sky130_fd_sc_hd__a21oi_1
X_1562_ _0564_ _0565_ _0832_ VSS VSS VDD VDD _0566_ sky130_fd_sc_hd__a21oi_1
X_1563_ _0796_ mem\[15\]\[3\] mem\[12\]\[3\] _0802_ _0814_
+ mem\[13\]\[3\] VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__a222oi_1
X_1564_ _0796_ mem\[11\]\[3\] mem\[8\]\[3\] _0802_ _0820_
+ mem\[9\]\[3\] VSS VSS VDD VDD _0568_ sky130_fd_sc_hd__a222oi_1
X_1565_ _0857_ _0567_ _0568_ _0145_ VSS VSS VDD VDD _0569_
+ sky130_fd_sc_hd__o22ai_2
X_1566_ _0860_ _0560_ _0563_ _0566_ _0569_ VSS VSS VDD VDD
+ _0570_ sky130_fd_sc_hd__a221oi_2
X_1567_ mem\[0\]\[3\] _0830_ VSS VSS VDD VDD _0571_ sky130_fd_sc_hd__nor2_1
X_1568_ _0157_ _0570_ _0571_ VSS VSS VDD VDD _0572_ sky130_fd_sc_hd__a21oi_4
X_1569_ net101 _0789_ _0793_ _0572_ VSS VSS VDD VDD _0073_
+ sky130_fd_sc_hd__a22o_1
X_1570_ mem\[2\]\[4\] mem\[6\]\[4\] mem\[10\]\[4\] mem\[14\]\[4\]
+ _0784_ _0199_ VSS VSS VDD VDD _0573_ sky130_fd_sc_hd__mux4_1
X_1571_ _0860_ _0573_ VSS VSS VDD VDD _0574_ sky130_fd_sc_hd__nand2_1
X_1572_ mem\[9\]\[4\] mem\[13\]\[4\] _0835_ VSS VSS VDD VDD
+ _0575_ sky130_fd_sc_hd__mux2i_1
X_1573_ _0200_ _0575_ VSS VSS VDD VDD _0576_ sky130_fd_sc_hd__nand2_1
X_1574_ _0234_ mem\[5\]\[4\] VSS VSS VDD VDD _0577_ sky130_fd_sc_hd__nand2_1
X_1575_ _0869_ _0577_ VSS VSS VDD VDD _0578_ sky130_fd_sc_hd__nand2_1
X_1576_ _0863_ _0576_ _0578_ VSS VSS VDD VDD _0579_ sky130_fd_sc_hd__nand3_1
X_1577_ _0224_ mem\[11\]\[4\] mem\[8\]\[4\] _0837_ _0145_
+ VSS VSS VDD VDD _0580_ sky130_fd_sc_hd__a221o_1
X_1578_ _0224_ mem\[15\]\[4\] mem\[12\]\[4\] _0245_ _0857_
+ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__a221o_1
X_1579_ _0136_ mem\[7\]\[4\] mem\[4\]\[4\] _0837_ VSS VSS
+ VDD VDD _0582_ sky130_fd_sc_hd__a22oi_1
X_1580_ _0247_ mem\[3\]\[4\] mem\[1\]\[4\] _0137_ VSS VSS
+ VDD VDD _0583_ sky130_fd_sc_hd__a22oi_1
X_1581_ _0866_ _0582_ _0583_ _0171_ VSS VSS VDD VDD _0584_
+ sky130_fd_sc_hd__a22oi_1
X_1582_ _0580_ _0581_ _0584_ VSS VSS VDD VDD _0585_ sky130_fd_sc_hd__nand3_1
X_1583_ mem\[0\]\[4\] _0830_ VSS VSS VDD VDD _0586_ sky130_fd_sc_hd__nor2_1
X_1584_ _0157_ _0574_ _0579_ _0585_ _0586_ VSS VSS VDD VDD
+ _0587_ sky130_fd_sc_hd__a41oi_4
X_1585_ net102 _0789_ _0793_ _0587_ VSS VSS VDD VDD _0074_
+ sky130_fd_sc_hd__a22o_1
X_1586_ mem\[6\]\[5\] _0124_ _0862_ mem\[5\]\[5\] VSS VSS
+ VDD VDD _0588_ sky130_fd_sc_hd__a22oi_1
X_1587_ mem\[2\]\[5\] _0152_ _0234_ VSS VSS VDD VDD _0589_
+ sky130_fd_sc_hd__a21oi_1
X_1588_ _0836_ _0588_ _0589_ VSS VSS VDD VDD _0590_ sky130_fd_sc_hd__a21oi_1
X_1589_ _0136_ mem\[11\]\[5\] mem\[10\]\[5\] _0859_ _0137_
+ mem\[9\]\[5\] VSS VSS VDD VDD _0591_ sky130_fd_sc_hd__a222oi_1
X_1590_ _0224_ mem\[15\]\[5\] mem\[14\]\[5\] _0851_ _0785_
+ VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__a221oi_1
X_1591_ _0848_ _0591_ _0592_ _0881_ VSS VSS VDD VDD _0593_
+ sky130_fd_sc_hd__a211oi_1
X_1592_ _0881_ _0590_ _0593_ VSS VSS VDD VDD _0594_ sky130_fd_sc_hd__a21oi_1
X_1593_ mem\[1\]\[5\] _0150_ VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__nand2_1
X_1594_ _0331_ mem\[8\]\[5\] _0173_ VSS VSS VDD VDD _0596_
+ sky130_fd_sc_hd__nand3_1
X_1595_ _0123_ _0595_ _0596_ VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__o21ai_0
X_1596_ _0331_ mem\[12\]\[5\] _0173_ _0243_ mem\[7\]\[5\]
+ VSS VSS VDD VDD _0598_ sky130_fd_sc_hd__a32oi_1
X_1597_ _0198_ _0598_ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__nand2_1
X_1598_ _0198_ _0597_ _0599_ VSS VSS VDD VDD _0600_ sky130_fd_sc_hd__o21ai_0
X_1599_ mem\[3\]\[5\] _0847_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__nand2_1
X_1600_ _0331_ _0197_ mem\[13\]\[5\] _0862_ VSS VSS VDD VDD
+ _0602_ sky130_fd_sc_hd__nand4_1
X_1601_ _0331_ _0601_ _0602_ VSS VSS VDD VDD _0603_ sky130_fd_sc_hd__o21ai_0
X_1602_ mem\[4\]\[5\] _0838_ _0866_ _0824_ _0603_ VSS VSS
+ VDD VDD _0604_ sky130_fd_sc_hd__a311oi_1
X_1603_ mem\[0\]\[5\] _0309_ VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__nor2_1
X_1604_ _0594_ _0600_ _0604_ _0605_ VSS VSS VDD VDD _0606_
+ sky130_fd_sc_hd__a31oi_1
X_1605_ net103 _0789_ _0793_ _0606_ VSS VSS VDD VDD _0075_
+ sky130_fd_sc_hd__a22o_1
X_1606_ net104 _0791_ VSS VSS VDD VDD _0607_ sky130_fd_sc_hd__nand2_1
X_1607_ mem\[14\]\[6\] _0182_ _0150_ mem\[13\]\[6\] VSS VSS
+ VDD VDD _0608_ sky130_fd_sc_hd__a22o_1
X_1608_ mem\[8\]\[6\] _0173_ _0860_ mem\[10\]\[6\] VSS VSS
+ VDD VDD _0609_ sky130_fd_sc_hd__a22oi_1
X_1609_ mem\[9\]\[6\] _0150_ _0840_ VSS VSS VDD VDD _0610_
+ sky130_fd_sc_hd__a21oi_1
X_1610_ _0609_ _0610_ _0881_ VSS VSS VDD VDD _0611_ sky130_fd_sc_hd__a21oi_1
X_1611_ _0884_ _0608_ _0611_ VSS VSS VDD VDD _0612_ sky130_fd_sc_hd__o21ai_0
X_1612_ mem\[3\]\[6\] mem\[7\]\[6\] _0835_ VSS VSS VDD VDD
+ _0613_ sky130_fd_sc_hd__mux2i_1
X_1613_ _0162_ _0613_ VSS VSS VDD VDD _0614_ sky130_fd_sc_hd__nor2_1
X_1614_ _0331_ _0197_ mem\[15\]\[6\] VSS VSS VDD VDD _0615_
+ sky130_fd_sc_hd__and3_1
X_1615_ _0614_ _0615_ _0218_ VSS VSS VDD VDD _0616_ sky130_fd_sc_hd__o21ai_0
X_1616_ mem\[2\]\[6\] mem\[6\]\[6\] _0197_ VSS VSS VDD VDD
+ _0617_ sky130_fd_sc_hd__mux2i_1
X_1617_ _0208_ mem\[5\]\[6\] _0193_ VSS VSS VDD VDD _0618_
+ sky130_fd_sc_hd__nand3_1
X_1618_ _0320_ _0617_ _0618_ VSS VSS VDD VDD _0619_ sky130_fd_sc_hd__o21ai_0
X_1619_ _0881_ _0619_ VSS VSS VDD VDD _0620_ sky130_fd_sc_hd__nand2_1
X_1620_ mem\[4\]\[6\] mem\[12\]\[6\] _0806_ VSS VSS VDD VDD
+ _0621_ sky130_fd_sc_hd__mux2_1
X_1621_ _0166_ _0841_ mem\[11\]\[6\] VSS VSS VDD VDD _0622_
+ sky130_fd_sc_hd__nand3_1
X_1622_ _0806_ mem\[1\]\[6\] _0226_ VSS VSS VDD VDD _0623_
+ sky130_fd_sc_hd__nand3b_1
X_1623_ _0622_ _0623_ _0840_ VSS VSS VDD VDD _0624_ sky130_fd_sc_hd__a21oi_1
X_1624_ _0836_ _0838_ _0621_ _0624_ _0132_ VSS VSS VDD VDD
+ _0625_ sky130_fd_sc_hd__a311oi_2
X_1625_ _0612_ _0616_ _0620_ _0625_ VSS VSS VDD VDD _0626_
+ sky130_fd_sc_hd__nand4_2
X_1626_ mem\[0\]\[6\] _0831_ _0626_ _0826_ _0827_ VSS VSS
+ VDD VDD _0627_ sky130_fd_sc_hd__o2111ai_2
X_1627_ _0231_ _0607_ _0627_ VSS VSS VDD VDD _0076_ sky130_fd_sc_hd__o21ai_0
X_1628_ mem\[6\]\[7\] _0804_ _0814_ mem\[5\]\[7\] VSS VSS
+ VDD VDD _0628_ sky130_fd_sc_hd__a22oi_2
X_1629_ _0836_ _0628_ VSS VSS VDD VDD _0629_ sky130_fd_sc_hd__nand2_1
X_1630_ mem\[13\]\[7\] _0178_ _0171_ mem\[1\]\[7\] VSS VSS
+ VDD VDD _0630_ sky130_fd_sc_hd__a22o_1
X_1631_ mem\[3\]\[7\] _0243_ _0629_ _0630_ _0863_ VSS VSS
+ VDD VDD _0631_ sky130_fd_sc_hd__a32oi_2
X_1632_ mem\[14\]\[7\] _0143_ VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__nand2_1
X_1633_ mem\[4\]\[7\] _0245_ _0122_ VSS VSS VDD VDD _0633_
+ sky130_fd_sc_hd__a21oi_1
X_1634_ _0832_ _0632_ _0633_ _0628_ _0276_ VSS VSS VDD VDD
+ _0634_ sky130_fd_sc_hd__a221oi_1
X_1635_ mem\[8\]\[7\] _0838_ _0174_ _0824_ _0634_ VSS VSS
+ VDD VDD _0635_ sky130_fd_sc_hd__a311oi_2
X_1636_ _0276_ mem\[2\]\[7\] _0124_ _0272_ mem\[7\]\[7\] VSS
+ VSS VDD VDD _0636_ sky130_fd_sc_hd__a32o_1
X_1637_ _0849_ mem\[11\]\[7\] mem\[10\]\[7\] _0817_ _0140_
+ mem\[9\]\[7\] VSS VSS VDD VDD _0637_ sky130_fd_sc_hd__a222oi_1
X_1638_ _0224_ mem\[15\]\[7\] mem\[12\]\[7\] _0245_ _0785_
+ VSS VSS VDD VDD _0638_ sky130_fd_sc_hd__a221oi_1
X_1639_ _0848_ _0637_ _0638_ _0869_ VSS VSS VDD VDD _0639_
+ sky130_fd_sc_hd__a211oi_1
X_1640_ _0881_ _0636_ _0639_ VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__a21oi_1
X_1641_ mem\[0\]\[7\] _0309_ VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__nor2_1
X_1642_ _0631_ _0635_ _0640_ _0641_ VSS VSS VDD VDD _0642_
+ sky130_fd_sc_hd__a31oi_4
X_1643_ net105 _0789_ _0793_ _0642_ VSS VSS VDD VDD _0077_
+ sky130_fd_sc_hd__a22o_1
X_1644_ mem\[12\]\[8\] _0850_ _0140_ mem\[13\]\[8\] VSS VSS
+ VDD VDD _0643_ sky130_fd_sc_hd__a22oi_1
X_1645_ mem\[4\]\[8\] _0245_ _0163_ mem\[6\]\[8\] VSS VSS
+ VDD VDD _0644_ sky130_fd_sc_hd__a22oi_1
X_1646_ _0247_ mem\[7\]\[8\] _0199_ VSS VSS VDD VDD _0645_
+ sky130_fd_sc_hd__a21oi_1
X_1647_ _0331_ _0643_ _0644_ _0645_ _0848_ VSS VSS VDD VDD
+ _0646_ sky130_fd_sc_hd__a221oi_1
X_1648_ mem\[2\]\[8\] mem\[10\]\[8\] _0199_ VSS VSS VDD VDD
+ _0647_ sky130_fd_sc_hd__mux2i_1
X_1649_ _0149_ mem\[15\]\[8\] mem\[14\]\[8\] _0182_ VSS VSS
+ VDD VDD _0648_ sky130_fd_sc_hd__a22oi_1
X_1650_ _0165_ _0647_ _0648_ _0857_ VSS VSS VDD VDD _0649_
+ sky130_fd_sc_hd__o22ai_1
X_1651_ mem\[3\]\[8\] mem\[11\]\[8\] _0166_ VSS VSS VDD VDD
+ _0650_ sky130_fd_sc_hd__mux2i_1
X_1652_ mem\[8\]\[8\] _0838_ _0174_ VSS VSS VDD VDD _0651_
+ sky130_fd_sc_hd__nand3_1
X_1653_ _0282_ _0650_ _0651_ VSS VSS VDD VDD _0652_ sky130_fd_sc_hd__o21ai_0
X_1654_ _0646_ _0649_ _0652_ VSS VSS VDD VDD _0653_ sky130_fd_sc_hd__nor3_1
X_1655_ mem\[1\]\[8\] mem\[5\]\[8\] _0867_ VSS VSS VDD VDD
+ _0654_ sky130_fd_sc_hd__mux2i_1
X_1656_ mem\[9\]\[8\] _0174_ VSS VSS VDD VDD _0655_ sky130_fd_sc_hd__nand2_1
X_1657_ _0123_ _0654_ _0655_ VSS VSS VDD VDD _0656_ sky130_fd_sc_hd__o21ai_0
X_1658_ _0863_ _0656_ _0132_ VSS VSS VDD VDD _0657_ sky130_fd_sc_hd__a21oi_1
X_1659_ mem\[0\]\[8\] _0129_ VSS VSS VDD VDD _0658_ sky130_fd_sc_hd__nor2_1
X_1660_ _0653_ _0657_ _0658_ VSS VSS VDD VDD _0659_ sky130_fd_sc_hd__a21oi_4
X_1661_ net106 _0789_ _0793_ _0659_ VSS VSS VDD VDD _0078_
+ sky130_fd_sc_hd__a22o_1
X_1662_ _0832_ mem\[8\]\[9\] _0842_ _0243_ mem\[3\]\[9\] VSS
+ VSS VDD VDD _0660_ sky130_fd_sc_hd__a32oi_1
X_1663_ _0884_ _0660_ VSS VSS VDD VDD _0661_ sky130_fd_sc_hd__nand2_1
X_1664_ _0841_ mem\[7\]\[9\] mem\[4\]\[9\] _0842_ VSS VSS
+ VDD VDD _0662_ sky130_fd_sc_hd__a22oi_1
X_1665_ mem\[5\]\[9\] _0226_ _0154_ VSS VSS VDD VDD _0663_
+ sky130_fd_sc_hd__a21oi_1
X_1666_ _0149_ mem\[15\]\[9\] _0857_ VSS VSS VDD VDD _0664_
+ sky130_fd_sc_hd__a21oi_1
X_1667_ _0662_ _0663_ _0664_ VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__a21oi_1
X_1668_ mem\[12\]\[9\] _0842_ VSS VSS VDD VDD _0666_ sky130_fd_sc_hd__nand2_1
X_1669_ _0224_ mem\[11\]\[9\] mem\[10\]\[9\] _0859_ _0867_
+ VSS VSS VDD VDD _0667_ sky130_fd_sc_hd__a221oi_1
X_1670_ _0840_ _0666_ _0667_ _0869_ VSS VSS VDD VDD _0668_
+ sky130_fd_sc_hd__a211oi_1
X_1671_ _0661_ _0665_ _0668_ VSS VSS VDD VDD _0669_ sky130_fd_sc_hd__a21oi_1
X_1672_ mem\[9\]\[9\] mem\[13\]\[9\] _0207_ VSS VSS VDD VDD
+ _0670_ sky130_fd_sc_hd__mux2i_1
X_1673_ _0162_ _0670_ VSS VSS VDD VDD _0671_ sky130_fd_sc_hd__nand2_1
X_1674_ _0276_ mem\[1\]\[9\] _0832_ VSS VSS VDD VDD _0672_
+ sky130_fd_sc_hd__a21o_1
X_1675_ mem\[2\]\[9\] mem\[6\]\[9\] _0867_ VSS VSS VDD VDD
+ _0673_ sky130_fd_sc_hd__mux2i_1
X_1676_ mem\[14\]\[9\] _0178_ VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__nand2_1
X_1677_ _0133_ _0673_ _0674_ VSS VSS VDD VDD _0675_ sky130_fd_sc_hd__o21ai_2
X_1678_ _0193_ _0671_ _0672_ _0675_ _0860_ VSS VSS VDD VDD
+ _0676_ sky130_fd_sc_hd__a32oi_4
X_1679_ mem\[0\]\[9\] _0309_ VSS VSS VDD VDD _0677_ sky130_fd_sc_hd__nor2_1
X_1680_ _0157_ _0669_ _0676_ _0677_ VSS VSS VDD VDD _0678_
+ sky130_fd_sc_hd__a31oi_4
X_1681_ net107 _0789_ _0793_ _0678_ VSS VSS VDD VDD _0079_
+ sky130_fd_sc_hd__a22o_1
X_1682_ net72 _0752_ VSS VSS VDD VDD _0679_ sky130_fd_sc_hd__nand2b_1
X_1683_ _0679_ VSS VSS VDD VDD _0680_ sky130_fd_sc_hd__clkbuf_2
X_1684_ net38 _0759_ VSS VSS VDD VDD _0681_ sky130_fd_sc_hd__nand2_1
X_1685_ _0680_ _0681_ VSS VSS VDD VDD _0682_ sky130_fd_sc_hd__nor2_1
X_1686_ _0777_ _0878_ _0753_ VSS VSS VDD VDD _0683_ sky130_fd_sc_hd__mux2i_1
X_1687_ _0754_ _0786_ VSS VSS VDD VDD _0684_ sky130_fd_sc_hd__nand2_1
X_1688_ _0744_ _0775_ _0776_ _0684_ VSS VSS VDD VDD _0685_
+ sky130_fd_sc_hd__a31oi_4
X_1689_ _0825_ _0685_ VSS VSS VDD VDD _0686_ sky130_fd_sc_hd__and2_0
X_1690_ net108 _0680_ _0682_ _0683_ _0686_ VSS VSS VDD VDD
+ _0080_ sky130_fd_sc_hd__a221o_1
X_1691_ _0754_ _0777_ _0786_ VSS VSS VDD VDD _0687_ sky130_fd_sc_hd__nand3_4
X_1692_ _0680_ VSS VSS VDD VDD _0688_ sky130_fd_sc_hd__clkbuf_4
X_1693_ net109 _0688_ VSS VSS VDD VDD _0689_ sky130_fd_sc_hd__nand2_1
X_1694_ _0131_ _0687_ _0689_ VSS VSS VDD VDD _0081_ sky130_fd_sc_hd__o21ai_0
X_1695_ _0685_ VSS VSS VDD VDD _0690_ sky130_fd_sc_hd__clkbuf_4
X_1696_ net110 _0688_ _0159_ _0690_ VSS VSS VDD VDD _0082_
+ sky130_fd_sc_hd__a22o_1
X_1697_ net111 _0688_ _0189_ _0690_ VSS VSS VDD VDD _0083_
+ sky130_fd_sc_hd__a22o_1
X_1698_ net112 _0688_ _0212_ _0690_ VSS VSS VDD VDD _0084_
+ sky130_fd_sc_hd__a22o_1
X_1699_ net113 _0688_ _0230_ _0690_ VSS VSS VDD VDD _0085_
+ sky130_fd_sc_hd__a22o_1
X_1700_ mem\[0\]\[15\] _0831_ _0254_ VSS VSS VDD VDD _0691_
+ sky130_fd_sc_hd__o21ai_0
X_1701_ net114 _0688_ VSS VSS VDD VDD _0692_ sky130_fd_sc_hd__nand2_1
X_1702_ _0691_ _0687_ _0692_ VSS VSS VDD VDD _0086_ sky130_fd_sc_hd__o21ai_0
X_1703_ _0680_ VSS VSS VDD VDD _0693_ sky130_fd_sc_hd__buf_4
X_1704_ net115 _0693_ _0270_ _0690_ VSS VSS VDD VDD _0087_
+ sky130_fd_sc_hd__a22o_1
X_1705_ net116 _0693_ _0291_ _0690_ VSS VSS VDD VDD _0088_
+ sky130_fd_sc_hd__a22o_1
X_1706_ net117 _0693_ _0311_ _0690_ VSS VSS VDD VDD _0089_
+ sky130_fd_sc_hd__a22o_1
X_1707_ net118 _0693_ _0329_ _0690_ VSS VSS VDD VDD _0090_
+ sky130_fd_sc_hd__a22o_1
X_1708_ _0753_ _0680_ _0681_ VSS VSS VDD VDD _0694_ sky130_fd_sc_hd__nor3_1
X_1709_ _0753_ _0875_ _0786_ VSS VSS VDD VDD _0695_ sky130_fd_sc_hd__nand3_1
X_1710_ net119 _0680_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__nand2_1
X_1711_ _0681_ _0695_ _0696_ VSS VSS VDD VDD _0697_ sky130_fd_sc_hd__o21ai_0
X_1712_ _0349_ _0685_ _0694_ net75 _0697_ VSS VSS VDD VDD
+ _0091_ sky130_fd_sc_hd__a221o_1
X_1713_ net120 _0693_ _0364_ _0690_ VSS VSS VDD VDD _0092_
+ sky130_fd_sc_hd__a22o_1
X_1714_ net121 _0693_ _0379_ _0690_ VSS VSS VDD VDD _0093_
+ sky130_fd_sc_hd__a22o_1
X_1715_ _0685_ VSS VSS VDD VDD _0698_ sky130_fd_sc_hd__clkbuf_4
X_1716_ net122 _0693_ _0395_ _0698_ VSS VSS VDD VDD _0094_
+ sky130_fd_sc_hd__a22o_1
X_1717_ net123 _0693_ _0409_ _0698_ VSS VSS VDD VDD _0095_
+ sky130_fd_sc_hd__a22o_1
X_1718_ net124 _0693_ _0423_ _0698_ VSS VSS VDD VDD _0096_
+ sky130_fd_sc_hd__a22o_1
X_1719_ net125 _0693_ _0440_ _0698_ VSS VSS VDD VDD _0097_
+ sky130_fd_sc_hd__a22o_1
X_1720_ _0680_ VSS VSS VDD VDD _0699_ sky130_fd_sc_hd__clkbuf_4
X_1721_ net126 _0699_ _0457_ _0698_ VSS VSS VDD VDD _0098_
+ sky130_fd_sc_hd__a22o_1
X_1722_ mem\[0\]\[27\] _0831_ _0471_ VSS VSS VDD VDD _0700_
+ sky130_fd_sc_hd__o21ai_0
X_1723_ net127 _0688_ VSS VSS VDD VDD _0701_ sky130_fd_sc_hd__nand2_1
X_1724_ _0700_ _0687_ _0701_ VSS VSS VDD VDD _0099_ sky130_fd_sc_hd__o21ai_0
X_1725_ net128 _0699_ _0488_ _0698_ VSS VSS VDD VDD _0100_
+ sky130_fd_sc_hd__a22o_1
X_1726_ net129 _0699_ _0508_ _0698_ VSS VSS VDD VDD _0101_
+ sky130_fd_sc_hd__a22o_1
X_1727_ net130 _0680_ VSS VSS VDD VDD _0702_ sky130_fd_sc_hd__nand2_1
X_1728_ _0758_ _0699_ VSS VSS VDD VDD _0703_ sky130_fd_sc_hd__nor2_1
X_1729_ _0759_ _0703_ VSS VSS VDD VDD _0704_ sky130_fd_sc_hd__nand2_1
X_1730_ _0878_ _0875_ VSS VSS VDD VDD _0705_ sky130_fd_sc_hd__xor2_1
X_1731_ _0753_ _0774_ _0681_ _0705_ VSS VSS VDD VDD _0706_
+ sky130_fd_sc_hd__nor4_1
X_1732_ net38 _0753_ _0759_ VSS VSS VDD VDD _0707_ sky130_fd_sc_hd__nand3_1
X_1733_ _0745_ _0707_ _0702_ VSS VSS VDD VDD _0708_ sky130_fd_sc_hd__o21ai_0
X_1734_ _0744_ _0776_ _0706_ _0708_ VSS VSS VDD VDD _0709_
+ sky130_fd_sc_hd__a31oi_1
X_1735_ _0754_ _0777_ _0526_ VSS VSS VDD VDD _0710_ sky130_fd_sc_hd__nand3_1
X_1736_ _0702_ _0704_ _0709_ _0710_ VSS VSS VDD VDD _0102_
+ sky130_fd_sc_hd__a22oi_1
X_1737_ net131 _0688_ VSS VSS VDD VDD _0711_ sky130_fd_sc_hd__nand2_1
X_1738_ _0540_ _0687_ _0711_ VSS VSS VDD VDD _0103_ sky130_fd_sc_hd__o21ai_0
X_1739_ net132 _0699_ _0558_ _0698_ VSS VSS VDD VDD _0104_
+ sky130_fd_sc_hd__a22o_1
X_1740_ _0875_ _0774_ _0753_ VSS VSS VDD VDD _0712_ sky130_fd_sc_hd__a21oi_1
X_1741_ _0753_ _0744_ _0776_ _0712_ VSS VSS VDD VDD _0713_
+ sky130_fd_sc_hd__o22ai_1
X_1742_ net133 _0699_ _0572_ _0685_ _0682_ _0713_ VSS VSS
+ VDD VDD _0714_ sky130_fd_sc_hd__a222oi_1
X_1743_ _0714_ VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__inv_1
X_1744_ _0587_ _0685_ VSS VSS VDD VDD _0715_ sky130_fd_sc_hd__nand2_1
X_1745_ net134 _0688_ VSS VSS VDD VDD _0716_ sky130_fd_sc_hd__nand2_1
X_1746_ _0744_ _0680_ _0707_ _0715_ _0716_ VSS VSS VDD VDD
+ _0106_ sky130_fd_sc_hd__o311ai_0
X_1747_ net135 _0699_ _0606_ _0698_ VSS VSS VDD VDD _0107_
+ sky130_fd_sc_hd__a22o_1
X_1748_ mem\[0\]\[6\] _0831_ _0626_ VSS VSS VDD VDD _0717_
+ sky130_fd_sc_hd__o21ai_0
X_1749_ net136 _0688_ VSS VSS VDD VDD _0718_ sky130_fd_sc_hd__nand2_1
X_1750_ _0717_ _0687_ _0718_ VSS VSS VDD VDD _0108_ sky130_fd_sc_hd__o21ai_0
X_1751_ net137 _0699_ _0642_ _0698_ VSS VSS VDD VDD _0109_
+ sky130_fd_sc_hd__a22o_1
X_1752_ net138 _0699_ _0659_ _0685_ VSS VSS VDD VDD _0110_
+ sky130_fd_sc_hd__a22o_1
X_1753_ net139 _0699_ _0678_ _0685_ VSS VSS VDD VDD _0111_
+ sky130_fd_sc_hd__a22o_1
X_1754_ rd_ptr\[0\] _0827_ VSS VSS VDD VDD _0719_ sky130_fd_sc_hd__xnor2_1
X_1755_ _0764_ _0719_ VSS VSS VDD VDD _0112_ sky130_fd_sc_hd__nor2_1
X_1756_ _0889_ _0826_ _0231_ VSS VSS VDD VDD _0720_ sky130_fd_sc_hd__nand3_1
X_1757_ _0872_ _0764_ _0231_ _0720_ VSS VSS VDD VDD _0113_
+ sky130_fd_sc_hd__o31ai_1
X_1758_ _0218_ _0827_ _0884_ VSS VSS VDD VDD _0721_ sky130_fd_sc_hd__a21o_1
X_1759_ _0884_ _0218_ _0827_ VSS VSS VDD VDD _0722_ sky130_fd_sc_hd__nand3_1
X_1760_ _0721_ _0722_ _0764_ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__a21oi_1
X_1761_ _0833_ _0763_ VSS VSS VDD VDD _0723_ sky130_fd_sc_hd__nor2_1
X_1762_ _0881_ _0763_ VSS VSS VDD VDD _0724_ sky130_fd_sc_hd__nor2_1
X_1763_ _0198_ rd_ptr\[0\] rd_ptr\[1\] _0827_ VSS VSS VDD
+ VDD _0725_ sky130_fd_sc_hd__nand4_1
X_1764_ _0723_ _0724_ _0725_ VSS VSS VDD VDD _0115_ sky130_fd_sc_hd__mux2_1
X_1765_ rd_ptr\[4\] _0763_ VSS VSS VDD VDD _0726_ sky130_fd_sc_hd__nor2_1
X_1766_ rd_ptr\[4\] _0791_ VSS VSS VDD VDD _0727_ sky130_fd_sc_hd__nand2_1
X_1767_ _0827_ _0303_ _0727_ VSS VSS VDD VDD _0728_ sky130_fd_sc_hd__a21oi_1
X_1768_ _0827_ _0303_ _0726_ _0728_ VSS VSS VDD VDD _0116_
+ sky130_fd_sc_hd__a31o_1
X_1769_ _0876_ _0756_ VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__xnor2_1
X_1770_ _0764_ _0729_ VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__nor2_1
X_1771_ _0898_ _0791_ VSS VSS VDD VDD _0730_ sky130_fd_sc_hd__nand2_1
X_1772_ wr_ptr\[1\] _0757_ _0826_ VSS VSS VDD VDD _0731_ sky130_fd_sc_hd__nand3_1
X_1773_ _0757_ _0730_ _0731_ VSS VSS VDD VDD _0118_ sky130_fd_sc_hd__o21ai_0
X_1774_ _0903_ VSS VSS VDD VDD _0732_ sky130_fd_sc_hd__inv_1
X_1775_ _0732_ _0756_ wr_ptr\[2\] VSS VSS VDD VDD _0733_ sky130_fd_sc_hd__o21ai_0
X_1776_ wr_ptr\[2\] _0732_ _0756_ VSS VSS VDD VDD _0734_ sky130_fd_sc_hd__or3_1
X_1777_ _0733_ _0734_ _0764_ VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__a21oi_1
X_1778_ wr_ptr\[2\] wr_ptr\[0\] wr_ptr\[1\] VSS VSS VDD VDD
+ _0735_ sky130_fd_sc_hd__nand3_1
X_1779_ _0756_ _0735_ _0766_ VSS VSS VDD VDD _0736_ sky130_fd_sc_hd__o21ai_0
X_1780_ _0766_ _0756_ _0735_ VSS VSS VDD VDD _0737_ sky130_fd_sc_hd__or3_1
X_1781_ _0736_ _0737_ _0764_ VSS VSS VDD VDD _0120_ sky130_fd_sc_hd__a21oi_1
X_1782_ wr_ptr\[2\] _0766_ _0903_ VSS VSS VDD VDD _0738_ sky130_fd_sc_hd__nand3_1
X_1783_ _0756_ _0738_ wr_ptr\[4\] VSS VSS VDD VDD _0739_ sky130_fd_sc_hd__o21ai_0
X_1784_ wr_ptr\[4\] _0756_ _0738_ VSS VSS VDD VDD _0740_ sky130_fd_sc_hd__or3_1
X_1785_ _0739_ _0740_ _0764_ VSS VSS VDD VDD _0121_ sky130_fd_sc_hd__a21oi_1
X_1786_ _0872_ wr_ptr\[1\] _0873_ VSS VSS VDD VDD _0874_ _0875_
+ sky130_fd_sc_hd__fa_4
X_1787_ rd_ptr\[0\] _0876_ VSS VSS VDD VDD _0877_ _0878_ sky130_fd_sc_hd__ha_1
X_1788_ _0872_ wr_ptr\[1\] VSS VSS VDD VDD _0879_ _0880_ sky130_fd_sc_hd__ha_1
X_1789_ _0881_ wr_ptr\[3\] VSS VSS VDD VDD _0882_ _0883_ sky130_fd_sc_hd__ha_2
X_1790_ _0884_ wr_ptr\[2\] VSS VSS VDD VDD _0885_ _0886_ sky130_fd_sc_hd__ha_1
X_1791_ _0887_ _0872_ VSS VSS VDD VDD _0888_ _0889_ sky130_fd_sc_hd__ha_2
X_1792_ _0887_ rd_ptr\[1\] VSS VSS VDD VDD _0890_ _0891_ sky130_fd_sc_hd__ha_1
X_1793_ rd_ptr\[0\] _0872_ VSS VSS VDD VDD _0892_ _0893_ sky130_fd_sc_hd__ha_1
X_1794_ rd_ptr\[0\] rd_ptr\[1\] VSS VSS VDD VDD _0894_ _0895_
+ sky130_fd_sc_hd__ha_2
X_1795_ _0876_ _0896_ VSS VSS VDD VDD _0897_ _0898_ sky130_fd_sc_hd__ha_1
X_1796_ _0876_ wr_ptr\[1\] VSS VSS VDD VDD _0899_ _0900_ sky130_fd_sc_hd__ha_1
X_1797_ wr_ptr\[0\] _0896_ VSS VSS VDD VDD _0901_ _0902_ sky130_fd_sc_hd__ha_1
X_1798_ wr_ptr\[0\] wr_ptr\[1\] VSS VSS VDD VDD _0903_ _0904_
+ sky130_fd_sc_hd__ha_1
Xext_data_reg\[0\]$_DFFE_PN0P_ clknet_leaf_37_clk _0048_ net1
+ VSS VSS VDD VDD net76 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[10\]$_DFFE_PN0P_ clknet_leaf_27_clk _0049_
+ net1 VSS VSS VDD VDD net77 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[11\]$_DFFE_PN0P_ clknet_leaf_29_clk _0050_
+ net1 VSS VSS VDD VDD net78 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[12\]$_DFFE_PN0P_ clknet_leaf_27_clk _0051_
+ net1 VSS VSS VDD VDD net79 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[13\]$_DFFE_PN0P_ clknet_leaf_29_clk _0052_
+ net1 VSS VSS VDD VDD net80 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[14\]$_DFFE_PN0P_ clknet_leaf_29_clk _0053_
+ net1 VSS VSS VDD VDD net81 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[15\]$_DFFE_PN0P_ clknet_leaf_27_clk _0054_
+ net1 VSS VSS VDD VDD net82 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[16\]$_DFFE_PN0P_ clknet_leaf_37_clk _0055_
+ net1 VSS VSS VDD VDD net83 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[17\]$_DFFE_PN0P_ clknet_leaf_27_clk _0056_
+ net1 VSS VSS VDD VDD net84 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[18\]$_DFFE_PN0P_ clknet_leaf_36_clk _0057_
+ net1 VSS VSS VDD VDD net85 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[19\]$_DFFE_PN0P_ clknet_leaf_27_clk _0058_
+ net1 VSS VSS VDD VDD net86 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[1\]$_DFFE_PN0P_ clknet_leaf_37_clk _0059_ net1
+ VSS VSS VDD VDD net87 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[20\]$_DFFE_PN0P_ clknet_leaf_36_clk _0060_
+ net1 VSS VSS VDD VDD net88 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[21\]$_DFFE_PN0P_ clknet_leaf_36_clk _0061_
+ net1 VSS VSS VDD VDD net89 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[22\]$_DFFE_PN0P_ clknet_leaf_36_clk _0062_
+ net1 VSS VSS VDD VDD net90 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[23\]$_DFFE_PN0P_ clknet_leaf_37_clk _0063_
+ net1 VSS VSS VDD VDD net91 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[24\]$_DFFE_PN0P_ clknet_leaf_38_clk _0064_
+ net1 VSS VSS VDD VDD net92 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[25\]$_DFFE_PN0P_ clknet_leaf_29_clk _0065_
+ net1 VSS VSS VDD VDD net93 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[26\]$_DFFE_PN0P_ clknet_leaf_29_clk _0066_
+ net1 VSS VSS VDD VDD net94 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[27\]$_DFFE_PN0P_ clknet_leaf_27_clk _0067_
+ net1 VSS VSS VDD VDD net95 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[28\]$_DFFE_PN0P_ clknet_leaf_29_clk _0068_
+ net1 VSS VSS VDD VDD net96 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[29\]$_DFFE_PN0P_ clknet_leaf_30_clk _0069_
+ net1 VSS VSS VDD VDD net97 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[2\]$_DFFE_PN0P_ clknet_leaf_29_clk _0070_ net1
+ VSS VSS VDD VDD net98 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[30\]$_DFFE_PN0P_ clknet_leaf_38_clk _0071_
+ net1 VSS VSS VDD VDD net99 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[31\]$_DFFE_PN0P_ clknet_leaf_37_clk _0072_
+ net1 VSS VSS VDD VDD net100 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[3\]$_DFFE_PN0P_ clknet_leaf_39_clk _0073_ net1
+ VSS VSS VDD VDD net101 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[4\]$_DFFE_PN0P_ clknet_leaf_37_clk _0074_ net1
+ VSS VSS VDD VDD net102 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[5\]$_DFFE_PN0P_ clknet_leaf_30_clk _0075_ net1
+ VSS VSS VDD VDD net103 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[6\]$_DFFE_PN0P_ clknet_leaf_30_clk _0076_ net1
+ VSS VSS VDD VDD net104 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[7\]$_DFFE_PN0P_ clknet_leaf_38_clk _0077_ net1
+ VSS VSS VDD VDD net105 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[8\]$_DFFE_PN0P_ clknet_leaf_30_clk _0078_ net1
+ VSS VSS VDD VDD net106 sky130_fd_sc_hd__dfrtp_1
Xext_data_reg\[9\]$_DFFE_PN0P_ clknet_leaf_30_clk _0079_ net1
+ VSS VSS VDD VDD net107 sky130_fd_sc_hd__dfrtp_1
Xmem\[0\]\[0\]$_DFFE_PP_ clknet_leaf_43_clk _0016_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[10\]$_DFFE_PP_ clknet_leaf_17_clk _0017_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[11\]$_DFFE_PP_ clknet_leaf_22_clk _0018_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[12\]$_DFFE_PP_ clknet_leaf_26_clk _0019_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[13\]$_DFFE_PP_ clknet_leaf_7_clk _0020_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[14\]$_DFFE_PP_ clknet_leaf_20_clk _0021_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[15\]$_DFFE_PP_ clknet_leaf_26_clk _0022_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[16\]$_DFFE_PP_ clknet_leaf_4_clk _0023_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[17\]$_DFFE_PP_ clknet_leaf_15_clk _0024_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[18\]$_DFFE_PP_ clknet_leaf_7_clk _0025_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[19\]$_DFFE_PP_ clknet_leaf_28_clk _0026_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[1\]$_DFFE_PP_ clknet_leaf_35_clk _0027_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[20\]$_DFFE_PP_ clknet_leaf_34_clk _0028_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[22\]$_DFFE_PP_ clknet_leaf_45_clk _0030_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[23\]$_DFFE_PP_ clknet_leaf_46_clk _0031_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[24\]$_DFFE_PP_ clknet_leaf_4_clk _0032_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[25\]$_DFFE_PP_ clknet_leaf_7_clk _0033_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk _0034_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[27\]$_DFFE_PP_ clknet_leaf_26_clk _0035_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[28\]$_DFFE_PP_ clknet_leaf_8_clk _0036_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[29\]$_DFFE_PP_ clknet_leaf_36_clk _0037_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[2\]$_DFFE_PP_ clknet_leaf_31_clk _0038_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[30\]$_DFFE_PP_ clknet_leaf_1_clk _0039_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[31\]$_DFFE_PP_ clknet_leaf_35_clk _0040_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[3\]$_DFFE_PP_ clknet_leaf_47_clk _0041_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[4\]$_DFFE_PP_ clknet_leaf_4_clk _0042_ _0015_ VSS
+ VSS VDD VDD mem\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[5\]$_DFFE_PP_ clknet_leaf_30_clk _0043_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[6\]$_DFFE_PP_ clknet_leaf_28_clk _0044_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[7\]$_DFFE_PP_ clknet_leaf_45_clk _0045_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[9\]$_DFFE_PP_ clknet_leaf_18_clk _0047_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[0\]$_DFFE_PP_ clknet_leaf_40_clk _0016_ net155
+ VSS VSS VDD VDD mem\[10\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[10\]$_DFFE_PP_ clknet_leaf_17_clk _0017_ net155
+ VSS VSS VDD VDD mem\[10\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[11\]$_DFFE_PP_ clknet_leaf_19_clk _0018_ net154
+ VSS VSS VDD VDD mem\[10\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[12\]$_DFFE_PP_ clknet_leaf_23_clk _0019_ net155
+ VSS VSS VDD VDD mem\[10\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[13\]$_DFFE_PP_ clknet_leaf_3_clk _0020_ net153
+ VSS VSS VDD VDD mem\[10\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[14\]$_DFFE_PP_ clknet_leaf_20_clk _0021_ net154
+ VSS VSS VDD VDD mem\[10\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[15\]$_DFFE_PP_ clknet_leaf_18_clk _0022_ net154
+ VSS VSS VDD VDD mem\[10\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[16\]$_DFFE_PP_ clknet_leaf_4_clk _0023_ net153
+ VSS VSS VDD VDD mem\[10\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[17\]$_DFFE_PP_ clknet_leaf_12_clk _0024_ net153
+ VSS VSS VDD VDD mem\[10\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[18\]$_DFFE_PP_ clknet_leaf_9_clk _0025_ net153
+ VSS VSS VDD VDD mem\[10\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[19\]$_DFFE_PP_ clknet_leaf_25_clk _0026_ net155
+ VSS VSS VDD VDD mem\[10\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[1\]$_DFFE_PP_ clknet_leaf_42_clk _0027_ _0005_
+ VSS VSS VDD VDD mem\[10\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[20\]$_DFFE_PP_ clknet_leaf_45_clk _0028_ net154
+ VSS VSS VDD VDD mem\[10\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[21\]$_DFFE_PP_ clknet_leaf_1_clk _0029_ _0005_
+ VSS VSS VDD VDD mem\[10\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[22\]$_DFFE_PP_ clknet_leaf_45_clk _0030_ net154
+ VSS VSS VDD VDD mem\[10\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[23\]$_DFFE_PP_ clknet_leaf_49_clk _0031_ _0005_
+ VSS VSS VDD VDD mem\[10\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[24\]$_DFFE_PP_ clknet_leaf_52_clk _0032_ _0005_
+ VSS VSS VDD VDD mem\[10\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[25\]$_DFFE_PP_ clknet_leaf_11_clk _0033_ net153
+ VSS VSS VDD VDD mem\[10\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[26\]$_DFFE_PP_ clknet_leaf_11_clk _0034_ net153
+ VSS VSS VDD VDD mem\[10\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[27\]$_DFFE_PP_ clknet_leaf_24_clk _0035_ net155
+ VSS VSS VDD VDD mem\[10\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0036_ net153
+ VSS VSS VDD VDD mem\[10\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[29\]$_DFFE_PP_ clknet_leaf_44_clk _0037_ net154
+ VSS VSS VDD VDD mem\[10\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[2\]$_DFFE_PP_ clknet_leaf_31_clk _0038_ net155
+ VSS VSS VDD VDD mem\[10\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[30\]$_DFFE_PP_ clknet_leaf_51_clk _0039_ net153
+ VSS VSS VDD VDD mem\[10\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk _0040_ net154
+ VSS VSS VDD VDD mem\[10\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ _0005_
+ VSS VSS VDD VDD mem\[10\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[4\]$_DFFE_PP_ clknet_leaf_4_clk _0042_ _0005_
+ VSS VSS VDD VDD mem\[10\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[5\]$_DFFE_PP_ clknet_leaf_6_clk _0043_ net154
+ VSS VSS VDD VDD mem\[10\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[6\]$_DFFE_PP_ clknet_leaf_25_clk _0044_ net155
+ VSS VSS VDD VDD mem\[10\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[7\]$_DFFE_PP_ clknet_leaf_49_clk _0045_ _0005_
+ VSS VSS VDD VDD mem\[10\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ net153
+ VSS VSS VDD VDD mem\[10\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[9\]$_DFFE_PP_ clknet_leaf_8_clk _0047_ net154
+ VSS VSS VDD VDD mem\[10\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[0\]$_DFFE_PP_ clknet_leaf_40_clk _0016_ _0004_
+ VSS VSS VDD VDD mem\[11\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[10\]$_DFFE_PP_ clknet_leaf_18_clk _0017_ net156
+ VSS VSS VDD VDD mem\[11\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[11\]$_DFFE_PP_ clknet_leaf_23_clk _0018_ net158
+ VSS VSS VDD VDD mem\[11\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[12\]$_DFFE_PP_ clknet_leaf_24_clk _0019_ net158
+ VSS VSS VDD VDD mem\[11\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[13\]$_DFFE_PP_ clknet_leaf_3_clk _0020_ net157
+ VSS VSS VDD VDD mem\[11\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[14\]$_DFFE_PP_ clknet_leaf_19_clk _0021_ net156
+ VSS VSS VDD VDD mem\[11\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[15\]$_DFFE_PP_ clknet_leaf_22_clk _0022_ net158
+ VSS VSS VDD VDD mem\[11\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[16\]$_DFFE_PP_ clknet_leaf_3_clk _0023_ net157
+ VSS VSS VDD VDD mem\[11\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[17\]$_DFFE_PP_ clknet_leaf_13_clk _0024_ net157
+ VSS VSS VDD VDD mem\[11\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[18\]$_DFFE_PP_ clknet_leaf_5_clk _0025_ net156
+ VSS VSS VDD VDD mem\[11\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[19\]$_DFFE_PP_ clknet_leaf_22_clk _0026_ net158
+ VSS VSS VDD VDD mem\[11\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[1\]$_DFFE_PP_ clknet_leaf_42_clk _0027_ _0004_
+ VSS VSS VDD VDD mem\[11\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[20\]$_DFFE_PP_ clknet_leaf_41_clk _0028_ _0004_
+ VSS VSS VDD VDD mem\[11\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[21\]$_DFFE_PP_ clknet_leaf_2_clk _0029_ net157
+ VSS VSS VDD VDD mem\[11\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[22\]$_DFFE_PP_ clknet_leaf_45_clk _0030_ net156
+ VSS VSS VDD VDD mem\[11\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[23\]$_DFFE_PP_ clknet_leaf_46_clk _0031_ net156
+ VSS VSS VDD VDD mem\[11\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[24\]$_DFFE_PP_ clknet_leaf_51_clk _0032_ net157
+ VSS VSS VDD VDD mem\[11\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[25\]$_DFFE_PP_ clknet_leaf_10_clk _0033_ net157
+ VSS VSS VDD VDD mem\[11\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk _0034_ net157
+ VSS VSS VDD VDD mem\[11\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk _0035_ net156
+ VSS VSS VDD VDD mem\[11\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0036_ net157
+ VSS VSS VDD VDD mem\[11\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[29\]$_DFFE_PP_ clknet_leaf_44_clk _0037_ net158
+ VSS VSS VDD VDD mem\[11\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[2\]$_DFFE_PP_ clknet_leaf_32_clk _0038_ net158
+ VSS VSS VDD VDD mem\[11\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[30\]$_DFFE_PP_ clknet_leaf_1_clk _0039_ net157
+ VSS VSS VDD VDD mem\[11\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[31\]$_DFFE_PP_ clknet_leaf_44_clk _0040_ net158
+ VSS VSS VDD VDD mem\[11\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[3\]$_DFFE_PP_ clknet_leaf_49_clk _0041_ _0004_
+ VSS VSS VDD VDD mem\[11\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[4\]$_DFFE_PP_ clknet_leaf_1_clk _0042_ net157
+ VSS VSS VDD VDD mem\[11\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[5\]$_DFFE_PP_ clknet_leaf_6_clk _0043_ net156
+ VSS VSS VDD VDD mem\[11\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[6\]$_DFFE_PP_ clknet_leaf_21_clk _0044_ net158
+ VSS VSS VDD VDD mem\[11\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[7\]$_DFFE_PP_ clknet_leaf_49_clk _0045_ _0004_
+ VSS VSS VDD VDD mem\[11\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[8\]$_DFFE_PP_ clknet_leaf_13_clk _0046_ net157
+ VSS VSS VDD VDD mem\[11\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[9\]$_DFFE_PP_ clknet_leaf_8_clk _0047_ net156
+ VSS VSS VDD VDD mem\[11\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[0\]$_DFFE_PP_ clknet_leaf_41_clk _0016_ net161
+ VSS VSS VDD VDD mem\[12\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[10\]$_DFFE_PP_ clknet_leaf_17_clk _0017_ net159
+ VSS VSS VDD VDD mem\[12\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[11\]$_DFFE_PP_ clknet_leaf_22_clk _0018_ net159
+ VSS VSS VDD VDD mem\[12\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[12\]$_DFFE_PP_ clknet_leaf_25_clk _0019_ net159
+ VSS VSS VDD VDD mem\[12\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[13\]$_DFFE_PP_ clknet_leaf_7_clk _0020_ net160
+ VSS VSS VDD VDD mem\[12\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[14\]$_DFFE_PP_ clknet_leaf_20_clk _0021_ net159
+ VSS VSS VDD VDD mem\[12\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[15\]$_DFFE_PP_ clknet_leaf_17_clk _0022_ net159
+ VSS VSS VDD VDD mem\[12\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[16\]$_DFFE_PP_ clknet_leaf_9_clk _0023_ net160
+ VSS VSS VDD VDD mem\[12\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[17\]$_DFFE_PP_ clknet_leaf_15_clk _0024_ net159
+ VSS VSS VDD VDD mem\[12\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[18\]$_DFFE_PP_ clknet_leaf_7_clk _0025_ net160
+ VSS VSS VDD VDD mem\[12\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[19\]$_DFFE_PP_ clknet_leaf_25_clk _0026_ net159
+ VSS VSS VDD VDD mem\[12\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[1\]$_DFFE_PP_ clknet_leaf_41_clk _0027_ net161
+ VSS VSS VDD VDD mem\[12\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[20\]$_DFFE_PP_ clknet_leaf_34_clk _0028_ _0003_
+ VSS VSS VDD VDD mem\[12\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[21\]$_DFFE_PP_ clknet_leaf_46_clk _0029_ net161
+ VSS VSS VDD VDD mem\[12\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[22\]$_DFFE_PP_ clknet_leaf_6_clk _0030_ net160
+ VSS VSS VDD VDD mem\[12\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[23\]$_DFFE_PP_ clknet_leaf_49_clk _0031_ net161
+ VSS VSS VDD VDD mem\[12\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[24\]$_DFFE_PP_ clknet_leaf_51_clk _0032_ net161
+ VSS VSS VDD VDD mem\[12\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[25\]$_DFFE_PP_ clknet_leaf_11_clk _0033_ net160
+ VSS VSS VDD VDD mem\[12\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk _0034_ net160
+ VSS VSS VDD VDD mem\[12\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[27\]$_DFFE_PP_ clknet_leaf_24_clk _0035_ net159
+ VSS VSS VDD VDD mem\[12\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0036_ net160
+ VSS VSS VDD VDD mem\[12\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[29\]$_DFFE_PP_ clknet_leaf_33_clk _0037_ net160
+ VSS VSS VDD VDD mem\[12\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[2\]$_DFFE_PP_ clknet_leaf_33_clk _0038_ net159
+ VSS VSS VDD VDD mem\[12\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[30\]$_DFFE_PP_ clknet_leaf_51_clk _0039_ net161
+ VSS VSS VDD VDD mem\[12\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[31\]$_DFFE_PP_ clknet_leaf_41_clk _0040_ net161
+ VSS VSS VDD VDD mem\[12\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ net161
+ VSS VSS VDD VDD mem\[12\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[4\]$_DFFE_PP_ clknet_leaf_1_clk _0042_ net161
+ VSS VSS VDD VDD mem\[12\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[5\]$_DFFE_PP_ clknet_leaf_32_clk _0043_ _0003_
+ VSS VSS VDD VDD mem\[12\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[6\]$_DFFE_PP_ clknet_leaf_21_clk _0044_ net159
+ VSS VSS VDD VDD mem\[12\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[7\]$_DFFE_PP_ clknet_leaf_47_clk _0045_ net161
+ VSS VSS VDD VDD mem\[12\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ net159
+ VSS VSS VDD VDD mem\[12\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[9\]$_DFFE_PP_ clknet_leaf_15_clk _0047_ net160
+ VSS VSS VDD VDD mem\[12\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[0\]$_DFFE_PP_ clknet_leaf_40_clk _0016_ net149
+ VSS VSS VDD VDD mem\[13\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[10\]$_DFFE_PP_ clknet_leaf_17_clk _0017_ net148
+ VSS VSS VDD VDD mem\[13\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[11\]$_DFFE_PP_ clknet_leaf_18_clk _0018_ net148
+ VSS VSS VDD VDD mem\[13\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[12\]$_DFFE_PP_ clknet_leaf_24_clk _0019_ net148
+ VSS VSS VDD VDD mem\[13\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[13\]$_DFFE_PP_ clknet_leaf_7_clk _0020_ net147
+ VSS VSS VDD VDD mem\[13\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[14\]$_DFFE_PP_ clknet_leaf_32_clk _0021_ _0002_
+ VSS VSS VDD VDD mem\[13\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[15\]$_DFFE_PP_ clknet_leaf_23_clk _0022_ net148
+ VSS VSS VDD VDD mem\[13\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[16\]$_DFFE_PP_ clknet_leaf_4_clk _0023_ net147
+ VSS VSS VDD VDD mem\[13\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[17\]$_DFFE_PP_ clknet_leaf_14_clk _0024_ net148
+ VSS VSS VDD VDD mem\[13\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[18\]$_DFFE_PP_ clknet_leaf_5_clk _0025_ net147
+ VSS VSS VDD VDD mem\[13\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[19\]$_DFFE_PP_ clknet_leaf_24_clk _0026_ net148
+ VSS VSS VDD VDD mem\[13\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[1\]$_DFFE_PP_ clknet_leaf_35_clk _0027_ _0002_
+ VSS VSS VDD VDD mem\[13\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[20\]$_DFFE_PP_ clknet_leaf_34_clk _0028_ _0002_
+ VSS VSS VDD VDD mem\[13\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ net147
+ VSS VSS VDD VDD mem\[13\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[22\]$_DFFE_PP_ clknet_leaf_45_clk _0030_ net147
+ VSS VSS VDD VDD mem\[13\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[23\]$_DFFE_PP_ clknet_leaf_49_clk _0031_ net149
+ VSS VSS VDD VDD mem\[13\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[24\]$_DFFE_PP_ clknet_leaf_52_clk _0032_ net149
+ VSS VSS VDD VDD mem\[13\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[25\]$_DFFE_PP_ clknet_leaf_11_clk _0033_ net147
+ VSS VSS VDD VDD mem\[13\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[26\]$_DFFE_PP_ clknet_leaf_11_clk _0034_ net147
+ VSS VSS VDD VDD mem\[13\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk _0035_ net148
+ VSS VSS VDD VDD mem\[13\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0036_ net147
+ VSS VSS VDD VDD mem\[13\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[29\]$_DFFE_PP_ clknet_leaf_33_clk _0037_ _0002_
+ VSS VSS VDD VDD mem\[13\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[2\]$_DFFE_PP_ clknet_leaf_32_clk _0038_ net148
+ VSS VSS VDD VDD mem\[13\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[30\]$_DFFE_PP_ clknet_leaf_51_clk _0039_ net149
+ VSS VSS VDD VDD mem\[13\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[31\]$_DFFE_PP_ clknet_leaf_42_clk _0040_ net149
+ VSS VSS VDD VDD mem\[13\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ net149
+ VSS VSS VDD VDD mem\[13\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[4\]$_DFFE_PP_ clknet_leaf_1_clk _0042_ net149
+ VSS VSS VDD VDD mem\[13\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[5\]$_DFFE_PP_ clknet_leaf_32_clk _0043_ _0002_
+ VSS VSS VDD VDD mem\[13\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[6\]$_DFFE_PP_ clknet_leaf_21_clk _0044_ net148
+ VSS VSS VDD VDD mem\[13\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[7\]$_DFFE_PP_ clknet_leaf_45_clk _0045_ net147
+ VSS VSS VDD VDD mem\[13\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ net147
+ VSS VSS VDD VDD mem\[13\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[9\]$_DFFE_PP_ clknet_leaf_16_clk _0047_ net148
+ VSS VSS VDD VDD mem\[13\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[0\]$_DFFE_PP_ clknet_leaf_41_clk _0016_ _0001_
+ VSS VSS VDD VDD mem\[14\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[10\]$_DFFE_PP_ clknet_leaf_16_clk _0017_ net141
+ VSS VSS VDD VDD mem\[14\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[11\]$_DFFE_PP_ clknet_leaf_33_clk _0018_ net142
+ VSS VSS VDD VDD mem\[14\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[12\]$_DFFE_PP_ clknet_leaf_24_clk _0019_ net142
+ VSS VSS VDD VDD mem\[14\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[13\]$_DFFE_PP_ clknet_leaf_6_clk _0020_ net141
+ VSS VSS VDD VDD mem\[14\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[14\]$_DFFE_PP_ clknet_leaf_20_clk _0021_ net142
+ VSS VSS VDD VDD mem\[14\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[15\]$_DFFE_PP_ clknet_leaf_23_clk _0022_ net142
+ VSS VSS VDD VDD mem\[14\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[16\]$_DFFE_PP_ clknet_leaf_9_clk _0023_ net141
+ VSS VSS VDD VDD mem\[14\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[17\]$_DFFE_PP_ clknet_leaf_15_clk _0024_ net141
+ VSS VSS VDD VDD mem\[14\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[18\]$_DFFE_PP_ clknet_leaf_5_clk _0025_ net141
+ VSS VSS VDD VDD mem\[14\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[19\]$_DFFE_PP_ clknet_leaf_25_clk _0026_ net142
+ VSS VSS VDD VDD mem\[14\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[1\]$_DFFE_PP_ clknet_leaf_44_clk _0027_ net143
+ VSS VSS VDD VDD mem\[14\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[20\]$_DFFE_PP_ clknet_leaf_44_clk _0028_ net143
+ VSS VSS VDD VDD mem\[14\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ net141
+ VSS VSS VDD VDD mem\[14\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[22\]$_DFFE_PP_ clknet_leaf_48_clk _0030_ net143
+ VSS VSS VDD VDD mem\[14\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[23\]$_DFFE_PP_ clknet_leaf_46_clk _0031_ net143
+ VSS VSS VDD VDD mem\[14\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[24\]$_DFFE_PP_ clknet_leaf_51_clk _0032_ net143
+ VSS VSS VDD VDD mem\[14\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[25\]$_DFFE_PP_ clknet_leaf_8_clk _0033_ net141
+ VSS VSS VDD VDD mem\[14\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[26\]$_DFFE_PP_ clknet_leaf_11_clk _0034_ net141
+ VSS VSS VDD VDD mem\[14\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk _0035_ net141
+ VSS VSS VDD VDD mem\[14\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[28\]$_DFFE_PP_ clknet_leaf_8_clk _0036_ net141
+ VSS VSS VDD VDD mem\[14\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[29\]$_DFFE_PP_ clknet_leaf_34_clk _0037_ net142
+ VSS VSS VDD VDD mem\[14\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[2\]$_DFFE_PP_ clknet_leaf_32_clk _0038_ net142
+ VSS VSS VDD VDD mem\[14\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[30\]$_DFFE_PP_ clknet_leaf_51_clk _0039_ net143
+ VSS VSS VDD VDD mem\[14\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk _0040_ net143
+ VSS VSS VDD VDD mem\[14\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ net143
+ VSS VSS VDD VDD mem\[14\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[4\]$_DFFE_PP_ clknet_leaf_4_clk _0042_ net143
+ VSS VSS VDD VDD mem\[14\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[5\]$_DFFE_PP_ clknet_leaf_6_clk _0043_ net142
+ VSS VSS VDD VDD mem\[14\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[6\]$_DFFE_PP_ clknet_leaf_21_clk _0044_ net142
+ VSS VSS VDD VDD mem\[14\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[7\]$_DFFE_PP_ clknet_leaf_47_clk _0045_ net143
+ VSS VSS VDD VDD mem\[14\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ net141
+ VSS VSS VDD VDD mem\[14\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[9\]$_DFFE_PP_ clknet_leaf_15_clk _0047_ net141
+ VSS VSS VDD VDD mem\[14\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[0\]$_DFFE_PP_ clknet_leaf_41_clk _0016_ _0000_
+ VSS VSS VDD VDD mem\[15\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[10\]$_DFFE_PP_ clknet_leaf_16_clk _0017_ net144
+ VSS VSS VDD VDD mem\[15\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[11\]$_DFFE_PP_ clknet_leaf_22_clk _0018_ net146
+ VSS VSS VDD VDD mem\[15\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[12\]$_DFFE_PP_ clknet_leaf_24_clk _0019_ net146
+ VSS VSS VDD VDD mem\[15\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[13\]$_DFFE_PP_ clknet_leaf_19_clk _0020_ net144
+ VSS VSS VDD VDD mem\[15\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[14\]$_DFFE_PP_ clknet_leaf_21_clk _0021_ net146
+ VSS VSS VDD VDD mem\[15\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[15\]$_DFFE_PP_ clknet_leaf_18_clk _0022_ net144
+ VSS VSS VDD VDD mem\[15\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[16\]$_DFFE_PP_ clknet_leaf_9_clk _0023_ net145
+ VSS VSS VDD VDD mem\[15\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[17\]$_DFFE_PP_ clknet_leaf_12_clk _0024_ net144
+ VSS VSS VDD VDD mem\[15\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[18\]$_DFFE_PP_ clknet_leaf_6_clk _0025_ net145
+ VSS VSS VDD VDD mem\[15\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[19\]$_DFFE_PP_ clknet_leaf_25_clk _0026_ net146
+ VSS VSS VDD VDD mem\[15\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[1\]$_DFFE_PP_ clknet_leaf_35_clk _0027_ net146
+ VSS VSS VDD VDD mem\[15\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[20\]$_DFFE_PP_ clknet_leaf_35_clk _0028_ net146
+ VSS VSS VDD VDD mem\[15\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[21\]$_DFFE_PP_ clknet_leaf_47_clk _0029_ net145
+ VSS VSS VDD VDD mem\[15\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[22\]$_DFFE_PP_ clknet_leaf_48_clk _0030_ _0000_
+ VSS VSS VDD VDD mem\[15\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[23\]$_DFFE_PP_ clknet_leaf_48_clk _0031_ _0000_
+ VSS VSS VDD VDD mem\[15\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[24\]$_DFFE_PP_ clknet_leaf_51_clk _0032_ _0000_
+ VSS VSS VDD VDD mem\[15\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[25\]$_DFFE_PP_ clknet_leaf_7_clk _0033_ net145
+ VSS VSS VDD VDD mem\[15\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk _0034_ net144
+ VSS VSS VDD VDD mem\[15\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[27\]$_DFFE_PP_ clknet_leaf_24_clk _0035_ net146
+ VSS VSS VDD VDD mem\[15\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0036_ net145
+ VSS VSS VDD VDD mem\[15\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[29\]$_DFFE_PP_ clknet_leaf_36_clk _0037_ net146
+ VSS VSS VDD VDD mem\[15\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[2\]$_DFFE_PP_ clknet_leaf_31_clk _0038_ net146
+ VSS VSS VDD VDD mem\[15\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[30\]$_DFFE_PP_ clknet_leaf_0_clk _0039_ _0000_
+ VSS VSS VDD VDD mem\[15\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[31\]$_DFFE_PP_ clknet_leaf_42_clk _0040_ net145
+ VSS VSS VDD VDD mem\[15\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ _0000_
+ VSS VSS VDD VDD mem\[15\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[4\]$_DFFE_PP_ clknet_leaf_1_clk _0042_ _0000_
+ VSS VSS VDD VDD mem\[15\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[5\]$_DFFE_PP_ clknet_leaf_6_clk _0043_ net144
+ VSS VSS VDD VDD mem\[15\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[6\]$_DFFE_PP_ clknet_leaf_32_clk _0044_ net146
+ VSS VSS VDD VDD mem\[15\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[7\]$_DFFE_PP_ clknet_leaf_47_clk _0045_ net145
+ VSS VSS VDD VDD mem\[15\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ net144
+ VSS VSS VDD VDD mem\[15\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[9\]$_DFFE_PP_ clknet_leaf_15_clk _0047_ net144
+ VSS VSS VDD VDD mem\[15\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[0\]$_DFFE_PP_ clknet_leaf_43_clk _0016_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[10\]$_DFFE_PP_ clknet_leaf_17_clk _0017_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[11\]$_DFFE_PP_ clknet_leaf_21_clk _0018_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[12\]$_DFFE_PP_ clknet_leaf_26_clk _0019_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[13\]$_DFFE_PP_ clknet_leaf_10_clk _0020_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[14\]$_DFFE_PP_ clknet_leaf_19_clk _0021_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[15\]$_DFFE_PP_ clknet_leaf_26_clk _0022_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[16\]$_DFFE_PP_ clknet_leaf_2_clk _0023_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[17\]$_DFFE_PP_ clknet_leaf_13_clk _0024_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[18\]$_DFFE_PP_ clknet_leaf_6_clk _0025_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[19\]$_DFFE_PP_ clknet_leaf_22_clk _0026_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[1\]$_DFFE_PP_ clknet_leaf_35_clk _0027_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[20\]$_DFFE_PP_ clknet_leaf_34_clk _0028_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[22\]$_DFFE_PP_ clknet_leaf_47_clk _0030_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[23\]$_DFFE_PP_ clknet_leaf_47_clk _0031_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[24\]$_DFFE_PP_ clknet_leaf_2_clk _0032_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[25\]$_DFFE_PP_ clknet_leaf_7_clk _0033_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk _0034_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk _0035_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[28\]$_DFFE_PP_ clknet_leaf_10_clk _0036_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[29\]$_DFFE_PP_ clknet_leaf_36_clk _0037_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[2\]$_DFFE_PP_ clknet_leaf_31_clk _0038_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[30\]$_DFFE_PP_ clknet_leaf_1_clk _0039_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[31\]$_DFFE_PP_ clknet_leaf_44_clk _0040_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[3\]$_DFFE_PP_ clknet_leaf_47_clk _0041_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[4\]$_DFFE_PP_ clknet_leaf_2_clk _0042_ _0014_ VSS
+ VSS VDD VDD mem\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[5\]$_DFFE_PP_ clknet_leaf_31_clk _0043_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[6\]$_DFFE_PP_ clknet_leaf_21_clk _0044_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[7\]$_DFFE_PP_ clknet_leaf_46_clk _0045_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[9\]$_DFFE_PP_ clknet_leaf_18_clk _0047_ _0014_
+ VSS VSS VDD VDD mem\[1\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[0\]$_DFFE_PP_ clknet_leaf_43_clk _0016_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[10\]$_DFFE_PP_ clknet_leaf_17_clk _0017_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[11\]$_DFFE_PP_ clknet_leaf_20_clk _0018_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[12\]$_DFFE_PP_ clknet_leaf_23_clk _0019_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[13\]$_DFFE_PP_ clknet_leaf_10_clk _0020_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[14\]$_DFFE_PP_ clknet_leaf_19_clk _0021_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[15\]$_DFFE_PP_ clknet_leaf_25_clk _0022_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[16\]$_DFFE_PP_ clknet_leaf_3_clk _0023_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[17\]$_DFFE_PP_ clknet_leaf_12_clk _0024_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[18\]$_DFFE_PP_ clknet_leaf_3_clk _0025_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[19\]$_DFFE_PP_ clknet_leaf_22_clk _0026_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[1\]$_DFFE_PP_ clknet_leaf_44_clk _0027_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[20\]$_DFFE_PP_ clknet_leaf_34_clk _0028_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[22\]$_DFFE_PP_ clknet_leaf_45_clk _0030_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[23\]$_DFFE_PP_ clknet_leaf_48_clk _0031_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[24\]$_DFFE_PP_ clknet_leaf_0_clk _0032_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[25\]$_DFFE_PP_ clknet_leaf_10_clk _0033_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[26\]$_DFFE_PP_ clknet_leaf_10_clk _0034_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk _0035_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[28\]$_DFFE_PP_ clknet_leaf_10_clk _0036_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[29\]$_DFFE_PP_ clknet_leaf_31_clk _0037_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[2\]$_DFFE_PP_ clknet_leaf_32_clk _0038_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[30\]$_DFFE_PP_ clknet_leaf_0_clk _0039_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[31\]$_DFFE_PP_ clknet_leaf_44_clk _0040_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[4\]$_DFFE_PP_ clknet_leaf_4_clk _0042_ _0013_ VSS
+ VSS VDD VDD mem\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[5\]$_DFFE_PP_ clknet_leaf_20_clk _0043_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[6\]$_DFFE_PP_ clknet_leaf_21_clk _0044_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[7\]$_DFFE_PP_ clknet_leaf_46_clk _0045_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[9\]$_DFFE_PP_ clknet_leaf_16_clk _0047_ _0013_
+ VSS VSS VDD VDD mem\[2\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[0\]$_DFFE_PP_ clknet_leaf_42_clk _0016_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[10\]$_DFFE_PP_ clknet_leaf_17_clk _0017_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[11\]$_DFFE_PP_ clknet_leaf_23_clk _0018_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[12\]$_DFFE_PP_ clknet_leaf_23_clk _0019_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[13\]$_DFFE_PP_ clknet_leaf_10_clk _0020_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[14\]$_DFFE_PP_ clknet_leaf_20_clk _0021_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[15\]$_DFFE_PP_ clknet_leaf_18_clk _0022_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[16\]$_DFFE_PP_ clknet_leaf_3_clk _0023_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[17\]$_DFFE_PP_ clknet_leaf_13_clk _0024_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[18\]$_DFFE_PP_ clknet_leaf_6_clk _0025_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[19\]$_DFFE_PP_ clknet_leaf_28_clk _0026_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[1\]$_DFFE_PP_ clknet_leaf_35_clk _0027_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[20\]$_DFFE_PP_ clknet_leaf_33_clk _0028_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[22\]$_DFFE_PP_ clknet_leaf_45_clk _0030_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[23\]$_DFFE_PP_ clknet_leaf_48_clk _0031_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[24\]$_DFFE_PP_ clknet_leaf_0_clk _0032_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[25\]$_DFFE_PP_ clknet_leaf_10_clk _0033_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[26\]$_DFFE_PP_ clknet_leaf_13_clk _0034_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[27\]$_DFFE_PP_ clknet_leaf_24_clk _0035_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0036_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[29\]$_DFFE_PP_ clknet_leaf_34_clk _0037_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[2\]$_DFFE_PP_ clknet_leaf_31_clk _0038_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[30\]$_DFFE_PP_ clknet_leaf_0_clk _0039_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk _0040_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[4\]$_DFFE_PP_ clknet_leaf_2_clk _0042_ _0012_ VSS
+ VSS VDD VDD mem\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[5\]$_DFFE_PP_ clknet_leaf_32_clk _0043_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[6\]$_DFFE_PP_ clknet_leaf_28_clk _0044_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[7\]$_DFFE_PP_ clknet_leaf_46_clk _0045_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[8\]$_DFFE_PP_ clknet_leaf_13_clk _0046_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[9\]$_DFFE_PP_ clknet_leaf_18_clk _0047_ _0012_
+ VSS VSS VDD VDD mem\[3\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[0\]$_DFFE_PP_ clknet_leaf_41_clk _0016_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[10\]$_DFFE_PP_ clknet_leaf_19_clk _0017_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[11\]$_DFFE_PP_ clknet_leaf_22_clk _0018_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[12\]$_DFFE_PP_ clknet_leaf_23_clk _0019_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[13\]$_DFFE_PP_ clknet_leaf_19_clk _0020_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[14\]$_DFFE_PP_ clknet_leaf_23_clk _0021_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[15\]$_DFFE_PP_ clknet_leaf_18_clk _0022_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[16\]$_DFFE_PP_ clknet_leaf_2_clk _0023_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[17\]$_DFFE_PP_ clknet_leaf_13_clk _0024_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[18\]$_DFFE_PP_ clknet_leaf_4_clk _0025_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[19\]$_DFFE_PP_ clknet_leaf_25_clk _0026_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[1\]$_DFFE_PP_ clknet_leaf_42_clk _0027_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[20\]$_DFFE_PP_ clknet_leaf_34_clk _0028_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[22\]$_DFFE_PP_ clknet_leaf_45_clk _0030_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[23\]$_DFFE_PP_ clknet_leaf_47_clk _0031_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[24\]$_DFFE_PP_ clknet_leaf_52_clk _0032_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[25\]$_DFFE_PP_ clknet_leaf_8_clk _0033_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[26\]$_DFFE_PP_ clknet_leaf_11_clk _0034_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[27\]$_DFFE_PP_ clknet_leaf_15_clk _0035_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0036_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[29\]$_DFFE_PP_ clknet_leaf_33_clk _0037_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[2\]$_DFFE_PP_ clknet_leaf_33_clk _0038_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[30\]$_DFFE_PP_ clknet_leaf_0_clk _0039_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk _0040_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[4\]$_DFFE_PP_ clknet_leaf_2_clk _0042_ _0011_ VSS
+ VSS VDD VDD mem\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[5\]$_DFFE_PP_ clknet_leaf_33_clk _0043_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[6\]$_DFFE_PP_ clknet_leaf_21_clk _0044_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[7\]$_DFFE_PP_ clknet_leaf_46_clk _0045_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[8\]$_DFFE_PP_ clknet_leaf_13_clk _0046_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[9\]$_DFFE_PP_ clknet_leaf_15_clk _0047_ _0011_
+ VSS VSS VDD VDD mem\[4\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[0\]$_DFFE_PP_ clknet_leaf_40_clk _0016_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[10\]$_DFFE_PP_ clknet_leaf_16_clk _0017_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[11\]$_DFFE_PP_ clknet_leaf_33_clk _0018_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[12\]$_DFFE_PP_ clknet_leaf_26_clk _0019_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[13\]$_DFFE_PP_ clknet_leaf_19_clk _0020_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[14\]$_DFFE_PP_ clknet_leaf_20_clk _0021_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[15\]$_DFFE_PP_ clknet_leaf_26_clk _0022_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[16\]$_DFFE_PP_ clknet_leaf_4_clk _0023_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[17\]$_DFFE_PP_ clknet_leaf_12_clk _0024_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[18\]$_DFFE_PP_ clknet_leaf_3_clk _0025_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[19\]$_DFFE_PP_ clknet_leaf_24_clk _0026_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[1\]$_DFFE_PP_ clknet_leaf_35_clk _0027_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[20\]$_DFFE_PP_ clknet_leaf_45_clk _0028_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[22\]$_DFFE_PP_ clknet_leaf_45_clk _0030_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[23\]$_DFFE_PP_ clknet_leaf_48_clk _0031_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[24\]$_DFFE_PP_ clknet_leaf_0_clk _0032_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[25\]$_DFFE_PP_ clknet_leaf_7_clk _0033_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[26\]$_DFFE_PP_ clknet_leaf_11_clk _0034_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[27\]$_DFFE_PP_ clknet_leaf_26_clk _0035_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0036_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[29\]$_DFFE_PP_ clknet_leaf_35_clk _0037_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[2\]$_DFFE_PP_ clknet_leaf_28_clk _0038_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[30\]$_DFFE_PP_ clknet_leaf_0_clk _0039_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[31\]$_DFFE_PP_ clknet_leaf_44_clk _0040_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[4\]$_DFFE_PP_ clknet_leaf_1_clk _0042_ _0010_ VSS
+ VSS VDD VDD mem\[5\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[5\]$_DFFE_PP_ clknet_leaf_20_clk _0043_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[6\]$_DFFE_PP_ clknet_leaf_21_clk _0044_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[7\]$_DFFE_PP_ clknet_leaf_47_clk _0045_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[9\]$_DFFE_PP_ clknet_leaf_15_clk _0047_ _0010_
+ VSS VSS VDD VDD mem\[5\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[0\]$_DFFE_PP_ clknet_leaf_41_clk _0016_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[10\]$_DFFE_PP_ clknet_leaf_19_clk _0017_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[11\]$_DFFE_PP_ clknet_leaf_22_clk _0018_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[12\]$_DFFE_PP_ clknet_leaf_23_clk _0019_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[13\]$_DFFE_PP_ clknet_leaf_7_clk _0020_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[14\]$_DFFE_PP_ clknet_leaf_22_clk _0021_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[15\]$_DFFE_PP_ clknet_leaf_18_clk _0022_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[16\]$_DFFE_PP_ clknet_leaf_2_clk _0023_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[17\]$_DFFE_PP_ clknet_leaf_13_clk _0024_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[18\]$_DFFE_PP_ clknet_leaf_10_clk _0025_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[19\]$_DFFE_PP_ clknet_leaf_25_clk _0026_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[1\]$_DFFE_PP_ clknet_leaf_42_clk _0027_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[20\]$_DFFE_PP_ clknet_leaf_34_clk _0028_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[22\]$_DFFE_PP_ clknet_leaf_48_clk _0030_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[23\]$_DFFE_PP_ clknet_leaf_48_clk _0031_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[24\]$_DFFE_PP_ clknet_leaf_0_clk _0032_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[25\]$_DFFE_PP_ clknet_leaf_8_clk _0033_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[26\]$_DFFE_PP_ clknet_leaf_11_clk _0034_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[27\]$_DFFE_PP_ clknet_leaf_24_clk _0035_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[28\]$_DFFE_PP_ clknet_leaf_8_clk _0036_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[29\]$_DFFE_PP_ clknet_leaf_34_clk _0037_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[2\]$_DFFE_PP_ clknet_leaf_32_clk _0038_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[30\]$_DFFE_PP_ clknet_leaf_0_clk _0039_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk _0040_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[3\]$_DFFE_PP_ clknet_leaf_51_clk _0041_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[4\]$_DFFE_PP_ clknet_leaf_4_clk _0042_ _0009_ VSS
+ VSS VDD VDD mem\[6\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[5\]$_DFFE_PP_ clknet_leaf_20_clk _0043_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[6\]$_DFFE_PP_ clknet_leaf_21_clk _0044_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[7\]$_DFFE_PP_ clknet_leaf_48_clk _0045_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[8\]$_DFFE_PP_ clknet_leaf_13_clk _0046_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[9\]$_DFFE_PP_ clknet_leaf_16_clk _0047_ _0009_
+ VSS VSS VDD VDD mem\[6\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[0\]$_DFFE_PP_ clknet_leaf_40_clk _0016_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[10\]$_DFFE_PP_ clknet_leaf_18_clk _0017_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[11\]$_DFFE_PP_ clknet_leaf_22_clk _0018_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[12\]$_DFFE_PP_ clknet_leaf_27_clk _0019_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[13\]$_DFFE_PP_ clknet_leaf_19_clk _0020_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[14\]$_DFFE_PP_ clknet_leaf_23_clk _0021_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[15\]$_DFFE_PP_ clknet_leaf_25_clk _0022_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[16\]$_DFFE_PP_ clknet_leaf_2_clk _0023_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[17\]$_DFFE_PP_ clknet_leaf_13_clk _0024_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[18\]$_DFFE_PP_ clknet_leaf_3_clk _0025_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[19\]$_DFFE_PP_ clknet_leaf_28_clk _0026_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[1\]$_DFFE_PP_ clknet_leaf_44_clk _0027_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[20\]$_DFFE_PP_ clknet_leaf_44_clk _0028_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[21\]$_DFFE_PP_ clknet_leaf_46_clk _0029_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[22\]$_DFFE_PP_ clknet_leaf_6_clk _0030_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[23\]$_DFFE_PP_ clknet_leaf_48_clk _0031_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[24\]$_DFFE_PP_ clknet_leaf_1_clk _0032_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[25\]$_DFFE_PP_ clknet_leaf_7_clk _0033_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk _0034_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[27\]$_DFFE_PP_ clknet_leaf_15_clk _0035_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0036_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[29\]$_DFFE_PP_ clknet_leaf_34_clk _0037_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[2\]$_DFFE_PP_ clknet_leaf_33_clk _0038_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[30\]$_DFFE_PP_ clknet_leaf_0_clk _0039_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[31\]$_DFFE_PP_ clknet_leaf_43_clk _0040_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[3\]$_DFFE_PP_ clknet_leaf_51_clk _0041_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[4\]$_DFFE_PP_ clknet_leaf_2_clk _0042_ _0008_ VSS
+ VSS VDD VDD mem\[7\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[5\]$_DFFE_PP_ clknet_leaf_32_clk _0043_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[6\]$_DFFE_PP_ clknet_leaf_28_clk _0044_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[7\]$_DFFE_PP_ clknet_leaf_46_clk _0045_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[8\]$_DFFE_PP_ clknet_leaf_12_clk _0046_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[9\]$_DFFE_PP_ clknet_leaf_15_clk _0047_ _0008_
+ VSS VSS VDD VDD mem\[7\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[0\]$_DFFE_PP_ clknet_leaf_43_clk _0016_ _0007_
+ VSS VSS VDD VDD mem\[8\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[10\]$_DFFE_PP_ clknet_leaf_17_clk _0017_ net163
+ VSS VSS VDD VDD mem\[8\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[11\]$_DFFE_PP_ clknet_leaf_21_clk _0018_ net162
+ VSS VSS VDD VDD mem\[8\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[12\]$_DFFE_PP_ clknet_leaf_25_clk _0019_ net163
+ VSS VSS VDD VDD mem\[8\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[13\]$_DFFE_PP_ clknet_leaf_19_clk _0020_ net162
+ VSS VSS VDD VDD mem\[8\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[14\]$_DFFE_PP_ clknet_leaf_19_clk _0021_ net162
+ VSS VSS VDD VDD mem\[8\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[15\]$_DFFE_PP_ clknet_leaf_25_clk _0022_ net163
+ VSS VSS VDD VDD mem\[8\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[16\]$_DFFE_PP_ clknet_leaf_3_clk _0023_ net164
+ VSS VSS VDD VDD mem\[8\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[17\]$_DFFE_PP_ clknet_leaf_12_clk _0024_ net162
+ VSS VSS VDD VDD mem\[8\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[18\]$_DFFE_PP_ clknet_leaf_3_clk _0025_ net164
+ VSS VSS VDD VDD mem\[8\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[19\]$_DFFE_PP_ clknet_leaf_22_clk _0026_ net163
+ VSS VSS VDD VDD mem\[8\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[1\]$_DFFE_PP_ clknet_leaf_42_clk _0027_ net164
+ VSS VSS VDD VDD mem\[8\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[20\]$_DFFE_PP_ clknet_leaf_42_clk _0028_ net164
+ VSS VSS VDD VDD mem\[8\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[21\]$_DFFE_PP_ clknet_leaf_5_clk _0029_ _0007_
+ VSS VSS VDD VDD mem\[8\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[22\]$_DFFE_PP_ clknet_leaf_48_clk _0030_ net164
+ VSS VSS VDD VDD mem\[8\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[23\]$_DFFE_PP_ clknet_leaf_49_clk _0031_ net164
+ VSS VSS VDD VDD mem\[8\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[24\]$_DFFE_PP_ clknet_leaf_52_clk _0032_ net164
+ VSS VSS VDD VDD mem\[8\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[25\]$_DFFE_PP_ clknet_leaf_7_clk _0033_ net162
+ VSS VSS VDD VDD mem\[8\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[26\]$_DFFE_PP_ clknet_leaf_8_clk _0034_ net162
+ VSS VSS VDD VDD mem\[8\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[27\]$_DFFE_PP_ clknet_leaf_16_clk _0035_ net163
+ VSS VSS VDD VDD mem\[8\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[28\]$_DFFE_PP_ clknet_leaf_8_clk _0036_ net162
+ VSS VSS VDD VDD mem\[8\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[29\]$_DFFE_PP_ clknet_leaf_31_clk _0037_ net163
+ VSS VSS VDD VDD mem\[8\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[2\]$_DFFE_PP_ clknet_leaf_33_clk _0038_ net162
+ VSS VSS VDD VDD mem\[8\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[30\]$_DFFE_PP_ clknet_leaf_1_clk _0039_ net164
+ VSS VSS VDD VDD mem\[8\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[31\]$_DFFE_PP_ clknet_leaf_41_clk _0040_ net164
+ VSS VSS VDD VDD mem\[8\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ net164
+ VSS VSS VDD VDD mem\[8\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[4\]$_DFFE_PP_ clknet_leaf_1_clk _0042_ net164 VSS
+ VSS VDD VDD mem\[8\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[5\]$_DFFE_PP_ clknet_leaf_31_clk _0043_ net163
+ VSS VSS VDD VDD mem\[8\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[6\]$_DFFE_PP_ clknet_leaf_28_clk _0044_ net163
+ VSS VSS VDD VDD mem\[8\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[7\]$_DFFE_PP_ clknet_leaf_46_clk _0045_ _0007_
+ VSS VSS VDD VDD mem\[8\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ net163
+ VSS VSS VDD VDD mem\[8\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[9\]$_DFFE_PP_ clknet_leaf_18_clk _0047_ net162
+ VSS VSS VDD VDD mem\[8\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[0\]$_DFFE_PP_ clknet_leaf_40_clk _0016_ _0006_
+ VSS VSS VDD VDD mem\[9\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[10\]$_DFFE_PP_ clknet_leaf_17_clk _0017_ net151
+ VSS VSS VDD VDD mem\[9\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[11\]$_DFFE_PP_ clknet_leaf_23_clk _0018_ net151
+ VSS VSS VDD VDD mem\[9\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[12\]$_DFFE_PP_ clknet_leaf_26_clk _0019_ net151
+ VSS VSS VDD VDD mem\[9\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[13\]$_DFFE_PP_ clknet_leaf_3_clk _0020_ net150
+ VSS VSS VDD VDD mem\[9\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[14\]$_DFFE_PP_ clknet_leaf_20_clk _0021_ _0006_
+ VSS VSS VDD VDD mem\[9\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[15\]$_DFFE_PP_ clknet_leaf_26_clk _0022_ net151
+ VSS VSS VDD VDD mem\[9\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[16\]$_DFFE_PP_ clknet_leaf_3_clk _0023_ net150
+ VSS VSS VDD VDD mem\[9\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[17\]$_DFFE_PP_ clknet_leaf_13_clk _0024_ net151
+ VSS VSS VDD VDD mem\[9\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[18\]$_DFFE_PP_ clknet_leaf_6_clk _0025_ net152
+ VSS VSS VDD VDD mem\[9\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[19\]$_DFFE_PP_ clknet_leaf_24_clk _0026_ net151
+ VSS VSS VDD VDD mem\[9\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[1\]$_DFFE_PP_ clknet_leaf_42_clk _0027_ net150
+ VSS VSS VDD VDD mem\[9\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[20\]$_DFFE_PP_ clknet_leaf_41_clk _0028_ _0006_
+ VSS VSS VDD VDD mem\[9\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[21\]$_DFFE_PP_ clknet_leaf_2_clk _0029_ net150
+ VSS VSS VDD VDD mem\[9\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[22\]$_DFFE_PP_ clknet_leaf_49_clk _0030_ net150
+ VSS VSS VDD VDD mem\[9\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[23\]$_DFFE_PP_ clknet_leaf_49_clk _0031_ net150
+ VSS VSS VDD VDD mem\[9\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[24\]$_DFFE_PP_ clknet_leaf_52_clk _0032_ net150
+ VSS VSS VDD VDD mem\[9\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[25\]$_DFFE_PP_ clknet_leaf_8_clk _0033_ net152
+ VSS VSS VDD VDD mem\[9\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[26\]$_DFFE_PP_ clknet_leaf_11_clk _0034_ net152
+ VSS VSS VDD VDD mem\[9\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[27\]$_DFFE_PP_ clknet_leaf_26_clk _0035_ net151
+ VSS VSS VDD VDD mem\[9\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[28\]$_DFFE_PP_ clknet_leaf_10_clk _0036_ net152
+ VSS VSS VDD VDD mem\[9\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[29\]$_DFFE_PP_ clknet_leaf_36_clk _0037_ _0006_
+ VSS VSS VDD VDD mem\[9\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[2\]$_DFFE_PP_ clknet_leaf_32_clk _0038_ _0006_
+ VSS VSS VDD VDD mem\[9\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[30\]$_DFFE_PP_ clknet_leaf_51_clk _0039_ net150
+ VSS VSS VDD VDD mem\[9\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[31\]$_DFFE_PP_ clknet_leaf_41_clk _0040_ _0006_
+ VSS VSS VDD VDD mem\[9\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[3\]$_DFFE_PP_ clknet_leaf_50_clk _0041_ net150
+ VSS VSS VDD VDD mem\[9\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[4\]$_DFFE_PP_ clknet_leaf_1_clk _0042_ net150 VSS
+ VSS VDD VDD mem\[9\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[5\]$_DFFE_PP_ clknet_leaf_6_clk _0043_ net152 VSS
+ VSS VDD VDD mem\[9\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[6\]$_DFFE_PP_ clknet_leaf_28_clk _0044_ net151
+ VSS VSS VDD VDD mem\[9\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[7\]$_DFFE_PP_ clknet_leaf_49_clk _0045_ net150
+ VSS VSS VDD VDD mem\[9\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[8\]$_DFFE_PP_ clknet_leaf_14_clk _0046_ net151
+ VSS VSS VDD VDD mem\[9\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[9\]$_DFFE_PP_ clknet_leaf_16_clk _0047_ net151
+ VSS VSS VDD VDD mem\[9\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem_rdata\[0\]$_DFFE_PN0P_ clknet_leaf_39_clk _0080_ net1
+ VSS VSS VDD VDD net108 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[10\]$_DFFE_PN0P_ clknet_leaf_26_clk _0081_ net1
+ VSS VSS VDD VDD net109 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[11\]$_DFFE_PN0P_ clknet_leaf_29_clk _0082_ net1
+ VSS VSS VDD VDD net110 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[12\]$_DFFE_PN0P_ clknet_leaf_27_clk _0083_ net1
+ VSS VSS VDD VDD net111 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[13\]$_DFFE_PN0P_ clknet_leaf_29_clk _0084_ net1
+ VSS VSS VDD VDD net112 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[14\]$_DFFE_PN0P_ clknet_leaf_29_clk _0085_ net1
+ VSS VSS VDD VDD net113 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[15\]$_DFFE_PN0P_ clknet_leaf_26_clk _0086_ net1
+ VSS VSS VDD VDD net114 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[16\]$_DFFE_PN0P_ clknet_leaf_37_clk _0087_ net1
+ VSS VSS VDD VDD net115 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[17\]$_DFFE_PN0P_ clknet_leaf_27_clk _0088_ net1
+ VSS VSS VDD VDD net116 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[18\]$_DFFE_PN0P_ clknet_leaf_36_clk _0089_ net1
+ VSS VSS VDD VDD net117 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[19\]$_DFFE_PN0P_ clknet_leaf_27_clk _0090_ net1
+ VSS VSS VDD VDD net118 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[1\]$_DFFE_PN0P_ clknet_leaf_39_clk _0091_ net1
+ VSS VSS VDD VDD net119 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[20\]$_DFFE_PN0P_ clknet_leaf_36_clk _0092_ net1
+ VSS VSS VDD VDD net120 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[21\]$_DFFE_PN0P_ clknet_leaf_37_clk _0093_ net1
+ VSS VSS VDD VDD net121 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[22\]$_DFFE_PN0P_ clknet_leaf_36_clk _0094_ net1
+ VSS VSS VDD VDD net122 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[23\]$_DFFE_PN0P_ clknet_leaf_37_clk _0095_ net1
+ VSS VSS VDD VDD net123 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[24\]$_DFFE_PN0P_ clknet_leaf_38_clk _0096_ net1
+ VSS VSS VDD VDD net124 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[25\]$_DFFE_PN0P_ clknet_leaf_30_clk _0097_ net1
+ VSS VSS VDD VDD net125 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[26\]$_DFFE_PN0P_ clknet_leaf_29_clk _0098_ net1
+ VSS VSS VDD VDD net126 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[27\]$_DFFE_PN0P_ clknet_leaf_27_clk _0099_ net1
+ VSS VSS VDD VDD net127 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[28\]$_DFFE_PN0P_ clknet_leaf_30_clk _0100_ net1
+ VSS VSS VDD VDD net128 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[29\]$_DFFE_PN0P_ clknet_leaf_36_clk _0101_ net1
+ VSS VSS VDD VDD net129 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[2\]$_DFFE_PN0P_ clknet_leaf_39_clk _0102_ net1
+ VSS VSS VDD VDD net130 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[30\]$_DFFE_PN0P_ clknet_leaf_37_clk _0103_ net1
+ VSS VSS VDD VDD net131 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[31\]$_DFFE_PN0P_ clknet_leaf_35_clk _0104_ net1
+ VSS VSS VDD VDD net132 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[3\]$_DFFE_PN0P_ clknet_leaf_39_clk _0105_ net1
+ VSS VSS VDD VDD net133 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[4\]$_DFFE_PN0P_ clknet_leaf_39_clk _0106_ net1
+ VSS VSS VDD VDD net134 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[5\]$_DFFE_PN0P_ clknet_leaf_30_clk _0107_ net1
+ VSS VSS VDD VDD net135 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[6\]$_DFFE_PN0P_ clknet_leaf_27_clk _0108_ net1
+ VSS VSS VDD VDD net136 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[7\]$_DFFE_PN0P_ clknet_leaf_38_clk _0109_ net1
+ VSS VSS VDD VDD net137 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[8\]$_DFFE_PN0P_ clknet_leaf_29_clk _0110_ net1
+ VSS VSS VDD VDD net138 sky130_fd_sc_hd__dfrtp_1
Xmem_rdata\[9\]$_DFFE_PN0P_ clknet_leaf_29_clk _0111_ net1
+ VSS VSS VDD VDD net139 sky130_fd_sc_hd__dfrtp_1
Xmem_ready$_DFF_PN0_ clknet_leaf_39_clk net39 net1 VSS VSS
+ VDD VDD net140 sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[0\]$_DFFE_PN0P_ clknet_leaf_38_clk _0112_ net1 VSS
+ VSS VDD VDD rd_ptr\[0\] sky130_fd_sc_hd__dfrtp_2
Xrd_ptr\[1\]$_DFFE_PN0P_ clknet_leaf_38_clk _0113_ net1 VSS
+ VSS VDD VDD rd_ptr\[1\] sky130_fd_sc_hd__dfrtp_2
Xrd_ptr\[2\]$_DFFE_PN0P_ clknet_leaf_38_clk _0114_ net1 VSS
+ VSS VDD VDD rd_ptr\[2\] sky130_fd_sc_hd__dfrtp_2
Xrd_ptr\[3\]$_DFFE_PN0P_ clknet_leaf_38_clk _0115_ net1 VSS
+ VSS VDD VDD rd_ptr\[3\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[4\]$_DFFE_PN0P_ clknet_leaf_38_clk _0116_ net1 VSS
+ VSS VDD VDD rd_ptr\[4\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[0\]$_DFFE_PN0P_ clknet_leaf_40_clk _0117_ net1 VSS
+ VSS VDD VDD wr_ptr\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[1\]$_DFFE_PN0P_ clknet_leaf_39_clk _0118_ net1 VSS
+ VSS VDD VDD wr_ptr\[1\] sky130_fd_sc_hd__dfrtp_4
Xwr_ptr\[2\]$_DFFE_PN0P_ clknet_leaf_40_clk _0119_ net1 VSS
+ VSS VDD VDD wr_ptr\[2\] sky130_fd_sc_hd__dfrtp_4
Xwr_ptr\[3\]$_DFFE_PN0P_ clknet_leaf_40_clk _0120_ net1 VSS
+ VSS VDD VDD wr_ptr\[3\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[4\]$_DFFE_PN0P_ clknet_leaf_40_clk _0121_ net1 VSS
+ VSS VDD VDD wr_ptr\[4\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net73 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_16
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 ext_rd_en VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 ext_wr_data[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 ext_wr_data[10] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 ext_wr_data[11] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 ext_wr_data[12] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 ext_wr_data[13] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 ext_wr_data[14] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 ext_wr_data[15] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 ext_wr_data[16] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 ext_wr_data[17] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 ext_wr_data[18] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 ext_wr_data[19] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput13 ext_wr_data[1] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput14 ext_wr_data[20] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput15 ext_wr_data[21] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput16 ext_wr_data[22] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput17 ext_wr_data[23] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xinput18 ext_wr_data[24] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xinput19 ext_wr_data[25] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
Xinput20 ext_wr_data[26] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
Xinput21 ext_wr_data[27] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
Xinput22 ext_wr_data[28] VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_1
Xinput23 ext_wr_data[29] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
Xinput24 ext_wr_data[2] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
Xinput25 ext_wr_data[30] VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_1
Xinput26 ext_wr_data[31] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
Xinput27 ext_wr_data[3] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_1
Xinput28 ext_wr_data[4] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_1
Xinput29 ext_wr_data[5] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_1
Xinput30 ext_wr_data[6] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_1
Xinput31 ext_wr_data[7] VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_1
Xinput32 ext_wr_data[8] VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_1
Xinput33 ext_wr_data[9] VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_1
Xinput34 ext_wr_en VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_1
Xinput35 mem_addr[0] VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkbuf_1
Xinput36 mem_addr[1] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_1
Xinput37 mem_addr[2] VSS VSS VDD VDD net38 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput38 net166 VSS VSS VDD VDD net39 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput39 mem_wdata[0] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
Xinput40 mem_wdata[10] VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_1
Xinput41 mem_wdata[11] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_1
Xinput42 mem_wdata[12] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
Xinput43 mem_wdata[13] VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_1
Xinput44 mem_wdata[14] VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_1
Xinput45 mem_wdata[15] VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkbuf_1
Xinput46 mem_wdata[16] VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkbuf_1
Xinput47 mem_wdata[17] VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_1
Xinput48 mem_wdata[18] VSS VSS VDD VDD net49 sky130_fd_sc_hd__clkbuf_1
Xinput49 mem_wdata[19] VSS VSS VDD VDD net50 sky130_fd_sc_hd__clkbuf_1
Xinput50 mem_wdata[1] VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkbuf_1
Xinput51 mem_wdata[20] VSS VSS VDD VDD net52 sky130_fd_sc_hd__clkbuf_1
Xinput52 mem_wdata[21] VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkbuf_1
Xinput53 mem_wdata[22] VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkbuf_1
Xinput54 mem_wdata[23] VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_1
Xinput55 mem_wdata[24] VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_1
Xinput56 mem_wdata[25] VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkbuf_1
Xinput57 mem_wdata[26] VSS VSS VDD VDD net58 sky130_fd_sc_hd__clkbuf_1
Xinput58 mem_wdata[27] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_1
Xinput59 mem_wdata[28] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_1
Xinput60 mem_wdata[29] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_1
Xinput61 mem_wdata[2] VSS VSS VDD VDD net62 sky130_fd_sc_hd__clkbuf_1
Xinput62 mem_wdata[30] VSS VSS VDD VDD net63 sky130_fd_sc_hd__clkbuf_1
Xinput63 mem_wdata[31] VSS VSS VDD VDD net64 sky130_fd_sc_hd__clkbuf_1
Xinput64 mem_wdata[3] VSS VSS VDD VDD net65 sky130_fd_sc_hd__clkbuf_1
Xinput65 mem_wdata[4] VSS VSS VDD VDD net66 sky130_fd_sc_hd__clkbuf_1
Xinput66 mem_wdata[5] VSS VSS VDD VDD net67 sky130_fd_sc_hd__clkbuf_1
Xinput67 mem_wdata[6] VSS VSS VDD VDD net68 sky130_fd_sc_hd__clkbuf_1
Xinput68 mem_wdata[7] VSS VSS VDD VDD net69 sky130_fd_sc_hd__clkbuf_1
Xinput69 mem_wdata[8] VSS VSS VDD VDD net70 sky130_fd_sc_hd__clkbuf_1
Xinput70 mem_wdata[9] VSS VSS VDD VDD net71 sky130_fd_sc_hd__clkbuf_1
Xinput71 mem_write VSS VSS VDD VDD net72 sky130_fd_sc_hd__clkbuf_2
Xinput72 net165 VSS VSS VDD VDD net73 sky130_fd_sc_hd__buf_2
Xoutput73 net74 VSS VSS VDD VDD ext_empty sky130_fd_sc_hd__clkbuf_1
Xoutput74 net75 VSS VSS VDD VDD ext_full sky130_fd_sc_hd__clkbuf_1
Xoutput75 net76 VSS VSS VDD VDD ext_rd_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net77 VSS VSS VDD VDD ext_rd_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net78 VSS VSS VDD VDD ext_rd_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net79 VSS VSS VDD VDD ext_rd_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net80 VSS VSS VDD VDD ext_rd_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net81 VSS VSS VDD VDD ext_rd_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net82 VSS VSS VDD VDD ext_rd_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net83 VSS VSS VDD VDD ext_rd_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net84 VSS VSS VDD VDD ext_rd_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net85 VSS VSS VDD VDD ext_rd_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput85 net86 VSS VSS VDD VDD ext_rd_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput86 net87 VSS VSS VDD VDD ext_rd_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput87 net88 VSS VSS VDD VDD ext_rd_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput88 net89 VSS VSS VDD VDD ext_rd_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput89 net90 VSS VSS VDD VDD ext_rd_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput90 net91 VSS VSS VDD VDD ext_rd_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput91 net92 VSS VSS VDD VDD ext_rd_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput92 net93 VSS VSS VDD VDD ext_rd_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput93 net94 VSS VSS VDD VDD ext_rd_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput94 net95 VSS VSS VDD VDD ext_rd_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput95 net96 VSS VSS VDD VDD ext_rd_data[28] sky130_fd_sc_hd__clkbuf_1
Xoutput96 net97 VSS VSS VDD VDD ext_rd_data[29] sky130_fd_sc_hd__clkbuf_1
Xoutput97 net98 VSS VSS VDD VDD ext_rd_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput98 net99 VSS VSS VDD VDD ext_rd_data[30] sky130_fd_sc_hd__clkbuf_1
Xoutput99 net100 VSS VSS VDD VDD ext_rd_data[31] sky130_fd_sc_hd__clkbuf_1
Xoutput100 net101 VSS VSS VDD VDD ext_rd_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput101 net102 VSS VSS VDD VDD ext_rd_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput102 net103 VSS VSS VDD VDD ext_rd_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput103 net104 VSS VSS VDD VDD ext_rd_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput104 net105 VSS VSS VDD VDD ext_rd_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput105 net106 VSS VSS VDD VDD ext_rd_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput106 net107 VSS VSS VDD VDD ext_rd_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput107 net108 VSS VSS VDD VDD mem_rdata[0] sky130_fd_sc_hd__clkbuf_1
Xoutput108 net109 VSS VSS VDD VDD mem_rdata[10] sky130_fd_sc_hd__clkbuf_1
Xoutput109 net110 VSS VSS VDD VDD mem_rdata[11] sky130_fd_sc_hd__clkbuf_1
Xoutput110 net111 VSS VSS VDD VDD mem_rdata[12] sky130_fd_sc_hd__clkbuf_1
Xoutput111 net112 VSS VSS VDD VDD mem_rdata[13] sky130_fd_sc_hd__clkbuf_1
Xoutput112 net113 VSS VSS VDD VDD mem_rdata[14] sky130_fd_sc_hd__clkbuf_1
Xoutput113 net114 VSS VSS VDD VDD mem_rdata[15] sky130_fd_sc_hd__clkbuf_1
Xoutput114 net115 VSS VSS VDD VDD mem_rdata[16] sky130_fd_sc_hd__clkbuf_1
Xoutput115 net116 VSS VSS VDD VDD mem_rdata[17] sky130_fd_sc_hd__clkbuf_1
Xoutput116 net117 VSS VSS VDD VDD mem_rdata[18] sky130_fd_sc_hd__clkbuf_1
Xoutput117 net118 VSS VSS VDD VDD mem_rdata[19] sky130_fd_sc_hd__clkbuf_1
Xoutput118 net119 VSS VSS VDD VDD mem_rdata[1] sky130_fd_sc_hd__clkbuf_1
Xoutput119 net120 VSS VSS VDD VDD mem_rdata[20] sky130_fd_sc_hd__clkbuf_1
Xoutput120 net121 VSS VSS VDD VDD mem_rdata[21] sky130_fd_sc_hd__clkbuf_1
Xoutput121 net122 VSS VSS VDD VDD mem_rdata[22] sky130_fd_sc_hd__clkbuf_1
Xoutput122 net123 VSS VSS VDD VDD mem_rdata[23] sky130_fd_sc_hd__clkbuf_1
Xoutput123 net124 VSS VSS VDD VDD mem_rdata[24] sky130_fd_sc_hd__clkbuf_1
Xoutput124 net125 VSS VSS VDD VDD mem_rdata[25] sky130_fd_sc_hd__clkbuf_1
Xoutput125 net126 VSS VSS VDD VDD mem_rdata[26] sky130_fd_sc_hd__clkbuf_1
Xoutput126 net127 VSS VSS VDD VDD mem_rdata[27] sky130_fd_sc_hd__clkbuf_1
Xoutput127 net128 VSS VSS VDD VDD mem_rdata[28] sky130_fd_sc_hd__clkbuf_1
Xoutput128 net129 VSS VSS VDD VDD mem_rdata[29] sky130_fd_sc_hd__clkbuf_1
Xoutput129 net130 VSS VSS VDD VDD mem_rdata[2] sky130_fd_sc_hd__clkbuf_1
Xoutput130 net131 VSS VSS VDD VDD mem_rdata[30] sky130_fd_sc_hd__clkbuf_1
Xoutput131 net132 VSS VSS VDD VDD mem_rdata[31] sky130_fd_sc_hd__clkbuf_1
Xoutput132 net133 VSS VSS VDD VDD mem_rdata[3] sky130_fd_sc_hd__clkbuf_1
Xoutput133 net134 VSS VSS VDD VDD mem_rdata[4] sky130_fd_sc_hd__clkbuf_1
Xoutput134 net135 VSS VSS VDD VDD mem_rdata[5] sky130_fd_sc_hd__clkbuf_1
Xoutput135 net136 VSS VSS VDD VDD mem_rdata[6] sky130_fd_sc_hd__clkbuf_1
Xoutput136 net137 VSS VSS VDD VDD mem_rdata[7] sky130_fd_sc_hd__clkbuf_1
Xoutput137 net138 VSS VSS VDD VDD mem_rdata[8] sky130_fd_sc_hd__clkbuf_1
Xoutput138 net139 VSS VSS VDD VDD mem_rdata[9] sky130_fd_sc_hd__clkbuf_1
Xoutput139 net140 VSS VSS VDD VDD mem_ready sky130_fd_sc_hd__clkbuf_1
Xload_slew140 net142 VSS VSS VDD VDD net141 sky130_fd_sc_hd__buf_6
Xload_slew141 net143 VSS VSS VDD VDD net142 sky130_fd_sc_hd__buf_6
Xwire142 _0001_ VSS VSS VDD VDD net143 sky130_fd_sc_hd__buf_6
Xload_slew143 net145 VSS VSS VDD VDD net144 sky130_fd_sc_hd__buf_6
Xload_slew144 _0000_ VSS VSS VDD VDD net145 sky130_fd_sc_hd__buf_8
Xmax_cap145 _0000_ VSS VSS VDD VDD net146 sky130_fd_sc_hd__buf_16
Xwire146 _0002_ VSS VSS VDD VDD net147 sky130_fd_sc_hd__buf_6
Xload_slew147 _0002_ VSS VSS VDD VDD net148 sky130_fd_sc_hd__buf_6
Xload_slew148 _0002_ VSS VSS VDD VDD net149 sky130_fd_sc_hd__buf_8
Xwire149 _0006_ VSS VSS VDD VDD net150 sky130_fd_sc_hd__buf_6
Xload_slew150 _0006_ VSS VSS VDD VDD net151 sky130_fd_sc_hd__buf_6
Xload_slew151 _0006_ VSS VSS VDD VDD net152 sky130_fd_sc_hd__buf_6
Xload_slew152 _0005_ VSS VSS VDD VDD net153 sky130_fd_sc_hd__buf_6
Xmax_cap153 net155 VSS VSS VDD VDD net154 sky130_fd_sc_hd__buf_8
Xmax_cap154 _0005_ VSS VSS VDD VDD net155 sky130_fd_sc_hd__buf_8
Xmax_cap155 net158 VSS VSS VDD VDD net156 sky130_fd_sc_hd__buf_8
Xwire156 _0004_ VSS VSS VDD VDD net157 sky130_fd_sc_hd__buf_6
Xload_slew157 _0004_ VSS VSS VDD VDD net158 sky130_fd_sc_hd__buf_8
Xmax_cap158 net160 VSS VSS VDD VDD net159 sky130_fd_sc_hd__buf_16
Xwire159 _0003_ VSS VSS VDD VDD net160 sky130_fd_sc_hd__buf_6
Xload_slew160 _0003_ VSS VSS VDD VDD net161 sky130_fd_sc_hd__buf_8
Xmax_cap161 net163 VSS VSS VDD VDD net162 sky130_fd_sc_hd__buf_8
Xwire162 _0007_ VSS VSS VDD VDD net163 sky130_fd_sc_hd__buf_6
Xwire163 _0007_ VSS VSS VDD VDD net164 sky130_fd_sc_hd__buf_6
Xclkbuf_leaf_0_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_1_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_1_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_2_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_2_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_3_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_3_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_4_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_4_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_5_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_5_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_6_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_6_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_7_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_7_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_8_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_8_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_9_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_9_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_10_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_10_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_11_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_11_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_12_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_12_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_13_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_13_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_14_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_14_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_15_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_15_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_16_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_16_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_17_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_17_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_18_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_18_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_19_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_19_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_20_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_20_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_21_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_21_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_22_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_22_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_23_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_23_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_24_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_24_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_25_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_25_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_26_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_26_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_27_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_27_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_28_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_28_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_29_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_29_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_30_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_30_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_31_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_31_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_32_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_32_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_33_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_33_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_34_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_34_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_35_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_35_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_36_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_36_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_37_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_37_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_38_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_38_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_39_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_39_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_40_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_40_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_41_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_41_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_42_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_42_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_43_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_43_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_44_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_44_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_45_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_45_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_46_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_46_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_47_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_47_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_48_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_48_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_49_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_49_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_50_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_50_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_51_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_51_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_52_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_52_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_2_2__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__inv_6
Xclkload1 clknet_2_3__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkbuf_16
Xclkload2 clknet_leaf_0_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkinv_1
Xclkload3 clknet_leaf_2_clk VSS VSS VDD VDD _unconnected_3
+ sky130_fd_sc_hd__clkinv_1
Xclkload4 clknet_leaf_3_clk VSS VSS VDD VDD _unconnected_4
+ sky130_fd_sc_hd__clkbuf_1
Xclkload5 clknet_leaf_4_clk VSS VSS VDD VDD _unconnected_5
+ sky130_fd_sc_hd__clkinv_1
Xclkload6 clknet_leaf_45_clk VSS VSS VDD VDD _unconnected_6
+ sky130_fd_sc_hd__clkbuf_1
Xclkload7 clknet_leaf_46_clk VSS VSS VDD VDD _unconnected_7
+ sky130_fd_sc_hd__clkinv_1
Xclkload8 clknet_leaf_47_clk VSS VSS VDD VDD _unconnected_8
+ sky130_fd_sc_hd__clkinv_2
Xclkload9 clknet_leaf_48_clk VSS VSS VDD VDD _unconnected_9
+ sky130_fd_sc_hd__clkinv_1
Xclkload10 clknet_leaf_49_clk VSS VSS VDD VDD _unconnected_10
+ sky130_fd_sc_hd__clkinv_2
Xclkload11 clknet_leaf_50_clk VSS VSS VDD VDD _unconnected_11
+ sky130_fd_sc_hd__clkinv_1
Xclkload12 clknet_leaf_51_clk VSS VSS VDD VDD _unconnected_12
+ sky130_fd_sc_hd__clkinv_1
Xclkload13 clknet_leaf_52_clk VSS VSS VDD VDD _unconnected_13
+ sky130_fd_sc_hd__inv_6
Xclkload14 clknet_leaf_6_clk VSS VSS VDD VDD _unconnected_14
+ sky130_fd_sc_hd__clkbuf_1
Xclkload15 clknet_leaf_7_clk VSS VSS VDD VDD _unconnected_15
+ sky130_fd_sc_hd__clkbuf_1
Xclkload16 clknet_leaf_8_clk VSS VSS VDD VDD _unconnected_16
+ sky130_fd_sc_hd__clkinv_1
Xclkload17 clknet_leaf_10_clk VSS VSS VDD VDD _unconnected_17
+ sky130_fd_sc_hd__clkinv_1
Xclkload18 clknet_leaf_11_clk VSS VSS VDD VDD _unconnected_18
+ sky130_fd_sc_hd__clkinv_2
Xclkload19 clknet_leaf_12_clk VSS VSS VDD VDD _unconnected_19
+ sky130_fd_sc_hd__clkbuf_1
Xclkload20 clknet_leaf_13_clk VSS VSS VDD VDD _unconnected_20
+ sky130_fd_sc_hd__clkbuf_1
Xclkload21 clknet_leaf_14_clk VSS VSS VDD VDD _unconnected_21
+ sky130_fd_sc_hd__clkbuf_1
Xclkload22 clknet_leaf_15_clk VSS VSS VDD VDD _unconnected_22
+ sky130_fd_sc_hd__clkinv_1
Xclkload23 clknet_leaf_17_clk VSS VSS VDD VDD _unconnected_23
+ sky130_fd_sc_hd__clkinv_2
Xclkload24 clknet_leaf_18_clk VSS VSS VDD VDD _unconnected_24
+ sky130_fd_sc_hd__clkbuf_1
Xclkload25 clknet_leaf_19_clk VSS VSS VDD VDD _unconnected_25
+ sky130_fd_sc_hd__clkbuf_1
Xclkload26 clknet_leaf_33_clk VSS VSS VDD VDD _unconnected_26
+ sky130_fd_sc_hd__clkbuf_1
Xclkload27 clknet_leaf_34_clk VSS VSS VDD VDD _unconnected_27
+ sky130_fd_sc_hd__clkbuf_1
Xclkload28 clknet_leaf_35_clk VSS VSS VDD VDD _unconnected_28
+ sky130_fd_sc_hd__clkbuf_8
Xclkload29 clknet_leaf_37_clk VSS VSS VDD VDD _unconnected_29
+ sky130_fd_sc_hd__clkinv_1
Xclkload30 clknet_leaf_38_clk VSS VSS VDD VDD _unconnected_30
+ sky130_fd_sc_hd__clkinv_1
Xclkload31 clknet_leaf_39_clk VSS VSS VDD VDD _unconnected_31
+ sky130_fd_sc_hd__bufinv_16
Xclkload32 clknet_leaf_40_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__clkbuf_8
Xclkload33 clknet_leaf_41_clk VSS VSS VDD VDD _unconnected_33
+ sky130_fd_sc_hd__clkbuf_1
Xclkload34 clknet_leaf_42_clk VSS VSS VDD VDD _unconnected_34
+ sky130_fd_sc_hd__clkbuf_8
Xclkload35 clknet_leaf_43_clk VSS VSS VDD VDD _unconnected_35
+ sky130_fd_sc_hd__clkbuf_8
Xclkload36 clknet_leaf_44_clk VSS VSS VDD VDD _unconnected_36
+ sky130_fd_sc_hd__clkbuf_1
Xclkload37 clknet_leaf_20_clk VSS VSS VDD VDD _unconnected_37
+ sky130_fd_sc_hd__clkbuf_8
Xclkload38 clknet_leaf_21_clk VSS VSS VDD VDD _unconnected_38
+ sky130_fd_sc_hd__clkbuf_4
Xclkload39 clknet_leaf_22_clk VSS VSS VDD VDD _unconnected_39
+ sky130_fd_sc_hd__clkbuf_4
Xclkload40 clknet_leaf_23_clk VSS VSS VDD VDD _unconnected_40
+ sky130_fd_sc_hd__clkbuf_4
Xclkload41 clknet_leaf_24_clk VSS VSS VDD VDD _unconnected_41
+ sky130_fd_sc_hd__clkbuf_4
Xclkload42 clknet_leaf_25_clk VSS VSS VDD VDD _unconnected_42
+ sky130_fd_sc_hd__clkbuf_4
Xclkload43 clknet_leaf_26_clk VSS VSS VDD VDD _unconnected_43
+ sky130_fd_sc_hd__clkbuf_1
Xclkload44 clknet_leaf_27_clk VSS VSS VDD VDD _unconnected_44
+ sky130_fd_sc_hd__clkbuf_1
Xclkload45 clknet_leaf_28_clk VSS VSS VDD VDD _unconnected_45
+ sky130_fd_sc_hd__clkbuf_16
Xclkload46 clknet_leaf_30_clk VSS VSS VDD VDD _unconnected_46
+ sky130_fd_sc_hd__bufinv_16
Xclkload47 clknet_leaf_31_clk VSS VSS VDD VDD _unconnected_47
+ sky130_fd_sc_hd__clkbuf_16
Xclkload48 clknet_leaf_32_clk VSS VSS VDD VDD _unconnected_48
+ sky130_fd_sc_hd__clkbuf_4
Xhold2 rst_n VSS VSS VDD VDD net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold3 mem_valid VSS VSS VDD VDD net166 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_1 _0133_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_2 _0181_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_3 _0320_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_4 _0659_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_5 _0659_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_6 _0143_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS memory_mapped_fifo
