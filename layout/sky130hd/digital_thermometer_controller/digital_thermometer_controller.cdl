* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT digital_thermometer_controller adc_valid adc_value[0]
+ adc_value[1] adc_value[2] adc_value[3] adc_value[4] adc_value[5]
+ adc_value[6] adc_value[7] adc_value[8] adc_value[9] alert
+ clk force_update rst_n status[0] status[1] status[2] temperature[0]
+ temperature[1] temperature[2] temperature[3] temperature[4]
+ temperature[5] temperature[6] temperature[7] units_select
+ update valid VSS VDD
Xinput6 adc_value[2] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkdlybuf4s50_1
X_078_ net13 net2 VSS VSS VDD VDD _000_ sky130_fd_sc_hd__or2_2
X_079_ input_count\[0\] VSS VSS VDD VDD _001_ sky130_fd_sc_hd__inv_1
X_080_ input_count\[1\] VSS VSS VDD VDD _002_ sky130_fd_sc_hd__inv_1
X_081_ net16 VSS VSS VDD VDD _053_ sky130_fd_sc_hd__inv_1
X_082_ _003_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__inv_1
X_083_ input_count\[2\] _054_ seen_high_temp input_count\[3\]
+ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__o211ai_1
X_084_ input_count\[2\] input_count\[3\] _054_ initialized
+ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__nor4_1
Xinput5 adc_value[1] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkdlybuf4s50_1
X_086_ _053_ _055_ net30 VSS VSS VDD VDD _006_ sky130_fd_sc_hd__a21oi_1
X_087_ celsius_value\[0\] VSS VSS VDD VDD _058_ sky130_fd_sc_hd__inv_1
X_088_ net10 net9 net12 net11 VSS VSS VDD VDD _059_ sky130_fd_sc_hd__nor4b_2
X_089_ net8 net7 _059_ VSS VSS VDD VDD _060_ sky130_fd_sc_hd__nand3_1
X_090_ net6 net5 net4 net3 VSS VSS VDD VDD _061_ sky130_fd_sc_hd__nor4bb_1
X_091_ net2 _061_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nand2_1
X_092_ net12 net9 VSS VSS VDD VDD _063_ sky130_fd_sc_hd__nor2b_1
X_093_ net8 net7 net10 net5 VSS VSS VDD VDD _064_ sky130_fd_sc_hd__and4bb_1
X_094_ net4 net3 net6 net2 VSS VSS VDD VDD _065_ sky130_fd_sc_hd__and4bb_2
X_095_ _063_ _064_ _065_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nand3_1
X_096_ _060_ _062_ _066_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__o21ai_2
X_097_ net4 net6 VSS VSS VDD VDD _068_ sky130_fd_sc_hd__and2b_1
X_098_ net3 _063_ _064_ _068_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__and4b_4
X_099_ net2 _069_ VSS VSS VDD VDD _070_ sky130_fd_sc_hd__nand2_1
X_100_ net11 VSS VSS VDD VDD _071_ sky130_fd_sc_hd__inv_1
X_101_ _058_ _067_ _070_ _071_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__o22ai_1
X_102_ net8 net7 _059_ _061_ VSS VSS VDD VDD _072_ sky130_fd_sc_hd__and4_1
X_103_ net2 _072_ VSS VSS VDD VDD _073_ sky130_fd_sc_hd__and2_1
X_104_ celsius_value\[1\] _070_ _073_ VSS VSS VDD VDD _008_
+ sky130_fd_sc_hd__a21o_1
X_105_ celsius_value\[2\] _067_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__or2_2
X_106_ net2 _071_ _069_ VSS VSS VDD VDD _074_ sky130_fd_sc_hd__nand3_2
X_107_ celsius_value\[3\] _067_ _074_ VSS VSS VDD VDD _010_
+ sky130_fd_sc_hd__o21a_1
X_108_ celsius_value\[4\] _067_ _070_ _071_ VSS VSS VDD VDD
+ _011_ sky130_fd_sc_hd__o22a_1
X_109_ net2 VSS VSS VDD VDD _030_ sky130_fd_sc_hd__inv_1
X_110_ _071_ _069_ _072_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__a21oi_1
X_111_ _030_ _031_ fahrenheit_value\[2\] VSS VSS VDD VDD _012_
+ sky130_fd_sc_hd__o21bai_1
X_112_ fahrenheit_value\[1\] _074_ _073_ VSS VSS VDD VDD _013_
+ sky130_fd_sc_hd__a21o_1
X_113_ net2 input_count\[0\] VSS VSS VDD VDD _015_ sky130_fd_sc_hd__xor2_1
X_114_ net2 _004_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__nand2_1
X_115_ net2 _002_ _032_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__o21ai_0
X_116_ net2 _005_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__nand2_1
X_117_ input_count\[2\] _033_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__xnor2_1
X_118_ input_count\[2\] net2 input_count\[1\] input_count\[0\]
+ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nand4_1
X_119_ input_count\[3\] _034_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__xnor2_1
X_120_ _071_ _066_ seen_high_temp VSS VSS VDD VDD _019_ sky130_fd_sc_hd__o21bai_1
X_121_ _030_ net17 _055_ net30 VSS VSS VDD VDD _020_ sky130_fd_sc_hd__a31o_2
X_122_ _030_ net18 VSS VSS VDD VDD _035_ sky130_fd_sc_hd__nand2_1
X_123_ net30 _035_ _055_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__o21ai_0
X_124_ net15 celsius_value\[0\] VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nand2_1
X_125_ net15 VSS VSS VDD VDD _037_ sky130_fd_sc_hd__inv_1
X_126_ net13 units_changed VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nor2_2
X_127_ _037_ net24 _038_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__nand3_1
X_128_ _036_ _039_ net30 VSS VSS VDD VDD _022_ sky130_fd_sc_hd__a21oi_1
X_129_ _038_ fahrenheit_value\[1\] VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nor2b_1
X_130_ net20 _038_ _040_ net15 VSS VSS VDD VDD _041_ sky130_fd_sc_hd__a211oi_1
X_131_ _037_ celsius_value\[1\] VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nor2_1
X_132_ net30 _041_ _042_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__nor3_1
X_133_ fahrenheit_value\[2\] net21 _038_ VSS VSS VDD VDD _043_
+ sky130_fd_sc_hd__mux2i_1
X_134_ _037_ celsius_value\[2\] VSS VSS VDD VDD _044_ sky130_fd_sc_hd__nor2_1
X_135_ _037_ _043_ _044_ net30 VSS VSS VDD VDD _024_ sky130_fd_sc_hd__a211oi_1
X_136_ net15 celsius_value\[3\] VSS VSS VDD VDD _045_ sky130_fd_sc_hd__nand2_1
X_137_ _037_ net22 _038_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__nand3_1
X_138_ _045_ _046_ net30 VSS VSS VDD VDD _025_ sky130_fd_sc_hd__a21oi_1
X_139_ net23 _038_ _040_ net15 VSS VSS VDD VDD _047_ sky130_fd_sc_hd__a211oi_1
X_140_ _037_ celsius_value\[4\] VSS VSS VDD VDD _048_ sky130_fd_sc_hd__nor2_1
X_141_ net30 _047_ _048_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__nor3_1
X_142_ fahrenheit_value\[2\] net25 _038_ VSS VSS VDD VDD _049_
+ sky130_fd_sc_hd__mux2i_1
X_143_ net15 net30 _049_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nor3_1
X_144_ net13 _037_ units_changed VSS VSS VDD VDD _028_ sky130_fd_sc_hd__a21o_1
X_145_ net27 VSS VSS VDD VDD _050_ sky130_fd_sc_hd__inv_1
X_146_ input_count\[2\] input_count\[3\] _005_ _069_ net2
+ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__o311ai_1
X_147_ _050_ _051_ net30 VSS VSS VDD VDD _029_ sky130_fd_sc_hd__a21oi_2
X_148_ initialized net30 VSS VSS VDD VDD _014_ sky130_fd_sc_hd__or2_2
X_149_ _001_ _002_ VSS VSS VDD VDD _003_ _004_ sky130_fd_sc_hd__ha_1
X_150_ input_count\[0\] input_count\[1\] VSS VSS VDD VDD _005_
+ _075_ sky130_fd_sc_hd__ha_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput4 adc_value[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkdlybuf4s50_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xinput3 adc_valid VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkdlybuf4s50_1
Xalert$_DFFE_PN0P_ clknet_1_1__leaf_clk _006_ net31 VSS VSS
+ VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xcelsius_value\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _007_
+ net31 VSS VSS VDD VDD celsius_value\[0\] sky130_fd_sc_hd__dfrtp_1
Xcelsius_value\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _008_
+ net31 VSS VSS VDD VDD celsius_value\[1\] sky130_fd_sc_hd__dfrtp_1
Xcelsius_value\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _009_
+ net31 VSS VSS VDD VDD celsius_value\[2\] sky130_fd_sc_hd__dfrtp_1
Xcelsius_value\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _010_
+ net31 VSS VSS VDD VDD celsius_value\[3\] sky130_fd_sc_hd__dfrtp_1
Xcelsius_value\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _011_
+ net31 VSS VSS VDD VDD celsius_value\[4\] sky130_fd_sc_hd__dfrtp_1
Xfahrenheit_value\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _012_
+ net31 VSS VSS VDD VDD fahrenheit_value\[2\] sky130_fd_sc_hd__dfrtp_1
Xfahrenheit_value\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _013_
+ net31 VSS VSS VDD VDD fahrenheit_value\[1\] sky130_fd_sc_hd__dfrtp_1
Xinitialized$_DFFE_PN0N_ clknet_1_1__leaf_clk _014_ net31
+ VSS VSS VDD VDD initialized sky130_fd_sc_hd__dfrtp_1
Xinput_count\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _015_ net31
+ VSS VSS VDD VDD input_count\[0\] sky130_fd_sc_hd__dfrtp_1
Xinput_count\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _016_ net31
+ VSS VSS VDD VDD input_count\[1\] sky130_fd_sc_hd__dfrtp_1
Xinput_count\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _017_ net31
+ VSS VSS VDD VDD input_count\[2\] sky130_fd_sc_hd__dfrtp_1
Xinput_count\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _018_ net31
+ VSS VSS VDD VDD input_count\[3\] sky130_fd_sc_hd__dfrtp_1
Xseen_high_temp$_DFFE_PN0P_ clknet_1_0__leaf_clk _019_ net31
+ VSS VSS VDD VDD seen_high_temp sky130_fd_sc_hd__dfrtp_1
Xstatus\[0\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _020_ net31
+ VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfstp_2
Xstatus\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _021_ net31
+ VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xtemperature\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _022_ net31
+ VSS VSS VDD VDD net24 sky130_fd_sc_hd__dfrtp_1
Xtemperature\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _023_ net31
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xtemperature\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _024_ net31
+ VSS VSS VDD VDD net21 sky130_fd_sc_hd__dfrtp_1
Xtemperature\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _025_ net31
+ VSS VSS VDD VDD net22 sky130_fd_sc_hd__dfrtp_1
Xtemperature\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _026_ net31
+ VSS VSS VDD VDD net23 sky130_fd_sc_hd__dfrtp_1
Xtemperature\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _027_ net31
+ VSS VSS VDD VDD net25 sky130_fd_sc_hd__dfrtp_1
Xunits_changed$_DFFE_PN0P_ clknet_1_1__leaf_clk _028_ net31
+ VSS VSS VDD VDD units_changed sky130_fd_sc_hd__dfrtp_1
Xupdate$_DFF_PN0_ clknet_1_1__leaf_clk _000_ net31 VSS VSS
+ VDD VDD net26 sky130_fd_sc_hd__dfrtp_1
Xvalid$_DFFE_PN0P_ clknet_1_1__leaf_clk _029_ net31 VSS VSS
+ VDD VDD net27 sky130_fd_sc_hd__dfrtp_1
X_152__1 VSS VSS VDD VDD _unconnected_0 status[1] sky130_fd_sc_hd__conb_1
X_154__2 VSS VSS VDD VDD _unconnected_1 temperature[7] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput7 adc_value[3] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput8 adc_value[4] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput9 adc_value[5] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput10 adc_value[6] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput11 adc_value[7] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput12 adc_value[8] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput13 adc_value[9] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput14 force_update VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput15 rst_n VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput16 units_select VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput17 net16 VSS VSS VDD VDD alert sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput18 net17 VSS VSS VDD VDD status[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput19 net18 VSS VSS VDD VDD status[2] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput20 net24 VSS VSS VDD VDD temperature[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput21 net20 VSS VSS VDD VDD temperature[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput22 net21 VSS VSS VDD VDD temperature[2] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput23 net22 VSS VSS VDD VDD temperature[3] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput24 net23 VSS VSS VDD VDD temperature[4] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput25 net24 VSS VSS VDD VDD temperature[5] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput26 net25 VSS VSS VDD VDD temperature[6] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput27 net26 VSS VSS VDD VDD update sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput28 net27 VSS VSS VDD VDD valid sky130_fd_sc_hd__clkdlybuf4s50_1
Xplace32 net14 VSS VSS VDD VDD net31 sky130_fd_sc_hd__buf_4
Xplace31 _056_ VSS VSS VDD VDD net30 sky130_fd_sc_hd__buf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkbuf_1
.ENDS digital_thermometer_controller
