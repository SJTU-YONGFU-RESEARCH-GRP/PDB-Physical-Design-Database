* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT configurable_priority_encoder grant_index[0] grant_index[1]
+ grant_index[2] request[0] request[1] request[2] request[3]
+ request[4] request[5] request[6] request[7] valid
X_10_ net7 VSS VSS VDD VDD _00_ sky130_fd_sc_hd__inv_1
X_11_ _00_ net8 net6 VSS VSS VDD VDD _01_ sky130_fd_sc_hd__a21oi_1
X_12_ net1 VSS VSS VDD VDD _02_ sky130_fd_sc_hd__inv_1
X_13_ net1 net3 net4 VSS VSS VDD VDD _03_ sky130_fd_sc_hd__nor3b_1
X_14_ _02_ net2 _03_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__a21oi_1
X_15_ net1 net5 net3 _01_ _04_ VSS VSS VDD VDD net9 sky130_fd_sc_hd__o41ai_1
X_16_ net4 net3 VSS VSS VDD VDD _05_ sky130_fd_sc_hd__nor2_1
X_17_ net6 net5 VSS VSS VDD VDD _06_ sky130_fd_sc_hd__nor2_1
X_18_ net7 net8 _06_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__o21ai_0
X_19_ net1 net2 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__nor2_1
X_20_ _05_ _07_ _08_ VSS VSS VDD VDD net10 sky130_fd_sc_hd__a21boi_0
X_21_ net7 net8 net6 net5 VSS VSS VDD VDD _09_ sky130_fd_sc_hd__nor4_1
X_22_ _09_ _05_ _08_ VSS VSS VDD VDD net11 sky130_fd_sc_hd__and3b_1
X_23_ _08_ _05_ _09_ VSS VSS VDD VDD net12 sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 request[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_1
Xinput2 request[1] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput3 request[2] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput4 request[3] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput5 request[4] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput6 request[5] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput7 request[6] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput8 request[7] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xoutput9 net9 VSS VSS VDD VDD grant_index[0] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net10 VSS VSS VDD VDD grant_index[1] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net11 VSS VSS VDD VDD grant_index[2] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net12 VSS VSS VDD VDD valid sky130_fd_sc_hd__clkbuf_1
.ENDS configurable_priority_encoder
