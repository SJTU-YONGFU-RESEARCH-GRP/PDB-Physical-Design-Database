* cell network_interface
* pin router_out_data[16]
* pin mem_rdata[0]
* pin router_out_data[12]
* pin mem_rdata[12]
* pin router_in_data[19]
* pin router_in_data[18]
* pin mem_addr[19]
* pin router_in_data[17]
* pin mem_addr[1]
* pin mem_wdata[1]
* pin mem_wdata[19]
* pin mem_wdata[17]
* pin mem_addr[17]
* pin router_in_data[22]
* pin mem_addr[18]
* pin msg_type[1]
* pin msg_type[2]
* pin mem_wdata[22]
* pin mem_wdata[18]
* pin mem_wdata[23]
* pin mem_wdata[20]
* pin mem_wdata[2]
* pin router_in_data[23]
* pin dest_id[2]
* pin dest_id[3]
* pin mem_wdata[26]
* pin router_in_data[27]
* pin router_in_data[26]
* pin mem_addr[13]
* pin mem_wdata[13]
* pin router_in_data[13]
* pin mem_addr[15]
* pin mem_wdata[15]
* pin router_in_data[15]
* pin mem_addr[11]
* pin mem_addr[12]
* pin mem_wdata[11]
* pin mem_wdata[12]
* pin mem_wdata[9]
* pin mem_addr[9]
* pin router_in_data[11]
* pin mem_rdata[16]
* pin router_in_data[20]
* pin dest_id[1]
* pin mem_wdata[25]
* pin router_in_data[25]
* pin router_in_data[12]
* pin router_out_data[0]
* pin mem_wdata[27]
* pin mem_addr[0]
* pin mem_rdata[10]
* pin mem_addr[8]
* pin mem_addr[10]
* pin router_in_data[9]
* pin router_out_data[10]
* pin mem_rdata[13]
* pin router_in_data[10]
* pin mem_addr[14]
* pin router_out_data[13]
* pin router_in_data[1]
* pin mem_wdata[14]
* pin mem_rdata[14]
* pin router_in_data[14]
* pin mem_wdata[8]
* pin mem_wdata[10]
* pin router_out_data[14]
* pin router_in_data[8]
* pin router_in_data[21]
* pin mem_rdata[17]
* pin router_in_data[0]
* pin mem_addr[16]
* pin msg_type[0]
* pin mem_wdata[16]
* pin router_out_data[17]
* pin router_in_data[16]
* pin mem_wdata[21]
* pin mem_wdata[24]
* pin mem_wdata[0]
* pin mem_addr[6]
* pin dest_id[0]
* pin mem_wdata[6]
* pin router_in_data[24]
* pin mem_wdata[5]
* pin mem_addr[20]
* pin router_out_data[15]
* pin mem_addr[2]
* pin mem_addr[5]
* pin mem_rdata[15]
* pin router_in_data[5]
* pin router_in_data[6]
* pin mem_rdata[11]
* pin mem_write
* pin router_out_data[11]
* pin mem_wdata[28]
* pin router_in_data[2]
* pin mem_read
* pin mem_rdata[9]
* pin dest_id[4]
* pin router_in_data[28]
* pin clk
* pin mem_rdata[7]
* pin router_out_data[9]
* pin mem_wdata[29]
* pin mem_wdata[31]
* pin router_out_data[7]
* pin dest_id[7]
* pin router_in_data[29]
* pin rst_n
* pin mem_wdata[4]
* pin router_in_data[31]
* pin mem_rdata[8]
* pin mem_wdata[7]
* pin router_out_data[8]
* pin mem_addr[7]
* pin router_in_data[4]
* pin mem_rdata[3]
* pin mem_addr[4]
* pin mem_rdata[4]
* pin router_in_data[7]
* pin router_out_data[4]
* pin dest_id[5]
* pin router_out_data[3]
* pin router_out_data[23]
* pin mem_rdata[23]
* pin router_out_data[2]
* pin mem_rdata[2]
* pin mem_rdata[18]
* pin router_out_data[30]
* pin router_out_data[28]
* pin router_out_ready
* pin mem_rdata[31]
* pin router_out_data[21]
* pin mem_rdata[19]
* pin mem_rdata[30]
* pin mem_rdata[28]
* pin router_out_data[5]
* pin router_out_data[31]
* pin router_in_data[30]
* pin mem_rdata[26]
* pin router_out_data[1]
* pin router_out_data[26]
* pin router_out_data[6]
* pin router_out_valid
* pin mem_wdata[30]
* pin router_out_data[24]
* pin router_out_data[22]
* pin router_out_data[18]
* pin router_out_data[19]
* pin router_out_data[27]
* pin router_out_data[20]
* pin mem_rdata[24]
* pin mem_ready
* pin dest_id[6]
* pin mem_wdata[3]
* pin router_out_data[25]
* pin router_out_data[29]
* pin mem_rdata[27]
* pin mem_rdata[6]
* pin mem_rdata[22]
* pin mem_rdata[5]
* pin router_in_ready
* pin mem_rdata[29]
* pin mem_rdata[21]
* pin router_in_data[3]
* pin router_in_valid
* pin mem_rdata[1]
* pin mem_rdata[25]
* pin mem_addr[3]
* pin mem_rdata[20]
.SUBCKT network_interface 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 44 45 46 47
+ 114 131 136 137 139 140 159 160 169 170 175 176 182 184 189 195 198 199 200
+ 207 212 221 222 224 225 230 232 237 243 254 255 258 259 267 272 273 281 284
+ 285 290 291 299 301 302 307 317 318 319 320 328 330 335 336 353 354 355 359
+ 360 365 373 374 378 380 381 387 392 395 400 401 412 417 424 429 434 437 447
+ 450 451 458 459 462 478 479 480 484 489 492 493 496 497 503 512 514 517 520
+ 523 524 525 526 527 528 529 530 531 532 533 534 535 536 537 538 539 541 542
+ 543 544 545 546 547 548 549 550 551
* net 1 router_out_data[16]
* net 2 mem_rdata[0]
* net 3 router_out_data[12]
* net 4 mem_rdata[12]
* net 5 router_in_data[19]
* net 6 router_in_data[18]
* net 7 mem_addr[19]
* net 8 router_in_data[17]
* net 9 mem_addr[1]
* net 10 mem_wdata[1]
* net 11 mem_wdata[19]
* net 12 mem_wdata[17]
* net 13 mem_addr[17]
* net 14 router_in_data[22]
* net 15 mem_addr[18]
* net 16 msg_type[1]
* net 17 msg_type[2]
* net 18 mem_wdata[22]
* net 19 mem_wdata[18]
* net 20 mem_wdata[23]
* net 21 mem_wdata[20]
* net 22 mem_wdata[2]
* net 23 router_in_data[23]
* net 24 dest_id[2]
* net 25 dest_id[3]
* net 26 mem_wdata[26]
* net 27 router_in_data[27]
* net 28 router_in_data[26]
* net 29 mem_addr[13]
* net 30 mem_wdata[13]
* net 31 router_in_data[13]
* net 32 mem_addr[15]
* net 33 mem_wdata[15]
* net 34 router_in_data[15]
* net 35 mem_addr[11]
* net 36 mem_addr[12]
* net 37 mem_wdata[11]
* net 38 mem_wdata[12]
* net 39 mem_wdata[9]
* net 40 mem_addr[9]
* net 41 router_in_data[11]
* net 42 mem_rdata[16]
* net 44 router_in_data[20]
* net 45 dest_id[1]
* net 46 mem_wdata[25]
* net 47 router_in_data[25]
* net 114 router_in_data[12]
* net 131 router_out_data[0]
* net 136 mem_wdata[27]
* net 137 mem_addr[0]
* net 139 mem_rdata[10]
* net 140 mem_addr[8]
* net 159 mem_addr[10]
* net 160 router_in_data[9]
* net 169 router_out_data[10]
* net 170 mem_rdata[13]
* net 175 router_in_data[10]
* net 176 mem_addr[14]
* net 182 router_out_data[13]
* net 184 router_in_data[1]
* net 189 mem_wdata[14]
* net 195 mem_rdata[14]
* net 198 router_in_data[14]
* net 199 mem_wdata[8]
* net 200 mem_wdata[10]
* net 207 router_out_data[14]
* net 212 router_in_data[8]
* net 221 router_in_data[21]
* net 222 mem_rdata[17]
* net 224 router_in_data[0]
* net 225 mem_addr[16]
* net 230 msg_type[0]
* net 232 mem_wdata[16]
* net 237 router_out_data[17]
* net 243 router_in_data[16]
* net 254 mem_wdata[21]
* net 255 mem_wdata[24]
* net 258 mem_wdata[0]
* net 259 mem_addr[6]
* net 267 dest_id[0]
* net 272 mem_wdata[6]
* net 273 router_in_data[24]
* net 281 mem_wdata[5]
* net 284 mem_addr[20]
* net 285 router_out_data[15]
* net 290 mem_addr[2]
* net 291 mem_addr[5]
* net 299 mem_rdata[15]
* net 301 router_in_data[5]
* net 302 router_in_data[6]
* net 307 mem_rdata[11]
* net 317 mem_write
* net 318 router_out_data[11]
* net 319 mem_wdata[28]
* net 320 router_in_data[2]
* net 328 mem_read
* net 330 mem_rdata[9]
* net 335 dest_id[4]
* net 336 router_in_data[28]
* net 353 clk
* net 354 mem_rdata[7]
* net 355 router_out_data[9]
* net 359 mem_wdata[29]
* net 360 mem_wdata[31]
* net 365 router_out_data[7]
* net 373 dest_id[7]
* net 374 router_in_data[29]
* net 378 rst_n
* net 380 mem_wdata[4]
* net 381 router_in_data[31]
* net 387 mem_rdata[8]
* net 392 mem_wdata[7]
* net 395 router_out_data[8]
* net 400 mem_addr[7]
* net 401 router_in_data[4]
* net 412 mem_rdata[3]
* net 417 mem_addr[4]
* net 424 mem_rdata[4]
* net 429 router_in_data[7]
* net 434 router_out_data[4]
* net 437 dest_id[5]
* net 447 router_out_data[3]
* net 450 router_out_data[23]
* net 451 mem_rdata[23]
* net 458 router_out_data[2]
* net 459 mem_rdata[2]
* net 462 mem_rdata[18]
* net 478 router_out_data[30]
* net 479 router_out_data[28]
* net 480 router_out_ready
* net 484 mem_rdata[31]
* net 489 router_out_data[21]
* net 492 mem_rdata[19]
* net 493 mem_rdata[30]
* net 496 mem_rdata[28]
* net 497 router_out_data[5]
* net 503 router_out_data[31]
* net 512 router_in_data[30]
* net 514 mem_rdata[26]
* net 517 router_out_data[1]
* net 520 router_out_data[26]
* net 523 router_out_data[6]
* net 524 router_out_valid
* net 525 mem_wdata[30]
* net 526 router_out_data[24]
* net 527 router_out_data[22]
* net 528 router_out_data[18]
* net 529 router_out_data[19]
* net 530 router_out_data[27]
* net 531 router_out_data[20]
* net 532 mem_rdata[24]
* net 533 mem_ready
* net 534 dest_id[6]
* net 535 mem_wdata[3]
* net 536 router_out_data[25]
* net 537 router_out_data[29]
* net 538 mem_rdata[27]
* net 539 mem_rdata[6]
* net 541 mem_rdata[22]
* net 542 mem_rdata[5]
* net 543 router_in_ready
* net 544 mem_rdata[29]
* net 545 mem_rdata[21]
* net 546 router_in_data[3]
* net 547 router_in_valid
* net 548 mem_rdata[1]
* net 549 mem_rdata[25]
* net 550 mem_addr[3]
* net 551 mem_rdata[20]
* cell instance $3 r0 *1 1.38,8.16
X$3 76 1 60 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $6 r0 *1 8.28,2.72
X$6 76 63 2 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $9 r0 *1 15.64,8.16
X$9 76 3 115 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $12 r0 *1 11.04,2.72
X$12 76 51 4 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $17 r0 *1 12.42,2.72
X$17 76 107 5 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $19 m0 *1 24.84,8.16
X$19 76 109 6 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $23 r0 *1 21.62,8.16
X$23 76 7 86 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $27 r0 *1 9.66,2.72
X$27 76 50 8 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $31 m0 *1 22.08,13.6
X$31 76 9 142 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $34 m0 *1 29.44,13.6
X$34 76 10 147 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $37 m0 *1 23.46,13.6
X$37 76 11 54 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $40 r0 *1 27.6,2.72
X$40 76 12 43 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $43 m0 *1 30.82,13.6
X$43 76 13 148 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $46 r0 *1 33.58,13.6
X$46 76 194 14 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $51 r0 *1 13.8,2.72
X$51 76 15 65 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $54 r0 *1 30.82,2.72
X$54 76 16 88 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $57 r0 *1 43.24,2.72
X$57 76 17 124 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $60 r0 *1 34.5,8.16
X$60 76 18 110 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $63 r0 *1 36.34,2.72
X$63 76 19 92 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $66 r0 *1 34.96,2.72
X$66 76 20 91 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $69 r0 *1 38.64,8.16
X$69 76 21 150 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $72 r0 *1 46,2.72
X$72 76 22 236 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $75 m0 *1 45.54,8.16
X$75 76 127 23 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $79 r0 *1 52.9,2.72
X$79 76 24 87 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $83 r0 *1 48.76,2.72
X$83 76 25 220 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $86 r0 *1 50.14,2.72
X$86 76 26 72 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $89 r0 *1 51.52,2.72
X$89 76 67 27 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $92 r0 *1 57.04,2.72
X$92 76 73 28 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $96 r0 *1 65.32,2.72
X$96 76 29 59 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $101 r0 *1 62.56,2.72
X$101 76 30 82 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $106 r0 *1 73.6,2.72
X$106 76 101 31 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $110 m0 *1 55.2,13.6
X$110 76 32 134 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $113 r0 *1 59.8,2.72
X$113 76 33 85 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $116 r0 *1 58.42,2.72
X$116 76 58 34 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $119 r0 *1 61.18,2.72
X$119 76 35 83 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $123 r0 *1 76.82,2.72
X$123 76 36 75 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $127 r0 *1 74.98,2.72
X$127 76 37 62 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $132 r0 *1 72.22,2.72
X$132 76 38 102 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $135 r0 *1 63.94,8.16
X$135 76 39 167 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $140 r0 *1 70.84,2.72
X$140 76 40 78 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $143 m0 *1 65.78,13.6
X$143 76 158 41 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $146 r0 *1 5.98,2.72
X$146 76 61 42 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $149 r0 *1 25.3,2.72
X$149 76 55 43 71 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $152 r0 *1 38.64,2.72
X$152 76 69 44 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $155 r0 *1 44.62,2.72
X$155 76 45 126 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $158 r0 *1 40.02,2.72
X$158 76 46 56 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $161 r0 *1 47.38,2.72
X$161 76 133 47 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $171 r0 *1 1.84,2.72
X$171 48 70 61 60 49 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $176 r0 *1 15.64,2.72
X$176 48 80 51 115 49 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $177 r0 *1 19.78,2.72
X$177 48 84 57 86 52 53 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $178 r0 *1 23,2.72
X$178 76 55 54 53 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $182 r0 *1 32.2,2.72
X$182 76 66 89 90 68 76 48 165 48 sky130_fd_sc_hd__o31ai_1
* cell instance $184 r0 *1 41.4,2.72
X$184 76 94 56 122 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $187 r0 *1 54.28,2.72
X$187 76 57 48 66 76 48 sky130_fd_sc_hd__buf_2
* cell instance $190 r0 *1 63.94,2.72
X$190 76 59 76 48 81 48 sky130_fd_sc_hd__inv_1
* cell instance $192 r0 *1 67.62,2.72
X$192 76 66 79 74 64 76 48 77 48 sky130_fd_sc_hd__o31ai_1
* cell instance $205 m0 *1 1.84,8.16
X$205 48 108 61 106 70 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $207 m0 *1 11.5,8.16
X$207 48 108 51 106 80 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $209 m0 *1 21.16,8.16
X$209 48 162 57 142 52 93 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $212 m0 *1 26.68,8.16
X$212 76 55 147 93 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $214 m0 *1 29.44,8.16
X$214 48 105 57 148 52 71 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $216 m0 *1 33.12,8.16
X$216 76 66 119 90 120 76 48 193 48 sky130_fd_sc_hd__o31ai_1
* cell instance $217 m0 *1 35.88,8.16
X$217 76 94 92 68 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $219 m0 *1 37.72,8.16
X$219 76 94 91 121 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $221 m0 *1 39.56,8.16
X$221 76 66 104 90 122 76 48 111 48 sky130_fd_sc_hd__o31ai_1
* cell instance $222 m0 *1 42.32,8.16
X$222 76 124 76 48 123 48 sky130_fd_sc_hd__inv_1
* cell instance $224 m0 *1 44.16,8.16
X$224 76 126 76 48 104 48 sky130_fd_sc_hd__inv_1
* cell instance $226 m0 *1 47.38,8.16
X$226 76 94 72 128 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $228 m0 *1 49.22,8.16
X$228 48 130 96 101 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $229 m0 *1 53.36,8.16
X$229 76 66 129 90 153 76 48 125 48 sky130_fd_sc_hd__o31ai_1
* cell instance $232 m0 *1 57.04,8.16
X$232 76 66 81 90 97 76 48 96 48 sky130_fd_sc_hd__o31ai_1
* cell instance $233 m0 *1 59.8,8.16
X$233 76 66 98 74 117 76 48 118 48 sky130_fd_sc_hd__o31ai_1
* cell instance $234 m0 *1 62.56,8.16
X$234 76 66 103 74 149 76 48 116 48 sky130_fd_sc_hd__o31ai_1
* cell instance $236 m0 *1 66.24,8.16
X$236 48 99 116 100 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $237 m0 *1 70.38,8.16
X$237 48 108 100 135 99 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $239 r0 *1 3.22,8.16
X$239 48 108 63 106 138 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $244 r0 *1 17.02,8.16
X$244 48 141 84 107 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $246 r0 *1 23,8.16
X$246 48 108 50 106 145 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $247 r0 *1 32.2,8.16
X$247 76 65 76 48 89 48 sky130_fd_sc_hd__inv_1
* cell instance $249 r0 *1 35.88,8.16
X$249 76 94 110 120 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $252 r0 *1 40.02,8.16
X$252 76 66 123 90 121 76 48 151 48 sky130_fd_sc_hd__o31ai_1
* cell instance $255 r0 *1 43.24,8.16
X$255 76 57 76 48 94 48 sky130_fd_sc_hd__clkbuf_2
* cell instance $256 r0 *1 45.08,8.16
X$256 76 66 112 90 128 76 48 152 48 sky130_fd_sc_hd__o31ai_1
* cell instance $257 r0 *1 47.84,8.16
X$257 76 87 76 48 112 48 sky130_fd_sc_hd__inv_1
* cell instance $258 r0 *1 49.22,8.16
X$258 48 108 101 135 130 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $259 r0 *1 58.42,8.16
X$259 76 94 85 153 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $260 r0 *1 59.8,8.16
X$260 76 83 76 48 98 48 sky130_fd_sc_hd__inv_1
* cell instance $261 r0 *1 61.18,8.16
X$261 76 94 82 97 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $262 r0 *1 62.56,8.16
X$262 76 94 62 117 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $263 r0 *1 65.32,8.16
X$263 76 94 102 64 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $264 r0 *1 66.7,8.16
X$264 76 78 76 48 103 48 sky130_fd_sc_hd__inv_1
* cell instance $267 r0 *1 69,8.16
X$267 76 75 76 48 79 48 sky130_fd_sc_hd__inv_1
* cell instance $269 r0 *1 70.84,8.16
X$269 48 146 77 113 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $270 r0 *1 74.98,8.16
X$270 76 140 143 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $272 r0 *1 76.82,8.16
X$272 76 137 144 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $273 r0 *1 78.2,8.16
X$273 76 113 114 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $281 m0 *1 3.22,13.6
X$281 76 131 155 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $282 m0 *1 4.6,13.6
X$282 48 138 63 155 49 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $283 m0 *1 8.74,13.6
X$283 76 156 139 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $286 m0 *1 12.88,13.6
X$286 48 108 107 106 141 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $287 m0 *1 24.84,13.6
X$287 48 145 105 50 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $289 m0 *1 32.2,13.6
X$289 76 88 76 48 119 48 sky130_fd_sc_hd__inv_1
* cell instance $292 m0 *1 35.88,13.6
X$292 48 157 111 133 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $293 m0 *1 40.02,13.6
X$293 48 108 133 135 157 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $296 m0 *1 53.82,13.6
X$296 76 134 76 48 129 48 sky130_fd_sc_hd__inv_1
* cell instance $299 m0 *1 57.96,13.6
X$299 48 168 118 158 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $301 m0 *1 63.94,13.6
X$301 76 94 167 149 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $303 m0 *1 67.16,13.6
X$303 76 136 166 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $304 m0 *1 68.54,13.6
X$304 48 108 113 135 146 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $306 m0 *1 78.2,13.6
X$306 76 100 160 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $307 r0 *1 1.38,13.6
X$307 76 169 154 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $308 r0 *1 2.76,13.6
X$308 48 108 156 106 161 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $318 r0 *1 17.02,13.6
X$318 48 191 162 185 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $325 r0 *1 38.64,13.6
X$325 48 181 151 127 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $335 r0 *1 53.82,13.6
X$335 48 180 125 58 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $336 r0 *1 57.96,13.6
X$336 48 108 158 135 168 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $345 r0 *1 71.76,13.6
X$345 48 179 164 163 52 192 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $346 r0 *1 74.98,13.6
X$346 76 159 163 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $348 r0 *1 76.82,13.6
X$348 76 189 178 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $349 r0 *1 78.2,13.6
X$349 76 176 177 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $350 m0 *1 1.38,19.04
X$350 76 172 170 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $352 m0 *1 3.68,19.04
X$352 48 190 172 171 49 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $353 m0 *1 7.82,19.04
X$353 48 161 156 154 49 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $357 m0 *1 18.4,19.04
X$357 48 186 106 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $361 m0 *1 29.44,19.04
X$361 48 202 165 109 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $364 m0 *1 38.18,19.04
X$364 48 108 127 135 181 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $365 m0 *1 47.38,19.04
X$365 48 108 58 135 180 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $370 m0 *1 64.86,19.04
X$370 48 173 179 174 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $371 m0 *1 69,19.04
X$371 48 108 174 135 173 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $372 m0 *1 78.2,19.04
X$372 76 174 175 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $373 r0 *1 1.38,19.04
X$373 76 182 171 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $374 r0 *1 2.76,19.04
X$374 76 183 195 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $375 r0 *1 4.14,19.04
X$375 48 108 172 106 190 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $376 r0 *1 13.34,19.04
X$376 76 185 184 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $381 r0 *1 15.64,19.04
X$381 48 108 185 196 191 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $382 r0 *1 24.84,19.04
X$382 48 106 552 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $385 r0 *1 32.66,19.04
X$385 48 203 193 194 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $395 r0 *1 51.52,19.04
X$395 48 186 135 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $398 r0 *1 58.88,19.04
X$398 48 108 187 135 206 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $399 r0 *1 68.08,19.04
X$399 76 187 198 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $405 r0 *1 71.3,19.04
X$405 76 55 178 204 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $406 r0 *1 73.6,19.04
X$406 76 55 188 192 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $407 r0 *1 75.9,19.04
X$407 76 200 188 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $408 r0 *1 77.28,19.04
X$408 76 199 201 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $413 m0 *1 1.38,24.48
X$413 76 207 208 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $414 m0 *1 2.76,24.48
X$414 48 108 183 106 213 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $418 m0 *1 19.78,24.48
X$418 48 108 109 196 202 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $422 m0 *1 30.82,24.48
X$422 48 108 194 106 203 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $424 m0 *1 41.86,24.48
X$424 48 108 73 135 219 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $430 m0 *1 61.18,24.48
X$430 48 206 205 187 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $434 m0 *1 68.54,24.48
X$434 48 205 164 177 52 204 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $437 m0 *1 73.14,24.48
X$437 48 217 164 143 52 197 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $438 m0 *1 76.36,24.48
X$438 76 55 201 197 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $442 r0 *1 2.76,24.48
X$442 76 214 222 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $443 r0 *1 4.14,24.48
X$443 48 213 183 208 49 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $446 r0 *1 12.42,24.48
X$446 76 209 221 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $451 r0 *1 15.64,24.48
X$451 48 234 216 209 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $462 r0 *1 44.16,24.48
X$462 48 219 152 73 228 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $463 r0 *1 48.3,24.48
X$463 76 220 76 48 229 48 sky130_fd_sc_hd__inv_1
* cell instance $465 r0 *1 50.14,24.48
X$465 48 108 210 135 211 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $467 r0 *1 61.18,24.48
X$467 48 211 217 210 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $469 r0 *1 65.78,24.48
X$469 76 218 224 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $470 r0 *1 67.16,24.48
X$470 48 227 164 144 52 215 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $475 r0 *1 74.98,24.48
X$475 76 225 226 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $476 r0 *1 76.36,24.48
X$476 76 210 212 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $478 r0 *1 78.2,24.48
X$478 76 231 243 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $485 m0 *1 1.38,29.92
X$485 48 108 214 196 244 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $486 m0 *1 10.58,29.92
X$486 76 230 223 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $487 m0 *1 11.96,29.92
X$487 48 108 209 196 234 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $488 m0 *1 21.16,29.92
X$488 48 216 57 223 52 248 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $489 m0 *1 24.38,29.92
X$489 76 240 48 57 76 48 sky130_fd_sc_hd__buf_2
* cell instance $494 m0 *1 29.9,29.92
X$494 48 108 69 196 250 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $495 m0 *1 39.1,29.92
X$495 48 228 132 76 76 48 sky130_fd_sc_hd__buf_6
* cell instance $499 m0 *1 46.46,29.92
X$499 76 57 236 253 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $500 m0 *1 48.76,29.92
X$500 48 228 95 76 76 48 sky130_fd_sc_hd__buf_6
* cell instance $503 m0 *1 54.28,29.92
X$503 76 235 166 251 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $509 m0 *1 63.48,29.92
X$509 48 249 227 218 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $510 m0 *1 67.62,29.92
X$510 48 108 231 233 241 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $512 m0 *1 77.74,29.92
X$512 76 232 245 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $514 r0 *1 1.38,29.92
X$514 76 237 238 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $515 r0 *1 2.76,29.92
X$515 48 244 214 238 49 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $516 r0 *1 6.9,29.92
X$516 76 254 239 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $519 r0 *1 13.8,29.92
X$519 76 196 554 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $523 r0 *1 16.1,29.92
X$523 48 261 257 246 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $525 r0 *1 21.16,29.92
X$525 76 240 239 248 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $526 r0 *1 23.46,29.92
X$526 76 240 262 275 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $528 r0 *1 26.22,29.92
X$528 76 240 48 55 76 48 sky130_fd_sc_hd__clkbuf_4
* cell instance $532 r0 *1 34.96,29.92
X$532 48 250 264 69 132 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $533 r0 *1 39.1,29.92
X$533 76 235 150 265 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $540 r0 *1 46,29.92
X$540 48 276 252 67 228 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $541 r0 *1 50.14,29.92
X$541 76 164 229 90 251 76 48 252 48 sky130_fd_sc_hd__o31ai_1
* cell instance $543 r0 *1 53.36,29.92
X$543 76 233 76 48 48 sky130_fd_sc_hd__clkinvlp_4
* cell instance $545 r0 *1 57.04,29.92
X$545 48 108 218 233 249 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $546 r0 *1 66.24,29.92
X$546 48 241 247 231 95 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $550 r0 *1 71.76,29.92
X$550 76 258 263 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $551 r0 *1 73.14,29.92
X$551 48 247 164 226 52 242 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $552 r0 *1 76.36,29.92
X$552 76 55 245 242 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $562 m0 *1 2.76,35.36
X$562 76 246 273 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $563 m0 *1 4.14,35.36
X$563 48 282 274 268 49 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $564 m0 *1 8.28,35.36
X$564 76 267 256 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $565 m0 *1 9.66,35.36
X$565 48 108 246 196 261 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $566 m0 *1 18.86,35.36
X$566 48 186 196 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $567 m0 *1 23.92,35.36
X$567 48 257 57 256 269 275 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $571 m0 *1 29.9,35.36
X$571 76 269 48 52 76 48 sky130_fd_sc_hd__clkbuf_4
* cell instance $573 m0 *1 33.58,35.36
X$573 76 269 48 90 76 48 sky130_fd_sc_hd__buf_2
* cell instance $575 m0 *1 37.26,35.36
X$575 76 266 296 265 76 264 48 48 sky130_fd_sc_hd__o21ai_0
* cell instance $577 m0 *1 40.94,35.36
X$577 76 57 48 266 76 48 sky130_fd_sc_hd__buf_2
* cell instance $578 m0 *1 42.78,35.36
X$578 48 108 67 233 276 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $579 m0 *1 51.98,35.36
X$579 76 57 48 235 76 48 sky130_fd_sc_hd__clkbuf_4
* cell instance $582 m0 *1 57.04,35.36
X$582 48 186 233 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $585 m0 *1 67.62,35.36
X$585 76 55 263 215 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $588 m0 *1 71.3,35.36
X$588 48 283 164 271 52 270 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $589 m0 *1 74.52,35.36
X$589 76 55 260 270 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $590 m0 *1 76.82,35.36
X$590 76 259 271 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $591 m0 *1 78.2,35.36
X$591 76 272 260 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $592 r0 *1 1.38,35.36
X$592 76 285 268 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $594 r0 *1 3.22,35.36
X$594 48 108 274 196 282 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $602 r0 *1 16.1,35.36
X$602 76 284 286 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $603 r0 *1 17.48,35.36
X$603 76 277 286 296 48 76 48 sky130_fd_sc_hd__nor2_1
* cell instance $604 r0 *1 18.86,35.36
X$604 76 255 262 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $605 r0 *1 20.24,35.36
X$605 76 287 277 269 48 76 48 sky130_fd_sc_hd__nor2b_1
* cell instance $608 r0 *1 27.14,35.36
X$608 48 108 278 196 294 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $609 r0 *1 36.34,35.36
X$609 76 278 76 48 240 48 sky130_fd_sc_hd__clkbuf_2
* cell instance $611 r0 *1 38.64,35.36
X$611 76 240 48 164 76 48 sky130_fd_sc_hd__buf_2
* cell instance $620 r0 *1 44.62,35.36
X$620 76 269 48 74 76 48 sky130_fd_sc_hd__clkbuf_4
* cell instance $622 r0 *1 49.22,35.36
X$622 48 297 164 279 90 253 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $625 r0 *1 53.82,35.36
X$625 48 108 300 233 298 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $626 r0 *1 63.02,35.36
X$626 48 306 164 280 90 289 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $627 r0 *1 66.24,35.36
X$627 76 55 295 289 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $628 r0 *1 68.54,35.36
X$628 76 281 295 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $634 r0 *1 70.84,35.36
X$634 48 293 283 292 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $635 r0 *1 74.98,35.36
X$635 76 291 280 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $637 r0 *1 78.2,35.36
X$637 76 290 279 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $638 m0 *1 1.38,40.8
X$638 76 274 299 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $639 m0 *1 2.76,40.8
X$639 76 304 307 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $640 m0 *1 4.14,40.8
X$640 48 313 304 312 49 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $643 m0 *1 11.04,40.8
X$643 48 108 287 196 305 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $644 m0 *1 20.24,40.8
X$644 76 277 288 287 48 76 305 48 sky130_fd_sc_hd__a21o_1
* cell instance $646 m0 *1 24.84,40.8
X$646 76 277 308 288 76 315 48 48 sky130_fd_sc_hd__o21ai_0
* cell instance $652 m0 *1 36.8,40.8
X$652 76 240 288 316 48 76 48 sky130_fd_sc_hd__nor2_1
* cell instance $662 m0 *1 62.1,40.8
X$662 48 298 306 300 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $663 m0 *1 66.24,40.8
X$663 76 300 301 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $666 m0 *1 70.38,40.8
X$666 48 108 292 233 293 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $667 r0 *1 1.38,40.8
X$667 76 318 312 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $668 r0 *1 2.76,40.8
X$668 48 108 304 196 313 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $675 r0 *1 17.48,40.8
X$675 76 288 308 314 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $676 r0 *1 18.86,40.8
X$676 76 309 314 277 288 48 351 76 48 sky130_fd_sc_hd__a22o_1
* cell instance $677 r0 *1 22.08,40.8
X$677 48 277 308 311 288 76 76 48 sky130_fd_sc_hd__nor3b_4
* cell instance $678 r0 *1 28.98,40.8
X$678 76 315 310 294 48 76 48 sky130_fd_sc_hd__nand2b_1
* cell instance $681 r0 *1 32.66,40.8
X$681 48 352 228 310 311 316 76 76 48 sky130_fd_sc_hd__nor4_4
* cell instance $688 r0 *1 46,40.8
X$688 48 228 303 76 76 48 sky130_fd_sc_hd__buf_6
* cell instance $689 r0 *1 50.14,40.8
X$689 48 324 297 323 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $694 r0 *1 61.18,40.8
X$694 48 108 321 233 322 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $699 r0 *1 78.2,40.8
X$699 76 292 302 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $707 m0 *1 1.84,46.24
X$707 76 331 330 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $708 m0 *1 3.22,46.24
X$708 48 337 331 347 368 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $712 m0 *1 10.58,46.24
X$712 76 317 76 48 277 48 sky130_fd_sc_hd__clkbuf_2
* cell instance $713 m0 *1 12.42,46.24
X$713 48 308 328 76 76 48 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $714 m0 *1 17.02,46.24
X$714 48 108 369 342 349 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $718 m0 *1 29.44,46.24
X$718 48 240 310 329 339 76 76 48 sky130_fd_sc_hd__a21boi_2
* cell instance $721 m0 *1 36.34,46.24
X$721 48 353 186 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $722 m0 *1 41.4,46.24
X$722 48 341 164 340 311 332 76 76 48 sky130_fd_sc_hd__o31a_1
* cell instance $723 m0 *1 44.62,46.24
X$723 76 339 76 48 332 48 sky130_fd_sc_hd__inv_1
* cell instance $726 m0 *1 47.38,46.24
X$726 48 108 323 333 324 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $731 m0 *1 66.24,46.24
X$731 48 322 338 321 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $733 m0 *1 70.84,46.24
X$733 76 235 327 74 325 76 48 338 48 sky130_fd_sc_hd__o31ai_1
* cell instance $734 m0 *1 73.6,46.24
X$734 76 266 334 325 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $735 m0 *1 74.98,46.24
X$735 76 319 334 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $737 m0 *1 76.82,46.24
X$737 76 326 76 48 327 48 sky130_fd_sc_hd__inv_1
* cell instance $738 m0 *1 78.2,46.24
X$738 76 323 320 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $740 r0 *1 3.22,46.24
X$740 76 355 347 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $741 r0 *1 4.6,46.24
X$741 48 108 331 342 337 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $748 r0 *1 17.94,46.24
X$748 76 49 76 48 349 48 sky130_fd_sc_hd__inv_1
* cell instance $750 r0 *1 19.78,46.24
X$750 48 108 309 342 351 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $753 r0 *1 30.36,46.24
X$753 48 344 339 311 310 356 343 76 76 48 sky130_fd_sc_hd__o41ai_1
* cell instance $754 r0 *1 33.58,46.24
X$754 48 329 339 352 309 240 76 76 48 sky130_fd_sc_hd__and4b_1
* cell instance $756 r0 *1 37.72,46.24
X$756 48 364 377 266 341 343 344 76 76 48 sky130_fd_sc_hd__a221oi_1
* cell instance $765 r0 *1 55.66,46.24
X$765 48 108 350 333 345 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $766 r0 *1 64.86,46.24
X$766 48 345 348 350 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $773 r0 *1 73.14,46.24
X$773 76 235 361 74 346 76 48 348 48 sky130_fd_sc_hd__o31ai_1
* cell instance $774 r0 *1 75.9,46.24
X$774 76 266 383 346 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $776 r0 *1 78.2,46.24
X$776 76 335 326 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $783 m0 *1 1.38,51.68
X$783 76 367 354 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $785 m0 *1 3.68,51.68
X$785 48 108 367 342 375 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $786 m0 *1 12.88,51.68
X$786 76 368 48 49 76 48 sky130_fd_sc_hd__clkbuf_4
* cell instance $787 m0 *1 15.64,51.68
X$787 48 384 288 342 362 76 76 48 sky130_fd_sc_hd__dfstp_2
* cell instance $791 m0 *1 30.36,51.68
X$791 48 329 356 339 309 76 76 48 sky130_fd_sc_hd__and3_1
* cell instance $792 m0 *1 32.66,51.68
X$792 48 379 339 329 309 76 76 48 sky130_fd_sc_hd__nand3_2
* cell instance $793 m0 *1 36.34,51.68
X$793 76 288 76 48 340 48 sky130_fd_sc_hd__inv_1
* cell instance $795 m0 *1 38.18,51.68
X$795 48 108 339 333 364 76 76 48 sky130_fd_sc_hd__dfrtp_4
* cell instance $801 m0 *1 57.5,51.68
X$801 48 108 370 333 357 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $803 m0 *1 67.16,51.68
X$803 48 357 376 370 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $805 m0 *1 72.22,51.68
X$805 76 235 363 74 358 76 48 376 48 sky130_fd_sc_hd__o31ai_1
* cell instance $807 m0 *1 75.44,51.68
X$807 76 266 371 358 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $808 m0 *1 76.82,51.68
X$808 76 321 336 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $809 m0 *1 78.2,51.68
X$809 76 359 371 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $810 r0 *1 1.38,51.68
X$810 76 365 366 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $812 r0 *1 3.68,51.68
X$812 48 375 367 366 368 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $815 r0 *1 11.96,51.68
X$815 76 382 76 48 384 48 sky130_fd_sc_hd__clkbuf_2
* cell instance $820 r0 *1 15.64,51.68
X$820 48 384 108 76 76 48 sky130_fd_sc_hd__buf_16
* cell instance $822 r0 *1 26.22,51.68
X$822 76 311 369 343 356 76 362 48 48 sky130_fd_sc_hd__a211o_1
* cell instance $823 r0 *1 29.44,51.68
X$823 76 288 369 388 48 76 48 sky130_fd_sc_hd__nor2_1
* cell instance $826 r0 *1 33.12,51.68
X$826 76 343 379 386 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $829 r0 *1 36.8,51.68
X$829 76 235 379 311 339 76 48 377 48 sky130_fd_sc_hd__o31ai_1
* cell instance $838 r0 *1 48.3,51.68
X$838 76 333 76 48 48 sky130_fd_sc_hd__clkinv_2
* cell instance $839 r0 *1 50.14,51.68
X$839 48 186 333 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $843 r0 *1 61.18,51.68
X$843 48 108 385 333 394 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $847 r0 *1 71.3,51.68
X$847 76 370 374 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $850 r0 *1 75.44,51.68
X$850 76 372 76 48 361 48 sky130_fd_sc_hd__inv_1
* cell instance $851 r0 *1 76.82,51.68
X$851 76 360 383 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $852 r0 *1 78.2,51.68
X$852 76 373 372 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $860 m0 *1 2.3,57.12
X$860 48 108 397 342 402 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $864 m0 *1 17.48,57.12
X$864 48 342 76 76 48 sky130_fd_sc_hd__bufinv_16
* cell instance $867 m0 *1 29.44,57.12
X$867 76 389 356 388 343 405 76 48 48 sky130_fd_sc_hd__o211ai_1
* cell instance $869 m0 *1 32.66,57.12
X$869 48 379 343 389 76 368 76 48 sky130_fd_sc_hd__nand3_4
* cell instance $871 m0 *1 39.56,57.12
X$871 76 407 48 343 76 48 sky130_fd_sc_hd__buf_2
* cell instance $873 m0 *1 42.32,57.12
X$873 48 108 411 333 410 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $878 m0 *1 57.04,57.12
X$878 48 409 420 408 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $882 m0 *1 67.62,57.12
X$882 48 394 404 385 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $883 m0 *1 71.76,57.12
X$883 76 235 393 74 390 76 48 404 48 sky130_fd_sc_hd__o31ai_1
* cell instance $885 m0 *1 75.44,57.12
X$885 76 266 391 390 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $886 m0 *1 76.82,57.12
X$886 76 385 401 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $887 m0 *1 78.2,57.12
X$887 76 380 391 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $888 r0 *1 1.38,57.12
X$888 76 395 396 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $889 r0 *1 2.76,57.12
X$889 48 402 397 396 368 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $890 r0 *1 6.9,57.12
X$890 76 378 76 382 48 48 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $891 r0 *1 10.58,57.12
X$891 76 397 387 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $898 r0 *1 17.48,57.12
X$898 48 186 342 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $901 r0 *1 26.68,57.12
X$901 76 369 343 419 48 76 48 sky130_fd_sc_hd__or2_0
* cell instance $902 r0 *1 28.98,57.12
X$902 76 399 388 398 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $903 r0 *1 30.36,57.12
X$903 76 389 343 399 379 76 406 48 48 sky130_fd_sc_hd__nand4b_1
* cell instance $904 r0 *1 33.58,57.12
X$904 48 108 407 333 421 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $909 r0 *1 46,57.12
X$909 48 410 423 411 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $911 r0 *1 53.82,57.12
X$911 48 108 408 333 409 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $915 r0 *1 66.24,57.12
X$915 76 350 381 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $922 r0 *1 72.22,57.12
X$922 76 403 76 48 393 48 sky130_fd_sc_hd__inv_1
* cell instance $932 m0 *1 1.38,62.56
X$932 76 425 412 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $933 m0 *1 2.76,62.56
X$933 48 438 430 439 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $936 m0 *1 9.2,62.56
X$936 48 108 425 342 441 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $938 m0 *1 22.08,62.56
X$938 76 368 48 431 76 48 sky130_fd_sc_hd__clkbuf_4
* cell instance $942 m0 *1 29.44,62.56
X$942 76 398 406 405 435 76 48 48 sky130_fd_sc_hd__nand3_1
* cell instance $945 m0 *1 33.58,62.56
X$945 76 389 386 413 76 421 48 48 sky130_fd_sc_hd__o21ai_0
* cell instance $946 m0 *1 35.42,62.56
X$946 76 266 339 329 413 76 48 48 sky130_fd_sc_hd__nand3_1
* cell instance $951 m0 *1 46,62.56
X$951 76 235 433 74 414 76 48 423 48 sky130_fd_sc_hd__o31ai_1
* cell instance $953 m0 *1 49.22,62.56
X$953 76 266 519 414 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $956 m0 *1 51.98,62.56
X$956 76 235 422 74 415 76 48 420 48 sky130_fd_sc_hd__o31ai_1
* cell instance $957 m0 *1 54.74,62.56
X$957 76 266 426 415 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $964 m0 *1 63.94,62.56
X$964 48 443 442 427 303 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $965 m0 *1 68.08,62.56
X$965 76 427 429 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $967 m0 *1 69.92,62.56
X$967 76 235 418 74 416 76 48 442 48 sky130_fd_sc_hd__o31ai_1
* cell instance $968 m0 *1 72.68,62.56
X$968 76 432 76 48 418 48 sky130_fd_sc_hd__inv_1
* cell instance $970 m0 *1 74.98,62.56
X$970 76 266 428 416 76 48 48 sky130_fd_sc_hd__nand2_1
* cell instance $971 m0 *1 76.36,62.56
X$971 76 417 403 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $973 m0 *1 78.2,62.56
X$973 76 392 428 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $974 r0 *1 1.38,62.56
X$974 48 108 430 456 438 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $975 r0 *1 10.58,62.56
X$975 48 441 425 453 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $984 r0 *1 23.92,62.56
X$984 48 108 399 456 435 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $987 r0 *1 37.72,62.56
X$987 76 368 48 436 76 48 sky130_fd_sc_hd__clkbuf_4
* cell instance $996 r0 *1 46,62.56
X$996 76 444 76 48 433 48 sky130_fd_sc_hd__inv_1
* cell instance $998 r0 *1 51.06,62.56
X$998 76 446 76 48 422 48 sky130_fd_sc_hd__inv_1
* cell instance $999 r0 *1 52.44,62.56
X$999 48 457 448 445 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1002 r0 *1 61.18,62.56
X$1002 48 108 427 449 443 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1008 r0 *1 71.3,62.56
X$1008 76 440 76 48 363 48 sky130_fd_sc_hd__inv_1
* cell instance $1009 r0 *1 72.68,62.56
X$1009 48 454 452 475 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1012 m0 *1 1.38,68
X$1012 76 460 459 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1013 m0 *1 2.76,68
X$1013 76 430 424 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1015 m0 *1 5.06,68
X$1015 76 434 439 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1018 m0 *1 11.96,68
X$1018 76 447 453 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1022 m0 *1 18.4,68
X$1022 48 108 485 456 455 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1027 m0 *1 30.36,68
X$1027 48 467 468 469 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1029 m0 *1 36.34,68
X$1029 48 108 461 449 482 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1032 m0 *1 51.06,68
X$1032 48 186 449 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $1035 m0 *1 57.04,68
X$1035 48 108 472 449 466 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1036 m0 *1 66.24,68
X$1036 48 465 463 464 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1037 m0 *1 70.38,68
X$1037 48 108 452 449 454 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1038 r0 *1 1.38,68
X$1038 76 458 473 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1039 r0 *1 2.76,68
X$1039 48 474 460 473 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1042 r0 *1 11.04,68
X$1042 48 476 470 477 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1046 r0 *1 17.48,68
X$1046 76 478 504 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1047 r0 *1 18.86,68
X$1047 76 456 553 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1048 r0 *1 20.24,68
X$1048 48 186 456 76 76 48 sky130_fd_sc_hd__clkbuf_8
* cell instance $1049 r0 *1 25.3,68
X$1049 76 479 495 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1051 r0 *1 27.6,68
X$1051 48 108 468 456 467 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1053 r0 *1 38.64,68
X$1053 48 482 461 483 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1057 r0 *1 45.08,68
X$1057 48 108 448 449 457 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1060 r0 *1 56.58,68
X$1060 48 466 472 481 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1062 r0 *1 61.18,68
X$1062 48 108 463 449 465 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1068 r0 *1 74.06,68
X$1068 76 400 432 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1069 r0 *1 75.44,68
X$1069 76 450 475 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1070 r0 *1 76.82,68
X$1070 76 437 440 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1071 r0 *1 78.2,68
X$1071 76 452 451 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1079 m0 *1 1.84,73.44
X$1079 48 108 460 456 474 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1081 m0 *1 11.5,73.44
X$1081 48 108 470 456 476 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1082 m0 *1 20.7,73.44
X$1082 76 494 493 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1083 m0 *1 22.08,73.44
X$1083 48 455 485 495 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1084 m0 *1 26.22,73.44
X$1084 76 485 496 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1085 m0 *1 27.6,73.44
X$1085 76 419 480 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1088 m0 *1 29.9,73.44
X$1088 76 497 486 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1090 m0 *1 32.2,73.44
X$1090 48 511 487 513 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1092 m0 *1 37.26,73.44
X$1092 48 108 488 449 515 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1094 m0 *1 47.38,73.44
X$1094 48 108 490 449 471 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1096 m0 *1 57.04,73.44
X$1096 48 471 490 518 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1097 m0 *1 61.18,73.44
X$1097 48 108 491 449 510 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1098 m0 *1 70.38,73.44
X$1098 48 108 500 449 508 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1101 r0 *1 2.76,73.44
X$1101 48 108 502 456 501 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1102 r0 *1 11.96,73.44
X$1102 76 470 484 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1104 r0 *1 13.8,73.44
X$1104 76 503 477 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1108 r0 *1 16.1,73.44
X$1108 48 505 494 504 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1109 r0 *1 20.24,73.44
X$1109 48 108 498 456 507 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1110 r0 *1 29.44,73.44
X$1110 48 108 487 456 511 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1111 r0 *1 38.64,73.44
X$1111 48 515 488 516 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1114 r0 *1 43.24,73.44
X$1114 76 517 483 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1115 r0 *1 44.62,73.44
X$1115 48 108 521 449 499 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1116 r0 *1 53.82,73.44
X$1116 76 489 445 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1117 r0 *1 55.2,73.44
X$1117 48 499 521 522 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1118 r0 *1 59.34,73.44
X$1118 76 520 518 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1119 r0 *1 60.72,73.44
X$1119 76 490 514 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1120 r0 *1 62.1,73.44
X$1120 76 408 512 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1123 r0 *1 64.86,73.44
X$1123 48 510 491 509 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1129 r0 *1 72.68,73.44
X$1129 48 508 500 506 436 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1130 r0 *1 76.82,73.44
X$1130 76 463 462 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1131 r0 *1 78.2,73.44
X$1131 76 500 492 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1141 m0 *1 7.36,78.88
X$1141 48 501 502 540 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1142 m0 *1 11.5,78.88
X$1142 76 530 540 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1143 m0 *1 12.88,78.88
X$1143 76 502 538 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1146 m0 *1 15.64,78.88
X$1146 48 108 494 456 505 76 76 48 sky130_fd_sc_hd__dfrtp_1
* cell instance $1147 m0 *1 24.84,78.88
X$1147 76 399 533 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1148 m0 *1 26.22,78.88
X$1148 76 498 542 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1149 m0 *1 27.6,78.88
X$1149 76 523 469 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1151 m0 *1 29.44,78.88
X$1151 48 507 498 486 431 76 76 48 sky130_fd_sc_hd__mux2_1
* cell instance $1152 m0 *1 33.58,78.88
X$1152 76 537 513 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1153 m0 *1 34.96,78.88
X$1153 76 543 76 48 329 48 sky130_fd_sc_hd__clkbuf_2
* cell instance $1154 m0 *1 36.8,78.88
X$1154 76 468 539 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1155 m0 *1 38.18,78.88
X$1155 76 487 544 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1156 m0 *1 39.56,78.88
X$1156 76 524 76 48 389 48 sky130_fd_sc_hd__clkbuf_2
* cell instance $1157 m0 *1 41.4,78.88
X$1157 76 536 516 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1159 m0 *1 43.24,78.88
X$1159 76 488 549 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1160 m0 *1 44.62,78.88
X$1160 76 461 548 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1161 m0 *1 46,78.88
X$1161 76 550 444 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1162 m0 *1 47.38,78.88
X$1162 76 339 547 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1163 m0 *1 48.76,78.88
X$1163 76 535 519 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1164 m0 *1 50.14,78.88
X$1164 76 411 546 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1166 m0 *1 52.44,78.88
X$1166 76 534 446 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1167 m0 *1 53.82,78.88
X$1167 76 448 545 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1168 m0 *1 55.2,78.88
X$1168 76 525 426 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1170 m0 *1 57.04,78.88
X$1170 76 521 532 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1171 m0 *1 58.42,78.88
X$1171 76 526 522 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1172 m0 *1 59.8,78.88
X$1172 76 527 481 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1173 m0 *1 61.18,78.88
X$1173 76 472 541 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1176 m0 *1 65.32,78.88
X$1176 76 531 509 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1178 m0 *1 67.16,78.88
X$1178 76 491 551 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1179 m0 *1 68.54,78.88
X$1179 76 528 464 48 76 48 sky130_fd_sc_hd__clkbuf_1
* cell instance $1185 m0 *1 74.06,78.88
X$1185 76 529 506 48 76 48 sky130_fd_sc_hd__clkbuf_1
.ENDS network_interface

* cell sky130_fd_sc_hd__clkinvlp_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinvlp_4 1 2 3 4 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.525,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=250000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 0.475,0.51 nfet_01v8
M$5 8 2 4 6 nfet_01v8 L=150000U W=550000U AS=145750000000P AD=57750000000P
+ PS=1630000U PD=760000U
* device instance $6 r0 *1 0.835,0.51 nfet_01v8
M$6 5 2 8 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=77000000000P
+ PS=760000U PD=830000U
* device instance $7 r0 *1 1.265,0.51 nfet_01v8
M$7 7 2 5 6 nfet_01v8 L=150000U W=550000U AS=77000000000P AD=57750000000P
+ PS=830000U PD=760000U
* device instance $8 r0 *1 1.625,0.51 nfet_01v8
M$8 4 2 7 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=145750000000P
+ PS=760000U PD=1630000U
.ENDS sky130_fd_sc_hd__clkinvlp_4

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__and4b_1
* pin VGND
* pin B
* pin C
* pin X
* pin A_N
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4b_1 1 4 5 6 7 8 12 13 14
* net 1 VGND
* net 4 B
* net 5 C
* net 6 X
* net 7 A_N
* net 8 D
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 12 7 2 13 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,2.275 pfet_01v8_hvt
M$2 3 2 12 13 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=98700000000P
+ PS=690000U PD=890000U
* device instance $3 r0 *1 1.51,2.275 pfet_01v8_hvt
M$3 12 4 3 13 pfet_01v8_hvt L=150000U W=420000U AS=98700000000P
+ AD=128100000000P PS=890000U PD=1030000U
* device instance $4 r0 *1 2.27,2.275 pfet_01v8_hvt
M$4 3 5 12 13 pfet_01v8_hvt L=150000U W=420000U AS=128100000000P
+ AD=66150000000P PS=1030000U PD=735000U
* device instance $5 r0 *1 2.735,2.275 pfet_01v8_hvt
M$5 3 8 12 13 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=66150000000P PS=1325000U PD=735000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 6 3 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 1.41,0.445 nfet_01v8
M$7 11 2 3 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $8 r0 *1 1.77,0.445 nfet_01v8
M$8 10 4 11 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=73500000000P
+ PS=630000U PD=770000U
* device instance $9 r0 *1 2.27,0.445 nfet_01v8
M$9 9 5 10 14 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=60900000000P
+ PS=770000U PD=710000U
* device instance $10 r0 *1 2.71,0.445 nfet_01v8
M$10 1 8 9 14 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=103400000000P
+ PS=710000U PD=1000000U
* device instance $11 r0 *1 3.21,0.56 nfet_01v8
M$11 6 3 1 14 nfet_01v8 L=150000U W=650000U AS=103400000000P AD=169000000000P
+ PS=1000000U PD=1820000U
* device instance $12 r0 *1 0.47,0.445 nfet_01v8
M$12 1 7 2 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and4b_1

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__nand3_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_2 1 3 5 6 7 8 9 10
* net 1 VGND
* net 3 Y
* net 5 A
* net 6 B
* net 7 C
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 3 7 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=445000000000P PS=3790000U PD=3890000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 3 6 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $7 r0 *1 2.67,0.56 nfet_01v8
M$7 4 7 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=289250000000P
+ PS=2740000U PD=2840000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 5 2 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.31,0.56 nfet_01v8
M$11 4 6 2 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand3_2

* cell sky130_fd_sc_hd__nand3_4
* pin VGND
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_4 1 2 5 6 7 8 9 10
* net 1 VGND
* net 2 C
* net 5 B
* net 6 A
* net 7 VPWR
* net 8 Y
* net 9 VPB
* device instance $1 r0 *1 4.35,1.985 pfet_01v8_hvt
M$1 8 6 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=675000000000P PS=6330000U PD=6350000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 2.15,1.985 pfet_01v8_hvt
M$9 8 5 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 2 3 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $17 r0 *1 2.15,0.56 nfet_01v8
M$17 4 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $21 r0 *1 4.35,0.56 nfet_01v8
M$21 8 6 4 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=438750000000P
+ PS=4580000U PD=4600000U
.ENDS sky130_fd_sc_hd__nand3_4

* cell sky130_fd_sc_hd__a211o_1
* pin VPB
* pin B1
* pin C1
* pin A1
* pin A2
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a211o_1 1 2 3 4 5 7 8 9 11
* net 1 VPB
* net 2 B1
* net 3 C1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 X
* net 9 VGND
* device instance $1 r0 *1 1.425,1.985 pfet_01v8_hvt
M$1 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.855,1.985 pfet_01v8_hvt
M$2 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 2.285,1.985 pfet_01v8_hvt
M$3 12 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 2.745,1.985 pfet_01v8_hvt
M$4 6 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.475,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=265000000000P PS=2530000U PD=2530000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 9 6 8 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=260000000000P
+ PS=1830000U PD=1450000U
* device instance $7 r0 *1 1.425,0.56 nfet_01v8
M$7 13 5 9 11 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=91000000000P
+ PS=1450000U PD=930000U
* device instance $8 r0 *1 1.855,0.56 nfet_01v8
M$8 6 4 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $9 r0 *1 2.285,0.56 nfet_01v8
M$9 9 2 6 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $10 r0 *1 2.745,0.56 nfet_01v8
M$10 6 3 9 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211o_1

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__a21boi_2
* pin VGND
* pin B1_N
* pin Y
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_2 1 2 4 5 6 9 10 12
* net 1 VGND
* net 2 B1_N
* net 4 Y
* net 5 A2
* net 6 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 4 3 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 2.26,1.985 pfet_01v8_hvt
M$3 9 5 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=275000000000P
+ AD=420000000000P PS=2550000U PD=3840000U
* device instance $4 r0 *1 2.68,1.985 pfet_01v8_hvt
M$4 11 6 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=275000000000P
+ AD=280000000000P PS=2550000U PD=2560000U
* device instance $7 r0 *1 0.475,2.1 pfet_01v8_hvt
M$7 3 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P
+ AD=111300000000P PS=1370000U PD=1370000U
* device instance $8 r0 *1 0.68,0.445 nfet_01v8
M$8 1 2 3 12 nfet_01v8 L=150000U W=420000U AS=126000000000P AD=183125000000P
+ PS=1440000U PD=1240000U
* device instance $9 r0 *1 1.42,0.56 nfet_01v8
M$9 4 3 1 12 nfet_01v8 L=150000U W=1300000U AS=270875000000P AD=195000000000P
+ PS=2160000U PD=1900000U
* device instance $11 r0 *1 2.32,0.56 nfet_01v8
M$11 8 5 1 12 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=68250000000P
+ PS=980000U PD=860000U
* device instance $12 r0 *1 2.68,0.56 nfet_01v8
M$12 4 6 8 12 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=91000000000P
+ PS=860000U PD=930000U
* device instance $13 r0 *1 3.11,0.56 nfet_01v8
M$13 7 6 4 12 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $14 r0 *1 3.54,0.56 nfet_01v8
M$14 1 5 7 12 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=185250000000P
+ PS=930000U PD=1870000U
.ENDS sky130_fd_sc_hd__a21boi_2

* cell sky130_fd_sc_hd__o41ai_1
* pin VGND
* pin Y
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o41ai_1 1 2 4 5 6 7 8 9 10 14
* net 1 VGND
* net 2 Y
* net 4 B1
* net 5 A4
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=312500000000P PS=1270000U PD=1625000U
* device instance $3 r0 *1 1.665,1.985 pfet_01v8_hvt
M$3 13 6 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=312500000000P
+ AD=135000000000P PS=1625000U PD=1270000U
* device instance $4 r0 *1 2.085,1.985 pfet_01v8_hvt
M$4 12 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=175000000000P PS=1270000U PD=1350000U
* device instance $5 r0 *1 2.585,1.985 pfet_01v8_hvt
M$5 9 8 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=280000000000P PS=1350000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 3 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=203125000000P
+ PS=1820000U PD=1275000U
* device instance $7 r0 *1 1.245,0.56 nfet_01v8
M$7 1 5 3 14 nfet_01v8 L=150000U W=650000U AS=203125000000P AD=87750000000P
+ PS=1275000U PD=920000U
* device instance $8 r0 *1 1.665,0.56 nfet_01v8
M$8 3 6 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 2.085,0.56 nfet_01v8
M$9 1 7 3 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $10 r0 *1 2.585,0.56 nfet_01v8
M$10 3 8 1 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=182000000000P
+ PS=1000000U PD=1860000U
.ENDS sky130_fd_sc_hd__o41ai_1

* cell sky130_fd_sc_hd__dlymetal6s2s_1
* pin VGND
* pin X
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dlymetal6s2s_1 1 3 8 9 10 11
* net 1 VGND
* net 3 X
* net 8 A
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.655,2.275 pfet_01v8_hvt
M$1 6 5 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 4.13,1.985 pfet_01v8_hvt
M$2 7 6 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 2.24,2.275 pfet_01v8_hvt
M$3 4 3 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $4 r0 *1 2.715,1.985 pfet_01v8_hvt
M$4 5 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $5 r0 *1 0.645,2.275 pfet_01v8_hvt
M$5 2 8 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $6 r0 *1 1.12,1.985 pfet_01v8_hvt
M$6 3 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 3.655,0.445 nfet_01v8
M$7 1 5 6 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $8 r0 *1 4.13,0.56 nfet_01v8
M$8 7 6 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $9 r0 *1 0.645,0.445 nfet_01v8
M$9 1 8 2 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $10 r0 *1 1.12,0.56 nfet_01v8
M$10 3 2 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 2.24,0.445 nfet_01v8
M$11 1 3 4 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $12 r0 *1 2.715,0.56 nfet_01v8
M$12 5 4 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
.ENDS sky130_fd_sc_hd__dlymetal6s2s_1

* cell sky130_fd_sc_hd__dfstp_2
* pin VGND
* pin SET_B
* pin Q
* pin CLK
* pin D
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__dfstp_2 1 6 10 16 17 19 20 24
* net 1 VGND
* net 6 SET_B
* net 10 Q
* net 16 CLK
* net 17 D
* net 19 VPB
* net 20 VPWR
* device instance $1 r0 *1 8.345,1.985 pfet_01v8_hvt
M$1 20 8 9 19 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 8.765,1.985 pfet_01v8_hvt
M$2 10 9 20 19 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $4 r0 *1 6.905,2.275 pfet_01v8_hvt
M$4 8 6 20 19 pfet_01v8_hvt L=150000U W=420000U AS=120750000000P
+ AD=109200000000P PS=1165000U PD=1360000U
* device instance $5 r0 *1 7.38,2.065 pfet_01v8_hvt
M$5 18 8 20 19 pfet_01v8_hvt L=150000U W=840000U AS=120750000000P
+ AD=222600000000P PS=1165000U PD=2210000U
* device instance $6 r0 *1 0.47,2.135 pfet_01v8_hvt
M$6 20 16 2 19 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $7 r0 *1 0.89,2.135 pfet_01v8_hvt
M$7 3 2 20 19 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $8 r0 *1 1.83,2.065 pfet_01v8_hvt
M$8 4 17 20 19 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=124950000000P PS=2200000U PD=1175000U
* device instance $9 r0 *1 2.315,2.275 pfet_01v8_hvt
M$9 5 3 4 19 pfet_01v8_hvt L=150000U W=420000U AS=124950000000P AD=56700000000P
+ PS=1175000U PD=690000U
* device instance $10 r0 *1 2.735,2.275 pfet_01v8_hvt
M$10 21 2 5 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=94500000000P PS=690000U PD=870000U
* device instance $11 r0 *1 3.335,2.275 pfet_01v8_hvt
M$11 20 7 21 19 pfet_01v8_hvt L=150000U W=420000U AS=94500000000P
+ AD=79800000000P PS=870000U PD=800000U
* device instance $12 r0 *1 3.865,2.275 pfet_01v8_hvt
M$12 7 6 20 19 pfet_01v8_hvt L=150000U W=420000U AS=79800000000P
+ AD=56700000000P PS=800000U PD=690000U
* device instance $13 r0 *1 4.285,2.275 pfet_01v8_hvt
M$13 20 5 7 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $14 r0 *1 4.705,2.275 pfet_01v8_hvt
M$14 22 5 20 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=44100000000P PS=690000U PD=630000U
* device instance $15 r0 *1 5.065,2.275 pfet_01v8_hvt
M$15 8 2 22 19 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=81900000000P PS=630000U PD=810000U
* device instance $16 r0 *1 5.605,2.275 pfet_01v8_hvt
M$16 23 3 8 19 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P
+ AD=44100000000P PS=810000U PD=630000U
* device instance $17 r0 *1 5.965,2.275 pfet_01v8_hvt
M$17 20 18 23 19 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=109200000000P PS=630000U PD=1360000U
* device instance $18 r0 *1 8.345,0.56 nfet_01v8
M$18 1 8 9 24 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $19 r0 *1 8.765,0.56 nfet_01v8
M$19 10 9 1 24 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $21 r0 *1 2.305,0.415 nfet_01v8
M$21 5 2 4 24 nfet_01v8 L=150000U W=360000U AS=93500000000P AD=72000000000P
+ PS=965000U PD=760000U
* device instance $22 r0 *1 2.855,0.415 nfet_01v8
M$22 12 3 5 24 nfet_01v8 L=150000U W=360000U AS=72000000000P AD=67050000000P
+ PS=760000U PD=750000U
* device instance $23 r0 *1 3.335,0.445 nfet_01v8
M$23 1 7 12 24 nfet_01v8 L=150000U W=420000U AS=67050000000P AD=88200000000P
+ PS=750000U PD=840000U
* device instance $24 r0 *1 3.905,0.445 nfet_01v8
M$24 15 6 1 24 nfet_01v8 L=150000U W=420000U AS=88200000000P AD=44100000000P
+ PS=840000U PD=630000U
* device instance $25 r0 *1 4.265,0.445 nfet_01v8
M$25 7 5 15 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=109200000000P
+ PS=630000U PD=1360000U
* device instance $26 r0 *1 1.83,0.555 nfet_01v8
M$26 4 17 1 24 nfet_01v8 L=150000U W=640000U AS=166400000000P AD=93500000000P
+ PS=1800000U PD=965000U
* device instance $27 r0 *1 0.47,0.445 nfet_01v8
M$27 1 16 2 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $28 r0 *1 0.89,0.445 nfet_01v8
M$28 3 2 1 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $29 r0 *1 5.205,0.445 nfet_01v8
M$29 13 5 1 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $30 r0 *1 5.565,0.445 nfet_01v8
M$30 8 3 13 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=73500000000P
+ PS=630000U PD=770000U
* device instance $31 r0 *1 6.065,0.445 nfet_01v8
M$31 14 2 8 24 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=44100000000P
+ PS=770000U PD=630000U
* device instance $32 r0 *1 6.425,0.445 nfet_01v8
M$32 11 18 14 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $33 r0 *1 6.785,0.445 nfet_01v8
M$33 1 6 11 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=113700000000P
+ PS=630000U PD=1010000U
* device instance $34 r0 *1 7.405,0.505 nfet_01v8
M$34 18 8 1 24 nfet_01v8 L=150000U W=540000U AS=113700000000P AD=140400000000P
+ PS=1010000U PD=1600000U
.ENDS sky130_fd_sc_hd__dfstp_2

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__buf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_16 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=935000000000P
+ AD=810000000000P PS=8870000U PD=7620000U
* device instance $7 r0 *1 2.99,1.985 pfet_01v8_hvt
M$7 4 3 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $23 r0 *1 0.47,0.56 nfet_01v8
M$23 3 2 1 7 nfet_01v8 L=150000U W=3900000U AS=607750000000P AD=526500000000P
+ PS=6420000U PD=5520000U
* device instance $29 r0 *1 2.99,0.56 nfet_01v8
M$29 4 3 1 7 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__buf_16

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__bufinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__bufinv_16 1 5 6 7 8
* net 1 VGND
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 5 2 7 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 3 2 6 7 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=810000000000P PS=7620000U PD=7620000U
* device instance $10 r0 *1 4.25,1.985 pfet_01v8_hvt
M$10 4 3 6 7 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 5 2 8 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $29 r0 *1 1.73,0.56 nfet_01v8
M$29 3 2 1 8 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=526500000000P
+ PS=5520000U PD=5520000U
* device instance $35 r0 *1 4.25,0.56 nfet_01v8
M$35 4 3 1 8 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__bufinv_16

* cell sky130_fd_sc_hd__or2_0
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_0 1 2 3 4 6 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 9 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.985 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=98950000000P
+ PS=630000U PD=975000U
* device instance $3 r0 *1 1.52,2.095 pfet_01v8_hvt
M$3 4 5 7 1 pfet_01v8_hvt L=150000U W=640000U AS=98950000000P AD=217600000000P
+ PS=975000U PD=1960000U
* device instance $4 r0 *1 0.615,0.675 nfet_01v8
M$4 5 2 6 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.675 nfet_01v8
M$5 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=70350000000P
+ PS=690000U PD=755000U
* device instance $6 r0 *1 1.52,0.675 nfet_01v8
M$6 4 5 6 8 nfet_01v8 L=150000U W=420000U AS=70350000000P AD=109200000000P
+ PS=755000U PD=1360000U
.ENDS sky130_fd_sc_hd__or2_0

* cell sky130_fd_sc_hd__nand4b_1
* pin VPB
* pin A_N
* pin B
* pin C
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_1 1 2 3 4 6 7 8 9 10
* net 1 VPB
* net 2 A_N
* net 3 B
* net 4 C
* net 6 D
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=195000000000P PS=1385000U PD=1390000U
* device instance $5 r0 *1 2.58,1.985 pfet_01v8_hvt
M$5 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $6 r0 *1 0.545,0.675 nfet_01v8
M$6 5 2 9 10 nfet_01v8 L=150000U W=420000U AS=118125000000P AD=111300000000P
+ PS=1040000U PD=1370000U
* device instance $7 r0 *1 1.085,0.56 nfet_01v8
M$7 11 6 9 10 nfet_01v8 L=150000U W=650000U AS=118125000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.505,0.56 nfet_01v8
M$8 13 4 11 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $9 r0 *1 2.04,0.56 nfet_01v8
M$9 12 3 13 10 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=126750000000P
+ PS=1035000U PD=1040000U
* device instance $10 r0 *1 2.58,0.56 nfet_01v8
M$10 8 5 12 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=227500000000P
+ PS=1040000U PD=2000000U
.ENDS sky130_fd_sc_hd__nand4b_1

* cell sky130_fd_sc_hd__o31a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31a_1 1 2 5 6 7 8 9 10 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.65,1.985 pfet_01v8_hvt
M$1 9 4 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=360000000000P
+ AD=195000000000P PS=2720000U PD=1390000U
* device instance $2 r0 *1 1.19,1.985 pfet_01v8_hvt
M$2 12 5 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=135000000000P PS=1390000U PD=1270000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 11 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.09,1.985 pfet_01v8_hvt
M$4 4 7 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=212500000000P PS=1330000U PD=1425000U
* device instance $5 r0 *1 2.665,1.985 pfet_01v8_hvt
M$5 9 8 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=345000000000P PS=1425000U PD=2690000U
* device instance $6 r0 *1 0.65,0.56 nfet_01v8
M$6 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=234000000000P AD=126750000000P
+ PS=2020000U PD=1040000U
* device instance $7 r0 *1 1.19,0.56 nfet_01v8
M$7 3 5 1 13 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.61,0.56 nfet_01v8
M$8 1 6 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 2.09,0.56 nfet_01v8
M$9 3 7 1 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.57,0.56 nfet_01v8
M$10 4 8 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=201500000000P
+ PS=980000U PD=1920000U
.ENDS sky130_fd_sc_hd__o31a_1

* cell sky130_fd_sc_hd__clkinv_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_2 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 4 2 3 1 pfet_01v8_hvt L=150000U W=3000000U AS=545000000000P
+ AD=545000000000P PS=5090000U PD=5090000U
* device instance $4 r0 *1 0.94,0.445 nfet_01v8
M$4 3 2 5 6 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=168000000000P
+ PS=2070000U PD=2060000U
.ENDS sky130_fd_sc_hd__clkinv_2

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__dfrtp_4
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_4 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPB
* net 18 VPWR
* device instance $1 r0 *1 8.63,1.985 pfet_01v8_hvt
M$1 9 8 18 17 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=710000000000P PS=6330000U PD=6420000U
* device instance $5 r0 *1 5.35,2.065 pfet_01v8_hvt
M$5 16 5 18 17 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $6 r0 *1 5.845,2.275 pfet_01v8_hvt
M$6 7 2 16 17 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $7 r0 *1 6.275,2.275 pfet_01v8_hvt
M$7 20 3 7 17 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $8 r0 *1 6.695,2.275 pfet_01v8_hvt
M$8 18 8 20 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $9 r0 *1 7.235,2.275 pfet_01v8_hvt
M$9 8 6 18 17 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $10 r0 *1 7.655,2.275 pfet_01v8_hvt
M$10 18 7 8 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $11 r0 *1 2.225,2.275 pfet_01v8_hvt
M$11 4 15 18 17 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $12 r0 *1 2.685,2.275 pfet_01v8_hvt
M$12 5 3 4 17 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $13 r0 *1 3.18,2.275 pfet_01v8_hvt
M$13 19 2 5 17 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $14 r0 *1 3.88,2.275 pfet_01v8_hvt
M$14 18 16 19 17 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $15 r0 *1 4.365,2.275 pfet_01v8_hvt
M$15 19 6 18 17 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $16 r0 *1 0.47,2.135 pfet_01v8_hvt
M$16 18 14 2 17 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $17 r0 *1 0.89,2.135 pfet_01v8_hvt
M$17 3 2 18 17 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $18 r0 *1 8.63,0.56 nfet_01v8
M$18 9 8 1 21 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $22 r0 *1 0.47,0.445 nfet_01v8
M$22 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $23 r0 *1 0.89,0.445 nfet_01v8
M$23 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $24 r0 *1 2.64,0.415 nfet_01v8
M$24 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $25 r0 *1 3.12,0.415 nfet_01v8
M$25 10 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $26 r0 *1 5.465,0.415 nfet_01v8
M$26 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $27 r0 *1 6.01,0.415 nfet_01v8
M$27 13 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $28 r0 *1 2.165,0.445 nfet_01v8
M$28 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $29 r0 *1 3.95,0.445 nfet_01v8
M$29 11 16 10 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $30 r0 *1 4.31,0.445 nfet_01v8
M$30 1 6 11 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $31 r0 *1 6.49,0.445 nfet_01v8
M$31 1 8 13 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $32 r0 *1 7.235,0.445 nfet_01v8
M$32 12 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $33 r0 *1 7.69,0.445 nfet_01v8
M$33 8 7 12 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $34 r0 *1 4.97,0.555 nfet_01v8
M$34 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_4

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 0.47,0.445 nfet_01v8
M$16 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 0.89,0.445 nfet_01v8
M$17 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__clkbuf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 1.335,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.12e+12P AD=1.245e+12P
+ PS=10240000U PD=11490000U
* device instance $11 r0 *1 0.475,0.445 nfet_01v8
M$11 3 2 1 7 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=117600000000P
+ PS=2070000U PD=1400000U
* device instance $13 r0 *1 1.335,0.445 nfet_01v8
M$13 4 3 1 7 nfet_01v8 L=150000U W=3360000U AS=470400000000P AD=525000000000P
+ PS=5600000U PD=6280000U
.ENDS sky130_fd_sc_hd__clkbuf_8

* cell sky130_fd_sc_hd__a22o_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a22o_1 1 2 3 4 5 6 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 VGND
* net 9 X
* net 10 VPWR
* device instance $1 r0 *1 1.82,1.985 pfet_01v8_hvt
M$1 7 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=252900000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $2 r0 *1 2.29,1.985 pfet_01v8_hvt
M$2 10 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=155000000000P PS=1320000U PD=1310000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 8 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=252850000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 1.79,0.56 nfet_01v8
M$6 12 4 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=113750000000P
+ PS=1820000U PD=1000000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 5 12 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $8 r0 *1 2.75,0.56 nfet_01v8
M$8 9 8 6 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=169000000000P
+ PS=960000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 13 2 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $10 r0 *1 0.85,0.56 nfet_01v8
M$10 8 3 13 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22o_1

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__a221oi_1
* pin VGND
* pin Y
* pin B1
* pin A1
* pin C1
* pin B2
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_1 1 2 3 4 5 6 7 10 11 14
* net 1 VGND
* net 2 Y
* net 3 B1
* net 4 A1
* net 5 C1
* net 6 B2
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 13 4 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=152500000000P PS=2520000U PD=1305000U
* device instance $2 r0 *1 2.705,1.985 pfet_01v8_hvt
M$2 11 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=305000000000P PS=1305000U PD=2610000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 12 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 13 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 12 3 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 2.25,0.56 nfet_01v8
M$6 9 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=99125000000P
+ PS=1820000U PD=955000U
* device instance $7 r0 *1 2.705,0.56 nfet_01v8
M$7 1 7 9 14 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=198250000000P
+ PS=955000U PD=1910000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $9 r0 *1 0.945,0.56 nfet_01v8
M$9 8 6 1 14 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=69875000000P
+ PS=975000U PD=865000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 2 3 8 14 nfet_01v8 L=150000U W=650000U AS=69875000000P AD=169000000000P
+ PS=865000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221oi_1

* cell sky130_fd_sc_hd__mux2_1
* pin VGND
* pin X
* pin A1
* pin A0
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_1 1 2 3 5 9 10 11 14
* net 1 VGND
* net 2 X
* net 3 A1
* net 5 A0
* net 9 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.015,2.08 pfet_01v8_hvt
M$1 12 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=158350000000P
+ AD=76650000000P PS=1395000U PD=785000U
* device instance $2 r0 *1 1.53,2.08 pfet_01v8_hvt
M$2 4 5 12 11 pfet_01v8_hvt L=150000U W=420000U AS=76650000000P
+ AD=193200000000P PS=785000U PD=1340000U
* device instance $3 r0 *1 2.6,2.08 pfet_01v8_hvt
M$3 13 3 4 11 pfet_01v8_hvt L=150000U W=420000U AS=193200000000P
+ AD=44100000000P PS=1340000U PD=630000U
* device instance $4 r0 *1 2.96,2.08 pfet_01v8_hvt
M$4 10 6 13 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $5 r0 *1 3.44,2.08 pfet_01v8_hvt
M$5 6 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=117600000000P PS=750000U PD=1400000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=158350000000P PS=2520000U PD=1395000U
* device instance $7 r0 *1 1.015,0.445 nfet_01v8
M$7 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=112850000000P AD=69300000000P
+ PS=1045000U PD=750000U
* device instance $8 r0 *1 1.495,0.445 nfet_01v8
M$8 4 3 7 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=99750000000P
+ PS=750000U PD=895000U
* device instance $9 r0 *1 2.12,0.445 nfet_01v8
M$9 8 5 4 14 nfet_01v8 L=150000U W=420000U AS=99750000000P AD=69300000000P
+ PS=895000U PD=750000U
* device instance $10 r0 *1 2.6,0.445 nfet_01v8
M$10 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=144900000000P
+ PS=750000U PD=1110000U
* device instance $11 r0 *1 3.44,0.445 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=420000U AS=144900000000P AD=109200000000P
+ PS=1110000U PD=1360000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112850000000P
+ PS=1820000U PD=1045000U
.ENDS sky130_fd_sc_hd__mux2_1

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6

* cell sky130_fd_sc_hd__nor4_4
* pin VGND
* pin C
* pin Y
* pin A
* pin B
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_4 1 2 3 4 6 7 8 11 12
* net 1 VGND
* net 2 C
* net 3 Y
* net 4 A
* net 6 B
* net 7 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.37,1.985 pfet_01v8_hvt
M$1 9 2 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.05,1.985 pfet_01v8_hvt
M$5 3 7 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 8 4 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $13 r0 *1 2.17,1.985 pfet_01v8_hvt
M$13 9 6 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 3 4 1 12 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $21 r0 *1 2.17,0.56 nfet_01v8
M$21 3 6 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $25 r0 *1 4.37,0.56 nfet_01v8
M$25 3 2 1 12 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $29 r0 *1 6.05,0.56 nfet_01v8
M$29 3 7 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor4_4

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__clkbuf_4
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 6 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=165000000000P PS=2530000U PD=1330000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=4000000U AS=585000000000P
+ AD=720000000000P PS=5170000U PD=6440000U
* device instance $6 r0 *1 0.475,0.445 nfet_01v8
M$6 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=70350000000P
+ PS=1370000U PD=755000U
* device instance $7 r0 *1 0.96,0.445 nfet_01v8
M$7 5 2 4 7 nfet_01v8 L=150000U W=1680000U AS=246750000000P AD=298200000000P
+ PS=2855000U PD=3520000U
.ENDS sky130_fd_sc_hd__clkbuf_4

* cell sky130_fd_sc_hd__nor3b_4
* pin VGND
* pin A
* pin B
* pin Y
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_4 1 2 3 4 5 7 10 11
* net 1 VGND
* net 2 A
* net 3 B
* net 4 Y
* net 5 C_N
* net 7 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.11,1.985 pfet_01v8_hvt
M$1 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 4.79,1.985 pfet_01v8_hvt
M$5 4 6 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 7 5 6 10 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=135000000000P PS=2560000U PD=1270000U
* device instance $10 r0 *1 0.91,1.985 pfet_01v8_hvt
M$10 8 2 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $14 r0 *1 0.49,0.56 nfet_01v8
M$14 1 5 6 11 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $15 r0 *1 0.91,0.56 nfet_01v8
M$15 4 2 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $19 r0 *1 3.11,0.56 nfet_01v8
M$19 4 3 1 11 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $23 r0 *1 4.79,0.56 nfet_01v8
M$23 4 6 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor3b_4

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__clkbuf_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_2 1 2 3 4 6 7
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 6 X
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=162500000000P PS=2530000U PD=1325000U
* device instance $2 r0 *1 0.95,1.985 pfet_01v8_hvt
M$2 6 5 3 1 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=395000000000P PS=2595000U PD=3790000U
* device instance $4 r0 *1 0.475,0.445 nfet_01v8
M$4 4 2 5 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=68250000000P
+ PS=1370000U PD=745000U
* device instance $5 r0 *1 0.95,0.445 nfet_01v8
M$5 6 5 4 7 nfet_01v8 L=150000U W=840000U AS=124950000000P AD=165900000000P
+ PS=1435000U PD=2050000U
.ENDS sky130_fd_sc_hd__clkbuf_2

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__buf_2
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_2 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.125 pfet_01v8_hvt
M$1 2 3 6 1 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P AD=166400000000P
+ PS=1325000U PD=1800000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=284000000000P
+ AD=400000000000P PS=2595000U PD=3800000U
* device instance $4 r0 *1 0.47,0.445 nfet_01v8
M$4 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $5 r0 *1 0.945,0.56 nfet_01v8
M$5 5 2 4 7 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=260000000000P
+ PS=1895000U PD=2750000U
.ENDS sky130_fd_sc_hd__buf_2
