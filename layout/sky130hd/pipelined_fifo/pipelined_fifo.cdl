* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT pipelined_fifo almost_empty almost_full clk data_count[0]
+ data_count[1] data_count[2] data_count[3] data_count[4] empty
+ full rd_data[0] rd_data[10] rd_data[11] rd_data[12] rd_data[13]
+ rd_data[14] rd_data[15] rd_data[16] rd_data[17] rd_data[18]
+ rd_data[19] rd_data[1] rd_data[20] rd_data[21] rd_data[22]
+ rd_data[23] rd_data[24] rd_data[25] rd_data[26] rd_data[27]
+ rd_data[28] rd_data[29] rd_data[2] rd_data[30] rd_data[31]
+ rd_data[3] rd_data[4] rd_data[5] rd_data[6] rd_data[7] rd_data[8]
+ rd_data[9] rd_en rst_n wr_data[0] wr_data[10] wr_data[11]
+ wr_data[12] wr_data[13] wr_data[14] wr_data[15] wr_data[16]
+ wr_data[17] wr_data[18] wr_data[19] wr_data[1] wr_data[20]
+ wr_data[21] wr_data[22] wr_data[23] wr_data[24] wr_data[25]
+ wr_data[26] wr_data[27] wr_data[28] wr_data[29] wr_data[2]
+ wr_data[30] wr_data[31] wr_data[3] wr_data[4] wr_data[5] wr_data[6]
+ wr_data[7] wr_data[8] wr_data[9] wr_en VSS VDD
X_111_ _005_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__inv_1
X_112_ _019_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__inv_1
X_113_ _014_ _004_ VSS VSS VDD VDD _097_ sky130_fd_sc_hd__xnor2_1
X_114_ _097_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__inv_1
X_115_ _018_ _016_ _014_ VSS VSS VDD VDD _098_ sky130_fd_sc_hd__and3b_1
X_116_ _014_ _015_ _013_ VSS VSS VDD VDD _099_ sky130_fd_sc_hd__a21o_2
X_117_ _098_ _099_ _022_ VSS VSS VDD VDD _100_ sky130_fd_sc_hd__o21ai_0
X_118_ _022_ _098_ _099_ VSS VSS VDD VDD _101_ sky130_fd_sc_hd__or3_4
X_119_ pipeline_count\[3\] pipeline_count\[2\] pipeline_count\[4\]
+ VSS VSS VDD VDD _102_ sky130_fd_sc_hd__nor3_1
X_120_ _005_ _019_ VSS VSS VDD VDD _103_ sky130_fd_sc_hd__nor2b_1
X_121_ _027_ _097_ _102_ _103_ VSS VSS VDD VDD _104_ sky130_fd_sc_hd__nand4_1
X_122_ _014_ _022_ _004_ VSS VSS VDD VDD _105_ sky130_fd_sc_hd__nand3_1
X_123_ _022_ _013_ _021_ VSS VSS VDD VDD _106_ sky130_fd_sc_hd__a21oi_1
X_124_ wr_ptr\[4\] rd_ptr\[4\] VSS VSS VDD VDD _107_ sky130_fd_sc_hd__xnor2_1
X_125_ _105_ _106_ _107_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__and3_1
X_126_ _105_ _106_ _107_ VSS VSS VDD VDD _060_ sky130_fd_sc_hd__a21oi_1
X_127_ _100_ _101_ _104_ _059_ _060_ VSS VSS VDD VDD net42
+ sky130_fd_sc_hd__a2111oi_4
X_128_ net42 net32 VSS VSS VDD VDD _061_ sky130_fd_sc_hd__nand2b_4
X_129_ _061_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__inv_1
X_130_ _100_ _101_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nand2_1
X_131_ _005_ _033_ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__nand2_1
X_132_ _060_ _059_ VSS VSS VDD VDD _064_ sky130_fd_sc_hd__nor2_1
X_133_ _062_ _063_ _064_ VSS VSS VDD VDD net43 sky130_fd_sc_hd__o21ai_0
X_134_ _063_ _101_ _100_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__and3b_2
X_135_ _065_ _064_ net34 VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nand3b_1
X_136_ _066_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__inv_1
X_137_ pipeline_count\[0\] VSS VSS VDD VDD _026_ sky130_fd_sc_hd__inv_1
X_138_ _010_ VSS VSS VDD VDD net38 sky130_fd_sc_hd__inv_1
X_139_ rd_ptr\[2\] VSS VSS VDD VDD _012_ sky130_fd_sc_hd__inv_1
X_140_ rd_ptr\[1\] VSS VSS VDD VDD _002_ sky130_fd_sc_hd__inv_1
X_141_ rd_ptr\[3\] VSS VSS VDD VDD _020_ sky130_fd_sc_hd__inv_1
X_142_ rd_en_pipe VSS VSS VDD VDD _023_ sky130_fd_sc_hd__inv_1
X_143_ wr_ptr\[0\] VSS VSS VDD VDD _017_ sky130_fd_sc_hd__inv_1
X_144_ _018_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__inv_1
X_145_ pipeline_count\[1\] VSS VSS VDD VDD _007_ sky130_fd_sc_hd__inv_1
X_146_ _062_ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__inv_1
X_147_ _011_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__inv_1
X_148_ rd_ptr\[0\] _061_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__xnor2_1
X_149_ _042_ rd_ptr\[1\] _061_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__mux2_4
X_150_ net32 _041_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__nand2_1
X_151_ net42 _067_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__nor2_1
X_152_ _012_ _068_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__xnor2_1
X_153_ rd_ptr\[0\] rd_ptr\[2\] rd_ptr\[1\] VSS VSS VDD VDD
+ _069_ sky130_fd_sc_hd__nand3_1
X_154_ net42 _069_ net32 VSS VSS VDD VDD _070_ sky130_fd_sc_hd__nor3b_1
X_155_ _020_ _070_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__xnor2_1
X_156_ _012_ _020_ net42 _067_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__nor4_1
X_157_ rd_ptr\[4\] _071_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__xor2_1
X_158_ wr_ptr\[0\] _066_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__xnor2_1
X_159_ _040_ wr_ptr\[1\] _066_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__mux2_2
X_160_ _065_ _064_ _039_ net34 VSS VSS VDD VDD _072_ sky130_fd_sc_hd__nand4b_1
X_161_ wr_ptr\[2\] _072_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__xnor2_1
X_162_ wr_ptr\[2\] wr_ptr\[1\] wr_ptr\[0\] VSS VSS VDD VDD
+ _073_ sky130_fd_sc_hd__nand3_1
X_163_ _065_ _073_ net34 _064_ VSS VSS VDD VDD _074_ sky130_fd_sc_hd__and4bb_2
X_164_ wr_ptr\[3\] _074_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__xor2_1
X_165_ _039_ wr_ptr\[2\] wr_ptr\[3\] VSS VSS VDD VDD _075_
+ sky130_fd_sc_hd__nand3_1
X_166_ _065_ _075_ net34 _064_ VSS VSS VDD VDD _076_ sky130_fd_sc_hd__and4bb_2
X_167_ wr_ptr\[4\] _076_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__xor2_1
X_168_ pipeline_count\[0\] _025_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__xnor2_1
X_169_ _024_ _028_ VSS VSS VDD VDD _077_ sky130_fd_sc_hd__xor2_1
X_170_ pipeline_count\[1\] _025_ VSS VSS VDD VDD _078_ sky130_fd_sc_hd__nand2_1
X_171_ _025_ _077_ _078_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__o21ai_0
X_172_ _027_ _030_ _024_ VSS VSS VDD VDD _079_ sky130_fd_sc_hd__mux2i_1
X_173_ _025_ _079_ VSS VSS VDD VDD _080_ sky130_fd_sc_hd__nor2_1
X_174_ pipeline_count\[2\] _080_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__xor2_1
X_175_ pipeline_count\[2\] pipeline_count\[1\] pipeline_count\[0\]
+ _024_ VSS VSS VDD VDD _081_ sky130_fd_sc_hd__nand4_1
X_176_ pipeline_count\[1\] pipeline_count\[0\] VSS VSS VDD
+ VDD _082_ sky130_fd_sc_hd__nor2_1
X_177_ pipeline_count\[2\] _024_ VSS VSS VDD VDD _083_ sky130_fd_sc_hd__nor2_1
X_178_ _082_ _083_ VSS VSS VDD VDD _084_ sky130_fd_sc_hd__nand2_1
X_179_ _081_ _084_ _025_ VSS VSS VDD VDD _085_ sky130_fd_sc_hd__a21oi_1
X_180_ pipeline_count\[3\] _085_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__xor2_1
X_181_ pipeline_count\[3\] pipeline_count\[2\] _024_ _030_
+ VSS VSS VDD VDD _086_ sky130_fd_sc_hd__nand4_1
X_182_ pipeline_count\[3\] pipeline_count\[2\] _024_ _027_
+ VSS VSS VDD VDD _087_ sky130_fd_sc_hd__or4b_2
X_183_ _086_ _087_ _025_ VSS VSS VDD VDD _088_ sky130_fd_sc_hd__a21oi_1
X_184_ pipeline_count\[4\] _088_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__xor2_1
X_185_ _064_ _062_ VSS VSS VDD VDD _089_ sky130_fd_sc_hd__nand2_1
X_186_ _097_ _103_ _082_ _029_ _102_ VSS VSS VDD VDD _090_
+ sky130_fd_sc_hd__o221ai_1
X_187_ _089_ _090_ VSS VSS VDD VDD net35 sky130_fd_sc_hd__nor2_1
X_188_ _097_ _062_ _064_ VSS VSS VDD VDD net36 sky130_fd_sc_hd__o21ai_0
X_189_ _035_ _009_ VSS VSS VDD VDD net39 sky130_fd_sc_hd__xnor2_1
X_190_ _032_ _011_ _031_ VSS VSS VDD VDD _091_ sky130_fd_sc_hd__a21o_1
X_191_ _035_ _091_ _034_ VSS VSS VDD VDD _092_ sky130_fd_sc_hd__a21oi_1
X_192_ _038_ _092_ VSS VSS VDD VDD net40 sky130_fd_sc_hd__xnor2_1
X_193_ _009_ VSS VSS VDD VDD _093_ sky130_fd_sc_hd__inv_1
X_194_ _035_ _093_ _034_ VSS VSS VDD VDD _094_ sky130_fd_sc_hd__a21o_1
X_195_ _038_ _094_ _037_ VSS VSS VDD VDD _095_ sky130_fd_sc_hd__a21oi_1
X_196_ pipeline_count\[4\] _095_ VSS VSS VDD VDD _096_ sky130_fd_sc_hd__xnor2_1
X_197_ _064_ _096_ VSS VSS VDD VDD net41 sky130_fd_sc_hd__xnor2_1
X_198_ _002_ wr_ptr\[1\] _003_ VSS VSS VDD VDD _004_ _005_
+ sky130_fd_sc_hd__fa_1
X_199_ _006_ _007_ _008_ VSS VSS VDD VDD _009_ _010_ sky130_fd_sc_hd__fa_1
X_200_ _012_ wr_ptr\[2\] VSS VSS VDD VDD _013_ _014_ sky130_fd_sc_hd__ha_1
X_201_ _002_ wr_ptr\[1\] VSS VSS VDD VDD _015_ _016_ sky130_fd_sc_hd__ha_1
X_202_ rd_ptr\[0\] _017_ VSS VSS VDD VDD _018_ _019_ sky130_fd_sc_hd__ha_1
X_203_ _020_ wr_ptr\[3\] VSS VSS VDD VDD _021_ _022_ sky130_fd_sc_hd__ha_1
X_204_ _023_ wr_en_pipe\[1\] VSS VSS VDD VDD _024_ _025_ sky130_fd_sc_hd__ha_1
X_205_ _026_ _007_ VSS VSS VDD VDD _027_ _028_ sky130_fd_sc_hd__ha_1
X_206_ pipeline_count\[0\] _007_ VSS VSS VDD VDD _029_ _108_
+ sky130_fd_sc_hd__ha_1
X_207_ pipeline_count\[0\] pipeline_count\[1\] VSS VSS VDD
+ VDD _030_ _109_ sky130_fd_sc_hd__ha_1
X_208_ pipeline_count\[1\] _005_ VSS VSS VDD VDD _031_ _032_
+ sky130_fd_sc_hd__ha_1
X_209_ pipeline_count\[2\] _033_ VSS VSS VDD VDD _034_ _035_
+ sky130_fd_sc_hd__ha_1
X_210_ pipeline_count\[3\] _036_ VSS VSS VDD VDD _037_ _038_
+ sky130_fd_sc_hd__ha_1
X_211_ wr_ptr\[0\] wr_ptr\[1\] VSS VSS VDD VDD _039_ _040_
+ sky130_fd_sc_hd__ha_1
X_212_ rd_ptr\[0\] rd_ptr\[1\] VSS VSS VDD VDD _041_ _042_
+ sky130_fd_sc_hd__ha_1
X_213_ pipeline_count\[0\] _043_ VSS VSS VDD VDD _011_ net37
+ sky130_fd_sc_hd__ha_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xplace45 net33 VSS VSS VDD VDD net44 sky130_fd_sc_hd__buf_4
Xoutput44 net43 VSS VSS VDD VDD full sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput43 net42 VSS VSS VDD VDD empty sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput42 net41 VSS VSS VDD VDD data_count[4] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput41 net40 VSS VSS VDD VDD data_count[3] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput40 net39 VSS VSS VDD VDD data_count[2] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput39 net38 VSS VSS VDD VDD data_count[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput38 net37 VSS VSS VDD VDD data_count[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput37 net36 VSS VSS VDD VDD almost_full sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput36 net35 VSS VSS VDD VDD almost_empty sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput35 wr_en VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput34 rst_n VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput33 rd_en VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkdlybuf4s50_1
Xpipeline_count\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _044_
+ net44 VSS VSS VDD VDD pipeline_count\[0\] sky130_fd_sc_hd__dfrtp_1
Xpipeline_count\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _045_
+ net44 VSS VSS VDD VDD pipeline_count\[1\] sky130_fd_sc_hd__dfrtp_1
Xpipeline_count\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _046_
+ net44 VSS VSS VDD VDD pipeline_count\[2\] sky130_fd_sc_hd__dfrtp_1
Xpipeline_count\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _047_
+ net44 VSS VSS VDD VDD pipeline_count\[3\] sky130_fd_sc_hd__dfrtp_1
Xpipeline_count\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _048_
+ net44 VSS VSS VDD VDD pipeline_count\[4\] sky130_fd_sc_hd__dfrtp_1
Xrd_en_pipe$_DFF_PN0_ clknet_1_1__leaf_clk _000_ net44 VSS
+ VSS VDD VDD rd_en_pipe sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _049_ net44
+ VSS VSS VDD VDD rd_ptr\[0\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _050_ net44
+ VSS VSS VDD VDD rd_ptr\[1\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _051_ net44
+ VSS VSS VDD VDD rd_ptr\[2\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _052_ net44
+ VSS VSS VDD VDD rd_ptr\[3\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _053_ net44
+ VSS VSS VDD VDD rd_ptr\[4\] sky130_fd_sc_hd__dfrtp_1
Xwr_en_pipe\[0\]$_DFF_PN0_ clknet_1_1__leaf_clk _001_ net44
+ VSS VSS VDD VDD wr_en_pipe\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_en_pipe\[1\]$_DFF_PN0_ clknet_1_1__leaf_clk wr_en_pipe\[0\]
+ net44 VSS VSS VDD VDD wr_en_pipe\[1\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _054_ net44
+ VSS VSS VDD VDD wr_ptr\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _055_ net44
+ VSS VSS VDD VDD wr_ptr\[1\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _056_ net44
+ VSS VSS VDD VDD wr_ptr\[2\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _057_ net44
+ VSS VSS VDD VDD wr_ptr\[3\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _058_ net44
+ VSS VSS VDD VDD wr_ptr\[4\] sky130_fd_sc_hd__dfrtp_1
X_215__1 VSS VSS VDD VDD _unconnected_1 rd_data[0] sky130_fd_sc_hd__conb_1
X_216__2 VSS VSS VDD VDD _unconnected_2 rd_data[1] sky130_fd_sc_hd__conb_1
X_217__3 VSS VSS VDD VDD _unconnected_3 rd_data[2] sky130_fd_sc_hd__conb_1
X_218__4 VSS VSS VDD VDD _unconnected_4 rd_data[3] sky130_fd_sc_hd__conb_1
X_219__5 VSS VSS VDD VDD _unconnected_5 rd_data[4] sky130_fd_sc_hd__conb_1
X_220__6 VSS VSS VDD VDD _unconnected_6 rd_data[5] sky130_fd_sc_hd__conb_1
X_221__7 VSS VSS VDD VDD _unconnected_7 rd_data[6] sky130_fd_sc_hd__conb_1
X_222__8 VSS VSS VDD VDD _unconnected_8 rd_data[7] sky130_fd_sc_hd__conb_1
X_223__9 VSS VSS VDD VDD _unconnected_9 rd_data[8] sky130_fd_sc_hd__conb_1
X_224__10 VSS VSS VDD VDD _unconnected_10 rd_data[9] sky130_fd_sc_hd__conb_1
X_225__11 VSS VSS VDD VDD _unconnected_11 rd_data[10] sky130_fd_sc_hd__conb_1
X_226__12 VSS VSS VDD VDD _unconnected_12 rd_data[11] sky130_fd_sc_hd__conb_1
X_227__13 VSS VSS VDD VDD _unconnected_13 rd_data[12] sky130_fd_sc_hd__conb_1
X_228__14 VSS VSS VDD VDD _unconnected_14 rd_data[13] sky130_fd_sc_hd__conb_1
X_229__15 VSS VSS VDD VDD _unconnected_15 rd_data[14] sky130_fd_sc_hd__conb_1
X_230__16 VSS VSS VDD VDD _unconnected_16 rd_data[15] sky130_fd_sc_hd__conb_1
X_231__17 VSS VSS VDD VDD _unconnected_17 rd_data[16] sky130_fd_sc_hd__conb_1
X_232__18 VSS VSS VDD VDD _unconnected_18 rd_data[17] sky130_fd_sc_hd__conb_1
X_233__19 VSS VSS VDD VDD _unconnected_19 rd_data[18] sky130_fd_sc_hd__conb_1
X_234__20 VSS VSS VDD VDD _unconnected_20 rd_data[19] sky130_fd_sc_hd__conb_1
X_235__21 VSS VSS VDD VDD _unconnected_21 rd_data[20] sky130_fd_sc_hd__conb_1
X_236__22 VSS VSS VDD VDD _unconnected_22 rd_data[21] sky130_fd_sc_hd__conb_1
X_237__23 VSS VSS VDD VDD _unconnected_23 rd_data[22] sky130_fd_sc_hd__conb_1
X_238__24 VSS VSS VDD VDD _unconnected_24 rd_data[23] sky130_fd_sc_hd__conb_1
X_239__25 VSS VSS VDD VDD _unconnected_25 rd_data[24] sky130_fd_sc_hd__conb_1
X_240__26 VSS VSS VDD VDD _unconnected_26 rd_data[25] sky130_fd_sc_hd__conb_1
X_241__27 VSS VSS VDD VDD _unconnected_27 rd_data[26] sky130_fd_sc_hd__conb_1
X_242__28 VSS VSS VDD VDD _unconnected_28 rd_data[27] sky130_fd_sc_hd__conb_1
X_243__29 VSS VSS VDD VDD _unconnected_29 rd_data[28] sky130_fd_sc_hd__conb_1
X_244__30 VSS VSS VDD VDD _unconnected_30 rd_data[29] sky130_fd_sc_hd__conb_1
X_245__31 VSS VSS VDD VDD _unconnected_31 rd_data[30] sky130_fd_sc_hd__conb_1
X_246__32 VSS VSS VDD VDD _unconnected_32 rd_data[31] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
.ENDS pipelined_fifo
