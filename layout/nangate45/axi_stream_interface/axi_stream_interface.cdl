* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT axi_stream_interface clk m_tdata[0] m_tdata[10] m_tdata[11]
+ m_tdata[12] m_tdata[13] m_tdata[14] m_tdata[15] m_tdata[16]
+ m_tdata[17] m_tdata[18] m_tdata[19] m_tdata[1] m_tdata[20]
+ m_tdata[21] m_tdata[22] m_tdata[23] m_tdata[24] m_tdata[25]
+ m_tdata[26] m_tdata[27] m_tdata[28] m_tdata[29] m_tdata[2]
+ m_tdata[30] m_tdata[31] m_tdata[3] m_tdata[4] m_tdata[5] m_tdata[6]
+ m_tdata[7] m_tdata[8] m_tdata[9] m_tdest m_tid m_tkeep[0]
+ m_tkeep[1] m_tkeep[2] m_tkeep[3] m_tlast m_tready m_tstrb[0]
+ m_tstrb[1] m_tstrb[2] m_tstrb[3] m_tuser m_tvalid rst_n s_tdata[0]
+ s_tdata[10] s_tdata[11] s_tdata[12] s_tdata[13] s_tdata[14]
+ s_tdata[15] s_tdata[16] s_tdata[17] s_tdata[18] s_tdata[19]
+ s_tdata[1] s_tdata[20] s_tdata[21] s_tdata[22] s_tdata[23]
+ s_tdata[24] s_tdata[25] s_tdata[26] s_tdata[27] s_tdata[28]
+ s_tdata[29] s_tdata[2] s_tdata[30] s_tdata[31] s_tdata[3]
+ s_tdata[4] s_tdata[5] s_tdata[6] s_tdata[7] s_tdata[8] s_tdata[9]
+ s_tdest s_tid s_tkeep[0] s_tkeep[1] s_tkeep[2] s_tkeep[3]
+ s_tlast s_tready s_tstrb[0] s_tstrb[1] s_tstrb[2] s_tstrb[3]
+ s_tuser s_tvalid
X_00_ s_tdata[0] net1 VDD VSS BUF_X1
X_01_ s_tdata[1] net12 VDD VSS BUF_X1
X_02_ s_tdata[2] net23 VDD VSS BUF_X1
X_03_ s_tdata[3] net26 VDD VSS BUF_X1
X_04_ s_tdata[4] net27 VDD VSS BUF_X1
X_05_ s_tdata[5] net28 VDD VSS BUF_X1
X_06_ s_tdata[6] net29 VDD VSS BUF_X1
X_07_ s_tdata[7] net30 VDD VSS BUF_X1
X_08_ s_tdata[8] net31 VDD VSS BUF_X1
X_09_ s_tdata[9] net32 VDD VSS BUF_X1
X_10_ s_tdata[10] net2 VDD VSS BUF_X1
X_11_ s_tdata[11] net3 VDD VSS BUF_X1
X_12_ s_tdata[12] net4 VDD VSS BUF_X1
X_13_ s_tdata[13] net5 VDD VSS BUF_X1
X_14_ s_tdata[14] net6 VDD VSS BUF_X1
X_15_ s_tdata[15] net7 VDD VSS BUF_X1
X_16_ s_tdata[16] net8 VDD VSS BUF_X1
X_17_ s_tdata[17] net9 VDD VSS BUF_X1
X_18_ s_tdata[18] net10 VDD VSS BUF_X1
X_19_ s_tdata[19] net11 VDD VSS BUF_X1
X_20_ s_tdata[20] net13 VDD VSS BUF_X1
X_21_ s_tdata[21] net14 VDD VSS BUF_X1
X_22_ s_tdata[22] net15 VDD VSS BUF_X1
X_23_ s_tdata[23] net16 VDD VSS BUF_X1
X_24_ s_tdata[24] net17 VDD VSS BUF_X1
X_25_ s_tdata[25] net18 VDD VSS BUF_X1
X_26_ s_tdata[26] net19 VDD VSS BUF_X1
X_27_ s_tdata[27] net20 VDD VSS BUF_X1
X_28_ s_tdata[28] net21 VDD VSS BUF_X1
X_29_ s_tdata[29] net22 VDD VSS BUF_X1
X_30_ s_tdata[30] net24 VDD VSS BUF_X1
X_31_ s_tdata[31] net25 VDD VSS BUF_X1
X_32_ s_tdest net33 VDD VSS BUF_X1
X_33_ s_tid net34 VDD VSS BUF_X1
X_34_ s_tkeep[0] net35 VDD VSS BUF_X1
X_35_ s_tkeep[1] net36 VDD VSS BUF_X1
X_36_ s_tkeep[2] net37 VDD VSS BUF_X1
X_37_ s_tkeep[3] net38 VDD VSS BUF_X1
X_38_ s_tlast net39 VDD VSS BUF_X1
X_39_ s_tstrb[0] net40 VDD VSS BUF_X1
X_40_ s_tstrb[1] net41 VDD VSS BUF_X1
X_41_ s_tstrb[2] net42 VDD VSS BUF_X1
X_42_ s_tstrb[3] net43 VDD VSS BUF_X1
X_43_ s_tuser net44 VDD VSS BUF_X1
X_44_ s_tvalid net45 VDD VSS BUF_X1
X_45_ m_tready net46 VDD VSS BUF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_47 VDD VSS TAPCELL_X1
Xoutput1 net1 m_tdata[0] VDD VSS BUF_X1
Xoutput2 net2 m_tdata[10] VDD VSS BUF_X1
Xoutput3 net3 m_tdata[11] VDD VSS BUF_X1
Xoutput4 net4 m_tdata[12] VDD VSS BUF_X1
Xoutput5 net5 m_tdata[13] VDD VSS BUF_X1
Xoutput6 net6 m_tdata[14] VDD VSS BUF_X1
Xoutput7 net7 m_tdata[15] VDD VSS BUF_X1
Xoutput8 net8 m_tdata[16] VDD VSS BUF_X1
Xoutput9 net9 m_tdata[17] VDD VSS BUF_X1
Xoutput10 net10 m_tdata[18] VDD VSS BUF_X1
Xoutput11 net11 m_tdata[19] VDD VSS BUF_X1
Xoutput12 net12 m_tdata[1] VDD VSS BUF_X1
Xoutput13 net13 m_tdata[20] VDD VSS BUF_X1
Xoutput14 net14 m_tdata[21] VDD VSS BUF_X1
Xoutput15 net15 m_tdata[22] VDD VSS BUF_X1
Xoutput16 net16 m_tdata[23] VDD VSS BUF_X1
Xoutput17 net17 m_tdata[24] VDD VSS BUF_X1
Xoutput18 net18 m_tdata[25] VDD VSS BUF_X1
Xoutput19 net19 m_tdata[26] VDD VSS BUF_X1
Xoutput20 net20 m_tdata[27] VDD VSS BUF_X1
Xoutput21 net21 m_tdata[28] VDD VSS BUF_X1
Xoutput22 net22 m_tdata[29] VDD VSS BUF_X1
Xoutput23 net23 m_tdata[2] VDD VSS BUF_X1
Xoutput24 net24 m_tdata[30] VDD VSS BUF_X1
Xoutput25 net25 m_tdata[31] VDD VSS BUF_X1
Xoutput26 net26 m_tdata[3] VDD VSS BUF_X1
Xoutput27 net27 m_tdata[4] VDD VSS BUF_X1
Xoutput28 net28 m_tdata[5] VDD VSS BUF_X1
Xoutput29 net29 m_tdata[6] VDD VSS BUF_X1
Xoutput30 net30 m_tdata[7] VDD VSS BUF_X1
Xoutput31 net31 m_tdata[8] VDD VSS BUF_X1
Xoutput32 net32 m_tdata[9] VDD VSS BUF_X1
Xoutput33 net33 m_tdest VDD VSS BUF_X1
Xoutput34 net34 m_tid VDD VSS BUF_X1
Xoutput35 net35 m_tkeep[0] VDD VSS BUF_X1
Xoutput36 net36 m_tkeep[1] VDD VSS BUF_X1
Xoutput37 net37 m_tkeep[2] VDD VSS BUF_X1
Xoutput38 net38 m_tkeep[3] VDD VSS BUF_X1
Xoutput39 net39 m_tlast VDD VSS BUF_X1
Xoutput40 net40 m_tstrb[0] VDD VSS BUF_X1
Xoutput41 net41 m_tstrb[1] VDD VSS BUF_X1
Xoutput42 net42 m_tstrb[2] VDD VSS BUF_X1
Xoutput43 net43 m_tstrb[3] VDD VSS BUF_X1
Xoutput44 net44 m_tuser VDD VSS BUF_X1
Xoutput45 net45 m_tvalid VDD VSS BUF_X1
Xoutput46 net46 s_tready VDD VSS BUF_X1
.ENDS axi_stream_interface
