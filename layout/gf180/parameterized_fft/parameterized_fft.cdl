* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_fft busy clk data_in_imag[0] data_in_imag[10]
+ data_in_imag[11] data_in_imag[12] data_in_imag[13] data_in_imag[14]
+ data_in_imag[15] data_in_imag[1] data_in_imag[2] data_in_imag[3]
+ data_in_imag[4] data_in_imag[5] data_in_imag[6] data_in_imag[7]
+ data_in_imag[8] data_in_imag[9] data_in_real[0] data_in_real[10]
+ data_in_real[11] data_in_real[12] data_in_real[13] data_in_real[14]
+ data_in_real[15] data_in_real[1] data_in_real[2] data_in_real[3]
+ data_in_real[4] data_in_real[5] data_in_real[6] data_in_real[7]
+ data_in_real[8] data_in_real[9] data_out_imag[0] data_out_imag[100]
+ data_out_imag[101] data_out_imag[102] data_out_imag[103] data_out_imag[104]
+ data_out_imag[105] data_out_imag[106] data_out_imag[107] data_out_imag[108]
+ data_out_imag[109] data_out_imag[10] data_out_imag[110] data_out_imag[111]
+ data_out_imag[112] data_out_imag[113] data_out_imag[114] data_out_imag[115]
+ data_out_imag[116] data_out_imag[117] data_out_imag[118] data_out_imag[119]
+ data_out_imag[11] data_out_imag[120] data_out_imag[121] data_out_imag[122]
+ data_out_imag[123] data_out_imag[124] data_out_imag[125] data_out_imag[126]
+ data_out_imag[127] data_out_imag[12] data_out_imag[13] data_out_imag[14]
+ data_out_imag[15] data_out_imag[16] data_out_imag[17] data_out_imag[18]
+ data_out_imag[19] data_out_imag[1] data_out_imag[20] data_out_imag[21]
+ data_out_imag[22] data_out_imag[23] data_out_imag[24] data_out_imag[25]
+ data_out_imag[26] data_out_imag[27] data_out_imag[28] data_out_imag[29]
+ data_out_imag[2] data_out_imag[30] data_out_imag[31] data_out_imag[32]
+ data_out_imag[33] data_out_imag[34] data_out_imag[35] data_out_imag[36]
+ data_out_imag[37] data_out_imag[38] data_out_imag[39] data_out_imag[3]
+ data_out_imag[40] data_out_imag[41] data_out_imag[42] data_out_imag[43]
+ data_out_imag[44] data_out_imag[45] data_out_imag[46] data_out_imag[47]
+ data_out_imag[48] data_out_imag[49] data_out_imag[4] data_out_imag[50]
+ data_out_imag[51] data_out_imag[52] data_out_imag[53] data_out_imag[54]
+ data_out_imag[55] data_out_imag[56] data_out_imag[57] data_out_imag[58]
+ data_out_imag[59] data_out_imag[5] data_out_imag[60] data_out_imag[61]
+ data_out_imag[62] data_out_imag[63] data_out_imag[64] data_out_imag[65]
+ data_out_imag[66] data_out_imag[67] data_out_imag[68] data_out_imag[69]
+ data_out_imag[6] data_out_imag[70] data_out_imag[71] data_out_imag[72]
+ data_out_imag[73] data_out_imag[74] data_out_imag[75] data_out_imag[76]
+ data_out_imag[77] data_out_imag[78] data_out_imag[79] data_out_imag[7]
+ data_out_imag[80] data_out_imag[81] data_out_imag[82] data_out_imag[83]
+ data_out_imag[84] data_out_imag[85] data_out_imag[86] data_out_imag[87]
+ data_out_imag[88] data_out_imag[89] data_out_imag[8] data_out_imag[90]
+ data_out_imag[91] data_out_imag[92] data_out_imag[93] data_out_imag[94]
+ data_out_imag[95] data_out_imag[96] data_out_imag[97] data_out_imag[98]
+ data_out_imag[99] data_out_imag[9] data_out_real[0] data_out_real[100]
+ data_out_real[101] data_out_real[102] data_out_real[103] data_out_real[104]
+ data_out_real[105] data_out_real[106] data_out_real[107] data_out_real[108]
+ data_out_real[109] data_out_real[10] data_out_real[110] data_out_real[111]
+ data_out_real[112] data_out_real[113] data_out_real[114] data_out_real[115]
+ data_out_real[116] data_out_real[117] data_out_real[118] data_out_real[119]
+ data_out_real[11] data_out_real[120] data_out_real[121] data_out_real[122]
+ data_out_real[123] data_out_real[124] data_out_real[125] data_out_real[126]
+ data_out_real[127] data_out_real[12] data_out_real[13] data_out_real[14]
+ data_out_real[15] data_out_real[16] data_out_real[17] data_out_real[18]
+ data_out_real[19] data_out_real[1] data_out_real[20] data_out_real[21]
+ data_out_real[22] data_out_real[23] data_out_real[24] data_out_real[25]
+ data_out_real[26] data_out_real[27] data_out_real[28] data_out_real[29]
+ data_out_real[2] data_out_real[30] data_out_real[31] data_out_real[32]
+ data_out_real[33] data_out_real[34] data_out_real[35] data_out_real[36]
+ data_out_real[37] data_out_real[38] data_out_real[39] data_out_real[3]
+ data_out_real[40] data_out_real[41] data_out_real[42] data_out_real[43]
+ data_out_real[44] data_out_real[45] data_out_real[46] data_out_real[47]
+ data_out_real[48] data_out_real[49] data_out_real[4] data_out_real[50]
+ data_out_real[51] data_out_real[52] data_out_real[53] data_out_real[54]
+ data_out_real[55] data_out_real[56] data_out_real[57] data_out_real[58]
+ data_out_real[59] data_out_real[5] data_out_real[60] data_out_real[61]
+ data_out_real[62] data_out_real[63] data_out_real[64] data_out_real[65]
+ data_out_real[66] data_out_real[67] data_out_real[68] data_out_real[69]
+ data_out_real[6] data_out_real[70] data_out_real[71] data_out_real[72]
+ data_out_real[73] data_out_real[74] data_out_real[75] data_out_real[76]
+ data_out_real[77] data_out_real[78] data_out_real[79] data_out_real[7]
+ data_out_real[80] data_out_real[81] data_out_real[82] data_out_real[83]
+ data_out_real[84] data_out_real[85] data_out_real[86] data_out_real[87]
+ data_out_real[88] data_out_real[89] data_out_real[8] data_out_real[90]
+ data_out_real[91] data_out_real[92] data_out_real[93] data_out_real[94]
+ data_out_real[95] data_out_real[96] data_out_real[97] data_out_real[98]
+ data_out_real[99] data_out_real[9] data_ready data_valid_in
+ data_valid_out rst_n start
X_08311_ state\[3\] _00563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_08312_ _00563_ _00564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08313_ net82 _00565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_08314_ state\[0\] _00565_ _00566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08315_ _00564_ _00566_ _00004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08316_ stage\[2\] _07787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_08317_ _07775_ _07787_ _07076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08318_ stage\[2\] _00567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08319_ _00567_ _07779_ _07136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08320_ _07136_ _07664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_08321_ _00567_ _07781_ _07123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08322_ _07123_ _07668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08323_ _00567_ _07775_ _07103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08324_ _07103_ _07672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_08325_ _07787_ _07779_ _07680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08326_ _07787_ _07781_ _05877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08327_ _07794_ _00568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08328_ _00568_ _00569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08329_ _00569_ _00570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08330_ _00570_ _00571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_08331_ _00571_ _00572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08332_ _00572_ _00573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08333_ _00573_ _00574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08334_ _00574_ _00575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08335_ _00575_ _07177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08336_ _07775_ _07781_ _00576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08337_ _07794_ _00577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_08338_ _07779_ _07791_ _00577_ _00578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08339_ _00567_ _00576_ _00578_ _00579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08340_ _00579_ _00580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08341_ butterfly_count\[2\] _00581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_08342_ _07660_ _00582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_08343_ _00582_ _00583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_08344_ _07779_ _07781_ stage\[2\] _00584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08345_ _00581_ _00584_ _07769_ _00583_ _00585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_08346_ _07672_ _07676_ _07680_ _00585_ _00586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_08347_ _07775_ _07781_ _00587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08348_ _00567_ _00587_ _07078_ _00588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08349_ _00586_ _00580_ _00588_ _07079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08350_ net1 _07637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08351_ _07080_ _00589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_08352_ _07775_ _00590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08353_ _00567_ _00589_ _00590_ _00578_ _07086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08354_ _00581_ _07769_ _00591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08355_ _07260_ _07252_ _07255_ _07258_ _00592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08356_ _07243_ _07246_ _00593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08357_ _07249_ _00591_ _00592_ _00593_ _00594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08358_ _07158_ _00595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08359_ _07162_ _07164_ _00596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08360_ _07161_ _00596_ _07159_ _00597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08361_ _00597_ _00595_ _00598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08362_ _07176_ _07175_ _07174_ _00599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08363_ _07170_ _07173_ _00600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08364_ _07170_ _07171_ _07168_ _00601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08365_ _00599_ _00600_ _00601_ _00602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08366_ _07162_ _07159_ _07165_ _00603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_08367_ _00602_ _07167_ _00603_ _00604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08368_ _00604_ _00598_ _00605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08369_ _00581_ _00582_ _07769_ _00584_ _00606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08370_ _07117_ _07106_ _07109_ _07112_ _00607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08371_ _07115_ _00607_ _00608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08372_ _07108_ _00609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08373_ _07112_ _07111_ _07109_ _00610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08374_ _07117_ _07116_ _07115_ _00611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08375_ _07108_ _07111_ _07114_ _00612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08376_ _00609_ _00610_ _00611_ _00612_ _00613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_08377_ _07106_ _00568_ _00584_ _00614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08378_ _07105_ _00569_ _00584_ _00615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08379_ _00608_ _00606_ _00613_ _00614_ _00615_ _00616_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08380_ _07122_ _07121_ _07135_ _07120_ _00617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08381_ _07135_ _07119_ _07134_ _00618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08382_ _00617_ _00618_ _00619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08383_ stage\[2\] _07779_ _07794_ _00620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08384_ _07126_ _07129_ _07132_ _00620_ _00621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08385_ _07126_ _07131_ _07129_ _00622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_08386_ _00620_ _00622_ _00623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08387_ _07126_ _07128_ _07125_ _00624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08388_ _00577_ _07664_ _00624_ _00625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08389_ _00619_ _00621_ _00625_ _00623_ _00626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08390_ net26 _07779_ _07781_ _00577_ _00627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08391_ _00567_ _00577_ _00628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08392_ _07090_ _07089_ _07085_ _07088_ _00629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08393_ _07085_ _07087_ _07084_ _00630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08394_ _07676_ _07090_ _00631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08395_ _00627_ _00628_ _00629_ _00630_ _00631_ _07098_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08396_ _07775_ _07779_ _07781_ stage\[2\] _00632_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08397_ _07102_ _07101_ _07100_ _00633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08398_ _07102_ _07100_ _07101_ _00634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08399_ _00569_ _00632_ _00633_ _00634_ _00635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08400_ _07093_ _07096_ _07099_ _00636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08401_ _07093_ _07097_ _07096_ _00637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08402_ _07093_ _07094_ _00638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08403_ _00633_ _00636_ _00638_ _00637_ _00639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08404_ _07098_ _00635_ _00639_ _07110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08405_ net5 _07110_ _00626_ _00640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_08406_ _00617_ _00618_ _00641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08407_ _07126_ _07129_ _07132_ _00620_ _00642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08408_ _07126_ _07128_ _00643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08409_ _07125_ _00643_ _00622_ _00620_ _00644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08410_ _00641_ _00642_ _00644_ _00645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08411_ _07114_ _00646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08412_ _00646_ _00611_ _00647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08413_ _07112_ _00647_ _00648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08414_ net5 _00645_ _00648_ _00649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08415_ _07138_ _00650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_08416_ _07142_ _07145_ _07148_ _00651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_08417_ _07156_ _07139_ _07151_ _07154_ _00652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08418_ _00581_ _00583_ _07769_ _00652_ _00653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_08419_ _00650_ net36 _00651_ _00653_ _00654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_08420_ _07139_ _00655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08421_ _07142_ _07147_ _07145_ _00656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_08422_ _07142_ _07144_ _00657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08423_ _07141_ _00656_ _00657_ _00658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08424_ _00577_ _00651_ _00655_ _00659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_08425_ _07156_ _07155_ _07154_ _07151_ _00660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08426_ _07151_ _07153_ _07150_ _00661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08427_ _00660_ _00661_ _00662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08428_ _00658_ net36 _00655_ _00659_ _00662_ _00663_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_08429_ _07132_ _00664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08430_ _00617_ _00618_ _00664_ _00665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08431_ _00664_ _00617_ _00618_ _00666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08432_ _00665_ _00644_ _00666_ _00667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08433_ _00654_ _00663_ _00667_ _00668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08434_ _00640_ _00649_ _00668_ _00669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08435_ _00663_ _00654_ _00670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08436_ _07148_ _00671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08437_ _00660_ _00661_ _00671_ _00672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08438_ _07147_ _00672_ _00673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08439_ _07145_ _00673_ _00674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08440_ _00674_ _00670_ _00675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08441_ _00669_ _00675_ _07160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08442_ _00660_ _00661_ _00651_ _00676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08443_ _07141_ _00656_ _00657_ _00677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08444_ _00676_ _00677_ _07139_ _00678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08445_ _07122_ _07121_ _07120_ _00679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08446_ _07119_ _07134_ _00680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08447_ _07135_ _07134_ _07129_ _07132_ _00681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08448_ _00679_ _00680_ _00681_ _00682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08449_ _07129_ _07131_ _00683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08450_ _07128_ _00683_ _00684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08451_ _07126_ _00682_ _00684_ _00685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08452_ _00682_ _00684_ _07126_ _00686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08453_ _07125_ _00620_ _00685_ _00686_ _00687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_08454_ _00651_ _00653_ _00650_ _00688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08455_ _07139_ _00676_ _00677_ _00689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08456_ _00689_ _00688_ _00690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08457_ _00687_ _00688_ _00690_ _00691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08458_ _00570_ _00678_ _00691_ _00692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08459_ _00616_ _00693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_08460_ _00569_ _00632_ _00694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08461_ _00639_ _00694_ _00695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08462_ _00567_ _07080_ _00590_ _00696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08463_ _00579_ _00696_ _00697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08464_ _07081_ _00698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_08465_ _00698_ _00589_ _00699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08466_ _07077_ _07080_ _00698_ _00700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_08467_ _07077_ _00698_ _00588_ _00699_ _00700_ _00701_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08468_ _00588_ _00579_ _00702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08469_ _07676_ _07672_ _07680_ _00585_ _00703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08470_ _07676_ _07091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_16
X_08471_ _00569_ _00632_ _00704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08472_ _00630_ _00629_ _00705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08473_ _07088_ _07085_ _07090_ _00706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_08474_ _07103_ _00706_ _00707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08475_ _00705_ _00704_ _00585_ _00707_ _00708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_08476_ _00697_ _00701_ _00702_ _00703_ _07091_ _00708_ _00709_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_08477_ _07090_ _07089_ _00710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08478_ _07088_ _00710_ _07087_ _00711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08479_ _07085_ _00711_ _00712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08480_ _07091_ _00708_ _00712_ _00713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_08481_ _07099_ _00714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08482_ _07097_ _00715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08483_ _00714_ _00633_ _00715_ _00716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08484_ _07096_ _00716_ _07094_ _00717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08485_ _07094_ _07096_ _00716_ _00718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08486_ _07093_ _00694_ _00717_ _00718_ _00719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08487_ _00713_ _00709_ _00695_ _00719_ _07104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08488_ _00569_ _00678_ _00720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08489_ _07106_ _00613_ _00721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08490_ net5 _00721_ _00626_ _00722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08491_ _00688_ _00720_ _00722_ _00723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08492_ _00693_ _07104_ _00723_ _00724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08493_ _00605_ _07160_ _00692_ _00724_ _00725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08494_ _07164_ _00726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08495_ _00602_ _07167_ _07165_ _00727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08496_ _07162_ _00728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08497_ _00727_ _00726_ _00728_ _00729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08498_ _00727_ _00726_ _00728_ _00730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_08499_ _00729_ _00730_ _00731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08500_ net36 _00731_ _00732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08501_ _07159_ _07161_ _00733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08502_ _07158_ _00733_ _00734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08503_ _00729_ _00730_ _07660_ _00734_ _00735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_08504_ _00654_ _00663_ _00645_ _00736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_08505_ _00693_ _00736_ _00737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08506_ _07106_ _00613_ _00738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08507_ net5 _00738_ _00739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08508_ _00569_ _00678_ _00689_ _00688_ _00740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08509_ _00670_ _00687_ _00739_ _00736_ _00740_ _00741_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08510_ _07104_ _00737_ _00741_ _00742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08511_ _00732_ _00735_ _00742_ _00743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08512_ _07182_ _00744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08513_ _07186_ _00745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08514_ _07191_ _07189_ _07188_ _00746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08515_ _07185_ _00747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08516_ _00746_ _00745_ _00747_ _00748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08517_ _07183_ _00748_ _00749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08518_ _07197_ _00750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08519_ _07200_ _07199_ _07198_ _00751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08520_ _07195_ _00752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08521_ _00750_ _00751_ _00752_ _00753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08522_ _07183_ _07186_ _07189_ _07192_ _00754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08523_ _07194_ _00753_ _00754_ _00755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08524_ _00744_ _00749_ _00755_ _00756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08525_ _07180_ _00756_ _07179_ _00757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08526_ net18 _00569_ _00758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08527_ _00598_ _00604_ _00758_ _00759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08528_ _00598_ _00604_ net18 _00760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08529_ _00759_ _00760_ _00761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08530_ _00757_ _00761_ _00762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08531_ _07186_ _07189_ _07192_ _00763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08532_ _07194_ _00753_ _00763_ _00764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08533_ _00748_ _07182_ _07179_ _00765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08534_ _07179_ _07183_ _07182_ _00766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_08535_ _07179_ _07180_ _00766_ _00767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08536_ _00765_ _00764_ _00767_ _00768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08537_ _00569_ _00678_ _00689_ _00688_ _00769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08538_ _00769_ _00768_ _00770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08539_ _00670_ _00687_ _00739_ _00736_ _00771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_08540_ _07104_ _00737_ _00771_ _00770_ _00772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08541_ _00762_ _00772_ _00773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08542_ _07660_ _00774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08543_ _00725_ _00743_ _00773_ _00774_ _00775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08544_ _07183_ _00748_ _00776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08545_ _00764_ _00776_ _00777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08546_ _00749_ _00755_ _00777_ _00778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08547_ _07211_ _00779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08548_ _07217_ _00780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08549_ _07220_ _07219_ _07218_ _00781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08550_ _07215_ _00782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_08551_ _00780_ _00781_ _00782_ _00783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08552_ _07214_ _00783_ _07212_ _00784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08553_ _07209_ _07206_ _00785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08554_ _00779_ _00784_ _00785_ _00786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08555_ _07206_ _07208_ _00787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08556_ _07205_ _00786_ _07202_ _00787_ _00788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_08557_ _07203_ _00789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08558_ _07202_ _00790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08559_ _00789_ _00790_ _00569_ _00791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08560_ _00791_ _00788_ _00792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08561_ _00583_ _00793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_08562_ _00757_ _00778_ _00792_ _00793_ _00794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_08563_ net18 _00734_ _00795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08564_ _00729_ _00730_ _00795_ _00760_ _00759_ _00796_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_08565_ _00778_ _00761_ _00796_ _00768_ _00797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08566_ _00640_ _00649_ _00668_ _00798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08567_ _00670_ _00674_ net18 _00799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08568_ _00798_ _00799_ _00768_ _00800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08569_ _00797_ _00800_ _00742_ _00801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08570_ _00762_ _00772_ _00802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08571_ _00778_ _00803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08572_ _07205_ _00786_ _00787_ _07203_ _00804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08573_ net36 _00805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08574_ _00790_ _00804_ _00805_ _00806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08575_ _00803_ _00806_ _00807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08576_ _00794_ _00801_ net33 _00807_ _00808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_08577_ _00605_ _07160_ _00692_ _00724_ _00809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_08578_ net36 _00731_ _00810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08579_ _00583_ _00669_ _00675_ _00735_ _00811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08580_ _00810_ _00811_ _00742_ _00812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_08581_ _00742_ _00731_ _00795_ _00806_ _00813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08582_ _00813_ _00773_ _00812_ _00809_ _00814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08583_ _00775_ _00808_ _00814_ _00815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_08584_ _00815_ _00816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08585_ _07161_ _00729_ _00817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08586_ _07159_ _00805_ _00742_ _00817_ _00818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08587_ _00629_ _00630_ _00819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08588_ _07103_ _00706_ _00820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08589_ _00694_ _00819_ _00606_ _00820_ _00821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_08590_ _07088_ _00710_ _00822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08591_ _07091_ _07103_ _00706_ _00823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08592_ _00585_ _00823_ _07086_ _00824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08593_ _07091_ _00694_ _00819_ _00825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08594_ _00821_ _07676_ _00822_ _00824_ _00825_ _07095_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_08595_ _00694_ _00639_ _00826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08596_ _00616_ _00826_ _00827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08597_ _07111_ _07114_ _00828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08598_ _07112_ _07111_ _00829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08599_ _00611_ _00828_ _00829_ _00830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08600_ _07109_ _00830_ _00831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08601_ _07094_ _07096_ _07093_ _00832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08602_ _00715_ _00714_ _00633_ _00833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08603_ _00704_ _00716_ _00832_ _00833_ _00834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_08604_ _00831_ _00834_ _00616_ _00835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08605_ _07095_ _00827_ _00835_ _00836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08606_ _07129_ _07131_ _00665_ _00837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08607_ _07131_ _00665_ _07129_ _00838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08608_ _00625_ _00837_ _00838_ _00839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08609_ _07142_ _00840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08610_ _00840_ _07144_ _07147_ _00672_ _00841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08611_ _00840_ _07145_ _00672_ _00842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08612_ _00840_ _07145_ _07147_ _00843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08613_ _00840_ _07145_ _07144_ _00844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08614_ _00840_ _07144_ _00843_ _00844_ _00845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08615_ _00841_ _00842_ _00845_ _00846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08616_ _00839_ _00846_ _00670_ _00847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08617_ _00736_ _00836_ _00847_ _07157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08618_ _07159_ _07162_ _00848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08619_ _00726_ _00727_ _00848_ _00849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08620_ _00733_ _00849_ _00850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08621_ _00742_ _00851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08622_ _07158_ _07157_ _00850_ _00805_ _00851_ _00852_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_08623_ _07159_ _00817_ _00853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08624_ _00805_ _00742_ _00853_ _00854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08625_ _00818_ _00852_ _00854_ _00855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08626_ _07159_ _00595_ _07161_ _00729_ _00856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08627_ _00850_ _00856_ _00774_ _00857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08628_ _00850_ _00856_ _00583_ _00858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08629_ _00857_ _00858_ _00851_ _00859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08630_ _00793_ _00805_ _00860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08631_ _00736_ _00836_ _00847_ _07660_ _00861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08632_ _00860_ _00861_ _00742_ _00862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08633_ net33 _00859_ _00862_ _00863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08634_ _07180_ _00756_ _00864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08635_ _00762_ net34 _00864_ _00865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08636_ _00855_ _00863_ _00865_ _00866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08637_ _00851_ _00761_ _00867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08638_ _00816_ _00866_ _00768_ _00867_ _00868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08639_ _00868_ _00869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08640_ _00757_ _00851_ _00761_ _00870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08641_ _07212_ _07218_ _07206_ _07209_ _00871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08642_ _07203_ _07215_ _00872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08643_ _07220_ _00591_ _00871_ _00872_ _00873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08644_ _00570_ _00873_ _00874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08645_ _00805_ _00873_ _00875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08646_ _00874_ _00875_ _00778_ _00876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08647_ _00762_ net34 _00876_ _00877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08648_ _00865_ _00870_ _00877_ _00878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08649_ _00855_ _00863_ _00878_ _00879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08650_ _00879_ _00880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08651_ _07237_ _07236_ _00881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08652_ _07235_ _00881_ _00882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08653_ _00882_ _07234_ _00883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08654_ _00883_ _07232_ _00884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08655_ _00782_ _00780_ _00781_ _00885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08656_ _00783_ _00885_ _00886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08657_ _07791_ _00886_ _00887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08658_ _00816_ _00880_ _00884_ _00887_ _00888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08659_ _00818_ _00852_ _00854_ _00889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_08660_ net33 _00859_ _00862_ _00890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08661_ _00889_ _00890_ _00775_ _00808_ _00891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08662_ _07198_ _07200_ _07199_ _00892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08663_ _00751_ _00892_ _00893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08664_ _07176_ _00768_ _00894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08665_ net18 _00805_ _00605_ _00895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08666_ _00772_ _00893_ _00762_ _00894_ _00895_ _00851_ _00896_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_4
X_08667_ _07176_ _00897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08668_ _00897_ _00757_ _00759_ _00898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08669_ _07660_ _00605_ _00899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08670_ _00894_ _00899_ _00900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08671_ _00898_ _00900_ _00851_ _00901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08672_ _00896_ _00901_ _07791_ _00884_ _00902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08673_ _00884_ _00903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_08674_ _07791_ _00903_ _00896_ _00901_ _00904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_08675_ _00865_ _00870_ _00877_ _00905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_08676_ _00904_ _00902_ _00814_ _00905_ _00906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08677_ _07226_ _07228_ _07225_ _00907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08678_ _07240_ _07231_ _07239_ _00908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08679_ _00907_ _00908_ _00909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08680_ _00891_ _00906_ _00909_ _00910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08681_ _07226_ _07229_ _00911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08682_ _00907_ _00911_ _00912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08683_ _00910_ _00888_ _00912_ _00913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08684_ _07223_ _00914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_08685_ _00896_ _00901_ _07213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08686_ _07791_ _07213_ _00915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08687_ _00805_ _00916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08688_ _07191_ _00917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08689_ _07194_ _00753_ _07192_ _00918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08690_ _07189_ _00919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08691_ _00917_ _00918_ _00919_ _00920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08692_ _07188_ _00920_ _00921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08693_ _00745_ _00921_ _00922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08694_ _00762_ _00772_ _00922_ _00923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08695_ _07117_ _07115_ _07116_ _00924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08696_ _00611_ _00924_ _00925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08697_ _07102_ _00926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08698_ _00926_ _00694_ _00639_ _00927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08699_ _00925_ _00927_ _00616_ _00928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08700_ _07119_ _00929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08701_ _00929_ _00679_ _00930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08702_ _07135_ _00930_ _00931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08703_ _00645_ _00931_ _00932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08704_ _07148_ _00662_ _00933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08705_ _00654_ _00663_ _00933_ _00934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08706_ _00736_ _00928_ _00932_ _00670_ _00934_ _07163_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08707_ _00899_ _07163_ _00935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08708_ _07165_ _07167_ _00602_ _00936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08709_ _00727_ _00936_ _00937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08710_ _00899_ _00937_ _00938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08711_ _00935_ _00938_ _00851_ _00939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08712_ _00916_ _00923_ _00939_ _00940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08713_ _00570_ _00762_ net34 _00941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08714_ _00570_ _00941_ _00923_ _00942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08715_ _00805_ _00851_ _00937_ _00943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08716_ _00939_ _00943_ _00916_ _00773_ _00944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08717_ _00940_ _00942_ _00944_ _00945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08718_ _00581_ _07769_ _00946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08719_ _07235_ _07237_ _07223_ _07232_ _00947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08720_ _00947_ _00911_ _00946_ _00948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08721_ _00915_ _00945_ _00948_ _00949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08722_ net33 _00864_ _00950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08723_ _00778_ _00762_ net34 _00951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08724_ _00809_ _00773_ _00812_ _00951_ _00952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_08725_ _00889_ _00890_ _00950_ _00952_ _00953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08726_ _00790_ _00570_ _00954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08727_ _00788_ _00791_ _00954_ _00804_ _00955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_08728_ _00768_ _00955_ _00956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08729_ _00768_ _00955_ _00957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08730_ _00867_ _00956_ _00957_ _00958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08731_ _00809_ _00812_ _00955_ net33 _00959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08732_ _00803_ _00958_ _00959_ _00960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08733_ _00815_ _00879_ _00953_ _00960_ _00961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08734_ _00952_ _00955_ _00962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08735_ _00887_ _00963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08736_ _07203_ _07205_ _00786_ _00787_ _00964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08737_ _00804_ _00964_ _00965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08738_ _00805_ _00965_ _00966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08739_ _00966_ _00967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08740_ _00948_ _00967_ _00963_ _00968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08741_ _00870_ _00968_ _00962_ _00969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08742_ _00815_ _00866_ _00970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08743_ _00949_ _00961_ _00970_ _00969_ _00971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_08744_ _00571_ _00965_ _00972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08745_ _00816_ _00880_ _00972_ _00973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08746_ _00939_ _00943_ _00974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08747_ _00773_ _00974_ _00923_ _07201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08748_ _00570_ _00816_ _00880_ _07201_ _00975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08749_ _07223_ _00973_ _00975_ _00976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08750_ _00774_ _00570_ _00977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08751_ _00816_ _00880_ _00977_ _00965_ _00978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08752_ _00814_ _00808_ _00775_ _00979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08753_ _00889_ _00890_ _00905_ _00980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08754_ _00979_ _00980_ _00977_ _07201_ _00981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08755_ _00978_ _00981_ _00982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08756_ _00914_ _00971_ _00976_ _00982_ _00983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_08757_ _00816_ _00880_ _00966_ _07222_ _00984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08758_ _07222_ _00985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08759_ _00985_ _00815_ _00879_ _00945_ _00986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08760_ _00984_ _00986_ _00987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08761_ _00815_ _00880_ _00965_ _00793_ _00988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08762_ _00793_ _00979_ _00980_ _07201_ _00989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08763_ _00988_ _00989_ _00990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08764_ _00919_ _00917_ _00918_ _00991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08765_ _07173_ _00992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08766_ _00992_ _00599_ _00993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08767_ _07171_ _00993_ _07170_ _07168_ _00994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08768_ _00602_ _00994_ _00995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08769_ _07117_ net5 _07118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08770_ _07120_ _07122_ _07121_ _00996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08771_ _00679_ _00996_ _00997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08772_ _07118_ _00997_ _00645_ _07149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08773_ _07156_ _07155_ _00998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08774_ _07154_ _00998_ _07153_ _00999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08775_ _07151_ _00999_ _01000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08776_ _07149_ _01000_ _00670_ _07166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08777_ _00916_ _00899_ _00851_ _01001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_08778_ _00995_ _07166_ _01001_ _07187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08779_ _00802_ _07187_ _01002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08780_ _00802_ _00920_ _00991_ _01002_ _07204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08781_ _00779_ _00784_ _01003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08782_ _07209_ _01003_ _07208_ _01004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08783_ _07206_ _01004_ _01005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08784_ _00980_ _00979_ _01006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_08785_ _07204_ _01005_ _01006_ _07221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08786_ _00971_ _00987_ _00990_ _07221_ _01007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_08787_ _00915_ _00945_ _00948_ _01008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08788_ _00815_ _00880_ _00953_ _00960_ _01009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08789_ _00870_ _00962_ _00968_ _01010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08790_ _00979_ _00866_ _01011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08791_ _01008_ _01009_ _01010_ _01011_ _01012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_08792_ _00984_ _00986_ _01013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08793_ _00988_ _00989_ _01014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08794_ _01012_ _01013_ _01014_ _00913_ net21 _01015_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_08795_ _00913_ _00983_ _01007_ _01015_ _01016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_08796_ _00571_ _00594_ _00869_ _01016_ _01017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08797_ _00916_ _01018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08798_ _07251_ _01019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08799_ _07257_ _01020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08800_ _07260_ _07259_ _07258_ _01021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08801_ _01021_ _01020_ _01022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08802_ _01022_ _07255_ _01023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08803_ _01023_ _07254_ _07252_ _01024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08804_ _01019_ _01024_ _01025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08805_ _01025_ _07249_ _01026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08806_ _01026_ _07248_ _01027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08807_ _07246_ _01027_ _01028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08808_ _01028_ _07245_ _01029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08809_ _01029_ _07243_ _07242_ _01030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08810_ _01018_ _01030_ _01031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08811_ _00571_ _01030_ _01032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08812_ _00571_ _01030_ _00774_ _01033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08813_ _01032_ _01033_ _01034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08814_ _01031_ _01034_ _01016_ _01035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08815_ _01017_ _01035_ _01036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08816_ _00980_ _00979_ _01037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08817_ _00816_ _00880_ _00945_ _01038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08818_ _01037_ _00967_ _01038_ _01039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08819_ _07223_ _01039_ _00913_ _01040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_08820_ _01037_ _00955_ _01041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08821_ _00952_ _01041_ _01042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_08822_ _00916_ _00778_ _01043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08823_ _01043_ _00873_ _01044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08824_ _00870_ _01044_ _01045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08825_ _00809_ _00812_ _00570_ _01046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08826_ _07104_ _00737_ _01047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08827_ _00741_ _01047_ _00735_ _01048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08828_ _00851_ _00761_ _00570_ _01049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08829_ _00757_ _00873_ _01050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08830_ _01048_ _01049_ _01050_ _01051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08831_ _00773_ _01045_ _01046_ _01051_ _01052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08832_ _00866_ _01052_ _01053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08833_ _00816_ _00866_ _01054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08834_ _00979_ _01053_ _01054_ _01055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08835_ _01012_ _00987_ _00990_ _01055_ _01056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08836_ net6 _01042_ _01056_ _01057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08837_ _00868_ _01057_ _01058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08838_ _01018_ _01030_ _01059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08839_ _01033_ _01060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08840_ _01059_ _01060_ _01016_ _01061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_08841_ _07223_ _00913_ _01039_ _01062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08842_ _00952_ _01041_ _01063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08843_ _01063_ _01056_ _00971_ _01064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08844_ _00866_ _01053_ _00979_ _01065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08845_ _07229_ _07239_ _01066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08846_ _07228_ _01066_ _01067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08847_ _07226_ _01067_ _07225_ _01068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08848_ _07231_ _00884_ _01069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08849_ _07229_ _07228_ _01069_ _07226_ _01070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08850_ _00816_ _00880_ _00915_ _01070_ _01071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08851_ _01070_ _01072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08852_ _00816_ _00880_ _00887_ _01072_ _01073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08853_ _01068_ _01071_ _01073_ _01074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08854_ _01065_ _01074_ _01075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08855_ _00987_ _00990_ _01065_ _01074_ _01076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_08856_ _01075_ _01076_ _01077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08857_ _01062_ _01042_ _01078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08858_ _00987_ _00990_ _01065_ _01079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08859_ _01042_ _01079_ _01080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08860_ _01062_ _01064_ _01077_ _01078_ _01080_ _01081_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08861_ _07201_ _00965_ _01006_ _01082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08862_ _00990_ _00971_ _00987_ _01083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_08863_ _00985_ _00916_ _01084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08864_ _01068_ _01071_ _01073_ _01084_ _01085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08865_ _01071_ _01073_ _00914_ _00916_ _01086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_08866_ _00914_ _00916_ _01068_ _01087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08867_ _00914_ _00985_ _01088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08868_ _07222_ _01088_ _00916_ _01089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08869_ _01085_ _01086_ _01087_ _01089_ _01090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08870_ _01040_ _01083_ _01090_ _01091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08871_ _01082_ _01091_ _01092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_08872_ _01058_ _01061_ _01081_ _01092_ _01093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08873_ _00987_ _00990_ _01094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08874_ _01042_ _01094_ _01065_ _01012_ _01095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08875_ _01075_ _01076_ _01096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08876_ _01062_ _01042_ _01097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08877_ _01042_ _01079_ _01098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08878_ _01040_ _01095_ _01096_ _01097_ _01098_ _01099_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_08879_ _00868_ _01057_ _01100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08880_ _01018_ _01030_ _01101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08881_ _00977_ _01030_ _01102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08882_ _01101_ _01102_ _01016_ _01103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08883_ _01099_ _01092_ _01100_ _01103_ _01104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08884_ _01036_ _01093_ _01104_ _01105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08885_ _01082_ _01091_ _01106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08886_ _01106_ _01107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_08887_ _01031_ _01033_ _01016_ _01108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
Xclone31 _01031_ _01033_ _01016_ net31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08889_ _00888_ _00910_ _01110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08890_ _01110_ _00912_ _01111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08891_ net21 _00973_ _00975_ _01112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08892_ _00978_ _00981_ _01113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08893_ net21 _01012_ _01112_ _01113_ _01114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_08894_ _01111_ _01114_ _00594_ _01018_ _01115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_08895_ _00571_ _00594_ _01116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08896_ _01007_ _01015_ _01117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08897_ _01007_ _01115_ _01116_ _01117_ _00868_ _01118_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_08898_ _07266_ _07263_ _07272_ _07280_ _01119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08899_ _07277_ _07274_ _07269_ _01120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08900_ _00591_ _01119_ _01120_ _01121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08901_ _07243_ _01029_ _01122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08902_ _01018_ _01121_ _01122_ _01123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_08903_ _00571_ _01121_ _01124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08904_ _01122_ _01124_ _01125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08905_ _01107_ net31 _01118_ _01123_ _01125_ _01126_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_08906_ _07239_ _01069_ _01127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08907_ _07229_ _01127_ _07228_ _01128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08908_ _01067_ _01128_ _07226_ _01129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08909_ _01129_ _01130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08910_ _07226_ _01131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08911_ _01131_ _07229_ _01132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08912_ _01069_ _01132_ _01133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08913_ _07228_ _07239_ _01134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08914_ _07226_ _01134_ _01135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08915_ _00915_ _00963_ _01006_ _01136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08916_ _01133_ _01135_ _01136_ _01137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08917_ net6 _01083_ _01130_ _01137_ _01138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08918_ _07171_ _00993_ _01139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08919_ _07122_ _00626_ _07152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08920_ _07154_ _00998_ _01140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08921_ _07152_ _01140_ _00670_ _07169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08922_ _01139_ _07169_ _01001_ _07190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08923_ _07192_ _07194_ _00753_ _01141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08924_ _00918_ _01141_ _01142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08925_ _07190_ _01142_ _00773_ _07207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08926_ _07209_ _01003_ _01143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08927_ _07207_ _01143_ _01006_ _07224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08928_ net6 _01083_ _07224_ _01144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08929_ _01138_ _01144_ _01124_ _01145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08930_ _01107_ _01108_ _01118_ _01145_ _01146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08931_ _01018_ _01121_ _01138_ _01144_ _01147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08932_ _01107_ _01108_ _01118_ _01147_ _01148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08933_ _01126_ _01146_ _01148_ _01149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08934_ _01111_ _01114_ _01117_ _01150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08935_ _01092_ _01061_ _01151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08936_ _01069_ _01132_ _01152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08937_ _07226_ _01134_ _01153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08938_ _01152_ _01153_ _01136_ _01154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08939_ _01062_ _01012_ _01094_ _01129_ _01154_ _01155_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_08940_ _01040_ _01083_ _07224_ _01156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_08941_ _07265_ _01157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08942_ _07274_ _07273_ _07266_ _01158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_08943_ _01157_ _01158_ _01159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08944_ _01159_ _07263_ _01160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08945_ _07262_ _01160_ _01161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08946_ _07272_ _01161_ _01162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08947_ _07271_ _01162_ _01163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08948_ _07269_ _01163_ _01164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08949_ _01164_ _07268_ _01165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08950_ _07280_ _01165_ _01166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08951_ _01166_ _07279_ _01167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08952_ _07277_ _01167_ _01168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_08953_ _01168_ _07276_ _01169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_08954_ _01155_ _01156_ _01169_ _00571_ _01170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08955_ _01168_ _07276_ _01171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_08956_ _01171_ _01155_ _01156_ _00571_ _01172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_08957_ _01155_ _01156_ _00774_ _01173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08958_ _01170_ _01173_ _01172_ _01174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_08959_ _00571_ _00913_ _00594_ _00983_ _01175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_08960_ _01018_ _00913_ _01176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08961_ _00914_ _01176_ _01115_ _01083_ _01177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08962_ _01099_ _01118_ _01175_ _01177_ _01178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08963_ _01150_ _01151_ _01174_ _01178_ _01179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_08964_ _07243_ _01029_ _01180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08965_ _01018_ _01122_ _01181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08966_ _01171_ _01181_ _01182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08967_ _00774_ _01180_ _01182_ _01183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_08968_ _01016_ _01032_ _01184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_08969_ _01183_ _01184_ _01185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08970_ _01106_ _01099_ _01108_ _01118_ _01186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_08971_ _01186_ _01187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_08972_ _01185_ _01187_ _01188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08973_ _01105_ _01149_ _01179_ _01188_ _01189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_08974_ _01183_ _01184_ _01187_ _01190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_08975_ _01150_ _01174_ net28 _01190_ _01191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_08976_ _01189_ _01191_ _01192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_08977_ _01189_ _01191_ _01193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08978_ _01099_ _01118_ _01175_ _01177_ _01194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08979_ _01151_ _01194_ _01195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08980_ _01107_ net31 _01196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_08981_ _01195_ _01196_ _01185_ _01197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08982_ _01099_ _01106_ _01108_ _01118_ _01198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08983_ _01099_ _01170_ _01172_ _01173_ _01199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_08984_ _01107_ net31 _01118_ _01200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08985_ _00572_ _01169_ _01201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_08986_ _01183_ _01198_ _01199_ _01200_ _01201_ _01202_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_08987_ _01036_ _01093_ _01201_ _01104_ _01203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_08988_ _01155_ _01156_ _01204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_08989_ _01204_ _07241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_08990_ _07241_ _01122_ _01186_ _01205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_08991_ _01202_ _01203_ _01205_ _01206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_08992_ _01202_ _01203_ _01205_ _01207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_08993_ _01197_ _01206_ _01207_ _01208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_08994_ _01193_ _01208_ _01209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08995_ _01017_ _01035_ _01210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_08996_ _01100_ net31 _01099_ _01107_ _01211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_08997_ _01099_ _01092_ _01100_ _01103_ _01212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_08998_ _01210_ _01211_ _01212_ _01213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_08999_ _00793_ _01122_ _01171_ _01181_ _01214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09000_ _01099_ _01170_ _01172_ _01173_ _01215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09001_ _01106_ _01108_ _01118_ _01216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_09002_ _01214_ _01186_ _01215_ _01216_ _01217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09003_ _07277_ _01167_ _01218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_4
X_09004_ _01218_ _01219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_09005_ _00572_ _01219_ _01220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09006_ _01018_ _01221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09007_ _01221_ _01218_ _01222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09008_ _01213_ _01217_ _01220_ _01222_ _01223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_09009_ _00752_ _00750_ _00751_ _01224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09010_ _07176_ _07174_ _07175_ _01225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09011_ _00599_ _01225_ _01226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09012_ _00650_ _00678_ _00916_ _07156_ _07172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_09013_ _01226_ _07172_ _01001_ _07193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09014_ _00802_ _07193_ _01227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09015_ _00753_ _00802_ _01224_ _01227_ _07210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09016_ _07212_ _07214_ _00783_ _01228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09017_ _00784_ _01228_ _01229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09018_ _07210_ _01229_ _01006_ _07227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09019_ _00891_ _00906_ _01230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09020_ _00908_ _00888_ _01230_ _01231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09021_ _07229_ _01231_ _01232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09022_ _01083_ _01040_ _01233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09023_ _07227_ _01232_ _01233_ _07244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09024_ _07244_ _01234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09025_ _07246_ _01027_ _01235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09026_ _01235_ _01236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09027_ _01234_ _01236_ _01186_ _01237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09028_ _00572_ _01213_ _01217_ _01237_ _01238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09029_ _07300_ _07292_ _07295_ _07298_ _01239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09030_ _07283_ _07286_ _07289_ _01240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09031_ _00591_ _01239_ _01240_ _01241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09032_ _01223_ _01238_ _01241_ _01242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09033_ _01105_ _01149_ _01243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09034_ _01062_ _00971_ _01094_ _01244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09035_ _01042_ _01244_ _01245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09036_ _01092_ _01061_ _01245_ _01246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09037_ _01092_ _01061_ _01245_ _01247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09038_ _01194_ _01246_ _01247_ _01248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09039_ _01107_ _01103_ _01249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09040_ _01035_ _01107_ _01214_ _01249_ _01250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09041_ _01179_ _01248_ _01250_ _01251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09042_ _01179_ _01250_ _01248_ _01252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09043_ _01243_ _01251_ _01252_ _01253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_09044_ net21 _01039_ _01254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09045_ _00987_ _00990_ _01255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09046_ _01254_ _01074_ _01255_ _01042_ _01256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_09047_ net6 _00971_ _01256_ _01257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09048_ _01256_ _01257_ _01055_ _01258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09049_ _01246_ _01258_ _01259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09050_ _01100_ _01259_ net28 _01260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09051_ _01237_ _07275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_09052_ _01017_ _01035_ _01107_ _01261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09053_ _01107_ _01103_ _01099_ _01262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09054_ _01261_ _01262_ _01263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09055_ _01241_ _01264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09056_ _00572_ _01264_ _01265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09057_ _01217_ _07275_ _01263_ _01265_ _01266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09058_ _01092_ _01061_ _01267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09059_ _01063_ _01244_ _01268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09060_ _01267_ _01268_ _01269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09061_ _01081_ _01061_ _01058_ _01270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09062_ _01100_ _01262_ _01270_ _01261_ _01271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_09063_ _01269_ _01271_ _01272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09064_ _01179_ _01250_ _01273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09065_ _01260_ _01266_ _01272_ _01273_ _01274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09066_ _01242_ _01253_ _01274_ _01275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09067_ _01174_ _01214_ _01186_ _01276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09068_ _01276_ _01277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09069_ _01105_ net42 _07275_ _01278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09070_ _01105_ _01279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09071_ _01279_ net42 _01219_ _01280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09072_ _00774_ _01281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09073_ _07297_ _01282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09074_ _07300_ _07299_ _07298_ _01283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09075_ _01282_ _01283_ _01284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09076_ _01284_ _07295_ _01285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09077_ _07294_ _01285_ _01286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09078_ _07292_ _01286_ _01287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09079_ _01287_ _07291_ _01288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09080_ _07289_ _01288_ _01289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09081_ _01289_ _07288_ _01290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09082_ _07286_ _01290_ _01291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09083_ _07285_ _01291_ _01292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09084_ _07283_ _01292_ _01293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09085_ _01293_ _07282_ _01294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09086_ _01294_ _01295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09087_ _01295_ _01221_ _01296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09088_ _01281_ _01296_ _01297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09089_ _01278_ _01280_ _01297_ _01298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09090_ _07282_ _01293_ _01299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_09091_ _01221_ _01278_ _01280_ _01299_ _01300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09092_ _01298_ _01300_ _01301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09093_ _01189_ _01191_ _01206_ _01207_ _01302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_09094_ _01018_ _01169_ _01303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09095_ _01214_ net28 _01215_ _01216_ _01303_ _01304_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_09096_ _01210_ _01211_ _01303_ _01212_ _01305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09097_ _01204_ _01180_ net28 _01306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09098_ _01304_ _01305_ _01306_ _01307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09099_ _01304_ _01305_ _01306_ _01308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09100_ _01307_ _01308_ _01309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09101_ _01192_ _01309_ _01298_ _01300_ _01310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_09102_ _01209_ _01275_ _01301_ _01302_ _01310_ _01311_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_09103_ _01213_ _01217_ _01237_ _01312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09104_ _01213_ _01217_ _01218_ _01313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09105_ _01312_ _01313_ _00774_ _01296_ _01314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09106_ _00572_ _01295_ _01313_ _01312_ _01315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_09107_ _01193_ _01208_ _01314_ _01315_ _01316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_09108_ _01279_ _01149_ _01179_ _01250_ _01317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09109_ _01197_ _01317_ _01318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09110_ _01081_ _01092_ _01061_ _01319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09111_ _01058_ _01319_ _01320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09112_ _01183_ _01263_ _01320_ _01321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09113_ _01118_ _01175_ _01177_ _01322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09114_ _01322_ _01319_ _01268_ _01258_ _01323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09115_ _01267_ _01258_ _01324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09116_ _01323_ _01324_ _01325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09117_ _01318_ _01321_ _01325_ _01326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09118_ _01253_ _01316_ _01326_ _01327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09119_ _01311_ _01327_ _01328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09120_ _00572_ _01219_ _01329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09121_ _01221_ _01218_ _01330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09122_ _01279_ net42 _01329_ _01330_ _01331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09123_ _01221_ _01279_ _01277_ _07275_ _01332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09124_ _01331_ _01332_ _01264_ _01333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09125_ _01243_ _01251_ _01252_ _01334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09126_ _01246_ _01258_ _01335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09127_ _01058_ _01335_ _01198_ _01336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09128_ _01217_ _07275_ _01263_ _01265_ _01337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_09129_ _01269_ _01271_ _01338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09130_ _01179_ _01250_ _01339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09131_ _01336_ _01337_ _01338_ _01339_ _01340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_09132_ _01333_ _01334_ _01340_ _01341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09133_ _01341_ _01342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09134_ _01314_ _01208_ _01193_ _01315_ _01343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09135_ _01343_ _01344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09136_ _07283_ _01292_ _01345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09137_ _01221_ _01345_ _01346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09138_ _01342_ net38 _01346_ _01347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09139_ _07280_ _01165_ _01348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09140_ _01279_ _01277_ _01348_ _01166_ _01349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09141_ _07213_ _00886_ _01006_ _07238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09142_ _07240_ _01069_ _01350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09143_ _07238_ _01350_ _01233_ _07247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09144_ _07249_ _01025_ _01351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09145_ _07247_ _01351_ _01186_ _07278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09146_ _01279_ _01277_ _07278_ _01352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09147_ _01349_ _01352_ _01353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09148_ _01353_ _07281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09149_ _00573_ _01341_ _01343_ _07281_ _01354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09150_ _01312_ _01313_ _01355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09151_ _00793_ _01219_ net32 _01356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09152_ _01279_ net42 _01356_ _01357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09153_ _00774_ _01299_ _01358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09154_ _01279_ net42 _07275_ _01358_ _01359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09155_ _01307_ _01308_ _01357_ _01359_ _01360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09156_ _01122_ _01236_ _01299_ _01361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09157_ _01180_ _01235_ _01295_ _01362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09158_ _01198_ _01361_ _01362_ _01363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09159_ _01204_ _07244_ net32 _01364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09160_ _01204_ _07244_ _01295_ _01365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09161_ net28 _01364_ _01365_ _01366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09162_ _01363_ _01366_ _00572_ _01367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09163_ _01219_ _01299_ _01368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09164_ _01218_ _01294_ _01369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09165_ _01369_ _01370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09166_ _01204_ _01169_ _01371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09167_ _01368_ _01370_ _01371_ _01372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09168_ _01169_ _01218_ _01295_ _01373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09169_ _01171_ _01219_ _01299_ _01374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09170_ _01373_ _01374_ _01180_ _01375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09171_ _01198_ _01375_ _01221_ _01376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09172_ _01169_ _01369_ _01377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09173_ _01169_ _01368_ _01377_ _01378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09174_ _01180_ _01198_ _01378_ _01379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09175_ _01198_ _01372_ _01376_ _01379_ _01380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_09176_ _01277_ _01279_ _01381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09177_ _01367_ _01380_ _01381_ _01382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09178_ _00573_ _01360_ _01382_ _01193_ _01383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09179_ _01221_ _01384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09180_ _01312_ _01313_ net32 _01281_ _01385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_09181_ _01312_ _01313_ net32 _01386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09182_ _01384_ _01309_ _01385_ _01386_ _01387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09183_ _01355_ _01343_ _01383_ _01387_ _01388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09184_ _01243_ _01251_ _01252_ _01349_ _01352_ _00573_ _01389_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_2
X_09185_ _01242_ _01274_ _01389_ _01390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09186_ _01314_ _01315_ _01302_ _01317_ _01197_ _01391_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_09187_ _00591_ _01392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09188_ _07303_ _07306_ _07309_ _01393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09189_ _07320_ _07312_ _07315_ _07318_ _01394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09190_ _01392_ _01393_ _01394_ _01395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09191_ _01316_ _01390_ _01391_ _01395_ _01396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_09192_ _01347_ _01354_ _01388_ _01396_ _01397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09193_ _01309_ _01398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09194_ _07283_ _01292_ _01399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09195_ _07309_ _07311_ _07308_ _01400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09196_ _07317_ _01401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09197_ _07320_ _07319_ _07318_ _01402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09198_ _01401_ _01402_ _01403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09199_ _01403_ _07315_ _01404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09200_ _01404_ _07314_ _01405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09201_ _07312_ _01405_ _01406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09202_ _01406_ _07309_ _01407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09203_ _01400_ _01407_ _01408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09204_ _07306_ _01408_ _01409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09205_ _01409_ _07305_ _01410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09206_ _07303_ _01410_ _01411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09207_ _01411_ _07302_ _01412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09208_ _01412_ _01346_ _01413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09209_ _00774_ _01399_ _01413_ _01414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09210_ _01221_ _01299_ _01415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09211_ _01415_ _01414_ _01416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09212_ _01416_ _01417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09213_ _00793_ _01345_ _01346_ _01412_ _01418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09214_ _01418_ _01415_ _01419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09215_ _01417_ _01419_ _01355_ _01420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09216_ _01398_ _01420_ _01421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09217_ _01298_ _01300_ _01422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09218_ _01193_ _01208_ _01423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09219_ _01423_ _01342_ _01424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09220_ _01312_ _01313_ _01425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09221_ _07302_ _01411_ _01426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09222_ _00572_ _01426_ _01281_ _01427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09223_ _00572_ _01412_ _01428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09224_ _01427_ _01428_ _01353_ _01429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09225_ _01425_ _01429_ _01430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09226_ _01424_ _01422_ _01430_ _01420_ _01398_ _01431_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_09227_ _01328_ _01397_ _01421_ _01422_ _01431_ _01432_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_09228_ _01192_ _01432_ _01433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09229_ _01316_ _01434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09230_ _01333_ _01340_ _01435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09231_ _01253_ _01435_ _01316_ _01436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09232_ _01253_ _01434_ _01436_ _01437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09233_ _01275_ _01438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09234_ _01425_ _01429_ _01316_ _01438_ _01439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_09235_ _01438_ _01434_ _01420_ _01440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09236_ _01192_ _01309_ _01298_ _01300_ _01441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09237_ _01298_ _01300_ _01302_ _01442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09238_ _01423_ _01342_ _01441_ _01442_ _01443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09239_ _01318_ _01321_ _01325_ _01444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09240_ _01334_ _01344_ _01444_ _01445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09241_ _01440_ _01439_ _01443_ _01445_ _01446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09242_ _01383_ _01387_ _01447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09243_ _01312_ _01313_ net32 _01448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09244_ _01448_ _01386_ _01449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09245_ _00573_ _01399_ _01393_ _01406_ _01450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09246_ _01400_ _01451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09247_ _07306_ _01451_ _01452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09248_ _07305_ _01452_ _01453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09249_ _07303_ _01453_ _07302_ _01454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09250_ _00573_ _01454_ _01281_ _01455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09251_ _01384_ _01454_ _01456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09252_ _01455_ _01456_ _01399_ _01457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09253_ _01384_ _01345_ _01393_ _01406_ _01458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_09254_ _01448_ _01386_ _01458_ _01459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09255_ _01449_ _01450_ _01457_ _01459_ _01460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_09256_ _01429_ _01438_ _01316_ _01425_ _01461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09257_ _01447_ _01460_ _01461_ _01462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09258_ _01446_ _01462_ _01463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09259_ _01437_ _01463_ _01464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09260_ _01342_ _01434_ _01391_ _01465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09261_ _01437_ _01463_ _01465_ _01466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09262_ _01433_ _01464_ _01465_ _01437_ _01466_ _01467_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_09263_ _01446_ _01462_ _01465_ _01468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09264_ _01462_ _01465_ _01469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09265_ _01468_ _01469_ _01470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09266_ _01221_ _01426_ _01471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09267_ _01399_ _01471_ _01472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09268_ _01438_ _01434_ _01472_ _01473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09269_ _01438_ _01316_ _01353_ _01471_ _01474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09270_ _01438_ _01434_ _01399_ _01471_ _01475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_09271_ _01342_ _01344_ _01353_ _01471_ _01476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_09272_ _01473_ _01474_ _01475_ _01476_ _01477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09273_ _01438_ _01316_ _01429_ _01478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09274_ _01414_ _01415_ _01479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09275_ _01438_ _01434_ _01416_ _01479_ _01480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_09276_ _01425_ _01478_ _01480_ _01481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09277_ _01478_ _01480_ _01425_ _01482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09278_ _01355_ _01415_ _01483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09279_ _01355_ _01415_ _01484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09280_ _01341_ _01344_ _01483_ _01484_ _01414_ _01485_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_09281_ _01485_ _01461_ _01311_ _01327_ _01486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09282_ _01486_ _01487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09283_ _01343_ _01341_ _01488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09284_ _07281_ _01345_ _01488_ _01489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09285_ _01477_ _01481_ _01482_ _01487_ _01489_ _01490_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_09286_ _01488_ _01491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09287_ _07286_ _01290_ _01492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_09288_ _07200_ _00802_ _07216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09289_ _07218_ _07220_ _07219_ _01493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09290_ _00781_ _01493_ _01494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09291_ _07216_ _01494_ _01006_ _07230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09292_ _07232_ _00883_ _01495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09293_ _07230_ _01495_ _01233_ _07250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09294_ _07252_ _07254_ _01023_ _01496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09295_ _01024_ _01496_ _01497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09296_ _07250_ _01497_ _01187_ _07267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09297_ _07267_ _01498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09298_ _07269_ _01163_ _01499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09299_ _01498_ _01499_ _01381_ _01500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09300_ _01342_ _01344_ _01500_ _01501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09301_ _07337_ _01502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09302_ _07340_ _07339_ _07338_ _01503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09303_ _01503_ _01502_ _01504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09304_ _07335_ _01504_ _01505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09305_ _07334_ _01505_ _01506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09306_ _07332_ _01506_ _01507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09307_ _01507_ _07331_ _01508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09308_ _07329_ _01508_ _01509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09309_ _01509_ _07328_ _01510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09310_ _07326_ _01510_ _01511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09311_ _01511_ _07325_ _01512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09312_ _01512_ _07323_ _07322_ _01513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09313_ _01513_ _01514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_09314_ _01384_ _01514_ _00793_ _01515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09315_ net13 _01492_ _01501_ _01515_ _01516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09316_ _01514_ _00573_ _01517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09317_ _01500_ _01517_ _01518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09318_ _01492_ _01517_ _01519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09319_ _01518_ _01519_ net13 _01520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09320_ _01516_ _01520_ _01446_ _01521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09321_ _01311_ _01327_ _01522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09322_ _01517_ _01523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09323_ _07303_ _01410_ _01524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09324_ _01523_ _01515_ _01524_ _01525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09325_ _01525_ _01526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_09326_ _01526_ _01439_ _01527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09327_ _01522_ _01526_ _01440_ _01527_ _01528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09328_ _01311_ _01490_ _01528_ _01521_ _01529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_09329_ _01437_ _01470_ _01529_ _01530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09330_ _01467_ _01530_ _01531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09331_ _01490_ _01521_ _01528_ _01532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_09332_ _01309_ _01422_ _01533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09333_ _01424_ _01533_ _01534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09334_ _01347_ _01354_ _01388_ _01396_ _01535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09335_ _01439_ _01440_ _01536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09336_ _01522_ _01535_ _01536_ _01537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09337_ _01534_ _01537_ _01538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09338_ _01532_ _01538_ _01539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09339_ _01425_ _01438_ _01434_ _01484_ _01540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09340_ _01342_ net38 _01483_ _01541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09341_ _01540_ _01541_ _01311_ _01327_ _01542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_09342_ _01438_ _01434_ _01418_ _01543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09343_ _01435_ _01434_ _01391_ _01334_ _01544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_09344_ _01478_ _01543_ _01544_ _01388_ _01545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_09345_ _01535_ _01542_ _01545_ _01546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09346_ _01217_ _01263_ _01547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09347_ _01317_ _01324_ _01323_ _01548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09348_ _01547_ _01320_ _01548_ _01549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09349_ _01436_ _01549_ _01550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09350_ _01546_ _01550_ _01551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_09351_ _01437_ _01468_ _01469_ _01552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_09352_ _00573_ _01524_ _01553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09353_ _07338_ _07329_ _07332_ _07335_ _01554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09354_ _07340_ _07323_ _07326_ _01555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09355_ _01392_ _01554_ _01555_ _01556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09356_ _01553_ _01556_ _01557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09357_ _01321_ _01557_ _01558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09358_ _01334_ net38 _01318_ _01325_ _01559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_09359_ _01439_ _01440_ _01443_ _01559_ _01560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09360_ _01253_ _01435_ _01434_ _01561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09361_ _01321_ _01562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09362_ _01561_ _01548_ _01562_ _01563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09363_ _01558_ _01560_ _01563_ _01557_ _01564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09364_ _01384_ _01492_ _01565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09365_ _01384_ _01492_ _01566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09366_ _01342_ net38 _01565_ _01566_ _01567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09367_ _01500_ _07284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09368_ _00573_ _07284_ _01568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09369_ _01384_ _01500_ _01569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09370_ _01568_ _01569_ net13 _01570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09371_ net22 _01556_ _01567_ _01570_ _01571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09372_ _01564_ _01571_ _01572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09373_ _01551_ _01552_ _01572_ _01573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09374_ _01437_ _01468_ _01574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09375_ _01539_ _01573_ _01574_ _01575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09376_ _01311_ _01490_ _01521_ _01528_ _01576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09377_ _01551_ _01552_ _01572_ _01576_ _01577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_09378_ _01532_ _01538_ _01433_ _01578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09379_ _01470_ _01529_ _01579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09380_ _01577_ _01578_ _01579_ _01580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09381_ _01531_ _01575_ _01580_ _01581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09382_ _01560_ _01563_ _01582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09383_ _01582_ _01583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09384_ _01529_ _01552_ _01551_ _01584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09385_ _01583_ _01584_ _01585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09386_ _01577_ _01578_ _01586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09387_ _01471_ _01525_ _01587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09388_ net22 _01516_ _01520_ _01588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09389_ net22 _01587_ _01588_ _01589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09390_ _01489_ _01589_ _01590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09391_ _01328_ _01397_ _01591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09392_ _01425_ _01429_ _01592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09393_ _01414_ _01483_ _01484_ _01593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09394_ _01592_ _01593_ net13 _01594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09395_ _01591_ _01536_ _01534_ _01594_ _01595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09396_ _01311_ _01490_ _01596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09397_ _01546_ _01550_ _01597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09398_ _01437_ _01468_ _01469_ _01598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09399_ _01564_ _01571_ _01599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09400_ _01596_ _01597_ _01598_ _01599_ _01600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_09401_ _01590_ _01595_ _01600_ _01601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09402_ _01491_ _01492_ _01501_ _07301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09403_ _07301_ _01524_ net22 _01602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09404_ _01384_ _01513_ _01603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09405_ _01602_ _01603_ _01604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09406_ _01515_ _01603_ _01605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09407_ _01602_ _01605_ _01606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09408_ _01604_ _01606_ _01600_ _01607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09409_ _07359_ _01608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09410_ _07342_ _07341_ _07360_ _01609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09411_ _01608_ _01609_ _01610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09412_ _07357_ _01610_ _01611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09413_ _01611_ _07356_ _01612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09414_ _01612_ _07354_ _01613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09415_ _01613_ _07353_ _01614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09416_ _01614_ _07351_ _01615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09417_ _01615_ _07350_ _01616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09418_ _07348_ _01616_ _01617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09419_ _01617_ _07347_ _01618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09420_ _01618_ _07345_ _07344_ _01619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09421_ _01037_ _07220_ _07233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_09422_ _07235_ _00881_ _01620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09423_ _07233_ _01620_ _01233_ _07253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09424_ _07255_ _01022_ _01621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09425_ _07253_ _01621_ _01187_ _07270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09426_ _07272_ _01161_ _01622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09427_ _07270_ _01622_ _01381_ _07287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09428_ _07289_ _01288_ _01623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09429_ _07287_ _01623_ _01491_ _07304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09430_ _07306_ _01408_ _01624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09431_ _07304_ _01624_ _01486_ _07321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09432_ _00574_ _07321_ _01625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09433_ _00793_ _01626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_09434_ _01626_ _07321_ _01627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09435_ _01619_ _01625_ _01627_ _01628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09436_ _07323_ _01512_ _01629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09437_ _00573_ _01629_ _01630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09438_ _00793_ _01629_ _01631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09439_ _01619_ _01630_ _01631_ _01632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09440_ _01551_ _01529_ _01552_ _01572_ _01633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_09441_ _01628_ _01632_ _01633_ _01634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09442_ _01586_ _01601_ _01607_ _01634_ _01635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_09443_ _01581_ _01585_ _01635_ _01636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09444_ _01470_ _01577_ _01579_ _01637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09445_ _01636_ _01637_ _01638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09446_ _01583_ _01584_ _01639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09447_ _01467_ _01530_ _01640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09448_ _01532_ _01538_ _01641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09449_ _01597_ _01598_ _01599_ _01642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09450_ _01641_ _01642_ _01437_ _01468_ _01643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09451_ _01640_ _01643_ _01644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09452_ _01577_ _01578_ _01579_ _01645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_09453_ _01607_ _01646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09454_ _01634_ _01647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09455_ _01645_ _01601_ _01646_ net30 _01648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09456_ _01644_ _01648_ _01649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09457_ _01639_ _01649_ _01650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09458_ _01638_ _01650_ _01651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09459_ _01384_ _01619_ _01652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09460_ _07321_ _01629_ _01633_ _01653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09461_ _01601_ _01646_ _01652_ _01653_ _01654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09462_ _00574_ _01619_ _01655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09463_ _01653_ _01655_ _01656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09464_ _01607_ _01647_ _01657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09465_ _01581_ _01585_ _01654_ _01656_ _01657_ _01658_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_09466_ _01590_ _01595_ _01659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09467_ _01531_ _01575_ _01600_ _01659_ _01639_ _01660_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_09468_ _01600_ _01590_ _01661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09469_ _01646_ net30 _01661_ _01662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09470_ _01646_ net30 _01661_ _01663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09471_ _01645_ _01660_ _01662_ _01663_ _01664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09472_ _01658_ _01664_ _01665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09473_ _01640_ _01643_ _01585_ _01601_ _01666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09474_ _01646_ _01645_ _01647_ _01667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_09475_ _07345_ _01618_ _01668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09476_ _01668_ _01669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09477_ _01384_ _01670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09478_ _07373_ _01671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09479_ _07362_ _01672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09480_ _07365_ _07364_ _07363_ _01673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09481_ _01672_ _01673_ _01674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09482_ _07380_ _01674_ _01675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09483_ _01675_ _07379_ _01676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09484_ _01676_ _07377_ _01677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09485_ _01677_ _07376_ _01678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09486_ _01678_ _07374_ _01679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09487_ _01679_ _01671_ _01680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09488_ _07368_ _01680_ _07371_ _01681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_09489_ _07368_ _07370_ _07367_ _01682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09490_ _01682_ _01681_ _01683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09491_ _01683_ _01670_ _01684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_09492_ _01684_ _01586_ _01669_ _01685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09493_ _01683_ _00574_ _01281_ _01686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09494_ _01668_ _01686_ _01586_ _01687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09495_ _01666_ _01667_ _01687_ _01685_ _01688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09496_ _01083_ _01040_ _07237_ _07256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09497_ _07260_ _07258_ _07259_ _01689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09498_ _01021_ _01689_ _01690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09499_ _07256_ _01690_ _01187_ _07261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09500_ _07263_ _01159_ _01691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09501_ _07261_ _01691_ _01381_ _07290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09502_ _07292_ _01286_ _01692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09503_ _07290_ _01692_ _01491_ _07307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09504_ _07311_ _01406_ _01693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09505_ _07309_ _01693_ _01694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09506_ _07307_ _01694_ _01487_ _07324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09507_ _07324_ _01695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09508_ _07326_ _01510_ _01696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09509_ _01695_ _01696_ _01633_ _01697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09510_ _01586_ _01697_ _01686_ _01698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09511_ _01697_ _07343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09512_ _01586_ _07343_ _01684_ _01699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09513_ _01645_ _01607_ _01634_ _01700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09514_ _01698_ _01699_ _01660_ _01700_ _01701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09515_ _01701_ _01688_ _01702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_09516_ _01640_ _01643_ _01645_ _01703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09517_ _01601_ _01646_ _01647_ _01704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09518_ _01703_ _01639_ _01704_ _01705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09519_ _01311_ _01642_ _01532_ _01706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09520_ net13 _01592_ _01707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09521_ _01342_ net38 _01591_ _01420_ _01593_ _01708_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_09522_ _01516_ _01520_ _01709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09523_ _01446_ _01477_ _01526_ _01710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09524_ _01489_ net22 _01709_ _01710_ _01711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09525_ _01707_ _01708_ _01711_ _01712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_09526_ _01706_ _01712_ _01713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09527_ _01600_ _01590_ _01714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09528_ _01646_ _01647_ _01714_ _01715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09529_ _01538_ _01706_ _01716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09530_ _01713_ _01715_ _01716_ _01717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09531_ _01646_ _01647_ _01714_ _01712_ _01706_ _01718_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_09532_ _01718_ _01719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09533_ _01601_ _01713_ _01715_ _01720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09534_ _01705_ _01717_ _01719_ _01720_ _01721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09535_ _01665_ _01702_ _01721_ _01722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09536_ _01668_ _01684_ _01723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09537_ _01669_ _01686_ _01724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09538_ _01660_ _01700_ _01723_ _01724_ _01725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_09539_ _07343_ _01686_ _01726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09540_ _01697_ _01684_ _01727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09541_ _01726_ _01727_ _01666_ _01667_ _01728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09542_ _01725_ _01728_ _01658_ _01729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09543_ _01651_ _01722_ _01729_ _01664_ _01730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09544_ _01725_ _01728_ _01731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09545_ _01660_ _01700_ _01655_ _01732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09546_ _01653_ _01732_ _01733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09547_ _01646_ net30 _01734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09548_ _01580_ _01666_ _01735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09549_ _01646_ net30 _01736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09550_ _01734_ _01735_ _01736_ _01737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09551_ _01731_ _01733_ _01737_ _01738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09552_ _01645_ _01660_ _01715_ _01713_ _01739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_09553_ _01718_ _01739_ _01740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09554_ _01718_ _01739_ _01741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09555_ _01731_ _01665_ _01741_ _01717_ _01705_ _01742_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_09556_ _01664_ _01729_ _01743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09557_ _01740_ _01742_ _01743_ _01744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09558_ _01730_ _01738_ _01744_ _01745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09559_ _01638_ _01650_ _01746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_09560_ _01702_ _01665_ _01721_ _01747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_09561_ _01747_ _01748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09562_ _07385_ _01749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09563_ _07388_ _07387_ _07386_ _01750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09564_ _01750_ _01749_ _01751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09565_ _07383_ _01751_ _01752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09566_ _01752_ _07382_ _01753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09567_ _07400_ _01753_ _01754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09568_ _01754_ _07399_ _01755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09569_ _07397_ _01755_ _01756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09570_ _01756_ _07396_ _01757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09571_ _07394_ _01757_ _01758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09572_ _01758_ _07393_ _01759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09573_ _01759_ _07391_ _07390_ _01760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09574_ _01670_ _01760_ _01761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09575_ _01667_ _01666_ _01762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09576_ _07348_ _01616_ _01763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09577_ _07260_ _01198_ _07264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09578_ _07266_ _07274_ _07273_ _01764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09579_ _01158_ _01764_ _01765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09580_ _07264_ _01765_ _01381_ _07293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09581_ _07295_ _01284_ _01766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09582_ _07293_ _01766_ _01491_ _07310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09583_ _07312_ _01405_ _01767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09584_ _07310_ _01767_ _01487_ _07327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09585_ _07329_ _01508_ _01768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09586_ _07327_ _01768_ _01633_ _07346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09587_ _01666_ _01667_ _07346_ _01769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09588_ _01762_ _01763_ _01769_ _01770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09589_ _01660_ _01700_ _01668_ _01771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09590_ _01660_ _01700_ _07343_ _01772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09591_ _01771_ _01772_ _01773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09592_ _01761_ _01770_ _01773_ _01774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09593_ _01770_ _07366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09594_ _01760_ _00574_ _01775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09595_ _01775_ _01281_ _01776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09596_ _07366_ _01776_ _01777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09597_ _01746_ _01748_ _01774_ _01777_ _01778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_09598_ _00574_ _01683_ _01779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09599_ _01779_ _01780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09600_ _01771_ _01772_ _01780_ _01781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09601_ _01771_ _01772_ _01780_ _01782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09602_ _07377_ _07379_ _01783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09603_ _07376_ _01783_ _07374_ _01784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09604_ _01671_ _01784_ _01785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09605_ _07371_ _07374_ _07377_ _07380_ _01786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09606_ _07371_ _01785_ _01786_ _01674_ _07370_ _01787_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_09607_ _07368_ _01787_ _01788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09608_ _01761_ _01776_ _01788_ _01789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09609_ _01789_ _01782_ _01781_ _01790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09610_ _01731_ _01733_ _01791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09611_ _01791_ _01790_ _01792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09612_ _01792_ _01778_ _01793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09613_ _01745_ _01793_ _01794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09614_ _01665_ _01721_ _01795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09615_ _01771_ _01772_ _01796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09616_ _01670_ _01668_ _01797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09617_ _00574_ _01669_ _01798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09618_ _01660_ _01700_ _01797_ _01798_ _01799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_09619_ _00574_ _07343_ _01800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09620_ _01670_ _01697_ _01801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09621_ _01800_ _01801_ _01666_ _01667_ _01802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09622_ _01799_ _01802_ _01803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09623_ _07368_ _07371_ _01680_ _01804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09624_ _01804_ _01653_ _01655_ _01805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09625_ _01666_ _01667_ _01805_ _01806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09626_ _01660_ _01700_ _01681_ _01653_ _01807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_09627_ _01681_ _01653_ _01655_ _01682_ _01808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09628_ _01806_ _01807_ _01808_ _01809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09629_ _01281_ _01796_ _01803_ _01809_ _01810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_09630_ _01636_ _01637_ _01811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09631_ _01584_ _01812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09632_ _01581_ _01704_ _01813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09633_ _01437_ _01599_ _01814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09634_ _01576_ _01598_ _01815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09635_ _01581_ _01583_ _01704_ _01814_ _01815_ _01816_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_09636_ _01812_ _01813_ _01816_ _01597_ _01817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09637_ _01531_ _01575_ _01585_ _01818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09638_ _01644_ _01818_ _01648_ _01819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09639_ _01586_ _01704_ _01820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09640_ _01636_ _01819_ _01820_ _01821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09641_ _01811_ _01817_ _01821_ _01822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09642_ _01581_ _01704_ _01823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09643_ _01551_ _01815_ _01814_ _01824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09644_ _01582_ _01584_ _01824_ _01825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09645_ _01823_ _01825_ _01639_ _01826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09646_ _07365_ _07368_ _01827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09647_ _07363_ _01392_ _01786_ _01827_ _01828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09648_ _01658_ _01799_ _01802_ _01828_ _01829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09649_ _01826_ _01829_ _01830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09650_ _01795_ _01810_ _01822_ _01830_ _01831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09651_ _01815_ _01813_ _01832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09652_ _01551_ _01832_ _01833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09653_ _01582_ _01833_ _01834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09654_ _07388_ _07394_ _07397_ _07400_ _01835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09655_ _07386_ _07391_ _01836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09656_ _07383_ _01392_ _01835_ _01836_ _01837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09657_ _01837_ _01838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09658_ _01670_ _01770_ _01839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09659_ _01838_ _01839_ _01746_ _01748_ _01840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_09660_ _01670_ _01788_ _01841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09661_ _01837_ _01841_ _01842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09662_ _01651_ _01722_ _01842_ _01843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09663_ _01831_ _01834_ _01840_ _01843_ _01844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09664_ _01636_ _01820_ _01845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09665_ _01795_ _01810_ _01845_ _01846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09666_ _01651_ _01748_ _01638_ _01847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09667_ _01832_ _01816_ _01597_ _01848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09668_ _01645_ _01704_ _01818_ _01649_ _01849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09669_ _01722_ _01848_ _01849_ _01850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09670_ _01702_ _01826_ _01851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09671_ _01748_ _01848_ _01851_ _01795_ _01819_ _01852_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_09672_ _01846_ _01847_ _01850_ _01852_ _01853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_09673_ _01844_ _01853_ _01854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09674_ _07391_ _01759_ _01855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09675_ _07403_ _07414_ _07417_ _07420_ _01856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09676_ _07411_ _07406_ _07409_ _01857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09677_ _01392_ _01856_ _01857_ _01858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09678_ _01670_ _01858_ _01859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09679_ _01846_ _01847_ _01860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09680_ _01855_ _01859_ _01860_ _01861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09681_ _01730_ _01738_ _01744_ _01862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09682_ _01778_ _01792_ _01863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09683_ _01855_ _01859_ _01864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09684_ _01811_ _01650_ _01865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09685_ _01811_ _01865_ net27 _01866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09686_ _01864_ _01866_ _01867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09687_ _01862_ _01863_ _01867_ _01868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09688_ _01794_ _01854_ _01861_ _01868_ _01869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09689_ _07391_ _01759_ _01870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09690_ _00574_ _01858_ _01871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09691_ _01870_ _01871_ _01872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09692_ _01279_ _01277_ _07274_ _07296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09693_ _07300_ _07298_ _07299_ _01873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09694_ _01283_ _01873_ _01874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09695_ _07296_ _01874_ _01491_ _07313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09696_ _07315_ _01403_ _01875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09697_ _07313_ _01875_ _01487_ _07330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09698_ _07332_ _01506_ _01876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09699_ _07330_ _01876_ _01633_ _07349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09700_ _07351_ _01614_ _01877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09701_ _07349_ _01877_ _01762_ _07369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09702_ _07371_ _01680_ _01878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09703_ _01746_ _01747_ _01879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09704_ _07369_ _01878_ _01879_ _01880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09705_ _01880_ _07389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09706_ _01859_ _01871_ _07389_ _01881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09707_ _01745_ _01793_ _01844_ _01853_ _01882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_09708_ _01872_ _01881_ _01882_ _01883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09709_ _01817_ _01830_ _01819_ _01884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09710_ _01819_ _01817_ _01885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09711_ _01665_ _01702_ _01721_ _01638_ _01886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09712_ _01884_ _01885_ _01886_ _01887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09713_ _01746_ _01748_ _01888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09714_ _01888_ _01790_ _01778_ _01889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09715_ _01651_ _01722_ _01791_ _01890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09716_ _01730_ _01738_ _01744_ _01890_ _01891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09717_ _01889_ _01860_ _01891_ _01892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09718_ _01844_ _01887_ _01893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09719_ _01811_ _01821_ _01894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09720_ _01795_ _01810_ _01894_ _01848_ _01895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09721_ _01831_ _01895_ _01896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09722_ _01826_ _01829_ _01819_ _01897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09723_ _01897_ _01819_ _01886_ _01898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09724_ _01778_ _01792_ _01898_ _01899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09725_ _01745_ _01860_ _01896_ _01899_ _01900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09726_ _01887_ _01892_ _01893_ _01900_ _01901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09727_ _01831_ _01834_ _01902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09728_ _01889_ _01860_ _01887_ _01891_ _01903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09729_ _01638_ _01846_ _01904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09730_ _01902_ _01903_ _01904_ _01847_ _01905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_09731_ _01869_ _01883_ _01901_ _01905_ _01906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_09732_ _01745_ _01793_ _01907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09733_ _01746_ net27 _01788_ _01908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09734_ _01746_ net27 _01770_ _01909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09735_ _01908_ _01909_ _01910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09736_ _01907_ _01854_ _01910_ _01911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09737_ _01796_ _01909_ _01912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09738_ _01888_ _01781_ _01782_ _01788_ _01913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09739_ _01670_ _01914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09740_ _01912_ _01913_ _01914_ _01760_ _01915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09741_ _00977_ _01760_ _01916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09742_ _01670_ _01760_ _01917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09743_ _01916_ _01917_ _01770_ _01918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09744_ _01917_ _01916_ _01788_ _01919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09745_ _01918_ _01919_ _01879_ _01920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09746_ _01281_ _01775_ _01921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09747_ _01670_ _01760_ _01922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09748_ _01921_ _01908_ _01909_ _01922_ _01923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_09749_ _01746_ net27 _01780_ _01924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09750_ _01773_ _01924_ _01925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09751_ _01920_ _01923_ _01925_ _01926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09752_ _01915_ _01926_ _01927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09753_ _01793_ _01745_ _01844_ _01853_ _01928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_09754_ _01725_ _01728_ _01658_ _01929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09755_ _01781_ _01782_ _01789_ _01929_ _01930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09756_ _01790_ _01930_ _01738_ _01931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09757_ _01791_ _01931_ _01879_ _01932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09758_ _01778_ _01932_ _01933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09759_ _01928_ _01933_ _01934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09760_ _01844_ _01853_ _01891_ _01935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_09761_ _01730_ _01743_ _01936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09762_ _01653_ _01732_ _01937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09763_ _01799_ _01802_ _01938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09764_ _01806_ _01807_ _01808_ _01939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09765_ _01626_ _01773_ _01938_ _01939_ _01940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09766_ _01734_ _01735_ _01941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09767_ _01937_ _01940_ _01941_ _01736_ _01942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09768_ _01778_ _01792_ _01942_ _01943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09769_ _01936_ _01943_ _01944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09770_ _01741_ _01730_ _01945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09771_ _01935_ _01944_ _01945_ _01946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09772_ _01911_ _01927_ _01934_ _01946_ _01947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09773_ _01651_ net27 _01948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09774_ _01846_ _01948_ _01949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09775_ _01844_ _01853_ _01950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09776_ _01740_ _01730_ _01743_ _01738_ _01951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09777_ _01665_ _01702_ _01651_ _01952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09778_ _01795_ _01810_ _01952_ _01953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09779_ _01951_ _01793_ _01953_ _01742_ _01954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09780_ _01907_ _01950_ _01954_ _01955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09781_ _01949_ _01955_ _01956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09782_ _07408_ _01957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09783_ _07411_ _07410_ _07409_ _01958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09784_ _01957_ _01958_ _01959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09785_ _01959_ _07406_ _01960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09786_ _01960_ _07405_ _01961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09787_ _07403_ _01961_ _01962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09788_ _01962_ _07402_ _01963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09789_ _07420_ _01963_ _01964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09790_ _07419_ _01964_ _01965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09791_ _07417_ _01965_ _01966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09792_ _01966_ _07416_ _01967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09793_ _07414_ _01967_ _01968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09794_ _07413_ _01968_ _01969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_09795_ _01914_ _07389_ _01969_ _01970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09796_ _01914_ _01870_ _01969_ _01971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09797_ _01970_ _01971_ _01928_ _01972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09798_ _07413_ _01968_ _01973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09799_ _01914_ _01973_ _01974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09800_ _01974_ _07389_ _01975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09801_ _01870_ _01974_ _01976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09802_ _01975_ _01976_ _01928_ _01977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09803_ _01626_ _01870_ _01978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09804_ _01626_ _07389_ _01979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09805_ _01978_ _01979_ _01882_ _01980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09806_ _01972_ _01980_ _01977_ _01981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_09807_ _01981_ _01947_ _01956_ _01906_ _01982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09808_ _01982_ _01983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_09809_ _07411_ _01983_ _07430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_09810_ _07434_ _07433_ _07432_ _01984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09811_ _07434_ _07432_ _07433_ _01985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09812_ _01984_ _01985_ _01986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09813_ _01906_ _01947_ _01956_ _01987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09814_ _01936_ _01943_ _01988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09815_ _01928_ _01989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09816_ _01933_ _01988_ net17 _01990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09817_ _01911_ _01927_ _01990_ _01991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09818_ _01945_ _01992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09819_ _01936_ _01943_ _01992_ _01993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09820_ _01936_ _01935_ _01943_ _01992_ _01994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09821_ _01742_ _01953_ _01995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09822_ _01951_ _01793_ _01996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09823_ _01846_ _01948_ _01997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09824_ _01745_ _01793_ _01997_ _01998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09825_ _01995_ _01996_ _01998_ _01854_ _01866_ _01999_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_09826_ _01993_ _01994_ _01999_ _02000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09827_ net20 _01991_ _02000_ _02001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_09828_ _01831_ _01895_ _02002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09829_ _01844_ _02002_ _02003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09830_ _01889_ _01860_ _01891_ _02004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09831_ _01898_ _02004_ _02005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09832_ _02002_ _02003_ _02005_ _02006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09833_ _01987_ _02001_ _02006_ _02007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09834_ _01987_ _02006_ _02001_ _02008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09835_ _01908_ _01909_ _02009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_09836_ _01794_ _01950_ _02009_ _02010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09837_ _01915_ _01926_ _02011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09838_ _02010_ _02011_ _02012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09839_ _01972_ _01977_ _01980_ _02013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_09840_ _01890_ _02012_ _02013_ _02014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09841_ _01738_ _01935_ _02015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09842_ _01879_ _01729_ _01942_ _02016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09843_ _02015_ _02016_ _01863_ _02017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09844_ _01889_ _01890_ _02018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09845_ _01793_ _01935_ _02018_ _02019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09846_ _02017_ _02019_ _02020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09847_ _01987_ _02014_ _02020_ _02021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09848_ _01993_ _01994_ _02022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09849_ _01911_ _01927_ _01934_ _02023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09850_ _02023_ net20 _01944_ _01935_ _02024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09851_ _01955_ _02022_ _02024_ _02025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09852_ _02007_ _02008_ _02021_ _02025_ _02026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09853_ _01902_ _01903_ _02027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_09854_ _01898_ _02004_ _02028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09855_ _01950_ _02005_ _02028_ _02029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09856_ _01901_ _01981_ _01991_ _02000_ _02030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09857_ _02027_ _02029_ _02030_ _01987_ _02031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09858_ _02009_ _01922_ _02032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09859_ _01870_ _01882_ _02032_ _02033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09860_ net17 _07389_ _02009_ _02033_ _02034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_09861_ _01914_ _01969_ _02035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09862_ _00758_ _01973_ _02036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09863_ _01980_ _02035_ _02036_ _01972_ _02037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09864_ _02013_ _02034_ _02038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09865_ _01869_ _01883_ _01901_ _01905_ _02039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09866_ _01844_ _01853_ _01891_ _02040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09867_ _01936_ _01943_ _02041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09868_ _02040_ _02041_ _01992_ _02042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09869_ _02010_ _02011_ _01933_ net17 _02042_ _02043_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_09870_ _01949_ _02039_ _02043_ _01955_ _02044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_09871_ _07389_ _02045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09872_ _01855_ _02045_ _01882_ _02046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09873_ _00575_ _01969_ _02047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09874_ _01922_ _02048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09875_ _01928_ _02048_ _02049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09876_ _01281_ _01910_ _02050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09877_ _02049_ _02050_ _02051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09878_ _01914_ _01969_ _02052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09879_ _07389_ _01910_ _02053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09880_ _01855_ _02048_ _02054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09881_ _01855_ _01922_ _02055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09882_ _02054_ _02055_ _02009_ _02056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09883_ _02053_ _02056_ net17 _02057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09884_ _07389_ _01910_ _02058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09885_ _01870_ _02048_ _02059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09886_ _01870_ _01922_ _02060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09887_ _02059_ _02060_ _01910_ _02061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09888_ _02058_ _02061_ net17 _02062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09889_ _02052_ _02057_ _02062_ _01974_ _02063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_09890_ _02046_ _02047_ _02051_ _02063_ _02064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09891_ _02034_ _02037_ _02038_ _02044_ _02064_ _02065_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_09892_ _01981_ _01991_ _02000_ _02066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09893_ _01907_ _01949_ _01950_ _02067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09894_ _01866_ _02067_ _02068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09895_ _02039_ _01991_ _02000_ _02069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09896_ _01949_ _02043_ _01955_ _02013_ _02070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09897_ _02066_ _02068_ _02069_ _02070_ _02071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09898_ _02039_ _01947_ _01956_ net20 _02072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_09899_ _01907_ _01949_ _02073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09900_ _01950_ _02073_ _02074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09901_ _07413_ _01911_ _01927_ _02075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09902_ _01972_ _01977_ _02076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09903_ _02075_ _01997_ _02076_ _02077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09904_ _02043_ _01955_ _01980_ _02078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09905_ _02072_ _02074_ _02077_ _02078_ _02079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09906_ _02031_ _02065_ _02071_ _02079_ _02080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_09907_ _02012_ _02013_ _02081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09908_ _02009_ _02049_ _02082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09909_ _01761_ _01776_ _02009_ _02083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09910_ _01796_ _01924_ _02084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09911_ _01889_ _01935_ _02083_ _02084_ _02085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_09912_ _02082_ _02013_ _02085_ _02086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09913_ _01987_ _02081_ _02086_ _02087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_09914_ _07414_ _01967_ _02088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_4
X_09915_ _01342_ _01344_ _07300_ _07316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_09916_ _07320_ _07318_ _07319_ _02089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09917_ _01402_ _02089_ _02090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09918_ _07316_ _02090_ _01487_ _07333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09919_ _07335_ _01504_ _02091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09920_ _07333_ _02091_ _01633_ _07352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09921_ _07354_ _01612_ _02092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09922_ _07352_ _02092_ _01762_ _07372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09923_ _07374_ _01678_ _02093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09924_ _07372_ _02093_ _01879_ _07392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09925_ _07392_ _02094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09926_ _07394_ _01757_ _02095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09927_ _02094_ _02095_ _01989_ _02096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09928_ _02039_ _02096_ _02097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09929_ _01947_ _01956_ _01981_ _02098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09930_ _01983_ _02088_ _02097_ _02098_ _01626_ _02099_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_09931_ _07414_ _01967_ _02100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09932_ _07439_ _02101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09933_ _07431_ _02102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09934_ _01984_ _02102_ _02103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09935_ _07429_ _02103_ _02104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09936_ _02104_ _07428_ _02105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09937_ _02105_ _07426_ _02106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09938_ _02106_ _07425_ _02107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09939_ _02107_ _07423_ _02108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09940_ _02108_ _07422_ _02109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09941_ _02109_ _07440_ _02110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09942_ _02101_ _02110_ _02111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_09943_ _02111_ _07437_ _02112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09944_ _02112_ _07436_ _02113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_09945_ _00574_ _02113_ _02114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_09946_ _02114_ _02100_ _02115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09947_ _02114_ _02096_ _02116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09948_ _02115_ _02116_ _01982_ _02117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09949_ _01914_ _02113_ _02118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09950_ _01982_ _02088_ _02097_ _02098_ _02118_ _02119_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_09951_ _02087_ _02099_ _02119_ _02117_ _02120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_09952_ _02120_ _02080_ _02026_ _02121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
Xclone40 _02120_ _02080_ _02026_ net40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_09954_ _07430_ _01986_ _02121_ _07450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09955_ _07454_ _02123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09956_ _07457_ _07456_ _07455_ _02124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09957_ _02123_ _02124_ _02125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09958_ _07452_ _02125_ _02126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_09959_ _02026_ _02127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09960_ _02080_ _02128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_09961_ _02087_ _02099_ _02129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09962_ _01914_ _02130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_09963_ _02100_ _02096_ net9 _02131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_09964_ _02130_ _02131_ _02113_ _02132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09965_ _02127_ _02128_ _02129_ _02132_ _02133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_09966_ _01866_ _02067_ _02134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09967_ _02039_ _01991_ _02000_ _02135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_09968_ _02001_ _02134_ _02135_ _02098_ _02136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_09969_ _01955_ _02137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09970_ _02076_ _02075_ _01980_ _02043_ _02138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09971_ _01949_ _02013_ _02139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09972_ _02039_ _01947_ _01956_ net20 _02140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_09973_ _01950_ _02073_ _02141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09974_ _02137_ _02138_ _02139_ _02140_ _02141_ _02142_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_09975_ _02136_ _02142_ _02143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_09976_ _02006_ _02144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_09977_ _02044_ _02066_ _02144_ _02145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_09978_ _02044_ _02144_ _02066_ _02146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_09979_ _01890_ _02012_ _02147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09980_ _01906_ _01947_ _01956_ _02013_ _02148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_09981_ _01955_ _02022_ _02017_ _02019_ _02149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_09982_ _02147_ _02148_ _02024_ _02149_ _02150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09983_ _02029_ _02151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09984_ _02145_ _02146_ _02150_ _02151_ _02152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_09985_ _02013_ _02034_ _02153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09986_ _02046_ _02047_ _02154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09987_ _02049_ _02050_ _02155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_09988_ _02154_ _02155_ _02057_ _02052_ _01974_ _02062_ _02156_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_4
X_09989_ _02034_ _02037_ _02157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_09990_ _01987_ _02153_ _02156_ _02157_ _02158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_09991_ _02158_ _02087_ _02099_ _02159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_09992_ _01902_ _01903_ _02160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_09993_ _02096_ _07412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_09994_ _02088_ _07412_ _01983_ _02161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_09995_ _01981_ _01947_ _01956_ _01906_ _02162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_09996_ _02162_ _02030_ _02100_ _02163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_09997_ _02160_ _02161_ _02163_ _02164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_09998_ _02143_ _02152_ _02159_ _02164_ _02165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_09999_ _02161_ _02113_ _02166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10000_ _02100_ _02114_ _02167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10001_ _02096_ _02114_ _02168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10002_ _02167_ _02168_ _01983_ _02169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10003_ _02130_ _02166_ _02169_ _02170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10004_ _02133_ _02165_ _02170_ _02171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10005_ _07451_ _02172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10006_ _07455_ _07456_ _02173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10007_ _07454_ _02173_ _07452_ _02174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10008_ _02172_ _02174_ _02175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10009_ _07449_ _07452_ _07455_ _07457_ _02176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_10010_ _07449_ _02175_ _07448_ _02176_ _02177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10011_ _02177_ _02178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10012_ _02178_ _07446_ _07445_ _02179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10013_ _02179_ _02180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10014_ _07443_ _02180_ _02181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10015_ _02181_ _07442_ _02182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10016_ _02182_ _07460_ _07459_ _02183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10017_ _02183_ _02184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_10018_ _02184_ _00575_ _02185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10019_ _02184_ _01914_ _02186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10020_ _01446_ _07320_ _07336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10021_ _07338_ _07340_ _07339_ _02187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10022_ _01503_ _02187_ _02188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10023_ _07336_ _02188_ _01633_ _07355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10024_ _07357_ _01610_ _02189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10025_ _07355_ _02189_ _01762_ _07375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10026_ _07377_ _01676_ _02190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10027_ _07375_ _02190_ _01879_ _07395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10028_ _07397_ _01755_ _02191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10029_ _07395_ _02191_ _01989_ _07415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10030_ _07417_ _01965_ _02192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10031_ _07415_ _02192_ _02162_ _07435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10032_ _02185_ _02186_ _07435_ _02193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10033_ _01626_ _07435_ _02194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10034_ _02193_ _02194_ _02195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10035_ _01281_ _02196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10036_ _07437_ _02111_ _02197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10037_ _02186_ _02185_ _02197_ _02198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10038_ _02196_ _02197_ _02198_ _02199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10039_ _02195_ _02199_ _02121_ _02200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_10040_ _02200_ _02171_ _02201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10041_ _02201_ _02202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10042_ _01626_ _02118_ _02203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10043_ _02088_ _02203_ _02204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10044_ _07412_ _02203_ _02205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10045_ _02204_ _02205_ _01982_ _02206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10046_ _02158_ _02087_ _02117_ _02206_ _02207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_10047_ _02127_ _02080_ _02207_ _02208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10048_ _02019_ _02209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10049_ _01987_ _02081_ _02210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10050_ _01987_ _02014_ _02211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10051_ _02209_ _02210_ _02211_ _02212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10052_ _02208_ _02212_ _02213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_10053_ _01974_ _02214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10054_ _02214_ _02047_ _02215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10055_ net9 _02215_ _02046_ _02216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_10056_ _02046_ net9 _02215_ _02217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10057_ _02161_ _02203_ _02216_ _02217_ _02169_ _02218_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_10058_ _02127_ _02128_ _02218_ _02219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10059_ _02215_ _02220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10060_ _02162_ _02220_ _02046_ _02221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10061_ _02046_ _02162_ _02220_ _02222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10062_ _02087_ _02221_ _02222_ _02223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10063_ _02216_ _02217_ _02224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10064_ _02117_ _02206_ _02225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10065_ _02223_ _02224_ _02225_ _02226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10066_ _02082_ _02148_ _02227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10067_ _02218_ _02227_ _02228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10068_ _02012_ _02013_ _02229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10069_ _02085_ _02013_ _02230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10070_ _02085_ _02082_ _02044_ _02229_ _02230_ _02231_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_10071_ _02158_ _02117_ _02206_ _02232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10072_ _02127_ _02128_ _02231_ _02232_ _02233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10073_ _02219_ _02226_ _02228_ _02233_ _02234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10074_ _02031_ _02065_ _02071_ _02079_ _02235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10075_ _02145_ _02146_ _02150_ _02231_ _02236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10076_ _02235_ _02236_ _02225_ _02065_ _02237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10077_ _02231_ _02237_ _02238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_10078_ _02213_ _02234_ _02238_ _02239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_10079_ _02145_ _02146_ _02240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10080_ _02021_ _02025_ _02241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10081_ _02240_ _02128_ _02207_ _02241_ _02242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10082_ _01987_ _02001_ _02243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10083_ _02243_ _02244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10084_ _02244_ _02029_ _02245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10085_ _02144_ _02143_ _02242_ _02245_ _02246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_10086_ _02130_ _07435_ _02247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10087_ _07443_ _07446_ _02248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10088_ _07460_ _01392_ _02176_ _02248_ _02249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10089_ _02247_ _02249_ _02250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10090_ _00575_ _02249_ _02197_ _02251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10091_ _02143_ _02152_ _02207_ _02251_ _02252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10092_ _01901_ _01991_ _02000_ _02253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10093_ _02148_ _02253_ _02160_ _02254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_10094_ _02254_ _02251_ _02255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10095_ _02127_ _02128_ _02120_ _02255_ _02256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10096_ _07437_ _02111_ _02257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10097_ _02130_ _02249_ _02257_ _02258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10098_ _02127_ _02128_ _02120_ _02258_ _02259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10099_ net40 _02250_ _02252_ _02256_ _02259_ _02260_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_10100_ _01987_ _02138_ _02261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10101_ _02022_ _02138_ _01983_ _02262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10102_ net20 _01991_ _02261_ _02262_ _02263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10103_ _01955_ _02263_ _02264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10104_ _02242_ _02264_ _02265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10105_ _02127_ _02128_ _02120_ _02266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_10106_ _01991_ _02148_ _02024_ _02267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10107_ _02021_ _02207_ _02267_ _02268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10108_ _02017_ _02209_ _02269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10109_ _02161_ _02118_ _02269_ _02169_ _02270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10110_ _02159_ _02270_ _02271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10111_ _02211_ _02017_ _02272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10112_ _02266_ _02268_ _02271_ _02272_ _02273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_10113_ _02246_ _02260_ _02265_ _02273_ _02274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10114_ _02274_ _02239_ _02202_ _02275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_10115_ _02275_ _02276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10116_ _07450_ _02126_ _02276_ _07470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10117_ _07477_ _02277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10118_ _07480_ _07479_ _07478_ _02278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10119_ _02277_ _02278_ _02279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10120_ _07475_ _02279_ _02280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10121_ _07474_ _02280_ _02281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10122_ _07472_ _02281_ _02282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10123_ _02133_ _02165_ _02170_ _02283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10124_ _02193_ _02194_ _02284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10125_ _02130_ _02184_ _02285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10126_ _02196_ _02257_ _02286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10127_ _02285_ _02227_ _02286_ _02287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10128_ _02197_ _02185_ _02288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10129_ _02088_ _02113_ _02289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10130_ _07412_ _02113_ _02290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10131_ _02289_ _02290_ net9 _02291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10132_ _02216_ _02217_ _02291_ _02286_ _02292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_10133_ _02196_ _02257_ _02293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10134_ _02216_ _02217_ _02291_ _02293_ _02294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10135_ _02287_ _02288_ _02292_ _02294_ _02295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10136_ _02284_ _02295_ net40 _02296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10137_ _02283_ _02234_ _02238_ _02296_ _02297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10138_ _02087_ _02232_ _02208_ _02298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_10139_ _02283_ _02234_ _02296_ _02299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10140_ _02298_ _02299_ _02300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10141_ _02171_ _02200_ _02301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10142_ _02213_ _02234_ _02238_ _02302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10143_ _02246_ _02260_ _02265_ _02273_ _02303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10144_ _02301_ _02302_ _02303_ _02304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_10145_ _02158_ _02087_ _02117_ _02206_ _02305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_10146_ _02267_ _02306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10147_ _02211_ _02020_ _02305_ _02306_ _02307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10148_ _02159_ _02270_ _02272_ _02308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10149_ net40 _02307_ _02308_ _02309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10150_ _02213_ _02297_ _02300_ _02304_ _02309_ _02310_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_10151_ _02239_ _02311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_10152_ _07435_ _02257_ net40 _02312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10153_ _01576_ _01642_ _07340_ _07358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10154_ _07360_ _07342_ _07341_ _02313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10155_ _01609_ _02313_ _02314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10156_ _07358_ _02314_ _01762_ _07378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10157_ _07380_ _01674_ _02315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10158_ _07378_ _02315_ _01879_ _07398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10159_ _07400_ _01753_ _02316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10160_ _07398_ _02316_ _01989_ _07418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10161_ _07418_ _02317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10162_ _07420_ _01963_ _02318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10163_ _02317_ _02318_ _02162_ _02319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10164_ _02127_ _02128_ _02120_ _02319_ _02320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10165_ _07440_ _02109_ _02321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10166_ _02127_ _02128_ _02120_ _02321_ _02322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10167_ _07472_ _02281_ _02323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10168_ _02323_ _07471_ _02324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10169_ _07469_ _02324_ _02325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10170_ _02325_ _07468_ _02326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10171_ _07466_ _02326_ _02327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10172_ _02327_ _07465_ _02328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10173_ _02328_ _07463_ _07462_ _02329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10174_ _02329_ _02330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_10175_ _02330_ _02130_ _02331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10176_ _02320_ _02322_ _02196_ _02331_ _02332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_10177_ _00575_ _02330_ _02322_ _02320_ _02333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_10178_ _02332_ _02312_ _02333_ _02334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_10179_ _02334_ _02311_ _02274_ _02202_ _02335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10180_ _07460_ _02182_ _02336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10181_ _07460_ _02182_ _02337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10182_ _00575_ _02337_ _02338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10183_ _02196_ _02336_ _02338_ _02329_ _02339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_10184_ _00575_ _02183_ _02340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10185_ _02312_ _02340_ _02341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10186_ _02299_ _02339_ _02341_ _02342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10187_ _02246_ _02260_ _02343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10188_ _02242_ _02264_ _02344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10189_ _02344_ _02309_ _02345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10190_ _02343_ _02239_ _02345_ _02301_ _02346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10191_ _02171_ _02200_ _02347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10192_ _02234_ _02347_ _02348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10193_ _02342_ _02335_ _02346_ _02348_ _02349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10194_ _02349_ _02310_ _02350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10195_ _02201_ _02239_ _02345_ _02351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10196_ _02145_ _02146_ _02352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10197_ _02352_ _02235_ _02305_ _02150_ _02353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10198_ _02142_ _02353_ _02354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10199_ _02241_ _02207_ _02355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10200_ _02142_ _02355_ _02356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10201_ _02071_ _02354_ _02356_ _02357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10202_ _02136_ _02142_ _02358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10203_ _02358_ _02242_ _02244_ _02359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10204_ _02143_ _02355_ _02243_ _02029_ _02360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_10205_ _02029_ _02359_ _02360_ _02361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10206_ _02357_ _02361_ _02362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10207_ _02029_ _02353_ _02363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10208_ _02243_ _02029_ _02144_ _02364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10209_ _02363_ _02364_ _02358_ _02365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10210_ _02144_ _02143_ _02242_ _02245_ _02366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10211_ _02366_ _02260_ _02367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10212_ _02201_ _02239_ _02345_ _02367_ _02368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10213_ _02029_ _02359_ _02369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10214_ _02144_ _02369_ _02370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10215_ _02351_ _02362_ _02365_ _02368_ _02370_ _02371_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_10216_ _02357_ _02361_ _02372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10217_ _02354_ _02356_ _02373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10218_ _02071_ _02354_ _02374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10219_ _02373_ _02374_ _02361_ _02375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10220_ _02246_ _02260_ _02344_ _02309_ _02376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10221_ _02201_ _02239_ _02376_ _02377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_10222_ _02372_ _02375_ _02377_ _02378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10223_ _02246_ _02260_ _02265_ _02309_ _02379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10224_ _02117_ _02119_ _02380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10225_ _02127_ _02128_ _02380_ _02381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10226_ _01914_ _02161_ _02382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10227_ _07436_ _07439_ _02383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10228_ _02110_ _02221_ _02222_ _02383_ _02384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10229_ _07437_ _07436_ _02382_ _02384_ _02385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10230_ _02021_ _02159_ _02306_ _02386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10231_ _02381_ _02385_ _02386_ _02387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10232_ _02263_ _02387_ _02388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10233_ _02201_ _02239_ _02379_ _02388_ _02389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10234_ _02246_ _02260_ _02265_ _02390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10235_ _02213_ _02234_ _02238_ _02309_ _02391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_10236_ _02201_ _02388_ _02390_ _02391_ _02392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_10237_ _02143_ _02152_ _02393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10238_ _02393_ _02207_ _02254_ _02394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10239_ _02201_ _02239_ _02345_ _02367_ _02395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10240_ net9 _02138_ _02396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10241_ _02137_ _02396_ _02397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10242_ _02381_ _02385_ _02263_ _02386_ _02398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10243_ _02397_ _02398_ _02242_ _02399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10244_ _02389_ _02392_ _02394_ _02395_ _02399_ _02400_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_10245_ _02371_ _02378_ _02400_ _02401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10246_ _02401_ _02402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_10247_ _02402_ _02350_ _02403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10248_ _02403_ _02404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10249_ _07470_ _02282_ _02404_ _07487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10250_ _07494_ _02405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10251_ _07498_ _07499_ _02406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10252_ _07497_ _02406_ _07495_ _02407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10253_ _02405_ _02407_ _02408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10254_ _07492_ _07495_ _07498_ _07500_ _02409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_10255_ _07492_ _02408_ _07491_ _02409_ _02410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10256_ _07489_ _02410_ _02411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10257_ _02346_ _02347_ _02412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10258_ _02202_ _02311_ _02274_ _02334_ _02413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10259_ _02304_ _02339_ _02341_ _02413_ _02414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10260_ _02412_ _02414_ _02415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10261_ _07463_ _02328_ _02416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10262_ _02416_ _02417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_10263_ _01626_ _02417_ _02418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10264_ _02320_ _02322_ _02419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10265_ _02419_ _02336_ _02275_ _02420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10266_ _02130_ _02329_ _02421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10267_ _02420_ _02421_ _02422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10268_ _02415_ _02418_ _02422_ _02423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10269_ _01666_ _01667_ _07342_ _07361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10270_ _07363_ _07365_ _07364_ _02424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10271_ _01673_ _02424_ _02425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10272_ _07361_ _02425_ _01879_ _07381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10273_ _07383_ _01751_ _02426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10274_ _07381_ _02426_ _01989_ _07401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10275_ _07403_ _01961_ _02427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10276_ _07401_ _02427_ _02162_ _07421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10277_ _07423_ _02107_ _02428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10278_ _07421_ _02428_ _02121_ _07441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10279_ _07441_ _02429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10280_ _07443_ _02179_ _02430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10281_ _02429_ _02430_ _02275_ _02431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10282_ _02431_ _02432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10283_ _02419_ _07458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10284_ _07458_ _02337_ net44 _02433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10285_ _01626_ _02432_ _02433_ _02434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10286_ _02350_ _02402_ _02434_ _02435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10287_ _02332_ _02333_ _02312_ _02436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10288_ _02339_ _02341_ _02437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10289_ _02436_ _02437_ net44 _02438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10290_ _02310_ _02349_ _02439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10291_ _02439_ _02440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10292_ _02371_ _02378_ _02400_ _02441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_10293_ _02440_ _02441_ _02414_ _02442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_10294_ _02423_ _02435_ _02438_ _02442_ _02443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10295_ _02410_ _02444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10296_ _02444_ _07489_ _07488_ _02445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10297_ _02445_ _02446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10298_ _07486_ _02446_ _02447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10299_ _02447_ _07485_ _02448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10300_ _07483_ _02448_ _02449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10301_ _02449_ _07482_ _02450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10302_ _00575_ _02450_ _02451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10303_ _02416_ _02451_ _02452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10304_ _02130_ _02450_ _02453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10305_ _02416_ _02453_ _02454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10306_ _02440_ _02441_ _02454_ _02452_ _02455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_10307_ _02432_ _02451_ _02456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10308_ _02432_ _02453_ _02457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10309_ _02456_ _02457_ _02350_ _02402_ _02458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10310_ _02458_ _02455_ _02459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10311_ _02350_ _02402_ _02460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10312_ _02202_ _02311_ _02303_ _02297_ _02213_ _02461_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_10313_ _02235_ _02236_ _02462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10314_ _02021_ _02207_ _02463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10315_ _02462_ _02463_ _02308_ _02464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10316_ net43 _02311_ _02303_ _02464_ _02465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10317_ net43 _02311_ _02303_ _02464_ _02466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10318_ _02465_ _02466_ _02467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10319_ net44 _02299_ _02468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10320_ _02298_ _02349_ _02468_ _02469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10321_ _02349_ _02468_ _02298_ _02470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10322_ _02461_ _02467_ _02469_ _02470_ _02471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10323_ _02218_ _02227_ _02472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10324_ _02219_ _02226_ _02473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10325_ _02473_ _02474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10326_ _02472_ _02237_ _02346_ _02474_ _02475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_10327_ _02473_ _02346_ _02476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10328_ _02468_ _02475_ _02476_ _02477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10329_ _02460_ _02471_ _02477_ _02478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_10330_ _02389_ _02392_ _02479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10331_ _02310_ _02349_ _02479_ _02480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10332_ _02263_ _02387_ _02481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10333_ _02298_ _02273_ _02399_ _02481_ _02482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10334_ _02242_ _02397_ _02483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10335_ _02263_ _02483_ _02484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10336_ _02397_ _02485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10337_ _02387_ _02485_ _02486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10338_ net43 _02311_ _02379_ _02486_ _02353_ _02487_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_10339_ net43 _02311_ _02265_ _02379_ _02488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10340_ _02484_ _02487_ _02488_ _02489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10341_ _02349_ _02461_ _02482_ _02489_ _02490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10342_ _02440_ _02441_ _02480_ _02490_ _02491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_10343_ _02306_ _02463_ _02387_ _02492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10344_ _02301_ _02302_ _02274_ _02464_ _02493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10345_ _02492_ _02493_ _02494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10346_ _02346_ _02348_ _02495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10347_ _02298_ _02461_ _02496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10348_ _02465_ _02466_ _02389_ _02392_ _02497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_10349_ _02495_ _02414_ _02496_ _02497_ _02498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_10350_ _02373_ _02377_ _02499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10351_ _02494_ _02498_ _02499_ _02500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10352_ _02491_ _02500_ _02501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10353_ _02459_ _02443_ _02478_ _02501_ _02502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10354_ _07463_ _02328_ _02503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10355_ _07483_ _07486_ _01392_ _02409_ _02504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10356_ _07489_ _07177_ _02504_ _02505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10357_ _02503_ _02505_ _02506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10358_ _02130_ _02507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_10359_ _07489_ _02507_ _02504_ _02508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10360_ _02417_ _02508_ _02509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10361_ _02440_ _02441_ _02506_ _02509_ _02510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_10362_ _02432_ _07461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_10363_ _07461_ _02508_ _02511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10364_ _02431_ _02505_ _02512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10365_ _02511_ _02512_ _02350_ _02402_ _02513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10366_ _02510_ _02513_ _02514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10367_ _02399_ _02515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10368_ _02371_ _02378_ _02515_ _02479_ _02516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_10369_ _02343_ _02311_ _02345_ _02517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10370_ _02299_ _02339_ _02341_ _02518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10371_ _02234_ _02347_ _02519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10372_ _02301_ _02517_ _02413_ _02518_ _02519_ _02520_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_10373_ _02461_ _02482_ _02521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10374_ _02520_ _02378_ _02521_ _02522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10375_ _02440_ _02516_ _02402_ _02522_ _02371_ _02523_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_10376_ _02373_ _02377_ _02524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10377_ _07177_ _02276_ _07458_ _02525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10378_ _07463_ _07480_ _07466_ _07469_ _02526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10379_ _07472_ _07475_ _07478_ _02527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10380_ _01392_ _02374_ _02526_ _02527_ _02528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_10381_ _00575_ _07458_ _02529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10382_ _02301_ _02302_ _02303_ _02529_ _02530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10383_ net44 _02338_ _02528_ _02530_ _02531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10384_ _02524_ _02525_ _02531_ _02532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10385_ _02520_ _02521_ _02533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10386_ _02071_ _02354_ _02356_ _02534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10387_ _02402_ _02532_ _02533_ _02534_ _02535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10388_ _02136_ _02461_ _02356_ _02482_ _02536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10389_ net43 _02311_ _02376_ _02242_ _02537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10390_ _02071_ _02142_ _02537_ _02538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10391_ _02142_ _02537_ _02071_ _02539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10392_ _02520_ _02536_ _02538_ _02539_ _02540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10393_ _02395_ _02394_ _02541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10394_ _02202_ _02311_ _02534_ _02376_ _02542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10395_ _02361_ _02542_ _02543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10396_ _02541_ _02543_ _02544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10397_ _02540_ _02544_ _02545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10398_ _02523_ _02535_ _02545_ _02546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_10399_ _02514_ _02546_ _02547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10400_ _02547_ _02502_ _02548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10401_ _02548_ _02549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10402_ _02549_ _02550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_10403_ _07487_ _02411_ _02550_ _07506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10404_ _07519_ _02551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10405_ _07502_ _07501_ _07520_ _02552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10406_ _02551_ _02552_ _02553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10407_ _07517_ _02553_ _02554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10408_ _02554_ _07516_ _02555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10409_ _02555_ _07514_ _02556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10410_ _02556_ _07513_ _02557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10411_ _02557_ _07511_ _02558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10412_ _02558_ _07510_ _02559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10413_ _07508_ _02559_ _02560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10414_ _02443_ _02459_ _02478_ _02501_ _02561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_10415_ _02514_ _02546_ _02562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10416_ _02443_ _02459_ _02563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10417_ _02561_ _02562_ _02477_ _02563_ _02564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10418_ _02130_ _02450_ _02565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10419_ _02196_ _02565_ _02566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10420_ _02417_ _02566_ _02567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10421_ _02440_ _02441_ _02452_ _02567_ _02568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_10422_ _07461_ _02566_ _02569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10423_ _02456_ _02569_ net4 _02402_ _02570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10424_ _02568_ _02570_ _02571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10425_ _02438_ _02442_ _02572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10426_ _02421_ _02415_ _02573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10427_ net24 _02573_ _02433_ _02574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10428_ _07177_ _02329_ _02575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10429_ net25 _02433_ _02575_ _02415_ _02576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10430_ _02574_ _02576_ _02476_ _02577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10431_ _02468_ _02475_ _02578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10432_ _02473_ _02412_ _02414_ _02403_ _02579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10433_ _02578_ _02579_ _02580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10434_ _02571_ _02572_ _02577_ _02580_ _02581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10435_ _02418_ _02422_ _02582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10436_ net25 _02582_ _02435_ _02583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10437_ _02438_ _02442_ _02584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10438_ _02583_ net15 _02584_ _02585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10439_ _02584_ _02583_ net15 _02586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10440_ _02561_ _02562_ _02585_ _02586_ _02587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10441_ _02414_ _02442_ _02412_ _02588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10442_ _02476_ _02588_ _02589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10443_ _02564_ _02581_ _02587_ _02589_ _02590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_10444_ _01888_ _07365_ _07384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10445_ _07388_ _07386_ _07387_ _02591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10446_ _01750_ _02591_ _02592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10447_ _07384_ _02592_ _01989_ _07404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10448_ _07406_ _01959_ _02593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10449_ _07404_ _02593_ _02162_ _07424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10450_ _07426_ _02105_ _02594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10451_ _07424_ _02594_ _02121_ _07444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10452_ _07446_ _02177_ _02595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10453_ _07444_ _02595_ _02276_ _07464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10454_ _07464_ _02596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10455_ _07466_ _02326_ _02597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10456_ _02596_ _02597_ _02403_ _02598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_10457_ _02507_ _02598_ _02599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10458_ _07508_ _02559_ _02600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10459_ _02600_ _07507_ _02601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10460_ _02601_ _07505_ _02602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10461_ _07504_ _02602_ _02603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10462_ _02196_ _02598_ _02599_ _02603_ _02604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_10463_ _02452_ _02605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10464_ _02417_ _02453_ _02606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10465_ net4 _02402_ _02605_ _02606_ _02607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_10466_ _07461_ _02451_ _02608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10467_ _07461_ _02453_ _02609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10468_ _02608_ _02609_ _02440_ _02441_ _02610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_10469_ _07482_ _02449_ _02611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10470_ _00758_ _02611_ _02612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10471_ _02417_ _02612_ _02613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10472_ _02607_ _02610_ _02613_ _02421_ _02433_ _02614_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_10473_ _07461_ _02612_ _02615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10474_ _02460_ _02455_ _02458_ _02615_ _02616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10475_ net25 _02575_ _02420_ _02617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10476_ net24 _02614_ _02616_ _02617_ _02618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10477_ _02460_ _02619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10478_ _02619_ _02431_ _02420_ _02620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10479_ net24 _02503_ _02422_ _02621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10480_ _00575_ _02611_ _02622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10481_ _02565_ _02622_ _02623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10482_ _07461_ _02623_ _02624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10483_ _02403_ _02420_ _02624_ _02625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10484_ _02417_ _02623_ _02626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10485_ _02460_ _02422_ _02626_ _02627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10486_ _02625_ _02627_ _02571_ _02628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10487_ _02618_ _02620_ _02621_ _02628_ _02629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10488_ _02602_ _07504_ _02630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10489_ _07483_ _02448_ _02631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_10490_ _07177_ _02631_ _02632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10491_ _02196_ _02631_ _02633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10492_ _02632_ _02630_ _02633_ _02634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10493_ _02561_ _02562_ _02618_ _02628_ _02634_ _02635_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_10494_ _02548_ _02604_ _02629_ _02635_ _02636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10495_ _02636_ _02637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10496_ _02637_ _02590_ _02638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10497_ _02440_ _02516_ _02639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10498_ _02541_ _02639_ _02640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10499_ _02371_ _02522_ _02641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10500_ _02404_ _02639_ _02641_ _02642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10501_ _02535_ _02540_ _02643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10502_ _02642_ _02543_ _02643_ _02644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10503_ _02478_ _02501_ _02645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10504_ _02563_ _02644_ _02645_ _02562_ _02646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10505_ _02461_ _02469_ _02470_ _02647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10506_ _02477_ _02415_ _02418_ _02422_ _02648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10507_ _02647_ _02648_ _02435_ _02649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10508_ _02495_ _02414_ _02496_ _02650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_10509_ net4 _02402_ _02650_ _02467_ _02651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_10510_ _02650_ _02467_ _02651_ _02652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10511_ _02572_ _02459_ _02649_ _02652_ _02653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10512_ _02572_ _02459_ _02652_ _02649_ _02654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10513_ _02561_ _02562_ _02653_ _02654_ _02655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10514_ _02640_ _02646_ _02655_ _02642_ _02656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10515_ _02650_ _02619_ _02657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10516_ _02473_ _02238_ _02412_ _02414_ _02658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10517_ _02461_ _02659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10518_ _02578_ _02658_ _02659_ _02660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10519_ _02657_ _02660_ _02661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10520_ _02582_ _02434_ _02460_ _02662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10521_ _02455_ _02458_ _02663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10522_ _02304_ _02300_ _02664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10523_ _02664_ _02477_ _02665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10524_ _02662_ _02588_ _02663_ _02665_ _02666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10525_ _02561_ _02562_ _02666_ _02584_ _02667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10526_ _02477_ _02668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10527_ _02524_ _02521_ _02525_ _02531_ _02669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10528_ _02310_ _02441_ _02669_ _02670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10529_ _02238_ _02520_ _02670_ _02671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10530_ _02664_ _02520_ _02671_ _02672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10531_ _02668_ _02443_ net15 _02672_ _02673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10532_ _02661_ _02667_ _02673_ _02674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_10533_ _02441_ _02669_ _02675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10534_ _02520_ _02675_ _02676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10535_ _02650_ _02467_ _02494_ _02677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10536_ _02310_ _02677_ _02678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10537_ _02494_ _02676_ _02678_ _02679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10538_ net44 _02340_ _02680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10539_ _02312_ _02680_ _02681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10540_ _02495_ _02669_ _02681_ _02682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10541_ _02441_ _02682_ net4 _02388_ _02683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10542_ net4 _02479_ _02683_ _02684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10543_ _02484_ _02487_ _02488_ _02685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10544_ _02440_ _02481_ _02685_ _02686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10545_ _02533_ _02686_ _02619_ _02687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10546_ _02499_ _02679_ _02684_ _02687_ _02688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10547_ _02491_ _02500_ _02689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10548_ _02443_ _02459_ _02478_ _02690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10549_ _02689_ _02546_ _02690_ _02691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10550_ _02501_ _02688_ _02691_ _02692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_10551_ _02510_ _02513_ _02693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10552_ _02523_ _02535_ _02545_ _02694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10553_ _02693_ _02694_ _02643_ _02695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10554_ _02643_ _02695_ _02502_ _02696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_10555_ _02535_ _02543_ _02697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10556_ _02696_ _02697_ _02698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10557_ _02656_ _02674_ _02692_ _02698_ _02699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_10558_ _02699_ _02638_ _02700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10559_ _02700_ _02701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10560_ _07506_ _02560_ _02701_ _07529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10561_ _07522_ _02702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10562_ _07525_ _07524_ _07523_ _02703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10563_ _02702_ _02703_ _02704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10564_ _07543_ _02704_ _02705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10565_ _02705_ _07542_ _02706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10566_ _02706_ _07540_ _02707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10567_ _02707_ _07539_ _02708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10568_ _02708_ _07537_ _02709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10569_ _02709_ _07536_ _02710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10570_ _02710_ _07534_ _02711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10571_ _02711_ _07533_ _02712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10572_ _07531_ _02712_ _02713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10573_ _02696_ _02697_ _02714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10574_ _02584_ _02715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_10575_ _02650_ _02479_ _02619_ _02716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10576_ _02467_ _02494_ _02660_ _02716_ _02717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_10577_ _02666_ _02717_ _02718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10578_ _02715_ _02549_ _02718_ _02719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10579_ _02684_ _02720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10580_ _02679_ _02691_ _02720_ _02721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10581_ _02719_ _02721_ _02722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10582_ _02679_ _02691_ _02723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10583_ _02723_ _02724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_10584_ _02652_ _02661_ _02667_ _02673_ _02725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10585_ _02590_ _02636_ _02725_ _02726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10586_ _02724_ _02726_ _02727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10587_ _02687_ _02722_ _02727_ net29 _02728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10588_ _02656_ _02674_ _02692_ _02698_ _02729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10589_ _02590_ _02729_ _02730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10590_ _02590_ _02637_ _02725_ _02731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_10591_ _02723_ _02722_ _02731_ _02732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10592_ _02520_ _02521_ _02733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10593_ net24 _02733_ _02686_ _02719_ _02734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_10594_ _02499_ _02734_ _02735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10595_ _02687_ _02730_ _02732_ _02735_ _02736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10596_ _02655_ _02737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10597_ _02523_ _02737_ _02692_ _02698_ _02738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10598_ _02640_ _02646_ _02739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10599_ _02739_ _02740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10600_ _02638_ _02674_ _02738_ _02740_ _02741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10601_ _02692_ _02698_ _02742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10602_ _02687_ _02743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10603_ _02524_ _02743_ _02543_ _02643_ _02744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10604_ _02715_ _02549_ _02744_ _02718_ _02745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10605_ _02642_ _02745_ _02746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10606_ _02742_ _02731_ _02746_ _02747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10607_ _02657_ _02660_ _02748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10608_ _02656_ _02748_ _02749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10609_ _02742_ _02746_ _02731_ _02749_ _02750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10610_ _02741_ _02747_ _02750_ _02751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10611_ _02714_ _02728_ _02736_ _02751_ _02752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_10612_ _02588_ _02587_ _02753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10613_ _02753_ _02637_ _02754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10614_ _02715_ net14 _02755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10615_ _02563_ net14 _02756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10616_ _02412_ _02414_ _02757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10617_ _02619_ _02757_ _02346_ _02758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10618_ _02474_ _02758_ _02759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10619_ _02571_ _02577_ _02755_ _02756_ _02759_ _02760_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_10620_ _02564_ _02581_ _02761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10621_ _02754_ _02760_ _02761_ _02762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10622_ _02662_ _02663_ _02763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10623_ net45 _02763_ _02764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10624_ _02568_ _02570_ _02765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10625_ _02420_ _02575_ _02766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10626_ net24 _02766_ _02617_ _02767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10627_ _02765_ net45 _02767_ _02768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10628_ _02764_ _02768_ _02769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10629_ _02502_ _02547_ _02770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10630_ _07461_ _02417_ net25 _02771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_10631_ _07177_ _02771_ _02772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10632_ _02440_ _02441_ _07461_ _02773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10633_ _02619_ _02417_ _02773_ _02774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_10634_ _02774_ _02453_ _02630_ _02775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10635_ _02774_ _02450_ _02603_ _02622_ _02776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10636_ _02620_ _02621_ _02777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10637_ _02772_ _02775_ _02776_ _02777_ _02778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10638_ _02770_ _02598_ _02778_ _02779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10639_ _02598_ _07481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10640_ _00977_ _02771_ _02603_ _07481_ _02780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10641_ _02507_ _02630_ _02781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10642_ _02611_ _02781_ _02782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10643_ _02622_ _02782_ _02417_ _02783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10644_ _02622_ _02782_ _07461_ _02784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10645_ _02783_ _02784_ _02619_ _02785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10646_ _02774_ _02451_ _02631_ _02785_ _02786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10647_ _01626_ _02507_ _02630_ _02631_ _02787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10648_ _02619_ _02417_ _02773_ _02623_ _02788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10649_ _02771_ _02450_ _02787_ _02789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10650_ _02775_ _02786_ _02787_ _02788_ _02789_ _02790_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_10651_ _02780_ _02790_ _02549_ _02791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10652_ _02565_ _02622_ _02792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10653_ _02771_ _02792_ _02793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10654_ _02561_ _02562_ _02793_ _02794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10655_ _02774_ _02514_ _02546_ _02795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10656_ _02774_ _02623_ _02796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10657_ _02502_ _02795_ _02796_ _02797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10658_ _00758_ _02603_ _02781_ _02798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10659_ _02794_ _02797_ _02798_ _02799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10660_ _07531_ _02712_ _02800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10661_ _02800_ _07530_ _02801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10662_ _02801_ _07528_ _07527_ _02802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10663_ _02779_ _02791_ _02799_ _02802_ _02803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_10664_ _02792_ _02634_ _02804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10665_ _02604_ _02804_ _02548_ _02805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10666_ _02771_ _02805_ _02806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10667_ _07177_ _02603_ _02807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10668_ _02802_ _02807_ _02808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10669_ _02631_ _02808_ _02809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10670_ _02507_ _02603_ _02810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10671_ _02810_ _02802_ _02811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10672_ _02631_ _02811_ _02812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10673_ net3 _02547_ _02809_ _02812_ _02813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_10674_ _02811_ _02814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10675_ _02808_ _02814_ _02598_ _02815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10676_ _02502_ _02547_ _02815_ _02816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_10677_ _02813_ _02816_ _02817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10678_ _02638_ _02699_ _02803_ _02817_ _02806_ _02818_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_10679_ _02564_ _02581_ _02587_ _02589_ _02819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_10680_ _02715_ _02634_ _02820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10681_ _02715_ _02763_ _02821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10682_ _02618_ _02628_ _02822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10683_ _02820_ _02821_ _02822_ _02823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10684_ _02715_ _02763_ _02634_ _02824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10685_ _02715_ _02549_ _02763_ _02825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10686_ net14 _02604_ _02629_ _02588_ _02826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10687_ _02823_ _02824_ _02825_ _02826_ _02827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10688_ _02819_ _02699_ _02827_ _02828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10689_ _02762_ _02769_ _02828_ _02818_ _02829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_10690_ _02667_ _02673_ _02830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10691_ _02590_ _02637_ _02830_ _02831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10692_ _02656_ _02748_ _02692_ _02698_ _02832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10693_ _02590_ _02637_ _02661_ _02830_ _02833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10694_ _02656_ _02692_ _02698_ _02725_ _02834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10695_ _02572_ net15 _02649_ _02835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10696_ net14 _02835_ _02748_ _02667_ _02836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_10697_ _02655_ _02836_ _02837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10698_ _02833_ _02834_ _02837_ _02731_ _02838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_10699_ _02590_ net11 _02830_ _02839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10700_ _02831_ _02832_ _02838_ _02839_ _02840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10701_ _02829_ _02840_ _02841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10702_ _02841_ _02842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10703_ _02842_ _02752_ _02843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10704_ _02843_ _02844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10705_ _07529_ _02713_ _02844_ _07552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10706_ _07457_ _02304_ _07476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10707_ _07480_ _07478_ _07479_ _02845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10708_ _02278_ _02845_ _02846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10709_ _07476_ _02846_ _02404_ _07493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10710_ _07497_ _02847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10711_ _07500_ _07499_ _07498_ _02848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10712_ _02847_ _02848_ _02849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10713_ _07495_ _02849_ _02850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10714_ _07493_ _02850_ _02550_ _07512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10715_ _07514_ _02555_ _02851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10716_ _07512_ _02851_ _02701_ _07535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10717_ _07537_ _02708_ _02852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10718_ _07535_ _02852_ _02844_ _07558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10719_ _07550_ _02853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10720_ _07545_ _07544_ _07551_ _02854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10721_ _02853_ _02854_ _02855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10722_ _07548_ _02855_ _02856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10723_ _07547_ _02856_ _02857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10724_ _07566_ _02857_ _02858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10725_ _02858_ _07565_ _02859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10726_ _07563_ _02859_ _02860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10727_ _02860_ _07562_ _02861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10728_ _07560_ _02861_ _02862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10729_ _02829_ _02840_ _02863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10730_ _02561_ _02695_ _02864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10731_ _02864_ _02697_ _02865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10732_ _02865_ _02866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10733_ _02866_ _02741_ _02747_ _02750_ _02867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10734_ _02696_ _02728_ _02736_ _02868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_10735_ _02692_ _02731_ _02869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10736_ _02656_ _02742_ _02869_ _02696_ _02870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10737_ _02742_ _02731_ _02749_ _02871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10738_ _02865_ _02870_ _02871_ _02872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10739_ _02863_ _02867_ _02868_ _02872_ _02873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10740_ _02863_ _02872_ _02867_ _02868_ _02874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10741_ _02698_ _02746_ _02875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10742_ _02875_ _02728_ _02736_ _02876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10743_ net41 _02876_ _02741_ _02877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10744_ _02873_ _02874_ _02877_ _02878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10745_ _02714_ _02728_ _02736_ _02879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10746_ _02842_ _02879_ _02880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10747_ _02747_ _02750_ _02881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10748_ _02741_ _02881_ _02882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10749_ _02714_ _02728_ _02736_ _02751_ _02883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_10750_ _07505_ _02601_ _02884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10751_ _02598_ _02631_ net14 _02885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10752_ _02810_ _02885_ _02886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10753_ _02884_ _02886_ _02887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10754_ _07388_ _01882_ _07407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10755_ _07411_ _07409_ _07410_ _02888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10756_ _01958_ _02888_ _02889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10757_ _07407_ _02889_ _02162_ _07427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10758_ _07429_ _02103_ _02890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10759_ _07427_ _02890_ _02121_ _07447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10760_ _07452_ _02125_ _07451_ _02891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10761_ _07449_ _02891_ _02892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10762_ _07447_ _02892_ _02276_ _07467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10763_ _07469_ _02324_ _02893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10764_ _07467_ _02893_ _02404_ _07484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10765_ _07484_ _02894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10766_ _07486_ _02445_ _02895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10767_ _02894_ _02895_ _02550_ _02896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10768_ _02885_ _02896_ _02897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10769_ _02699_ _02898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10770_ _02638_ _02898_ _02899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10771_ _02887_ _02897_ _02899_ _02900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10772_ _07528_ _02801_ _02901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10773_ _02638_ _02898_ _02807_ _02902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10774_ _02802_ _02885_ _02902_ _02903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_10775_ _02901_ _02903_ _02904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10776_ _02590_ _02729_ _02905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10777_ _02572_ _02763_ _02906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10778_ _02572_ _02763_ _02907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10779_ _02770_ _02906_ _02907_ _02635_ _02908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_10780_ _02656_ _02692_ _02698_ _02908_ _02909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10781_ _02587_ net11 _02910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10782_ _02905_ _02909_ _02910_ _02911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10783_ _02883_ _02863_ _02900_ _02904_ _02911_ _02912_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_10784_ _02476_ _02753_ net11 _02913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10785_ _02819_ _02898_ _02913_ _02914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10786_ _02831_ _02832_ _02839_ _02915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10787_ _02914_ _02762_ _02915_ _02916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10788_ _02769_ _02818_ _02828_ _02917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_10789_ _02916_ _02917_ _02918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10790_ _07545_ _07554_ _07557_ _07563_ _02919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10791_ _07548_ _07551_ _07560_ _07566_ _02920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10792_ _01392_ _02919_ _02920_ _02921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10793_ _02794_ _02797_ _02922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10794_ net45 _02604_ _02923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10795_ net45 net7 _02924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10796_ _02923_ _02924_ _02925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10797_ net23 _02898_ _02922_ _02925_ _02926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10798_ _02922_ _02925_ _02927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10799_ _02921_ _02926_ _02927_ _02928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10800_ _02838_ _02928_ _02929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10801_ _02813_ _02816_ _02771_ _02623_ _02930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10802_ _02770_ _02604_ _02815_ _02931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10803_ _02604_ _02815_ _02771_ _02770_ _02932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10804_ _02930_ _02931_ _02932_ _02933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10805_ net7 _02812_ _02934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10806_ net7 _02809_ _02771_ _02623_ _02935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_10807_ _02598_ _02811_ _02936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10808_ net3 _02547_ _02634_ _02936_ _02937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_10809_ _02770_ _02934_ _02935_ _02937_ _02938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10810_ _02809_ _02788_ _02939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10811_ net3 _02547_ _02936_ _02788_ _02940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10812_ _02812_ _02788_ _02941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10813_ net3 _02547_ _02941_ _02942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10814_ net7 _02939_ _02940_ _02942_ _02943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10815_ _02938_ _02943_ _02770_ _02944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10816_ _02933_ _02944_ _02945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10817_ net23 _02898_ _02769_ _02946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10818_ _02764_ _02768_ _02933_ _02944_ _02947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_10819_ net29 _02803_ _02945_ _02946_ _02947_ _02948_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_10820_ _02883_ _02918_ _02929_ _02928_ _02948_ _02949_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_10821_ _02747_ _02750_ _02842_ _02879_ _02950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_10822_ _02880_ _02882_ _02912_ _02949_ _02950_ _02951_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_10823_ _02878_ _02951_ _02952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10824_ _02696_ _02728_ _02867_ _02953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10825_ _02842_ _02953_ _02954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10826_ _02836_ _02914_ _02762_ _02915_ _02955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10827_ _02833_ _02834_ _02956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10828_ _02737_ _02726_ _02956_ _02957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10829_ _02917_ _02955_ _02957_ _02958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10830_ _02868_ _02954_ _02958_ _02959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_10831_ _02883_ _02863_ _02900_ _02904_ _02960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10832_ _07560_ _02861_ _02961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10833_ _07559_ _02961_ _02962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10834_ _07557_ _02962_ _02963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10835_ _02963_ _07556_ _02964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10836_ _07554_ _02964_ _02965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10837_ _02965_ _07553_ _02966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10838_ _02960_ _02966_ _02967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10839_ _02769_ _02818_ _02968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10840_ _02968_ _02969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10841_ _02819_ _02898_ _02909_ _02910_ _02970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10842_ _02885_ _02971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10843_ _02802_ _02971_ _02972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10844_ _02802_ _02885_ _02973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10845_ _02972_ _02973_ _02902_ _02974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10846_ _02819_ _02898_ _02925_ _02975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10847_ net45 _02777_ _02822_ _02976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10848_ _02924_ _02793_ _02796_ _02923_ _02774_ _02977_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_10849_ _02975_ _02976_ _02977_ _02769_ _02978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_10850_ _02974_ _02978_ _02979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10851_ _02926_ _02927_ _02980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10852_ _02885_ _02902_ _02981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10853_ _02948_ _02980_ _02802_ _02981_ _02982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10854_ _02969_ _02970_ _02979_ _02982_ _02983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_10855_ _02412_ _02414_ _02984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10856_ _02619_ _02757_ _02984_ _02985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10857_ _02985_ _02764_ _02819_ _02699_ _02986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10858_ _02715_ _02985_ net11 _02987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10859_ _02764_ net11 _02715_ _02988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10860_ _02715_ _02985_ _02764_ _02989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10861_ _02588_ _02988_ _02989_ _02990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10862_ _02986_ _02987_ _02990_ _02991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10863_ _02769_ _02818_ _02970_ _02992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10864_ _02991_ _02992_ _02993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10865_ _02752_ net41 _02993_ _02916_ _02994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_10866_ _02667_ _02673_ _02995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10867_ _02995_ _02836_ _02996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10868_ _02995_ _02836_ _02997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10869_ net23 _02997_ _02998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10870_ net23 _02729_ _02999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10871_ _02836_ _02999_ _03000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10872_ _03000_ _02997_ _02829_ _03001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10873_ _02898_ _02996_ _02998_ _03001_ _03002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10874_ _02843_ _02983_ _02994_ _03002_ _03003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10875_ _02959_ _02967_ _03003_ _03004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_10876_ _03004_ _02952_ _03005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10877_ _03005_ _03006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_10878_ _07558_ _02862_ _03006_ _07581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10879_ _07574_ _03007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10880_ _07577_ _07576_ _07575_ _03008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10881_ _03007_ _03008_ _03009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10882_ _03009_ _07572_ _03010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10883_ _03010_ _07571_ _03011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10884_ _07569_ _03011_ _03012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10885_ _03012_ _07568_ _03013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10886_ _07589_ _03013_ _03014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10887_ _07588_ _03014_ _03015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10888_ _07586_ _03015_ _03016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10889_ _03016_ _07585_ _03017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10890_ _07583_ _03017_ _03018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10891_ _02959_ _02967_ _03003_ _03019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10892_ _02728_ _02736_ _03020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10893_ _02883_ net41 _03021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_10894_ _03020_ _03021_ _03022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10895_ _02696_ _02869_ _03023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10896_ _02870_ _03023_ _03024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10897_ _03022_ _03024_ _03025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10898_ net41 _02953_ _02958_ _03020_ _03026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_10899_ _03026_ _02967_ _03003_ _03027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10900_ _02881_ _02882_ _02880_ _03028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10901_ _03025_ _03027_ _03028_ _03029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10902_ _02951_ _03019_ _03029_ _02878_ _03030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_10903_ _02878_ _02951_ _02959_ _03031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10904_ _03002_ _02994_ _03032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10905_ _02752_ _02842_ _03033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10906_ _07528_ _02801_ _03034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10907_ net29 _02884_ _03035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10908_ _02899_ _02896_ _03035_ _07526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10909_ _07529_ _02883_ _02863_ _07526_ _03036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_10910_ net384 _02713_ _03034_ _03036_ _03037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10911_ net23 _02898_ _02897_ _03038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10912_ _02899_ _02887_ _03038_ _03039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10913_ _07553_ _02838_ _02965_ _03040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_10914_ _02916_ _02917_ _03039_ _03040_ _03041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10915_ _02901_ _02903_ _02966_ _03042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10916_ _02752_ _03041_ _03042_ _03043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10917_ _02843_ _02983_ _03043_ _03044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10918_ _03032_ _03037_ _03044_ _03045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10919_ _07554_ _02964_ _03046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10920_ _03046_ _03047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10921_ _03034_ _07526_ _03033_ _03048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10922_ _02966_ _03048_ _03049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10923_ _03031_ _03045_ _03047_ _03049_ _03050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_10924_ _02878_ _02951_ _02959_ _03003_ _03051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_10925_ _02968_ _02970_ _03052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10926_ _07553_ _02904_ _02965_ _03053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10927_ _02730_ _02754_ _03054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10928_ _02760_ _03054_ _03055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_10929_ _02991_ _03055_ _03056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10930_ _03052_ _03053_ _03056_ _03057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10931_ _02991_ _03058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10932_ _03058_ _03052_ _03043_ _03055_ _03059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10933_ _02843_ _02983_ _03060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10934_ _03057_ _03059_ _03060_ _03061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10935_ net384 _03043_ _03062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10936_ _03051_ _03061_ _03062_ _03063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10937_ _07569_ _07577_ _07586_ _07589_ _03064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10938_ _07580_ _07572_ _07575_ _07583_ _03065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10939_ _01392_ _03064_ _03065_ _03066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10940_ _02878_ _02951_ _02959_ _03003_ _03067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_10941_ _02901_ _02966_ _03068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10942_ _03033_ _02903_ _03068_ _03069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10943_ _03043_ _03067_ _03069_ _03070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_10944_ _03050_ _03063_ _03066_ _03070_ _03071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_10945_ _02915_ _03072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10946_ _02883_ _03072_ _02838_ _02829_ _03073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10947_ _02917_ _02843_ _03055_ _03074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10948_ _02761_ _03075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10949_ _03075_ _02913_ _03076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10950_ _02999_ _03076_ _03077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10951_ _03074_ _03077_ _03078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_10952_ _03073_ _03078_ _03079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10953_ _02979_ _02982_ _03080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10954_ _07553_ _03081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10955_ _03033_ _03080_ _02912_ _03081_ _03082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10956_ _02993_ _03055_ net384 _03083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_10957_ _02960_ _02980_ _02965_ _03084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_10958_ _03082_ _03083_ _03084_ _03085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10959_ _02952_ _03004_ _03085_ _03086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10960_ _03079_ _03086_ _03087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_10961_ _03032_ _03044_ _03088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10962_ _07554_ _07557_ _02961_ _03089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_10963_ _07557_ _07559_ _03090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10964_ _07556_ _03090_ _07554_ _03091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10965_ _03034_ _03089_ _03091_ _03092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10966_ _07526_ _03089_ _03091_ _03093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_10967_ _03092_ _03093_ _03033_ _03094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10968_ _02994_ _03082_ _03094_ _03002_ _03095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_10969_ _07583_ _03017_ _03096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10970_ _03096_ _07582_ _03097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10971_ _07580_ _03097_ _03098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_10972_ _03098_ _07579_ _03099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_10973_ _03099_ _03100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_10974_ _03026_ _03100_ _03101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_10975_ _03072_ _02829_ _03102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10976_ _02915_ _03073_ _03102_ _03103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_10977_ _03103_ _03101_ _03104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10978_ _03031_ _03088_ _03095_ _03104_ _03105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_10979_ _03063_ _03050_ _03070_ _03105_ _03106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_10980_ _03106_ _03071_ _03087_ _03030_ _03107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_10981_ _03107_ _03108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_10982_ _07581_ _03018_ _03108_ _07610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10983_ butterfly_count\[1\] _07636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10984_ butterfly_count\[0\] _07686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_10985_ _07480_ _02619_ _07496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_10986_ _07500_ _07498_ _07499_ _03109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_10987_ _02848_ _03109_ _03110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_10988_ _07496_ _03110_ _02550_ _07515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10989_ _07517_ _02553_ _03111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10990_ _07515_ _03111_ _02701_ _07538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10991_ _07540_ _02706_ _03112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10992_ _07538_ _03112_ _02844_ _07561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10993_ _07563_ _02859_ _03113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10994_ _07561_ _03113_ _03006_ _07584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10995_ _07586_ _03015_ _03114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_10996_ _03108_ _03115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_10997_ _07584_ _03114_ _03115_ _07604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_10998_ _07596_ _03116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_10999_ _07591_ _07590_ _07597_ _03117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11000_ _03116_ _03117_ _03118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11001_ _07594_ _03118_ _03119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11002_ _03119_ _07593_ _03120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11003_ _03120_ _07603_ _03121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11004_ _07602_ _03121_ _03122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11005_ _03122_ _07600_ _03123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11006_ _03123_ _07599_ _03124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11007_ _03124_ _07609_ _03125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11008_ _03125_ _07608_ _03126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11009_ _07606_ net387 _03127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11010_ _02873_ _02874_ _03128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11011_ _03128_ _03129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11012_ _03129_ _03004_ _03130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11013_ _02880_ _02882_ _02950_ _03131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11014_ _02878_ _03131_ _03132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11015_ net35 _02948_ _03133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11016_ _02970_ _02921_ _02980_ _03134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11017_ _02960_ _03133_ _03134_ _03032_ _03135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11018_ _03132_ _03135_ _03004_ _03129_ _03136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11019_ _03130_ _03136_ _03131_ _03137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11020_ _03129_ net380 _03138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11021_ _02877_ _03028_ _03139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11022_ _02877_ _03138_ _03139_ _03140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11023_ _03137_ _03140_ _03141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11024_ _02722_ _03142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11025_ _02724_ _03142_ _02726_ _03143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11026_ _02905_ _03143_ _02719_ _03144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11027_ _02687_ _03144_ _03145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11028_ _02878_ _02951_ _02959_ _03146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_11029_ _03032_ _03044_ _03147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11030_ _02722_ _02726_ net29 _03148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11031_ _02723_ _03142_ _02726_ _03149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11032_ _02724_ _03148_ _03149_ _03150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11033_ _02917_ _02955_ _03151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11034_ _02957_ _03151_ _03152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11035_ _03021_ _03152_ _03153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11036_ _03150_ _03153_ _03154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11037_ _03146_ _03147_ _03154_ _03155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11038_ _03021_ _03150_ _03156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11039_ _03145_ _03155_ _03156_ _03157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_11040_ _03021_ _03152_ _03158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11041_ _02728_ _03158_ _03159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11042_ _02728_ net41 _03160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11043_ _02687_ _02735_ _02730_ _02732_ _03161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11044_ _02736_ _03161_ _03162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11045_ _03088_ _03159_ _03160_ _03162_ _03163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11046_ _03026_ _02967_ _03003_ _03164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11047_ _03132_ _03025_ _03135_ _03164_ _03165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11048_ _03022_ _03163_ _03165_ _03166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11049_ _02878_ _02951_ _03167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11050_ _03025_ _03027_ _03168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11051_ _03167_ net385 _03168_ _03169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11052_ _03128_ _03019_ _03170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11053_ _03170_ _03154_ _03136_ _03171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11054_ _03157_ _03166_ _03169_ _03171_ _03172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_11055_ _03146_ _03147_ _03173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11056_ _03103_ _03174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11057_ _03095_ _03174_ _03175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11058_ _03173_ _03175_ _03176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11059_ _03051_ _03061_ _03062_ _03177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_11060_ _03079_ _03086_ _03177_ _03178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_11061_ _03050_ _03070_ _03099_ _03179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11062_ _03176_ _03178_ _03179_ _03180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11063_ _03030_ _03071_ _03106_ _03181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_11064_ _03137_ _03139_ _03182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11065_ _03172_ _03180_ _03181_ _03182_ _03183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_11066_ _02878_ _02951_ _02959_ _03032_ _03184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_11067_ _02914_ _02762_ _02993_ _03185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11068_ net384 _03185_ _03186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11069_ _03044_ _03186_ _03187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11070_ _03145_ _03188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11071_ _02898_ _02726_ _03189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11072_ _02731_ _03189_ _02724_ _03190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11073_ _03021_ _03190_ _03191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11074_ _02724_ _02726_ _03142_ _03192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11075_ _03143_ _03192_ net29 _03193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_11076_ _03188_ _03191_ _03193_ _03194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_11077_ _03184_ _03187_ _03194_ _03195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11078_ _03173_ _03175_ _03158_ _03195_ _03196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_11079_ _03178_ _03179_ _03196_ _03166_ _03197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11080_ _03178_ _03166_ _03179_ _03196_ _03198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11081_ _03087_ net373 _03169_ _03199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11082_ _03087_ net373 _03169_ _03200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11083_ _03197_ _03198_ _03199_ _03200_ _03201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11084_ _03106_ _03071_ _03087_ _03030_ _03202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_11085_ _03170_ _03136_ _03203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11086_ _03141_ _03183_ _03201_ _03202_ _03203_ _03204_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_11087_ _02967_ _03051_ _03205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11088_ _03047_ _03100_ _03049_ _03206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11089_ _03005_ _03206_ _03207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11090_ _03205_ _03069_ _03207_ _03208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11091_ _07552_ _03046_ _03005_ _03209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11092_ _03099_ _03209_ _03210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11093_ _03126_ _07606_ _03211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11094_ _03211_ _07605_ _03212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11095_ _03212_ _07612_ _03213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11096_ _03213_ _07611_ _03214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11097_ _07580_ _03097_ _03215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11098_ _03214_ _03215_ _03216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11099_ _03184_ _03187_ _03217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11100_ _07434_ _02266_ _07453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11101_ _07457_ _07455_ _07456_ _03218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11102_ _02124_ _03218_ _03219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11103_ _07453_ _03219_ _02276_ _07473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11104_ _07475_ _02279_ _03220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11105_ _07473_ _03220_ _02404_ _07490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11106_ _07495_ _02849_ _07494_ _03221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11107_ _07492_ _03221_ _03222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11108_ _07490_ _03222_ _02550_ _07509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11109_ _07511_ _02557_ _03223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11110_ _07509_ _03223_ _02701_ _07532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11111_ _07534_ _02710_ _03224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11112_ _07532_ _03224_ _02843_ _07555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11113_ _07552_ _07555_ _03225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11114_ _07557_ _02962_ _03226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11115_ _03046_ _03226_ _03227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11116_ _03225_ _03227_ _03005_ _03228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11117_ _03214_ _03217_ _03228_ _03229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_11118_ _03210_ _03216_ _03107_ _03229_ _03230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_11119_ _03208_ _03230_ _03231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11120_ _03178_ _03179_ _03232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11121_ _03103_ _03232_ _03181_ _03233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11122_ _03184_ _03187_ _03234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11123_ _03103_ _03234_ _03235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11124_ _03174_ _03217_ _03236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11125_ _03232_ _03235_ _03236_ _03237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11126_ _03233_ _03237_ _03238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11127_ _03173_ _03095_ _03239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11128_ _03050_ _03070_ _03099_ _03240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_11129_ _02926_ _02927_ _03241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11130_ _02818_ net35 _02974_ _03241_ _03242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11131_ _03205_ _03242_ _03243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11132_ _03240_ _03243_ _03244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11133_ _03239_ _03244_ _03108_ _03245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11134_ _02967_ _03051_ _03246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11135_ _02979_ _02982_ _03247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11136_ net35 _03247_ _03248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11137_ _03242_ _03249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11138_ _03133_ _03250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11139_ _03246_ _03248_ _03249_ _03250_ _03251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11140_ _03133_ _03246_ _03240_ _03251_ _03252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_11141_ _02952_ _03004_ _03253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11142_ _02991_ _03052_ _03254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11143_ _02917_ net35 _03254_ _03255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11144_ _02917_ _03055_ _03256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11145_ _03044_ _03074_ _03256_ _03257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_11146_ _03255_ _03257_ _03258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11147_ _02969_ _02911_ _03259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11148_ _03247_ _03259_ _03260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11149_ _03052_ _03260_ _03261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11150_ _03205_ _03259_ _03261_ net35 _03262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11151_ _03079_ _03086_ _03263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11152_ _03253_ _03258_ _03262_ _03263_ _03264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11153_ _03252_ _03264_ _03265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11154_ _03245_ _03265_ _03266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11155_ _03238_ _03231_ _03266_ _03267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_11156_ _03180_ _03181_ _03268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11157_ _03173_ _03158_ _03269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11158_ _03268_ _03269_ _03270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11159_ _03157_ _03271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11160_ _03146_ _03147_ _03158_ _03272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11161_ _03190_ _03272_ _03273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11162_ _03176_ _03273_ _03274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11163_ _03173_ _03175_ _03158_ _03275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_11164_ _03153_ _03191_ _03276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11165_ _03146_ _03147_ _03158_ _03190_ _03277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11166_ _03173_ _03191_ _03276_ _03277_ _03278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_11167_ _03178_ _03179_ _03275_ _03278_ _03279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11168_ _03232_ _03181_ _03274_ _03279_ _03280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_11169_ _03193_ _03281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11170_ _03232_ _03181_ _03281_ _03274_ _03282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_11171_ _03178_ _03179_ _03283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11172_ _02958_ _03031_ _03088_ _03284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11173_ _03021_ _03284_ _03190_ _03285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11174_ _03193_ _03285_ _03286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11175_ _03021_ _03284_ _03287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11176_ _03287_ _03190_ _03273_ _03176_ _03281_ _03288_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11177_ _03193_ _03285_ _03289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11178_ _03283_ _03286_ _03288_ _03289_ _03290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11179_ _03271_ _03280_ _03282_ _03290_ _03291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11180_ _03270_ _03291_ _03292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11181_ _03267_ _03204_ _03292_ _03293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_11182_ _03293_ _03294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_11183_ _03294_ _03295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_11184_ _07604_ _03127_ _03295_ _07630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11185_ _07502_ _02899_ _07521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11186_ _07523_ _07525_ _07524_ _03296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11187_ _02703_ _03296_ _03297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11188_ _07521_ _03297_ _02844_ _07546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11189_ _07548_ _02855_ _03298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11190_ _07546_ _03298_ _03006_ _07567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11191_ _07569_ _03011_ _03299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11192_ _07567_ _03299_ _03115_ _07598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11193_ _07600_ _03122_ _03300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11194_ _07598_ _03300_ _03295_ _07618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11195_ _07614_ _03301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11196_ _07617_ _07616_ _07615_ _03302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11197_ _03301_ _03302_ _03303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11198_ _03303_ _07629_ _03304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11199_ _03304_ _07628_ _03305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11200_ _07626_ _03305_ _03306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11201_ _03306_ _07625_ _03307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11202_ _07623_ _03307_ _03308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11203_ _07622_ _03308_ _03309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11204_ _07620_ _03309_ _03310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11205_ _03267_ _03311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11206_ _03292_ _03312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11207_ _07555_ _03226_ net12 _07578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11208_ _03215_ _07578_ _03202_ _03313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11209_ _07610_ _03313_ _03314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11210_ _03204_ _03311_ _03312_ _03314_ _03315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_11211_ _07612_ net386 _03316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11212_ _03214_ _03313_ _03317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11213_ _03214_ _03313_ _03318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11214_ _03316_ _03317_ _03318_ _03319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_11215_ _03319_ _03320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11216_ _07615_ _07623_ _07626_ net391 _03321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11217_ _07620_ _07617_ _07632_ _03322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11218_ _07635_ _07769_ _03321_ _03322_ _03323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11219_ _03315_ _03320_ _03323_ _03324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11220_ _03141_ _03183_ _03325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11221_ _03202_ _03201_ _03326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11222_ _03166_ _03169_ _03327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11223_ _03202_ _03232_ _03196_ _03328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11224_ _03327_ _03328_ _03329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11225_ _03203_ _03329_ _03330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11226_ _03326_ _03311_ _03312_ _03330_ _03331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11227_ _03325_ _03331_ _03332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11228_ _03141_ _03183_ _03333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11229_ _03202_ _03201_ _03203_ _03334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11230_ _03333_ _03334_ _03335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11231_ _03166_ _03328_ _03336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11232_ _03198_ _03336_ _03337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11233_ _03335_ _03311_ _03312_ _03337_ _03338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11234_ _03335_ _03311_ _03312_ _03337_ _03339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11235_ _03087_ _03106_ _03340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11236_ _03340_ _03341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11237_ _03341_ _03169_ _03327_ _03328_ _03342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_11238_ _03338_ _03339_ _03291_ _03342_ _03343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_11239_ _03324_ _03332_ _03343_ _03344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_11240_ _03344_ _03345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11241_ net383 _03238_ _03266_ _03346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_11242_ _03270_ _03347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11243_ _03233_ _03237_ _03348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11244_ _03248_ _03240_ _03349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11245_ net378 _03349_ _03264_ _03252_ _03350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_11246_ _03208_ net377 _03243_ _03350_ _03351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_11247_ _03239_ _03233_ _03352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11248_ _03269_ _03348_ _03351_ _03352_ _03353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_11249_ _03346_ _03347_ _03353_ _03354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11250_ net376 _03354_ _03355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11251_ _03334_ _03238_ _03266_ _03356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11252_ _03348_ _03351_ _03357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11253_ _03333_ _03312_ _03356_ _03357_ _03358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11254_ _03204_ _03270_ _03291_ _03359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11255_ _03348_ _03351_ _03352_ _03360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11256_ _03346_ _03359_ _03360_ _03361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11257_ _03348_ _03351_ _03358_ _03361_ _03362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11258_ _03355_ _03362_ _03363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11259_ _03363_ _03364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11260_ _03204_ _03311_ _03292_ _03314_ _03365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11261_ _07620_ _03309_ _03366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11262_ _07619_ _03366_ _03367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11263_ _07635_ _03367_ _03368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11264_ _07634_ _03368_ _03369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11265_ _03369_ _07632_ _03370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11266_ _03370_ _07631_ _03371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11267_ _03365_ _03319_ _03371_ _03372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11268_ _03333_ _03312_ _03356_ _03373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11269_ _03263_ _03234_ _03374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11270_ _03177_ net39 _03240_ _03375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11271_ _03374_ _03375_ _03376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11272_ _03376_ _03377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11273_ _03060_ _03240_ _03378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11274_ net39 _03378_ _03379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11275_ _02991_ _03052_ _03055_ _03380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11276_ _02992_ _03056_ _03380_ _03381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11277_ _03255_ _03382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11278_ net39 _03382_ _03257_ _03378_ _03383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11279_ _03258_ _03379_ _03381_ _03044_ _03383_ _03384_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_11280_ _03108_ _03349_ _03252_ _03385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11281_ net12 _03044_ _03386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11282_ _03386_ _03262_ _03387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11283_ _03385_ _03387_ _03379_ _03388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_11284_ _03208_ net377 _03243_ _03389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_11285_ net12 _03384_ _03388_ _03389_ _03390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_11286_ _03204_ _03311_ _03312_ _03390_ _03391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11287_ _03351_ _03373_ _03377_ _03391_ _03392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11288_ _03044_ _03255_ _03393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11289_ net12 _03393_ _03394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11290_ _03379_ _03394_ _03395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11291_ _03389_ _03388_ _03396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11292_ _03204_ _03311_ _03292_ _03396_ _03397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11293_ _03395_ _03397_ _03398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11294_ _03385_ _03399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11295_ _03210_ _03216_ net381 net39 _03400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_11296_ net47 _03210_ _03216_ _03401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11297_ _03050_ _03099_ _03402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11298_ _03243_ _03403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11299_ _03402_ _03403_ net47 _03404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11300_ _03208_ _03404_ _03405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11301_ _03399_ _03400_ _03401_ _03405_ _03406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_11302_ _03406_ _03407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11303_ _03074_ _03256_ _03408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11304_ _03060_ _03240_ _03409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11305_ _03386_ _03409_ _03382_ _03410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11306_ _03408_ _03410_ _03411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11307_ net47 _03411_ _03412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11308_ net47 _03349_ _03413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11309_ _03413_ _03387_ _03379_ _03414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_11310_ _03294_ _03407_ _03412_ _03414_ _03415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_11311_ _03415_ _03392_ _03398_ _03372_ _03416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_11312_ _03416_ _03364_ _03345_ _03417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_11313_ _07618_ _03310_ net10 _07648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11314_ _03294_ _03400_ _03401_ _03418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11315_ _03392_ _03398_ _03415_ _03419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_11316_ _03345_ _03364_ _03419_ _03372_ _03420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11317_ _03418_ _03420_ _03421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11318_ net39 _03402_ _03422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11319_ net12 _03206_ _03422_ _03423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11320_ _03207_ _03400_ _03422_ _03424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11321_ _03070_ _03424_ _03425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11322_ _03243_ _03425_ _03426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11323_ net37 _03426_ _03427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11324_ _03372_ _03418_ _03423_ _03427_ _03428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11325_ _03344_ _03363_ _03416_ _03428_ _03429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11326_ _03311_ _03204_ _03312_ _03430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_11327_ _03430_ _03389_ _03431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11328_ _03385_ _03429_ _03431_ _03432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_11329_ _03421_ _03432_ _03433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11330_ _03345_ _03364_ _03419_ _03434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_11331_ _03423_ _03435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11332_ _03372_ _03418_ _03436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11333_ _03435_ _03436_ _03437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11334_ _03207_ net37 _03400_ _03438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11335_ _03422_ _03438_ _03439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11336_ _03070_ _03439_ _03440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11337_ net47 _03231_ _03244_ _03441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11338_ _03431_ _03441_ _03442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11339_ _03434_ _03437_ _03440_ _03442_ _03443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11340_ _03434_ _03437_ _03442_ _03440_ _03444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11341_ net370 _03317_ _03318_ _03445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_11342_ _03207_ net46 _03446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11343_ _03435_ _03446_ _03400_ _03447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11344_ _03440_ _03445_ _03447_ _03448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11345_ _03443_ _03444_ _03448_ _03449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11346_ _07630_ net10 _03450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11347_ _07610_ _03451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11348_ _03451_ _03316_ net37 _03452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11349_ _07631_ _03452_ _03453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11350_ _07632_ _03369_ _03454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11351_ _03370_ _03452_ _03453_ _03454_ _03455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11352_ _07631_ _03370_ _03456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11353_ _03315_ _03320_ _03456_ _03457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11354_ _07500_ _02770_ _07518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11355_ _07502_ _07520_ _07501_ _03458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11356_ _02552_ _03458_ _03459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11357_ _07518_ _03459_ _02701_ _07541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11358_ _07543_ _02704_ _03460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11359_ _07541_ _03460_ _02844_ _07564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11360_ _07566_ _02857_ _03461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11361_ _07564_ _03461_ _03006_ _07587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11362_ _07589_ _03013_ _03462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11363_ _07587_ _03462_ _03115_ _07607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11364_ _07609_ net389 _03463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11365_ _07607_ _03463_ net374 _07633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11366_ _03457_ _07633_ _03464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11367_ _03344_ _03364_ _03419_ _03464_ _03465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11368_ _07635_ _03367_ _03466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11369_ _03345_ _03364_ _03416_ _03466_ _03368_ _03467_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_11370_ _07653_ _03468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11371_ _07658_ _03469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11372_ _07646_ _03470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11373_ _07639_ _07640_ _07647_ _03471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11374_ _03471_ _03470_ _03472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11375_ _03472_ _07644_ _03473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11376_ _03473_ _07643_ _07659_ _03474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11377_ _03474_ _03469_ _03475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11378_ _03475_ _07656_ _07655_ _03476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11379_ _07652_ _03477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11380_ _03476_ _03468_ _03477_ _03478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11381_ _03478_ _07650_ _07649_ _03479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11382_ _07177_ _03479_ _02196_ _03480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11383_ _03480_ _03467_ _03465_ _03481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_11384_ _03465_ _03467_ _03479_ _02507_ _03482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_11385_ _03450_ _03455_ _03482_ _03481_ _03483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_11386_ _03483_ _03449_ _03433_ _03484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_11387_ net46 _03407_ _03457_ _03485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11388_ _03345_ _03364_ _03416_ _03485_ _03486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_11389_ _03385_ _03431_ _03487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11390_ _03486_ _03487_ _03414_ _03488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11391_ _03414_ _03486_ _03487_ _03489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11392_ _03346_ _03359_ _03490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11393_ _03360_ _03490_ _03491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11394_ _03348_ _03351_ _03492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11395_ _03373_ _03357_ _03492_ _03493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11396_ _03372_ _03392_ _03398_ _03415_ _03494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11397_ _03493_ _03494_ _03495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11398_ _03324_ _03332_ _03343_ _03496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11399_ net46 _03354_ _03497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11400_ _03493_ _03372_ _03498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11401_ _03496_ _03497_ _03419_ _03498_ _03499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_11402_ _03491_ _03495_ _03499_ _03500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11403_ _03395_ _03397_ _03501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11404_ _03412_ _03502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11405_ net46 _03396_ _03395_ _03503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11406_ _03502_ _03503_ _03391_ _03504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11407_ _03377_ _03504_ _03505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11408_ _03203_ _03329_ _03506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11409_ _03506_ _03137_ _03507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11410_ _03138_ _03506_ _03508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11411_ _03028_ _03508_ _03507_ _02877_ _03509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11412_ _03334_ _03311_ _03312_ _03510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_11413_ _03507_ _03509_ _03510_ _03511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11414_ _03511_ _03512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11415_ _03501_ _03505_ _03512_ _03513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11416_ _03488_ _03489_ _03500_ _03513_ _03514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11417_ net372 _03353_ _03515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11418_ _03280_ _03515_ _03516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11419_ _03282_ _03290_ _03517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11420_ _03280_ net371 _03353_ _03518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11421_ _03517_ _03518_ _03519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11422_ _03355_ _03362_ _03457_ _03520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11423_ _07631_ _03430_ _03406_ _03371_ _03521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11424_ _03365_ _03319_ _03373_ _03357_ _03492_ _03522_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_11425_ net37 _03354_ _03280_ _03523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11426_ _03361_ _03521_ _03522_ _03523_ _03524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11427_ _03392_ _03398_ _03415_ _03525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11428_ _03344_ _03520_ _03524_ _03525_ _03526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_11429_ _03519_ _03526_ _03527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11430_ _03345_ _03497_ _03528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11431_ _03362_ _03457_ _03419_ _03529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11432_ _03528_ _03355_ _03529_ _03530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11433_ _03338_ _03339_ _03531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11434_ _03342_ _03531_ _03532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11435_ _03157_ _03282_ _03533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11436_ _03328_ _03533_ _03534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11437_ _03517_ _03518_ _03535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11438_ _03534_ _03535_ _03536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11439_ _03532_ _03536_ _03537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11440_ _03516_ _03527_ _03530_ _03537_ _03538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11441_ _03333_ _03510_ _03539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11442_ _03331_ _03539_ _03540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11443_ _07635_ _07769_ _03321_ _03322_ _03541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_11444_ _03365_ _03319_ _03541_ _03542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11445_ _03325_ _03331_ _03543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11446_ _03542_ _03543_ _03343_ _03544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11447_ _03497_ _03361_ _03545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11448_ _03419_ _03498_ _03544_ _03545_ _03546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_11449_ _03540_ _03546_ _03547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11450_ _03519_ _03534_ _03548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11451_ _03507_ _03549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11452_ _03532_ _03549_ _03540_ _03550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11453_ _03028_ _03508_ _02877_ _03551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11454_ _03510_ _03507_ _03551_ _03552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11455_ _03526_ _03548_ _03550_ _03552_ _03553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_11456_ _03547_ _03553_ _03554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11457_ _03514_ _03538_ _03554_ _03555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_11458_ _03555_ _03484_ _03556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11459_ _03556_ _03557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11460_ _07650_ _03478_ _03558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11461_ _03557_ _03558_ _03559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11462_ _07648_ net16 _03559_ _07661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11463_ _07525_ _03033_ _07549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11464_ _07545_ _07551_ _07544_ _03560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11465_ _02854_ _03560_ _03561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11466_ _07549_ _03561_ _03006_ _07570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11467_ _07572_ _03009_ _03562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11468_ _07570_ _03562_ _03115_ _07601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11469_ _07603_ _03120_ _03563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11470_ _07601_ _03563_ net401 _07621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11471_ _07623_ _03307_ _03564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11472_ _07621_ _03564_ _03417_ _07651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11473_ _07643_ _03565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11474_ _07647_ _03566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11475_ _03566_ _07638_ _03470_ _03567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11476_ _07644_ _03567_ _03568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11477_ _03565_ _03568_ _03569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11478_ _07659_ _03569_ _03570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11479_ _07658_ _03570_ _03571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11480_ _07656_ _03571_ _07655_ _03572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11481_ _03468_ _03572_ _03573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11482_ _03557_ _03573_ _03574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11483_ _03557_ _07651_ _03574_ _07665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11484_ _07545_ _03253_ _07573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11485_ _07577_ _07575_ _07576_ _03575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11486_ _03008_ _03575_ _03576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11487_ _07573_ _03576_ _03115_ _07592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11488_ _07594_ _03118_ _03577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11489_ _07592_ _03577_ net401 _07624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11490_ _07626_ net388 _03578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11491_ _07624_ _03578_ _03417_ _07654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11492_ _07656_ _03475_ _03579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11493_ _03579_ _03557_ _03580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11494_ net16 _07654_ _03580_ _07669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11495_ _07577_ _03202_ _07595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11496_ _07597_ _07591_ _07590_ _03581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11497_ _03117_ _03581_ _03582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11498_ _07595_ _03582_ _03295_ _07627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11499_ net382 _03303_ _03583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_11500_ net379 _03583_ _03417_ _07657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11501_ _07659_ _03569_ _03584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11502_ _03570_ _03584_ _03557_ _03585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11503_ net16 _07657_ _03585_ _07673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11504_ _07591_ _03430_ _07613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11505_ _07615_ _07617_ _07616_ _03586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11506_ _03302_ _03586_ _03587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11507_ _07613_ _03587_ _03417_ _07642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11508_ _07644_ _03472_ _03588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11509_ _03473_ _03588_ net16 _03589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11510_ net16 _07642_ _03589_ _07677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11511_ _07617_ _03590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11512_ butterfly_count\[2\] _03590_ _03417_ _07645_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11513_ _05877_ _05862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_16
X_11514_ state\[0\] _03591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11515_ net80 _07803_ _03592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11516_ state\[2\] _03592_ _03593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11517_ _03591_ _00565_ _03593_ _00006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11518_ state\[1\] _03594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_11519_ _03594_ _03595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11520_ _03595_ _03596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11521_ state\[2\] net80 _03597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11522_ _03596_ _07789_ _03597_ _07803_ _03598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11523_ _03598_ _00005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11524_ idx1\[1\] _03599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_11525_ _03599_ _03600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11526_ idx1\[2\] _03601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_11527_ idx1\[0\] _03602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11528_ _03601_ _03602_ _03603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11529_ _03602_ _03604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11530_ idx1\[2\] _03604_ _03605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11531_ samples_real\[3\]\[0\] _03603_ _03605_ samples_real\[6\]\[0\]
+ _03606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11532_ _03600_ _03606_ _03607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11533_ samples_real\[4\]\[0\] samples_real\[5\]\[0\] _03602_
+ _03608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11534_ _03602_ _03609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11535_ _03609_ samples_real\[7\]\[0\] _03610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11536_ idx1\[1\] _03611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11537_ _03608_ _03610_ _03611_ _03612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11538_ _03609_ _03613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11539_ samples_real\[1\]\[0\] _03614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11540_ _03604_ samples_real\[2\]\[0\] _03615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11541_ _03613_ _03614_ _03615_ _03611_ _03616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11542_ _03601_ _03617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11543_ _03612_ _03616_ _03617_ _03618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11544_ _03599_ _03604_ _03619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11545_ _03601_ _03619_ _03620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11546_ _03607_ _03618_ _03620_ samples_real\[0\]\[0\] _07704_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_11547_ samples_real\[4\]\[1\] samples_real\[5\]\[1\] samples_real\[6\]\[1\]
+ samples_real\[7\]\[1\] _03609_ _03611_ _03621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11548_ _03611_ _03622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11549_ samples_real\[2\]\[1\] samples_real\[3\]\[1\] _03609_
+ _03623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11550_ _03623_ _03624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11551_ _03599_ _03602_ _03625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11552_ _03625_ _03626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11553_ samples_real\[1\]\[1\] _03627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11554_ _03622_ _03624_ _03626_ _03627_ _03628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11555_ _03621_ _03628_ _03601_ _03629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11556_ samples_real\[0\]\[1\] _03620_ _03629_ _05853_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11557_ temp_real\[0\] _05852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
X_11558_ _05861_ _05858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11559_ stage\[1\] _07774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_11560_ butterfly_in_group\[0\] butterfly_in_group\[1\] stage\[0\]
+ _03630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11561_ _07787_ stage\[1\] _03630_ _03631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11562_ stage\[0\] _07773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_11563_ _00567_ _07773_ butterfly_in_group\[2\] _07774_ _03632_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11564_ _03631_ _03632_ _03633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11565_ _00581_ _03594_ _03634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11566_ _07789_ net81 _03634_ _03635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11567_ _03635_ _03636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11568_ twiddle_idx\[0\] _03633_ _03636_ _00000_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_11569_ butterfly_in_group\[0\] butterfly_in_group\[2\] stage\[1\]
+ _03637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11570_ butterfly_in_group\[1\] stage\[1\] _03638_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11571_ _03637_ _03638_ _07773_ _03639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11572_ _07787_ _03639_ _03640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11573_ twiddle_idx\[1\] _03640_ _03636_ _00007_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_11574_ _00000_ _00007_ _00021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11575_ _00021_ _00018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11576_ _00000_ _00007_ _00020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11577_ _00018_ _00020_ _00001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11578_ _00007_ _00002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11579_ _03620_ _03641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11580_ _03613_ _03642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11581_ _03642_ _03643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11582_ _03622_ _03644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11583_ _03644_ _03645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11584_ samples_imag\[4\]\[0\] samples_imag\[5\]\[0\] samples_imag\[6\]\[0\]
+ samples_imag\[7\]\[0\] _03643_ _03645_ _03646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11585_ samples_imag\[1\]\[0\] _03647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11586_ _03626_ _03648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11587_ _03609_ _03649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11588_ _03649_ _03650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11589_ samples_imag\[2\]\[0\] samples_imag\[3\]\[0\] _03650_
+ _03651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11590_ _03651_ _03652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11591_ _03647_ _03648_ _03652_ _03645_ _03653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11592_ _03617_ _03654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11593_ _03654_ _03655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11594_ _03646_ _03653_ _03655_ _03656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11595_ samples_imag\[0\]\[0\] _03641_ _03656_ _07818_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11596_ samples_imag\[3\]\[1\] _03603_ _03605_ samples_imag\[6\]\[1\]
+ _03657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11597_ _03600_ _03657_ _03658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11598_ samples_imag\[4\]\[1\] samples_imag\[5\]\[1\] _03642_
+ _03659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11599_ _03650_ samples_imag\[7\]\[1\] _03660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11600_ _03622_ _03661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11601_ _03659_ _03660_ _03661_ _03662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11602_ samples_imag\[1\]\[1\] _03663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11603_ _03604_ _03664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11604_ _03664_ _03665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11605_ _03665_ samples_imag\[2\]\[1\] _03666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11606_ _03643_ _03663_ _03666_ _03645_ _03667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11607_ _03662_ _03667_ _03655_ _03668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11608_ samples_imag\[0\]\[1\] _03641_ _03658_ _03668_ _05868_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
X_11609_ temp_imag\[0\] _05867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
X_11610_ _05876_ _05873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11611_ _07787_ _07773_ _07774_ _03669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11612_ group\[0\] _02507_ _03669_ _07883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11613_ group\[1\] _02507_ _03669_ _07885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11614_ _07790_ _03670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11615_ group\[0\] _07777_ _03670_ _03669_ _07888_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11616_ idx2\[1\] _03671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11617_ _03671_ _03672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11618_ _03672_ _03673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11619_ idx2\[0\] _03674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11620_ _03674_ _03675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11621_ _03675_ _03676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11622_ idx2\[2\] _03677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11623_ _03677_ _03678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11624_ _03678_ _03679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11625_ _03679_ _03680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11626_ samples_real\[2\]\[12\] samples_real\[3\]\[12\] samples_real\[6\]\[12\]
+ samples_real\[7\]\[12\] _03676_ _03680_ _03681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11627_ _03673_ _03681_ _03682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11628_ _03674_ _03683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_11629_ _03683_ _03684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11630_ _03684_ _03685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11631_ samples_real\[1\]\[12\] samples_real\[5\]\[12\] _03680_
+ _03686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11632_ _03677_ _03687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_11633_ _03687_ _03688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11634_ _03688_ _03689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11635_ _03676_ _03689_ samples_real\[4\]\[12\] _03690_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11636_ idx2\[1\] _03691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_11637_ _03691_ _03692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11638_ _03692_ _03693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11639_ _03685_ _03686_ _03690_ _03693_ _03694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11640_ _03683_ _03687_ _03695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11641_ _03695_ _03696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11642_ _03692_ _03696_ _03697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11643_ _03697_ _03698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_11644_ samples_real\[0\]\[12\] _03699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11645_ _03682_ _03694_ _03698_ _03699_ _03700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11646_ _00010_ _03700_ _05917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11647_ _03688_ samples_imag\[4\]\[12\] _03701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11648_ _03689_ samples_imag\[1\]\[12\] _03701_ _03684_ _03702_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11649_ _03691_ _03678_ _03703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11650_ _03671_ _03687_ _03704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11651_ samples_imag\[5\]\[12\] _03703_ _03704_ samples_imag\[3\]\[12\]
+ _03705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11652_ idx2\[1\] _03677_ _03706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11653_ _03706_ _03707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11654_ samples_imag\[6\]\[12\] samples_imag\[7\]\[12\] _03675_
+ _03708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11655_ samples_imag\[2\]\[12\] _03696_ _03707_ _03708_ _03709_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11656_ _03672_ _03702_ _03705_ _03684_ _03709_ _03710_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11657_ _03692_ _03695_ _03711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11658_ _03711_ _03712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_11659_ samples_imag\[0\]\[12\] _03712_ _03713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11660_ _03710_ _03713_ _03714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11661_ _00008_ _03714_ _07908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11662_ _00010_ _03715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_11663_ samples_real\[5\]\[11\] _03703_ _03704_ samples_real\[3\]\[11\]
+ _03716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11664_ _03687_ _03717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11665_ _03687_ samples_real\[4\]\[11\] _03718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11666_ _03717_ samples_real\[1\]\[11\] _03718_ _03683_ _03719_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11667_ samples_real\[6\]\[11\] samples_real\[7\]\[11\] _03674_
+ _03720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11668_ samples_real\[2\]\[11\] _03696_ _03706_ _03720_ _03721_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11669_ _03684_ _03716_ _03719_ _03671_ _03721_ _03722_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11670_ samples_real\[0\]\[11\] _03711_ _03723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11671_ _03722_ _03723_ _03724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11672_ _03715_ _03724_ _05922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11673_ _05922_ _05881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11674_ _00008_ _03725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11675_ _03725_ _03726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11676_ samples_imag\[0\]\[11\] _03727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11677_ _03698_ _03728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_11678_ _03676_ _03729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_11679_ _03729_ _03730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11680_ _03680_ _03731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11681_ samples_imag\[2\]\[11\] samples_imag\[3\]\[11\] samples_imag\[6\]\[11\]
+ samples_imag\[7\]\[11\] _03730_ _03731_ _03732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11682_ _03673_ _03732_ _03733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11683_ samples_imag\[1\]\[11\] samples_imag\[5\]\[11\] _03731_
+ _03734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11684_ _03689_ _03735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11685_ _03730_ _03735_ samples_imag\[4\]\[11\] _03736_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11686_ _03693_ _03737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11687_ _03685_ _03734_ _03736_ _03737_ _03738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11688_ _03727_ _03728_ _03733_ _03738_ _03739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11689_ _03726_ _03739_ _05882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11690_ _03725_ _03740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11691_ samples_imag\[0\]\[10\] _03741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11692_ samples_imag\[3\]\[10\] samples_imag\[7\]\[10\] _03731_
+ _03742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11693_ _03673_ _03730_ _03742_ _03743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_11694_ samples_imag\[4\]\[10\] samples_imag\[5\]\[10\] _03729_
+ _03744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11695_ _03671_ _03683_ _03745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11696_ _03737_ _03744_ _03745_ samples_imag\[6\]\[10\] _03746_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11697_ _03685_ samples_imag\[2\]\[10\] _03747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11698_ _03685_ samples_imag\[1\]\[10\] _03747_ _03737_ _03748_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_11699_ _03746_ _03748_ _03735_ _03749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11700_ _03741_ _03728_ _03743_ _03749_ _03750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11701_ _03740_ _03750_ _05891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11702_ _05891_ _05883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11703_ samples_imag\[0\]\[9\] _03751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_11704_ _03674_ _03706_ _03752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11705_ _03752_ _03753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11706_ _03691_ _03674_ _03754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11707_ _03687_ _03754_ _03755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11708_ samples_imag\[7\]\[9\] _03753_ _03755_ samples_imag\[1\]\[9\]
+ _03756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11709_ _03683_ _03677_ _03757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11710_ _03757_ _03758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11711_ _03691_ _03758_ _03759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11712_ _03759_ _03760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11713_ idx2\[1\] _03695_ _03761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11714_ _03761_ _03762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11715_ samples_imag\[4\]\[9\] _03760_ _03762_ samples_imag\[2\]\[9\]
+ _03763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11716_ _03674_ _03687_ _03764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11717_ samples_imag\[6\]\[9\] _03758_ _03764_ samples_imag\[3\]\[9\]
+ _03765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11718_ _03674_ _03678_ _03766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11719_ _03766_ _03767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11720_ samples_imag\[5\]\[9\] _03767_ _03696_ _03768_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11721_ _03765_ _03768_ _03693_ _03769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11722_ _03756_ _03763_ _03769_ _03770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11723_ _03751_ _03698_ _03770_ _03771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11724_ _03725_ _03771_ _05892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11725_ _05892_ _05907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11726_ samples_real\[0\]\[10\] _03772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_11727_ samples_real\[7\]\[10\] _03753_ _03755_ samples_real\[1\]\[10\]
+ _03773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11728_ samples_real\[4\]\[10\] _03760_ _03762_ samples_real\[2\]\[10\]
+ _03774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11729_ samples_real\[6\]\[10\] _03758_ _03764_ samples_real\[3\]\[10\]
+ _03775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11730_ samples_real\[5\]\[10\] _03767_ _03696_ _03776_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11731_ _03775_ _03776_ _03693_ _03777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11732_ _03773_ _03774_ _03777_ _03778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11733_ _03772_ _03698_ _03778_ _03779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11734_ _00010_ _03779_ _05964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11735_ _05964_ _05893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11736_ samples_imag\[0\]\[8\] _03780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_11737_ samples_imag\[4\]\[8\] samples_imag\[5\]\[8\] _03674_
+ _03781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11738_ _03675_ samples_imag\[7\]\[8\] _03782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11739_ _03781_ _03782_ _03671_ _03783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11740_ samples_imag\[6\]\[8\] _03758_ _03764_ samples_imag\[3\]\[8\]
+ _03784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11741_ _03683_ samples_imag\[2\]\[8\] _03785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11742_ _03684_ samples_imag\[1\]\[8\] _03785_ _03692_ _03786_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_11743_ _03692_ _03784_ _03786_ _03679_ _03787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_11744_ _03680_ _03783_ _03787_ _03788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11745_ _03780_ _03697_ _03788_ _03789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11746_ _03726_ _03789_ _05908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11747_ samples_imag\[0\]\[7\] _03790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11748_ samples_imag\[2\]\[7\] samples_imag\[3\]\[7\] samples_imag\[6\]\[7\]
+ samples_imag\[7\]\[7\] _03675_ _03680_ _03791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11749_ _03672_ _03791_ _03792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11750_ samples_imag\[1\]\[7\] samples_imag\[5\]\[7\] _03679_
+ _03793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11751_ _03676_ _03688_ samples_imag\[4\]\[7\] _03794_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11752_ _03684_ _03793_ _03794_ _03693_ _03795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11753_ _03790_ _03698_ _03792_ _03795_ _03796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11754_ _00008_ _03796_ _05950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11755_ samples_imag\[0\]\[6\] _03797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_11756_ _03735_ samples_imag\[1\]\[6\] _03767_ samples_imag\[5\]\[6\]
+ _03798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11757_ _03673_ _03798_ _03799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11758_ _03691_ _03687_ _03800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11759_ samples_imag\[6\]\[6\] _03707_ _03801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11760_ _03800_ _03801_ _03685_ _03802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11761_ samples_imag\[4\]\[6\] _03760_ _03762_ samples_imag\[2\]\[6\]
+ _03803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11762_ idx2\[1\] _03674_ _03804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11763_ _03677_ _03804_ _03805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_11764_ _03805_ _03806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11765_ samples_imag\[7\]\[6\] _03753_ _03806_ samples_imag\[3\]\[6\]
+ _03807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11766_ _03799_ _03802_ _03803_ _03807_ _03808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11767_ _03797_ _03728_ _03808_ _03809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11768_ _03740_ _03809_ _06040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11769_ _06040_ _06093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_11770_ _03688_ samples_imag\[2\]\[4\] _03707_ samples_imag\[6\]\[4\]
+ _03810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11771_ samples_imag\[5\]\[4\] _03766_ _03696_ _03811_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11772_ samples_imag\[4\]\[4\] _03759_ _03806_ samples_imag\[3\]\[4\]
+ _03812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11773_ samples_imag\[7\]\[4\] _03752_ _03755_ samples_imag\[1\]\[4\]
+ _03813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11774_ _03812_ _03813_ _03814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11775_ _03676_ _03810_ _03811_ _03671_ _03814_ _03815_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11776_ samples_imag\[0\]\[4\] _03711_ _03816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11777_ _03815_ _03816_ _03817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11778_ _03726_ _03817_ _06145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11779_ samples_real\[0\]\[9\] _03818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11780_ samples_real\[7\]\[9\] _03753_ _03806_ samples_real\[3\]\[9\]
+ _03819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11781_ _03692_ _03767_ _03820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11782_ samples_real\[4\]\[9\] _03821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11783_ samples_real\[6\]\[9\] _03822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11784_ samples_real\[2\]\[9\] _03823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11785_ _03822_ _03823_ _03717_ _03824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11786_ _03821_ _03703_ _03824_ _03671_ _03676_ _03825_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_11787_ samples_real\[1\]\[9\] _03755_ _03820_ samples_real\[5\]\[9\]
+ _03825_ _03826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_11788_ _03818_ _03698_ _03819_ _03826_ _03827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11789_ _03715_ _03827_ _05927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11790_ _05927_ _05909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11791_ _03688_ samples_imag\[1\]\[5\] _03767_ samples_imag\[5\]\[5\]
+ _03828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11792_ samples_imag\[6\]\[5\] _03707_ _03800_ _03829_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11793_ samples_imag\[4\]\[5\] _03759_ _03762_ samples_imag\[2\]\[5\]
+ _03830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11794_ samples_imag\[7\]\[5\] _03752_ _03806_ samples_imag\[3\]\[5\]
+ _03831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11795_ _03830_ _03831_ _03832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11796_ _03672_ _03828_ _03829_ _03676_ _03832_ _03833_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11797_ samples_imag\[0\]\[5\] _03712_ _03834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11798_ _03833_ _03834_ _03835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11799_ _03725_ _03835_ _06094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11800_ samples_imag\[0\]\[3\] _03836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_11801_ samples_imag\[1\]\[3\] samples_imag\[5\]\[3\] _03678_
+ _03837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11802_ _03717_ samples_imag\[4\]\[3\] _03691_ _03838_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11803_ _03717_ samples_imag\[2\]\[3\] _03839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11804_ _03838_ _03839_ _03675_ _03840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11805_ samples_imag\[3\]\[3\] samples_imag\[7\]\[3\] _03677_
+ _03841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11806_ samples_imag\[6\]\[3\] _03758_ _03841_ _03674_ _03842_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11807_ _03692_ _03842_ _03843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11808_ _03754_ _03837_ _03840_ _03843_ _03844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_11809_ _03836_ _03697_ _03844_ _03845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11810_ _03740_ _03845_ _06255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11811_ _06255_ _06205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11812_ samples_imag\[0\]\[2\] _03846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_11813_ _03717_ samples_imag\[2\]\[2\] _03706_ samples_imag\[6\]\[2\]
+ _03847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11814_ _03675_ _03847_ _03848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11815_ samples_imag\[5\]\[2\] _03766_ _03849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11816_ _03696_ _03849_ _03692_ _03850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11817_ samples_imag\[4\]\[2\] _03760_ _03806_ samples_imag\[3\]\[2\]
+ _03851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11818_ samples_imag\[7\]\[2\] _03752_ _03755_ samples_imag\[1\]\[2\]
+ _03852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11819_ _03848_ _03850_ _03851_ _03852_ _03853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11820_ _03846_ _03697_ _03853_ _03854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11821_ _03725_ _03854_ _06256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11822_ _06256_ _06471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_11823_ samples_real\[0\]\[8\] _03855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11824_ samples_real\[4\]\[8\] samples_real\[5\]\[8\] _03729_
+ _03856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11825_ _03729_ samples_real\[7\]\[8\] _03857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11826_ _03856_ _03857_ _03673_ _03858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11827_ samples_real\[6\]\[8\] _03758_ _03764_ samples_real\[3\]\[8\]
+ _03859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11828_ samples_real\[1\]\[8\] _03860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11829_ _03729_ _03860_ _03672_ _03861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11830_ _03685_ samples_real\[2\]\[8\] _03861_ _03862_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11831_ _03693_ _03859_ _03862_ _03680_ _03863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_11832_ _03731_ _03858_ _03863_ _03864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11833_ _03855_ _03728_ _03864_ _03865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11834_ _03715_ _03865_ _05928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11835_ _05928_ _05951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11836_ samples_imag\[0\]\[1\] _03866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11837_ samples_imag\[3\]\[1\] samples_imag\[7\]\[1\] _03677_
+ _03867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11838_ _03678_ samples_imag\[5\]\[1\] _03868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11839_ _03867_ _03868_ _03691_ _03869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11840_ samples_imag\[2\]\[1\] samples_imag\[6\]\[1\] _03678_
+ _03870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11841_ _03717_ samples_imag\[4\]\[1\] _03683_ _03871_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11842_ _03717_ samples_imag\[1\]\[1\] _03872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11843_ _03871_ _03872_ _03671_ _03873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11844_ _03675_ _03869_ _03870_ _03745_ _03873_ _03874_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_11845_ _03866_ _03697_ _03874_ _03875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11846_ _03740_ _03875_ _06303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11847_ _06303_ _07898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_11848_ _00009_ _03876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11849_ _03876_ _03877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11850_ samples_real\[0\]\[13\] _03878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11851_ samples_real\[1\]\[13\] samples_real\[5\]\[13\] _03678_
+ _03879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11852_ _03717_ samples_real\[4\]\[13\] _03691_ _03880_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11853_ _03717_ samples_real\[2\]\[13\] _03881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11854_ _03880_ _03881_ _03675_ _03882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11855_ samples_real\[3\]\[13\] samples_real\[7\]\[13\] _03677_
+ _03883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11856_ samples_real\[6\]\[13\] _03758_ _03883_ _03675_ _03884_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11857_ _03692_ _03884_ _03885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11858_ _03754_ _03879_ _03882_ _03885_ _03886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_11859_ _03878_ _03697_ _03886_ _03887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11860_ _03877_ _03887_ _05924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11861_ samples_real\[0\]\[7\] _03888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11862_ _03688_ samples_real\[2\]\[7\] _03707_ samples_real\[6\]\[7\]
+ _03889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11863_ _03676_ _03889_ _03890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11864_ samples_real\[5\]\[7\] _03767_ _03891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11865_ _03696_ _03891_ _03693_ _03892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11866_ samples_real\[4\]\[7\] _03760_ _03806_ samples_real\[3\]\[7\]
+ _03893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11867_ samples_real\[7\]\[7\] _03753_ _03755_ samples_real\[1\]\[7\]
+ _03894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11868_ _03890_ _03892_ _03893_ _03894_ _03895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11869_ _03888_ _03698_ _03895_ _03896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11870_ _00010_ _03896_ _05969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11871_ _05969_ _05972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11872_ _00012_ _03897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11873_ _03897_ _03898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11874_ _03898_ _03724_ _05965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11875_ _03735_ samples_real\[1\]\[6\] _03767_ samples_real\[5\]\[6\]
+ _03899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11876_ samples_real\[6\]\[6\] _03707_ _03800_ _03900_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11877_ samples_real\[4\]\[6\] _03760_ _03762_ samples_real\[2\]\[6\]
+ _03901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11878_ samples_real\[7\]\[6\] _03753_ _03806_ samples_real\[3\]\[6\]
+ _03902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11879_ _03901_ _03902_ _03903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11880_ _03673_ _03899_ _03900_ _03730_ _03903_ _03904_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11881_ _03712_ _03905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11882_ samples_real\[0\]\[6\] _03905_ _03906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11883_ _03904_ _03906_ _03907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11884_ _03715_ _03907_ _05932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11885_ _05932_ _06095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11886_ samples_real\[0\]\[5\] _03908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11887_ samples_real\[6\]\[5\] samples_real\[7\]\[5\] _03730_
+ _03909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11888_ samples_real\[1\]\[5\] _03755_ _03909_ _03707_ _03910_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11889_ samples_real\[5\]\[5\] _03703_ _03704_ samples_real\[3\]\[5\]
+ _03911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11890_ _03735_ samples_real\[4\]\[5\] _03912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11891_ _03735_ samples_real\[2\]\[5\] _03912_ _03737_ _03913_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11892_ _03911_ _03913_ _03685_ _03914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11893_ _03908_ _03728_ _03910_ _03914_ _03915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11894_ _00011_ _03915_ _05933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11895_ samples_imag\[0\]\[0\] _03916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11896_ samples_imag\[3\]\[0\] samples_imag\[7\]\[0\] _03677_
+ _03917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11897_ _03677_ samples_imag\[5\]\[0\] _03918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11898_ _03917_ _03918_ _03691_ _03919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11899_ samples_imag\[2\]\[0\] samples_imag\[6\]\[0\] _03678_
+ _03920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11900_ _03687_ samples_imag\[4\]\[0\] _03683_ _03921_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11901_ _03687_ samples_imag\[1\]\[0\] _03922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11902_ _03921_ _03922_ _03671_ _03923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11903_ _03675_ _03919_ _03920_ _03745_ _03923_ _03924_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_11904_ _03916_ _03697_ _03924_ _03925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11905_ _00008_ _03925_ _06337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11906_ _06337_ _06341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11907_ _03877_ _03724_ _06051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11908_ _03715_ _03915_ _06065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11909_ _06065_ _05974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_11910_ samples_real\[0\]\[4\] _03926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11911_ samples_real\[2\]\[4\] samples_real\[3\]\[4\] samples_real\[6\]\[4\]
+ samples_real\[7\]\[4\] _03730_ _03731_ _03927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11912_ _03673_ _03927_ _03928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11913_ samples_real\[1\]\[4\] samples_real\[5\]\[4\] _03731_
+ _03929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11914_ _03730_ _03735_ samples_real\[4\]\[4\] _03930_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11915_ _03685_ _03929_ _03930_ _03737_ _03931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11916_ _03926_ _03728_ _03928_ _03931_ _03932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11917_ _03715_ _03932_ _06011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11918_ _06011_ _05987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_11919_ _00011_ _03933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11920_ samples_real\[0\]\[3\] _03934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11921_ samples_real\[7\]\[3\] _03753_ _03755_ samples_real\[1\]\[3\]
+ _03935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11922_ samples_real\[4\]\[3\] _03760_ _03762_ samples_real\[2\]\[3\]
+ _03936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11923_ samples_real\[6\]\[3\] _03758_ _03764_ samples_real\[3\]\[3\]
+ _03937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11924_ samples_real\[5\]\[3\] _03767_ _03696_ _03938_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11925_ _03937_ _03938_ _03737_ _03939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11926_ _03935_ _03936_ _03939_ _03940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11927_ _03934_ _03728_ _03940_ _03941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11928_ _03933_ _03941_ _05988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11929_ _05988_ _06001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11930_ _03688_ samples_real\[1\]\[2\] _03766_ samples_real\[5\]\[2\]
+ _03942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11931_ samples_real\[6\]\[2\] _03706_ _03800_ _03943_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11932_ samples_real\[4\]\[2\] _03759_ _03762_ samples_real\[2\]\[2\]
+ _03944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11933_ samples_real\[7\]\[2\] _03752_ _03805_ samples_real\[3\]\[2\]
+ _03945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11934_ _03944_ _03945_ _03946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11935_ _03672_ _03942_ _03943_ _03676_ _03946_ _03947_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11936_ samples_real\[0\]\[2\] _03711_ _03948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11937_ _03947_ _03948_ _03949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11938_ _03933_ _03949_ _05989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11939_ _05989_ _06170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11940_ _00010_ _03950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11941_ _03950_ _03941_ _05997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11942_ _05997_ _06169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11943_ _03735_ samples_real\[4\]\[1\] _03951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11944_ _03735_ samples_real\[2\]\[1\] _03951_ _03737_ _03952_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11945_ samples_real\[3\]\[1\] samples_real\[7\]\[1\] _03731_
+ _03953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11946_ samples_real\[6\]\[1\] _03758_ _03953_ _03730_ _03954_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11947_ samples_real\[1\]\[1\] samples_real\[5\]\[1\] _03731_
+ _03955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11948_ _03754_ _03955_ _03956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11949_ _03730_ _03952_ _03954_ _03737_ _03956_ _03957_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11950_ samples_real\[0\]\[1\] _03905_ _03958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11951_ _03957_ _03958_ _03959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11952_ _03933_ _03959_ _05998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11953_ _05998_ _06002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11954_ _03950_ _03949_ _06016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11955_ _06016_ _06003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_11956_ samples_real\[0\]\[0\] _03960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11957_ samples_real\[3\]\[0\] samples_real\[7\]\[0\] _03678_
+ _03961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11958_ _03679_ samples_real\[5\]\[0\] _03962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11959_ _03961_ _03962_ _03692_ _03963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11960_ samples_real\[2\]\[0\] samples_real\[6\]\[0\] _03679_
+ _03964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11961_ _03688_ samples_real\[4\]\[0\] _03684_ _03965_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11962_ _03688_ samples_real\[1\]\[0\] _03966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11963_ _03965_ _03966_ _03671_ _03967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11964_ _03729_ _03963_ _03964_ _03745_ _03967_ _03968_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_11965_ _03960_ _03698_ _03968_ _03969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11966_ _03933_ _03969_ _06017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11967_ _06017_ _06171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11968_ _03950_ _03959_ _06404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11969_ _06404_ _06172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_11970_ samples_imag\[0\]\[13\] _03970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_11971_ samples_imag\[3\]\[13\] samples_imag\[7\]\[13\] _03679_
+ _03971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11972_ _03679_ samples_imag\[5\]\[13\] _03972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11973_ _03971_ _03972_ _03693_ _03973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11974_ samples_imag\[2\]\[13\] samples_imag\[6\]\[13\] _03680_
+ _03974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11975_ _03689_ samples_imag\[4\]\[13\] _03684_ _03975_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11976_ _03689_ samples_imag\[1\]\[13\] _03976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11977_ _03975_ _03976_ _03672_ _03977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11978_ _03729_ _03973_ _03974_ _03745_ _03977_ _03978_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_11979_ _03970_ _03698_ _03978_ _03979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11980_ _03725_ _03979_ _07909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11981_ _03950_ _03969_ _06435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11982_ _06435_ _06352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_11983_ _03877_ _03779_ _06104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11984_ _03898_ _03865_ _06153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11985_ _03877_ _03865_ _06214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11986_ _03876_ _03980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11987_ _03980_ _03896_ _06264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11988_ _03980_ _03907_ _06311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11989_ _03898_ _03932_ _06348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11990_ _03898_ _03949_ _06405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11991_ _03980_ _03932_ _08021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11992_ _03898_ _03959_ _06436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11993_ _03980_ _03959_ _08052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11994_ _03898_ _03969_ _08053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11995_ _08039_ _07926_ _06441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11996_ _00009_ _03969_ _03981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11997_ _03981_ _08090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11998_ _08078_ _06301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11999_ _06301_ _08082_ _06488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12000_ _03933_ _03925_ _06856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12001_ _06856_ _08101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12002_ _03726_ _03887_ _08102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12003_ _00011_ _03875_ _06501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12004_ _06501_ _06799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12005_ _00010_ _03854_ _06567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12006_ _06567_ _06683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12007_ _03715_ _03875_ _06496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12008_ _06496_ _06631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12009_ _03933_ _03854_ _06632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12010_ _06632_ _06497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12011_ _00011_ _03845_ _06568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12012_ _06568_ _06498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12013_ _03933_ _03817_ _06533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12014_ _00010_ _03835_ _06534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12015_ _06534_ _06745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12016_ _00010_ _03817_ _06505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12017_ _06505_ _06569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_12018_ _00011_ _03835_ _06506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12019_ _06506_ _06577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12020_ _03950_ _03809_ _06578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12021_ _06578_ _06507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12022_ _03740_ _03700_ _06613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12023_ _06613_ _06616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12024_ _00011_ _03809_ _08107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12025_ _08107_ _06546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12026_ _03950_ _03796_ _06547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12027_ _06547_ _06691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12028_ _03933_ _03796_ _06520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12029_ _03950_ _03789_ _06521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12030_ _06521_ _06692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12031_ _03950_ _03771_ _06522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12032_ _06522_ _06515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12033_ _03950_ _03750_ _06580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12034_ _06580_ _06516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12035_ _03715_ _03739_ _06517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12036_ _03715_ _03714_ _06525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12037_ _03740_ _03724_ _06600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12038_ _06600_ _06663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12039_ _03898_ _03979_ _08111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12040_ _03689_ samples_imag\[1\]\[14\] _03767_ samples_imag\[5\]\[14\]
+ _03982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12041_ samples_imag\[6\]\[14\] _03707_ _03800_ _03983_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12042_ samples_imag\[4\]\[14\] _03760_ _03762_ samples_imag\[2\]\[14\]
+ _03984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12043_ samples_imag\[7\]\[14\] _03753_ _03806_ samples_imag\[3\]\[14\]
+ _03985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12044_ _03984_ _03985_ _03986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12045_ _03672_ _03982_ _03983_ _03729_ _03986_ _03987_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12046_ samples_imag\[0\]\[14\] _03712_ _03988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12047_ _03987_ _03988_ _03989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12048_ _03980_ _03989_ _08112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12049_ _00008_ _03949_ _06918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12050_ _06918_ _06699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_12051_ _03726_ _03959_ _06748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12052_ _03726_ _03932_ _08116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12053_ _08116_ _06823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_12054_ _03726_ _03779_ _06601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12055_ _03725_ _03969_ _06803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12056_ _03740_ _03941_ _06873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12057_ _06873_ _06961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_12058_ _03740_ _03915_ _06767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12059_ _06767_ _06956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_12060_ _03725_ _03896_ _08126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12061_ _08126_ _06667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_12062_ _03740_ _03865_ _06668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12063_ _06668_ _06618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_12064_ _03726_ _03907_ _06719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12065_ _06719_ _06913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_12066_ _03726_ _03827_ _06605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12067_ _06605_ _06602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_12068_ _08305_ _06803_ _08306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12069_ _07789_ _03990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12070_ _03594_ _03990_ _03991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12071_ _03991_ _00003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12072_ _03933_ _03907_ _05973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12073_ _03933_ _03932_ _05975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12074_ _07912_ _06069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12075_ _08125_ _06606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12076_ _06676_ _06725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12077_ _08181_ _06810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12078_ _08195_ _06865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12079_ _06868_ _06875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12080_ _06842_ _06884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12081_ _06849_ _06892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12082_ _06901_ _06903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12083_ _08212_ _06908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12084_ _08226_ _06951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12085_ _08244_ _06997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12086_ _06900_ _06897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12087_ _08246_ _07039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12088_ _03898_ _03887_ _05918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12089_ _07918_ _06021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12090_ _07950_ _06222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12091_ _07961_ _06272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12092_ _06466_ _06463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12093_ _06476_ _06472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12094_ _08084_ _06492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12095_ _08122_ _06628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12096_ _08140_ _06659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12097_ _08153_ _06712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12098_ _08165_ _06760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12099_ _08178_ _06816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12100_ _08183_ _06847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12101_ _06874_ _06914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12102_ _06934_ _06931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12103_ _08276_ _07040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12104_ _07065_ _07062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12105_ _08287_ _07067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12106_ _07075_ _07070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12107_ _07701_ _05854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12108_ _07815_ _05869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12109_ samples_real\[0\]\[14\] _03992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12110_ samples_real\[3\]\[14\] samples_real\[7\]\[14\] _03679_
+ _03993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12111_ _03679_ samples_real\[5\]\[14\] _03994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12112_ _03993_ _03994_ _03693_ _03995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12113_ samples_real\[2\]\[14\] samples_real\[6\]\[14\] _03680_
+ _03996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12114_ _03689_ samples_real\[4\]\[14\] _03684_ _03997_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12115_ _03689_ samples_real\[1\]\[14\] _03998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12116_ _03997_ _03998_ _03672_ _03999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12117_ _03729_ _03995_ _03996_ _03745_ _03999_ _04000_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_12118_ _03992_ _03698_ _04000_ _04001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12119_ _03877_ _04001_ _05919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12120_ _03877_ _03700_ _05966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12121_ _03877_ _03827_ _06154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12122_ _07949_ _06223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12123_ _07960_ _06273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12124_ _03877_ _03915_ _06349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12125_ _03877_ _03941_ _06406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12126_ _03877_ _03949_ _06437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12127_ _06454_ _06464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12128_ _06477_ _06473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12129_ _08133_ _06608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12130_ _08121_ _06629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12131_ _08139_ _06660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12132_ _08152_ _06713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12133_ _08164_ _06761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12134_ _08186_ _06812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12135_ _08177_ _06817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12136_ _08182_ _06848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12137_ _08201_ _06867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12138_ _06869_ _06894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12139_ _08217_ _06910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12140_ _06919_ _06915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12141_ _03950_ _03845_ _06535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12142_ _08231_ _06953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12143_ _08251_ _06999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12144_ _08257_ _07019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12145_ _08286_ _07068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12146_ _05926_ _07906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12147_ _05938_ _05961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12148_ _05963_ _05983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12149_ _06019_ _06070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12150_ _06053_ _07933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12151_ _06057_ _06100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12152_ _06106_ _07942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12153_ _06109_ _06150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12154_ _06160_ _06210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12155_ _06164_ _06176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12156_ _06167_ _06221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12157_ _06216_ _07965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12158_ _06220_ _06260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12159_ _06250_ _07974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12160_ _06266_ _07976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12161_ _06270_ _06307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12162_ _06298_ _07984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12163_ _06302_ _07986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12164_ _06313_ _07989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12165_ _06317_ _06345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12166_ _06340_ _08018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12167_ _06378_ _08007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12168_ _06401_ _08022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12169_ _06425_ _08042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12170_ _06432_ _08033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12171_ _06500_ _08105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12172_ _06509_ _06511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12173_ _06532_ _06559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12174_ _06545_ _06551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12175_ _06566_ _06623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12176_ _06586_ _06625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12177_ _06590_ _06596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12178_ _06604_ _06611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12179_ _06649_ _06655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12180_ _06682_ _06733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12181_ _06702_ _06707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12182_ _06739_ _06785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12183_ _06758_ _06787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12184_ _06793_ _06843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12185_ _06805_ _06811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12186_ _06830_ _06841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12187_ _06879_ _06890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12188_ _06896_ _06935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12189_ _06925_ _06937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12190_ _06943_ _06977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12191_ _06962_ _06991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12192_ _06967_ _06979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12193_ _07038_ _07041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12194_ _05925_ _07901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12195_ _05999_ _05994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12196_ _05981_ _05978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12197_ _06018_ _06014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12198_ _06052_ _07920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12199_ _06105_ _07934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12200_ _06215_ _07954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12201_ _06265_ _07966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12202_ _06297_ _07975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12203_ _06312_ _07977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12204_ _06339_ _07987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12205_ _06377_ _07992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12206_ _06400_ _08008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12207_ _06424_ _08019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12208_ _06431_ _08023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12209_ _06503_ _06510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12210_ _06540_ _06550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12211_ _06565_ _06560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12212_ _06574_ _06552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12213_ _06585_ _06595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12214_ _06617_ _06612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12215_ _06644_ _06654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12216_ _06648_ _06597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12217_ _06681_ _06677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12218_ _06697_ _06706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12219_ _06701_ _06656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12220_ _06738_ _06734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12221_ _06750_ _06708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12222_ _06757_ _06770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12223_ _06792_ _06786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12224_ _06895_ _06889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12225_ _06942_ _06936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12226_ _06984_ _06978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12227_ _06995_ _06992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12228_ _07680_ _07082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_16
X_12229_ samples_real\[4\]\[14\] samples_real\[5\]\[14\] samples_real\[6\]\[14\]
+ samples_real\[7\]\[14\] _03609_ _03611_ _04002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12230_ samples_real\[1\]\[14\] _04003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12231_ samples_real\[2\]\[14\] samples_real\[3\]\[14\] _03609_
+ _04004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12232_ _04004_ _04005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12233_ _04003_ _03626_ _04005_ _03622_ _04006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12234_ _04002_ _04006_ _03617_ _04007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12235_ _03601_ _03619_ _04008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12236_ _03992_ _04008_ _04009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12237_ _04007_ _04009_ _07691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12238_ _04008_ _04010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12239_ idx1\[2\] _03611_ _04011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12240_ _03613_ _04011_ _04012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12241_ _04012_ _04013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12242_ _03601_ idx1\[1\] _04014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12243_ _04014_ _04015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12244_ _03613_ _04015_ _04016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12245_ _04016_ _04017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12246_ samples_real\[7\]\[13\] _04013_ _04017_ samples_real\[3\]\[13\]
+ _04018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12247_ idx1\[2\] _03626_ _04019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12248_ _04019_ _04020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12249_ _03601_ _03626_ _04021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12250_ _04021_ _04022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12251_ samples_real\[5\]\[13\] _04020_ _04022_ samples_real\[1\]\[13\]
+ _04023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12252_ samples_real\[4\]\[13\] samples_real\[6\]\[13\] _03622_
+ _04024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12253_ idx1\[2\] _03599_ samples_real\[2\]\[13\] _04025_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12254_ _03617_ _04024_ _04025_ _03664_ _04026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12255_ _04018_ _04023_ _04026_ _04027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12256_ _03878_ _04010_ _04027_ _07696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12257_ samples_real\[3\]\[15\] _03603_ _03605_ samples_real\[6\]\[15\]
+ _04028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12258_ _03599_ _04028_ _04029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12259_ samples_real\[4\]\[15\] samples_real\[5\]\[15\] _03602_
+ _04030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12260_ _03602_ samples_real\[7\]\[15\] _04031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12261_ _04030_ _04031_ idx1\[1\] _04032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12262_ samples_real\[1\]\[15\] _04033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12263_ _03604_ samples_real\[2\]\[15\] _04034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12264_ _03602_ _04033_ _04034_ idx1\[1\] _04035_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12265_ _04032_ _04035_ _03601_ _04036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12266_ samples_real\[0\]\[15\] _03620_ _04029_ _04036_ _04037_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_12267_ _04037_ _07706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12268_ _04010_ _04038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12269_ _03604_ _04011_ _04039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12270_ _04039_ _04040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12271_ _04040_ _04041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12272_ samples_real\[4\]\[12\] samples_real\[5\]\[12\] _03643_
+ _04042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12273_ _03643_ samples_real\[7\]\[12\] _04043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12274_ _03665_ samples_real\[1\]\[12\] _04044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12275_ samples_real\[2\]\[12\] samples_real\[3\]\[12\] _03650_
+ _04045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12276_ _04042_ _04043_ _04044_ _04045_ _03645_ _03655_ _04046_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12277_ samples_real\[6\]\[12\] _04041_ _04046_ _04047_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12278_ _03699_ _04038_ _04047_ _07710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12279_ samples_real\[4\]\[11\] samples_real\[5\]\[11\] samples_real\[6\]\[11\]
+ samples_real\[7\]\[11\] _03609_ _03611_ _04048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12280_ samples_real\[1\]\[11\] _04049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12281_ samples_real\[2\]\[11\] samples_real\[3\]\[11\] _03609_
+ _04050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12282_ _04050_ _04051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12283_ _04049_ _03626_ _04051_ _03611_ _04052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12284_ _04048_ _04052_ _03617_ _04053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12285_ samples_real\[0\]\[11\] _03620_ _04054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12286_ _04053_ _04054_ _07715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12287_ samples_real\[5\]\[10\] samples_real\[7\]\[10\] _03611_
+ _04055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12288_ _03622_ samples_real\[3\]\[10\] _04056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12289_ _04055_ _04056_ _03617_ _04057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12290_ idx1\[2\] _04058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12291_ samples_real\[2\]\[10\] samples_real\[6\]\[10\] _04058_
+ _04059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12292_ _03611_ _03604_ _04060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12293_ _03664_ samples_real\[1\]\[10\] _03617_ _04061_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12294_ _03664_ samples_real\[4\]\[10\] _04062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12295_ _04061_ _04062_ _03644_ _04063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12296_ _03643_ _04057_ _04059_ _04060_ _04063_ _04064_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_12297_ _03772_ _04010_ _04064_ _07720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12298_ samples_real\[7\]\[9\] _04013_ _04022_ samples_real\[1\]\[9\]
+ _04065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12299_ _03822_ _03821_ _03599_ _04066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12300_ _03823_ _04015_ _04066_ _04058_ _04067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12301_ samples_real\[3\]\[9\] _04017_ _04020_ samples_real\[5\]\[9\]
+ _03664_ _04067_ _04068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_12302_ _03818_ _04010_ _04065_ _04068_ _07725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12303_ samples_real\[4\]\[8\] samples_real\[5\]\[8\] samples_real\[6\]\[8\]
+ samples_real\[7\]\[8\] _03649_ _03622_ _04069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12304_ samples_real\[2\]\[8\] samples_real\[3\]\[8\] _03613_
+ _04070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12305_ _04070_ _04071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12306_ _03860_ _03626_ _04071_ _03644_ _04072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12307_ _04069_ _04072_ _03654_ _04073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12308_ _03855_ _04010_ _04074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12309_ _04073_ _04074_ _07730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12310_ _03604_ _04015_ _04075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12311_ _04075_ _04076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12312_ samples_real\[7\]\[7\] _04013_ _04076_ samples_real\[2\]\[7\]
+ _04077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12313_ idx1\[2\] _03619_ _04078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12314_ _04078_ _04079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12315_ samples_real\[1\]\[7\] _04021_ _04079_ samples_real\[4\]\[7\]
+ _04080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12316_ _03622_ _03649_ samples_real\[3\]\[7\] _04081_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12317_ samples_real\[5\]\[7\] _03626_ _04060_ samples_real\[6\]\[7\]
+ _04082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12318_ _04058_ _04082_ _04083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12319_ _04058_ _03619_ _04081_ _04083_ _04084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12320_ _04077_ _04080_ _04084_ _04085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12321_ _03888_ _04010_ _04085_ _07735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12322_ samples_real\[0\]\[6\] _03641_ _04086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12323_ _03664_ samples_real\[1\]\[6\] _04087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12324_ _03665_ samples_real\[4\]\[6\] _04087_ _03654_ _04088_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12325_ samples_real\[6\]\[6\] samples_real\[7\]\[6\] _03649_
+ _04089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12326_ samples_real\[5\]\[6\] _03648_ _04089_ _03661_ _04090_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12327_ samples_real\[2\]\[6\] samples_real\[3\]\[6\] _03649_
+ _04091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12328_ _04015_ _04091_ _04092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12329_ _03661_ _04088_ _04090_ _03654_ _04092_ _04093_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12330_ _04086_ _04093_ _07740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12331_ _04021_ _04094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12332_ samples_real\[6\]\[5\] samples_real\[7\]\[5\] _03642_
+ _04095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12333_ samples_real\[1\]\[5\] _04094_ _04095_ _04011_ _04096_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12334_ idx1\[2\] _03599_ _04097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12335_ samples_real\[3\]\[5\] _04015_ _04097_ samples_real\[5\]\[5\]
+ _04098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12336_ _03599_ samples_real\[2\]\[5\] _04099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12337_ _03600_ samples_real\[4\]\[5\] _04099_ _03617_ _04100_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12338_ _04098_ _04100_ _03664_ _04101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12339_ _03908_ _04010_ _04096_ _04101_ _07745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12340_ samples_real\[4\]\[4\] samples_real\[5\]\[4\] _03650_
+ _04102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12341_ _03643_ samples_real\[7\]\[4\] _04103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12342_ _03665_ samples_real\[1\]\[4\] _04104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12343_ samples_real\[2\]\[4\] samples_real\[3\]\[4\] _03650_
+ _04105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12344_ _04102_ _04103_ _04104_ _04105_ _03645_ _03655_ _04106_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12345_ samples_real\[6\]\[4\] _04041_ _04106_ _04107_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12346_ _03926_ _04038_ _04107_ _07750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12347_ samples_real\[4\]\[3\] samples_real\[5\]\[3\] samples_real\[6\]\[3\]
+ samples_real\[7\]\[3\] _03642_ _03661_ _04108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12348_ samples_real\[1\]\[3\] _04109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12349_ samples_real\[2\]\[3\] samples_real\[3\]\[3\] _03649_
+ _04110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12350_ _04110_ _04111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12351_ _04109_ _03648_ _04111_ _03661_ _04112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12352_ _04108_ _04112_ _03655_ _04113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12353_ _03934_ _04038_ _04114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12354_ _04113_ _04114_ _07755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12355_ samples_real\[3\]\[2\] _03603_ _03605_ samples_real\[6\]\[2\]
+ _04115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12356_ _03600_ _04115_ _04116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12357_ samples_real\[4\]\[2\] samples_real\[5\]\[2\] _03609_
+ _04117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12358_ _03613_ samples_real\[7\]\[2\] _04118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12359_ _04117_ _04118_ _03622_ _04119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12360_ samples_real\[1\]\[2\] _04120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12361_ _03664_ samples_real\[2\]\[2\] _04121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12362_ _03642_ _04120_ _04121_ _03644_ _04122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12363_ _04119_ _04122_ _03617_ _04123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12364_ samples_real\[0\]\[2\] _03641_ _04116_ _04123_ _04124_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_12365_ _04124_ _07760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12366_ _05853_ _05857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12367_ sample_count\[0\] _07797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12368_ samples_imag\[4\]\[14\] samples_imag\[5\]\[14\] samples_imag\[6\]\[14\]
+ samples_imag\[7\]\[14\] _03650_ _03661_ _04125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12369_ samples_imag\[1\]\[14\] _04126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12370_ samples_imag\[2\]\[14\] samples_imag\[3\]\[14\] _03649_
+ _04127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12371_ _04127_ _04128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12372_ _04126_ _03648_ _04128_ _03645_ _04129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12373_ _04125_ _04129_ _03655_ _04130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12374_ samples_imag\[0\]\[14\] _03641_ _04131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12375_ _04130_ _04131_ _07805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12376_ samples_imag\[2\]\[13\] samples_imag\[3\]\[13\] _03643_
+ _04132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12377_ _03665_ samples_imag\[1\]\[13\] _03655_ _04133_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12378_ _03665_ samples_imag\[4\]\[13\] _04134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12379_ _04133_ _04134_ _03645_ _04135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12380_ samples_imag\[5\]\[13\] _03648_ _04136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12381_ samples_imag\[6\]\[13\] samples_imag\[7\]\[13\] _03650_
+ _04137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12382_ _03645_ _04137_ _04138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12383_ _04136_ _04138_ _03655_ _04139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12384_ _04015_ _04132_ _04135_ _04139_ _04140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_12385_ _03970_ _04038_ _04140_ _07810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12386_ samples_imag\[4\]\[15\] samples_imag\[5\]\[15\] samples_imag\[6\]\[15\]
+ samples_imag\[7\]\[15\] _03602_ idx1\[1\] _04141_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12387_ samples_imag\[1\]\[15\] _04142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12388_ samples_imag\[2\]\[15\] samples_imag\[3\]\[15\] _03602_
+ _04143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12389_ _04143_ _04144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12390_ _04142_ _03626_ _04144_ idx1\[1\] _04145_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12391_ _04141_ _04145_ _03601_ _04146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12392_ samples_imag\[0\]\[15\] _03620_ _04147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12393_ _04146_ _04147_ _07820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12394_ samples_imag\[4\]\[12\] samples_imag\[5\]\[12\] samples_imag\[6\]\[12\]
+ samples_imag\[7\]\[12\] _03650_ _03661_ _04148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12395_ samples_imag\[1\]\[12\] _04149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12396_ samples_imag\[2\]\[12\] samples_imag\[3\]\[12\] _03649_
+ _04150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12397_ _04150_ _04151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12398_ _04149_ _03648_ _04151_ _03645_ _04152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12399_ _04148_ _04152_ _03655_ _04153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12400_ samples_imag\[0\]\[12\] _03641_ _04154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12401_ _04153_ _04154_ _07824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12402_ _04079_ _04155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12403_ samples_imag\[1\]\[11\] _04094_ _04155_ samples_imag\[4\]\[11\]
+ _04156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12404_ _04017_ _04157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12405_ _04020_ _04158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12406_ samples_imag\[3\]\[11\] _04157_ _04158_ samples_imag\[5\]\[11\]
+ _04159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12407_ samples_imag\[6\]\[11\] samples_imag\[7\]\[11\] _03650_
+ _04160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12408_ _04011_ _04160_ _04161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12409_ _03600_ samples_imag\[2\]\[11\] _03665_ _03655_ _04162_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12410_ _04156_ _04159_ _04161_ _04162_ _04163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12411_ _03727_ _04038_ _04163_ _07829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12412_ _04013_ _04164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12413_ samples_imag\[7\]\[10\] _04164_ _04094_ samples_imag\[1\]\[10\]
+ _04165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12414_ samples_imag\[2\]\[10\] _04166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12415_ samples_imag\[4\]\[10\] samples_imag\[6\]\[10\] _03644_
+ _04167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12416_ _03654_ _04167_ _04168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12417_ _04166_ _04015_ _04168_ _03643_ _04169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_12418_ samples_imag\[3\]\[10\] _04157_ _04158_ samples_imag\[5\]\[10\]
+ _04169_ _04170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_12419_ _03741_ _04038_ _04165_ _04170_ _07834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12420_ samples_imag\[6\]\[9\] samples_imag\[7\]\[9\] _03642_
+ _04171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12421_ samples_imag\[1\]\[9\] _04094_ _04171_ _04011_ _04172_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12422_ samples_imag\[3\]\[9\] _04015_ _04097_ samples_imag\[5\]\[9\]
+ _04173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12423_ _03600_ samples_imag\[2\]\[9\] _04174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12424_ _03600_ samples_imag\[4\]\[9\] _04174_ _03654_ _04175_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12425_ _04173_ _04175_ _03665_ _04176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12426_ _03751_ _04038_ _04172_ _04176_ _07839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12427_ samples_imag\[6\]\[8\] samples_imag\[7\]\[8\] _03642_
+ _04177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12428_ samples_imag\[1\]\[8\] _04094_ _04177_ _04011_ _04178_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12429_ samples_imag\[3\]\[8\] _04015_ _04097_ samples_imag\[5\]\[8\]
+ _04179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12430_ _03599_ samples_imag\[2\]\[8\] _04180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12431_ _03600_ samples_imag\[4\]\[8\] _04180_ _03654_ _04181_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12432_ _04179_ _04181_ _03665_ _04182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12433_ _03780_ _04038_ _04178_ _04182_ _07844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12434_ samples_imag\[4\]\[7\] samples_imag\[5\]\[7\] samples_imag\[6\]\[7\]
+ samples_imag\[7\]\[7\] _03642_ _03661_ _04183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12435_ samples_imag\[1\]\[7\] _04184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12436_ samples_imag\[2\]\[7\] samples_imag\[3\]\[7\] _03613_
+ _04185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12437_ _04185_ _04186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12438_ _04184_ _03648_ _04186_ _03661_ _04058_ _04187_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_12439_ _04058_ _04183_ _04187_ _04188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12440_ _03790_ _04038_ _04188_ _07849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12441_ _04076_ _04189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12442_ samples_imag\[5\]\[6\] samples_imag\[7\]\[6\] _03622_
+ _04190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12443_ _04058_ _03650_ _04190_ _04191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12444_ samples_imag\[2\]\[6\] _04189_ _04191_ _04192_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12445_ samples_imag\[3\]\[6\] _03603_ _03605_ samples_imag\[6\]\[6\]
+ _04193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12446_ _03664_ samples_imag\[1\]\[6\] _04194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12447_ _03664_ samples_imag\[4\]\[6\] _04194_ _03654_ _04195_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12448_ _04193_ _04195_ _03600_ _04196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12449_ _03797_ _04038_ _04192_ _04196_ _07854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12450_ samples_imag\[4\]\[5\] samples_imag\[5\]\[5\] samples_imag\[6\]\[5\]
+ samples_imag\[7\]\[5\] _03649_ _03644_ _04197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12451_ samples_imag\[1\]\[5\] _04198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12452_ samples_imag\[2\]\[5\] samples_imag\[3\]\[5\] _03613_
+ _04199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12453_ _04199_ _04200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12454_ _04198_ _03648_ _04200_ _03644_ _04201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12455_ _04197_ _04201_ _03654_ _04202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12456_ samples_imag\[0\]\[5\] _03641_ _04203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12457_ _04202_ _04203_ _07859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12458_ samples_imag\[4\]\[4\] samples_imag\[5\]\[4\] samples_imag\[6\]\[4\]
+ samples_imag\[7\]\[4\] _03649_ _03644_ _04204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12459_ samples_imag\[1\]\[4\] _04205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12460_ samples_imag\[2\]\[4\] samples_imag\[3\]\[4\] _03613_
+ _04206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12461_ _04206_ _04207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12462_ _04205_ _03648_ _04207_ _03644_ _04208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12463_ _04204_ _04208_ _03654_ _04209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12464_ samples_imag\[0\]\[4\] _03641_ _04210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12465_ _04209_ _04210_ _07864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12466_ samples_imag\[4\]\[3\] samples_imag\[5\]\[3\] samples_imag\[6\]\[3\]
+ samples_imag\[7\]\[3\] _03642_ _03644_ _04211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12467_ samples_imag\[1\]\[3\] _04212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12468_ samples_imag\[2\]\[3\] samples_imag\[3\]\[3\] _03613_
+ _04213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12469_ _04213_ _04214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12470_ _04212_ _03648_ _04214_ _03661_ _04058_ _04215_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_12471_ _04058_ _04211_ _04215_ _04216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12472_ _03836_ _04010_ _04216_ _07869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12473_ samples_imag\[6\]\[2\] samples_imag\[7\]\[2\] _03642_
+ _04217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12474_ samples_imag\[1\]\[2\] _04094_ _04217_ _04011_ _04218_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12475_ samples_imag\[3\]\[2\] _04015_ _04097_ samples_imag\[5\]\[2\]
+ _04219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12476_ _03599_ samples_imag\[2\]\[2\] _04220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12477_ _03600_ samples_imag\[4\]\[2\] _04220_ _03617_ _04221_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12478_ _04219_ _04221_ _03665_ _04222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12479_ _03846_ _04010_ _04218_ _04222_ _07874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12480_ _05868_ _05872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12481_ _05885_ _05886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12482_ _05899_ _05901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12483_ _05911_ _05946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12484_ _00011_ _03896_ _05931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12485_ _07903_ _05959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12486_ _05916_ _05944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12487_ _05950_ _06039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12488_ _05953_ _06035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12489_ _05976_ _05992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12490_ _05979_ _06006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12491_ _07911_ _07914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12492_ _05986_ _06026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12493_ _05958_ _06033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12494_ _06013_ _06055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12495_ _06076_ _06072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12496_ _06064_ _06062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12497_ _07917_ _07921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12498_ _06075_ _06078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12499_ _06084_ _06082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12500_ _06046_ _06088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12501_ _06097_ _06141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12502_ _06122_ _06118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12503_ _06117_ _06157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12504_ _07893_ _07935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12505_ _06121_ _06128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12506_ _06133_ _06131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12507_ _06137_ _06135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12508_ _06145_ _07925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12509_ _06147_ _06201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12510_ _06168_ _06217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12511_ _07957_ _07946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12512_ _06178_ _07951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12513_ _06179_ _06188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12514_ _06193_ _06191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12515_ _06197_ _06195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12516_ _06207_ _06251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12517_ _07967_ _05895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12518_ _06228_ _07962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12519_ _06229_ _06238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12520_ _06243_ _06241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12521_ _06247_ _06245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12522_ _06280_ _06275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12523_ _05912_ _07897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12524_ _06294_ _06291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12525_ _07978_ _06318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12526_ _05954_ _07904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12527_ _06426_ _06422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12528_ _06379_ _06374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12529_ _07993_ _06354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12530_ _08011_ _06042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12531_ _06336_ _06366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12532_ _06402_ _06397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12533_ _08009_ _06381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12534_ _07928_ _08013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12535_ _06373_ _06393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12536_ _06433_ _06428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12537_ _08024_ _08027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12538_ _06420_ _06417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12539_ _08035_ _08037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12540_ _08031_ _06447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12541_ _03845_ _08035_ _03817_ _04223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12542_ _03740_ _04223_ _06445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12543_ _08032_ _08045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12544_ _08058_ _06452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12545_ _08051_ _08070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12546_ _06299_ _06296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12547_ _06465_ _06482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12548_ _06474_ _06479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12549_ _06475_ _06484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12550_ _08081_ _08079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12551_ _06524_ _06542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12552_ _06514_ _06530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12553_ _06549_ _06572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12554_ _03898_ _03714_ _08114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12555_ _06581_ _06591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12556_ _06571_ _08119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12557_ _06579_ _06635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12558_ _03897_ _04224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_12559_ _04224_ _03739_ _08123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12560_ _06640_ _06650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12561_ _06615_ _08137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12562_ _06634_ _08141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12563_ _06639_ _06686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12564_ _06630_ _06679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12565_ _04224_ _03750_ _08144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12566_ _06670_ _06715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12567_ _06690_ _06740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12568_ _04224_ _03771_ _08156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12569_ _06721_ _06763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12570_ _06723_ _08166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12571_ _06744_ _06794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12572_ _04224_ _03789_ _08169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12573_ _06801_ _06806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12574_ _06769_ _06819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12575_ _06772_ _08179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12576_ _06732_ _06778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12577_ _06800_ _06850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12578_ _04224_ _03796_ _08184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12579_ _06858_ _06860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12580_ _06813_ _06826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12581_ _06784_ _06835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12582_ _06802_ _06852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12583_ _04224_ _03809_ _08199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12584_ _06872_ _08202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12585_ _06899_ _08210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12586_ _04224_ _03835_ _08215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12587_ _06944_ _06946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12588_ _06911_ _06921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12589_ _06920_ _06957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12590_ _06891_ _06930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12591_ _06912_ _06941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12592_ _06902_ _08223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12593_ _04224_ _03817_ _08229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12594_ _06954_ _06963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12595_ _06938_ _06972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12596_ _06955_ _06983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12597_ _04224_ _03845_ _08240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12598_ _06994_ _08248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12599_ _07000_ _08252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12600_ _06980_ _07006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12601_ _07001_ _07011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12602_ _04224_ _03854_ _08258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12603_ _07021_ _08267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12604_ _03897_ _03875_ _08272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12605_ _07042_ _07049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12606_ _07043_ _07052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12607_ _03897_ _03925_ _08303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12608_ _00701_ _00697_ _04225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12609_ _00588_ _00579_ _00586_ _04225_ _07083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12610_ _00709_ _00713_ _07092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12611_ _00826_ _07095_ _04226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12612_ _00834_ _04226_ _07107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12613_ _00927_ _07113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12614_ _00721_ _07104_ _00616_ _07124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12615_ _00836_ _07127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12616_ _00648_ _04227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12617_ _07110_ _04227_ _00693_ _07130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12618_ _00928_ _07133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12619_ _00626_ _07124_ _04228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12620_ _00687_ _04228_ _07137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12621_ _00645_ _00836_ _00839_ _07140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12622_ _00640_ _00649_ _00667_ _07143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_12623_ _00645_ _00928_ _00932_ _07146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12624_ _00889_ _00859_ _00862_ _07178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12625_ _00812_ _00809_ _07181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_12626_ _00974_ _07184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12627_ _07176_ _01001_ _07196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12628_ _02319_ _07438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12629_ _02896_ _07503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12630_ _03484_ _03555_ _04229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12631_ _07645_ _04230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12632_ _07647_ _07638_ _04231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_12633_ _03556_ _04231_ _04232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12634_ _04229_ _04230_ _04232_ _04233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12635_ _04233_ _07681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12636_ _03433_ _03449_ _03483_ _04234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_12637_ _03514_ _03538_ _03554_ _04235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_12638_ butterfly_count\[1\] _04234_ _04235_ _04236_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12639_ _04234_ _04235_ _07639_ _04237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12640_ _04236_ _04237_ _04238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12641_ _04238_ _05863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12642_ _07704_ _07702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12643_ _07740_ _07745_ _04239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12644_ _07702_ _05857_ _07691_ _07715_ _04240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12645_ _07730_ _07760_ _04240_ _04241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12646_ _07696_ _07720_ _07725_ _07735_ _04242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12647_ _07755_ _04239_ _04241_ _04242_ _04243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12648_ _07706_ _07710_ _07750_ _04243_ _07707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12649_ _07785_ _07788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12650_ sample_count\[1\] _07798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12651_ _07687_ _05864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12652_ _07818_ _07816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12653_ _07810_ _07820_ _07824_ _07829_ _04244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12654_ _07839_ _07844_ _07849_ _07874_ _04245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12655_ _07854_ _07859_ _07864_ _07869_ _04246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12656_ _04245_ _04246_ _04247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12657_ _07805_ _07834_ _04248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12658_ _07818_ _05868_ _04247_ _04248_ _04249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_12659_ _04244_ _04249_ _07821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12660_ _05910_ _05904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12661_ _07895_ _05896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12662_ _07896_ _05897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12663_ _05952_ _05947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12664_ _03897_ _03700_ _05923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12665_ _05970_ _05936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12666_ _07907_ _05960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12667_ _03897_ _03779_ _06050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12668_ _05991_ _05993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12669_ _06015_ _06061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12670_ _06096_ _06090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12671_ _07919_ _06043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12672_ _07930_ _06044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12673_ _03897_ _03827_ _06103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12674_ _06110_ _06107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12675_ _06071_ _06114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12676_ _07892_ _07923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12677_ _06146_ _06142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12678_ _06161_ _06158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12679_ _07944_ _07936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12680_ _06206_ _06202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12681_ _03897_ _03896_ _06213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12682_ _07945_ _07947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12683_ _03897_ _03907_ _06263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12684_ _07958_ _05888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12685_ _03897_ _03915_ _06310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12686_ _06293_ _06290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12687_ _06274_ _06276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12688_ _07968_ _05905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12689_ _06342_ _06338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12690_ _07979_ _05948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12691_ _06332_ _06330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12692_ _06427_ _06423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12693_ _06380_ _06375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12694_ _07994_ _06037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12695_ _06369_ _06367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12696_ _03898_ _03941_ _08002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12697_ _06403_ _06398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12698_ _08012_ _06091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12699_ _06396_ _06394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12700_ _06434_ _06429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12701_ _06421_ _06418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12702_ _08047_ _08034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12703_ _03726_ _03817_ _08038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12704_ _08043_ _06448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12705_ _08050_ _08046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12706_ _08054_ _08049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12707_ _08071_ _08057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12708_ _07952_ _06451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12709_ _06461_ _06459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12710_ _08059_ _08068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12711_ _06468_ _06253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12712_ _06486_ _06483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12713_ _06494_ _06487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12714_ _08080_ _08087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12715_ _08088_ _06337_ _04250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12716_ _08098_ _04250_ _08095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12717_ _03715_ _03925_ _06502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12718_ _06548_ _06543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12719_ _06536_ _06538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12720_ _06570_ _06539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12721_ _06576_ _06573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12722_ _03980_ _03979_ _08115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12723_ _06633_ _08120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12724_ _06638_ _06636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12725_ _03980_ _03714_ _08124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12726_ _06669_ _06664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12727_ _06689_ _06687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12728_ _03980_ _03739_ _08145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12729_ _06720_ _06716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12730_ _06743_ _06741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12731_ _03980_ _03750_ _08157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12732_ _06768_ _06764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12733_ _06730_ _06726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12734_ _06798_ _06795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12735_ _03980_ _03771_ _08170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12736_ _06824_ _06820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12737_ _06782_ _06779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12738_ _06855_ _06851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12739_ _03876_ _03789_ _08185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12740_ _06818_ _06827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12741_ _06871_ _08187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12742_ _06839_ _06836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12743_ _06898_ _08194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12744_ _03876_ _03796_ _08200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12745_ _06888_ _06885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12746_ _03876_ _03809_ _08216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12747_ _03876_ _03835_ _08230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12748_ _06993_ _08232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12749_ _06976_ _06973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12750_ _06945_ _08237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12751_ _03876_ _03817_ _08241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12752_ _07020_ _08255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12753_ _03876_ _03845_ _08259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12754_ _03876_ _03854_ _08273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12755_ _07072_ _08300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12756_ _03876_ _03875_ _08304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12757_ _08044_ _08067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12758_ _08069_ _08077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12759_ _08118_ _06627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12760_ _08132_ _06607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12761_ _08147_ _06711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12762_ _08159_ _06759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12763_ _08172_ _06815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12764_ _08180_ _06846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12765_ _08245_ _06998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12766_ _08284_ _07066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12767_ _07900_ _05940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12768_ _07905_ _06030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12769_ _07916_ _06020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12770_ _07927_ _06143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12771_ _07932_ _06139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12772_ _07940_ _06203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12773_ _07941_ _06199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12774_ _07953_ _06249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12775_ _07955_ _06271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12776_ _08048_ _08056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12777_ _08055_ _08089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12778_ _08072_ _06467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12779_ _08198_ _06866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12780_ _08214_ _06909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12781_ _08228_ _06952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12782_ _07074_ _07071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12783_ _08242_ _07018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12784_ bit_rev_idx\[0\] sample_count\[2\] _03597_ _00022_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12785_ bit_rev_idx\[1\] sample_count\[1\] _03597_ _00023_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12786_ bit_rev_idx\[2\] sample_count\[0\] _03597_ _00024_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12787_ _00564_ net83 _00565_ _04251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12788_ _00564_ net83 _04251_ state\[0\] _04252_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12789_ _04252_ _00025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12790_ _07686_ _03634_ _04253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12791_ state\[2\] _04254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
X_12792_ state\[1\] _04255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_12793_ _04254_ _04255_ _04256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12794_ _03593_ _03991_ _04256_ _04257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12795_ butterfly_count\[0\] _04253_ _04257_ _00026_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12796_ _07770_ _03634_ _04258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12797_ butterfly_count\[1\] _04258_ _04257_ _00027_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12798_ _07771_ _03634_ _04259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12799_ butterfly_count\[2\] _04259_ _04257_ _00028_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12800_ butterfly_in_group\[0\] _04260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12801_ _03636_ _04261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12802_ _07685_ _07683_ _04262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12803_ _07678_ _07682_ _04263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12804_ _07666_ _04264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12805_ _07674_ _07671_ _04265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12806_ _04265_ _07670_ _07667_ _04266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12807_ _04266_ _04264_ _04267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12808_ _04267_ _07663_ _07662_ _04268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12809_ _07689_ _04262_ _04263_ _04268_ _04269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12810_ _07683_ _05877_ _04270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12811_ _04236_ _04237_ _04270_ _04271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12812_ _03419_ _03498_ _04272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12813_ _03345_ _03364_ _04273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12814_ _03493_ _03494_ _04272_ _04273_ _04274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_12815_ _03414_ _03486_ _03501_ _04275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12816_ _03501_ _03414_ _03486_ _04276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12817_ _03372_ _03398_ _03415_ _04277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12818_ _03345_ _03364_ _03392_ _04277_ _04278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12819_ _03392_ _04277_ _04279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12820_ _04275_ _04276_ _04278_ _04279_ _04280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_12821_ _03345_ _03364_ _03416_ _03456_ _04281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_12822_ _03452_ _04281_ _04282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12823_ _03445_ _03447_ _04283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12824_ _03414_ _03487_ _04284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12825_ net46 _03426_ _04283_ _04284_ _04285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_12826_ _03421_ _03432_ _04282_ _04285_ _04286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_12827_ _03465_ _03467_ _04287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12828_ _07177_ _04287_ _04288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12829_ _03370_ _03454_ _04289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12830_ _07630_ _04289_ net10 _04290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12831_ _07650_ _07639_ _07686_ _07656_ _04291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_12832_ _07647_ _07644_ _07653_ _07659_ _04292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_12833_ _03504_ _04290_ _04291_ _04292_ _04293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12834_ _04280_ _04286_ _04288_ _04293_ _04294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_12835_ _03505_ _04295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12836_ _04295_ _04275_ _04276_ _04296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12837_ _04296_ _04297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12838_ _03488_ _03489_ _04298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12839_ _03433_ _03449_ _03483_ _04298_ _04299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12840_ _04235_ _04294_ _04297_ _04299_ _04300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12841_ _04274_ _04300_ _04301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_12842_ _03418_ _03420_ _04302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_12843_ _03452_ _04303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12844_ _04303_ _04281_ _04304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12845_ _03468_ _03572_ _03477_ _04305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12846_ _07650_ _04305_ _07649_ _04306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12847_ _07177_ _04306_ _02196_ _04307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12848_ _03465_ _03467_ _04307_ _04308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12849_ _03465_ _03467_ _04306_ _02507_ _04309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_12850_ _04290_ _04308_ _04309_ _04310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_12851_ _04302_ _04304_ _04283_ _04310_ _04311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_12852_ _04234_ _04235_ _04311_ _03427_ _04312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12853_ _03432_ _04312_ _04313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12854_ _04269_ _04271_ _04301_ _04313_ _04314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12855_ _04303_ _04281_ _04310_ _04315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12856_ _04303_ _04281_ _04316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12857_ _03445_ _03452_ _04317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12858_ _03445_ _04315_ _04316_ _04317_ _04310_ _04281_ _04318_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_2
X_12859_ _04286_ _04296_ _04319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12860_ _03345_ _03361_ _04320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12861_ _03419_ _03498_ _03491_ _04321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12862_ _04272_ _04320_ _04321_ _03497_ _04322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12863_ _03516_ _03527_ _04274_ _04322_ _04323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12864_ _03518_ _03526_ _03517_ _04324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12865_ _03518_ _03526_ _04325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12866_ _04324_ _04325_ _04326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12867_ _03534_ _04326_ _04327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12868_ _04310_ _04319_ _04323_ _04327_ _04328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12869_ _03483_ _04329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12870_ _03434_ _03436_ _03445_ _04329_ _03447_ _04330_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_12871_ _03519_ _03534_ _04331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12872_ _03337_ _04331_ _04332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12873_ _03337_ _04333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12874_ _03335_ _03311_ _03312_ _04334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12875_ _04333_ _04334_ _04335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12876_ _04332_ _04335_ _03526_ _04336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12877_ _07675_ _07667_ _07671_ _07663_ _04337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_12878_ _07679_ _07678_ _04337_ _04338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_12879_ _07679_ _07685_ _07683_ _07688_ _04339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12880_ _04338_ _04268_ _04339_ _04337_ _03342_ _04340_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_12881_ _04333_ _04334_ _04341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12882_ _04331_ _04335_ _04341_ _04340_ _04342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12883_ _03496_ _03364_ _03416_ _04343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12884_ _03516_ _04343_ _04344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12885_ _04342_ _04322_ _04302_ _04344_ _04345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12886_ _04280_ _04345_ _04346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12887_ _03547_ _04346_ _04336_ _04347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12888_ _04318_ _04328_ _04330_ _04347_ _04348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_12889_ _03484_ _04298_ _04349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12890_ _04287_ _04235_ _04294_ _04327_ _04350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_12891_ _03443_ _03444_ _04351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12892_ _03501_ _03414_ _03486_ _04352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12893_ _03504_ _04352_ _04353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_12894_ _04288_ _04306_ _04354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12895_ _03482_ _03481_ _04355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12896_ _04290_ _04355_ _04356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12897_ _04351_ _04353_ _04354_ _04356_ _04357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12898_ _04349_ _04350_ _04357_ _04229_ _04358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_12899_ _03434_ _03437_ _04359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12900_ _03440_ _04359_ _04360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_12901_ _03500_ _03530_ _04319_ _04360_ _04361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12902_ _04234_ _04235_ _04311_ _04362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12903_ _04361_ _04360_ _04362_ _04363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12904_ _04304_ _04310_ _04364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12905_ _03484_ _04298_ _03553_ _04364_ _04365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12906_ _03547_ _04366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12907_ _03514_ _03538_ _04366_ _04367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_12908_ _03553_ _04364_ _04367_ _03484_ _04368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12909_ _04365_ _04368_ _04369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12910_ _04363_ _04358_ _04348_ _04369_ _04370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_12911_ _04272_ _03499_ _03361_ _04371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12912_ _03538_ _04274_ _04310_ _04371_ _04372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12913_ _03484_ _03555_ _04319_ _04372_ _04373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_12914_ _03540_ _04374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12915_ _03546_ _04373_ _04374_ _04375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12916_ _03512_ _04375_ _04376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12917_ _03500_ _03516_ _03530_ _04300_ _04377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12918_ _03527_ _04377_ _04378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12919_ _04370_ _04314_ _04376_ _04378_ _04379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_12920_ _07688_ _04379_ _04380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12921_ _04370_ _04314_ _04381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_12922_ _04376_ _04378_ _04382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12923_ butterfly_count\[0\] _04381_ _04382_ _04261_ _04383_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12924_ _04260_ _04261_ _04380_ _04383_ _00029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_12925_ _04314_ _04370_ _04376_ _04378_ _04384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_12926_ _04238_ _04376_ _04378_ _04385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12927_ _05866_ _04384_ _04381_ _04385_ _03636_ _04386_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12928_ butterfly_in_group\[1\] _03636_ _04387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12929_ _04387_ _04386_ _00030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12930_ butterfly_in_group\[2\] _04388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12931_ _05865_ _07683_ _04389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12932_ _04379_ _04389_ _04390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12933_ _04233_ _04381_ _04382_ _04261_ _04391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12934_ _04388_ _04261_ _04390_ _04391_ _00031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_12935_ _00563_ _04392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12936_ net84 samples_imag\[0\]\[0\] _04392_ _00032_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12937_ net85 samples_imag\[6\]\[4\] _04392_ _00033_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12938_ net86 samples_imag\[6\]\[5\] _04392_ _00034_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12939_ net87 samples_imag\[6\]\[6\] _04392_ _00035_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12940_ net88 samples_imag\[6\]\[7\] _04392_ _00036_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12941_ net89 samples_imag\[6\]\[8\] _04392_ _00037_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12942_ net90 samples_imag\[6\]\[9\] _04392_ _00038_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12943_ net91 samples_imag\[6\]\[10\] _04392_ _00039_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12944_ net92 samples_imag\[6\]\[11\] _04392_ _00040_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12945_ _00563_ _04393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_12946_ _04393_ _04394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12947_ net93 samples_imag\[6\]\[12\] _04394_ _00041_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12948_ net94 samples_imag\[6\]\[13\] _04394_ _00042_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12949_ net95 samples_imag\[0\]\[10\] _04394_ _00043_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12950_ net96 samples_imag\[6\]\[14\] _04394_ _00044_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12951_ net97 samples_imag\[6\]\[15\] _04394_ _00045_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12952_ net98 samples_imag\[7\]\[0\] _04394_ _00046_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12953_ net99 samples_imag\[7\]\[1\] _04394_ _00047_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12954_ net100 samples_imag\[7\]\[2\] _04394_ _00048_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12955_ net101 samples_imag\[7\]\[3\] _04394_ _00049_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12956_ net102 samples_imag\[7\]\[4\] _04394_ _00050_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12957_ _04393_ _04395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12958_ net103 samples_imag\[7\]\[5\] _04395_ _00051_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12959_ net104 samples_imag\[7\]\[6\] _04395_ _00052_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12960_ net105 samples_imag\[7\]\[7\] _04395_ _00053_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12961_ net106 samples_imag\[0\]\[11\] _04395_ _00054_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12962_ net107 samples_imag\[7\]\[8\] _04395_ _00055_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12963_ net108 samples_imag\[7\]\[9\] _04395_ _00056_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12964_ net109 samples_imag\[7\]\[10\] _04395_ _00057_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12965_ net110 samples_imag\[7\]\[11\] _04395_ _00058_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12966_ net111 samples_imag\[7\]\[12\] _04395_ _00059_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12967_ net112 samples_imag\[7\]\[13\] _04395_ _00060_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12968_ _00563_ _04396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12969_ _04396_ _04397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12970_ net113 samples_imag\[7\]\[14\] _04397_ _00061_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12971_ net114 samples_imag\[7\]\[15\] _04397_ _00062_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12972_ net115 samples_imag\[0\]\[12\] _04397_ _00063_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12973_ net116 samples_imag\[0\]\[13\] _04397_ _00064_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12974_ net117 samples_imag\[0\]\[14\] _04397_ _00065_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12975_ net118 samples_imag\[0\]\[15\] _04397_ _00066_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12976_ net119 samples_imag\[1\]\[0\] _04397_ _00067_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12977_ net120 samples_imag\[1\]\[1\] _04397_ _00068_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12978_ net121 samples_imag\[1\]\[2\] _04397_ _00069_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12979_ net122 samples_imag\[1\]\[3\] _04397_ _00070_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12980_ _04396_ _04398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12981_ net123 samples_imag\[0\]\[1\] _04398_ _00071_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12982_ net124 samples_imag\[1\]\[4\] _04398_ _00072_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12983_ net125 samples_imag\[1\]\[5\] _04398_ _00073_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12984_ net126 samples_imag\[1\]\[6\] _04398_ _00074_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12985_ net127 samples_imag\[1\]\[7\] _04398_ _00075_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12986_ net128 samples_imag\[1\]\[8\] _04398_ _00076_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12987_ net129 samples_imag\[1\]\[9\] _04398_ _00077_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12988_ net130 samples_imag\[1\]\[10\] _04398_ _00078_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12989_ net131 samples_imag\[1\]\[11\] _04398_ _00079_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12990_ net132 samples_imag\[1\]\[12\] _04398_ _00080_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12991_ _04396_ _04399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12992_ net133 samples_imag\[1\]\[13\] _04399_ _00081_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12993_ net134 samples_imag\[0\]\[2\] _04399_ _00082_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12994_ net135 samples_imag\[1\]\[14\] _04399_ _00083_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12995_ net136 samples_imag\[1\]\[15\] _04399_ _00084_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12996_ net137 samples_imag\[2\]\[0\] _04399_ _00085_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12997_ net138 samples_imag\[2\]\[1\] _04399_ _00086_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12998_ net139 samples_imag\[2\]\[2\] _04399_ _00087_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12999_ net140 samples_imag\[2\]\[3\] _04399_ _00088_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13000_ net141 samples_imag\[2\]\[4\] _04399_ _00089_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13001_ net142 samples_imag\[2\]\[5\] _04399_ _00090_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13002_ _04396_ _04400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13003_ net143 samples_imag\[2\]\[6\] _04400_ _00091_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13004_ net144 samples_imag\[2\]\[7\] _04400_ _00092_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13005_ net145 samples_imag\[0\]\[3\] _04400_ _00093_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13006_ net146 samples_imag\[2\]\[8\] _04400_ _00094_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13007_ net147 samples_imag\[2\]\[9\] _04400_ _00095_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13008_ net148 samples_imag\[2\]\[10\] _04400_ _00096_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13009_ net149 samples_imag\[2\]\[11\] _04400_ _00097_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13010_ net150 samples_imag\[2\]\[12\] _04400_ _00098_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13011_ net151 samples_imag\[2\]\[13\] _04400_ _00099_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13012_ net152 samples_imag\[2\]\[14\] _04400_ _00100_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13013_ _04396_ _04401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13014_ net153 samples_imag\[2\]\[15\] _04401_ _00101_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13015_ net154 samples_imag\[3\]\[0\] _04401_ _00102_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13016_ net155 samples_imag\[3\]\[1\] _04401_ _00103_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13017_ net156 samples_imag\[0\]\[4\] _04401_ _00104_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13018_ net157 samples_imag\[3\]\[2\] _04401_ _00105_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13019_ net158 samples_imag\[3\]\[3\] _04401_ _00106_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13020_ net159 samples_imag\[3\]\[4\] _04401_ _00107_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13021_ net160 samples_imag\[3\]\[5\] _04401_ _00108_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13022_ net161 samples_imag\[3\]\[6\] _04401_ _00109_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13023_ net162 samples_imag\[3\]\[7\] _04401_ _00110_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13024_ _04396_ _04402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13025_ net163 samples_imag\[3\]\[8\] _04402_ _00111_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13026_ net164 samples_imag\[3\]\[9\] _04402_ _00112_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13027_ net165 samples_imag\[3\]\[10\] _04402_ _00113_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13028_ net166 samples_imag\[3\]\[11\] _04402_ _00114_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13029_ net167 samples_imag\[0\]\[5\] _04402_ _00115_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13030_ net168 samples_imag\[3\]\[12\] _04402_ _00116_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13031_ net169 samples_imag\[3\]\[13\] _04402_ _00117_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13032_ net170 samples_imag\[3\]\[14\] _04402_ _00118_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13033_ net171 samples_imag\[3\]\[15\] _04402_ _00119_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13034_ net172 samples_imag\[4\]\[0\] _04402_ _00120_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13035_ _04396_ _04403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13036_ net173 samples_imag\[4\]\[1\] _04403_ _00121_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13037_ net174 samples_imag\[4\]\[2\] _04403_ _00122_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13038_ net175 samples_imag\[4\]\[3\] _04403_ _00123_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13039_ net176 samples_imag\[4\]\[4\] _04403_ _00124_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13040_ net177 samples_imag\[4\]\[5\] _04403_ _00125_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13041_ net178 samples_imag\[0\]\[6\] _04403_ _00126_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13042_ net179 samples_imag\[4\]\[6\] _04403_ _00127_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13043_ net180 samples_imag\[4\]\[7\] _04403_ _00128_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13044_ net181 samples_imag\[4\]\[8\] _04403_ _00129_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13045_ net182 samples_imag\[4\]\[9\] _04403_ _00130_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13046_ _04396_ _04404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13047_ net183 samples_imag\[4\]\[10\] _04404_ _00131_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13048_ net184 samples_imag\[4\]\[11\] _04404_ _00132_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13049_ net185 samples_imag\[4\]\[12\] _04404_ _00133_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13050_ net186 samples_imag\[4\]\[13\] _04404_ _00134_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13051_ net187 samples_imag\[4\]\[14\] _04404_ _00135_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13052_ net188 samples_imag\[4\]\[15\] _04404_ _00136_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13053_ net189 samples_imag\[0\]\[7\] _04404_ _00137_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13054_ net190 samples_imag\[5\]\[0\] _04404_ _00138_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13055_ net191 samples_imag\[5\]\[1\] _04404_ _00139_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13056_ net192 samples_imag\[5\]\[2\] _04404_ _00140_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13057_ _04396_ _04405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13058_ net193 samples_imag\[5\]\[3\] _04405_ _00141_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13059_ net194 samples_imag\[5\]\[4\] _04405_ _00142_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13060_ net195 samples_imag\[5\]\[5\] _04405_ _00143_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13061_ net196 samples_imag\[5\]\[6\] _04405_ _00144_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13062_ net197 samples_imag\[5\]\[7\] _04405_ _00145_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13063_ net198 samples_imag\[5\]\[8\] _04405_ _00146_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13064_ net199 samples_imag\[5\]\[9\] _04405_ _00147_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13065_ net200 samples_imag\[0\]\[8\] _04405_ _00148_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13066_ net201 samples_imag\[5\]\[10\] _04405_ _00149_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13067_ net202 samples_imag\[5\]\[11\] _04405_ _00150_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13068_ _04396_ _04406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13069_ net203 samples_imag\[5\]\[12\] _04406_ _00151_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13070_ net204 samples_imag\[5\]\[13\] _04406_ _00152_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13071_ net205 samples_imag\[5\]\[14\] _04406_ _00153_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13072_ net206 samples_imag\[5\]\[15\] _04406_ _00154_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13073_ net207 samples_imag\[6\]\[0\] _04406_ _00155_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13074_ net208 samples_imag\[6\]\[1\] _04406_ _00156_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13075_ net209 samples_imag\[6\]\[2\] _04406_ _00157_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13076_ net210 samples_imag\[6\]\[3\] _04406_ _00158_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13077_ net211 samples_imag\[0\]\[9\] _04406_ _00159_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13078_ net212 samples_real\[0\]\[0\] _04406_ _00160_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13079_ _00563_ _04407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13080_ _04407_ _04408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13081_ net213 samples_real\[6\]\[4\] _04408_ _00161_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13082_ net214 samples_real\[6\]\[5\] _04408_ _00162_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13083_ net215 samples_real\[6\]\[6\] _04408_ _00163_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13084_ net216 samples_real\[6\]\[7\] _04408_ _00164_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13085_ net217 samples_real\[6\]\[8\] _04408_ _00165_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13086_ net218 samples_real\[6\]\[9\] _04408_ _00166_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13087_ net219 samples_real\[6\]\[10\] _04408_ _00167_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13088_ net220 samples_real\[6\]\[11\] _04408_ _00168_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13089_ net221 samples_real\[6\]\[12\] _04408_ _00169_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13090_ net222 samples_real\[6\]\[13\] _04408_ _00170_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13091_ _04407_ _04409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13092_ net223 samples_real\[0\]\[10\] _04409_ _00171_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13093_ net224 samples_real\[6\]\[14\] _04409_ _00172_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13094_ net225 samples_real\[6\]\[15\] _04409_ _00173_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13095_ net226 samples_real\[7\]\[0\] _04409_ _00174_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13096_ net227 samples_real\[7\]\[1\] _04409_ _00175_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13097_ net228 samples_real\[7\]\[2\] _04409_ _00176_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13098_ net229 samples_real\[7\]\[3\] _04409_ _00177_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13099_ net230 samples_real\[7\]\[4\] _04409_ _00178_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13100_ net231 samples_real\[7\]\[5\] _04409_ _00179_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13101_ net232 samples_real\[7\]\[6\] _04409_ _00180_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13102_ _04407_ _04410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13103_ net233 samples_real\[7\]\[7\] _04410_ _00181_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13104_ net234 samples_real\[0\]\[11\] _04410_ _00182_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13105_ net235 samples_real\[7\]\[8\] _04410_ _00183_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13106_ net236 samples_real\[7\]\[9\] _04410_ _00184_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13107_ net237 samples_real\[7\]\[10\] _04410_ _00185_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13108_ net238 samples_real\[7\]\[11\] _04410_ _00186_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13109_ net239 samples_real\[7\]\[12\] _04410_ _00187_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13110_ net240 samples_real\[7\]\[13\] _04410_ _00188_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13111_ net241 samples_real\[7\]\[14\] _04410_ _00189_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13112_ net242 samples_real\[7\]\[15\] _04410_ _00190_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13113_ _04407_ _04411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13114_ net243 samples_real\[0\]\[12\] _04411_ _00191_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13115_ net244 samples_real\[0\]\[13\] _04411_ _00192_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13116_ net245 samples_real\[0\]\[14\] _04411_ _00193_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13117_ net246 samples_real\[0\]\[15\] _04411_ _00194_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13118_ net247 samples_real\[1\]\[0\] _04411_ _00195_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13119_ net248 samples_real\[1\]\[1\] _04411_ _00196_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13120_ net249 samples_real\[1\]\[2\] _04411_ _00197_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13121_ net250 samples_real\[1\]\[3\] _04411_ _00198_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13122_ net251 samples_real\[0\]\[1\] _04411_ _00199_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13123_ net252 samples_real\[1\]\[4\] _04411_ _00200_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13124_ _04407_ _04412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13125_ net253 samples_real\[1\]\[5\] _04412_ _00201_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13126_ net254 samples_real\[1\]\[6\] _04412_ _00202_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13127_ net255 samples_real\[1\]\[7\] _04412_ _00203_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13128_ net256 samples_real\[1\]\[8\] _04412_ _00204_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13129_ net257 samples_real\[1\]\[9\] _04412_ _00205_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13130_ net258 samples_real\[1\]\[10\] _04412_ _00206_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13131_ net259 samples_real\[1\]\[11\] _04412_ _00207_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13132_ net260 samples_real\[1\]\[12\] _04412_ _00208_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13133_ net261 samples_real\[1\]\[13\] _04412_ _00209_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13134_ net262 samples_real\[0\]\[2\] _04412_ _00210_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13135_ _04407_ _04413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13136_ net263 samples_real\[1\]\[14\] _04413_ _00211_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13137_ net264 samples_real\[1\]\[15\] _04413_ _00212_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13138_ net265 samples_real\[2\]\[0\] _04413_ _00213_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13139_ net266 samples_real\[2\]\[1\] _04413_ _00214_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13140_ net267 samples_real\[2\]\[2\] _04413_ _00215_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13141_ net268 samples_real\[2\]\[3\] _04413_ _00216_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13142_ net269 samples_real\[2\]\[4\] _04413_ _00217_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13143_ net270 samples_real\[2\]\[5\] _04413_ _00218_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13144_ net271 samples_real\[2\]\[6\] _04413_ _00219_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13145_ net272 samples_real\[2\]\[7\] _04413_ _00220_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13146_ _04407_ _04414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13147_ net273 samples_real\[0\]\[3\] _04414_ _00221_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13148_ net274 samples_real\[2\]\[8\] _04414_ _00222_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13149_ net275 samples_real\[2\]\[9\] _04414_ _00223_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13150_ net276 samples_real\[2\]\[10\] _04414_ _00224_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13151_ net277 samples_real\[2\]\[11\] _04414_ _00225_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13152_ net278 samples_real\[2\]\[12\] _04414_ _00226_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13153_ net279 samples_real\[2\]\[13\] _04414_ _00227_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13154_ net280 samples_real\[2\]\[14\] _04414_ _00228_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13155_ net281 samples_real\[2\]\[15\] _04414_ _00229_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13156_ net282 samples_real\[3\]\[0\] _04414_ _00230_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13157_ _04407_ _04415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13158_ net283 samples_real\[3\]\[1\] _04415_ _00231_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13159_ net284 samples_real\[0\]\[4\] _04415_ _00232_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13160_ net285 samples_real\[3\]\[2\] _04415_ _00233_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13161_ net286 samples_real\[3\]\[3\] _04415_ _00234_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13162_ net287 samples_real\[3\]\[4\] _04415_ _00235_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13163_ net288 samples_real\[3\]\[5\] _04415_ _00236_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13164_ net289 samples_real\[3\]\[6\] _04415_ _00237_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13165_ net290 samples_real\[3\]\[7\] _04415_ _00238_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13166_ net291 samples_real\[3\]\[8\] _04415_ _00239_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13167_ net292 samples_real\[3\]\[9\] _04415_ _00240_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13168_ _04407_ _04416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13169_ net293 samples_real\[3\]\[10\] _04416_ _00241_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13170_ net294 samples_real\[3\]\[11\] _04416_ _00242_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13171_ net295 samples_real\[0\]\[5\] _04416_ _00243_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13172_ net296 samples_real\[3\]\[12\] _04416_ _00244_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13173_ net297 samples_real\[3\]\[13\] _04416_ _00245_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13174_ net298 samples_real\[3\]\[14\] _04416_ _00246_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13175_ net299 samples_real\[3\]\[15\] _04416_ _00247_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13176_ net300 samples_real\[4\]\[0\] _04416_ _00248_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13177_ net301 samples_real\[4\]\[1\] _04416_ _00249_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13178_ net302 samples_real\[4\]\[2\] _04416_ _00250_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13179_ _04407_ _04417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13180_ net303 samples_real\[4\]\[3\] _04417_ _00251_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13181_ net304 samples_real\[4\]\[4\] _04417_ _00252_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13182_ net305 samples_real\[4\]\[5\] _04417_ _00253_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13183_ net306 samples_real\[0\]\[6\] _04417_ _00254_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13184_ net307 samples_real\[4\]\[6\] _04417_ _00255_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13185_ net308 samples_real\[4\]\[7\] _04417_ _00256_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13186_ net309 samples_real\[4\]\[8\] _04417_ _00257_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13187_ net310 samples_real\[4\]\[9\] _04417_ _00258_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13188_ net311 samples_real\[4\]\[10\] _04417_ _00259_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13189_ net312 samples_real\[4\]\[11\] _04417_ _00260_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13190_ _00563_ _04418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13191_ net313 samples_real\[4\]\[12\] _04418_ _00261_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13192_ net314 samples_real\[4\]\[13\] _04418_ _00262_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13193_ net315 samples_real\[4\]\[14\] _04418_ _00263_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13194_ net316 samples_real\[4\]\[15\] _04418_ _00264_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13195_ net317 samples_real\[0\]\[7\] _04418_ _00265_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13196_ net318 samples_real\[5\]\[0\] _04418_ _00266_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13197_ net319 samples_real\[5\]\[1\] _04418_ _00267_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13198_ net320 samples_real\[5\]\[2\] _04418_ _00268_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13199_ net321 samples_real\[5\]\[3\] _04418_ _00269_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13200_ net322 samples_real\[5\]\[4\] _04418_ _00270_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13201_ _00563_ _04419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13202_ net323 samples_real\[5\]\[5\] _04419_ _00271_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13203_ net324 samples_real\[5\]\[6\] _04419_ _00272_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13204_ net325 samples_real\[5\]\[7\] _04419_ _00273_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13205_ net326 samples_real\[5\]\[8\] _04419_ _00274_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13206_ net327 samples_real\[5\]\[9\] _04419_ _00275_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13207_ net328 samples_real\[0\]\[8\] _04419_ _00276_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13208_ net329 samples_real\[5\]\[10\] _04419_ _00277_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13209_ net330 samples_real\[5\]\[11\] _04419_ _00278_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13210_ net331 samples_real\[5\]\[12\] _04419_ _00279_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13211_ net332 samples_real\[5\]\[13\] _04419_ _00280_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13212_ net333 samples_real\[5\]\[14\] _04393_ _00281_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13213_ net334 samples_real\[5\]\[15\] _04393_ _00282_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13214_ net335 samples_real\[6\]\[0\] _04393_ _00283_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13215_ net336 samples_real\[6\]\[1\] _04393_ _00284_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13216_ net337 samples_real\[6\]\[2\] _04393_ _00285_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13217_ net338 samples_real\[6\]\[3\] _04393_ _00286_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13218_ net339 samples_real\[0\]\[9\] _04393_ _00287_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13219_ _03591_ _04392_ net340 _04420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13220_ _04254_ net340 _00565_ _04421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13221_ state\[0\] _04421_ _04422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13222_ net340 _03592_ _04423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13223_ state\[2\] _04420_ _04422_ _04423_ _00288_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13224_ net341 _04424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13225_ net341 _04393_ net82 _04425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13226_ _04425_ _04426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13227_ _00564_ _04424_ _04426_ state\[0\] _00289_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_13228_ group\[0\] _04379_ _04261_ _00290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13229_ group\[1\] _03556_ _04261_ _00291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13230_ group\[2\] net10 _04261_ _00292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13231_ _03643_ _00013_ _04261_ _00293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13232_ _03645_ _00014_ _04261_ _00294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13233_ group\[0\] _07783_ _04427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13234_ group\[1\] _07777_ _04428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13235_ _04427_ _04428_ _04429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13236_ _03670_ _04429_ _04430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13237_ group\[2\] _02507_ _04431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13238_ _04430_ _04431_ _04432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13239_ _03669_ _04432_ _04433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13240_ butterfly_in_group\[2\] _07886_ _04434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13241_ _07889_ _07891_ _04434_ _04435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_13242_ _04433_ _04435_ _04436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13243_ _04436_ _04437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_13244_ _04058_ _04437_ _04261_ _00295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13245_ _03730_ _00015_ _03636_ _00296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13246_ _05880_ _04438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13247_ _03673_ _04438_ _03636_ _00297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13248_ _05879_ _07680_ _04436_ _04439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_13249_ _03731_ _04439_ _03636_ _00298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13250_ _07803_ _04440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13251_ state\[2\] _04440_ _07797_ _04441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13252_ _03595_ _07789_ _04442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13253_ state\[0\] _04256_ _04443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13254_ _04254_ net80 _04444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13255_ _00566_ _04442_ _04443_ _04444_ _04445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13256_ sample_count\[0\] _04441_ _04445_ _00299_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13257_ state\[2\] _04440_ _07800_ _04446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13258_ sample_count\[1\] _04446_ _04445_ _00300_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13259_ state\[2\] _07804_ _04447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13260_ sample_count\[2\] _04447_ _04445_ _00301_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13261_ _07817_ _04448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13262_ temp_imag\[0\] _07820_ _04449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13263_ _07812_ _04450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13264_ _07831_ _04451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13265_ _07841_ _04452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13266_ _07851_ _04453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13267_ _07861_ _04454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13268_ _07871_ _04455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_13269_ _07880_ _04456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13270_ _04456_ _07815_ _07881_ _04457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13271_ _07877_ _04458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13272_ _07876_ _04457_ _04458_ _04459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13273_ _04455_ _04459_ _07872_ _04460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13274_ _07867_ _04461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13275_ _07866_ _04460_ _04461_ _04462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13276_ _04454_ _04462_ _07862_ _04463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13277_ _07857_ _04464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13278_ _07856_ _04463_ _04464_ _04465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13279_ _04453_ _04465_ _07852_ _04466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13280_ _07847_ _04467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13281_ _07846_ _04466_ _04467_ _04468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13282_ _04452_ _04468_ _07842_ _04469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13283_ _07837_ _04470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13284_ _07836_ _04469_ _04470_ _04471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13285_ _04451_ _04471_ _07832_ _04472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13286_ _07827_ _04473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13287_ _07826_ _04472_ _04473_ _04474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13288_ _04450_ _04474_ _07813_ _04475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13289_ _07808_ _04476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13290_ _07807_ _04475_ _04476_ _04477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13291_ _04449_ _04477_ _04478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13292_ _07876_ _05870_ _04458_ _04479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13293_ _04455_ _04479_ _07872_ _04480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13294_ _07866_ _04480_ _04461_ _04481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13295_ _04454_ _04481_ _07862_ _04482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13296_ _07856_ _04482_ _04464_ _04483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13297_ _04453_ _04483_ _07852_ _04484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13298_ _07846_ _04484_ _04467_ _04485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13299_ _04452_ _04485_ _07842_ _04486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13300_ _07836_ _04486_ _04470_ _04487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13301_ _04451_ _04487_ _07832_ _04488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13302_ _07826_ _04488_ _04473_ _04489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13303_ _04450_ _04489_ _07813_ _04490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13304_ _07807_ _04490_ _04491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13305_ _04450_ _04474_ _04492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13306_ _04452_ _04468_ _04493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13307_ _07856_ _04482_ _04494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13308_ _04454_ _04462_ _04495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13309_ _04455_ _04459_ _04496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13310_ _07876_ _05870_ _04497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13311_ _07866_ _04480_ _04498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13312_ _05871_ _04448_ _04497_ _04498_ _04499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13313_ _04494_ _04495_ _04496_ _04499_ _04500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13314_ _07846_ _04484_ _04501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13315_ _04453_ _04465_ _04502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13316_ _07836_ _04486_ _04503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13317_ _04500_ _04501_ _04502_ _04503_ _04504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13318_ _07826_ _04488_ _04505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13319_ _04451_ _04471_ _04506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13320_ _04493_ _04504_ _04505_ _04506_ _04507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13321_ _04491_ _04492_ _04507_ _04508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13322_ temp_imag\[0\] _07822_ _04508_ _04509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13323_ _04478_ _04509_ _04510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_13324_ _04448_ _04510_ _04511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13325_ butterfly_count\[2\] _03990_ _03594_ _04512_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13326_ _04256_ _04444_ _04512_ _04513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13327_ sample_count\[2\] _04514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13328_ _04514_ _07799_ _04515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13329_ _04254_ _04515_ _04516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13330_ bit_rev_idx\[1\] bit_rev_idx\[0\] bit_rev_idx\[2\]
+ _04516_ _04517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13331_ _04513_ _04517_ _04518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_13332_ _04010_ _04518_ _04519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13333_ samples_imag\[0\]\[0\] _03641_ _04511_ _04519_ _04520_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_13334_ _07811_ _04521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13335_ _07825_ _04522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13336_ _07835_ _04523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13337_ _07845_ _04524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13338_ _07855_ _04525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13339_ _07865_ _04526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13340_ _07875_ _04527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13341_ _07880_ _05873_ _04528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13342_ _07879_ _04528_ _07876_ _04529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13343_ _04527_ _04529_ _04530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13344_ _07871_ _04530_ _04531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13345_ _07870_ _04531_ _07866_ _04532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13346_ _04526_ _04532_ _04533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13347_ _07861_ _04533_ _04534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13348_ _07860_ _04534_ _07856_ _04535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13349_ _04525_ _04535_ _04536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13350_ _07851_ _04536_ _04537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13351_ _07850_ _04537_ _07846_ _04538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13352_ _04524_ _04538_ _04539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13353_ _07841_ _04539_ _04540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13354_ _07840_ _04540_ _07836_ _04541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13355_ _04523_ _04541_ _04542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13356_ _07831_ _04542_ _04543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13357_ _07830_ _04543_ _07826_ _04544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13358_ _04522_ _04544_ _04545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13359_ _07812_ _04545_ _04546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13360_ _04521_ _04546_ _04547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13361_ _07807_ _04547_ _07806_ _04548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13362_ _04449_ _04548_ _04549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_13363_ temp_imag\[0\] _07823_ _04549_ _04550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_13364_ _04550_ _04551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13365_ _07817_ _04551_ _04552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13366_ _03728_ _04518_ _04553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13367_ _03728_ _04520_ _04552_ _04553_ _04554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_13368_ _03596_ _04554_ _04555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13369_ _04255_ net48 _04556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_13370_ samples_imag\[0\]\[0\] _04556_ _04518_ _04557_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13371_ _04555_ _04557_ _00302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13372_ _07876_ _05874_ _07875_ _04558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13373_ _07870_ _04559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13374_ _04455_ _04558_ _04559_ _04560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13375_ _07866_ _04560_ _07865_ _04561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13376_ _07860_ _04562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13377_ _04454_ _04561_ _04562_ _04563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13378_ _07856_ _04563_ _07855_ _04564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13379_ _07850_ _04565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13380_ _04453_ _04564_ _04565_ _04566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13381_ _07846_ _04566_ _07845_ _04567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13382_ _07840_ _04568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13383_ _04452_ _04567_ _04568_ _04569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13384_ _07836_ _04569_ _04570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13385_ _04551_ _04570_ _04571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13386_ _04510_ _04572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13387_ _04503_ _04572_ _04573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13388_ _04008_ _04574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13389_ samples_imag\[0\]\[10\] _04573_ _04574_ _04575_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13390_ _04571_ _04575_ _03905_ _04576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13391_ _03594_ _04577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13392_ _04577_ _04578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13393_ net49 _04576_ _04578_ _04579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13394_ _04518_ _04580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13395_ samples_imag\[0\]\[10\] _04579_ _04580_ _00303_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13396_ _07831_ _04542_ _04581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13397_ _04550_ _04582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_13398_ _07831_ _04542_ _04583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13399_ _04581_ _04582_ _04583_ _04584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13400_ _04506_ _04572_ _04585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13401_ samples_imag\[0\]\[11\] _04585_ _04574_ _04586_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13402_ _04584_ _04586_ _03905_ _04587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13403_ net50 _04587_ _04578_ _04588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13404_ samples_imag\[0\]\[11\] _04588_ _04580_ _00304_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13405_ _07836_ _04569_ _07835_ _04589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13406_ _07830_ _04590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13407_ _04451_ _04589_ _04590_ _04591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13408_ _07826_ _04591_ _04592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13409_ _07826_ _04591_ _04593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13410_ _04582_ _04592_ _04593_ _04594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13411_ _04505_ _04572_ _04595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13412_ samples_imag\[0\]\[12\] _04595_ _04574_ _04596_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13413_ _04594_ _04596_ _03905_ _04597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13414_ _04577_ _04598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13415_ net51 _04597_ _04598_ _04599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13416_ samples_imag\[0\]\[12\] _04599_ _04580_ _00305_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13417_ _07812_ _04545_ _04600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13418_ _04546_ _04582_ _04600_ _04601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13419_ _04492_ _04572_ _04602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13420_ samples_imag\[0\]\[13\] _04602_ _04574_ _04603_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13421_ _04601_ _04603_ _03905_ _04604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13422_ net52 _04604_ _04598_ _04605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13423_ samples_imag\[0\]\[13\] _04605_ _04580_ _00306_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13424_ _04522_ _04593_ _04606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13425_ _07812_ _04606_ _07811_ _04607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13426_ _07807_ _04607_ _04608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13427_ _04551_ _04608_ _04609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13428_ _04491_ _04572_ _04610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13429_ samples_imag\[0\]\[14\] _04610_ _04574_ _04611_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13430_ _04609_ _04611_ _03905_ _04612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13431_ net53 _04612_ _04598_ _04613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13432_ samples_imag\[0\]\[14\] _04613_ _04580_ _00307_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13433_ _04509_ _04614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13434_ _04478_ _04614_ _04615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_13435_ samples_imag\[0\]\[15\] _04615_ _04574_ _04616_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13436_ _04549_ _04616_ _03905_ _04617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13437_ net54 _04617_ _04598_ _04618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13438_ samples_imag\[0\]\[15\] _04618_ _04580_ _00308_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13439_ _05875_ _04619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13440_ _04619_ _04582_ _04620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13441_ _05871_ _04572_ _04621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13442_ samples_imag\[0\]\[1\] _04621_ _04574_ _04622_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13443_ _04620_ _04622_ _03905_ _04623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13444_ net55 _04623_ _04598_ _04624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13445_ samples_imag\[0\]\[1\] _04624_ _04580_ _00309_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13446_ _07876_ _05874_ _04625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13447_ _04551_ _04625_ _04626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13448_ _04497_ _04572_ _04627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13449_ samples_imag\[0\]\[2\] _04627_ _04574_ _04628_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13450_ _04626_ _04628_ _03905_ _04629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13451_ net56 _04629_ _04598_ _04630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13452_ samples_imag\[0\]\[2\] _04630_ _04580_ _00310_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13453_ _04455_ _04530_ _04631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13454_ _04582_ _04631_ _04632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13455_ _04496_ _04572_ _04633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13456_ samples_imag\[0\]\[3\] _04633_ _04574_ _04634_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13457_ _03712_ _04635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13458_ _04632_ _04634_ _04635_ _04636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13459_ net57 _04636_ _04598_ _04637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13460_ samples_imag\[0\]\[3\] _04637_ _04580_ _00311_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13461_ _07866_ _04560_ _04638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13462_ _04582_ _04638_ _04639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13463_ _04498_ _04572_ _04640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13464_ samples_imag\[0\]\[4\] _04640_ _04574_ _04641_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13465_ _04639_ _04641_ _04635_ _04642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13466_ net58 _04642_ _04598_ _04643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13467_ samples_imag\[0\]\[4\] _04643_ _04580_ _00312_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13468_ _07861_ _04533_ _04644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13469_ _07861_ _04533_ _04645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13470_ _04644_ _04582_ _04645_ _04646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13471_ _04495_ _04572_ _04647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13472_ _04008_ _04648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13473_ samples_imag\[0\]\[5\] _04647_ _04648_ _04649_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13474_ _04646_ _04649_ _04635_ _04650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13475_ net59 _04650_ _04598_ _04651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13476_ _04518_ _04652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13477_ samples_imag\[0\]\[5\] _04651_ _04652_ _00313_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13478_ _07856_ _04563_ _04653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13479_ _04582_ _04653_ _04654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13480_ _04494_ _04510_ _04655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13481_ samples_imag\[0\]\[6\] _04655_ _04648_ _04656_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13482_ _04654_ _04656_ _04635_ _04657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13483_ net60 _04657_ _04598_ _04658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13484_ samples_imag\[0\]\[6\] _04658_ _04652_ _00314_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13485_ _07851_ _04536_ _04659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13486_ _07851_ _04536_ _04660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13487_ _04659_ _04582_ _04660_ _04661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13488_ _04502_ _04510_ _04662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13489_ samples_imag\[0\]\[7\] _04662_ _04648_ _04663_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13490_ _04661_ _04663_ _04635_ _04664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13491_ _04577_ _04665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13492_ net61 _04664_ _04665_ _04666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13493_ samples_imag\[0\]\[7\] _04666_ _04652_ _00315_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13494_ _07846_ _04566_ _04667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13495_ _04582_ _04667_ _04668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13496_ _04501_ _04510_ _04669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13497_ samples_imag\[0\]\[8\] _04669_ _04648_ _04670_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13498_ _04668_ _04670_ _04635_ _04671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13499_ net62 _04671_ _04665_ _04672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13500_ samples_imag\[0\]\[8\] _04672_ _04652_ _00316_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13501_ _07841_ _04539_ _04673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13502_ _07841_ _04539_ _04674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13503_ _04673_ _04550_ _04674_ _04675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_13504_ _04493_ _04510_ _04676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13505_ samples_imag\[0\]\[9\] _04676_ _04648_ _04677_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13506_ _04675_ _04677_ _04635_ _04678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13507_ net63 _04678_ _04665_ _04679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13508_ samples_imag\[0\]\[9\] _04679_ _04652_ _00317_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13509_ bit_rev_idx\[0\] _04680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13510_ bit_rev_idx\[1\] _04680_ bit_rev_idx\[2\] _04681_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13511_ state\[2\] _04515_ _04682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13512_ _04513_ _04682_ _04683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_13513_ _04516_ _04681_ _04683_ _04684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_13514_ _04684_ _04685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13515_ _04685_ _04686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13516_ _03735_ _03754_ _04687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_13517_ _04687_ _04688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13518_ _04511_ _04684_ _04689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13519_ samples_imag\[1\]\[0\] _04689_ _04094_ _04690_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13520_ _07817_ _03755_ _04551_ _04685_ _04691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13521_ _04688_ _04690_ _04691_ _04692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13522_ _04556_ _04686_ _04693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13523_ _03647_ _04686_ _04692_ _04255_ _04693_ _00318_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13524_ samples_imag\[1\]\[10\] _04573_ _04094_ _04694_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13525_ _04571_ _04694_ _04688_ _04695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13526_ net49 _04695_ _04665_ _04696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13527_ samples_imag\[1\]\[10\] _04696_ _04686_ _00319_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13528_ samples_imag\[1\]\[11\] _04585_ _04094_ _04697_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13529_ _04584_ _04697_ _04688_ _04698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13530_ net50 _04698_ _04665_ _04699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13531_ samples_imag\[1\]\[11\] _04699_ _04686_ _00320_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13532_ _04021_ _04700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13533_ samples_imag\[1\]\[12\] _04595_ _04700_ _04701_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13534_ _04594_ _04701_ _04688_ _04702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13535_ net51 _04702_ _04665_ _04703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13536_ samples_imag\[1\]\[12\] _04703_ _04686_ _00321_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13537_ samples_imag\[1\]\[13\] _04602_ _04700_ _04704_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13538_ _04601_ _04704_ _04688_ _04705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13539_ net52 _04705_ _04665_ _04706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13540_ samples_imag\[1\]\[13\] _04706_ _04686_ _00322_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13541_ samples_imag\[1\]\[14\] _04610_ _04700_ _04707_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13542_ _04609_ _04707_ _04688_ _04708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13543_ net53 _04708_ _04665_ _04709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13544_ samples_imag\[1\]\[14\] _04709_ _04686_ _00323_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13545_ samples_imag\[1\]\[15\] _04615_ _04700_ _04710_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13546_ _04549_ _04710_ _04688_ _04711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13547_ net54 _04711_ _04665_ _04712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13548_ samples_imag\[1\]\[15\] _04712_ _04686_ _00324_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13549_ samples_imag\[1\]\[1\] _04621_ _04700_ _04713_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13550_ _04620_ _04713_ _04688_ _04714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13551_ net55 _04714_ _04665_ _04715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13552_ _04685_ _04716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13553_ samples_imag\[1\]\[1\] _04715_ _04716_ _00325_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13554_ samples_imag\[1\]\[2\] _04627_ _04700_ _04717_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13555_ _04626_ _04717_ _04688_ _04718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13556_ _04577_ _04719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13557_ net56 _04718_ _04719_ _04720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13558_ samples_imag\[1\]\[2\] _04720_ _04716_ _00326_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13559_ samples_imag\[1\]\[3\] _04633_ _04700_ _04721_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13560_ _04687_ _04722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13561_ _04632_ _04721_ _04722_ _04723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13562_ net57 _04723_ _04719_ _04724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13563_ samples_imag\[1\]\[3\] _04724_ _04716_ _00327_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13564_ samples_imag\[1\]\[4\] _04640_ _04700_ _04725_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13565_ _04639_ _04725_ _04722_ _04726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13566_ net58 _04726_ _04719_ _04727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13567_ samples_imag\[1\]\[4\] _04727_ _04716_ _00328_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13568_ samples_imag\[1\]\[5\] _04647_ _04700_ _04728_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13569_ _04646_ _04728_ _04722_ _04729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13570_ net59 _04729_ _04719_ _04730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13571_ samples_imag\[1\]\[5\] _04730_ _04716_ _00329_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13572_ samples_imag\[1\]\[6\] _04655_ _04700_ _04731_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13573_ _04654_ _04731_ _04722_ _04732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13574_ net60 _04732_ _04719_ _04733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13575_ samples_imag\[1\]\[6\] _04733_ _04716_ _00330_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13576_ _04021_ _04734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13577_ samples_imag\[1\]\[7\] _04662_ _04734_ _04735_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13578_ _04661_ _04735_ _04722_ _04736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13579_ net61 _04736_ _04719_ _04737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13580_ samples_imag\[1\]\[7\] _04737_ _04716_ _00331_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13581_ samples_imag\[1\]\[8\] _04669_ _04734_ _04738_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13582_ _04668_ _04738_ _04722_ _04739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13583_ net62 _04739_ _04719_ _04740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13584_ samples_imag\[1\]\[8\] _04740_ _04716_ _00332_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13585_ samples_imag\[1\]\[9\] _04676_ _04734_ _04741_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13586_ _04675_ _04741_ _04722_ _04742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13587_ net63 _04742_ _04719_ _04743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13588_ samples_imag\[1\]\[9\] _04743_ _04716_ _00333_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13589_ bit_rev_idx\[1\] _04744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13590_ _04744_ bit_rev_idx\[0\] bit_rev_idx\[2\] _04745_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13591_ _04516_ _04745_ _04683_ _04746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_13592_ _04511_ _04746_ _04747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13593_ samples_imag\[2\]\[0\] _04747_ _04189_ _04748_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13594_ _07817_ _04551_ _04746_ _04749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13595_ _04748_ _04749_ _03762_ _04750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13596_ _03596_ _04750_ _04751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13597_ samples_imag\[2\]\[0\] _04556_ _04746_ _04752_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13598_ _04751_ _04752_ _00334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13599_ samples_imag\[2\]\[10\] _04573_ _04189_ _04753_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13600_ _03673_ _03696_ _04754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_13601_ _04754_ _04755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13602_ _04571_ _04753_ _04755_ _04756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13603_ net49 _04756_ _04719_ _04757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13604_ _04746_ _04758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13605_ samples_imag\[2\]\[10\] _04757_ _04758_ _00335_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13606_ samples_imag\[2\]\[11\] _04585_ _04189_ _04759_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13607_ _04584_ _04759_ _04755_ _04760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13608_ net50 _04760_ _04719_ _04761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13609_ samples_imag\[2\]\[11\] _04761_ _04758_ _00336_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13610_ samples_imag\[2\]\[12\] _04595_ _04189_ _04762_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13611_ _04594_ _04762_ _04755_ _04763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13612_ _04577_ _04764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13613_ net51 _04763_ _04764_ _04765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13614_ samples_imag\[2\]\[12\] _04765_ _04758_ _00337_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13615_ samples_imag\[2\]\[13\] _04602_ _04189_ _04766_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13616_ _04601_ _04766_ _04755_ _04767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13617_ net52 _04767_ _04764_ _04768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13618_ samples_imag\[2\]\[13\] _04768_ _04758_ _00338_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13619_ samples_imag\[2\]\[14\] _04610_ _04189_ _04769_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13620_ _04609_ _04769_ _04755_ _04770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13621_ net53 _04770_ _04764_ _04771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13622_ samples_imag\[2\]\[14\] _04771_ _04758_ _00339_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13623_ samples_imag\[2\]\[15\] _04615_ _04189_ _04772_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13624_ _04549_ _04772_ _04755_ _04773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13625_ net54 _04773_ _04764_ _04774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13626_ samples_imag\[2\]\[15\] _04774_ _04758_ _00340_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13627_ samples_imag\[2\]\[1\] _04621_ _04189_ _04775_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13628_ _04620_ _04775_ _04755_ _04776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13629_ net55 _04776_ _04764_ _04777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13630_ samples_imag\[2\]\[1\] _04777_ _04758_ _00341_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13631_ _04076_ _04778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13632_ samples_imag\[2\]\[2\] _04627_ _04778_ _04779_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13633_ _04626_ _04779_ _04755_ _04780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13634_ net56 _04780_ _04764_ _04781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13635_ samples_imag\[2\]\[2\] _04781_ _04758_ _00342_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13636_ samples_imag\[2\]\[3\] _04633_ _04778_ _04782_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13637_ _04632_ _04782_ _04755_ _04783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13638_ net57 _04783_ _04764_ _04784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13639_ samples_imag\[2\]\[3\] _04784_ _04758_ _00343_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13640_ samples_imag\[2\]\[4\] _04640_ _04778_ _04785_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13641_ _04639_ _04785_ _04755_ _04786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13642_ net58 _04786_ _04764_ _04787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13643_ samples_imag\[2\]\[4\] _04787_ _04758_ _00344_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13644_ samples_imag\[2\]\[5\] _04647_ _04778_ _04788_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13645_ _04754_ _04789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13646_ _04646_ _04788_ _04789_ _04790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13647_ net59 _04790_ _04764_ _04791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13648_ _04746_ _04792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13649_ samples_imag\[2\]\[5\] _04791_ _04792_ _00345_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13650_ samples_imag\[2\]\[6\] _04655_ _04778_ _04793_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13651_ _04654_ _04793_ _04789_ _04794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13652_ net60 _04794_ _04764_ _04795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13653_ samples_imag\[2\]\[6\] _04795_ _04792_ _00346_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13654_ samples_imag\[2\]\[7\] _04662_ _04778_ _04796_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13655_ _04661_ _04796_ _04789_ _04797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13656_ _04577_ _04798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13657_ net61 _04797_ _04798_ _04799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13658_ samples_imag\[2\]\[7\] _04799_ _04792_ _00347_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13659_ samples_imag\[2\]\[8\] _04669_ _04778_ _04800_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13660_ _04668_ _04800_ _04789_ _04801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13661_ net62 _04801_ _04798_ _04802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13662_ samples_imag\[2\]\[8\] _04802_ _04792_ _00348_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13663_ samples_imag\[2\]\[9\] _04676_ _04778_ _04803_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13664_ _04675_ _04803_ _04789_ _04804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13665_ net63 _04804_ _04798_ _04805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13666_ samples_imag\[2\]\[9\] _04805_ _04792_ _00349_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13667_ bit_rev_idx\[1\] bit_rev_idx\[0\] _04806_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13668_ bit_rev_idx\[2\] _04806_ _04807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13669_ _04516_ _04807_ _04683_ _04808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_13670_ _04511_ _04808_ _04809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13671_ samples_imag\[3\]\[0\] _04809_ _04157_ _04810_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13672_ _07817_ _04551_ _04808_ _04811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13673_ _04810_ _04811_ _03806_ _04812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13674_ _03596_ _04812_ _04813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13675_ samples_imag\[3\]\[0\] _04556_ _04808_ _04814_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13676_ _04813_ _04814_ _00350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13677_ samples_imag\[3\]\[10\] _04573_ _04157_ _04815_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13678_ _03731_ _03804_ _04816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_13679_ _04816_ _04817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13680_ _04571_ _04815_ _04817_ _04818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13681_ net49 _04818_ _04798_ _04819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13682_ _04808_ _04820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13683_ samples_imag\[3\]\[10\] _04819_ _04820_ _00351_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13684_ samples_imag\[3\]\[11\] _04585_ _04157_ _04821_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13685_ _04584_ _04821_ _04817_ _04822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13686_ net50 _04822_ _04798_ _04823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13687_ samples_imag\[3\]\[11\] _04823_ _04820_ _00352_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13688_ samples_imag\[3\]\[12\] _04595_ _04157_ _04824_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13689_ _04594_ _04824_ _04817_ _04825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13690_ net51 _04825_ _04798_ _04826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13691_ samples_imag\[3\]\[12\] _04826_ _04820_ _00353_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13692_ samples_imag\[3\]\[13\] _04602_ _04157_ _04827_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13693_ _04601_ _04827_ _04817_ _04828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13694_ net52 _04828_ _04798_ _04829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13695_ samples_imag\[3\]\[13\] _04829_ _04820_ _00354_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13696_ samples_imag\[3\]\[14\] _04610_ _04157_ _04830_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13697_ _04609_ _04830_ _04817_ _04831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13698_ net53 _04831_ _04798_ _04832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13699_ samples_imag\[3\]\[14\] _04832_ _04820_ _00355_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13700_ samples_imag\[3\]\[15\] _04615_ _04157_ _04833_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13701_ _04549_ _04833_ _04817_ _04834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13702_ net54 _04834_ _04798_ _04835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13703_ samples_imag\[3\]\[15\] _04835_ _04820_ _00356_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13704_ _04017_ _04836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13705_ samples_imag\[3\]\[1\] _04621_ _04836_ _04837_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13706_ _04620_ _04837_ _04817_ _04838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13707_ net55 _04838_ _04798_ _04839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13708_ samples_imag\[3\]\[1\] _04839_ _04820_ _00357_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13709_ samples_imag\[3\]\[2\] _04627_ _04836_ _04840_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13710_ _04626_ _04840_ _04817_ _04841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13711_ _04577_ _04842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13712_ net56 _04841_ _04842_ _04843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13713_ samples_imag\[3\]\[2\] _04843_ _04820_ _00358_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13714_ samples_imag\[3\]\[3\] _04633_ _04836_ _04844_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13715_ _04632_ _04844_ _04817_ _04845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13716_ net57 _04845_ _04842_ _04846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13717_ samples_imag\[3\]\[3\] _04846_ _04820_ _00359_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13718_ samples_imag\[3\]\[4\] _04640_ _04836_ _04847_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13719_ _04639_ _04847_ _04817_ _04848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13720_ net58 _04848_ _04842_ _04849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13721_ samples_imag\[3\]\[4\] _04849_ _04820_ _00360_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13722_ samples_imag\[3\]\[5\] _04647_ _04836_ _04850_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13723_ _04816_ _04851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13724_ _04646_ _04850_ _04851_ _04852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13725_ net59 _04852_ _04842_ _04853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13726_ _04808_ _04854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13727_ samples_imag\[3\]\[5\] _04853_ _04854_ _00361_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13728_ samples_imag\[3\]\[6\] _04655_ _04836_ _04855_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13729_ _04654_ _04855_ _04851_ _04856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13730_ net60 _04856_ _04842_ _04857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13731_ samples_imag\[3\]\[6\] _04857_ _04854_ _00362_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13732_ samples_imag\[3\]\[7\] _04662_ _04836_ _04858_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13733_ _04661_ _04858_ _04851_ _04859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13734_ net61 _04859_ _04842_ _04860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13735_ samples_imag\[3\]\[7\] _04860_ _04854_ _00363_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13736_ samples_imag\[3\]\[8\] _04669_ _04836_ _04861_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13737_ _04668_ _04861_ _04851_ _04862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13738_ net62 _04862_ _04842_ _04863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13739_ samples_imag\[3\]\[8\] _04863_ _04854_ _00364_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13740_ samples_imag\[3\]\[9\] _04676_ _04836_ _04864_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13741_ _04675_ _04864_ _04851_ _04865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13742_ net63 _04865_ _04842_ _04866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13743_ samples_imag\[3\]\[9\] _04866_ _04854_ _00365_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13744_ bit_rev_idx\[2\] _04867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13745_ bit_rev_idx\[1\] bit_rev_idx\[0\] _04867_ _04868_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13746_ _04516_ _04868_ _04683_ _04869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_13747_ _04511_ _04869_ _04870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13748_ samples_imag\[4\]\[0\] _04870_ _04155_ _04871_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13749_ _07817_ _04551_ _04869_ _04872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13750_ _04871_ _04872_ _03760_ _04873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13751_ _03596_ _04873_ _04874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13752_ samples_imag\[4\]\[0\] _04556_ _04869_ _04875_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13753_ _04874_ _04875_ _00366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13754_ samples_imag\[4\]\[10\] _04573_ _04155_ _04876_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13755_ _03737_ _03758_ _04877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_13756_ _04877_ _04878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13757_ _04571_ _04876_ _04878_ _04879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13758_ net49 _04879_ _04842_ _04880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13759_ _04869_ _04881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13760_ samples_imag\[4\]\[10\] _04880_ _04881_ _00367_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13761_ samples_imag\[4\]\[11\] _04585_ _04155_ _04882_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13762_ _04584_ _04882_ _04878_ _04883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13763_ net50 _04883_ _04842_ _04884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13764_ samples_imag\[4\]\[11\] _04884_ _04881_ _00368_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13765_ samples_imag\[4\]\[12\] _04595_ _04155_ _04885_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13766_ _04594_ _04885_ _04878_ _04886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13767_ _04577_ _04887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13768_ net51 _04886_ _04887_ _04888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13769_ samples_imag\[4\]\[12\] _04888_ _04881_ _00369_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13770_ samples_imag\[4\]\[13\] _04602_ _04155_ _04889_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13771_ _04601_ _04889_ _04878_ _04890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13772_ net52 _04890_ _04887_ _04891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13773_ samples_imag\[4\]\[13\] _04891_ _04881_ _00370_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13774_ samples_imag\[4\]\[14\] _04610_ _04155_ _04892_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13775_ _04609_ _04892_ _04878_ _04893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13776_ net53 _04893_ _04887_ _04894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13777_ samples_imag\[4\]\[14\] _04894_ _04881_ _00371_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13778_ samples_imag\[4\]\[15\] _04615_ _04155_ _04895_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13779_ _04549_ _04895_ _04878_ _04896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13780_ net54 _04896_ _04887_ _04897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13781_ samples_imag\[4\]\[15\] _04897_ _04881_ _00372_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13782_ samples_imag\[4\]\[1\] _04621_ _04155_ _04898_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13783_ _04620_ _04898_ _04878_ _04899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13784_ net55 _04899_ _04887_ _04900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13785_ samples_imag\[4\]\[1\] _04900_ _04881_ _00373_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13786_ _04079_ _04901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13787_ samples_imag\[4\]\[2\] _04627_ _04901_ _04902_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13788_ _04626_ _04902_ _04878_ _04903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13789_ net56 _04903_ _04887_ _04904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13790_ samples_imag\[4\]\[2\] _04904_ _04881_ _00374_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13791_ samples_imag\[4\]\[3\] _04633_ _04901_ _04905_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13792_ _04632_ _04905_ _04878_ _04906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13793_ net57 _04906_ _04887_ _04907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13794_ samples_imag\[4\]\[3\] _04907_ _04881_ _00375_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13795_ samples_imag\[4\]\[4\] _04640_ _04901_ _04908_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13796_ _04639_ _04908_ _04878_ _04909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13797_ net58 _04909_ _04887_ _04910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13798_ samples_imag\[4\]\[4\] _04910_ _04881_ _00376_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13799_ samples_imag\[4\]\[5\] _04647_ _04901_ _04911_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13800_ _04877_ _04912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13801_ _04646_ _04911_ _04912_ _04913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13802_ net59 _04913_ _04887_ _04914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13803_ _04869_ _04915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13804_ samples_imag\[4\]\[5\] _04914_ _04915_ _00377_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13805_ samples_imag\[4\]\[6\] _04655_ _04901_ _04916_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13806_ _04654_ _04916_ _04912_ _04917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13807_ net60 _04917_ _04887_ _04918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13808_ samples_imag\[4\]\[6\] _04918_ _04915_ _00378_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13809_ samples_imag\[4\]\[7\] _04662_ _04901_ _04919_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13810_ _04661_ _04919_ _04912_ _04920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13811_ _03594_ _04921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13812_ _04921_ _04922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13813_ net61 _04920_ _04922_ _04923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13814_ samples_imag\[4\]\[7\] _04923_ _04915_ _00379_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13815_ samples_imag\[4\]\[8\] _04669_ _04901_ _04924_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13816_ _04668_ _04924_ _04912_ _04925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13817_ net62 _04925_ _04922_ _04926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13818_ samples_imag\[4\]\[8\] _04926_ _04915_ _00380_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13819_ samples_imag\[4\]\[9\] _04676_ _04901_ _04927_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13820_ _04675_ _04927_ _04912_ _04928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13821_ net63 _04928_ _04922_ _04929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13822_ samples_imag\[4\]\[9\] _04929_ _04915_ _00381_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13823_ bit_rev_idx\[1\] _04680_ _04867_ _04930_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13824_ _04516_ _04930_ _04683_ _04931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_13825_ _04511_ _04931_ _04932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13826_ samples_imag\[5\]\[0\] _04932_ _04158_ _04933_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13827_ _07817_ _04551_ _04931_ _04934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13828_ _04933_ _04934_ _03820_ _04935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13829_ _03596_ _04935_ _04936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13830_ samples_imag\[5\]\[0\] _04556_ _04931_ _04937_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13831_ _04936_ _04937_ _00382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13832_ samples_imag\[5\]\[10\] _04573_ _04158_ _04938_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13833_ _03737_ _03767_ _04939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_13834_ _04939_ _04940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13835_ _04571_ _04938_ _04940_ _04941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13836_ net49 _04941_ _04922_ _04942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13837_ _04931_ _04943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13838_ samples_imag\[5\]\[10\] _04942_ _04943_ _00383_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13839_ samples_imag\[5\]\[11\] _04585_ _04158_ _04944_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13840_ _04584_ _04944_ _04940_ _04945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13841_ net50 _04945_ _04922_ _04946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13842_ samples_imag\[5\]\[11\] _04946_ _04943_ _00384_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13843_ samples_imag\[5\]\[12\] _04595_ _04158_ _04947_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13844_ _04594_ _04947_ _04940_ _04948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13845_ net51 _04948_ _04922_ _04949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13846_ samples_imag\[5\]\[12\] _04949_ _04943_ _00385_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13847_ samples_imag\[5\]\[13\] _04602_ _04158_ _04950_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13848_ _04601_ _04950_ _04940_ _04951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13849_ net52 _04951_ _04922_ _04952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13850_ samples_imag\[5\]\[13\] _04952_ _04943_ _00386_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13851_ samples_imag\[5\]\[14\] _04610_ _04158_ _04953_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13852_ _04609_ _04953_ _04940_ _04954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13853_ net53 _04954_ _04922_ _04955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13854_ samples_imag\[5\]\[14\] _04955_ _04943_ _00387_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13855_ samples_imag\[5\]\[15\] _04615_ _04158_ _04956_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13856_ _04549_ _04956_ _04940_ _04957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13857_ net54 _04957_ _04922_ _04958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13858_ samples_imag\[5\]\[15\] _04958_ _04943_ _00388_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13859_ _04020_ _04959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13860_ samples_imag\[5\]\[1\] _04621_ _04959_ _04960_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13861_ _04620_ _04960_ _04940_ _04961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13862_ net55 _04961_ _04922_ _04962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13863_ samples_imag\[5\]\[1\] _04962_ _04943_ _00389_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13864_ samples_imag\[5\]\[2\] _04627_ _04959_ _04963_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13865_ _04626_ _04963_ _04940_ _04964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13866_ _04921_ _04965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13867_ net56 _04964_ _04965_ _04966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13868_ samples_imag\[5\]\[2\] _04966_ _04943_ _00390_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13869_ samples_imag\[5\]\[3\] _04633_ _04959_ _04967_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13870_ _04632_ _04967_ _04940_ _04968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13871_ net57 _04968_ _04965_ _04969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13872_ samples_imag\[5\]\[3\] _04969_ _04943_ _00391_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13873_ samples_imag\[5\]\[4\] _04640_ _04959_ _04970_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13874_ _04639_ _04970_ _04940_ _04971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13875_ net58 _04971_ _04965_ _04972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13876_ samples_imag\[5\]\[4\] _04972_ _04943_ _00392_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13877_ samples_imag\[5\]\[5\] _04647_ _04959_ _04973_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13878_ _04939_ _04974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13879_ _04646_ _04973_ _04974_ _04975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13880_ net59 _04975_ _04965_ _04976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13881_ _04931_ _04977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13882_ samples_imag\[5\]\[5\] _04976_ _04977_ _00393_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13883_ samples_imag\[5\]\[6\] _04655_ _04959_ _04978_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13884_ _04654_ _04978_ _04974_ _04979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13885_ net60 _04979_ _04965_ _04980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13886_ samples_imag\[5\]\[6\] _04980_ _04977_ _00394_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13887_ samples_imag\[5\]\[7\] _04662_ _04959_ _04981_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13888_ _04661_ _04981_ _04974_ _04982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13889_ net61 _04982_ _04965_ _04983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13890_ samples_imag\[5\]\[7\] _04983_ _04977_ _00395_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13891_ samples_imag\[5\]\[8\] _04669_ _04959_ _04984_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13892_ _04668_ _04984_ _04974_ _04985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13893_ net62 _04985_ _04965_ _04986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13894_ samples_imag\[5\]\[8\] _04986_ _04977_ _00396_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13895_ samples_imag\[5\]\[9\] _04676_ _04959_ _04987_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13896_ _04675_ _04987_ _04974_ _04988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13897_ net63 _04988_ _04965_ _04989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13898_ samples_imag\[5\]\[9\] _04989_ _04977_ _00397_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13899_ _04744_ bit_rev_idx\[0\] _04867_ _04990_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13900_ _04516_ _04990_ _04683_ _04991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_13901_ _07817_ _04551_ _04991_ _04992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13902_ _04511_ _04991_ _04993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13903_ samples_imag\[6\]\[0\] _04993_ _04041_ _04994_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13904_ _03685_ _03707_ _04995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_13905_ _04995_ _04996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13906_ _04992_ _04994_ _04996_ _04997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13907_ _03596_ _04997_ _04998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13908_ samples_imag\[6\]\[0\] _04556_ _04991_ _04999_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13909_ _04998_ _04999_ _00398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13910_ samples_imag\[6\]\[10\] _04573_ _04041_ _05000_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13911_ _04571_ _05000_ _04996_ _05001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13912_ net49 _05001_ _04965_ _05002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13913_ _04991_ _05003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13914_ samples_imag\[6\]\[10\] _05002_ _05003_ _00399_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13915_ samples_imag\[6\]\[11\] _04585_ _04041_ _05004_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13916_ _04584_ _05004_ _04996_ _05005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13917_ net50 _05005_ _04965_ _05006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13918_ samples_imag\[6\]\[11\] _05006_ _05003_ _00400_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13919_ samples_imag\[6\]\[12\] _04595_ _04041_ _05007_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13920_ _04594_ _05007_ _04996_ _05008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13921_ _04921_ _05009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13922_ net51 _05008_ _05009_ _05010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13923_ samples_imag\[6\]\[12\] _05010_ _05003_ _00401_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13924_ samples_imag\[6\]\[13\] _04602_ _04041_ _05011_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13925_ _04601_ _05011_ _04996_ _05012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13926_ net52 _05012_ _05009_ _05013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13927_ samples_imag\[6\]\[13\] _05013_ _05003_ _00402_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13928_ samples_imag\[6\]\[14\] _04610_ _04041_ _05014_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13929_ _04609_ _05014_ _04996_ _05015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13930_ net53 _05015_ _05009_ _05016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13931_ samples_imag\[6\]\[14\] _05016_ _05003_ _00403_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13932_ samples_imag\[6\]\[15\] _04615_ _04041_ _05017_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13933_ _04549_ _05017_ _04996_ _05018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13934_ net54 _05018_ _05009_ _05019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13935_ samples_imag\[6\]\[15\] _05019_ _05003_ _00404_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13936_ _04040_ _05020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13937_ samples_imag\[6\]\[1\] _04621_ _05020_ _05021_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13938_ _04620_ _05021_ _04996_ _05022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13939_ net55 _05022_ _05009_ _05023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13940_ samples_imag\[6\]\[1\] _05023_ _05003_ _00405_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13941_ samples_imag\[6\]\[2\] _04627_ _05020_ _05024_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13942_ _04626_ _05024_ _04996_ _05025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13943_ net56 _05025_ _05009_ _05026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13944_ samples_imag\[6\]\[2\] _05026_ _05003_ _00406_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13945_ samples_imag\[6\]\[3\] _04633_ _05020_ _05027_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13946_ _04995_ _05028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13947_ _04632_ _05027_ _05028_ _05029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13948_ net57 _05029_ _05009_ _05030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13949_ samples_imag\[6\]\[3\] _05030_ _05003_ _00407_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13950_ samples_imag\[6\]\[4\] _04640_ _05020_ _05031_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13951_ _04639_ _05031_ _05028_ _05032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13952_ net58 _05032_ _05009_ _05033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13953_ samples_imag\[6\]\[4\] _05033_ _05003_ _00408_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13954_ samples_imag\[6\]\[5\] _04647_ _05020_ _05034_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13955_ _04646_ _05034_ _05028_ _05035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13956_ net59 _05035_ _05009_ _05036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13957_ _04991_ _05037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13958_ samples_imag\[6\]\[5\] _05036_ _05037_ _00409_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13959_ samples_imag\[6\]\[6\] _04655_ _05020_ _05038_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13960_ _04654_ _05038_ _05028_ _05039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13961_ net60 _05039_ _05009_ _05040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13962_ samples_imag\[6\]\[6\] _05040_ _05037_ _00410_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13963_ samples_imag\[6\]\[7\] _04662_ _05020_ _05041_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13964_ _04661_ _05041_ _05028_ _05042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13965_ _04921_ _05043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13966_ net61 _05042_ _05043_ _05044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13967_ samples_imag\[6\]\[7\] _05044_ _05037_ _00411_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13968_ samples_imag\[6\]\[8\] _04669_ _05020_ _05045_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13969_ _04668_ _05045_ _05028_ _05046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13970_ net62 _05046_ _05043_ _05047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13971_ samples_imag\[6\]\[8\] _05047_ _05037_ _00412_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13972_ samples_imag\[6\]\[9\] _04676_ _05020_ _05048_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13973_ _04675_ _05048_ _05028_ _05049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13974_ net63 _05049_ _05043_ _05050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13975_ samples_imag\[6\]\[9\] _05050_ _05037_ _00413_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13976_ _03643_ _04011_ _05051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13977_ _04867_ _04806_ _05052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13978_ net80 _05052_ _04515_ _05053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13979_ _04254_ _05053_ _04513_ _05054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_13980_ _05051_ _05054_ _05055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13981_ samples_imag\[7\]\[0\] _05051_ _04511_ _05055_ _05056_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_13982_ _03729_ _03707_ _05057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_13983_ _05057_ _05058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13984_ _05058_ _05054_ _05059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13985_ _03753_ _05056_ _05059_ _04552_ _05060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_13986_ _03596_ _05060_ _05061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13987_ _04556_ samples_imag\[7\]\[0\] _05054_ _05062_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13988_ _05061_ _05062_ _00414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13989_ samples_imag\[7\]\[10\] _04573_ _04164_ _05063_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13990_ _04571_ _05063_ _05058_ _05064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13991_ _03594_ _05065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_13992_ net49 _05064_ _05065_ _05066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13993_ _05054_ _05067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_13994_ _05066_ samples_imag\[7\]\[10\] _05067_ _00415_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13995_ samples_imag\[7\]\[11\] _04585_ _04164_ _05068_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13996_ _04584_ _05068_ _05058_ _05069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13997_ net50 _05069_ _05065_ _05070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13998_ _05070_ samples_imag\[7\]\[11\] _05067_ _00416_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13999_ samples_imag\[7\]\[12\] _04595_ _04164_ _05071_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14000_ _04594_ _05071_ _05058_ _05072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14001_ _04577_ _05073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14002_ net51 _05072_ _05073_ _05074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14003_ _05074_ samples_imag\[7\]\[12\] _05067_ _00417_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14004_ samples_imag\[7\]\[13\] _04602_ _04164_ _05075_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14005_ _04601_ _05075_ _05058_ _05076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14006_ net52 _05076_ _05073_ _05077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14007_ _05077_ samples_imag\[7\]\[13\] _05067_ _00418_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14008_ samples_imag\[7\]\[14\] _04610_ _04164_ _05078_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14009_ _04609_ _05078_ _05058_ _05079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14010_ net53 _05079_ _05073_ _05080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14011_ _05080_ samples_imag\[7\]\[14\] _05067_ _00419_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14012_ samples_imag\[7\]\[15\] _04615_ _04164_ _05081_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14013_ _04549_ _05081_ _05058_ _05082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14014_ net54 _05082_ _05073_ _05083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14015_ _05083_ samples_imag\[7\]\[15\] _05067_ _00420_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14016_ samples_imag\[7\]\[1\] _04621_ _04164_ _05084_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14017_ _04620_ _05084_ _05058_ _05085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14018_ net55 _05085_ _05073_ _05086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14019_ _05086_ samples_imag\[7\]\[1\] _05067_ _00421_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14020_ samples_imag\[7\]\[2\] _04627_ _04164_ _05087_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14021_ _04626_ _05087_ _05058_ _05088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14022_ net56 _05088_ _05073_ _05089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14023_ _05089_ samples_imag\[7\]\[2\] _05067_ _00422_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14024_ samples_imag\[7\]\[3\] _04633_ _04164_ _05090_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14025_ _04632_ _05090_ _05058_ _05091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14026_ net57 _05091_ _05073_ _05092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14027_ _05092_ samples_imag\[7\]\[3\] _05067_ _00423_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14028_ _04013_ _05093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14029_ samples_imag\[7\]\[4\] _04640_ _05093_ _05094_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14030_ _05057_ _05095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14031_ _04639_ _05094_ _05095_ _05096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14032_ net58 _05096_ _05073_ _05097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14033_ _05097_ samples_imag\[7\]\[4\] _05067_ _00424_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14034_ samples_imag\[7\]\[5\] _04647_ _05093_ _05098_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14035_ _04646_ _05098_ _05095_ _05099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14036_ net59 _05099_ _05073_ _05100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14037_ _05054_ _05101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14038_ _05100_ samples_imag\[7\]\[5\] _05101_ _00425_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14039_ samples_imag\[7\]\[6\] _04655_ _05093_ _05102_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14040_ _04654_ _05102_ _05095_ _05103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14041_ net60 _05103_ _05073_ _05104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14042_ _05104_ samples_imag\[7\]\[6\] _05101_ _00426_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14043_ samples_imag\[7\]\[7\] _04662_ _05093_ _05105_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14044_ _04661_ _05105_ _05095_ _05106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14045_ _04577_ _05107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14046_ net61 _05106_ _05107_ _05108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14047_ _05108_ samples_imag\[7\]\[7\] _05101_ _00427_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14048_ samples_imag\[7\]\[8\] _04669_ _05093_ _05109_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14049_ _04668_ _05109_ _05095_ _05110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14050_ net62 _05110_ _05107_ _05111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14051_ _05111_ samples_imag\[7\]\[8\] _05101_ _00428_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14052_ samples_imag\[7\]\[9\] _04676_ _05093_ _05112_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14053_ _04675_ _05112_ _05095_ _05113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14054_ net63 _05113_ _05107_ _05114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14055_ _05114_ samples_imag\[7\]\[9\] _05101_ _00429_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14056_ _07703_ _05115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14057_ temp_real\[0\] _04037_ _05116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14058_ _07698_ _05117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14059_ _07717_ _05118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14060_ _07727_ _05119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14061_ _07737_ _05120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14062_ _07747_ _05121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14063_ _07757_ _05122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_14064_ _07766_ _05123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14065_ _05123_ _07701_ _07767_ _05124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14066_ _07763_ _05125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14067_ _07762_ _05124_ _05125_ _05126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14068_ _05122_ _05126_ _07758_ _05127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14069_ _07753_ _05128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14070_ _07752_ _05127_ _05128_ _05129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14071_ _05121_ _05129_ _07748_ _05130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14072_ _07743_ _05131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14073_ _07742_ _05130_ _05131_ _05132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14074_ _05120_ _05132_ _07738_ _05133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14075_ _07733_ _05134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14076_ _07732_ _05133_ _05134_ _05135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14077_ _05119_ _05135_ _07728_ _05136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14078_ _07723_ _05137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14079_ _07722_ _05136_ _05137_ _05138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14080_ _05118_ _05138_ _07718_ _05139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14081_ _07713_ _05140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14082_ _07712_ _05139_ _05140_ _05141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14083_ _05117_ _05141_ _07699_ _05142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14084_ _07694_ _05143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14085_ _07693_ _05142_ _05143_ _05144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14086_ _05116_ _05144_ _05145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14087_ _07762_ _05855_ _05125_ _05146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14088_ _05122_ _05146_ _07758_ _05147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14089_ _07752_ _05147_ _05128_ _05148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14090_ _05121_ _05148_ _07748_ _05149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14091_ _07742_ _05149_ _05131_ _05150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14092_ _05120_ _05150_ _07738_ _05151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14093_ _07732_ _05151_ _05134_ _05152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14094_ _05119_ _05152_ _07728_ _05153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14095_ _07722_ _05153_ _05137_ _05154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14096_ _05118_ _05154_ _07718_ _05155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14097_ _07712_ _05155_ _05140_ _05156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14098_ _05117_ _05156_ _07699_ _05157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14099_ _07693_ _05157_ _05158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14100_ _05117_ _05141_ _05159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14101_ _05119_ _05135_ _05160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14102_ _07712_ _05155_ _05161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14103_ _05118_ _05138_ _05162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14104_ _07722_ _05153_ _05163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14105_ _07742_ _05149_ _05164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14106_ _05121_ _05129_ _05165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14107_ _05122_ _05126_ _05166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14108_ _07762_ _05855_ _05167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14109_ _07752_ _05147_ _05168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14110_ _05856_ _05115_ _05167_ _05168_ _05169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_14111_ _05164_ _05165_ _05166_ _05169_ _05170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_14112_ _07732_ _05151_ _05171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14113_ _05120_ _05132_ _05172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14114_ _05163_ _05170_ _05171_ _05172_ _05173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_14115_ _05160_ _05161_ _05162_ _05173_ _05174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_14116_ _05158_ _05159_ _05174_ _05175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_14117_ temp_real\[0\] _07708_ _05175_ _05176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_14118_ _05145_ _05176_ _05177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14119_ _05115_ _05177_ _05178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14120_ samples_real\[0\]\[0\] _03641_ _04519_ _05178_ _05179_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14121_ _07697_ _05180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14122_ _07711_ _05181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14123_ _07721_ _05182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14124_ _07731_ _05183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14125_ _07741_ _05184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14126_ _07751_ _05185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14127_ _07761_ _05186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14128_ _07766_ _05858_ _05187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14129_ _07765_ _05187_ _07762_ _05188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14130_ _05186_ _05188_ _05189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14131_ _07757_ _05189_ _05190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14132_ _07756_ _05190_ _07752_ _05191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14133_ _05185_ _05191_ _05192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14134_ _07747_ _05192_ _05193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14135_ _07746_ _05193_ _07742_ _05194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14136_ _05184_ _05194_ _05195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14137_ _07737_ _05195_ _05196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14138_ _07736_ _05196_ _07732_ _05197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14139_ _05183_ _05197_ _05198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14140_ _07727_ _05198_ _05199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14141_ _07726_ _05199_ _07722_ _05200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14142_ _05182_ _05200_ _05201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14143_ _07717_ _05201_ _05202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14144_ _07716_ _05202_ _07712_ _05203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14145_ _05181_ _05203_ _05204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14146_ _07698_ _05204_ _05205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14147_ _05180_ _05205_ _05206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14148_ _07693_ _05206_ _07692_ _05207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14149_ _05116_ _05207_ _05208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_4
X_14150_ temp_real\[0\] _07709_ _05208_ _05209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_14151_ _05209_ _05210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14152_ _07703_ _05210_ _05211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14153_ _03728_ _05179_ _05211_ _04553_ _05212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14154_ _03596_ _05212_ _05213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14155_ _04255_ net64 _05214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14156_ samples_real\[0\]\[0\] _05214_ _04518_ _05215_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14157_ _05213_ _05215_ _00430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14158_ _07762_ _05859_ _07761_ _05216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14159_ _07756_ _05217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14160_ _05122_ _05216_ _05217_ _05218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14161_ _07752_ _05218_ _07751_ _05219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14162_ _07746_ _05220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14163_ _05121_ _05219_ _05220_ _05221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14164_ _07742_ _05221_ _07741_ _05222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14165_ _07736_ _05223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14166_ _05120_ _05222_ _05223_ _05224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14167_ _07732_ _05224_ _07731_ _05225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14168_ _07726_ _05226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14169_ _05119_ _05225_ _05226_ _05227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14170_ _07722_ _05227_ _05228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14171_ _05210_ _05228_ _05229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14172_ _05177_ _05230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14173_ _05163_ _05230_ _05231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14174_ samples_real\[0\]\[10\] _05231_ _04648_ _05232_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14175_ _05229_ _05232_ _04635_ _05233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14176_ net65 _05233_ _05043_ _05234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14177_ samples_real\[0\]\[10\] _05234_ _04652_ _00431_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14178_ _07717_ _05201_ _05235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14179_ _05209_ _05236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14180_ _07717_ _05201_ _05237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14181_ _05235_ _05236_ _05237_ _05238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_14182_ _05162_ _05230_ _05239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14183_ samples_real\[0\]\[11\] _05239_ _04648_ _05240_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14184_ _05238_ _05240_ _04635_ _05241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14185_ net66 _05241_ _05043_ _05242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14186_ samples_real\[0\]\[11\] _05242_ _04652_ _00432_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14187_ _07722_ _05227_ _07721_ _05243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14188_ _07716_ _05244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14189_ _05118_ _05243_ _05244_ _05245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14190_ _07712_ _05245_ _05246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14191_ _07712_ _05245_ _05247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14192_ _05236_ _05246_ _05247_ _05248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_14193_ _05161_ _05230_ _05249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14194_ samples_real\[0\]\[12\] _05249_ _04648_ _05250_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14195_ _05248_ _05250_ _04635_ _05251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14196_ net67 _05251_ _05043_ _05252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14197_ samples_real\[0\]\[12\] _05252_ _04652_ _00433_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14198_ _07698_ _05204_ _05253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14199_ _05205_ _05236_ _05253_ _05254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14200_ _05159_ _05230_ _05255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14201_ samples_real\[0\]\[13\] _05255_ _04648_ _05256_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14202_ _03712_ _05257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14203_ _05254_ _05256_ _05257_ _05258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14204_ net68 _05258_ _05043_ _05259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14205_ samples_real\[0\]\[13\] _05259_ _04652_ _00434_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14206_ _05181_ _05247_ _05260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14207_ _07698_ _05260_ _07697_ _05261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14208_ _07693_ _05261_ _05262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14209_ _05210_ _05262_ _05263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14210_ _05158_ _05230_ _05264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14211_ samples_real\[0\]\[14\] _05264_ _04648_ _05265_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14212_ _05263_ _05265_ _05257_ _05266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14213_ net69 _05266_ _05043_ _05267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14214_ samples_real\[0\]\[14\] _05267_ _04652_ _00435_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14215_ _05145_ _05268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14216_ _05268_ _05176_ _05269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_14217_ _04008_ _05270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14218_ samples_real\[0\]\[15\] _05269_ _05270_ _05271_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14219_ _05208_ _05271_ _05257_ _05272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14220_ net70 _05272_ _05043_ _05273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14221_ _04518_ _05274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14222_ samples_real\[0\]\[15\] _05273_ _05274_ _00436_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14223_ _05860_ _05275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14224_ _05275_ _05236_ _05276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14225_ _05856_ _05230_ _05277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14226_ samples_real\[0\]\[1\] _05277_ _05270_ _05278_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14227_ _05276_ _05278_ _05257_ _05279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14228_ net71 _05279_ _05043_ _05280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14229_ samples_real\[0\]\[1\] _05280_ _05274_ _00437_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14230_ _07762_ _05859_ _05281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14231_ _05210_ _05281_ _05282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_14232_ _05167_ _05230_ _05283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14233_ samples_real\[0\]\[2\] _05283_ _05270_ _05284_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14234_ _05282_ _05284_ _05257_ _05285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14235_ _04921_ _05286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14236_ net72 _05285_ _05286_ _05287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14237_ samples_real\[0\]\[2\] _05287_ _05274_ _00438_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14238_ _05122_ _05189_ _05288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14239_ _05236_ _05288_ _05289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14240_ _05166_ _05230_ _05290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14241_ samples_real\[0\]\[3\] _05290_ _05270_ _05291_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14242_ _05289_ _05291_ _05257_ _05292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14243_ net73 _05292_ _05286_ _05293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14244_ samples_real\[0\]\[3\] _05293_ _05274_ _00439_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14245_ _07752_ _05218_ _05294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14246_ _05236_ _05294_ _05295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14247_ _05168_ _05230_ _05296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14248_ samples_real\[0\]\[4\] _05296_ _05270_ _05297_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14249_ _05295_ _05297_ _05257_ _05298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14250_ net74 _05298_ _05286_ _05299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14251_ samples_real\[0\]\[4\] _05299_ _05274_ _00440_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14252_ _07747_ _05192_ _05300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14253_ _07747_ _05192_ _05301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14254_ _05300_ _05236_ _05301_ _05302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14255_ _05165_ _05230_ _05303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14256_ samples_real\[0\]\[5\] _05303_ _05270_ _05304_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14257_ _05302_ _05304_ _05257_ _05305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14258_ net75 _05305_ _05286_ _05306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14259_ samples_real\[0\]\[5\] _05306_ _05274_ _00441_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14260_ _07742_ _05221_ _05307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14261_ _05236_ _05307_ _05308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_14262_ _05164_ _05177_ _05309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14263_ samples_real\[0\]\[6\] _05309_ _05270_ _05310_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14264_ _05308_ _05310_ _05257_ _05311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14265_ net76 _05311_ _05286_ _05312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14266_ samples_real\[0\]\[6\] _05312_ _05274_ _00442_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14267_ _07737_ _05195_ _05313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14268_ _07737_ _05195_ _05314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14269_ _05313_ _05236_ _05314_ _05315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_14270_ _05172_ _05177_ _05316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14271_ samples_real\[0\]\[7\] _05316_ _05270_ _05317_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14272_ _05315_ _05317_ _05257_ _05318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14273_ net77 _05318_ _05286_ _05319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14274_ samples_real\[0\]\[7\] _05319_ _05274_ _00443_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14275_ _07732_ _05224_ _05320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14276_ _05236_ _05320_ _05321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14277_ _05171_ _05177_ _05322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14278_ samples_real\[0\]\[8\] _05322_ _05270_ _05323_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14279_ _05321_ _05323_ _03712_ _05324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14280_ net78 _05324_ _05286_ _05325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14281_ samples_real\[0\]\[8\] _05325_ _05274_ _00444_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14282_ _07727_ _05198_ _05326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14283_ _07727_ _05198_ _05327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14284_ _05326_ _05209_ _05327_ _05328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_14285_ _05160_ _05177_ _05329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14286_ samples_real\[0\]\[9\] _05329_ _05270_ _05330_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14287_ _05328_ _05330_ _03712_ _05331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14288_ net79 _05331_ _05286_ _05332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14289_ samples_real\[0\]\[9\] _05332_ _05274_ _00445_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14290_ _04685_ _05178_ _05333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14291_ samples_real\[1\]\[0\] _05333_ _04094_ _05334_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14292_ _07703_ _03755_ _04685_ _05210_ _05335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_14293_ _04688_ _05334_ _05335_ _05336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14294_ _04686_ _05214_ _05337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14295_ _03614_ _04686_ _05336_ _04255_ _05337_ _00446_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_14296_ samples_real\[1\]\[10\] _05231_ _04734_ _05338_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14297_ _05229_ _05338_ _04722_ _05339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14298_ net65 _05339_ _05286_ _05340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14299_ samples_real\[1\]\[10\] _05340_ _04716_ _00447_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14300_ samples_real\[1\]\[11\] _05239_ _04734_ _05341_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14301_ _05238_ _05341_ _04722_ _05342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14302_ net66 _05342_ _05286_ _05343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14303_ _04685_ _05344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14304_ samples_real\[1\]\[11\] _05343_ _05344_ _00448_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14305_ samples_real\[1\]\[12\] _05249_ _04734_ _05345_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14306_ _05248_ _05345_ _04722_ _05346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14307_ _04921_ _05347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14308_ net67 _05346_ _05347_ _05348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14309_ samples_real\[1\]\[12\] _05348_ _05344_ _00449_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14310_ samples_real\[1\]\[13\] _05255_ _04734_ _05349_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14311_ _04687_ _05350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14312_ _05254_ _05349_ _05350_ _05351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14313_ net68 _05351_ _05347_ _05352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14314_ samples_real\[1\]\[13\] _05352_ _05344_ _00450_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14315_ samples_real\[1\]\[14\] _05264_ _04734_ _05353_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14316_ _05263_ _05353_ _05350_ _05354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14317_ net69 _05354_ _05347_ _05355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14318_ samples_real\[1\]\[14\] _05355_ _05344_ _00451_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14319_ samples_real\[1\]\[15\] _05269_ _04734_ _05356_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14320_ _05208_ _05356_ _05350_ _05357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14321_ net70 _05357_ _05347_ _05358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14322_ samples_real\[1\]\[15\] _05358_ _05344_ _00452_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14323_ samples_real\[1\]\[1\] _05277_ _04734_ _05359_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14324_ _05276_ _05359_ _05350_ _05360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14325_ net71 _05360_ _05347_ _05361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14326_ samples_real\[1\]\[1\] _05361_ _05344_ _00453_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14327_ samples_real\[1\]\[2\] _05283_ _04022_ _05362_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14328_ _05282_ _05362_ _05350_ _05363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14329_ net72 _05363_ _05347_ _05364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14330_ samples_real\[1\]\[2\] _05364_ _05344_ _00454_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14331_ samples_real\[1\]\[3\] _05290_ _04022_ _05365_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14332_ _05289_ _05365_ _05350_ _05366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14333_ net73 _05366_ _05347_ _05367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14334_ samples_real\[1\]\[3\] _05367_ _05344_ _00455_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14335_ samples_real\[1\]\[4\] _05296_ _04022_ _05368_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14336_ _05295_ _05368_ _05350_ _05369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14337_ net74 _05369_ _05347_ _05370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14338_ samples_real\[1\]\[4\] _05370_ _05344_ _00456_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14339_ samples_real\[1\]\[5\] _05303_ _04022_ _05371_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14340_ _05302_ _05371_ _05350_ _05372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14341_ net75 _05372_ _05347_ _05373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14342_ samples_real\[1\]\[5\] _05373_ _05344_ _00457_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14343_ samples_real\[1\]\[6\] _05309_ _04022_ _05374_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14344_ _05308_ _05374_ _05350_ _05375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14345_ net76 _05375_ _05347_ _05376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14346_ samples_real\[1\]\[6\] _05376_ _04685_ _00458_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14347_ samples_real\[1\]\[7\] _05316_ _04022_ _05377_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14348_ _05315_ _05377_ _05350_ _05378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14349_ _04921_ _05379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14350_ net77 _05378_ _05379_ _05380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14351_ samples_real\[1\]\[7\] _05380_ _04685_ _00459_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14352_ samples_real\[1\]\[8\] _05322_ _04022_ _05381_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14353_ _05321_ _05381_ _04687_ _05382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14354_ net78 _05382_ _05379_ _05383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14355_ samples_real\[1\]\[8\] _05383_ _04685_ _00460_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14356_ samples_real\[1\]\[9\] _05329_ _04022_ _05384_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14357_ _05328_ _05384_ _04687_ _05385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14358_ net79 _05385_ _05379_ _05386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14359_ samples_real\[1\]\[9\] _05386_ _04685_ _00461_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14360_ _04746_ _05178_ _05387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14361_ samples_real\[2\]\[0\] _05387_ _04189_ _05388_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14362_ _07703_ _04746_ _05210_ _05389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14363_ _05388_ _05389_ _03762_ _05390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14364_ _03596_ _05390_ _05391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14365_ samples_real\[2\]\[0\] _05214_ _04746_ _05392_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14366_ _05391_ _05392_ _00462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14367_ samples_real\[2\]\[10\] _05231_ _04778_ _05393_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14368_ _05229_ _05393_ _04789_ _05394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14369_ net65 _05394_ _05379_ _05395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14370_ samples_real\[2\]\[10\] _05395_ _04792_ _00463_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14371_ samples_real\[2\]\[11\] _05239_ _04778_ _05396_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14372_ _05238_ _05396_ _04789_ _05397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14373_ net66 _05397_ _05379_ _05398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14374_ samples_real\[2\]\[11\] _05398_ _04792_ _00464_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14375_ _04076_ _05399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14376_ samples_real\[2\]\[12\] _05249_ _05399_ _05400_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14377_ _05248_ _05400_ _04789_ _05401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14378_ net67 _05401_ _05379_ _05402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14379_ samples_real\[2\]\[12\] _05402_ _04792_ _00465_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14380_ samples_real\[2\]\[13\] _05255_ _05399_ _05403_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14381_ _05254_ _05403_ _04789_ _05404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14382_ net68 _05404_ _05379_ _05405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14383_ samples_real\[2\]\[13\] _05405_ _04792_ _00466_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14384_ samples_real\[2\]\[14\] _05264_ _05399_ _05406_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14385_ _05263_ _05406_ _04789_ _05407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14386_ net69 _05407_ _05379_ _05408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14387_ samples_real\[2\]\[14\] _05408_ _04792_ _00467_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14388_ samples_real\[2\]\[15\] _05269_ _05399_ _05409_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14389_ _04754_ _05410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14390_ _05208_ _05409_ _05410_ _05411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14391_ net70 _05411_ _05379_ _05412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14392_ _04746_ _05413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14393_ samples_real\[2\]\[15\] _05412_ _05413_ _00468_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14394_ samples_real\[2\]\[1\] _05277_ _05399_ _05414_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14395_ _05276_ _05414_ _05410_ _05415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14396_ net71 _05415_ _05379_ _05416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14397_ samples_real\[2\]\[1\] _05416_ _05413_ _00469_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14398_ samples_real\[2\]\[2\] _05283_ _05399_ _05417_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14399_ _05282_ _05417_ _05410_ _05418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14400_ _04921_ _05419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14401_ net72 _05418_ _05419_ _05420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14402_ samples_real\[2\]\[2\] _05420_ _05413_ _00470_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14403_ samples_real\[2\]\[3\] _05290_ _05399_ _05421_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14404_ _05289_ _05421_ _05410_ _05422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14405_ net73 _05422_ _05419_ _05423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14406_ samples_real\[2\]\[3\] _05423_ _05413_ _00471_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14407_ samples_real\[2\]\[4\] _05296_ _05399_ _05424_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14408_ _05295_ _05424_ _05410_ _05425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14409_ net74 _05425_ _05419_ _05426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14410_ samples_real\[2\]\[4\] _05426_ _05413_ _00472_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14411_ samples_real\[2\]\[5\] _05303_ _05399_ _05427_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14412_ _05302_ _05427_ _05410_ _05428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14413_ net75 _05428_ _05419_ _05429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14414_ samples_real\[2\]\[5\] _05429_ _05413_ _00473_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14415_ samples_real\[2\]\[6\] _05309_ _05399_ _05430_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14416_ _05308_ _05430_ _05410_ _05431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14417_ net76 _05431_ _05419_ _05432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14418_ samples_real\[2\]\[6\] _05432_ _05413_ _00474_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14419_ samples_real\[2\]\[7\] _05316_ _04076_ _05433_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14420_ _05315_ _05433_ _05410_ _05434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14421_ net77 _05434_ _05419_ _05435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14422_ samples_real\[2\]\[7\] _05435_ _05413_ _00475_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14423_ samples_real\[2\]\[8\] _05322_ _04076_ _05436_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14424_ _05321_ _05436_ _05410_ _05437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14425_ net78 _05437_ _05419_ _05438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14426_ samples_real\[2\]\[8\] _05438_ _05413_ _00476_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14427_ samples_real\[2\]\[9\] _05329_ _04076_ _05439_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14428_ _05328_ _05439_ _05410_ _05440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14429_ net79 _05440_ _05419_ _05441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14430_ samples_real\[2\]\[9\] _05441_ _05413_ _00477_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14431_ _04808_ _05178_ _05442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14432_ samples_real\[3\]\[0\] _05442_ _04157_ _05443_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14433_ _07703_ _04808_ _05210_ _05444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14434_ _05443_ _05444_ _03806_ _05445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14435_ _05065_ _05445_ _05446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14436_ samples_real\[3\]\[0\] _05214_ _04808_ _05447_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14437_ _05446_ _05447_ _00478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14438_ samples_real\[3\]\[10\] _05231_ _04836_ _05448_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14439_ _05229_ _05448_ _04851_ _05449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14440_ net65 _05449_ _05419_ _05450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14441_ samples_real\[3\]\[10\] _05450_ _04854_ _00479_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14442_ _04017_ _05451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14443_ samples_real\[3\]\[11\] _05239_ _05451_ _05452_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14444_ _05238_ _05452_ _04851_ _05453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14445_ net66 _05453_ _05419_ _05454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14446_ samples_real\[3\]\[11\] _05454_ _04854_ _00480_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14447_ samples_real\[3\]\[12\] _05249_ _05451_ _05455_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14448_ _05248_ _05455_ _04851_ _05456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14449_ _04921_ _05457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14450_ net67 _05456_ _05457_ _05458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14451_ samples_real\[3\]\[12\] _05458_ _04854_ _00481_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14452_ samples_real\[3\]\[13\] _05255_ _05451_ _05459_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14453_ _05254_ _05459_ _04851_ _05460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14454_ net68 _05460_ _05457_ _05461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14455_ samples_real\[3\]\[13\] _05461_ _04854_ _00482_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14456_ samples_real\[3\]\[14\] _05264_ _05451_ _05462_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14457_ _05263_ _05462_ _04851_ _05463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14458_ net69 _05463_ _05457_ _05464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14459_ samples_real\[3\]\[14\] _05464_ _04854_ _00483_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14460_ samples_real\[3\]\[15\] _05269_ _05451_ _05465_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14461_ _04816_ _05466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14462_ _05208_ _05465_ _05466_ _05467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14463_ net70 _05467_ _05457_ _05468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14464_ _04808_ _05469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14465_ samples_real\[3\]\[15\] _05468_ _05469_ _00484_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14466_ samples_real\[3\]\[1\] _05277_ _05451_ _05470_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14467_ _05276_ _05470_ _05466_ _05471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14468_ net71 _05471_ _05457_ _05472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14469_ samples_real\[3\]\[1\] _05472_ _05469_ _00485_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14470_ samples_real\[3\]\[2\] _05283_ _05451_ _05473_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14471_ _05282_ _05473_ _05466_ _05474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14472_ net72 _05474_ _05457_ _05475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14473_ samples_real\[3\]\[2\] _05475_ _05469_ _00486_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14474_ samples_real\[3\]\[3\] _05290_ _05451_ _05476_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14475_ _05289_ _05476_ _05466_ _05477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14476_ net73 _05477_ _05457_ _05478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14477_ samples_real\[3\]\[3\] _05478_ _05469_ _00487_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14478_ samples_real\[3\]\[4\] _05296_ _05451_ _05479_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14479_ _05295_ _05479_ _05466_ _05480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14480_ net74 _05480_ _05457_ _05481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14481_ samples_real\[3\]\[4\] _05481_ _05469_ _00488_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14482_ samples_real\[3\]\[5\] _05303_ _05451_ _05482_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14483_ _05302_ _05482_ _05466_ _05483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14484_ net75 _05483_ _05457_ _05484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14485_ samples_real\[3\]\[5\] _05484_ _05469_ _00489_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14486_ samples_real\[3\]\[6\] _05309_ _04017_ _05485_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14487_ _05308_ _05485_ _05466_ _05486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14488_ net76 _05486_ _05457_ _05487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14489_ samples_real\[3\]\[6\] _05487_ _05469_ _00490_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14490_ samples_real\[3\]\[7\] _05316_ _04017_ _05488_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14491_ _05315_ _05488_ _05466_ _05489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14492_ _04921_ _05490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14493_ net77 _05489_ _05490_ _05491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14494_ samples_real\[3\]\[7\] _05491_ _05469_ _00491_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14495_ samples_real\[3\]\[8\] _05322_ _04017_ _05492_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14496_ _05321_ _05492_ _05466_ _05493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14497_ net78 _05493_ _05490_ _05494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14498_ samples_real\[3\]\[8\] _05494_ _05469_ _00492_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14499_ samples_real\[3\]\[9\] _05329_ _04017_ _05495_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14500_ _05328_ _05495_ _05466_ _05496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14501_ net79 _05496_ _05490_ _05497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14502_ samples_real\[3\]\[9\] _05497_ _05469_ _00493_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14503_ _04869_ _05178_ _05498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14504_ samples_real\[4\]\[0\] _05498_ _04155_ _05499_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14505_ _07703_ _04869_ _05210_ _05500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14506_ _05499_ _05500_ _03760_ _05501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14507_ _05065_ _05501_ _05502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14508_ samples_real\[4\]\[0\] _05214_ _04869_ _05503_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14509_ _05502_ _05503_ _00494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14510_ samples_real\[4\]\[10\] _05231_ _04901_ _05504_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14511_ _05229_ _05504_ _04912_ _05505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14512_ net65 _05505_ _05490_ _05506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14513_ samples_real\[4\]\[10\] _05506_ _04915_ _00495_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14514_ samples_real\[4\]\[11\] _05239_ _04901_ _05507_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14515_ _05238_ _05507_ _04912_ _05508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14516_ net66 _05508_ _05490_ _05509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14517_ samples_real\[4\]\[11\] _05509_ _04915_ _00496_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14518_ _04079_ _05510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14519_ samples_real\[4\]\[12\] _05249_ _05510_ _05511_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14520_ _05248_ _05511_ _04912_ _05512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14521_ net67 _05512_ _05490_ _05513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14522_ samples_real\[4\]\[12\] _05513_ _04915_ _00497_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14523_ samples_real\[4\]\[13\] _05255_ _05510_ _05514_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14524_ _05254_ _05514_ _04912_ _05515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14525_ net68 _05515_ _05490_ _05516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14526_ samples_real\[4\]\[13\] _05516_ _04915_ _00498_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14527_ samples_real\[4\]\[14\] _05264_ _05510_ _05517_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14528_ _05263_ _05517_ _04912_ _05518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14529_ net69 _05518_ _05490_ _05519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14530_ samples_real\[4\]\[14\] _05519_ _04915_ _00499_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14531_ samples_real\[4\]\[15\] _05269_ _05510_ _05520_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14532_ _04877_ _05521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14533_ _05208_ _05520_ _05521_ _05522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14534_ net70 _05522_ _05490_ _05523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14535_ _04869_ _05524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14536_ samples_real\[4\]\[15\] _05523_ _05524_ _00500_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14537_ samples_real\[4\]\[1\] _05277_ _05510_ _05525_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14538_ _05276_ _05525_ _05521_ _05526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14539_ net71 _05526_ _05490_ _05527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14540_ samples_real\[4\]\[1\] _05527_ _05524_ _00501_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14541_ samples_real\[4\]\[2\] _05283_ _05510_ _05528_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14542_ _05282_ _05528_ _05521_ _05529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14543_ _03594_ _05530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14544_ net72 _05529_ _05530_ _05531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14545_ samples_real\[4\]\[2\] _05531_ _05524_ _00502_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14546_ samples_real\[4\]\[3\] _05290_ _05510_ _05532_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14547_ _05289_ _05532_ _05521_ _05533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14548_ net73 _05533_ _05530_ _05534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14549_ samples_real\[4\]\[3\] _05534_ _05524_ _00503_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14550_ samples_real\[4\]\[4\] _05296_ _05510_ _05535_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14551_ _05295_ _05535_ _05521_ _05536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14552_ net74 _05536_ _05530_ _05537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14553_ samples_real\[4\]\[4\] _05537_ _05524_ _00504_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14554_ samples_real\[4\]\[5\] _05303_ _05510_ _05538_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14555_ _05302_ _05538_ _05521_ _05539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14556_ net75 _05539_ _05530_ _05540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14557_ samples_real\[4\]\[5\] _05540_ _05524_ _00505_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14558_ samples_real\[4\]\[6\] _05309_ _05510_ _05541_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14559_ _05308_ _05541_ _05521_ _05542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14560_ net76 _05542_ _05530_ _05543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14561_ samples_real\[4\]\[6\] _05543_ _05524_ _00506_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14562_ samples_real\[4\]\[7\] _05316_ _04079_ _05544_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14563_ _05315_ _05544_ _05521_ _05545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14564_ net77 _05545_ _05530_ _05546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14565_ samples_real\[4\]\[7\] _05546_ _05524_ _00507_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14566_ samples_real\[4\]\[8\] _05322_ _04079_ _05547_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14567_ _05321_ _05547_ _05521_ _05548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14568_ net78 _05548_ _05530_ _05549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14569_ samples_real\[4\]\[8\] _05549_ _05524_ _00508_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14570_ samples_real\[4\]\[9\] _05329_ _04079_ _05550_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14571_ _05328_ _05550_ _05521_ _05551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14572_ net79 _05551_ _05530_ _05552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14573_ samples_real\[4\]\[9\] _05552_ _05524_ _00509_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14574_ _04931_ _05178_ _05553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14575_ samples_real\[5\]\[0\] _05553_ _04158_ _05554_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14576_ _07703_ _04931_ _05210_ _05555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14577_ _05554_ _05555_ _03820_ _05556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14578_ _05065_ _05556_ _05557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14579_ samples_real\[5\]\[0\] _05214_ _04931_ _05558_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14580_ _05557_ _05558_ _00510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14581_ samples_real\[5\]\[10\] _05231_ _04959_ _05559_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14582_ _05229_ _05559_ _04974_ _05560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14583_ net65 _05560_ _05530_ _05561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14584_ samples_real\[5\]\[10\] _05561_ _04977_ _00511_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14585_ _04020_ _05562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14586_ samples_real\[5\]\[11\] _05239_ _05562_ _05563_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14587_ _05238_ _05563_ _04974_ _05564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14588_ net66 _05564_ _05530_ _05565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14589_ samples_real\[5\]\[11\] _05565_ _04977_ _00512_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14590_ samples_real\[5\]\[12\] _05249_ _05562_ _05566_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14591_ _05248_ _05566_ _04974_ _05567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14592_ _03594_ _05568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14593_ net67 _05567_ _05568_ _05569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14594_ samples_real\[5\]\[12\] _05569_ _04977_ _00513_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14595_ samples_real\[5\]\[13\] _05255_ _05562_ _05570_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14596_ _05254_ _05570_ _04974_ _05571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14597_ net68 _05571_ _05568_ _05572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14598_ samples_real\[5\]\[13\] _05572_ _04977_ _00514_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14599_ samples_real\[5\]\[14\] _05264_ _05562_ _05573_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14600_ _05263_ _05573_ _04974_ _05574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14601_ net69 _05574_ _05568_ _05575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14602_ samples_real\[5\]\[14\] _05575_ _04977_ _00515_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14603_ samples_real\[5\]\[15\] _05269_ _05562_ _05576_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14604_ _04939_ _05577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14605_ _05208_ _05576_ _05577_ _05578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14606_ net70 _05578_ _05568_ _05579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14607_ _04931_ _05580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14608_ samples_real\[5\]\[15\] _05579_ _05580_ _00516_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14609_ samples_real\[5\]\[1\] _05277_ _05562_ _05581_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14610_ _05276_ _05581_ _05577_ _05582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14611_ net71 _05582_ _05568_ _05583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14612_ samples_real\[5\]\[1\] _05583_ _05580_ _00517_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14613_ samples_real\[5\]\[2\] _05283_ _05562_ _05584_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14614_ _05282_ _05584_ _05577_ _05585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14615_ net72 _05585_ _05568_ _05586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14616_ samples_real\[5\]\[2\] _05586_ _05580_ _00518_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14617_ samples_real\[5\]\[3\] _05290_ _05562_ _05587_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14618_ _05289_ _05587_ _05577_ _05588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14619_ net73 _05588_ _05568_ _05589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14620_ samples_real\[5\]\[3\] _05589_ _05580_ _00519_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14621_ samples_real\[5\]\[4\] _05296_ _05562_ _05590_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14622_ _05295_ _05590_ _05577_ _05591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14623_ net74 _05591_ _05568_ _05592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14624_ samples_real\[5\]\[4\] _05592_ _05580_ _00520_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14625_ samples_real\[5\]\[5\] _05303_ _05562_ _05593_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14626_ _05302_ _05593_ _05577_ _05594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14627_ net75 _05594_ _05568_ _05595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14628_ samples_real\[5\]\[5\] _05595_ _05580_ _00521_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14629_ samples_real\[5\]\[6\] _05309_ _04020_ _05596_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14630_ _05308_ _05596_ _05577_ _05597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14631_ net76 _05597_ _05568_ _05598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14632_ samples_real\[5\]\[6\] _05598_ _05580_ _00522_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14633_ samples_real\[5\]\[7\] _05316_ _04020_ _05599_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14634_ _05315_ _05599_ _05577_ _05600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14635_ _03594_ _05601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14636_ net77 _05600_ _05601_ _05602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14637_ samples_real\[5\]\[7\] _05602_ _05580_ _00523_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14638_ samples_real\[5\]\[8\] _05322_ _04020_ _05603_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14639_ _05321_ _05603_ _05577_ _05604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14640_ net78 _05604_ _05601_ _05605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14641_ samples_real\[5\]\[8\] _05605_ _05580_ _00524_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14642_ samples_real\[5\]\[9\] _05329_ _04020_ _05606_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14643_ _05328_ _05606_ _05577_ _05607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14644_ net79 _05607_ _05601_ _05608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14645_ samples_real\[5\]\[9\] _05608_ _05580_ _00525_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14646_ _07703_ _04991_ _05210_ _05609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14647_ _04991_ _05178_ _05610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14648_ samples_real\[6\]\[0\] _05610_ _04041_ _05611_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14649_ _05609_ _05611_ _04996_ _05612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14650_ _05065_ _05612_ _05613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14651_ samples_real\[6\]\[0\] _05214_ _04991_ _05614_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14652_ _05613_ _05614_ _00526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14653_ samples_real\[6\]\[10\] _05231_ _05020_ _05615_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14654_ _05229_ _05615_ _05028_ _05616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14655_ net65 _05616_ _05601_ _05617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14656_ samples_real\[6\]\[10\] _05617_ _05037_ _00527_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14657_ _04040_ _05618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14658_ samples_real\[6\]\[11\] _05239_ _05618_ _05619_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14659_ _05238_ _05619_ _05028_ _05620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14660_ net66 _05620_ _05601_ _05621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14661_ samples_real\[6\]\[11\] _05621_ _05037_ _00528_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14662_ samples_real\[6\]\[12\] _05249_ _05618_ _05622_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14663_ _05248_ _05622_ _05028_ _05623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14664_ net67 _05623_ _05601_ _05624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14665_ samples_real\[6\]\[12\] _05624_ _05037_ _00529_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14666_ samples_real\[6\]\[13\] _05255_ _05618_ _05625_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14667_ _04995_ _05626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14668_ _05254_ _05625_ _05626_ _05627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14669_ net68 _05627_ _05601_ _05628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14670_ samples_real\[6\]\[13\] _05628_ _05037_ _00530_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14671_ samples_real\[6\]\[14\] _05264_ _05618_ _05629_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14672_ _05263_ _05629_ _05626_ _05630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14673_ net69 _05630_ _05601_ _05631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14674_ samples_real\[6\]\[14\] _05631_ _05037_ _00531_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14675_ samples_real\[6\]\[15\] _05269_ _05618_ _05632_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14676_ _05208_ _05632_ _05626_ _05633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14677_ net70 _05633_ _05601_ _05634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14678_ _04991_ _05635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_14679_ samples_real\[6\]\[15\] _05634_ _05635_ _00532_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14680_ samples_real\[6\]\[1\] _05277_ _05618_ _05636_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14681_ _05276_ _05636_ _05626_ _05637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14682_ net71 _05637_ _05601_ _05638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14683_ samples_real\[6\]\[1\] _05638_ _05635_ _00533_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14684_ samples_real\[6\]\[2\] _05283_ _05618_ _05639_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14685_ _05282_ _05639_ _05626_ _05640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14686_ net72 _05640_ _03595_ _05641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14687_ samples_real\[6\]\[2\] _05641_ _05635_ _00534_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14688_ samples_real\[6\]\[3\] _05290_ _05618_ _05642_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14689_ _05289_ _05642_ _05626_ _05643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14690_ net73 _05643_ _03595_ _05644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14691_ samples_real\[6\]\[3\] _05644_ _05635_ _00535_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14692_ samples_real\[6\]\[4\] _05296_ _05618_ _05645_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14693_ _05295_ _05645_ _05626_ _05646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14694_ net74 _05646_ _03595_ _05647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14695_ samples_real\[6\]\[4\] _05647_ _05635_ _00536_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14696_ samples_real\[6\]\[5\] _05303_ _05618_ _05648_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14697_ _05302_ _05648_ _05626_ _05649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14698_ net75 _05649_ _03595_ _05650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14699_ samples_real\[6\]\[5\] _05650_ _05635_ _00537_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14700_ samples_real\[6\]\[6\] _05309_ _04040_ _05651_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14701_ _05308_ _05651_ _05626_ _05652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14702_ net76 _05652_ _03595_ _05653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14703_ samples_real\[6\]\[6\] _05653_ _05635_ _00538_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14704_ samples_real\[6\]\[7\] _05316_ _04040_ _05654_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14705_ _05315_ _05654_ _05626_ _05655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14706_ net77 _05655_ _03595_ _05656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14707_ samples_real\[6\]\[7\] _05656_ _05635_ _00539_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14708_ samples_real\[6\]\[8\] _05322_ _04040_ _05657_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14709_ _05321_ _05657_ _04995_ _05658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14710_ net78 _05658_ _03595_ _05659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14711_ samples_real\[6\]\[8\] _05659_ _05635_ _00540_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14712_ samples_real\[6\]\[9\] _05329_ _04040_ _05660_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14713_ _05328_ _05660_ _04995_ _05661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14714_ net79 _05661_ _03595_ _05662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14715_ samples_real\[6\]\[9\] _05662_ _05635_ _00541_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14716_ samples_real\[7\]\[0\] _05051_ _05055_ _05178_ _05663_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14717_ _05059_ _05211_ _05663_ _03753_ _05664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14718_ _05065_ _05664_ _05665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14719_ _05214_ samples_real\[7\]\[0\] _05054_ _05666_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14720_ _05665_ _05666_ _00542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14721_ samples_real\[7\]\[10\] _05231_ _05093_ _05667_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14722_ _05229_ _05667_ _05095_ _05668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14723_ net65 _05668_ _05107_ _05669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14724_ _05669_ samples_real\[7\]\[10\] _05101_ _00543_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14725_ samples_real\[7\]\[11\] _05239_ _05093_ _05670_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14726_ _05238_ _05670_ _05095_ _05671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14727_ net66 _05671_ _05107_ _05672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14728_ _05672_ samples_real\[7\]\[11\] _05101_ _00544_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14729_ samples_real\[7\]\[12\] _05249_ _05093_ _05673_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14730_ _05248_ _05673_ _05095_ _05674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14731_ net67 _05674_ _05107_ _05675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14732_ _05675_ samples_real\[7\]\[12\] _05101_ _00545_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14733_ samples_real\[7\]\[13\] _05255_ _05093_ _05676_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14734_ _05254_ _05676_ _05095_ _05677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14735_ net68 _05677_ _05107_ _05678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14736_ _05678_ samples_real\[7\]\[13\] _05101_ _00546_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14737_ _04013_ _05679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14738_ samples_real\[7\]\[14\] _05264_ _05679_ _05680_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14739_ _05057_ _05681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14740_ _05263_ _05680_ _05681_ _05682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14741_ net69 _05682_ _05107_ _05683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14742_ _05683_ samples_real\[7\]\[14\] _05101_ _00547_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14743_ samples_real\[7\]\[15\] _05269_ _05679_ _05684_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14744_ _05208_ _05684_ _05681_ _05685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14745_ net70 _05685_ _05107_ _05686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14746_ _05054_ _05687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14747_ _05686_ samples_real\[7\]\[15\] _05687_ _00548_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14748_ samples_real\[7\]\[1\] _05277_ _05679_ _05688_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14749_ _05276_ _05688_ _05681_ _05689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14750_ net71 _05689_ _05107_ _05690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14751_ _05690_ samples_real\[7\]\[1\] _05687_ _00549_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14752_ samples_real\[7\]\[2\] _05283_ _05679_ _05691_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14753_ _05282_ _05691_ _05681_ _05692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14754_ net72 _05692_ _04578_ _05693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14755_ _05693_ samples_real\[7\]\[2\] _05687_ _00550_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14756_ samples_real\[7\]\[3\] _05290_ _05679_ _05694_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14757_ _05289_ _05694_ _05681_ _05695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14758_ net73 _05695_ _04578_ _05696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14759_ _05696_ samples_real\[7\]\[3\] _05687_ _00551_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14760_ samples_real\[7\]\[4\] _05296_ _05679_ _05697_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14761_ _05295_ _05697_ _05681_ _05698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14762_ net74 _05698_ _04578_ _05699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14763_ _05699_ samples_real\[7\]\[4\] _05687_ _00552_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14764_ samples_real\[7\]\[5\] _05303_ _05679_ _05700_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14765_ _05302_ _05700_ _05681_ _05701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14766_ net75 _05701_ _04578_ _05702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14767_ _05702_ samples_real\[7\]\[5\] _05687_ _00553_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14768_ samples_real\[7\]\[6\] _05309_ _05679_ _05703_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14769_ _05308_ _05703_ _05681_ _05704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14770_ net76 _05704_ _04578_ _05705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14771_ _05705_ samples_real\[7\]\[6\] _05687_ _00554_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14772_ samples_real\[7\]\[7\] _05316_ _05679_ _05706_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14773_ _05315_ _05706_ _05681_ _05707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14774_ net77 _05707_ _04578_ _05708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14775_ _05708_ samples_real\[7\]\[7\] _05687_ _00555_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14776_ samples_real\[7\]\[8\] _05322_ _05679_ _05709_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14777_ _05321_ _05709_ _05681_ _05710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14778_ net78 _05710_ _04578_ _05711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14779_ _05711_ samples_real\[7\]\[8\] _05687_ _00556_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14780_ samples_real\[7\]\[9\] _05329_ _04013_ _05712_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14781_ _05328_ _05712_ _05057_ _05713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14782_ net79 _05713_ _04578_ _05714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14783_ _05714_ samples_real\[7\]\[9\] _05687_ _00557_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14784_ _05065_ _07773_ _05715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14785_ _07789_ _03634_ _05716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14786_ _05716_ _04257_ _05717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14787_ stage\[0\] _05715_ _05717_ _00558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14788_ _05065_ _07776_ _05718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14789_ stage\[1\] _05718_ _05717_ _00559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14790_ _05065_ _07790_ _05719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14791_ _00567_ _05719_ _05717_ _00560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14792_ _08207_ _05720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14793_ _07073_ _05721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14794_ _05721_ _08297_ _08299_ _08301_ _05722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_14795_ _08308_ _06803_ _08307_ _05723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14796_ _05722_ _05723_ _05724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14797_ _08254_ _08290_ _08236_ _08266_ _05725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_14798_ _08296_ _05724_ _05725_ _08283_ _05726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_14799_ _08253_ _05727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14800_ _08289_ _08283_ _05728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14801_ _08282_ _05728_ _05729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14802_ _08266_ _05729_ _05730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14803_ _08265_ _05730_ _08254_ _05731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14804_ _05727_ _05731_ _05732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14805_ _08236_ _05732_ _08235_ _05733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14806_ _05726_ _05733_ _05734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14807_ _08222_ _05734_ _05735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14808_ _08221_ _05735_ _08208_ _05736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14809_ _05720_ _05736_ _05737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14810_ _08193_ _05737_ _08192_ _05738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14811_ _03845_ _03875_ _05739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14812_ _03789_ _03817_ _05739_ _05740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14813_ _00011_ _05740_ _05741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14814_ samples_imag\[2\]\[15\] samples_imag\[6\]\[15\] _03679_
+ _05742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14815_ _03717_ samples_imag\[4\]\[15\] _05743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14816_ samples_imag\[3\]\[15\] samples_imag\[7\]\[15\] _03678_
+ _05744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14817_ _03688_ samples_imag\[1\]\[15\] _05745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14818_ _05742_ _05743_ _05744_ _05745_ _03693_ _03676_ _05746_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_14819_ samples_imag\[5\]\[15\] _03820_ _05747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14820_ samples_imag\[0\]\[15\] _03712_ _05746_ _05747_ _00009_
+ _05748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_14821_ _06918_ _05748_ _05749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14822_ _06567_ _06745_ _05749_ _05750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14823_ _03724_ _03887_ _05751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14824_ _03700_ _04001_ _05751_ _05752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14825_ _03725_ _05752_ _05753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14826_ _05741_ _05750_ _05753_ _05754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14827_ _06609_ _06614_ _05755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14828_ _06598_ _06661_ _05755_ _05756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14829_ _08103_ _08106_ _05757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14830_ _08113_ _08131_ _05757_ _05758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14831_ _06519_ _06499_ _05759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14832_ _06508_ _06531_ _05759_ _05760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14833_ _06675_ _08138_ _05761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14834_ _06672_ _06603_ _05761_ _05762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14835_ _05760_ _05762_ _05763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14836_ _05756_ _05758_ _05763_ _05764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14837_ _00016_ _00017_ _05765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14838_ _06557_ _06589_ _05765_ _05766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14839_ _08167_ _06544_ _05766_ _05767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14840_ _03714_ _03979_ _05768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14841_ _00010_ _05768_ _05769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14842_ _05764_ _05767_ _05769_ _05770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14843_ _00012_ _03989_ _05771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14844_ _03925_ _05772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14845_ _00016_ _05772_ _05773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14846_ _06523_ _06513_ _05774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14847_ _06561_ _06526_ _05774_ _05775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14848_ _06553_ _06621_ _05776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14849_ _08129_ _06728_ _05776_ _05777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14850_ _08117_ _06776_ _05778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14851_ _08109_ _08128_ _05778_ _05779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14852_ _05775_ _05777_ _05779_ _05780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14853_ _03969_ _05781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14854_ _00017_ _05781_ _05782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14855_ _05780_ _05782_ _05783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14856_ _05771_ _05773_ _05783_ _05784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14857_ _05770_ _05784_ _05785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14858_ _05738_ _05754_ _05785_ _05786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14859_ temp_imag\[0\] _05786_ _03636_ _00561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14860_ _07972_ _05787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14861_ _08017_ _08030_ _08041_ _08066_ _05788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_14862_ _08086_ _08093_ _05789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14863_ _08085_ _05789_ _05790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14864_ _08094_ _08096_ _08100_ _08086_ _05791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_14865_ _08099_ _06341_ _05792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14866_ _08076_ _03981_ _05791_ _05792_ _05793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_14867_ _08076_ _05790_ _05793_ _08075_ _05794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_14868_ _08029_ _05795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14869_ _08065_ _08041_ _05796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14870_ _08040_ _05796_ _08030_ _05797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14871_ _05795_ _05797_ _05798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14872_ _08017_ _05798_ _08016_ _05799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14873_ _05788_ _05794_ _05799_ _05800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14874_ _07998_ _05800_ _05801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14875_ _07997_ _05801_ _05802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14876_ _07983_ _05802_ _05803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14877_ _07982_ _05803_ _07973_ _05804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14878_ _05787_ _05804_ _05805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14879_ _07964_ _05805_ _07963_ _05806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_14880_ _00016_ _05781_ _05807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14881_ _00011_ _03865_ _05808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14882_ _05889_ _05902_ _05809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14883_ _05929_ _05934_ _05809_ _05810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14884_ _05884_ _07893_ _05811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14885_ _07902_ _06005_ _05811_ _05812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14886_ _05810_ _05812_ _05813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14887_ _06008_ _06027_ _05814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14888_ _06059_ _06079_ _05814_ _05815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14889_ _06074_ _05937_ _05816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14890_ _05941_ _05962_ _05816_ _05817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14891_ _05815_ _05817_ _05818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14892_ _07957_ _07894_ _05819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14893_ _05898_ _05920_ _05819_ _05820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14894_ _07899_ _05977_ _05821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14895_ _05990_ _06023_ _05821_ _05822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14896_ _07912_ _07915_ _05823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_14897_ _07910_ _05985_ _05823_ _05824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14898_ _05820_ _05822_ _05824_ _05825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14899_ _05813_ _05818_ _05825_ _05826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14900_ _00012_ _04001_ _05827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14901_ _07909_ _05826_ _05827_ _05828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14902_ _05807_ _05808_ _05828_ _05829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14903_ _07908_ _05950_ _05830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14904_ _06094_ _06256_ _05830_ _05831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14905_ _03725_ _03989_ _05832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14906_ _00017_ _05772_ _05833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14907_ _05832_ _05833_ _05834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14908_ _05917_ _05969_ _05834_ _05835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14909_ _03827_ _05751_ _05836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14910_ _00010_ _05836_ _05837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14911_ samples_real\[3\]\[15\] samples_real\[7\]\[15\] _03680_
+ _05838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14912_ samples_real\[5\]\[15\] _03703_ _05838_ _03672_ _05839_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14913_ _03689_ samples_real\[4\]\[15\] _05840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14914_ _03689_ samples_real\[1\]\[15\] _05840_ _03684_ _05841_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14915_ samples_real\[2\]\[15\] samples_real\[6\]\[15\] _03680_
+ _05842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14916_ _03745_ _05842_ _05843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14917_ _03685_ _05839_ _05841_ _03673_ _05843_ _05844_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_14918_ samples_real\[0\]\[15\] _03712_ _05844_ _00009_ _05845_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_14919_ _06125_ _06182_ _05765_ _05846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14920_ _07938_ _05995_ _05846_ _05847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14921_ _05964_ _05845_ _05847_ _05848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14922_ _05892_ _05837_ _05848_ _05849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14923_ _05831_ _05835_ _05849_ _05850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14924_ _05806_ _05829_ _05850_ _05851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_14925_ temp_real\[0\] _05851_ _03636_ _00562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14926_ _00000_ _00002_ _00019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14927_ _05852_ _05853_ _05854_ _05855_ _05856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_14928_ _05852_ _05857_ _05858_ _05859_ _05860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_14929_ _05862_ _05863_ _05864_ _05865_ _05866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14930_ _05867_ _05868_ _05869_ _05870_ _05871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_14931_ _05867_ _05872_ _05873_ _05874_ _05875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_14932_ _05877_ _00014_ _05878_ _05879_ _05880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14933_ _05881_ _05882_ _05883_ _05884_ _05885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14934_ _05886_ _05887_ _05888_ _05889_ _05890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14935_ _05891_ _05892_ _05893_ _05887_ _05894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14936_ _05895_ _05896_ _05897_ _05898_ _05899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14937_ _05890_ _05900_ _05901_ _05902_ _05903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14938_ _05894_ _05904_ _05905_ _05900_ _05906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14939_ _05907_ _05908_ _05909_ _05910_ _05911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14940_ _05912_ _05913_ _05914_ _05915_ _05916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14941_ _05917_ _05918_ _05919_ _05920_ _05921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14942_ _05922_ _05923_ _05924_ _05925_ _05926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14943_ _05893_ _05927_ _05928_ _05929_ _05930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14944_ _05931_ _05932_ _05933_ _05934_ _05935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14945_ _05930_ _05936_ _05935_ _05937_ _05938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14946_ _05903_ _05939_ _05940_ _05941_ _05942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14947_ _05906_ _05943_ _05944_ _05939_ _05945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14948_ _05946_ _05947_ _05948_ _05943_ _05949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14949_ _05908_ _05950_ _05951_ _05952_ _05953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14950_ _05954_ _05955_ _05956_ _05957_ _05958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14951_ _05959_ _05960_ _05961_ _05962_ _05963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14952_ _05964_ _05965_ _05966_ _05967_ _05968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14953_ _05909_ _05951_ _05969_ _05970_ _05971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14954_ _05973_ _05974_ _05975_ _05976_ _05977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_14955_ _05971_ _05978_ _05977_ _05979_ _05980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14956_ _05982_ _05983_ _05984_ _05985_ _05986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14957_ _05987_ _05988_ _05989_ _05990_ _05991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14958_ _05992_ _05993_ _05994_ _05995_ _05996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_14959_ _05989_ _05997_ _05998_ _05999_ _06000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14960_ _06001_ _06002_ _06003_ _06004_ _06005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_14961_ _06006_ _05996_ _06007_ _06008_ _06009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_14962_ _05928_ _05972_ _05932_ _05981_ _06010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14963_ _05933_ _06011_ _06001_ _06012_ _06013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14964_ _06012_ _06000_ _06014_ _06007_ _06015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14965_ _05998_ _06016_ _06017_ _06018_ _06019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14966_ _06020_ _06021_ _06022_ _06023_ _06024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14967_ _05942_ _06025_ _06026_ _06027_ _06028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14968_ _05945_ _06029_ _06030_ _06025_ _06031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14969_ _05949_ _06032_ _06033_ _06029_ _06034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14970_ _06035_ _06036_ _06037_ _06032_ _06038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14971_ _06039_ _06040_ _05972_ _06036_ _06041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14972_ _06042_ _06043_ _06044_ _06045_ _06046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14973_ _06047_ _06048_ _05980_ _05984_ _06049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14974_ _05927_ _06050_ _06051_ _06052_ _06053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14975_ _06010_ _06054_ _06055_ _06056_ _06057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14976_ _06009_ _06058_ _06024_ _06059_ _06060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_14977_ _06056_ _06061_ _06062_ _06058_ _06063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14978_ _05972_ _05932_ _06065_ _06054_ _06066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14979_ _05975_ _05989_ _05997_ _06067_ _06068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14980_ _06069_ _06067_ _06070_ _06064_ _06071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14981_ _06072_ _06060_ _06073_ _06074_ _06075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14982_ _06028_ _06077_ _06078_ _06079_ _06080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14983_ _06031_ _06081_ _06082_ _06077_ _06083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14984_ _06034_ _06085_ _06045_ _06081_ _06086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14985_ _06038_ _06087_ _06088_ _06085_ _06089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14986_ _06041_ _06090_ _06091_ _06087_ _06092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14987_ _06093_ _06094_ _06095_ _06096_ _06097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14988_ _06098_ _06099_ _06100_ _06101_ _06102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14989_ _05928_ _06103_ _06104_ _06105_ _06106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14990_ _06066_ _06107_ _06068_ _06108_ _06109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14991_ _06063_ _06111_ _06112_ _06073_ _06113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14992_ _06108_ _06114_ _06115_ _06111_ _06116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14993_ _06095_ _05974_ _05987_ _06110_ _06117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14994_ _06118_ _06113_ _06119_ _06120_ _06121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14995_ _06080_ _06123_ _06124_ _06125_ _06126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14996_ _06083_ _06127_ _06128_ _06123_ _06129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14997_ _06086_ _06130_ _06131_ _06127_ _06132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14998_ _06089_ _06134_ _06135_ _06130_ _06136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_14999_ _06092_ _06138_ _06139_ _06134_ _06140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15000_ _06141_ _06142_ _06143_ _06138_ _06144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15001_ _06145_ _06094_ _05974_ _06146_ _06147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15002_ _06148_ _06149_ _06150_ _06151_ _06152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15003_ _05969_ _06153_ _06154_ _06155_ _06156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15004_ _06157_ _06158_ _06005_ _06159_ _06160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15005_ _06116_ _06162_ _06163_ _06119_ _06164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15006_ _06159_ _06165_ _06166_ _06162_ _06167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15007_ _05974_ _05987_ _05997_ _06161_ _06168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15008_ _06170_ _06171_ _06172_ _06173_ _06174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15009_ _06175_ _06176_ _06177_ _06178_ _06179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15010_ _06126_ _06180_ _06181_ _06182_ _06183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15011_ _06129_ _06184_ _06185_ _06180_ _06186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15012_ _06132_ _06187_ _06188_ _06184_ _06189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15013_ _06136_ _06190_ _06191_ _06187_ _06192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15014_ _06140_ _06194_ _06195_ _06190_ _06196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15015_ _06144_ _06198_ _06199_ _06194_ _06200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15016_ _06201_ _06202_ _06203_ _06198_ _06204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15017_ _06145_ _06205_ _05987_ _06206_ _06207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15018_ _06208_ _06209_ _06210_ _06211_ _06212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15019_ _05932_ _06213_ _06214_ _06215_ _06216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15020_ _06217_ _06218_ _06174_ _06219_ _06220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15021_ _06221_ _06222_ _06223_ _06177_ _06224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15022_ _06011_ _06169_ _06003_ _06218_ _06225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15023_ _06226_ _06224_ _06227_ _06228_ _06229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15024_ _06186_ _06230_ _06231_ _06232_ _06233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15025_ _06189_ _06234_ _06235_ _06230_ _06236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15026_ _06192_ _06237_ _06238_ _06234_ _06239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15027_ _06196_ _06240_ _06241_ _06237_ _06242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15028_ _06200_ _06244_ _06245_ _06240_ _06246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15029_ _06204_ _06248_ _06249_ _06244_ _06250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15030_ _06251_ _06252_ _06253_ _06248_ _06254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15031_ _06255_ _06256_ _06169_ _06252_ _06257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15032_ _06258_ _06259_ _06260_ _06261_ _06262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15033_ _06065_ _06263_ _06264_ _06265_ _06266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15034_ _06225_ _06267_ _06268_ _06269_ _06270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15035_ _06271_ _06272_ _06273_ _06227_ _06274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15036_ _06275_ _06276_ _06277_ _06278_ _06279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15037_ _06236_ _06281_ _06282_ _06283_ _06284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15038_ _06239_ _06285_ _06286_ _06281_ _06287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15039_ _06242_ _06288_ _06279_ _06285_ _06289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15040_ _06246_ _06290_ _06291_ _06288_ _06292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15041_ _06254_ _06295_ _06296_ _06297_ _06298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15042_ _06257_ _06300_ _06301_ _06295_ _06302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15043_ _06256_ _06303_ _06003_ _06300_ _06304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15044_ _06305_ _06306_ _06307_ _06308_ _06309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15045_ _06011_ _06310_ _06311_ _06312_ _06313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15046_ _06169_ _06003_ _06172_ _06267_ _06314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15047_ _06171_ _06314_ _06315_ _06316_ _06317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15048_ _06318_ _06319_ _06320_ _06321_ _06322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15049_ _06287_ _06323_ _06324_ _06325_ _06326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15050_ _06289_ _06327_ _06328_ _06323_ _06329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15051_ _06292_ _06330_ _06322_ _06327_ _06331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15052_ _06333_ _06334_ _06335_ _06332_ _06336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15053_ _06337_ _06304_ _06338_ _06339_ _06340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15054_ _06343_ _06344_ _06345_ _06346_ _06347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15055_ _05997_ _06348_ _06349_ _06350_ _06351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15056_ _06003_ _06172_ _06352_ _06315_ _06353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15057_ _06354_ _06355_ _06356_ _06357_ _06358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15058_ _06329_ _06359_ _06360_ _06361_ _06362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15059_ _06331_ _06363_ _06364_ _06359_ _06365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15060_ _06366_ _06367_ _06358_ _06363_ _06368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15061_ _06370_ _06371_ _06372_ _06369_ _06373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15062_ _06374_ _06375_ _06376_ _06377_ _06378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15063_ _06381_ _06382_ _06383_ _06384_ _06385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15064_ _06365_ _06386_ _06387_ _06388_ _06389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15065_ _06368_ _06390_ _06391_ _06386_ _06392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15066_ _06393_ _06394_ _06385_ _06390_ _06395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15067_ _06397_ _06398_ _06399_ _06400_ _06401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15068_ _06404_ _06405_ _06406_ _06407_ _06408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15069_ _06392_ _06409_ _06410_ _06411_ _06412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15070_ _06395_ _06413_ _06414_ _06409_ _06415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15071_ _06416_ _06417_ _06418_ _06413_ _06419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15072_ _06337_ _06422_ _06423_ _06424_ _06425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15073_ _06428_ _06429_ _06430_ _06431_ _06432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15074_ _06435_ _06436_ _06437_ _06438_ _06439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15075_ _06415_ _06440_ _06441_ _06442_ _06443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15076_ _06419_ _06444_ _06445_ _06440_ _06446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15077_ _06447_ _06448_ _06449_ _06444_ _06450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15078_ _06205_ _06451_ _06452_ _06453_ _06454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15079_ _06446_ _06455_ _06456_ _06457_ _06458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15080_ _06450_ _06459_ _06453_ _06455_ _06460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15081_ _06462_ _06463_ _06464_ _06461_ _06465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15082_ _06299_ _06467_ _06468_ _06469_ _06470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15083_ _06471_ _06472_ _06473_ _06474_ _06475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15084_ _06460_ _06478_ _06479_ _06480_ _06481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15085_ _06482_ _06483_ _06484_ _06478_ _06485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15086_ _06485_ _06487_ _06488_ _06489_ _06490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15087_ _06491_ _06492_ _06493_ _06494_ _06495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15088_ _06496_ _06497_ _06498_ _06499_ _06500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15089_ _06501_ _06497_ _06502_ _06503_ _06504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15090_ _06505_ _06506_ _06507_ _06508_ _06509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15091_ _06510_ _06511_ _06512_ _06513_ _06514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15092_ _06515_ _06516_ _06517_ _06518_ _06519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_15093_ _06520_ _06521_ _06522_ _06523_ _06524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15094_ _06516_ _06517_ _06525_ _06526_ _06527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15095_ _06528_ _06529_ _06530_ _06531_ _06532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15096_ _06533_ _06534_ _06535_ _06512_ _06536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15097_ _06537_ _06538_ _06539_ _06540_ _06541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15098_ _06542_ _06543_ _06527_ _06544_ _06545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15099_ _06546_ _06547_ _06521_ _06548_ _06549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15100_ _06550_ _06551_ _06552_ _06553_ _06554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15101_ _06518_ _06555_ _06556_ _06557_ _06558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15102_ _06559_ _06560_ _06554_ _06561_ _06562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15103_ _06563_ _06564_ _06541_ _06565_ _06566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15104_ _06567_ _06568_ _06569_ _06570_ _06571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15105_ _06572_ _06573_ _06519_ _06574_ _06575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15106_ _06577_ _06578_ _06547_ _06576_ _06579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15107_ _06521_ _06522_ _06580_ _06581_ _06582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15108_ _06583_ _06575_ _06584_ _06585_ _06586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15109_ _06558_ _06587_ _06588_ _06589_ _06590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15110_ _06591_ _06592_ _06593_ _06587_ _06594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_15111_ _06595_ _06596_ _06597_ _06598_ _06599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15112_ _06600_ _06601_ _06602_ _06603_ _06604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15113_ _06606_ _06607_ _06608_ _06609_ _06610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15114_ _06611_ _06612_ _06613_ _06614_ _06615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15115_ _06601_ _06618_ _06602_ _06617_ _06619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15116_ _06562_ _06620_ _06599_ _06621_ _06622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15117_ _06623_ _06624_ _06625_ _06620_ _06626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15118_ _06627_ _06628_ _06629_ _06624_ _06630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15119_ _06631_ _06632_ _06535_ _06633_ _06634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15120_ _06635_ _06636_ _06582_ _06584_ _06637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15121_ _06533_ _06534_ _06578_ _06638_ _06639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15122_ _06547_ _06521_ _06522_ _06640_ _06641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15123_ _06642_ _06637_ _06643_ _06644_ _06645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15124_ _06594_ _06646_ _06647_ _06648_ _06649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15125_ _06650_ _06651_ _06652_ _06646_ _06653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_15126_ _06654_ _06655_ _06656_ _06657_ _06658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15127_ _06610_ _06659_ _06660_ _06661_ _06662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15128_ _06663_ _06619_ _06664_ _06665_ _06666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15129_ _06667_ _06668_ _06605_ _06669_ _06670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15130_ _06657_ _06662_ _06671_ _06672_ _06673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15131_ _06622_ _06674_ _06673_ _06675_ _06676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15132_ _06626_ _06677_ _06658_ _06674_ _06678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15133_ _06679_ _06680_ _06645_ _06681_ _06682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15134_ _06501_ _06683_ _06502_ _06684_ _06685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15135_ _06686_ _06687_ _06641_ _06643_ _06688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15136_ _06568_ _06534_ _06569_ _06689_ _06690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15137_ _06507_ _06691_ _06692_ _06693_ _06694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15138_ _06695_ _06688_ _06696_ _06697_ _06698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15139_ _06699_ _06653_ _06700_ _06701_ _06702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15140_ _06693_ _06703_ _06704_ _06700_ _06705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_15141_ _06706_ _06707_ _06708_ _06709_ _06710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_15142_ _06711_ _06712_ _06713_ _06671_ _06714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15143_ _06601_ _06715_ _06716_ _06717_ _06718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15144_ _06667_ _06668_ _06719_ _06720_ _06721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15145_ _06709_ _06714_ _06722_ _06723_ _06724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15146_ _06725_ _06726_ _06727_ _06728_ _06729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_15147_ _06678_ _06731_ _06724_ _06730_ _06732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15148_ _06733_ _06734_ _06710_ _06731_ _06735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15149_ _06736_ _06737_ _06698_ _06738_ _06739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15150_ _06740_ _06741_ _06694_ _06696_ _06742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15151_ _06632_ _06569_ _06535_ _06743_ _06744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15152_ _06745_ _06507_ _06691_ _06746_ _06747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15153_ _06748_ _06705_ _06749_ _06750_ _06751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15154_ _06746_ _06752_ _06753_ _06749_ _06754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15155_ _06755_ _06751_ _06756_ _06757_ _06758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15156_ _06759_ _06760_ _06761_ _06722_ _06762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15157_ _06602_ _06763_ _06764_ _06765_ _06766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15158_ _06767_ _06667_ _06719_ _06768_ _06769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15159_ _06770_ _06762_ _06771_ _06772_ _06773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15160_ _06729_ _06774_ _06775_ _06776_ _06777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_15161_ _06778_ _06779_ _06780_ _06774_ _06781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15162_ _06735_ _06783_ _06773_ _06782_ _06784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15163_ _06785_ _06786_ _06787_ _06783_ _06788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15164_ _06789_ _06790_ _06791_ _06792_ _06793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15165_ _06794_ _06795_ _06747_ _06796_ _06797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15166_ _06799_ _06567_ _06535_ _06798_ _06800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15167_ _06534_ _06569_ _06578_ _06801_ _06802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15168_ _06803_ _06754_ _06804_ _06756_ _06805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15169_ _06806_ _06807_ _06808_ _06804_ _06809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15170_ _06810_ _06811_ _06812_ _06813_ _06814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15171_ _06815_ _06816_ _06817_ _06771_ _06818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15172_ _06618_ _06819_ _06820_ _06821_ _06822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15173_ _06823_ _06767_ _06719_ _06824_ _06825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15174_ _06826_ _06827_ _06828_ _06829_ _06830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15175_ _06781_ _06831_ _06832_ _06833_ _06834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15176_ _06835_ _06836_ _06837_ _06831_ _06838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15177_ _06788_ _06840_ _06841_ _06839_ _06842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15178_ _06843_ _06844_ _06814_ _06840_ _06845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_15179_ _06846_ _06847_ _06848_ _06844_ _06849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15180_ _06850_ _06851_ _06852_ _06853_ _06854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15181_ _06856_ _06567_ _06631_ _06855_ _06857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15182_ _06534_ _06569_ _06535_ _06858_ _06859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15183_ _06860_ _06861_ _06862_ _06863_ _06864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15184_ _06865_ _06866_ _06867_ _06868_ _06869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15185_ _06667_ _06825_ _06870_ _06871_ _06872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15186_ _06823_ _06873_ _06767_ _06870_ _06874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15187_ _06875_ _06876_ _06877_ _06878_ _06879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15188_ _06838_ _06880_ _06881_ _06882_ _06883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15189_ _06884_ _06885_ _06886_ _06880_ _06887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15190_ _06845_ _06889_ _06890_ _06888_ _06891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15191_ _06892_ _06893_ _06894_ _06895_ _06896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15192_ _06857_ _06897_ _06859_ _06898_ _06899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15193_ _06567_ _06569_ _06535_ _06901_ _06902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15194_ _06903_ _06904_ _06905_ _06906_ _06907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15195_ _06908_ _06909_ _06910_ _06911_ _06912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15196_ _06913_ _06914_ _06915_ _06916_ _06917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15197_ _06918_ _06823_ _06873_ _06919_ _06920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15198_ _06921_ _06922_ _06923_ _06924_ _06925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15199_ _06887_ _06926_ _06927_ _06928_ _06929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15200_ _06930_ _06931_ _06932_ _06926_ _06933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15201_ _06935_ _06936_ _06937_ _06934_ _06938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15202_ _06939_ _06940_ _06941_ _06942_ _06943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15203_ _06567_ _06631_ _06535_ _06944_ _06945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15204_ _06946_ _06947_ _06948_ _06949_ _06950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15205_ _06951_ _06952_ _06953_ _06954_ _06955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15206_ _06956_ _06957_ _06958_ _06959_ _06960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15207_ _06699_ _06748_ _06961_ _06958_ _06962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15208_ _06963_ _06964_ _06965_ _06966_ _06967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15209_ _06933_ _06968_ _06969_ _06970_ _06971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15210_ _06972_ _06973_ _06974_ _06968_ _06975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15211_ _06977_ _06978_ _06979_ _06976_ _06980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15212_ _06981_ _06982_ _06983_ _06984_ _06985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15213_ _06986_ _06987_ _06988_ _06989_ _06990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15214_ _06823_ _06991_ _06992_ _06993_ _06994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15215_ _06699_ _06748_ _06803_ _06995_ _06996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15216_ _06997_ _06998_ _06999_ _07000_ _07001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15217_ _06975_ _07002_ _07003_ _07004_ _07005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15218_ _07006_ _07007_ _07008_ _07002_ _07009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15219_ _06985_ _07010_ _07011_ _07007_ _07012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15220_ _07013_ _07014_ _07015_ _07010_ _07016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15221_ _06683_ _06496_ _06502_ _06986_ _07017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15222_ _06897_ _07018_ _07019_ _07020_ _07021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15223_ _07009_ _07022_ _07023_ _07024_ _07025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15224_ _07012_ _07026_ _07027_ _07022_ _07028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15225_ _07016_ _07029_ _07030_ _07026_ _07031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15226_ _07032_ _07033_ _07034_ _07029_ _07035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15227_ _06961_ _07036_ _06996_ _07037_ _07038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15228_ _07039_ _07040_ _07041_ _07042_ _07043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15229_ _07028_ _07044_ _07045_ _07046_ _07047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15230_ _07031_ _07048_ _07049_ _07044_ _07050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15231_ _07035_ _07051_ _07052_ _07048_ _07053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15232_ _07054_ _07055_ _07056_ _07051_ _07057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15233_ _07058_ _07053_ _07059_ _07060_ _07061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15234_ _07057_ _07062_ _07063_ _07059_ _07064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15235_ _07066_ _07067_ _07068_ _07065_ _07069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15236_ _07069_ _07070_ _07071_ _07072_ _07073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_15237_ _07076_ net369 _07077_ _07078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15238_ _05862_ _07079_ _07080_ _07081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15239_ _07082_ _07083_ _07084_ _07085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15240_ _05862_ _07086_ _07087_ _07088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15241_ _07076_ net342 _07089_ _07090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15242_ _07092_ _07091_ _07093_ _07094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15243_ _07095_ _07082_ _07096_ _07097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15244_ _05862_ _07098_ _07099_ _07100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15245_ _07076_ net343 _07101_ _07102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15246_ _07104_ _07103_ _07105_ _07106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15247_ _07091_ _07107_ _07108_ _07109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15248_ _07082_ _07110_ _07111_ _07112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15249_ _05862_ _07113_ _07114_ _07115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15250_ _07076_ net344 _07116_ _07117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15251_ _05862_ _07118_ _07119_ _07120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15252_ _07076_ net345 _07121_ _07122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15253_ _07123_ _07124_ _07125_ _07126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15254_ _07127_ _07103_ _07128_ _07129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15255_ _07091_ _07130_ _07131_ _07132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15256_ _07082_ _07133_ _07134_ _07135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15257_ _07136_ _07137_ _07138_ _07139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15258_ _07123_ _07140_ _07141_ _07142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15259_ _07143_ _07103_ _07144_ _07145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15260_ _07091_ _07146_ _07147_ _07148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15261_ _07082_ _07149_ _07150_ _07151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15262_ _05862_ _07152_ _07153_ _07154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15263_ _07076_ net346 _07155_ _07156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15264_ _07157_ _07136_ _07158_ _07159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15265_ _07160_ _07123_ _07161_ _07162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15266_ _07103_ _07163_ _07164_ _07165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15267_ _07091_ _07166_ _07167_ _07168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15268_ _07082_ _07169_ _07170_ _07171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15269_ _05862_ _07172_ _07173_ _07174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15270_ _07076_ net347 _07175_ _07176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15271_ _07177_ _07178_ _07179_ _07180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15272_ _07136_ _07181_ _07182_ _07183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15273_ _07123_ _07184_ _07185_ _07186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15274_ net19 _07187_ _07188_ _07189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15275_ _07091_ _07190_ _07191_ _07192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15276_ _07082_ _07193_ _07194_ _07195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15277_ _05862_ _07196_ _07197_ _07198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15278_ _07076_ net348 _07199_ _07200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15279_ _07136_ _07201_ _07202_ _07203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15280_ _07123_ _07204_ _07205_ _07206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15281_ _07207_ net19 _07208_ _07209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15282_ _07091_ _07210_ _07211_ _07212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15283_ _07082_ _07213_ _07214_ _07215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15284_ _05862_ _07216_ _07217_ _07218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15285_ net8 net349 _07219_ _07220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15286_ _07136_ _07221_ _07222_ _07223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15287_ _07123_ _07224_ _07225_ _07226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15288_ net19 _07227_ _07228_ _07229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15289_ _07230_ _07082_ _07231_ _07232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15290_ _07233_ _05862_ _07234_ _07235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15291_ net8 net350 _07236_ _07237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15292_ _07091_ _07238_ _07239_ _07240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15293_ _07136_ _07241_ _07242_ _07243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15294_ _07123_ _07244_ _07245_ _07246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15295_ net19 _07247_ _07248_ _07249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15296_ _07091_ _07250_ _07251_ _07252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15297_ _07082_ _07253_ _07254_ _07255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15298_ _05862_ _07256_ _07257_ _07258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15299_ net8 net351 _07259_ _07260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15300_ _07082_ _07261_ _07262_ _07263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15301_ _05862_ _07264_ _07265_ _07266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15302_ net19 _07267_ _07268_ _07269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15303_ _07091_ _07270_ _07271_ _07272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15304_ net8 net352 _07273_ _07274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15305_ _07136_ _07275_ _07276_ _07277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15306_ _07123_ _07278_ _07279_ _07280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15307_ _07136_ _07281_ _07282_ _07283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15308_ _07123_ _07284_ _07285_ _07286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15309_ net19 _07287_ _07288_ _07289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15310_ _07091_ _07290_ _07291_ _07292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15311_ _07082_ _07293_ _07294_ _07295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15312_ _05862_ _07296_ _07297_ _07298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15313_ net8 net353 _07299_ _07300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15314_ _07136_ _07301_ _07302_ _07303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15315_ _07123_ _07304_ _07305_ _07306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15316_ net19 _07307_ _07308_ _07309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15317_ _07091_ _07310_ _07311_ _07312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15318_ _07082_ _07313_ _07314_ _07315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15319_ _05862_ _07316_ _07317_ _07318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15320_ net8 net354 _07319_ _07320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15321_ _07136_ _07321_ _07322_ _07323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15322_ _07123_ _07324_ _07325_ _07326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15323_ net19 _07327_ _07328_ _07329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15324_ _07091_ _07330_ _07331_ _07332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15325_ _07082_ _07333_ _07334_ _07335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15326_ _05862_ _07336_ _07337_ _07338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15327_ net8 net355 _07339_ _07340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15328_ net8 net356 _07341_ _07342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15329_ _07136_ _07343_ _07344_ _07345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15330_ _07123_ _07346_ _07347_ _07348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15331_ net2 _07349_ _07350_ _07351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15332_ _07091_ _07352_ _07353_ _07354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15333_ _07082_ _07355_ _07356_ _07357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15334_ _05862_ _07358_ _07359_ _07360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15335_ _05862_ _07361_ _07362_ _07363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15336_ net1 net357 _07364_ _07365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15337_ _07136_ _07366_ _07367_ _07368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15338_ _07123_ _07369_ _07370_ _07371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15339_ net2 _07372_ _07373_ _07374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15340_ _07091_ _07375_ _07376_ _07377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15341_ _07082_ _07378_ _07379_ _07380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15342_ _07082_ _07381_ _07382_ _07383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15343_ _05862_ _07384_ _07385_ _07386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15344_ net1 net358 _07387_ _07388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15345_ _07136_ _07389_ _07390_ _07391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15346_ _07123_ _07392_ _07393_ _07394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15347_ net2 _07395_ _07396_ _07397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15348_ _07091_ _07398_ _07399_ _07400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15349_ _07091_ _07401_ _07402_ _07403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15350_ _07082_ _07404_ _07405_ _07406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15351_ _05862_ _07407_ _07408_ _07409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15352_ net1 net359 _07410_ _07411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15353_ _07136_ _07412_ _07413_ _07414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15354_ _07123_ _07415_ _07416_ _07417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15355_ net2 _07418_ _07419_ _07420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15356_ net2 _07421_ _07422_ _07423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15357_ _07091_ _07424_ _07425_ _07426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15358_ _07082_ _07427_ _07428_ _07429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15359_ _05862_ _07430_ _07431_ _07432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15360_ net1 net360 _07433_ _07434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15361_ _07136_ _07435_ _07436_ _07437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15362_ _07123_ _07438_ _07439_ _07440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15363_ _07123_ _07441_ _07442_ _07443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15364_ net2 _07444_ _07445_ _07446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15365_ _07091_ _07447_ _07448_ _07449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15366_ _07082_ _07450_ _07451_ _07452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15367_ _05862_ _07453_ _07454_ _07455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15368_ net1 net361 _07456_ _07457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15369_ _07136_ _07458_ _07459_ _07460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15370_ _07136_ _07461_ _07462_ _07463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15371_ _07123_ _07464_ _07465_ _07466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15372_ net2 _07467_ _07468_ _07469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15373_ _07091_ _07470_ _07471_ _07472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15374_ _07082_ _07473_ _07474_ _07475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15375_ _05862_ _07476_ _07477_ _07478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15376_ net1 net362 _07479_ _07480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15377_ _07136_ _07481_ _07482_ _07483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15378_ _07123_ _07484_ _07485_ _07486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15379_ net2 _07487_ _07488_ _07489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15380_ _07091_ _07490_ _07491_ _07492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15381_ _07082_ _07493_ _07494_ _07495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15382_ _05862_ _07496_ _07497_ _07498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15383_ net1 net363 _07499_ _07500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15384_ net1 net364 _07501_ _07502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15385_ _07136_ _07503_ _07504_ _07505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15386_ _07123_ _07506_ _07507_ _07508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15387_ net2 _07509_ _07510_ _07511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15388_ _07091_ _07512_ _07513_ _07514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15389_ _07082_ _07515_ _07516_ _07517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15390_ _05862_ _07518_ _07519_ _07520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15391_ _05862_ _07521_ _07522_ _07523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15392_ net1 net365 _07524_ _07525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15393_ _07177_ _07526_ _07527_ _07528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15394_ _07136_ _07529_ _07530_ _07531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15395_ _07123_ _07532_ _07533_ _07534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15396_ net2 _07535_ _07536_ _07537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15397_ _07091_ _07538_ _07539_ _07540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15398_ _07082_ _07541_ _07542_ _07543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15399_ net1 net366 _07544_ _07545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15400_ _07082_ _07546_ _07547_ _07548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15401_ _05862_ _07549_ _07550_ _07551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15402_ _07177_ _07552_ _07553_ _07554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15403_ _07136_ _07555_ _07556_ _07557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15404_ _07123_ _07558_ _07559_ _07560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15405_ net2 _07561_ _07562_ _07563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15406_ _07091_ _07564_ _07565_ _07566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15407_ _07091_ _07567_ _07568_ _07569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15408_ _07082_ _07570_ _07571_ _07572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15409_ _05862_ _07573_ _07574_ _07575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15410_ net1 net367 _07576_ _07577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15411_ _07177_ _07578_ _07579_ _07580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15412_ _07136_ _07581_ _07582_ _07583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15413_ _07123_ _07584_ _07585_ _07586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15414_ net2 _07587_ _07588_ _07589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15415_ net1 net368 _07590_ _07591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15416_ _07082_ _07592_ _07593_ _07594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15417_ _05862_ _07595_ _07596_ _07597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15418_ net2 _07598_ _07599_ _07600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15419_ _07091_ _07601_ _07602_ _07603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15420_ _07136_ _07604_ _07605_ _07606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15421_ _07123_ _07607_ _07608_ _07609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15422_ _07177_ _07610_ _07611_ _07612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15423_ _05862_ _07613_ _07614_ _07615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15424_ butterfly_count\[2\] net1 _07616_ _07617_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15425_ _07123_ _07618_ _07619_ _07620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15426_ net2 _07621_ _07622_ _07623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15427_ _07091_ _07624_ _07625_ _07626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15428_ _07082_ _07627_ _07628_ _07629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15429_ _07177_ _07630_ _07631_ _07632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15430_ _07136_ _07633_ _07634_ _07635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15431_ _07636_ _07637_ _07638_ _07639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15432_ butterfly_count\[1\] net1 _07640_ _07641_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15433_ _07082_ _07642_ _07643_ _07644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15434_ _05862_ _07645_ _07646_ _07647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15435_ _07136_ _07648_ _07649_ _07650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15436_ _07123_ _07651_ _07652_ _07653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15437_ net2 _07654_ _07655_ _07656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15438_ _07091_ _07657_ _07658_ _07659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15439_ _07660_ _07661_ _07662_ _07663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15440_ _07664_ _07665_ _07666_ _07667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15441_ _07669_ _07668_ _07670_ _07671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15442_ _07672_ _07673_ _07674_ _07675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15443_ _07676_ _07677_ _07678_ _07679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15444_ _07680_ _07681_ _07682_ _07683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15445_ _05862_ _05863_ _07684_ _07685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15446_ _07686_ _07637_ _07687_ _07688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15447_ butterfly_count\[0\] net1 _07689_ _07690_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15448_ _05852_ _07691_ _07692_ _07693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15449_ temp_real\[0\] _07691_ _07694_ _07695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15450_ _05852_ _07696_ _07697_ _07698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15451_ temp_real\[0\] _07696_ _07699_ _07700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15452_ temp_real\[0\] _07702_ _07701_ _07703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15453_ temp_real\[0\] _07704_ _05861_ _07705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15454_ _07706_ _07707_ _07708_ _07709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15455_ _05852_ _07710_ _07711_ _07712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15456_ temp_real\[0\] _07710_ _07713_ _07714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15457_ _05852_ _07715_ _07716_ _07717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15458_ temp_real\[0\] _07715_ _07718_ _07719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15459_ _05852_ _07720_ _07721_ _07722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15460_ temp_real\[0\] _07720_ _07723_ _07724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15461_ _05852_ _07725_ _07726_ _07727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15462_ temp_real\[0\] _07725_ _07728_ _07729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15463_ _05852_ _07730_ _07731_ _07732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15464_ temp_real\[0\] _07730_ _07733_ _07734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15465_ _05852_ _07735_ _07736_ _07737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15466_ temp_real\[0\] _07735_ _07738_ _07739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15467_ _05852_ _07740_ _07741_ _07742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15468_ temp_real\[0\] _07740_ _07743_ _07744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15469_ _05852_ _07745_ _07746_ _07747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15470_ temp_real\[0\] _07745_ _07748_ _07749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15471_ _05852_ _07750_ _07751_ _07752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15472_ temp_real\[0\] _07750_ _07753_ _07754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15473_ _05852_ _07755_ _07756_ _07757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15474_ temp_real\[0\] _07755_ _07758_ _07759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15475_ _05852_ _07760_ _07761_ _07762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15476_ temp_real\[0\] _07760_ _07763_ _07764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15477_ _05852_ _05857_ _07765_ _07766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15478_ temp_real\[0\] _05857_ _07767_ _07768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15479_ _07686_ _07636_ _07769_ _07770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15480_ butterfly_count\[0\] butterfly_count\[1\] _07771_
+ _07772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15481_ _07773_ _07774_ _07775_ _07776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15482_ _07773_ _07774_ _07777_ _07778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15483_ _07773_ stage\[1\] _07779_ _07780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15484_ stage\[0\] _07774_ _07781_ _07782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15485_ stage\[0\] _07774_ _07783_ _07784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15486_ stage\[0\] stage\[1\] _07785_ _07786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15487_ _07787_ _07788_ _07789_ _07790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15488_ _07787_ _07785_ _07791_ _07792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15489_ _07787_ _07785_ _07676_ _07793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15490_ stage\[2\] _07785_ _07794_ _07795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15491_ stage\[2\] _07785_ _07660_ _07796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15492_ _07797_ _07798_ _07799_ _07800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15493_ sample_count\[0\] sample_count\[1\] _07801_ _07802_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15494_ sample_count\[2\] _07801_ _07803_ _07804_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15495_ _05867_ _07805_ _07806_ _07807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15496_ temp_imag\[0\] _07805_ _07808_ _07809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15497_ _05867_ _07810_ _07811_ _07812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15498_ temp_imag\[0\] _07810_ _07813_ _07814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15499_ temp_imag\[0\] _07816_ _07815_ _07817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_15500_ temp_imag\[0\] _07818_ _05876_ _07819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15501_ _07820_ _07821_ _07822_ _07823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15502_ _05867_ _07824_ _07825_ _07826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15503_ temp_imag\[0\] _07824_ _07827_ _07828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15504_ _05867_ _07829_ _07830_ _07831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15505_ temp_imag\[0\] _07829_ _07832_ _07833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15506_ _05867_ _07834_ _07835_ _07836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15507_ temp_imag\[0\] _07834_ _07837_ _07838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15508_ _05867_ _07839_ _07840_ _07841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15509_ temp_imag\[0\] _07839_ _07842_ _07843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15510_ _05867_ _07844_ _07845_ _07846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15511_ temp_imag\[0\] _07844_ _07847_ _07848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15512_ _05867_ _07849_ _07850_ _07851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15513_ temp_imag\[0\] _07849_ _07852_ _07853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15514_ _05867_ _07854_ _07855_ _07856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15515_ temp_imag\[0\] _07854_ _07857_ _07858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15516_ _05867_ _07859_ _07860_ _07861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15517_ temp_imag\[0\] _07859_ _07862_ _07863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15518_ _05867_ _07864_ _07865_ _07866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15519_ temp_imag\[0\] _07864_ _07867_ _07868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15520_ _05867_ _07869_ _07870_ _07871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15521_ temp_imag\[0\] _07869_ _07872_ _07873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15522_ _05867_ _07874_ _07875_ _07876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15523_ temp_imag\[0\] _07874_ _07877_ _07878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15524_ _05867_ _05872_ _07879_ _07880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15525_ temp_imag\[0\] _05872_ _07881_ _07882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15526_ butterfly_in_group\[0\] _07883_ _07884_ _00013_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15527_ butterfly_in_group\[1\] _07885_ _07886_ _07887_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15528_ _07887_ _07888_ _07889_ _07890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15529_ _07890_ _07884_ _07891_ _00014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15530_ _07637_ _00013_ _05878_ _00015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15531_ _05882_ _05883_ _07892_ _07893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15532_ _06093_ _06145_ _07894_ _07895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15533_ _06094_ _06205_ _07896_ _05913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15534_ _05915_ _07898_ _07899_ _07900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15535_ _05921_ _07901_ _07902_ _07903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15536_ _06145_ _06471_ _05914_ _05955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15537_ _05957_ _06341_ _05982_ _07905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15538_ _07906_ _05967_ _07907_ _06047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15539_ _07908_ _07909_ _07910_ _07911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15540_ _06171_ _06172_ _07912_ _07913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15541_ _07914_ _07913_ _07915_ _07916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15542_ _07908_ _05882_ _06022_ _07917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15543_ _06205_ _07898_ _05956_ _07919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15544_ _05968_ _07920_ _06048_ _06098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15545_ _06049_ _06101_ _06076_ _06084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15546_ _07921_ _06352_ _07918_ _07922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15547_ _07922_ _07923_ _07924_ _06112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15548_ _07925_ _06255_ _07926_ _07927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15549_ _06145_ _06205_ _07928_ _07929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15550_ _06471_ _06341_ _07930_ _07931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15551_ _07928_ _07931_ _06137_ _07932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15552_ _07933_ _07934_ _06099_ _06148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15553_ _06102_ _06151_ _06122_ _06133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15554_ _07913_ _06004_ _06115_ _06165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15555_ _07935_ _07936_ _07937_ _06163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15556_ _06120_ _07924_ _07938_ _06124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15557_ _06205_ _06471_ _07939_ _07940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15558_ _07898_ _07939_ _06197_ _07941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15559_ _07942_ _06155_ _06149_ _06208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15560_ _06152_ _06211_ _06175_ _06193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15561_ _06352_ _06173_ _06166_ _07943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15562_ _05883_ _05907_ _07944_ _07945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15563_ _07946_ _07947_ _07948_ _07949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15564_ _07951_ _07937_ _06181_ _06185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15565_ _06341_ _07952_ _06247_ _07953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15566_ _06156_ _07954_ _06209_ _06258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15567_ _06212_ _06261_ _06226_ _06243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15568_ _06219_ _07943_ _07950_ _07955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15569_ _06002_ _06352_ _07956_ _06268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15570_ _05907_ _05908_ _07957_ _07958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15571_ _05895_ _05888_ _07959_ _07960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15572_ _07962_ _07948_ _06231_ _06235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15573_ _06183_ _06232_ _07963_ _07964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15574_ _07965_ _07966_ _06259_ _06305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15575_ _06262_ _06308_ _06280_ _06294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15576_ _05908_ _05950_ _07967_ _07968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15577_ _07897_ _05905_ _07969_ _07970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15578_ _06269_ _07956_ _07961_ _07971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15579_ _06278_ _07959_ _06282_ _06286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15580_ _06233_ _06283_ _07972_ _07973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15581_ _07974_ _07975_ _06293_ _06333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15582_ _07976_ _07977_ _06306_ _06343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15583_ _06309_ _06346_ _07978_ _06335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15584_ _07970_ _07971_ _06277_ _06319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15585_ _05950_ _06093_ _05912_ _07979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15586_ _07904_ _05948_ _07980_ _07981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15587_ _06321_ _07969_ _06324_ _06328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15588_ _06284_ _06325_ _07982_ _07983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15589_ _07984_ _07985_ _06334_ _06370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15590_ _07986_ _07987_ _07985_ _07988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15591_ _07898_ _06404_ _06342_ _06426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15592_ _07989_ _06350_ _06344_ _06379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15593_ _06353_ _07990_ _07991_ _06376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15594_ _06347_ _07992_ _07993_ _06372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15595_ _07981_ _06316_ _06320_ _06355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15596_ _06093_ _06094_ _05954_ _07994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15597_ _06042_ _06037_ _07995_ _07996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15598_ _06357_ _07980_ _06360_ _06364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15599_ _06326_ _06361_ _07997_ _07998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15600_ _07988_ _07999_ _06371_ _08000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15601_ _06351_ _08001_ _06380_ _06402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15602_ _06016_ _08002_ _08001_ _08003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15603_ _06172_ _06352_ _07990_ _08004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15604_ _08004_ _08005_ _08006_ _06399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15605_ _08007_ _08008_ _08009_ _08010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15606_ _07996_ _07991_ _06356_ _06382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15607_ _06145_ _06094_ _08011_ _08012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15608_ _08013_ _06091_ _08014_ _08015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15609_ _06384_ _07995_ _06387_ _06391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15610_ _06362_ _06388_ _08016_ _08017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15611_ _08000_ _08010_ _06396_ _06420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15612_ _08018_ _08019_ _07999_ _08020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15613_ _08003_ _06407_ _06403_ _06433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15614_ _06352_ _08021_ _08005_ _06430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15615_ _08022_ _08023_ _08024_ _08025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15616_ _08015_ _08006_ _06383_ _08026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15617_ _08027_ _08026_ _08028_ _06416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15618_ _08028_ _08014_ _06410_ _06414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15619_ _06389_ _06411_ _08029_ _08030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15620_ _08020_ _08025_ _06421_ _08031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15621_ _06408_ _06438_ _06434_ _08032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15622_ _08033_ _08034_ _08035_ _08036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15623_ _08037_ _08038_ _08039_ _06449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15624_ _06412_ _06442_ _08040_ _08041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15625_ _08042_ _08036_ _08043_ _06462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15626_ _06341_ _06435_ _06427_ _08044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15627_ _08045_ _08046_ _08047_ _08048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15628_ _06439_ _08049_ _08050_ _08051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15629_ _08052_ _08053_ _08054_ _08055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15630_ _08056_ _08057_ _08058_ _08059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15631_ _06205_ _06451_ _08060_ _08061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15632_ _06452_ _08061_ _08062_ _08063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15633_ _08062_ _08060_ _06456_ _08064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15634_ _06443_ _06457_ _08065_ _08066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15635_ _08067_ _08068_ _06466_ _08069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15636_ _08070_ _08055_ _08071_ _08072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15637_ _06471_ _07898_ _07952_ _06468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15638_ _06296_ _06253_ _06477_ _08073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15639_ _08072_ _08073_ _06476_ _08074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15640_ _06458_ _06480_ _08075_ _08076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15641_ _08077_ _06470_ _06486_ _06491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15642_ _07898_ _06341_ _06299_ _08078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15643_ _08079_ _08078_ _06493_ _08080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15644_ _08081_ _08078_ _08082_ _08083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15645_ _06481_ _06489_ _08085_ _08086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15646_ _06467_ _08087_ _08084_ _08088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15647_ _08089_ _08090_ _08081_ _08091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15648_ _06490_ _08092_ _08093_ _08094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15649_ _06495_ _08095_ _08092_ _08096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15650_ _08088_ _08097_ _08098_ _08099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15651_ _06341_ _08091_ _08097_ _08100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15652_ _08101_ _08102_ _08103_ _08104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15653_ _08105_ _08104_ _08106_ _06528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15654_ _08107_ _06691_ _08108_ _08109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15655_ _06504_ _06616_ _06529_ _06563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15656_ _08101_ _06501_ _06537_ _08110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15657_ _08111_ _08112_ _08113_ _06555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15658_ _08114_ _08115_ _06556_ _06592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15659_ _06748_ _08116_ _08117_ _06588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15660_ _08110_ _06663_ _06564_ _08118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15661_ _08119_ _08120_ _06583_ _08121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15662_ _08123_ _08124_ _06593_ _06651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15663_ _06803_ _06961_ _08125_ _06647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15664_ _06956_ _08126_ _08127_ _08128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15665_ _06618_ _06913_ _08129_ _08130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15666_ _08127_ _08130_ _08131_ _08132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15667_ _08116_ _06913_ _08134_ _08135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15668_ _08128_ _08134_ _08133_ _08136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15669_ _08137_ _06665_ _08138_ _08139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15670_ _08141_ _06684_ _06642_ _08142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15671_ _08101_ _06601_ _08122_ _08143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15672_ _08144_ _08145_ _06652_ _06703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15673_ _08146_ _08136_ _08140_ _08147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15674_ _06961_ _06956_ _08148_ _08149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15675_ _08148_ _08135_ _08146_ _08150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15676_ _06666_ _06717_ _08151_ _08152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15677_ _08142_ _08143_ _06680_ _06736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15678_ _06685_ _08154_ _06695_ _08155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15679_ _08156_ _08157_ _06704_ _06752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15680_ _08158_ _08150_ _08153_ _08159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15681_ _06699_ _08116_ _08160_ _08161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15682_ _08160_ _08149_ _08158_ _08162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15683_ _06718_ _06765_ _08163_ _08164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15684_ _08166_ _08151_ _08167_ _06727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15685_ _06602_ _08155_ _06737_ _06789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15686_ _08101_ _06496_ _08154_ _08168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15687_ _06742_ _06796_ _06755_ _06791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15688_ _08169_ _08170_ _06753_ _06807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15689_ _08171_ _08162_ _08165_ _08172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15690_ _06748_ _06961_ _08173_ _08174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15691_ _08173_ _08161_ _08171_ _08175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15692_ _06766_ _06821_ _08176_ _08177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15693_ _08179_ _08163_ _06775_ _06780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15694_ _06618_ _08168_ _06790_ _08180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15695_ _06797_ _06853_ _08181_ _08182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15696_ _08184_ _08185_ _06808_ _06861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15697_ _06822_ _08187_ _08188_ _08189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15698_ _08190_ _08175_ _08178_ _08191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15699_ _06829_ _08176_ _06832_ _06837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15700_ _06777_ _06833_ _08192_ _08193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15701_ _06854_ _08194_ _08195_ _08196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15702_ _06502_ _08126_ _08183_ _08197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15703_ _06809_ _06863_ _08186_ _08198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15704_ _08199_ _08200_ _06862_ _06904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15705_ _08189_ _08191_ _06828_ _06876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15706_ _08202_ _06916_ _08203_ _08204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15707_ _08205_ _08174_ _08190_ _08206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15708_ _06878_ _08188_ _06881_ _06886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15709_ _06834_ _06882_ _08207_ _08208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15710_ _08196_ _08197_ _06893_ _06939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15711_ _06496_ _06502_ _06900_ _08209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15712_ _08210_ _08211_ _08212_ _08213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15713_ _06864_ _06906_ _08201_ _08214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15714_ _08215_ _08216_ _06905_ _06947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15715_ _08204_ _08206_ _06877_ _06922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15716_ _06917_ _06959_ _08218_ _08219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15717_ _06699_ _06803_ _08205_ _08220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15718_ _06924_ _08203_ _06927_ _06932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15719_ _06883_ _06928_ _08221_ _08222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15720_ _06913_ _08213_ _06940_ _06981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15721_ _08223_ _08209_ _08211_ _08224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15722_ _08224_ _08225_ _08226_ _08227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15723_ _06907_ _06949_ _08217_ _08228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15724_ _08229_ _08230_ _06948_ _06987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15725_ _08219_ _08220_ _06923_ _06964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15726_ _06748_ _06803_ _07036_ _07074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15727_ _06960_ _08232_ _08233_ _08234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15728_ _06966_ _08218_ _06969_ _06974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15729_ _06929_ _06970_ _08235_ _08236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15730_ _06956_ _08227_ _06982_ _07013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15731_ _06502_ _08237_ _08225_ _08238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15732_ _06950_ _06989_ _08231_ _08239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15733_ _08240_ _08241_ _06988_ _08242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15734_ _08239_ _08243_ _08244_ _07015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15735_ _06748_ _08234_ _06965_ _08245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15736_ _06699_ _07074_ _08246_ _08247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15737_ _07036_ _06996_ _07058_ _07063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15738_ _08248_ _07037_ _08249_ _08250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15739_ _08252_ _08233_ _07003_ _07008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15740_ _06971_ _07004_ _08253_ _08254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15741_ _08116_ _08238_ _07014_ _07032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15742_ _06990_ _08255_ _08243_ _08256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15743_ _08258_ _08259_ _08257_ _08260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15744_ _08256_ _08261_ _08262_ _07034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15745_ _06803_ _08250_ _08251_ _08263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15746_ _08262_ _08263_ _08264_ _07030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15747_ _08264_ _08249_ _07023_ _07027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15748_ _07005_ _07024_ _08265_ _08266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15749_ _06961_ _07017_ _07033_ _07054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15750_ _08267_ _08268_ _08261_ _08269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15751_ _08270_ _08260_ _08268_ _08271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15752_ _08272_ _08273_ _08270_ _08274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15753_ _08269_ _08275_ _08276_ _07056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_15754_ _08246_ _07038_ _08277_ _08278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15755_ _08276_ _08278_ _08279_ _08280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15756_ _08279_ _08277_ _07045_ _08281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15757_ _07025_ _07046_ _08282_ _08283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15758_ _06699_ _08209_ _07055_ _08284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15759_ _08271_ _08285_ _08275_ _08286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15760_ _07047_ _08288_ _08289_ _08290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15761_ _07050_ _07060_ _08288_ _08291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15762_ _08292_ _08274_ _08285_ _08293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15763_ _06502_ _06748_ _08287_ _08294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15764_ _08291_ _08295_ _08296_ _08297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15765_ _07061_ _08298_ _08295_ _08299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15766_ _07064_ _08300_ _08298_ _08301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15767_ _08293_ _08294_ _07075_ _08302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15768_ _08303_ _08304_ _08292_ _08305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15769_ _08302_ _08306_ _08307_ _08308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_15770_ _00002_ clknet_leaf_0_clk _00011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
X_15771_ _00001_ clknet_leaf_0_clk _00010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
X_15772_ _00000_ clknet_leaf_21_clk _00008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
X_15773_ _00018_ clknet_leaf_0_clk _00009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
X_15774_ _00019_ clknet_leaf_0_clk _00012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
X_15775_ _00020_ clknet_leaf_0_clk _00016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
X_15776_ _00021_ clknet_leaf_0_clk _00017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xclkbuf_leaf_0_clk clknet_1_0__leaf_clk clknet_leaf_0_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_15237__322 net369 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
Xbit_rev_idx\[0\]$_DFFE_PN0P_ _00022_ net81 clknet_leaf_21_clk
+ bit_rev_idx\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_rev_idx\[1\]$_DFFE_PN0P_ _00023_ net81 clknet_leaf_17_clk
+ bit_rev_idx\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_rev_idx\[2\]$_DFFE_PN0P_ _00024_ net81 clknet_leaf_17_clk
+ bit_rev_idx\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbusy$_DFFE_PN0P_ _00025_ net81 clknet_leaf_20_clk net83 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbutterfly_count\[0\]$_DFFE_PN0P_ _00026_ net81 clknet_leaf_20_clk
+ butterfly_count\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbutterfly_count\[1\]$_DFFE_PN0P_ _00027_ net81 clknet_leaf_20_clk
+ butterfly_count\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbutterfly_count\[2\]$_DFFE_PN0P_ _00028_ net81 clknet_leaf_20_clk
+ butterfly_count\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xbutterfly_in_group\[0\]$_DFFE_PP_ _00029_ clknet_leaf_20_clk
+ butterfly_in_group\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbutterfly_in_group\[1\]$_DFFE_PP_ _00030_ clknet_leaf_20_clk
+ butterfly_in_group\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xbutterfly_in_group\[2\]$_DFFE_PP_ _00031_ clknet_leaf_20_clk
+ butterfly_in_group\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xdata_out_imag\[0\]$_DFFE_PN0P_ _00032_ net81 clknet_leaf_17_clk
+ net84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[100\]$_DFFE_PN0P_ _00033_ net81 clknet_leaf_11_clk
+ net85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[101\]$_DFFE_PN0P_ _00034_ net81 clknet_leaf_11_clk
+ net86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[102\]$_DFFE_PN0P_ _00035_ net81 clknet_leaf_10_clk
+ net87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[103\]$_DFFE_PN0P_ _00036_ net81 clknet_leaf_11_clk
+ net88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[104\]$_DFFE_PN0P_ _00037_ net81 clknet_leaf_10_clk
+ net89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[105\]$_DFFE_PN0P_ _00038_ net81 clknet_leaf_11_clk
+ net90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[106\]$_DFFE_PN0P_ _00039_ net81 clknet_leaf_10_clk
+ net91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[107\]$_DFFE_PN0P_ _00040_ net81 clknet_leaf_16_clk
+ net92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[108\]$_DFFE_PN0P_ _00041_ net81 clknet_leaf_18_clk
+ net93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[109\]$_DFFE_PN0P_ _00042_ net81 clknet_leaf_18_clk
+ net94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[10\]$_DFFE_PN0P_ _00043_ net81 clknet_leaf_9_clk
+ net95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[110\]$_DFFE_PN0P_ _00044_ net81 clknet_leaf_18_clk
+ net96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[111\]$_DFFE_PN0P_ _00045_ net81 clknet_leaf_18_clk
+ net97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[112\]$_DFFE_PN0P_ _00046_ net81 clknet_leaf_19_clk
+ net98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[113\]$_DFFE_PN0P_ _00047_ net81 clknet_leaf_15_clk
+ net99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[114\]$_DFFE_PN0P_ _00048_ net81 clknet_leaf_9_clk
+ net100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[115\]$_DFFE_PN0P_ _00049_ net81 clknet_leaf_9_clk
+ net101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[116\]$_DFFE_PN0P_ _00050_ net81 clknet_leaf_9_clk
+ net102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[117\]$_DFFE_PN0P_ _00051_ net81 clknet_leaf_11_clk
+ net103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[118\]$_DFFE_PN0P_ _00052_ net81 clknet_leaf_10_clk
+ net104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[119\]$_DFFE_PN0P_ _00053_ net81 clknet_leaf_11_clk
+ net105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[11\]$_DFFE_PN0P_ _00054_ net81 clknet_leaf_10_clk
+ net106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[120\]$_DFFE_PN0P_ _00055_ net81 clknet_leaf_10_clk
+ net107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[121\]$_DFFE_PN0P_ _00056_ net81 clknet_leaf_10_clk
+ net108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[122\]$_DFFE_PN0P_ _00057_ net81 clknet_leaf_10_clk
+ net109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[123\]$_DFFE_PN0P_ _00058_ net81 clknet_leaf_10_clk
+ net110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[124\]$_DFFE_PN0P_ _00059_ net81 clknet_leaf_18_clk
+ net111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[125\]$_DFFE_PN0P_ _00060_ net81 clknet_leaf_18_clk
+ net112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[126\]$_DFFE_PN0P_ _00061_ net81 clknet_leaf_19_clk
+ net113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[127\]$_DFFE_PN0P_ _00062_ net81 clknet_leaf_19_clk
+ net114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[12\]$_DFFE_PN0P_ _00063_ net81 clknet_leaf_19_clk
+ net115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[13\]$_DFFE_PN0P_ _00064_ net81 clknet_leaf_19_clk
+ net116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[14\]$_DFFE_PN0P_ _00065_ net81 clknet_leaf_19_clk
+ net117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[15\]$_DFFE_PN0P_ _00066_ net81 clknet_leaf_19_clk
+ net118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[16\]$_DFFE_PN0P_ _00067_ net81 clknet_leaf_15_clk
+ net119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[17\]$_DFFE_PN0P_ _00068_ net81 clknet_leaf_15_clk
+ net120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[18\]$_DFFE_PN0P_ _00069_ net81 clknet_leaf_14_clk
+ net121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[19\]$_DFFE_PN0P_ _00070_ net81 clknet_leaf_14_clk
+ net122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[1\]$_DFFE_PN0P_ _00071_ net81 clknet_leaf_15_clk
+ net123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[20\]$_DFFE_PN0P_ _00072_ net81 clknet_leaf_13_clk
+ net124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[21\]$_DFFE_PN0P_ _00073_ net81 clknet_leaf_13_clk
+ net125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[22\]$_DFFE_PN0P_ _00074_ net81 clknet_leaf_13_clk
+ net126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[23\]$_DFFE_PN0P_ _00075_ net81 clknet_leaf_12_clk
+ net127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[24\]$_DFFE_PN0P_ _00076_ net81 clknet_leaf_12_clk
+ net128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[25\]$_DFFE_PN0P_ _00077_ net81 clknet_leaf_12_clk
+ net129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[26\]$_DFFE_PN0P_ _00078_ net81 clknet_leaf_15_clk
+ net130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[27\]$_DFFE_PN0P_ _00079_ net81 clknet_leaf_15_clk
+ net131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[28\]$_DFFE_PN0P_ _00080_ net81 clknet_leaf_15_clk
+ net132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[29\]$_DFFE_PN0P_ _00081_ net81 clknet_leaf_19_clk
+ net133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[2\]$_DFFE_PN0P_ _00082_ net81 clknet_leaf_14_clk
+ net134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[30\]$_DFFE_PN0P_ _00083_ net81 clknet_leaf_19_clk
+ net135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[31\]$_DFFE_PN0P_ _00084_ net81 clknet_leaf_19_clk
+ net136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[32\]$_DFFE_PN0P_ _00085_ net81 clknet_leaf_19_clk
+ net137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[33\]$_DFFE_PN0P_ _00086_ net81 clknet_leaf_15_clk
+ net138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[34\]$_DFFE_PN0P_ _00087_ net81 clknet_leaf_14_clk
+ net139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[35\]$_DFFE_PN0P_ _00088_ net81 clknet_leaf_14_clk
+ net140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[36\]$_DFFE_PN0P_ _00089_ net81 clknet_leaf_13_clk
+ net141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[37\]$_DFFE_PN0P_ _00090_ net81 clknet_leaf_13_clk
+ net142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[38\]$_DFFE_PN0P_ _00091_ net81 clknet_leaf_13_clk
+ net143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[39\]$_DFFE_PN0P_ _00092_ net81 clknet_leaf_13_clk
+ net144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[3\]$_DFFE_PN0P_ _00093_ net81 clknet_leaf_14_clk
+ net145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[40\]$_DFFE_PN0P_ _00094_ net81 clknet_leaf_13_clk
+ net146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[41\]$_DFFE_PN0P_ _00095_ net81 clknet_leaf_13_clk
+ net147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[42\]$_DFFE_PN0P_ _00096_ net81 clknet_leaf_15_clk
+ net148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[43\]$_DFFE_PN0P_ _00097_ net81 clknet_leaf_15_clk
+ net149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[44\]$_DFFE_PN0P_ _00098_ net81 clknet_leaf_15_clk
+ net150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[45\]$_DFFE_PN0P_ _00099_ net81 clknet_leaf_19_clk
+ net151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[46\]$_DFFE_PN0P_ _00100_ net81 clknet_leaf_19_clk
+ net152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[47\]$_DFFE_PN0P_ _00101_ net81 clknet_leaf_19_clk
+ net153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[48\]$_DFFE_PN0P_ _00102_ net81 clknet_leaf_19_clk
+ net154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[49\]$_DFFE_PN0P_ _00103_ net81 clknet_leaf_15_clk
+ net155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[4\]$_DFFE_PN0P_ _00104_ net81 clknet_leaf_13_clk
+ net156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[50\]$_DFFE_PN0P_ _00105_ net81 clknet_leaf_14_clk
+ net157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[51\]$_DFFE_PN0P_ _00106_ net81 clknet_leaf_14_clk
+ net158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[52\]$_DFFE_PN0P_ _00107_ net81 clknet_leaf_14_clk
+ net159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[53\]$_DFFE_PN0P_ _00108_ net81 clknet_leaf_11_clk
+ net160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[54\]$_DFFE_PN0P_ _00109_ net81 clknet_leaf_11_clk
+ net161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[55\]$_DFFE_PN0P_ _00110_ net81 clknet_leaf_11_clk
+ net162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[56\]$_DFFE_PN0P_ _00111_ net81 clknet_leaf_10_clk
+ net163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[57\]$_DFFE_PN0P_ _00112_ net81 clknet_leaf_11_clk
+ net164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[58\]$_DFFE_PN0P_ _00113_ net81 clknet_leaf_19_clk
+ net165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[59\]$_DFFE_PN0P_ _00114_ net81 clknet_leaf_15_clk
+ net166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[5\]$_DFFE_PN0P_ _00115_ net81 clknet_leaf_11_clk
+ net167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[60\]$_DFFE_PN0P_ _00116_ net81 clknet_leaf_20_clk
+ net168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[61\]$_DFFE_PN0P_ _00117_ net81 clknet_leaf_20_clk
+ net169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[62\]$_DFFE_PN0P_ _00118_ net81 clknet_leaf_19_clk
+ net170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[63\]$_DFFE_PN0P_ _00119_ net81 clknet_leaf_19_clk
+ net171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[64\]$_DFFE_PN0P_ _00120_ net81 clknet_leaf_17_clk
+ net172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[65\]$_DFFE_PN0P_ _00121_ net81 clknet_leaf_15_clk
+ net173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[66\]$_DFFE_PN0P_ _00122_ net81 clknet_leaf_14_clk
+ net174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[67\]$_DFFE_PN0P_ _00123_ net81 clknet_leaf_14_clk
+ net175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[68\]$_DFFE_PN0P_ _00124_ net81 clknet_leaf_14_clk
+ net176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[69\]$_DFFE_PN0P_ _00125_ net81 clknet_leaf_12_clk
+ net177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[6\]$_DFFE_PN0P_ _00126_ net81 clknet_leaf_13_clk
+ net178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[70\]$_DFFE_PN0P_ _00127_ net81 clknet_leaf_12_clk
+ net179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[71\]$_DFFE_PN0P_ _00128_ net81 clknet_leaf_12_clk
+ net180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[72\]$_DFFE_PN0P_ _00129_ net81 clknet_leaf_11_clk
+ net181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[73\]$_DFFE_PN0P_ _00130_ net81 clknet_leaf_11_clk
+ net182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[74\]$_DFFE_PN0P_ _00131_ net81 clknet_leaf_15_clk
+ net183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[75\]$_DFFE_PN0P_ _00132_ net81 clknet_leaf_15_clk
+ net184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[76\]$_DFFE_PN0P_ _00133_ net81 clknet_leaf_19_clk
+ net185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[77\]$_DFFE_PN0P_ _00134_ net81 clknet_leaf_19_clk
+ net186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[78\]$_DFFE_PN0P_ _00135_ net81 clknet_leaf_19_clk
+ net187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[79\]$_DFFE_PN0P_ _00136_ net81 clknet_leaf_19_clk
+ net188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[7\]$_DFFE_PN0P_ _00137_ net81 clknet_leaf_13_clk
+ net189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[80\]$_DFFE_PN0P_ _00138_ net81 clknet_leaf_19_clk
+ net190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[81\]$_DFFE_PN0P_ _00139_ net81 clknet_leaf_14_clk
+ net191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[82\]$_DFFE_PN0P_ _00140_ net81 clknet_leaf_13_clk
+ net192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[83\]$_DFFE_PN0P_ _00141_ net81 clknet_leaf_11_clk
+ net193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[84\]$_DFFE_PN0P_ _00142_ net81 clknet_leaf_14_clk
+ net194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[85\]$_DFFE_PN0P_ _00143_ net81 clknet_leaf_11_clk
+ net195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[86\]$_DFFE_PN0P_ _00144_ net81 clknet_leaf_10_clk
+ net196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[87\]$_DFFE_PN0P_ _00145_ net81 clknet_leaf_11_clk
+ net197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[88\]$_DFFE_PN0P_ _00146_ net81 clknet_leaf_11_clk
+ net198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[89\]$_DFFE_PN0P_ _00147_ net81 clknet_leaf_11_clk
+ net199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[8\]$_DFFE_PN0P_ _00148_ net81 clknet_leaf_11_clk
+ net200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[90\]$_DFFE_PN0P_ _00149_ net81 clknet_leaf_11_clk
+ net201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[91\]$_DFFE_PN0P_ _00150_ net81 clknet_leaf_15_clk
+ net202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[92\]$_DFFE_PN0P_ _00151_ net81 clknet_leaf_20_clk
+ net203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[93\]$_DFFE_PN0P_ _00152_ net81 clknet_leaf_20_clk
+ net204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[94\]$_DFFE_PN0P_ _00153_ net81 clknet_leaf_18_clk
+ net205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[95\]$_DFFE_PN0P_ _00154_ net81 clknet_leaf_18_clk
+ net206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[96\]$_DFFE_PN0P_ _00155_ net81 clknet_leaf_17_clk
+ net207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[97\]$_DFFE_PN0P_ _00156_ net81 clknet_leaf_9_clk
+ net208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[98\]$_DFFE_PN0P_ _00157_ net81 clknet_leaf_9_clk
+ net209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[99\]$_DFFE_PN0P_ _00158_ net81 clknet_leaf_9_clk
+ net210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_imag\[9\]$_DFFE_PN0P_ _00159_ net81 clknet_leaf_13_clk
+ net211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[0\]$_DFFE_PN0P_ _00160_ net81 clknet_leaf_19_clk
+ net212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[100\]$_DFFE_PN0P_ _00161_ net81 clknet_leaf_0_clk
+ net213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[101\]$_DFFE_PN0P_ _00162_ net81 clknet_leaf_0_clk
+ net214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[102\]$_DFFE_PN0P_ _00163_ net81 clknet_leaf_3_clk
+ net215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[103\]$_DFFE_PN0P_ _00164_ net81 clknet_leaf_3_clk
+ net216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[104\]$_DFFE_PN0P_ _00165_ net81 clknet_leaf_4_clk
+ net217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[105\]$_DFFE_PN0P_ _00166_ net81 clknet_leaf_5_clk
+ net218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[106\]$_DFFE_PN0P_ _00167_ net81 clknet_leaf_10_clk
+ net219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[107\]$_DFFE_PN0P_ _00168_ net81 clknet_leaf_7_clk
+ net220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[108\]$_DFFE_PN0P_ _00169_ net81 clknet_leaf_6_clk
+ net221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[109\]$_DFFE_PN0P_ _00170_ net81 clknet_leaf_6_clk
+ net222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[10\]$_DFFE_PN0P_ _00171_ net81 clknet_leaf_10_clk
+ net223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[110\]$_DFFE_PN0P_ _00172_ net81 clknet_leaf_6_clk
+ net224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[111\]$_DFFE_PN0P_ _00173_ net81 clknet_leaf_6_clk
+ net225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[112\]$_DFFE_PN0P_ _00174_ net81 clknet_leaf_10_clk
+ net226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[113\]$_DFFE_PN0P_ _00175_ net81 clknet_leaf_5_clk
+ net227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[114\]$_DFFE_PN0P_ _00176_ net81 clknet_leaf_3_clk
+ net228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[115\]$_DFFE_PN0P_ _00177_ net81 clknet_leaf_0_clk
+ net229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[116\]$_DFFE_PN0P_ _00178_ net81 clknet_leaf_0_clk
+ net230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[117\]$_DFFE_PN0P_ _00179_ net81 clknet_leaf_0_clk
+ net231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[118\]$_DFFE_PN0P_ _00180_ net81 clknet_leaf_3_clk
+ net232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[119\]$_DFFE_PN0P_ _00181_ net81 clknet_leaf_5_clk
+ net233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[11\]$_DFFE_PN0P_ _00182_ net81 clknet_leaf_10_clk
+ net234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[120\]$_DFFE_PN0P_ _00183_ net81 clknet_leaf_4_clk
+ net235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[121\]$_DFFE_PN0P_ _00184_ net81 clknet_leaf_5_clk
+ net236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[122\]$_DFFE_PN0P_ _00185_ net81 clknet_leaf_10_clk
+ net237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[123\]$_DFFE_PN0P_ _00186_ net81 clknet_leaf_7_clk
+ net238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[124\]$_DFFE_PN0P_ _00187_ net81 clknet_leaf_6_clk
+ net239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[125\]$_DFFE_PN0P_ _00188_ net81 clknet_leaf_6_clk
+ net240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[126\]$_DFFE_PN0P_ _00189_ net81 clknet_leaf_6_clk
+ net241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[127\]$_DFFE_PN0P_ _00190_ net81 clknet_leaf_6_clk
+ net242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[12\]$_DFFE_PN0P_ _00191_ net81 clknet_leaf_6_clk
+ net243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[13\]$_DFFE_PN0P_ _00192_ net81 clknet_leaf_6_clk
+ net244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[14\]$_DFFE_PN0P_ _00193_ net81 clknet_leaf_6_clk
+ net245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[15\]$_DFFE_PN0P_ _00194_ net81 clknet_leaf_6_clk
+ net246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[16\]$_DFFE_PN0P_ _00195_ net81 clknet_leaf_6_clk
+ net247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[17\]$_DFFE_PN0P_ _00196_ net81 clknet_leaf_5_clk
+ net248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[18\]$_DFFE_PN0P_ _00197_ net81 clknet_leaf_5_clk
+ net249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[19\]$_DFFE_PN0P_ _00198_ net81 clknet_leaf_3_clk
+ net250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[1\]$_DFFE_PN0P_ _00199_ net81 clknet_leaf_5_clk
+ net251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[20\]$_DFFE_PN0P_ _00200_ net81 clknet_leaf_3_clk
+ net252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[21\]$_DFFE_PN0P_ _00201_ net81 clknet_leaf_3_clk
+ net253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[22\]$_DFFE_PN0P_ _00202_ net81 clknet_leaf_3_clk
+ net254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[23\]$_DFFE_PN0P_ _00203_ net81 clknet_leaf_4_clk
+ net255 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[24\]$_DFFE_PN0P_ _00204_ net81 clknet_leaf_4_clk
+ net256 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[25\]$_DFFE_PN0P_ _00205_ net81 clknet_leaf_4_clk
+ net257 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[26\]$_DFFE_PN0P_ _00206_ net81 clknet_leaf_5_clk
+ net258 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[27\]$_DFFE_PN0P_ _00207_ net81 clknet_leaf_5_clk
+ net259 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[28\]$_DFFE_PN0P_ _00208_ net81 clknet_leaf_5_clk
+ net260 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[29\]$_DFFE_PN0P_ _00209_ net81 clknet_leaf_5_clk
+ net261 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[2\]$_DFFE_PN0P_ _00210_ net81 clknet_leaf_3_clk
+ net262 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[30\]$_DFFE_PN0P_ _00211_ net81 clknet_leaf_5_clk
+ net263 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[31\]$_DFFE_PN0P_ _00212_ net81 clknet_leaf_5_clk
+ net264 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[32\]$_DFFE_PN0P_ _00213_ net81 clknet_leaf_5_clk
+ net265 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[33\]$_DFFE_PN0P_ _00214_ net81 clknet_leaf_5_clk
+ net266 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[34\]$_DFFE_PN0P_ _00215_ net81 clknet_leaf_3_clk
+ net267 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[35\]$_DFFE_PN0P_ _00216_ net81 clknet_leaf_1_clk
+ net268 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[36\]$_DFFE_PN0P_ _00217_ net81 clknet_leaf_0_clk
+ net269 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[37\]$_DFFE_PN0P_ _00218_ net81 clknet_leaf_1_clk
+ net270 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[38\]$_DFFE_PN0P_ _00219_ net81 clknet_leaf_3_clk
+ net271 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[39\]$_DFFE_PN0P_ _00220_ net81 clknet_leaf_3_clk
+ net272 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[3\]$_DFFE_PN0P_ _00221_ net81 clknet_leaf_4_clk
+ net273 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[40\]$_DFFE_PN0P_ _00222_ net81 clknet_leaf_4_clk
+ net274 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[41\]$_DFFE_PN0P_ _00223_ net81 clknet_leaf_5_clk
+ net275 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[42\]$_DFFE_PN0P_ _00224_ net81 clknet_leaf_10_clk
+ net276 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[43\]$_DFFE_PN0P_ _00225_ net81 clknet_leaf_10_clk
+ net277 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[44\]$_DFFE_PN0P_ _00226_ net81 clknet_leaf_6_clk
+ net278 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[45\]$_DFFE_PN0P_ _00227_ net81 clknet_leaf_6_clk
+ net279 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[46\]$_DFFE_PN0P_ _00228_ net81 clknet_leaf_6_clk
+ net280 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[47\]$_DFFE_PN0P_ _00229_ net81 clknet_leaf_8_clk
+ net281 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[48\]$_DFFE_PN0P_ _00230_ net81 clknet_leaf_8_clk
+ net282 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[49\]$_DFFE_PN0P_ _00231_ net81 clknet_leaf_1_clk
+ net283 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[4\]$_DFFE_PN0P_ _00232_ net81 clknet_leaf_1_clk
+ net284 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[50\]$_DFFE_PN0P_ _00233_ net81 clknet_leaf_3_clk
+ net285 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[51\]$_DFFE_PN0P_ _00234_ net81 clknet_leaf_1_clk
+ net286 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[52\]$_DFFE_PN0P_ _00235_ net81 clknet_leaf_1_clk
+ net287 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[53\]$_DFFE_PN0P_ _00236_ net81 clknet_leaf_1_clk
+ net288 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[54\]$_DFFE_PN0P_ _00237_ net81 clknet_leaf_1_clk
+ net289 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[55\]$_DFFE_PN0P_ _00238_ net81 clknet_leaf_3_clk
+ net290 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[56\]$_DFFE_PN0P_ _00239_ net81 clknet_leaf_3_clk
+ net291 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[57\]$_DFFE_PN0P_ _00240_ net81 clknet_leaf_3_clk
+ net292 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[58\]$_DFFE_PN0P_ _00241_ net81 clknet_leaf_10_clk
+ net293 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[59\]$_DFFE_PN0P_ _00242_ net81 clknet_leaf_10_clk
+ net294 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[5\]$_DFFE_PN0P_ _00243_ net81 clknet_leaf_1_clk
+ net295 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[60\]$_DFFE_PN0P_ _00244_ net81 clknet_leaf_6_clk
+ net296 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[61\]$_DFFE_PN0P_ _00245_ net81 clknet_leaf_6_clk
+ net297 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[62\]$_DFFE_PN0P_ _00246_ net81 clknet_leaf_6_clk
+ net298 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[63\]$_DFFE_PN0P_ _00247_ net81 clknet_leaf_6_clk
+ net299 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[64\]$_DFFE_PN0P_ _00248_ net81 clknet_leaf_7_clk
+ net300 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[65\]$_DFFE_PN0P_ _00249_ net81 clknet_leaf_5_clk
+ net301 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[66\]$_DFFE_PN0P_ _00250_ net81 clknet_leaf_3_clk
+ net302 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[67\]$_DFFE_PN0P_ _00251_ net81 clknet_leaf_1_clk
+ net303 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[68\]$_DFFE_PN0P_ _00252_ net81 clknet_leaf_1_clk
+ net304 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[69\]$_DFFE_PN0P_ _00253_ net81 clknet_leaf_1_clk
+ net305 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[6\]$_DFFE_PN0P_ _00254_ net81 clknet_leaf_3_clk
+ net306 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[70\]$_DFFE_PN0P_ _00255_ net81 clknet_leaf_1_clk
+ net307 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[71\]$_DFFE_PN0P_ _00256_ net81 clknet_leaf_3_clk
+ net308 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[72\]$_DFFE_PN0P_ _00257_ net81 clknet_leaf_3_clk
+ net309 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[73\]$_DFFE_PN0P_ _00258_ net81 clknet_leaf_3_clk
+ net310 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[74\]$_DFFE_PN0P_ _00259_ net81 clknet_leaf_3_clk
+ net311 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[75\]$_DFFE_PN0P_ _00260_ net81 clknet_leaf_3_clk
+ net312 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[76\]$_DFFE_PN0P_ _00261_ net81 clknet_leaf_6_clk
+ net313 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[77\]$_DFFE_PN0P_ _00262_ net81 clknet_leaf_7_clk
+ net314 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[78\]$_DFFE_PN0P_ _00263_ net81 clknet_leaf_6_clk
+ net315 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[79\]$_DFFE_PN0P_ _00264_ net81 clknet_leaf_6_clk
+ net316 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[7\]$_DFFE_PN0P_ _00265_ net81 clknet_leaf_3_clk
+ net317 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[80\]$_DFFE_PN0P_ _00266_ net81 clknet_leaf_8_clk
+ net318 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[81\]$_DFFE_PN0P_ _00267_ net81 clknet_leaf_5_clk
+ net319 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[82\]$_DFFE_PN0P_ _00268_ net81 clknet_leaf_3_clk
+ net320 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[83\]$_DFFE_PN0P_ _00269_ net81 clknet_leaf_3_clk
+ net321 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[84\]$_DFFE_PN0P_ _00270_ net81 clknet_leaf_0_clk
+ net322 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[85\]$_DFFE_PN0P_ _00271_ net81 clknet_leaf_5_clk
+ net323 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[86\]$_DFFE_PN0P_ _00272_ net81 clknet_leaf_4_clk
+ net324 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[87\]$_DFFE_PN0P_ _00273_ net81 clknet_leaf_3_clk
+ net325 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[88\]$_DFFE_PN0P_ _00274_ net81 clknet_leaf_3_clk
+ net326 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[89\]$_DFFE_PN0P_ _00275_ net81 clknet_leaf_4_clk
+ net327 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[8\]$_DFFE_PN0P_ _00276_ net81 clknet_leaf_4_clk
+ net328 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[90\]$_DFFE_PN0P_ _00277_ net81 clknet_leaf_10_clk
+ net329 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[91\]$_DFFE_PN0P_ _00278_ net81 clknet_leaf_10_clk
+ net330 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[92\]$_DFFE_PN0P_ _00279_ net81 clknet_leaf_6_clk
+ net331 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[93\]$_DFFE_PN0P_ _00280_ net81 clknet_leaf_6_clk
+ net332 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[94\]$_DFFE_PN0P_ _00281_ net81 clknet_leaf_6_clk
+ net333 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[95\]$_DFFE_PN0P_ _00282_ net81 clknet_leaf_17_clk
+ net334 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[96\]$_DFFE_PN0P_ _00283_ net81 clknet_leaf_21_clk
+ net335 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[97\]$_DFFE_PN0P_ _00284_ net81 clknet_leaf_5_clk
+ net336 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[98\]$_DFFE_PN0P_ _00285_ net81 clknet_leaf_6_clk
+ net337 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[99\]$_DFFE_PN0P_ _00286_ net81 clknet_leaf_5_clk
+ net338 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_out_real\[9\]$_DFFE_PN0P_ _00287_ net81 clknet_leaf_5_clk
+ net339 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_ready$_DFFE_PN1P_ _00288_ net81 clknet_leaf_21_clk net340
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_4
Xdata_valid_out$_DFFE_PN0P_ _00289_ net81 clknet_leaf_20_clk
+ net341 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgroup\[0\]$_DFFE_PP_ _00290_ clknet_leaf_20_clk group\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xgroup\[1\]$_DFFE_PP_ _00291_ clknet_leaf_20_clk group\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xgroup\[2\]$_DFFE_PP_ _00292_ clknet_leaf_20_clk group\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xidx1\[0\]$_DFFE_PP_ _00293_ clknet_leaf_17_clk idx1\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xidx1\[1\]$_DFFE_PP_ _00294_ clknet_leaf_17_clk idx1\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xidx1\[2\]$_DFFE_PP_ _00295_ clknet_leaf_9_clk idx1\[2\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xidx2\[0\]$_DFFE_PP_ _00296_ clknet_leaf_9_clk idx2\[0\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xidx2\[1\]$_DFFE_PP_ _00297_ clknet_leaf_9_clk idx2\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xidx2\[2\]$_DFFE_PP_ _00298_ clknet_leaf_17_clk idx2\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xsample_count\[0\]$_DFFE_PN0P_ _00299_ net81 clknet_leaf_21_clk
+ sample_count\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsample_count\[1\]$_DFFE_PN0P_ _00300_ net81 clknet_leaf_21_clk
+ sample_count\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsample_count\[2\]$_DFFE_PN0P_ _00301_ net81 clknet_leaf_21_clk
+ sample_count\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[0\]$_DFFE_PN0P_ _00302_ net81 clknet_leaf_17_clk
+ samples_imag\[0\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[10\]$_DFFE_PN0P_ _00303_ net81 clknet_leaf_9_clk
+ samples_imag\[0\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[11\]$_DFFE_PN0P_ _00304_ net81 clknet_leaf_9_clk
+ samples_imag\[0\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[12\]$_DFFE_PN0P_ _00305_ net81 clknet_leaf_19_clk
+ samples_imag\[0\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[13\]$_DFFE_PN0P_ _00306_ net81 clknet_leaf_19_clk
+ samples_imag\[0\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[14\]$_DFFE_PN0P_ _00307_ net81 clknet_leaf_19_clk
+ samples_imag\[0\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[15\]$_DFFE_PN0P_ _00308_ net81 clknet_leaf_19_clk
+ samples_imag\[0\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[1\]$_DFFE_PN0P_ _00309_ net81 clknet_leaf_15_clk
+ samples_imag\[0\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[2\]$_DFFE_PN0P_ _00310_ net81 clknet_leaf_14_clk
+ samples_imag\[0\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[3\]$_DFFE_PN0P_ _00311_ net81 clknet_leaf_13_clk
+ samples_imag\[0\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[4\]$_DFFE_PN0P_ _00312_ net81 clknet_leaf_13_clk
+ samples_imag\[0\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[5\]$_DFFE_PN0P_ _00313_ net81 clknet_leaf_13_clk
+ samples_imag\[0\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[6\]$_DFFE_PN0P_ _00314_ net81 clknet_leaf_13_clk
+ samples_imag\[0\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[7\]$_DFFE_PN0P_ _00315_ net81 clknet_leaf_13_clk
+ samples_imag\[0\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[8\]$_DFFE_PN0P_ _00316_ net81 clknet_leaf_12_clk
+ samples_imag\[0\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[0\]\[9\]$_DFFE_PN0P_ _00317_ net81 clknet_leaf_13_clk
+ samples_imag\[0\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[0\]$_DFFE_PN0P_ _00318_ net81 clknet_leaf_16_clk
+ samples_imag\[1\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[10\]$_DFFE_PN0P_ _00319_ net81 clknet_leaf_16_clk
+ samples_imag\[1\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[11\]$_DFFE_PN0P_ _00320_ net81 clknet_leaf_16_clk
+ samples_imag\[1\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[12\]$_DFFE_PN0P_ _00321_ net81 clknet_leaf_16_clk
+ samples_imag\[1\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[13\]$_DFFE_PN0P_ _00322_ net81 clknet_leaf_16_clk
+ samples_imag\[1\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[14\]$_DFFE_PN0P_ _00323_ net81 clknet_leaf_18_clk
+ samples_imag\[1\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[15\]$_DFFE_PN0P_ _00324_ net81 clknet_leaf_18_clk
+ samples_imag\[1\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[1\]$_DFFE_PN0P_ _00325_ net81 clknet_leaf_16_clk
+ samples_imag\[1\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[2\]$_DFFE_PN0P_ _00326_ net81 clknet_leaf_16_clk
+ samples_imag\[1\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[3\]$_DFFE_PN0P_ _00327_ net81 clknet_leaf_13_clk
+ samples_imag\[1\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[4\]$_DFFE_PN0P_ _00328_ net81 clknet_leaf_13_clk
+ samples_imag\[1\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[5\]$_DFFE_PN0P_ _00329_ net81 clknet_leaf_13_clk
+ samples_imag\[1\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[6\]$_DFFE_PN0P_ _00330_ net81 clknet_leaf_13_clk
+ samples_imag\[1\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[7\]$_DFFE_PN0P_ _00331_ net81 clknet_leaf_12_clk
+ samples_imag\[1\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[8\]$_DFFE_PN0P_ _00332_ net81 clknet_leaf_12_clk
+ samples_imag\[1\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[1\]\[9\]$_DFFE_PN0P_ _00333_ net81 clknet_leaf_12_clk
+ samples_imag\[1\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[0\]$_DFFE_PN0P_ _00334_ net81 clknet_leaf_17_clk
+ samples_imag\[2\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[10\]$_DFFE_PN0P_ _00335_ net81 clknet_leaf_15_clk
+ samples_imag\[2\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[11\]$_DFFE_PN0P_ _00336_ net81 clknet_leaf_15_clk
+ samples_imag\[2\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[12\]$_DFFE_PN0P_ _00337_ net81 clknet_leaf_15_clk
+ samples_imag\[2\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[13\]$_DFFE_PN0P_ _00338_ net81 clknet_leaf_15_clk
+ samples_imag\[2\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[14\]$_DFFE_PN0P_ _00339_ net81 clknet_leaf_15_clk
+ samples_imag\[2\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[15\]$_DFFE_PN0P_ _00340_ net81 clknet_leaf_19_clk
+ samples_imag\[2\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[1\]$_DFFE_PN0P_ _00341_ net81 clknet_leaf_15_clk
+ samples_imag\[2\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[2\]$_DFFE_PN0P_ _00342_ net81 clknet_leaf_14_clk
+ samples_imag\[2\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[3\]$_DFFE_PN0P_ _00343_ net81 clknet_leaf_14_clk
+ samples_imag\[2\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[4\]$_DFFE_PN0P_ _00344_ net81 clknet_leaf_13_clk
+ samples_imag\[2\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[5\]$_DFFE_PN0P_ _00345_ net81 clknet_leaf_13_clk
+ samples_imag\[2\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[6\]$_DFFE_PN0P_ _00346_ net81 clknet_leaf_13_clk
+ samples_imag\[2\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[7\]$_DFFE_PN0P_ _00347_ net81 clknet_leaf_12_clk
+ samples_imag\[2\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[8\]$_DFFE_PN0P_ _00348_ net81 clknet_leaf_12_clk
+ samples_imag\[2\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[2\]\[9\]$_DFFE_PN0P_ _00349_ net81 clknet_leaf_12_clk
+ samples_imag\[2\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[0\]$_DFFE_PN0P_ _00350_ net81 clknet_leaf_17_clk
+ samples_imag\[3\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[10\]$_DFFE_PN0P_ _00351_ net81 clknet_leaf_15_clk
+ samples_imag\[3\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[11\]$_DFFE_PN0P_ _00352_ net81 clknet_leaf_15_clk
+ samples_imag\[3\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[12\]$_DFFE_PN0P_ _00353_ net81 clknet_leaf_18_clk
+ samples_imag\[3\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[13\]$_DFFE_PN0P_ _00354_ net81 clknet_leaf_18_clk
+ samples_imag\[3\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[14\]$_DFFE_PN0P_ _00355_ net81 clknet_leaf_18_clk
+ samples_imag\[3\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[15\]$_DFFE_PN0P_ _00356_ net81 clknet_leaf_18_clk
+ samples_imag\[3\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[1\]$_DFFE_PN0P_ _00357_ net81 clknet_leaf_15_clk
+ samples_imag\[3\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[2\]$_DFFE_PN0P_ _00358_ net81 clknet_leaf_14_clk
+ samples_imag\[3\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[3\]$_DFFE_PN0P_ _00359_ net81 clknet_leaf_14_clk
+ samples_imag\[3\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[4\]$_DFFE_PN0P_ _00360_ net81 clknet_leaf_14_clk
+ samples_imag\[3\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[5\]$_DFFE_PN0P_ _00361_ net81 clknet_leaf_12_clk
+ samples_imag\[3\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[6\]$_DFFE_PN0P_ _00362_ net81 clknet_leaf_12_clk
+ samples_imag\[3\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[7\]$_DFFE_PN0P_ _00363_ net81 clknet_leaf_12_clk
+ samples_imag\[3\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[8\]$_DFFE_PN0P_ _00364_ net81 clknet_leaf_9_clk
+ samples_imag\[3\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[3\]\[9\]$_DFFE_PN0P_ _00365_ net81 clknet_leaf_9_clk
+ samples_imag\[3\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[0\]$_DFFE_PN0P_ _00366_ net81 clknet_leaf_17_clk
+ samples_imag\[4\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[10\]$_DFFE_PN0P_ _00367_ net81 clknet_leaf_14_clk
+ samples_imag\[4\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[11\]$_DFFE_PN0P_ _00368_ net81 clknet_leaf_15_clk
+ samples_imag\[4\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[12\]$_DFFE_PN0P_ _00369_ net81 clknet_leaf_18_clk
+ samples_imag\[4\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[13\]$_DFFE_PN0P_ _00370_ net81 clknet_leaf_19_clk
+ samples_imag\[4\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[14\]$_DFFE_PN0P_ _00371_ net81 clknet_leaf_19_clk
+ samples_imag\[4\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[15\]$_DFFE_PN0P_ _00372_ net81 clknet_leaf_19_clk
+ samples_imag\[4\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[1\]$_DFFE_PN0P_ _00373_ net81 clknet_leaf_14_clk
+ samples_imag\[4\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[2\]$_DFFE_PN0P_ _00374_ net81 clknet_leaf_14_clk
+ samples_imag\[4\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[3\]$_DFFE_PN0P_ _00375_ net81 clknet_leaf_14_clk
+ samples_imag\[4\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[4\]$_DFFE_PN0P_ _00376_ net81 clknet_leaf_14_clk
+ samples_imag\[4\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[5\]$_DFFE_PN0P_ _00377_ net81 clknet_leaf_12_clk
+ samples_imag\[4\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[6\]$_DFFE_PN0P_ _00378_ net81 clknet_leaf_12_clk
+ samples_imag\[4\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[7\]$_DFFE_PN0P_ _00379_ net81 clknet_leaf_11_clk
+ samples_imag\[4\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[8\]$_DFFE_PN0P_ _00380_ net81 clknet_leaf_12_clk
+ samples_imag\[4\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[4\]\[9\]$_DFFE_PN0P_ _00381_ net81 clknet_leaf_11_clk
+ samples_imag\[4\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[0\]$_DFFE_PN0P_ _00382_ net81 clknet_leaf_17_clk
+ samples_imag\[5\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[10\]$_DFFE_PN0P_ _00383_ net81 clknet_leaf_16_clk
+ samples_imag\[5\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[11\]$_DFFE_PN0P_ _00384_ net81 clknet_leaf_16_clk
+ samples_imag\[5\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[12\]$_DFFE_PN0P_ _00385_ net81 clknet_leaf_18_clk
+ samples_imag\[5\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[13\]$_DFFE_PN0P_ _00386_ net81 clknet_leaf_18_clk
+ samples_imag\[5\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[14\]$_DFFE_PN0P_ _00387_ net81 clknet_leaf_17_clk
+ samples_imag\[5\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[15\]$_DFFE_PN0P_ _00388_ net81 clknet_leaf_18_clk
+ samples_imag\[5\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[1\]$_DFFE_PN0P_ _00389_ net81 clknet_leaf_16_clk
+ samples_imag\[5\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[2\]$_DFFE_PN0P_ _00390_ net81 clknet_leaf_14_clk
+ samples_imag\[5\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[3\]$_DFFE_PN0P_ _00391_ net81 clknet_leaf_14_clk
+ samples_imag\[5\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[4\]$_DFFE_PN0P_ _00392_ net81 clknet_leaf_14_clk
+ samples_imag\[5\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[5\]$_DFFE_PN0P_ _00393_ net81 clknet_leaf_11_clk
+ samples_imag\[5\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[6\]$_DFFE_PN0P_ _00394_ net81 clknet_leaf_11_clk
+ samples_imag\[5\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[7\]$_DFFE_PN0P_ _00395_ net81 clknet_leaf_11_clk
+ samples_imag\[5\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[8\]$_DFFE_PN0P_ _00396_ net81 clknet_leaf_11_clk
+ samples_imag\[5\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[5\]\[9\]$_DFFE_PN0P_ _00397_ net81 clknet_leaf_11_clk
+ samples_imag\[5\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[0\]$_DFFE_PN0P_ _00398_ net81 clknet_leaf_17_clk
+ samples_imag\[6\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[10\]$_DFFE_PN0P_ _00399_ net81 clknet_leaf_16_clk
+ samples_imag\[6\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[11\]$_DFFE_PN0P_ _00400_ net81 clknet_leaf_16_clk
+ samples_imag\[6\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[12\]$_DFFE_PN0P_ _00401_ net81 clknet_leaf_18_clk
+ samples_imag\[6\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[13\]$_DFFE_PN0P_ _00402_ net81 clknet_leaf_18_clk
+ samples_imag\[6\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[14\]$_DFFE_PN0P_ _00403_ net81 clknet_leaf_17_clk
+ samples_imag\[6\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[15\]$_DFFE_PN0P_ _00404_ net81 clknet_leaf_18_clk
+ samples_imag\[6\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[1\]$_DFFE_PN0P_ _00405_ net81 clknet_leaf_16_clk
+ samples_imag\[6\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[2\]$_DFFE_PN0P_ _00406_ net81 clknet_leaf_16_clk
+ samples_imag\[6\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[3\]$_DFFE_PN0P_ _00407_ net81 clknet_leaf_13_clk
+ samples_imag\[6\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[4\]$_DFFE_PN0P_ _00408_ net81 clknet_leaf_12_clk
+ samples_imag\[6\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[5\]$_DFFE_PN0P_ _00409_ net81 clknet_leaf_12_clk
+ samples_imag\[6\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[6\]$_DFFE_PN0P_ _00410_ net81 clknet_leaf_12_clk
+ samples_imag\[6\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[7\]$_DFFE_PN0P_ _00411_ net81 clknet_leaf_12_clk
+ samples_imag\[6\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[8\]$_DFFE_PN0P_ _00412_ net81 clknet_leaf_10_clk
+ samples_imag\[6\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[6\]\[9\]$_DFFE_PN0P_ _00413_ net81 clknet_leaf_9_clk
+ samples_imag\[6\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[0\]$_DFFE_PN0P_ _00414_ net81 clknet_leaf_17_clk
+ samples_imag\[7\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[10\]$_DFFE_PN0P_ _00415_ net81 clknet_leaf_9_clk
+ samples_imag\[7\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[11\]$_DFFE_PN0P_ _00416_ net81 clknet_leaf_16_clk
+ samples_imag\[7\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[12\]$_DFFE_PN0P_ _00417_ net81 clknet_leaf_18_clk
+ samples_imag\[7\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[13\]$_DFFE_PN0P_ _00418_ net81 clknet_leaf_18_clk
+ samples_imag\[7\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[14\]$_DFFE_PN0P_ _00419_ net81 clknet_leaf_17_clk
+ samples_imag\[7\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[15\]$_DFFE_PN0P_ _00420_ net81 clknet_leaf_18_clk
+ samples_imag\[7\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[1\]$_DFFE_PN0P_ _00421_ net81 clknet_leaf_16_clk
+ samples_imag\[7\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[2\]$_DFFE_PN0P_ _00422_ net81 clknet_leaf_14_clk
+ samples_imag\[7\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[3\]$_DFFE_PN0P_ _00423_ net81 clknet_leaf_14_clk
+ samples_imag\[7\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[4\]$_DFFE_PN0P_ _00424_ net81 clknet_leaf_12_clk
+ samples_imag\[7\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[5\]$_DFFE_PN0P_ _00425_ net81 clknet_leaf_12_clk
+ samples_imag\[7\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[6\]$_DFFE_PN0P_ _00426_ net81 clknet_leaf_12_clk
+ samples_imag\[7\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[7\]$_DFFE_PN0P_ _00427_ net81 clknet_leaf_11_clk
+ samples_imag\[7\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[8\]$_DFFE_PN0P_ _00428_ net81 clknet_leaf_10_clk
+ samples_imag\[7\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_imag\[7\]\[9\]$_DFFE_PN0P_ _00429_ net81 clknet_leaf_11_clk
+ samples_imag\[7\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[0\]$_DFFE_PN0P_ _00430_ net81 clknet_leaf_17_clk
+ samples_real\[0\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xsamples_real\[0\]\[10\]$_DFFE_PN0P_ _00431_ net81 clknet_leaf_9_clk
+ samples_real\[0\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[11\]$_DFFE_PN0P_ _00432_ net81 clknet_leaf_9_clk
+ samples_real\[0\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[12\]$_DFFE_PN0P_ _00433_ net81 clknet_leaf_7_clk
+ samples_real\[0\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[13\]$_DFFE_PN0P_ _00434_ net81 clknet_leaf_8_clk
+ samples_real\[0\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[14\]$_DFFE_PN0P_ _00435_ net81 clknet_leaf_7_clk
+ samples_real\[0\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[15\]$_DFFE_PN0P_ _00436_ net81 clknet_leaf_8_clk
+ samples_real\[0\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[1\]$_DFFE_PN0P_ _00437_ net81 clknet_leaf_7_clk
+ samples_real\[0\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[2\]$_DFFE_PN0P_ _00438_ net81 clknet_leaf_2_clk
+ samples_real\[0\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[3\]$_DFFE_PN0P_ _00439_ net81 clknet_leaf_1_clk
+ samples_real\[0\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[4\]$_DFFE_PN0P_ _00440_ net81 clknet_leaf_1_clk
+ samples_real\[0\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[5\]$_DFFE_PN0P_ _00441_ net81 clknet_leaf_1_clk
+ samples_real\[0\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[6\]$_DFFE_PN0P_ _00442_ net81 clknet_leaf_1_clk
+ samples_real\[0\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[7\]$_DFFE_PN0P_ _00443_ net81 clknet_leaf_2_clk
+ samples_real\[0\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[8\]$_DFFE_PN0P_ _00444_ net81 clknet_leaf_4_clk
+ samples_real\[0\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[0\]\[9\]$_DFFE_PN0P_ _00445_ net81 clknet_leaf_5_clk
+ samples_real\[0\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[0\]$_DFFE_PN0P_ _00446_ net81 clknet_leaf_8_clk
+ samples_real\[1\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[10\]$_DFFE_PN0P_ _00447_ net81 clknet_leaf_10_clk
+ samples_real\[1\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[11\]$_DFFE_PN0P_ _00448_ net81 clknet_leaf_7_clk
+ samples_real\[1\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[12\]$_DFFE_PN0P_ _00449_ net81 clknet_leaf_7_clk
+ samples_real\[1\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[13\]$_DFFE_PN0P_ _00450_ net81 clknet_leaf_8_clk
+ samples_real\[1\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[14\]$_DFFE_PN0P_ _00451_ net81 clknet_leaf_7_clk
+ samples_real\[1\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[15\]$_DFFE_PN0P_ _00452_ net81 clknet_leaf_8_clk
+ samples_real\[1\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[1\]$_DFFE_PN0P_ _00453_ net81 clknet_leaf_5_clk
+ samples_real\[1\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[2\]$_DFFE_PN0P_ _00454_ net81 clknet_leaf_2_clk
+ samples_real\[1\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[3\]$_DFFE_PN0P_ _00455_ net81 clknet_leaf_2_clk
+ samples_real\[1\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[4\]$_DFFE_PN0P_ _00456_ net81 clknet_leaf_2_clk
+ samples_real\[1\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[5\]$_DFFE_PN0P_ _00457_ net81 clknet_leaf_2_clk
+ samples_real\[1\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[6\]$_DFFE_PN0P_ _00458_ net81 clknet_leaf_4_clk
+ samples_real\[1\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[7\]$_DFFE_PN0P_ _00459_ net81 clknet_leaf_4_clk
+ samples_real\[1\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[8\]$_DFFE_PN0P_ _00460_ net81 clknet_leaf_4_clk
+ samples_real\[1\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[1\]\[9\]$_DFFE_PN0P_ _00461_ net81 clknet_leaf_4_clk
+ samples_real\[1\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[0\]$_DFFE_PN0P_ _00462_ net81 clknet_leaf_17_clk
+ samples_real\[2\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xsamples_real\[2\]\[10\]$_DFFE_PN0P_ _00463_ net81 clknet_leaf_10_clk
+ samples_real\[2\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[11\]$_DFFE_PN0P_ _00464_ net81 clknet_leaf_10_clk
+ samples_real\[2\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[12\]$_DFFE_PN0P_ _00465_ net81 clknet_leaf_7_clk
+ samples_real\[2\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[13\]$_DFFE_PN0P_ _00466_ net81 clknet_leaf_7_clk
+ samples_real\[2\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[14\]$_DFFE_PN0P_ _00467_ net81 clknet_leaf_5_clk
+ samples_real\[2\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[15\]$_DFFE_PN0P_ _00468_ net81 clknet_leaf_8_clk
+ samples_real\[2\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[1\]$_DFFE_PN0P_ _00469_ net81 clknet_leaf_5_clk
+ samples_real\[2\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[2\]$_DFFE_PN0P_ _00470_ net81 clknet_leaf_2_clk
+ samples_real\[2\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[3\]$_DFFE_PN0P_ _00471_ net81 clknet_leaf_1_clk
+ samples_real\[2\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[4\]$_DFFE_PN0P_ _00472_ net81 clknet_leaf_1_clk
+ samples_real\[2\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[5\]$_DFFE_PN0P_ _00473_ net81 clknet_leaf_1_clk
+ samples_real\[2\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[6\]$_DFFE_PN0P_ _00474_ net81 clknet_leaf_2_clk
+ samples_real\[2\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[7\]$_DFFE_PN0P_ _00475_ net81 clknet_leaf_3_clk
+ samples_real\[2\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[8\]$_DFFE_PN0P_ _00476_ net81 clknet_leaf_4_clk
+ samples_real\[2\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[2\]\[9\]$_DFFE_PN0P_ _00477_ net81 clknet_leaf_5_clk
+ samples_real\[2\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[0\]$_DFFE_PN0P_ _00478_ net81 clknet_leaf_8_clk
+ samples_real\[3\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[10\]$_DFFE_PN0P_ _00479_ net81 clknet_leaf_9_clk
+ samples_real\[3\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[11\]$_DFFE_PN0P_ _00480_ net81 clknet_leaf_9_clk
+ samples_real\[3\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[12\]$_DFFE_PN0P_ _00481_ net81 clknet_leaf_7_clk
+ samples_real\[3\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[13\]$_DFFE_PN0P_ _00482_ net81 clknet_leaf_8_clk
+ samples_real\[3\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[14\]$_DFFE_PN0P_ _00483_ net81 clknet_leaf_7_clk
+ samples_real\[3\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[15\]$_DFFE_PN0P_ _00484_ net81 clknet_leaf_8_clk
+ samples_real\[3\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[1\]$_DFFE_PN0P_ _00485_ net81 clknet_leaf_8_clk
+ samples_real\[3\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[2\]$_DFFE_PN0P_ _00486_ net81 clknet_leaf_2_clk
+ samples_real\[3\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[3\]$_DFFE_PN0P_ _00487_ net81 clknet_leaf_1_clk
+ samples_real\[3\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[4\]$_DFFE_PN0P_ _00488_ net81 clknet_leaf_1_clk
+ samples_real\[3\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[5\]$_DFFE_PN0P_ _00489_ net81 clknet_leaf_1_clk
+ samples_real\[3\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[6\]$_DFFE_PN0P_ _00490_ net81 clknet_leaf_1_clk
+ samples_real\[3\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[7\]$_DFFE_PN0P_ _00491_ net81 clknet_leaf_2_clk
+ samples_real\[3\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[8\]$_DFFE_PN0P_ _00492_ net81 clknet_leaf_2_clk
+ samples_real\[3\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[3\]\[9\]$_DFFE_PN0P_ _00493_ net81 clknet_leaf_2_clk
+ samples_real\[3\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[0\]$_DFFE_PN0P_ _00494_ net81 clknet_leaf_8_clk
+ samples_real\[4\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[10\]$_DFFE_PN0P_ _00495_ net81 clknet_leaf_10_clk
+ samples_real\[4\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xsamples_real\[4\]\[11\]$_DFFE_PN0P_ _00496_ net81 clknet_leaf_10_clk
+ samples_real\[4\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[12\]$_DFFE_PN0P_ _00497_ net81 clknet_leaf_7_clk
+ samples_real\[4\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[13\]$_DFFE_PN0P_ _00498_ net81 clknet_leaf_7_clk
+ samples_real\[4\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[14\]$_DFFE_PN0P_ _00499_ net81 clknet_leaf_7_clk
+ samples_real\[4\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[15\]$_DFFE_PN0P_ _00500_ net81 clknet_leaf_8_clk
+ samples_real\[4\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[1\]$_DFFE_PN0P_ _00501_ net81 clknet_leaf_5_clk
+ samples_real\[4\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[2\]$_DFFE_PN0P_ _00502_ net81 clknet_leaf_2_clk
+ samples_real\[4\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[3\]$_DFFE_PN0P_ _00503_ net81 clknet_leaf_1_clk
+ samples_real\[4\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[4\]$_DFFE_PN0P_ _00504_ net81 clknet_leaf_1_clk
+ samples_real\[4\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[5\]$_DFFE_PN0P_ _00505_ net81 clknet_leaf_1_clk
+ samples_real\[4\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[6\]$_DFFE_PN0P_ _00506_ net81 clknet_leaf_1_clk
+ samples_real\[4\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[7\]$_DFFE_PN0P_ _00507_ net81 clknet_leaf_2_clk
+ samples_real\[4\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[8\]$_DFFE_PN0P_ _00508_ net81 clknet_leaf_2_clk
+ samples_real\[4\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[4\]\[9\]$_DFFE_PN0P_ _00509_ net81 clknet_leaf_2_clk
+ samples_real\[4\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[0\]$_DFFE_PN0P_ _00510_ net81 clknet_leaf_8_clk
+ samples_real\[5\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[10\]$_DFFE_PN0P_ _00511_ net81 clknet_leaf_10_clk
+ samples_real\[5\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[11\]$_DFFE_PN0P_ _00512_ net81 clknet_leaf_7_clk
+ samples_real\[5\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[12\]$_DFFE_PN0P_ _00513_ net81 clknet_leaf_7_clk
+ samples_real\[5\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[13\]$_DFFE_PN0P_ _00514_ net81 clknet_leaf_7_clk
+ samples_real\[5\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[14\]$_DFFE_PN0P_ _00515_ net81 clknet_leaf_7_clk
+ samples_real\[5\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[15\]$_DFFE_PN0P_ _00516_ net81 clknet_leaf_8_clk
+ samples_real\[5\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[1\]$_DFFE_PN0P_ _00517_ net81 clknet_leaf_5_clk
+ samples_real\[5\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[2\]$_DFFE_PN0P_ _00518_ net81 clknet_leaf_4_clk
+ samples_real\[5\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[3\]$_DFFE_PN0P_ _00519_ net81 clknet_leaf_2_clk
+ samples_real\[5\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[4\]$_DFFE_PN0P_ _00520_ net81 clknet_leaf_0_clk
+ samples_real\[5\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[5\]$_DFFE_PN0P_ _00521_ net81 clknet_leaf_0_clk
+ samples_real\[5\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[6\]$_DFFE_PN0P_ _00522_ net81 clknet_leaf_4_clk
+ samples_real\[5\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[7\]$_DFFE_PN0P_ _00523_ net81 clknet_leaf_4_clk
+ samples_real\[5\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[8\]$_DFFE_PN0P_ _00524_ net81 clknet_leaf_4_clk
+ samples_real\[5\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[5\]\[9\]$_DFFE_PN0P_ _00525_ net81 clknet_leaf_4_clk
+ samples_real\[5\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[0\]$_DFFE_PN0P_ _00526_ net81 clknet_leaf_8_clk
+ samples_real\[6\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[10\]$_DFFE_PN0P_ _00527_ net81 clknet_leaf_10_clk
+ samples_real\[6\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[11\]$_DFFE_PN0P_ _00528_ net81 clknet_leaf_7_clk
+ samples_real\[6\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[12\]$_DFFE_PN0P_ _00529_ net81 clknet_leaf_7_clk
+ samples_real\[6\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[13\]$_DFFE_PN0P_ _00530_ net81 clknet_leaf_7_clk
+ samples_real\[6\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[14\]$_DFFE_PN0P_ _00531_ net81 clknet_leaf_7_clk
+ samples_real\[6\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[15\]$_DFFE_PN0P_ _00532_ net81 clknet_leaf_0_clk
+ samples_real\[6\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[1\]$_DFFE_PN0P_ _00533_ net81 clknet_leaf_8_clk
+ samples_real\[6\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[2\]$_DFFE_PN0P_ _00534_ net81 clknet_leaf_2_clk
+ samples_real\[6\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[3\]$_DFFE_PN0P_ _00535_ net81 clknet_leaf_2_clk
+ samples_real\[6\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[4\]$_DFFE_PN0P_ _00536_ net81 clknet_leaf_0_clk
+ samples_real\[6\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[5\]$_DFFE_PN0P_ _00537_ net81 clknet_leaf_0_clk
+ samples_real\[6\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[6\]$_DFFE_PN0P_ _00538_ net81 clknet_leaf_2_clk
+ samples_real\[6\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[7\]$_DFFE_PN0P_ _00539_ net81 clknet_leaf_2_clk
+ samples_real\[6\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[8\]$_DFFE_PN0P_ _00540_ net81 clknet_leaf_2_clk
+ samples_real\[6\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[6\]\[9\]$_DFFE_PN0P_ _00541_ net81 clknet_leaf_4_clk
+ samples_real\[6\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[0\]$_DFFE_PN0P_ _00542_ net81 clknet_leaf_17_clk
+ samples_real\[7\]\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[10\]$_DFFE_PN0P_ _00543_ net81 clknet_leaf_10_clk
+ samples_real\[7\]\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[11\]$_DFFE_PN0P_ _00544_ net81 clknet_leaf_10_clk
+ samples_real\[7\]\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[12\]$_DFFE_PN0P_ _00545_ net81 clknet_leaf_7_clk
+ samples_real\[7\]\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[13\]$_DFFE_PN0P_ _00546_ net81 clknet_leaf_7_clk
+ samples_real\[7\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[14\]$_DFFE_PN0P_ _00547_ net81 clknet_leaf_6_clk
+ samples_real\[7\]\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[15\]$_DFFE_PN0P_ _00548_ net81 clknet_leaf_8_clk
+ samples_real\[7\]\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[1\]$_DFFE_PN0P_ _00549_ net81 clknet_leaf_5_clk
+ samples_real\[7\]\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[2\]$_DFFE_PN0P_ _00550_ net81 clknet_leaf_2_clk
+ samples_real\[7\]\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[3\]$_DFFE_PN0P_ _00551_ net81 clknet_leaf_0_clk
+ samples_real\[7\]\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[4\]$_DFFE_PN0P_ _00552_ net81 clknet_leaf_0_clk
+ samples_real\[7\]\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[5\]$_DFFE_PN0P_ _00553_ net81 clknet_leaf_1_clk
+ samples_real\[7\]\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[6\]$_DFFE_PN0P_ _00554_ net81 clknet_leaf_2_clk
+ samples_real\[7\]\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[7\]$_DFFE_PN0P_ _00555_ net81 clknet_leaf_3_clk
+ samples_real\[7\]\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[8\]$_DFFE_PN0P_ _00556_ net81 clknet_leaf_3_clk
+ samples_real\[7\]\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xsamples_real\[7\]\[9\]$_DFFE_PN0P_ _00557_ net81 clknet_leaf_5_clk
+ samples_real\[7\]\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xstage\[0\]$_DFFE_PN0P_ _00558_ net81 clknet_leaf_20_clk stage\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xstage\[1\]$_DFFE_PN0P_ _00559_ net81 clknet_leaf_20_clk stage\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xstage\[2\]$_DFFE_PN0P_ _00560_ net81 clknet_leaf_20_clk stage\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xstate\[0\]$_DFF_PN1_ _00004_ net81 clknet_leaf_20_clk state\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_4
Xstate\[1\]$_DFF_PN0_ _00005_ net81 clknet_leaf_21_clk state\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xstate\[2\]$_DFF_PN0_ _00006_ net81 clknet_leaf_21_clk state\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xstate\[3\]$_DFF_PN0_ _00003_ net81 clknet_leaf_21_clk state\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtemp_imag\[0\]$_DFFE_PP_ _00561_ clknet_leaf_17_clk temp_imag\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xtemp_real\[0\]$_DFFE_PP_ _00562_ clknet_leaf_0_clk temp_real\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xtwiddle_idx\[0\]$_DFFE_PP_ _00000_ clknet_leaf_20_clk twiddle_idx\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xtwiddle_idx\[1\]$_DFFE_PP_ _00007_ clknet_leaf_20_clk twiddle_idx\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xclone1 net26 _07787_ net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xclone2 net26 _00567_ net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xclone3 net15 _02443_ _02478_ _02501_ net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
Xclone4 _02349_ _02310_ net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xclone5 _00608_ _00606_ _00613_ _00614_ _00615_ net5 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
Xclone6 net21 _01039_ _00913_ net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
Xclone7 _02632_ _02630_ _02633_ net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xclone8 net26 _07787_ net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xclone9 _01982_ net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xclone10 _03416_ _03364_ _03345_ net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
Xclone11 _02636_ net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclone12 _03005_ net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclone13 _01488_ net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xclone14 _02548_ net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xclone15 _02458_ _02455_ net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xclone16 _03556_ net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xclone17 _01928_ net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone18 _00582_ net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclone19 net26 _00567_ net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xclone20 _01972_ _01980_ _01977_ net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
Xsplit21 _07223_ net21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone22 _01486_ net22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone23 _02637_ _02590_ net23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xclone24 _02403_ net24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone25 _02402_ _02350_ net25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xsplit26 _07775_ net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclone27 _01747_ net27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone28 _01186_ net28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone29 _02700_ net29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclone30 _01634_ net30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone32 _01294_ net32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xclone33 _00772_ _00762_ net33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xclone34 _07104_ _00737_ _00771_ _00770_ net34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
Xclone35 _02843_ net35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone36 _07794_ net36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone37 net390 net37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone38 _01343_ net38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone39 _03107_ net39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone41 _02841_ net41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclone42 _01276_ net42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone43 _02201_ net43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone44 _02275_ net44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone45 _02549_ net45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclone46 net375 net46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xclone47 _03108_ net47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Right_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Right_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Right_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Right_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Right_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Right_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Right_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Right_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Right_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Right_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Right_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Right_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Right_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Right_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Right_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Right_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Right_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Right_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Right_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Right_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Right_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Right_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Right_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Right_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Right_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Right_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Right_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Right_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Right_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Right_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Right_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Right_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Right_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Right_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Right_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Right_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Right_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Right_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Right_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Right_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Right_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Right_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Right_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_72_Right_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_73_Right_73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_74_Right_74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_75_Right_75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_76_Right_76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_77_Right_77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_78_Right_78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_79_Right_79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_80_Right_80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_81_Right_81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_82_Right_82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_83_Right_83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_84_Right_84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_85_Right_85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_86_Right_86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_87_Right_87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_88_Right_88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_89_Right_89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_90_Right_90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_91_Right_91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_92_Right_92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_93_Right_93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_94_Right_94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_95_Right_95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_96_Right_96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_97_Right_97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_98_Right_98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_99_Right_99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_100_Right_100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_101_Right_101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_102_Right_102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_103_Right_103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_104_Right_104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_105_Right_105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_106_Right_106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_107_Right_107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_108_Right_108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_109_Right_109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_110_Right_110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_111_Right_111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_112_Right_112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_113_Right_113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_114_Right_114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_115_Right_115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_116_Right_116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_117_Right_117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_118_Right_118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_119_Right_119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_120_Right_120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_121_Right_121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_122_Right_122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_123_Right_123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_124_Right_124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_125_Right_125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_126_Right_126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_127_Right_127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_128_Right_128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_129_Right_129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_130_Right_130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_131_Right_131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_132_Right_132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_133_Right_133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_134_Right_134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_135_Right_135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_136_Right_136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_137_Right_137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_138_Right_138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_139_Right_139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_140_Right_140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_141_Right_141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_142_Right_142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_143_Right_143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_144_Right_144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_145_Right_145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_146_Right_146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_147_Right_147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_148_Right_148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_149_Right_149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_150_Right_150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_151_Right_151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_152_Right_152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_153_Right_153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_154_Right_154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_155_Right_155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_156_Right_156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_157_Right_157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_158_Right_158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_159_Right_159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_160_Right_160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_161_Right_161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_162_Right_162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_163_Right_163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_164_Right_164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_165_Right_165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_166_Right_166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_167_Right_167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_168_Right_168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_169_Right_169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_170_Right_170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_171_Right_171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_172_Right_172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_173_Right_173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_174_Right_174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_175_Right_175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_176_Right_176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_177_Right_177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_178_Right_178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_179_Right_179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_180_Right_180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_181_Right_181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_182_Right_182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_183_Right_183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_184_Right_184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_185_Right_185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_186_Right_186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_187_Right_187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_188_Right_188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_189_Right_189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_190_Right_190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_191_Right_191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_192_Right_192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_193_Right_193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_194_Right_194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Left_224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Left_225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Left_226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Left_227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Left_228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Left_229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Left_230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Left_231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Left_232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Left_233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Left_234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Left_235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Left_236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Left_237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Left_238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Left_239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Left_240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Left_241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Left_242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Left_243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Left_244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Left_245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Left_246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Left_247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Left_248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Left_249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Left_250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Left_251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Left_252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Left_253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Left_254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Left_255 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Left_256 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Left_257 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Left_258 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Left_259 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Left_260 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Left_261 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Left_262 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Left_263 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Left_264 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Left_265 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Left_266 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_72_Left_267 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_73_Left_268 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_74_Left_269 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_75_Left_270 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_76_Left_271 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_77_Left_272 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_78_Left_273 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_79_Left_274 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_80_Left_275 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_81_Left_276 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_82_Left_277 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_83_Left_278 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_84_Left_279 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_85_Left_280 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_86_Left_281 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_87_Left_282 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_88_Left_283 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_89_Left_284 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_90_Left_285 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_91_Left_286 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_92_Left_287 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_93_Left_288 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_94_Left_289 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_95_Left_290 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_96_Left_291 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_97_Left_292 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_98_Left_293 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_99_Left_294 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_100_Left_295 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_101_Left_296 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_102_Left_297 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_103_Left_298 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_104_Left_299 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_105_Left_300 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_106_Left_301 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_107_Left_302 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_108_Left_303 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_109_Left_304 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_110_Left_305 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_111_Left_306 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_112_Left_307 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_113_Left_308 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_114_Left_309 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_115_Left_310 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_116_Left_311 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_117_Left_312 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_118_Left_313 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_119_Left_314 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_120_Left_315 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_121_Left_316 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_122_Left_317 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_123_Left_318 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_124_Left_319 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_125_Left_320 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_126_Left_321 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_127_Left_322 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_128_Left_323 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_129_Left_324 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_130_Left_325 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_131_Left_326 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_132_Left_327 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_133_Left_328 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_134_Left_329 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_135_Left_330 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_136_Left_331 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_137_Left_332 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_138_Left_333 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_139_Left_334 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_140_Left_335 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_141_Left_336 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_142_Left_337 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_143_Left_338 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_144_Left_339 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_145_Left_340 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_146_Left_341 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_147_Left_342 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_148_Left_343 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_149_Left_344 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_150_Left_345 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_151_Left_346 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_152_Left_347 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_153_Left_348 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_154_Left_349 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_155_Left_350 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_156_Left_351 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_157_Left_352 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_158_Left_353 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_159_Left_354 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_160_Left_355 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_161_Left_356 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_162_Left_357 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_163_Left_358 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_164_Left_359 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_165_Left_360 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_166_Left_361 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_167_Left_362 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_168_Left_363 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_169_Left_364 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_170_Left_365 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_171_Left_366 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_172_Left_367 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_173_Left_368 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_174_Left_369 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_175_Left_370 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_176_Left_371 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_177_Left_372 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_178_Left_373 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_179_Left_374 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_180_Left_375 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_181_Left_376 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_182_Left_377 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_183_Left_378 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_184_Left_379 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_185_Left_380 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_186_Left_381 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_187_Left_382 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_188_Left_383 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_189_Left_384 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_190_Left_385 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_191_Left_386 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_192_Left_387 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_193_Left_388 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_194_Left_389 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_390 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_391 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_392 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_393 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_394 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_395 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_396 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_397 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_398 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_399 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_400 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_401 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_402 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_403 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_404 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_405 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_406 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_407 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_408 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_409 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_410 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_411 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_412 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_413 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_414 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_415 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_416 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_417 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_418 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_419 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_420 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_421 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_422 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_423 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_424 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_425 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_426 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_427 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_428 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_429 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_430 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_431 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_432 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_433 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_434 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_435 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_436 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_437 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_438 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_439 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_440 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_441 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_442 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_443 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_444 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_445 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_446 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_447 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_448 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_449 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_450 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_451 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_452 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_453 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_454 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_455 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_456 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_457 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_458 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_459 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_460 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_461 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_462 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_463 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_464 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_465 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_466 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_467 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_468 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_469 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_470 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_471 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_472 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_473 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_474 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_475 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_476 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_477 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_478 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_479 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_480 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_481 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_482 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_483 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_484 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_485 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_486 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_487 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_488 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_489 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_490 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_491 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_492 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_493 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_494 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_495 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_496 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_497 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_498 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_499 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_500 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_501 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_502 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_503 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_504 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_505 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_506 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_507 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_508 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_509 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_510 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_511 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_512 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_513 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_514 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_515 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_516 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_517 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_518 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_519 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_520 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_521 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_522 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_523 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_524 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_525 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_526 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_527 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_528 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_529 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_530 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_531 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_532 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_533 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_534 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_535 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_536 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_537 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_538 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_539 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_540 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_541 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_542 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_543 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_544 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_545 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_546 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_547 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_548 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_549 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_550 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_551 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_552 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_553 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_554 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_555 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_556 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_557 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_558 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_559 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_560 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_561 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_562 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_563 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_564 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_565 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_566 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_567 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_568 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_569 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_570 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_571 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_572 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_573 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_574 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_575 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_576 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_577 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_578 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_579 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_580 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_581 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_582 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_583 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_584 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_585 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_586 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_587 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_588 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_589 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_590 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_591 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_592 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_593 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_594 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_595 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_596 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_597 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_598 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_599 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_600 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_601 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_602 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_603 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_604 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_605 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_606 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_607 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_608 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_609 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_610 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_611 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_612 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_613 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_614 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_615 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_616 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_617 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_618 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_619 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_620 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_621 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_622 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_623 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_624 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_625 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_626 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_627 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_628 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_629 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_630 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_631 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_632 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_633 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_634 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_635 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_636 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_637 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_638 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_639 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_640 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_641 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_642 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_643 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_644 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_645 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_646 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_647 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_648 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_649 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_650 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_651 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_652 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_653 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_654 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_655 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_656 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_657 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_658 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_659 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_660 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_661 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_662 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_663 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_664 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_665 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_666 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_667 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_668 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_669 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_670 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_671 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_672 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_673 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_674 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_675 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_676 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_677 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_678 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_679 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_680 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_681 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_682 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_683 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_684 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_685 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_686 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_687 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_688 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_689 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_690 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_691 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_692 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_693 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_694 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_695 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_696 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_697 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_698 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_699 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_700 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_701 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_702 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_703 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_704 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_705 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_706 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_707 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_708 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_709 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_710 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_711 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_712 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_713 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_714 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_715 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_716 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_717 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_718 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_719 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_720 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_721 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_722 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_723 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_724 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_725 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_726 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_727 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_728 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_729 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_730 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_731 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_732 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_733 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_734 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_735 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_736 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_737 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_738 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_739 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_740 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_741 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_742 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_743 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_744 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_745 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_746 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_747 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_748 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_749 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_750 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_751 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_752 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_753 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_754 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_755 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_756 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_757 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_758 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_759 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_760 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_761 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_762 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_763 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_764 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_765 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_766 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_767 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_768 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_769 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_770 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_771 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_772 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_773 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_774 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_775 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_776 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_777 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_778 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_779 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_780 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_781 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_782 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_783 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_784 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_785 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_786 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_787 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_788 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_789 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_790 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_791 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_792 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_793 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_794 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_795 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_796 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_797 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_798 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_799 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_800 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_801 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_802 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_803 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_804 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_805 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_806 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_807 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_808 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_809 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_810 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_811 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_812 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_813 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_814 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_815 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_816 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_817 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_818 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_819 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_820 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_821 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_822 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_823 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_824 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_825 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_826 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_827 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_828 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_829 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_830 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_831 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_832 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_833 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_834 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_835 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_836 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_837 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_838 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_839 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_840 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_841 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_842 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_843 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_844 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_845 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_846 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_847 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_848 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_849 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_850 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_851 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_852 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_853 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_854 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_855 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_856 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_857 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_858 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_859 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_860 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_861 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_862 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_863 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_864 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_865 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_866 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_867 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_868 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_869 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_870 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_871 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_872 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_873 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_874 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_875 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_876 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_877 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_878 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_879 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_880 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_881 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_882 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_883 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_884 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_885 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_886 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_887 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_888 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_889 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_890 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_891 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_892 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_893 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_894 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_895 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_896 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_897 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_898 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_899 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_900 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_901 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_902 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_903 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_904 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_905 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_906 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_907 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_908 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_909 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_910 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_911 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_912 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_913 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_914 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_915 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_916 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_917 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_918 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_919 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_920 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_921 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_922 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_923 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_924 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_925 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_926 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_927 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_928 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_929 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_930 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_931 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_932 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_933 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_934 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_935 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_936 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_937 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_938 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_939 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_940 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_941 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_942 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_943 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_944 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_945 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_946 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_947 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_948 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_949 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_950 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_951 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_952 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_953 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_954 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_955 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_956 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_957 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_958 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_959 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_960 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_961 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_962 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_963 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_964 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_965 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_966 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_967 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_968 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_969 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_970 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_971 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_972 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_973 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_974 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_975 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_976 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_977 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_978 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_979 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_980 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_981 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_982 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_983 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_984 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_985 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_986 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_987 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_988 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_989 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_990 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_991 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_992 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_993 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_994 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_995 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_996 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_997 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_998 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_999 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_1000 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_1001 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_1002 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_1003 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_1004 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_1005 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1006 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1007 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1008 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1009 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1010 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_1011 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_1012 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_1013 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_1014 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1015 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1016 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1017 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1018 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1019 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_1020 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_1021 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_1022 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_1023 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1024 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1025 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1026 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1027 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1028 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_1029 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_1030 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_1031 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_1032 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1033 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1034 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1035 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1036 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1037 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_1038 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_1039 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_1040 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_1041 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1042 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1043 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1044 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1045 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1046 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_1047 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_1048 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_1049 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_1050 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1051 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1052 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1053 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1054 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1055 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_1056 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_1057 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_1058 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_1059 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1060 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1061 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1062 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1063 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1064 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_1065 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_1066 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_1067 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_1068 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1069 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1070 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1071 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1072 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1073 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_1074 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_1075 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_1076 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_1077 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1078 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1079 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1080 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1081 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1082 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_1083 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_1084 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_1085 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_1086 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1087 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1088 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1089 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1090 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1091 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_1092 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_1093 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_1094 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_1095 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1096 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1097 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1098 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1099 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_1101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_1102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_1103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_1104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_1110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_1111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_1112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_1113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_1119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_1120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_1121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_1122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_163_1128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_163_1129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_163_1130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_163_1131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_165_1137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_165_1138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_165_1139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_165_1140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_167_1146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_167_1147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_167_1148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_167_1149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_169_1155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_169_1156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_169_1157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_169_1158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_171_1164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_171_1165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_171_1166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_171_1167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_173_1173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_173_1174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_173_1175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_173_1176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_175_1182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_175_1183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_175_1184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_175_1185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_177_1191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_177_1192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_177_1193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_177_1194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_179_1200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_179_1201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_179_1202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_179_1203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_181_1209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_181_1210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_181_1211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_181_1212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_183_1218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_183_1219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_183_1220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_183_1221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_185_1227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_185_1228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_185_1229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_185_1230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_187_1236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_187_1237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_187_1238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_187_1239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_189_1245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_189_1246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_189_1247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_189_1248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_191_1254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_191_1255 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_191_1256 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_191_1257 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1258 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1259 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1260 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1261 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1262 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_193_1263 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_193_1264 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_193_1265 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_193_1266 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1267 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1268 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1269 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1270 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1271 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1272 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1273 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1274 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1275 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 data_in_imag[0] net48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput2 data_in_imag[10] net49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput3 data_in_imag[11] net50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput4 data_in_imag[12] net51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput5 data_in_imag[13] net52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput6 data_in_imag[14] net53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput7 data_in_imag[15] net54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput8 data_in_imag[1] net55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput9 data_in_imag[2] net56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput10 data_in_imag[3] net57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput11 data_in_imag[4] net58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput12 data_in_imag[5] net59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput13 data_in_imag[6] net60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput14 data_in_imag[7] net61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput15 data_in_imag[8] net62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput16 data_in_imag[9] net63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput17 data_in_real[0] net64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput18 data_in_real[10] net65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput19 data_in_real[11] net66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput20 data_in_real[12] net67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput21 data_in_real[13] net68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput22 data_in_real[14] net69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput23 data_in_real[15] net70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput24 data_in_real[1] net71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput25 data_in_real[2] net72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput26 data_in_real[3] net73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xinput27 data_in_real[4] net74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xinput28 data_in_real[5] net75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xinput29 data_in_real[6] net76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput30 data_in_real[7] net77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput31 data_in_real[8] net78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput32 data_in_real[9] net79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xinput33 data_valid_in net80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xinput34 rst_n net81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xinput35 start net82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xoutput36 net83 busy VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput37 net84 data_out_imag[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput38 net85 data_out_imag[100] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput39 net86 data_out_imag[101] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput40 net87 data_out_imag[102] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput41 net88 data_out_imag[103] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput42 net89 data_out_imag[104] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput43 net90 data_out_imag[105] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput44 net91 data_out_imag[106] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput45 net92 data_out_imag[107] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput46 net93 data_out_imag[108] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput47 net94 data_out_imag[109] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput48 net95 data_out_imag[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput49 net96 data_out_imag[110] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput50 net97 data_out_imag[111] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput51 net98 data_out_imag[112] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput52 net99 data_out_imag[113] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput53 net100 data_out_imag[114] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput54 net101 data_out_imag[115] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput55 net102 data_out_imag[116] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput56 net103 data_out_imag[117] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput57 net104 data_out_imag[118] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput58 net105 data_out_imag[119] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput59 net106 data_out_imag[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput60 net107 data_out_imag[120] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput61 net108 data_out_imag[121] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput62 net109 data_out_imag[122] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput63 net110 data_out_imag[123] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput64 net111 data_out_imag[124] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput65 net112 data_out_imag[125] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput66 net113 data_out_imag[126] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput67 net114 data_out_imag[127] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput68 net115 data_out_imag[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput69 net116 data_out_imag[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput70 net117 data_out_imag[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput71 net118 data_out_imag[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput72 net119 data_out_imag[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput73 net120 data_out_imag[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput74 net121 data_out_imag[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput75 net122 data_out_imag[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput76 net123 data_out_imag[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput77 net124 data_out_imag[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput78 net125 data_out_imag[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput79 net126 data_out_imag[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput80 net127 data_out_imag[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput81 net128 data_out_imag[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput82 net129 data_out_imag[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput83 net130 data_out_imag[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput84 net131 data_out_imag[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput85 net132 data_out_imag[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput86 net133 data_out_imag[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput87 net134 data_out_imag[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput88 net135 data_out_imag[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput89 net136 data_out_imag[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput90 net137 data_out_imag[32] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput91 net138 data_out_imag[33] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput92 net139 data_out_imag[34] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput93 net140 data_out_imag[35] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput94 net141 data_out_imag[36] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput95 net142 data_out_imag[37] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput96 net143 data_out_imag[38] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput97 net144 data_out_imag[39] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput98 net145 data_out_imag[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput99 net146 data_out_imag[40] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput100 net147 data_out_imag[41] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput101 net148 data_out_imag[42] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput102 net149 data_out_imag[43] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput103 net150 data_out_imag[44] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput104 net151 data_out_imag[45] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput105 net152 data_out_imag[46] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput106 net153 data_out_imag[47] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput107 net154 data_out_imag[48] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput108 net155 data_out_imag[49] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput109 net156 data_out_imag[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput110 net157 data_out_imag[50] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput111 net158 data_out_imag[51] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput112 net159 data_out_imag[52] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput113 net160 data_out_imag[53] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput114 net161 data_out_imag[54] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput115 net162 data_out_imag[55] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput116 net163 data_out_imag[56] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput117 net164 data_out_imag[57] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput118 net165 data_out_imag[58] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput119 net166 data_out_imag[59] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput120 net167 data_out_imag[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput121 net168 data_out_imag[60] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput122 net169 data_out_imag[61] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput123 net170 data_out_imag[62] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput124 net171 data_out_imag[63] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput125 net172 data_out_imag[64] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput126 net173 data_out_imag[65] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput127 net174 data_out_imag[66] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput128 net175 data_out_imag[67] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput129 net176 data_out_imag[68] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput130 net177 data_out_imag[69] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput131 net178 data_out_imag[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput132 net179 data_out_imag[70] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput133 net180 data_out_imag[71] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput134 net181 data_out_imag[72] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput135 net182 data_out_imag[73] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput136 net183 data_out_imag[74] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput137 net184 data_out_imag[75] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput138 net185 data_out_imag[76] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput139 net186 data_out_imag[77] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput140 net187 data_out_imag[78] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput141 net188 data_out_imag[79] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput142 net189 data_out_imag[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput143 net190 data_out_imag[80] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput144 net191 data_out_imag[81] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput145 net192 data_out_imag[82] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput146 net193 data_out_imag[83] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput147 net194 data_out_imag[84] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput148 net195 data_out_imag[85] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput149 net196 data_out_imag[86] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput150 net197 data_out_imag[87] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput151 net198 data_out_imag[88] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput152 net199 data_out_imag[89] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput153 net200 data_out_imag[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput154 net201 data_out_imag[90] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput155 net202 data_out_imag[91] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput156 net203 data_out_imag[92] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput157 net204 data_out_imag[93] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput158 net205 data_out_imag[94] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput159 net206 data_out_imag[95] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput160 net207 data_out_imag[96] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput161 net208 data_out_imag[97] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput162 net209 data_out_imag[98] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput163 net210 data_out_imag[99] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput164 net211 data_out_imag[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput165 net212 data_out_real[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput166 net213 data_out_real[100] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput167 net214 data_out_real[101] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput168 net215 data_out_real[102] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput169 net216 data_out_real[103] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput170 net217 data_out_real[104] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput171 net218 data_out_real[105] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput172 net219 data_out_real[106] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput173 net220 data_out_real[107] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput174 net221 data_out_real[108] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput175 net222 data_out_real[109] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput176 net223 data_out_real[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput177 net224 data_out_real[110] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput178 net225 data_out_real[111] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput179 net226 data_out_real[112] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput180 net227 data_out_real[113] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput181 net228 data_out_real[114] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput182 net229 data_out_real[115] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput183 net230 data_out_real[116] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput184 net231 data_out_real[117] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput185 net232 data_out_real[118] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput186 net233 data_out_real[119] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput187 net234 data_out_real[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput188 net235 data_out_real[120] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput189 net236 data_out_real[121] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput190 net237 data_out_real[122] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput191 net238 data_out_real[123] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput192 net239 data_out_real[124] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput193 net240 data_out_real[125] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput194 net241 data_out_real[126] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput195 net242 data_out_real[127] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput196 net243 data_out_real[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput197 net244 data_out_real[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput198 net245 data_out_real[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput199 net246 data_out_real[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput200 net247 data_out_real[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput201 net248 data_out_real[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput202 net249 data_out_real[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput203 net250 data_out_real[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput204 net251 data_out_real[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput205 net252 data_out_real[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput206 net253 data_out_real[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput207 net254 data_out_real[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput208 net255 data_out_real[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput209 net256 data_out_real[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput210 net257 data_out_real[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput211 net258 data_out_real[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput212 net259 data_out_real[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput213 net260 data_out_real[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput214 net261 data_out_real[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput215 net262 data_out_real[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput216 net263 data_out_real[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput217 net264 data_out_real[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput218 net265 data_out_real[32] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput219 net266 data_out_real[33] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput220 net267 data_out_real[34] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput221 net268 data_out_real[35] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput222 net269 data_out_real[36] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput223 net270 data_out_real[37] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput224 net271 data_out_real[38] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput225 net272 data_out_real[39] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput226 net273 data_out_real[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput227 net274 data_out_real[40] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput228 net275 data_out_real[41] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput229 net276 data_out_real[42] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput230 net277 data_out_real[43] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput231 net278 data_out_real[44] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput232 net279 data_out_real[45] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput233 net280 data_out_real[46] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput234 net281 data_out_real[47] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput235 net282 data_out_real[48] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput236 net283 data_out_real[49] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput237 net284 data_out_real[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput238 net285 data_out_real[50] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput239 net286 data_out_real[51] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput240 net287 data_out_real[52] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput241 net288 data_out_real[53] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput242 net289 data_out_real[54] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput243 net290 data_out_real[55] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput244 net291 data_out_real[56] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput245 net292 data_out_real[57] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput246 net293 data_out_real[58] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput247 net294 data_out_real[59] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput248 net295 data_out_real[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput249 net296 data_out_real[60] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput250 net297 data_out_real[61] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput251 net298 data_out_real[62] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput252 net299 data_out_real[63] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput253 net300 data_out_real[64] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput254 net301 data_out_real[65] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput255 net302 data_out_real[66] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput256 net303 data_out_real[67] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput257 net304 data_out_real[68] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput258 net305 data_out_real[69] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput259 net306 data_out_real[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput260 net307 data_out_real[70] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput261 net308 data_out_real[71] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput262 net309 data_out_real[72] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput263 net310 data_out_real[73] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput264 net311 data_out_real[74] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput265 net312 data_out_real[75] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput266 net313 data_out_real[76] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput267 net314 data_out_real[77] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput268 net315 data_out_real[78] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput269 net316 data_out_real[79] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput270 net317 data_out_real[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput271 net318 data_out_real[80] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput272 net319 data_out_real[81] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput273 net320 data_out_real[82] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput274 net321 data_out_real[83] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput275 net322 data_out_real[84] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput276 net323 data_out_real[85] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput277 net324 data_out_real[86] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput278 net325 data_out_real[87] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput279 net326 data_out_real[88] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput280 net327 data_out_real[89] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput281 net328 data_out_real[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput282 net329 data_out_real[90] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput283 net330 data_out_real[91] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput284 net331 data_out_real[92] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput285 net332 data_out_real[93] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput286 net333 data_out_real[94] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput287 net334 data_out_real[95] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput288 net335 data_out_real[96] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput289 net336 data_out_real[97] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput290 net337 data_out_real[98] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput291 net338 data_out_real[99] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput292 net339 data_out_real[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput293 net340 data_ready VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput294 net341 data_valid_out VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_15241__295 net342 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15245__296 net343 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15250__297 net344 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15252__298 net345 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15263__299 net346 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15270__300 net347 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15278__301 net348 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15285__302 net349 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15291__303 net350 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15299__304 net351 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15304__305 net352 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15313__306 net353 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15320__307 net354 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15327__308 net355 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15328__309 net356 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15336__310 net357 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15344__311 net358 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15352__312 net359 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15360__313 net360 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15368__314 net361 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15376__315 net362 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15383__316 net363 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15384__317 net364 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15392__318 net365 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15399__319 net366 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15410__320 net367 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_15415__321 net368 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
Xclkbuf_leaf_1_clk clknet_1_0__leaf_clk clknet_leaf_1_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_2_clk clknet_1_0__leaf_clk clknet_leaf_2_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_3_clk clknet_1_0__leaf_clk clknet_leaf_3_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_4_clk clknet_1_0__leaf_clk clknet_leaf_4_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_5_clk clknet_1_0__leaf_clk clknet_leaf_5_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_6_clk clknet_1_0__leaf_clk clknet_leaf_6_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_7_clk clknet_1_0__leaf_clk clknet_leaf_7_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_8_clk clknet_1_0__leaf_clk clknet_leaf_8_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_9_clk clknet_1_1__leaf_clk clknet_leaf_9_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_10_clk clknet_1_0__leaf_clk clknet_leaf_10_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_11_clk clknet_1_1__leaf_clk clknet_leaf_11_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_12_clk clknet_1_1__leaf_clk clknet_leaf_12_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_13_clk clknet_1_1__leaf_clk clknet_leaf_13_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_14_clk clknet_1_1__leaf_clk clknet_leaf_14_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_15_clk clknet_1_1__leaf_clk clknet_leaf_15_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_16_clk clknet_1_1__leaf_clk clknet_leaf_16_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_17_clk clknet_1_1__leaf_clk clknet_leaf_17_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_18_clk clknet_1_1__leaf_clk clknet_leaf_18_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_19_clk clknet_1_1__leaf_clk clknet_leaf_19_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_20_clk clknet_1_1__leaf_clk clknet_leaf_20_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_21_clk clknet_1_1__leaf_clk clknet_leaf_21_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload0 clknet_1_0__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_20
Xclkload1 clknet_leaf_0_clk _unconnected_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xclkload2 clknet_leaf_1_clk _unconnected_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload3 clknet_leaf_2_clk _unconnected_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkload4 clknet_leaf_3_clk _unconnected_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload5 clknet_leaf_4_clk _unconnected_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload6 clknet_leaf_5_clk _unconnected_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload7 clknet_leaf_6_clk _unconnected_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload8 clknet_leaf_7_clk _unconnected_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload9 clknet_leaf_8_clk _unconnected_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xclkload10 clknet_leaf_9_clk _unconnected_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xclkload11 clknet_leaf_11_clk _unconnected_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload12 clknet_leaf_12_clk _unconnected_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload13 clknet_leaf_13_clk _unconnected_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload14 clknet_leaf_14_clk _unconnected_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload15 clknet_leaf_15_clk _unconnected_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload16 clknet_leaf_16_clk _unconnected_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_12
Xclkload17 clknet_leaf_17_clk _unconnected_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkload18 clknet_leaf_18_clk _unconnected_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
Xclkload19 clknet_leaf_20_clk _unconnected_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload20 clknet_leaf_21_clk _unconnected_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_20
Xrebuffer1 _03430_ net370 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer2 _03430_ net371 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer3 net371 net372 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer4 _03106_ net373 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xrebuffer5 _03294_ net374 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer6 _03294_ net375 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer7 _03294_ net376 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer8 _03230_ net377 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer9 _03108_ net378 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer10 _07627_ net379 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer11 _03004_ net380 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer12 _03229_ net381 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer13 _07629_ net382 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer14 net394 net383 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xclone21 _02752_ _02842_ net384 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer23 _03212_ net386 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer24 _03126_ net387 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer25 _03305_ net388 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer26 _03124_ net389 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer27 net392 net390 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer31 net395 net394 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer32 net396 net395 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer33 _03231_ net396 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer15 _03004_ net385 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer16 _07629_ net391 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer17 net393 net392 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer18 net397 net393 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer19 net398 net397 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer20 net399 net398 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer21 net400 net399 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer22 _03293_ net400 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xrebuffer28 _03295_ net401 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
XANTENNA_1 net100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_2 net208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
.ENDS parameterized_fft
