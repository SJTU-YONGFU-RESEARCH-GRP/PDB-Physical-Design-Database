* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT piso_register clk load parallel_in[0] parallel_in[1]
+ parallel_in[2] parallel_in[3] parallel_in[4] parallel_in[5]
+ parallel_in[6] parallel_in[7] rst_n serial_out
X_09_ load VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_6
X_10_ shift_reg\[5\] net6 _08_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__mux2_1
X_11_ shift_reg\[6\] net7 _08_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__mux2_1
X_12_ shift_reg\[7\] net8 _08_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__mux2_1
X_13_ _08_ net9 VSS VSS VDD VDD _07_ sky130_fd_sc_hd__and2_0
X_14_ shift_reg\[1\] net2 _08_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__mux2_1
X_15_ shift_reg\[2\] net3 _08_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__mux2_1
X_16_ shift_reg\[3\] net4 _08_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__mux2_1
X_17_ shift_reg\[4\] net5 _08_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__mux2_1
Xshift_reg\[0\]$_DFF_PN0_ clknet_1_1__leaf_clk _00_ net1 VSS
+ VSS VDD VDD net10 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[1\]$_DFF_PN0_ clknet_1_1__leaf_clk _01_ net1 VSS
+ VSS VDD VDD shift_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[2\]$_DFF_PN0_ clknet_1_1__leaf_clk _02_ net1 VSS
+ VSS VDD VDD shift_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[3\]$_DFF_PN0_ clknet_1_1__leaf_clk _03_ net1 VSS
+ VSS VDD VDD shift_reg\[3\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[4\]$_DFF_PN0_ clknet_1_0__leaf_clk _04_ net1 VSS
+ VSS VDD VDD shift_reg\[4\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[5\]$_DFF_PN0_ clknet_1_0__leaf_clk _05_ net1 VSS
+ VSS VDD VDD shift_reg\[5\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[6\]$_DFF_PN0_ clknet_1_0__leaf_clk _06_ net1 VSS
+ VSS VDD VDD shift_reg\[6\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[7\]$_DFF_PN0_ clknet_1_0__leaf_clk _07_ net1 VSS
+ VSS VDD VDD shift_reg\[7\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net11 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 parallel_in[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 parallel_in[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 parallel_in[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 parallel_in[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 parallel_in[4] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 parallel_in[5] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 parallel_in[6] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 parallel_in[7] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xoutput9 net10 VSS VSS VDD VDD serial_out sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xhold2 rst_n VSS VSS VDD VDD net11 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS piso_register
