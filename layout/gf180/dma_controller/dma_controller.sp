* cell dma_controller
* pin channel_length[14]
* pin channel_length[15]
* pin channel_length[13]
* pin channel_length[12]
* pin channel_length[11]
* pin channel_length[8]
* pin channel_length[9]
* pin channel_length[10]
* pin channel_length[7]
* pin channel_length[0]
* pin channel_length[6]
* pin channel_length[1]
* pin rst_n
* pin channel_length[5]
* pin channel_length[4]
* pin channel_length[3]
* pin channel_length[2]
* pin debug_active_channels[0]
* pin channel_length[67]
* pin channel_length[65]
* pin channel_length[64]
* pin channel_length[66]
* pin channel_length[69]
* pin channel_length[68]
* pin channel_length[70]
* pin channel_length[71]
* pin channel_length[73]
* pin channel_length[72]
* pin channel_start[2]
* pin dst_wready[2]
* pin channel_length[74]
* pin channel_error[2]
* pin channel_length[79]
* pin channel_length[78]
* pin channel_length[75]
* pin channel_length[77]
* pin dst_write[1]
* pin channel_length[76]
* pin channel_done[2]
* pin channel_busy[2]
* pin dst_write[2]
* pin channel_length[59]
* pin channel_length[58]
* pin channel_length[61]
* pin channel_length[60]
* pin channel_length[63]
* pin channel_length[62]
* pin channel_length[95]
* pin channel_length[87]
* pin channel_length[86]
* pin channel_length[81]
* pin channel_length[83]
* pin channel_length[80]
* pin channel_length[82]
* pin channel_length[85]
* pin channel_length[84]
* pin channel_length[22]
* pin channel_length[23]
* pin channel_length[21]
* pin channel_length[25]
* pin src_addr[97]
* pin channel_length[24]
* pin src_addr[84]
* pin channel_length[94]
* pin src_addr[90]
* pin src_addr[86]
* pin channel_length[93]
* pin src_addr[9]
* pin clk
* pin channel_length[26]
* pin channel_length[27]
* pin channel_length[31]
* pin channel_length[88]
* pin src_addr[80]
* pin src_addr[96]
* pin src_rvalid[2]
* pin src_addr[67]
* pin src_addr[73]
* pin src_addr[94]
* pin src_addr[91]
* pin src_addr[85]
* pin debug_active_channels[1]
* pin channel_length[29]
* pin src_rready[2]
* pin channel_length[28]
* pin channel_length[30]
* pin channel_length[90]
* pin channel_length[89]
* pin src_addr[70]
* pin src_addr[74]
* pin src_addr[78]
* pin src_addr[69]
* pin src_addr[82]
* pin src_addr[47]
* pin channel_length[17]
* pin src_addr[56]
* pin src_addr[40]
* pin src_addr[55]
* pin src_addr[66]
* pin src_addr[59]
* pin channel_length[92]
* pin channel_length[91]
* pin channel_enable[2]
* pin src_addr[4]
* pin dst_addr[92]
* pin src_addr[45]
* pin src_addr[43]
* pin debug_active_channels[2]
* pin debug_has_active_channels
* pin src_addr[30]
* pin src_addr[115]
* pin src_addr[3]
* pin src_addr[37]
* pin src_addr[26]
* pin src_addr[2]
* pin src_addr[1]
* pin channel_length[16]
* pin dst_wready[0]
* pin dst_wstrb[4]
* pin src_addr[104]
* pin src_addr[16]
* pin src_addr[12]
* pin src_addr[102]
* pin src_addr[103]
* pin src_read[2]
* pin dst_write[0]
* pin channel_busy[0]
* pin src_addr[0]
* pin dst_wstrb[1]
* pin dst_wstrb[5]
* pin debug_active_channels[3]
* pin channel_length[20]
* pin dst_wstrb[14]
* pin dst_wstrb[11]
* pin dst_wstrb[13]
* pin dst_wdata[99]
* pin dst_wstrb[10]
* pin channel_error[1]
* pin channel_enable[0]
* pin src_read[1]
* pin channel_length[18]
* pin channel_length[19]
* pin dst_wdata[89]
* pin dst_wdata[92]
* pin dst_wdata[98]
* pin dst_wdata[85]
* pin dst_wdata[7]
* pin dst_wdata[77]
* pin dst_wdata[81]
* pin dst_wdata[83]
* pin channel_start[0]
* pin src_rvalid[0]
* pin src_rready[0]
* pin channel_enable[1]
* pin dst_wdata[62]
* pin dst_wdata[4]
* pin dst_wdata[70]
* pin dst_wdata[60]
* pin dst_wdata[61]
* pin dst_wdata[68]
* pin dst_wdata[55]
* pin dst_wdata[49]
* pin dst_wdata[5]
* pin src_rready[1]
* pin dst_wdata[37]
* pin dst_wdata[47]
* pin src_rvalid[1]
* pin src_rready[3]
* pin dst_wdata[23]
* pin dst_wdata[25]
* pin dst_wdata[2]
* pin dst_wdata[26]
* pin src_read[3]
* pin dst_wdata[122]
* pin dst_wdata[14]
* pin dst_wdata[21]
* pin dst_wdata[118]
* pin src_read[0]
* pin channel_done[0]
* pin dst_wdata[109]
* pin dst_wdata[106]
* pin dst_wdata[107]
* pin dst_wdata[114]
* pin channel_error[0]
* pin dst_wdata[100]
* pin dst_wdata[102]
* pin dst_wdata[103]
* pin dst_wdata[101]
* pin dst_wready[1]
* pin src_rvalid[3]
* pin channel_enable[3]
* pin channel_length[37]
* pin dst_addr[94]
* pin dst_addr[97]
* pin channel_length[39]
* pin channel_length[50]
* pin dst_wdata[0]
* pin channel_start[1]
* pin debug_transfer_count[97]
* pin debug_transfer_count[83]
* pin debug_channel_state[6]
* pin channel_length[36]
* pin dst_addr[103]
* pin dst_addr[19]
* pin channel_length[51]
* pin debug_transfer_count[95]
* pin dst_addr[109]
* pin debug_transfer_count[120]
* pin channel_length[57]
* pin channel_length[53]
* pin channel_length[106]
* pin channel_length[104]
* pin dst_addr[46]
* pin dst_addr[28]
* pin channel_length[56]
* pin channel_length[105]
* pin dst_addr[68]
* pin debug_transfer_count[61]
* pin debug_transfer_count[75]
* pin debug_transfer_count[77]
* pin channel_done[1]
* pin channel_busy[1]
* pin debug_transfer_count[105]
* pin channel_length[52]
* pin dst_addr[3]
* pin channel_length[55]
* pin debug_transfer_count[25]
* pin channel_start[3]
* pin channel_length[101]
* pin debug_transfer_count[23]
* pin channel_length[54]
* pin debug_transfer_count[37]
* pin debug_transfer_count[24]
* pin dst_addr[101]
* pin debug_channel_state[3]
* pin debug_transfer_count[110]
* pin debug_transfer_count[65]
* pin debug_transfer_count[67]
* pin channel_length[102]
* pin channel_length[109]
* pin dst_wready[3]
* pin dst_addr[79]
* pin channel_length[49]
* pin channel_length[48]
* pin channel_length[107]
* pin channel_length[110]
* pin channel_length[100]
* pin channel_length[108]
* pin channel_length[103]
* pin channel_length[38]
* pin dst_addr[24]
* pin dst_addr[112]
* pin debug_transfer_count[126]
* pin dst_addr[59]
* pin dst_addr[75]
* pin channel_length[111]
* pin debug_channel_state[8]
* pin dst_addr[70]
* pin debug_transfer_count[92]
* pin debug_transfer_count[119]
* pin debug_transfer_count[90]
* pin dst_addr[32]
* pin debug_transfer_count[53]
* pin debug_transfer_count[121]
* pin debug_transfer_count[56]
* pin dst_addr[87]
* pin debug_transfer_count[62]
* pin debug_transfer_count[102]
* pin dst_addr[57]
* pin dst_addr[113]
* pin dst_addr[50]
* pin debug_transfer_count[100]
* pin dst_addr[108]
* pin dst_addr[124]
* pin debug_transfer_count[9]
* pin debug_transfer_count[101]
* pin dst_addr[121]
* pin dst_addr[52]
* pin dst_addr[14]
* pin dst_addr[102]
* pin debug_transfer_count[10]
* pin debug_transfer_count[63]
* pin dst_addr[64]
* pin dst_addr[31]
* pin dst_addr[34]
* pin channel_length[99]
* pin dst_addr[63]
* pin debug_transfer_count[33]
* pin debug_transfer_count[103]
* pin debug_transfer_count[39]
* pin dst_addr[82]
* pin debug_transfer_count[123]
* pin channel_length[98]
* pin debug_transfer_count[112]
* pin dst_addr[20]
* pin debug_transfer_count[89]
* pin debug_transfer_count[104]
* pin dst_addr[7]
* pin dst_addr[77]
* pin dst_addr[86]
* pin dst_addr[89]
* pin dst_addr[56]
* pin channel_length[96]
* pin dst_addr[67]
* pin debug_transfer_count[127]
* pin debug_transfer_count[87]
* pin channel_length[97]
* pin debug_transfer_count[109]
* pin debug_transfer_count[13]
* pin debug_transfer_count[70]
* pin dst_addr[66]
* pin debug_transfer_count[26]
* pin dst_addr[44]
* pin dst_addr[105]
* pin debug_transfer_count[117]
* pin dst_addr[72]
* pin debug_channel_state[1]
* pin debug_transfer_count[40]
* pin dst_addr[18]
* pin dst_addr[123]
* pin dst_addr[17]
* pin dst_addr[49]
* pin debug_transfer_count[60]
* pin debug_transfer_count[116]
* pin debug_transfer_count[106]
* pin debug_transfer_count[30]
* pin dst_addr[2]
* pin dst_addr[35]
* pin debug_channel_state[9]
* pin debug_transfer_count[14]
* pin dst_addr[116]
* pin debug_transfer_count[15]
* pin debug_transfer_count[72]
* pin dst_addr[12]
* pin debug_transfer_count[38]
* pin dst_addr[88]
* pin debug_transfer_count[68]
* pin dst_addr[53]
* pin dst_addr[41]
* pin dst_addr[4]
* pin dst_addr[54]
* pin debug_transfer_count[20]
* pin debug_transfer_count[21]
* pin dst_addr[27]
* pin channel_length[119]
* pin dst_addr[38]
* pin debug_transfer_count[122]
* pin debug_transfer_count[6]
* pin dst_addr[127]
* pin debug_transfer_count[107]
* pin debug_transfer_count[91]
* pin channel_length[118]
* pin channel_length[120]
* pin channel_length[122]
* pin debug_transfer_count[29]
* pin dst_addr[37]
* pin dst_addr[111]
* pin debug_transfer_count[58]
* pin channel_length[121]
* pin dst_addr[42]
* pin dst_addr[55]
* pin dst_addr[40]
* pin debug_transfer_count[88]
* pin debug_transfer_count[124]
* pin debug_transfer_count[4]
* pin dst_addr[85]
* pin debug_transfer_count[80]
* pin channel_length[123]
* pin debug_transfer_count[82]
* pin dst_addr[125]
* pin debug_transfer_count[41]
* pin dst_addr[6]
* pin debug_transfer_count[52]
* pin dst_addr[83]
* pin debug_transfer_count[79]
* pin debug_transfer_count[85]
* pin debug_transfer_count[31]
* pin dst_addr[60]
* pin debug_transfer_count[98]
* pin debug_transfer_count[43]
* pin dst_addr[30]
* pin debug_transfer_count[69]
* pin dst_addr[119]
* pin dst_addr[65]
* pin dst_addr[48]
* pin debug_transfer_count[12]
* pin dst_addr[1]
* pin dst_addr[51]
* pin dst_addr[11]
* pin dst_addr[29]
* pin dst_addr[76]
* pin debug_transfer_count[118]
* pin debug_transfer_count[64]
* pin dst_addr[80]
* pin dst_addr[16]
* pin debug_transfer_count[51]
* pin debug_transfer_count[74]
* pin dst_addr[15]
* pin dst_addr[122]
* pin debug_transfer_count[1]
* pin debug_channel_state[11]
* pin debug_transfer_count[99]
* pin dst_addr[120]
* pin debug_transfer_count[71]
* pin dst_addr[45]
* pin dst_addr[61]
* pin debug_transfer_count[78]
* pin dst_addr[5]
* pin debug_transfer_count[59]
* pin dst_addr[10]
* pin debug_transfer_count[45]
* pin dst_addr[13]
* pin debug_transfer_count[93]
* pin debug_transfer_count[16]
* pin debug_transfer_count[81]
* pin dst_addr[118]
* pin src_addr[54]
* pin dst_wdata[9]
* pin dst_wdata[75]
* pin src_addr[10]
* pin dst_wstrb[3]
* pin debug_transfer_count[46]
* pin dst_addr[43]
* pin dst_addr[33]
* pin dst_addr[22]
* pin dst_addr[91]
* pin dst_wdata[34]
* pin dst_addr[21]
* pin src_addr[101]
* pin debug_transfer_count[111]
* pin src_addr[53]
* pin dst_wdata[82]
* pin dst_wdata[58]
* pin dst_wdata[120]
* pin dst_addr[9]
* pin src_addr[116]
* pin dst_wdata[65]
* pin src_addr[57]
* pin dst_wdata[104]
* pin src_addr[110]
* pin dst_wdata[19]
* pin src_addr[33]
* pin dst_wstrb[9]
* pin dst_wdata[53]
* pin dst_addr[39]
* pin dst_addr[69]
* pin dst_wdata[44]
* pin dst_wstrb[8]
* pin debug_transfer_count[11]
* pin src_addr[24]
* pin src_addr[21]
* pin dst_addr[93]
* pin src_addr[64]
* pin src_addr[108]
* pin src_addr[126]
* pin dst_addr[47]
* pin debug_transfer_count[115]
* pin dst_wdata[125]
* pin dst_wdata[88]
* pin dst_wdata[73]
* pin dst_addr[36]
* pin dst_wdata[95]
* pin dst_wdata[35]
* pin dst_wdata[90]
* pin debug_transfer_count[49]
* pin dst_wdata[59]
* pin dst_wdata[84]
* pin src_addr[25]
* pin dst_wdata[38]
* pin dst_wdata[105]
* pin dst_wdata[111]
* pin dst_wdata[39]
* pin src_addr[50]
* pin debug_transfer_count[113]
* pin src_addr[122]
* pin debug_transfer_count[3]
* pin debug_transfer_count[36]
* pin dst_wdata[108]
* pin debug_transfer_count[7]
* pin dst_wdata[12]
* pin dst_wdata[3]
* pin src_addr[14]
* pin debug_transfer_count[47]
* pin dst_wdata[24]
* pin dst_wdata[119]
* pin src_addr[118]
* pin debug_transfer_count[19]
* pin src_addr[34]
* pin dst_wdata[17]
* pin src_addr[109]
* pin dst_addr[74]
* pin dst_wdata[56]
* pin dst_wdata[64]
* pin debug_transfer_count[18]
* pin src_addr[105]
* pin debug_transfer_count[54]
* pin dst_wdata[123]
* pin dst_wdata[1]
* pin src_addr[38]
* pin dst_addr[26]
* pin debug_transfer_count[34]
* pin dst_addr[104]
* pin dst_wdata[121]
* pin dst_wdata[46]
* pin dst_wdata[74]
* pin debug_transfer_count[108]
* pin debug_transfer_count[28]
* pin src_addr[36]
* pin dst_addr[106]
* pin debug_transfer_count[8]
* pin dst_wdata[57]
* pin dst_addr[25]
* pin src_addr[51]
* pin debug_channel_state[7]
* pin debug_transfer_count[125]
* pin dst_addr[95]
* pin src_addr[106]
* pin debug_transfer_count[27]
* pin dst_wdata[115]
* pin debug_channel_state[4]
* pin dst_addr[96]
* pin dst_wdata[42]
* pin dst_wdata[78]
* pin src_addr[107]
* pin dst_wdata[15]
* pin debug_channel_state[0]
* pin src_addr[17]
* pin dst_wdata[51]
* pin dst_wstrb[7]
* pin src_addr[22]
* pin dst_wdata[30]
* pin debug_transfer_count[50]
* pin dst_addr[23]
* pin dst_wstrb[0]
* pin src_addr[29]
* pin dst_wdata[67]
* pin dst_addr[8]
* pin dst_wdata[50]
* pin dst_wdata[41]
* pin dst_wdata[80]
* pin dst_wdata[33]
* pin dst_wdata[31]
* pin src_addr[20]
* pin src_addr[60]
* pin dst_addr[58]
* pin src_addr[100]
* pin debug_channel_state[2]
* pin dst_addr[99]
* pin debug_transfer_count[66]
* pin dst_wdata[124]
* pin dst_wdata[127]
* pin src_addr[68]
* pin dst_wdata[96]
* pin src_addr[48]
* pin dst_wstrb[2]
* pin src_addr[121]
* pin dst_addr[117]
* pin dst_wdata[97]
* pin dst_wdata[117]
* pin src_addr[111]
* pin dst_wdata[79]
* pin src_addr[61]
* pin dst_addr[115]
* pin dst_wdata[36]
* pin dst_wdata[27]
* pin debug_transfer_count[0]
* pin dst_wdata[91]
* pin dst_addr[100]
* pin src_addr[46]
* pin dst_wdata[18]
* pin dst_wdata[86]
* pin debug_transfer_count[114]
* pin dst_addr[84]
* pin src_addr[117]
* pin src_addr[6]
* pin src_addr[35]
* pin debug_transfer_count[42]
* pin debug_transfer_count[94]
* pin dst_wdata[28]
* pin debug_channel_state[5]
* pin dst_wdata[94]
* pin dst_wdata[76]
* pin src_addr[39]
* pin dst_wdata[11]
* pin src_addr[65]
* pin dst_wdata[93]
* pin debug_transfer_count[22]
* pin debug_transfer_count[2]
* pin src_addr[19]
* pin dst_wstrb[6]
* pin debug_transfer_count[73]
* pin dst_wdata[43]
* pin src_addr[28]
* pin dst_addr[98]
* pin src_addr[11]
* pin dst_wdata[6]
* pin src_addr[15]
* pin dst_wdata[66]
* pin src_addr[5]
* pin dst_addr[107]
* pin debug_transfer_count[32]
* pin src_addr[112]
* pin dst_wdata[20]
* pin debug_transfer_count[84]
* pin dst_addr[114]
* pin src_addr[52]
* pin dst_wdata[54]
* pin src_addr[114]
* pin debug_transfer_count[44]
* pin dst_addr[81]
* pin src_addr[119]
* pin src_addr[41]
* pin debug_transfer_count[48]
* pin debug_transfer_count[96]
* pin debug_transfer_count[86]
* pin src_addr[49]
* pin src_addr[31]
* pin src_addr[124]
* pin dst_wstrb[15]
* pin dst_wdata[10]
* pin dst_addr[78]
* pin dst_addr[90]
* pin src_addr[27]
* pin src_addr[89]
* pin debug_channel_state[10]
* pin src_addr[88]
* pin dst_wdata[63]
* pin src_addr[120]
* pin src_addr[127]
* pin dst_wdata[8]
* pin src_addr[13]
* pin src_addr[123]
* pin debug_transfer_count[57]
* pin src_addr[23]
* pin dst_wdata[45]
* pin debug_transfer_count[76]
* pin src_addr[125]
* pin dst_wdata[116]
* pin src_addr[62]
* pin dst_wdata[113]
* pin src_addr[32]
* pin dst_wdata[110]
* pin dst_addr[0]
* pin dst_wstrb[12]
* pin dst_wdata[112]
* pin src_addr[71]
* pin src_addr[81]
* pin src_addr[76]
* pin src_addr[7]
* pin src_addr[75]
* pin dst_addr[126]
* pin src_addr[44]
* pin src_addr[58]
* pin src_addr[93]
* pin dst_wdata[22]
* pin src_addr[98]
* pin debug_transfer_count[55]
* pin dst_addr[73]
* pin src_addr[77]
* pin src_addr[83]
* pin src_addr[8]
* pin channel_length[114]
* pin channel_done[3]
* pin src_addr[87]
* pin channel_length[46]
* pin channel_length[43]
* pin debug_transfer_count[35]
* pin src_addr[95]
* pin src_addr[99]
* pin dst_addr[110]
* pin src_addr[18]
* pin dst_wdata[69]
* pin src_addr[92]
* pin dst_wdata[72]
* pin src_addr[42]
* pin dst_wdata[40]
* pin dst_wdata[52]
* pin src_addr[113]
* pin dst_wdata[71]
* pin dst_addr[62]
* pin dst_wdata[87]
* pin dst_wdata[32]
* pin channel_length[125]
* pin channel_length[124]
* pin channel_length[126]
* pin channel_length[127]
* pin channel_length[116]
* pin channel_length[115]
* pin channel_length[117]
* pin channel_busy[3]
* pin channel_length[112]
* pin channel_length[113]
* pin dst_write[3]
* pin channel_error[3]
* pin channel_length[47]
* pin channel_length[44]
* pin channel_length[41]
* pin channel_length[45]
* pin channel_length[42]
* pin channel_length[40]
* pin channel_length[33]
* pin channel_length[35]
* pin channel_length[32]
* pin channel_length[34]
* pin debug_transfer_count[17]
* pin dst_wdata[16]
* pin debug_transfer_count[5]
* pin dst_wdata[13]
* pin dst_wdata[29]
* pin dst_wdata[48]
* pin dst_wdata[126]
* pin dst_addr[71]
* pin src_addr[63]
* pin src_addr[72]
* pin src_addr[79]
* pin NWELL
* pin PWELL,gf180mcu_gnd
.SUBCKT dma_controller 1 2 3 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 23 24 25
+ 26 27 29 30 31 32 33 35 38 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56
+ 57 58 59 60 61 62 63 64 65 765 766 784 801 819 828 836 838 839 840 843 844
+ 850 851 852 853 867 868 870 876 889 890 891 892 893 901 902 903 904 905 910
+ 911 912 913 914 915 916 924 927 935 936 937 938 939 940 941 942 956 957 958
+ 959 966 967 979 982 984 985 986 987 990 992 993 1007 1008 1010 1011 1012 1013
+ 1016 1017 1018 1030 1031 1032 1036 1037 1050 1051 1053 1054 1055 1058 1059
+ 1060 1061 1062 1078 1079 1080 1081 1099 1100 1101 1102 1110 1111 1112 1114
+ 1123 1128 1129 1130 1131 1132 1145 1146 1147 1153 1168 1169 1178 1179 1202
+ 1203 1204 1205 1211 1227 1228 1229 1230 1236 1237 1255 1256 1257 1258 1264
+ 1281 1282 1283 1284 1290 1291 1292 1307 1310 1311 1312 1313 1314 1322 1340
+ 1341 1342 1343 1344 1374 1375 1400 1401 1402 1403 1404 1414 1415 1428 1431
+ 1432 1444 1452 1453 1454 1455 1466 1467 1475 1478 1479 1480 1481 1488 1489
+ 1507 1508 1509 1510 1511 1536 1538 1539 1540 1549 1550 1551 1574 1576 1577
+ 1598 1599 1600 1601 1602 1614 1615 1616 1617 1618 1621 1630 1651 1653 1654
+ 1655 1656 1677 1679 1680 1681 1682 1683 1709 1711 1712 1713 1717 1746 1747
+ 1749 1776 1777 1778 1803 1805 1806 1807 1808 1809 1810 1818 1831 1833 1834
+ 1835 1836 1837 1842 1865 1868 1869 1870 1890 1891 1892 1893 1897 1900 1922
+ 1923 1924 1929 1944 1946 1947 1948 1949 1983 1984 1985 1986 1987 2010 2013
+ 2015 2016 2017 2018 2019 2041 2042 2064 2066 2067 2068 2069 2070 2071 2084
+ 2086 2087 2088 2115 2116 2117 2118 2119 2120 2121 2128 2142 2145 2146 2148
+ 2149 2150 2159 2160 2161 2182 2184 2185 2186 2200 2216 2217 2219 2220 2221
+ 2222 2223 2226 2236 2247 2255 2256 2257 2258 2278 2280 2281 2282 2283 2284
+ 2285 2286 2302 2303 2304 2305 2317 2320 2325 2326 2327 2328 2329 2330 2342
+ 2343 2344 2345 2346 2347 2369 2370 2373 2374 2375 2376 2377 2378 2387 2391
+ 2392 2395 2396 2397 2398 2399 2412 2415 2416 2417 2418 2419 2420 2421 2422
+ 2423 2424 2425 2426 2432 2440 2441 2444 2445 2446 2447 2448 2449 2453 2456
+ 2457 2458 2461 2462 2463 2464 2465 2466 2467 2471 2472 2484 2485 2486 2487
+ 2488 2489 2490 2491 2492 2498 2502 2505 2506 2507 2508 2509 2510 2511 2512
+ 2524 2528 2529 2530 2531 2532 2533 2534 2535 2536 2537 2538 2539 2541 2546
+ 2547 2551 2552 2554 2555 2556 2557 2560 2565 2569 2572 2573 2574 2575 2576
+ 2577 2578 2581 2584 2586 2589 2590 2591 2592 2593 2594 2595 2600 2605 2606
+ 2609 2610 2611 2612 2613 2614 2615 2626 2627 2628 2629 2630 2631 2632 2633
+ 2634 2635 2640 2645 2648 2649 2650 2651 2652 2653 2654 2655 2666 2670 2671
+ 2672 2673 2674 2675 2676 2677 2678 2679 2680 2686 2688 2691 2692 2693 2694
+ 2695 2696 2697 2698 2704 2706 2712 2716 2717 2718 2719 2720 2721 2722 2723
+ 2724 2733 2734 2735 2736 2737 2738 2739 2740 2741 2742 2743 2749 2755 2758
+ 2759 2760 2761 2762 2763 2764 2765 2774 2775 2776 2777 2778 2779 2780 2781
+ 2782 2783 2784 2785 2794 2796 2799 2800 2801 2802 2803 2804 2805 2806 2807
+ 2808 2812 2815 2826 2828 2829 2830 2833 2834 2839 2843 2848 2850 2851 2858
+ 2859 2861 2862 2863 2864 2865 2866 2867 2870 2876 2878 2880 2886 2887 2888
+ 2890 2892 2894 2895 2896 2897 2898 2899 2900 2912 2915 2916 2917 2918 2919
+ 2920 2921 2923 2926 2927 2928 2929 2930 2931 2932 2933 2935 2936 2937 2938
+ 2939 2940 2941 2943 2944 2945 2946 2947 2948 2949 2950 2951 2952 2953 2954
+ 2955 2956 2957 2958 2959 2960 2961 2962 2963 2964 2965 2966 2968 2969 2971
+ 2972 2973 2974 2975 2977 2978 2984 2985
* net 1 channel_length[14]
* net 2 channel_length[15]
* net 3 channel_length[13]
* net 7 channel_length[12]
* net 8 channel_length[11]
* net 9 channel_length[8]
* net 10 channel_length[9]
* net 11 channel_length[10]
* net 12 channel_length[7]
* net 13 channel_length[0]
* net 14 channel_length[6]
* net 15 channel_length[1]
* net 16 rst_n
* net 17 channel_length[5]
* net 18 channel_length[4]
* net 19 channel_length[3]
* net 20 channel_length[2]
* net 21 debug_active_channels[0]
* net 23 channel_length[67]
* net 24 channel_length[65]
* net 25 channel_length[64]
* net 26 channel_length[66]
* net 27 channel_length[69]
* net 29 channel_length[68]
* net 30 channel_length[70]
* net 31 channel_length[71]
* net 32 channel_length[73]
* net 33 channel_length[72]
* net 35 channel_start[2]
* net 38 dst_wready[2]
* net 40 channel_length[74]
* net 41 channel_error[2]
* net 42 channel_length[79]
* net 43 channel_length[78]
* net 44 channel_length[75]
* net 45 channel_length[77]
* net 46 dst_write[1]
* net 47 channel_length[76]
* net 48 channel_done[2]
* net 49 channel_busy[2]
* net 50 dst_write[2]
* net 51 channel_length[59]
* net 52 channel_length[58]
* net 53 channel_length[61]
* net 54 channel_length[60]
* net 55 channel_length[63]
* net 56 channel_length[62]
* net 57 channel_length[95]
* net 58 channel_length[87]
* net 59 channel_length[86]
* net 60 channel_length[81]
* net 61 channel_length[83]
* net 62 channel_length[80]
* net 63 channel_length[82]
* net 64 channel_length[85]
* net 65 channel_length[84]
* net 765 channel_length[22]
* net 766 channel_length[23]
* net 784 channel_length[21]
* net 801 channel_length[25]
* net 819 src_addr[97]
* net 828 channel_length[24]
* net 836 src_addr[84]
* net 838 channel_length[94]
* net 839 src_addr[90]
* net 840 src_addr[86]
* net 843 channel_length[93]
* net 844 src_addr[9]
* net 850 clk
* net 851 channel_length[26]
* net 852 channel_length[27]
* net 853 channel_length[31]
* net 867 channel_length[88]
* net 868 src_addr[80]
* net 870 src_addr[96]
* net 876 src_rvalid[2]
* net 889 src_addr[67]
* net 890 src_addr[73]
* net 891 src_addr[94]
* net 892 src_addr[91]
* net 893 src_addr[85]
* net 901 debug_active_channels[1]
* net 902 channel_length[29]
* net 903 src_rready[2]
* net 904 channel_length[28]
* net 905 channel_length[30]
* net 910 channel_length[90]
* net 911 channel_length[89]
* net 912 src_addr[70]
* net 913 src_addr[74]
* net 914 src_addr[78]
* net 915 src_addr[69]
* net 916 src_addr[82]
* net 924 src_addr[47]
* net 927 channel_length[17]
* net 935 src_addr[56]
* net 936 src_addr[40]
* net 937 src_addr[55]
* net 938 src_addr[66]
* net 939 src_addr[59]
* net 940 channel_length[92]
* net 941 channel_length[91]
* net 942 channel_enable[2]
* net 956 src_addr[4]
* net 957 dst_addr[92]
* net 958 src_addr[45]
* net 959 src_addr[43]
* net 966 debug_active_channels[2]
* net 967 debug_has_active_channels
* net 979 src_addr[30]
* net 982 src_addr[115]
* net 984 src_addr[3]
* net 985 src_addr[37]
* net 986 src_addr[26]
* net 987 src_addr[2]
* net 990 src_addr[1]
* net 992 channel_length[16]
* net 993 dst_wready[0]
* net 1007 dst_wstrb[4]
* net 1008 src_addr[104]
* net 1010 src_addr[16]
* net 1011 src_addr[12]
* net 1012 src_addr[102]
* net 1013 src_addr[103]
* net 1016 src_read[2]
* net 1017 dst_write[0]
* net 1018 channel_busy[0]
* net 1030 src_addr[0]
* net 1031 dst_wstrb[1]
* net 1032 dst_wstrb[5]
* net 1036 debug_active_channels[3]
* net 1037 channel_length[20]
* net 1050 dst_wstrb[14]
* net 1051 dst_wstrb[11]
* net 1053 dst_wstrb[13]
* net 1054 dst_wdata[99]
* net 1055 dst_wstrb[10]
* net 1058 channel_error[1]
* net 1059 channel_enable[0]
* net 1060 src_read[1]
* net 1061 channel_length[18]
* net 1062 channel_length[19]
* net 1078 dst_wdata[89]
* net 1079 dst_wdata[92]
* net 1080 dst_wdata[98]
* net 1081 dst_wdata[85]
* net 1099 dst_wdata[7]
* net 1100 dst_wdata[77]
* net 1101 dst_wdata[81]
* net 1102 dst_wdata[83]
* net 1110 channel_start[0]
* net 1111 src_rvalid[0]
* net 1112 src_rready[0]
* net 1114 channel_enable[1]
* net 1123 dst_wdata[62]
* net 1128 dst_wdata[4]
* net 1129 dst_wdata[70]
* net 1130 dst_wdata[60]
* net 1131 dst_wdata[61]
* net 1132 dst_wdata[68]
* net 1145 dst_wdata[55]
* net 1146 dst_wdata[49]
* net 1147 dst_wdata[5]
* net 1153 src_rready[1]
* net 1168 dst_wdata[37]
* net 1169 dst_wdata[47]
* net 1178 src_rvalid[1]
* net 1179 src_rready[3]
* net 1202 dst_wdata[23]
* net 1203 dst_wdata[25]
* net 1204 dst_wdata[2]
* net 1205 dst_wdata[26]
* net 1211 src_read[3]
* net 1227 dst_wdata[122]
* net 1228 dst_wdata[14]
* net 1229 dst_wdata[21]
* net 1230 dst_wdata[118]
* net 1236 src_read[0]
* net 1237 channel_done[0]
* net 1255 dst_wdata[109]
* net 1256 dst_wdata[106]
* net 1257 dst_wdata[107]
* net 1258 dst_wdata[114]
* net 1264 channel_error[0]
* net 1281 dst_wdata[100]
* net 1282 dst_wdata[102]
* net 1283 dst_wdata[103]
* net 1284 dst_wdata[101]
* net 1290 dst_wready[1]
* net 1291 src_rvalid[3]
* net 1292 channel_enable[3]
* net 1307 channel_length[37]
* net 1310 dst_addr[94]
* net 1311 dst_addr[97]
* net 1312 channel_length[39]
* net 1313 channel_length[50]
* net 1314 dst_wdata[0]
* net 1322 channel_start[1]
* net 1340 debug_transfer_count[97]
* net 1341 debug_transfer_count[83]
* net 1342 debug_channel_state[6]
* net 1343 channel_length[36]
* net 1344 dst_addr[103]
* net 1374 dst_addr[19]
* net 1375 channel_length[51]
* net 1400 debug_transfer_count[95]
* net 1401 dst_addr[109]
* net 1402 debug_transfer_count[120]
* net 1403 channel_length[57]
* net 1404 channel_length[53]
* net 1414 channel_length[106]
* net 1415 channel_length[104]
* net 1428 dst_addr[46]
* net 1431 dst_addr[28]
* net 1432 channel_length[56]
* net 1444 channel_length[105]
* net 1452 dst_addr[68]
* net 1453 debug_transfer_count[61]
* net 1454 debug_transfer_count[75]
* net 1455 debug_transfer_count[77]
* net 1466 channel_done[1]
* net 1467 channel_busy[1]
* net 1475 debug_transfer_count[105]
* net 1478 channel_length[52]
* net 1479 dst_addr[3]
* net 1480 channel_length[55]
* net 1481 debug_transfer_count[25]
* net 1488 channel_start[3]
* net 1489 channel_length[101]
* net 1507 debug_transfer_count[23]
* net 1508 channel_length[54]
* net 1509 debug_transfer_count[37]
* net 1510 debug_transfer_count[24]
* net 1511 dst_addr[101]
* net 1536 debug_channel_state[3]
* net 1538 debug_transfer_count[110]
* net 1539 debug_transfer_count[65]
* net 1540 debug_transfer_count[67]
* net 1549 channel_length[102]
* net 1550 channel_length[109]
* net 1551 dst_wready[3]
* net 1574 dst_addr[79]
* net 1576 channel_length[49]
* net 1577 channel_length[48]
* net 1598 channel_length[107]
* net 1599 channel_length[110]
* net 1600 channel_length[100]
* net 1601 channel_length[108]
* net 1602 channel_length[103]
* net 1614 channel_length[38]
* net 1615 dst_addr[24]
* net 1616 dst_addr[112]
* net 1617 debug_transfer_count[126]
* net 1618 dst_addr[59]
* net 1621 dst_addr[75]
* net 1630 channel_length[111]
* net 1651 debug_channel_state[8]
* net 1653 dst_addr[70]
* net 1654 debug_transfer_count[92]
* net 1655 debug_transfer_count[119]
* net 1656 debug_transfer_count[90]
* net 1677 dst_addr[32]
* net 1679 debug_transfer_count[53]
* net 1680 debug_transfer_count[121]
* net 1681 debug_transfer_count[56]
* net 1682 dst_addr[87]
* net 1683 debug_transfer_count[62]
* net 1709 debug_transfer_count[102]
* net 1711 dst_addr[57]
* net 1712 dst_addr[113]
* net 1713 dst_addr[50]
* net 1717 debug_transfer_count[100]
* net 1746 dst_addr[108]
* net 1747 dst_addr[124]
* net 1749 debug_transfer_count[9]
* net 1776 debug_transfer_count[101]
* net 1777 dst_addr[121]
* net 1778 dst_addr[52]
* net 1803 dst_addr[14]
* net 1805 dst_addr[102]
* net 1806 debug_transfer_count[10]
* net 1807 debug_transfer_count[63]
* net 1808 dst_addr[64]
* net 1809 dst_addr[31]
* net 1810 dst_addr[34]
* net 1818 channel_length[99]
* net 1831 dst_addr[63]
* net 1833 debug_transfer_count[33]
* net 1834 debug_transfer_count[103]
* net 1835 debug_transfer_count[39]
* net 1836 dst_addr[82]
* net 1837 debug_transfer_count[123]
* net 1842 channel_length[98]
* net 1865 debug_transfer_count[112]
* net 1868 dst_addr[20]
* net 1869 debug_transfer_count[89]
* net 1870 debug_transfer_count[104]
* net 1890 dst_addr[7]
* net 1891 dst_addr[77]
* net 1892 dst_addr[86]
* net 1893 dst_addr[89]
* net 1897 dst_addr[56]
* net 1900 channel_length[96]
* net 1922 dst_addr[67]
* net 1923 debug_transfer_count[127]
* net 1924 debug_transfer_count[87]
* net 1929 channel_length[97]
* net 1944 debug_transfer_count[109]
* net 1946 debug_transfer_count[13]
* net 1947 debug_transfer_count[70]
* net 1948 dst_addr[66]
* net 1949 debug_transfer_count[26]
* net 1983 dst_addr[44]
* net 1984 dst_addr[105]
* net 1985 debug_transfer_count[117]
* net 1986 dst_addr[72]
* net 1987 debug_channel_state[1]
* net 2010 debug_transfer_count[40]
* net 2013 dst_addr[18]
* net 2015 dst_addr[123]
* net 2016 dst_addr[17]
* net 2017 dst_addr[49]
* net 2018 debug_transfer_count[60]
* net 2019 debug_transfer_count[116]
* net 2041 debug_transfer_count[106]
* net 2042 debug_transfer_count[30]
* net 2064 dst_addr[2]
* net 2066 dst_addr[35]
* net 2067 debug_channel_state[9]
* net 2068 debug_transfer_count[14]
* net 2069 dst_addr[116]
* net 2070 debug_transfer_count[15]
* net 2071 debug_transfer_count[72]
* net 2084 dst_addr[12]
* net 2086 debug_transfer_count[38]
* net 2087 dst_addr[88]
* net 2088 debug_transfer_count[68]
* net 2115 dst_addr[53]
* net 2116 dst_addr[41]
* net 2117 dst_addr[4]
* net 2118 dst_addr[54]
* net 2119 debug_transfer_count[20]
* net 2120 debug_transfer_count[21]
* net 2121 dst_addr[27]
* net 2128 channel_length[119]
* net 2142 dst_addr[38]
* net 2145 debug_transfer_count[122]
* net 2146 debug_transfer_count[6]
* net 2148 dst_addr[127]
* net 2149 debug_transfer_count[107]
* net 2150 debug_transfer_count[91]
* net 2159 channel_length[118]
* net 2160 channel_length[120]
* net 2161 channel_length[122]
* net 2182 debug_transfer_count[29]
* net 2184 dst_addr[37]
* net 2185 dst_addr[111]
* net 2186 debug_transfer_count[58]
* net 2200 channel_length[121]
* net 2216 dst_addr[42]
* net 2217 dst_addr[55]
* net 2219 dst_addr[40]
* net 2220 debug_transfer_count[88]
* net 2221 debug_transfer_count[124]
* net 2222 debug_transfer_count[4]
* net 2223 dst_addr[85]
* net 2226 debug_transfer_count[80]
* net 2236 channel_length[123]
* net 2247 debug_transfer_count[82]
* net 2255 dst_addr[125]
* net 2256 debug_transfer_count[41]
* net 2257 dst_addr[6]
* net 2258 debug_transfer_count[52]
* net 2278 dst_addr[83]
* net 2280 debug_transfer_count[79]
* net 2281 debug_transfer_count[85]
* net 2282 debug_transfer_count[31]
* net 2283 dst_addr[60]
* net 2284 debug_transfer_count[98]
* net 2285 debug_transfer_count[43]
* net 2286 dst_addr[30]
* net 2302 debug_transfer_count[69]
* net 2303 dst_addr[119]
* net 2304 dst_addr[65]
* net 2305 dst_addr[48]
* net 2317 debug_transfer_count[12]
* net 2320 dst_addr[1]
* net 2325 dst_addr[51]
* net 2326 dst_addr[11]
* net 2327 dst_addr[29]
* net 2328 dst_addr[76]
* net 2329 debug_transfer_count[118]
* net 2330 debug_transfer_count[64]
* net 2342 dst_addr[80]
* net 2343 dst_addr[16]
* net 2344 debug_transfer_count[51]
* net 2345 debug_transfer_count[74]
* net 2346 dst_addr[15]
* net 2347 dst_addr[122]
* net 2369 debug_transfer_count[1]
* net 2370 debug_channel_state[11]
* net 2373 debug_transfer_count[99]
* net 2374 dst_addr[120]
* net 2375 debug_transfer_count[71]
* net 2376 dst_addr[45]
* net 2377 dst_addr[61]
* net 2378 debug_transfer_count[78]
* net 2387 dst_addr[5]
* net 2391 debug_transfer_count[59]
* net 2392 dst_addr[10]
* net 2395 debug_transfer_count[45]
* net 2396 dst_addr[13]
* net 2397 debug_transfer_count[93]
* net 2398 debug_transfer_count[16]
* net 2399 debug_transfer_count[81]
* net 2412 dst_addr[118]
* net 2415 src_addr[54]
* net 2416 dst_wdata[9]
* net 2417 dst_wdata[75]
* net 2418 src_addr[10]
* net 2419 dst_wstrb[3]
* net 2420 debug_transfer_count[46]
* net 2421 dst_addr[43]
* net 2422 dst_addr[33]
* net 2423 dst_addr[22]
* net 2424 dst_addr[91]
* net 2425 dst_wdata[34]
* net 2426 dst_addr[21]
* net 2432 src_addr[101]
* net 2440 debug_transfer_count[111]
* net 2441 src_addr[53]
* net 2444 dst_wdata[82]
* net 2445 dst_wdata[58]
* net 2446 dst_wdata[120]
* net 2447 dst_addr[9]
* net 2448 src_addr[116]
* net 2449 dst_wdata[65]
* net 2453 src_addr[57]
* net 2456 dst_wdata[104]
* net 2457 src_addr[110]
* net 2458 dst_wdata[19]
* net 2461 src_addr[33]
* net 2462 dst_wstrb[9]
* net 2463 dst_wdata[53]
* net 2464 dst_addr[39]
* net 2465 dst_addr[69]
* net 2466 dst_wdata[44]
* net 2467 dst_wstrb[8]
* net 2471 debug_transfer_count[11]
* net 2472 src_addr[24]
* net 2484 src_addr[21]
* net 2485 dst_addr[93]
* net 2486 src_addr[64]
* net 2487 src_addr[108]
* net 2488 src_addr[126]
* net 2489 dst_addr[47]
* net 2490 debug_transfer_count[115]
* net 2491 dst_wdata[125]
* net 2492 dst_wdata[88]
* net 2498 dst_wdata[73]
* net 2502 dst_addr[36]
* net 2505 dst_wdata[95]
* net 2506 dst_wdata[35]
* net 2507 dst_wdata[90]
* net 2508 debug_transfer_count[49]
* net 2509 dst_wdata[59]
* net 2510 dst_wdata[84]
* net 2511 src_addr[25]
* net 2512 dst_wdata[38]
* net 2524 dst_wdata[105]
* net 2528 dst_wdata[111]
* net 2529 dst_wdata[39]
* net 2530 src_addr[50]
* net 2531 debug_transfer_count[113]
* net 2532 src_addr[122]
* net 2533 debug_transfer_count[3]
* net 2534 debug_transfer_count[36]
* net 2535 dst_wdata[108]
* net 2536 debug_transfer_count[7]
* net 2537 dst_wdata[12]
* net 2538 dst_wdata[3]
* net 2539 src_addr[14]
* net 2541 debug_transfer_count[47]
* net 2546 dst_wdata[24]
* net 2547 dst_wdata[119]
* net 2551 src_addr[118]
* net 2552 debug_transfer_count[19]
* net 2554 src_addr[34]
* net 2555 dst_wdata[17]
* net 2556 src_addr[109]
* net 2557 dst_addr[74]
* net 2560 dst_wdata[56]
* net 2565 dst_wdata[64]
* net 2569 debug_transfer_count[18]
* net 2572 src_addr[105]
* net 2573 debug_transfer_count[54]
* net 2574 dst_wdata[123]
* net 2575 dst_wdata[1]
* net 2576 src_addr[38]
* net 2577 dst_addr[26]
* net 2578 debug_transfer_count[34]
* net 2581 dst_addr[104]
* net 2584 dst_wdata[121]
* net 2586 dst_wdata[46]
* net 2589 dst_wdata[74]
* net 2590 debug_transfer_count[108]
* net 2591 debug_transfer_count[28]
* net 2592 src_addr[36]
* net 2593 dst_addr[106]
* net 2594 debug_transfer_count[8]
* net 2595 dst_wdata[57]
* net 2600 dst_addr[25]
* net 2605 src_addr[51]
* net 2606 debug_channel_state[7]
* net 2609 debug_transfer_count[125]
* net 2610 dst_addr[95]
* net 2611 src_addr[106]
* net 2612 debug_transfer_count[27]
* net 2613 dst_wdata[115]
* net 2614 debug_channel_state[4]
* net 2615 dst_addr[96]
* net 2626 dst_wdata[42]
* net 2627 dst_wdata[78]
* net 2628 src_addr[107]
* net 2629 dst_wdata[15]
* net 2630 debug_channel_state[0]
* net 2631 src_addr[17]
* net 2632 dst_wdata[51]
* net 2633 dst_wstrb[7]
* net 2634 src_addr[22]
* net 2635 dst_wdata[30]
* net 2640 debug_transfer_count[50]
* net 2645 dst_addr[23]
* net 2648 dst_wstrb[0]
* net 2649 src_addr[29]
* net 2650 dst_wdata[67]
* net 2651 dst_addr[8]
* net 2652 dst_wdata[50]
* net 2653 dst_wdata[41]
* net 2654 dst_wdata[80]
* net 2655 dst_wdata[33]
* net 2666 dst_wdata[31]
* net 2670 src_addr[20]
* net 2671 src_addr[60]
* net 2672 dst_addr[58]
* net 2673 src_addr[100]
* net 2674 debug_channel_state[2]
* net 2675 dst_addr[99]
* net 2676 debug_transfer_count[66]
* net 2677 dst_wdata[124]
* net 2678 dst_wdata[127]
* net 2679 src_addr[68]
* net 2680 dst_wdata[96]
* net 2686 src_addr[48]
* net 2688 dst_wstrb[2]
* net 2691 src_addr[121]
* net 2692 dst_addr[117]
* net 2693 dst_wdata[97]
* net 2694 dst_wdata[117]
* net 2695 src_addr[111]
* net 2696 dst_wdata[79]
* net 2697 src_addr[61]
* net 2698 dst_addr[115]
* net 2704 dst_wdata[36]
* net 2706 dst_wdata[27]
* net 2712 debug_transfer_count[0]
* net 2716 dst_wdata[91]
* net 2717 dst_addr[100]
* net 2718 src_addr[46]
* net 2719 dst_wdata[18]
* net 2720 dst_wdata[86]
* net 2721 debug_transfer_count[114]
* net 2722 dst_addr[84]
* net 2723 src_addr[117]
* net 2724 src_addr[6]
* net 2733 src_addr[35]
* net 2734 debug_transfer_count[42]
* net 2735 debug_transfer_count[94]
* net 2736 dst_wdata[28]
* net 2737 debug_channel_state[5]
* net 2738 dst_wdata[94]
* net 2739 dst_wdata[76]
* net 2740 src_addr[39]
* net 2741 dst_wdata[11]
* net 2742 src_addr[65]
* net 2743 dst_wdata[93]
* net 2749 debug_transfer_count[22]
* net 2755 debug_transfer_count[2]
* net 2758 src_addr[19]
* net 2759 dst_wstrb[6]
* net 2760 debug_transfer_count[73]
* net 2761 dst_wdata[43]
* net 2762 src_addr[28]
* net 2763 dst_addr[98]
* net 2764 src_addr[11]
* net 2765 dst_wdata[6]
* net 2774 src_addr[15]
* net 2775 dst_wdata[66]
* net 2776 src_addr[5]
* net 2777 dst_addr[107]
* net 2778 debug_transfer_count[32]
* net 2779 src_addr[112]
* net 2780 dst_wdata[20]
* net 2781 debug_transfer_count[84]
* net 2782 dst_addr[114]
* net 2783 src_addr[52]
* net 2784 dst_wdata[54]
* net 2785 src_addr[114]
* net 2794 debug_transfer_count[44]
* net 2796 dst_addr[81]
* net 2799 src_addr[119]
* net 2800 src_addr[41]
* net 2801 debug_transfer_count[48]
* net 2802 debug_transfer_count[96]
* net 2803 debug_transfer_count[86]
* net 2804 src_addr[49]
* net 2805 src_addr[31]
* net 2806 src_addr[124]
* net 2807 dst_wstrb[15]
* net 2808 dst_wdata[10]
* net 2812 dst_addr[78]
* net 2815 dst_addr[90]
* net 2826 src_addr[27]
* net 2828 src_addr[89]
* net 2829 debug_channel_state[10]
* net 2830 src_addr[88]
* net 2833 dst_wdata[63]
* net 2834 src_addr[120]
* net 2839 src_addr[127]
* net 2843 dst_wdata[8]
* net 2848 src_addr[13]
* net 2850 src_addr[123]
* net 2851 debug_transfer_count[57]
* net 2858 src_addr[23]
* net 2859 dst_wdata[45]
* net 2861 debug_transfer_count[76]
* net 2862 src_addr[125]
* net 2863 dst_wdata[116]
* net 2864 src_addr[62]
* net 2865 dst_wdata[113]
* net 2866 src_addr[32]
* net 2867 dst_wdata[110]
* net 2870 dst_addr[0]
* net 2876 dst_wstrb[12]
* net 2878 dst_wdata[112]
* net 2880 src_addr[71]
* net 2886 src_addr[81]
* net 2887 src_addr[76]
* net 2888 src_addr[7]
* net 2890 src_addr[75]
* net 2892 dst_addr[126]
* net 2894 src_addr[44]
* net 2895 src_addr[58]
* net 2896 src_addr[93]
* net 2897 dst_wdata[22]
* net 2898 src_addr[98]
* net 2899 debug_transfer_count[55]
* net 2900 dst_addr[73]
* net 2912 src_addr[77]
* net 2915 src_addr[83]
* net 2916 src_addr[8]
* net 2917 channel_length[114]
* net 2918 channel_done[3]
* net 2919 src_addr[87]
* net 2920 channel_length[46]
* net 2921 channel_length[43]
* net 2923 debug_transfer_count[35]
* net 2926 src_addr[95]
* net 2927 src_addr[99]
* net 2928 dst_addr[110]
* net 2929 src_addr[18]
* net 2930 dst_wdata[69]
* net 2931 src_addr[92]
* net 2932 dst_wdata[72]
* net 2933 src_addr[42]
* net 2935 dst_wdata[40]
* net 2936 dst_wdata[52]
* net 2937 src_addr[113]
* net 2938 dst_wdata[71]
* net 2939 dst_addr[62]
* net 2940 dst_wdata[87]
* net 2941 dst_wdata[32]
* net 2943 channel_length[125]
* net 2944 channel_length[124]
* net 2945 channel_length[126]
* net 2946 channel_length[127]
* net 2947 channel_length[116]
* net 2948 channel_length[115]
* net 2949 channel_length[117]
* net 2950 channel_busy[3]
* net 2951 channel_length[112]
* net 2952 channel_length[113]
* net 2953 dst_write[3]
* net 2954 channel_error[3]
* net 2955 channel_length[47]
* net 2956 channel_length[44]
* net 2957 channel_length[41]
* net 2958 channel_length[45]
* net 2959 channel_length[42]
* net 2960 channel_length[40]
* net 2961 channel_length[33]
* net 2962 channel_length[35]
* net 2963 channel_length[32]
* net 2964 channel_length[34]
* net 2965 debug_transfer_count[17]
* net 2966 dst_wdata[16]
* net 2968 debug_transfer_count[5]
* net 2969 dst_wdata[13]
* net 2971 dst_wdata[29]
* net 2972 dst_wdata[48]
* net 2973 dst_wdata[126]
* net 2974 dst_addr[71]
* net 2975 src_addr[63]
* net 2977 src_addr[72]
* net 2978 src_addr[79]
* net 2984 NWELL
* net 2985 PWELL,gf180mcu_gnd
* cell instance $2 m0 *1 260.96,15.12
X$2 1 2984 2985 110 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6 r0 *1 259.28,5.04
X$6 2 2984 2985 69 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11 r0 *1 267.68,5.04
X$11 3 2984 2985 70 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14 m0 *1 245.84,176.4
X$14 2985 556 555 4 579 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $16 r0 *1 325.36,5.04
X$16 14 2984 2985 4 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $20 m0 *1 232.96,166.32
X$20 532 2985 2984 5 595 554 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $22 r0 *1 316.4,5.04
X$22 12 2984 2985 5 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $26 r0 *1 217.28,166.32
X$26 566 2985 2984 6 551 553 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $28 r0 *1 345.52,5.04
X$28 18 2984 2985 6 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $33 r0 *1 282.24,5.04
X$33 7 2984 2985 71 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $36 r0 *1 286.72,5.04
X$36 8 2984 2985 72 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $40 r0 *1 301.28,5.04
X$40 9 2984 2985 73 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $44 r0 *1 305.76,5.04
X$44 10 2984 2985 394 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $48 m0 *1 313.6,15.12
X$48 11 2984 2985 111 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $56 r0 *1 337.12,5.04
X$56 13 2984 2985 74 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $63 m0 *1 333.2,15.12
X$63 15 2984 2985 113 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $66 r0 *1 358.4,5.04
X$66 2985 77 16 2984 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $71 r0 *1 364.56,15.12
X$71 17 2984 2985 147 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $78 r0 *1 353.92,5.04
X$78 19 2984 2985 76 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $82 r0 *1 371.28,5.04
X$82 20 2984 2985 78 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $85 r0 *1 391.44,5.04
X$85 79 2984 2985 21 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $89 m0 *1 420,25.2
X$89 152 2985 2984 22 153 122 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $91 r0 *1 421.68,5.04
X$91 26 2984 2985 22 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $95 m0 *1 427.28,15.12
X$95 23 2984 2985 151 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99 r0 *1 410.48,5.04
X$99 24 2984 2985 80 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $104 m0 *1 418.88,15.12
X$104 25 2984 2985 86 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $111 r0 *1 438.48,5.04
X$111 27 2984 2985 28 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $114 r0 *1 431.76,15.12
X$114 123 2985 2984 28 225 124 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $120 r0 *1 446.88,5.04
X$120 29 2984 2985 82 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $123 r0 *1 430.08,5.04
X$123 30 2984 2985 190 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $128 r0 *1 453.04,15.12
X$128 31 2984 2985 156 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $132 r0 *1 455.28,5.04
X$132 32 2984 2985 34 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $135 m0 *1 454.72,15.12
X$135 33 2984 2985 83 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $140 r0 *1 466.48,15.12
X$140 127 2985 2984 34 128 129 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $144 m0 *1 463.12,15.12
X$144 2985 118 35 2984 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $148 m0 *1 465.92,25.2
X$148 2985 127 2984 192 129 36 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $150 r0 *1 463.68,5.04
X$150 36 2985 2984 83 84 37 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $154 r0 *1 480.48,25.2
X$154 98 91 37 174 2985 2984 169 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $159 m0 *1 473.2,25.2
X$159 38 2984 2985 167 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $163 r0 *1 459.76,35.28
X$163 2984 39 230 2985 218 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $165 r0 *1 475.44,5.04
X$165 39 2984 2985 41 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $167 m0 *1 457.52,35.28
X$167 2985 150 39 246 218 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $173 r0 *1 483.84,5.04
X$173 40 2984 2985 85 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $181 m0 *1 488.32,15.12
X$181 42 2984 2985 92 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $185 m0 *1 478.24,25.2
X$185 43 2984 2985 193 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $189 r0 *1 517.44,5.04
X$189 44 2984 2985 114 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $193 m0 *1 504.56,25.2
X$193 45 2984 2985 176 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $196 m0 *1 496.72,15.12
X$196 117 2984 2985 46 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $200 r0 *1 491.12,15.12
X$200 47 2984 2985 116 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $205 r0 *1 509.04,5.04
X$205 96 2984 2985 48 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $208 m0 *1 493.92,25.2
X$208 173 2984 2985 49 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $212 r0 *1 500.64,5.04
X$212 93 2984 2985 50 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $217 m0 *1 530.88,15.12
X$217 51 2984 2985 178 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $220 r0 *1 530.32,5.04
X$220 52 2984 2985 99 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $225 r0 *1 573.44,5.04
X$225 53 2984 2985 104 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $229 r0 *1 577.92,5.04
X$229 54 2984 2985 81 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $233 m0 *1 578.48,15.12
X$233 55 2984 2985 108 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $236 m0 *1 580.16,25.2
X$236 56 2984 2985 1105 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $240 r0 *1 582.4,5.04
X$240 57 2984 2985 75 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $245 r0 *1 590.8,5.04
X$245 58 2984 2985 68 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $249 r0 *1 608.72,5.04
X$249 59 2984 2985 66 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $252 m0 *1 608.72,15.12
X$252 60 2984 2985 143 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $256 r0 *1 594.16,15.12
X$256 61 2984 2985 141 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $261 r0 *1 600.32,5.04
X$261 62 2984 2985 67 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $264 m0 *1 600.32,25.2
X$264 63 2984 2985 142 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $269 m0 *1 600.32,15.12
X$269 64 2984 2985 105 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $273 r0 *1 602.56,25.2
X$273 65 2984 2985 182 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $276 r0 *1 594.16,95.76
X$276 340 2985 2984 66 341 342 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $281 m0 *1 586.88,15.12
X$281 144 2985 2984 67 106 213 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $286 m0 *1 584.64,115.92
X$286 375 2985 2984 68 376 370 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $293 r0 *1 229.6,136.08
X$293 459 2985 2984 69 449 460 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $296 r0 *1 214.48,136.08
X$296 437 2985 2984 70 473 476 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $301 m0 *1 183.68,136.08
X$301 2985 452 434 71 380 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $306 r0 *1 183.12,136.08
X$306 451 2985 2984 72 474 453 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $311 m0 *1 201.6,136.08
X$311 426 2985 2984 73 427 475 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $316 r0 *1 260.4,15.12
X$316 2985 2984 74 186 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $321 m0 *1 583.52,136.08
X$321 422 2985 2984 75 421 444 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $326 r0 *1 210.56,176.4
X$326 603 2985 2984 76 617 604 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $331 m0 *1 353.36,15.12
X$331 2985 77 150 2984 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $337 m0 *1 213.92,186.48
X$337 640 2985 2984 78 638 577 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $348 m0 *1 142.24,367.92
X$348 2985 150 79 814 950 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $354 m0 *1 403.2,25.2
X$354 159 2985 2984 80 160 119 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $359 r0 *1 568.4,408.24
X$359 1093 2985 2984 81 1084 1094 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $364 m0 *1 439.6,15.12
X$364 87 2985 2984 82 198 88 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $375 m0 *1 454.16,55.44
X$375 2984 229 248 2985 84 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $380 m0 *1 478.24,15.12
X$380 89 2985 2984 85 90 91 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $383 r0 *1 425.04,15.12
X$383 2985 2984 86 149 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $387 m0 *1 434,25.2
X$387 2985 123 2984 163 124 87 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $389 m0 *1 448.56,25.2
X$389 126 165 88 124 2985 2984 199 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $392 r0 *1 476,15.12
X$392 2984 130 158 89 131 98 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $396 m0 *1 473.76,75.6
X$396 2984 293 292 2985 90 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $398 r0 *1 470.96,25.2
X$398 2985 2984 91 166 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $406 r0 *1 487.76,25.2
X$406 2985 170 171 92 172 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $409 r0 *1 480.48,65.52
X$409 2985 150 93 109 349 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $413 r0 *1 485.52,15.12
X$413 2984 158 94 2985 132 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $415 r0 *1 506.8,15.12
X$415 115 98 133 94 95 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $421 m0 *1 507.36,15.12
X$421 2985 95 98 116 97 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $424 m0 *1 470.96,146.16
X$424 2984 96 466 2985 491 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $427 m0 *1 486.64,146.16
X$427 2985 150 96 467 504 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $434 r0 *1 505.68,85.68
X$434 2984 294 323 2985 97 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $445 m0 *1 528.64,428.4
X$445 1173 2985 2984 99 1174 1196 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $447 m0 *1 539.84,25.2
X$447 2984 179 2985 134 100 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $449 m0 *1 539.28,15.12
X$449 2985 2984 112 100 101 136 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $451 r0 *1 549.92,15.12
X$451 2984 101 134 2985 106 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $453 m0 *1 555.52,25.2
X$453 137 2984 101 103 2985 237 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $455 m0 *1 548.24,25.2
X$455 137 2984 101 187 2985 139 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $458 r0 *1 530.88,15.12
X$458 2985 150 101 109 112 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $464 m0 *1 556.64,15.12
X$464 2985 150 103 109 102 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $466 r0 *1 562.8,15.12
X$466 2985 2984 102 138 103 146 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $470 r0 *1 575.12,15.12
X$470 2984 103 139 2985 107 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $480 m0 *1 568.4,418.32
X$480 1151 2985 2984 104 1134 1121 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $486 m0 *1 589.68,65.52
X$486 280 2985 2984 105 297 281 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $495 r0 *1 584.64,15.12
X$495 145 2985 2984 143 107 140 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $501 m0 *1 569.52,408.24
X$501 2985 1070 1072 108 1071 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $505 r0 *1 574.56,95.76
X$505 2985 150 296 109 339 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $507 m0 *1 492.24,85.68
X$507 2985 331 109 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $512 r0 *1 460.32,55.44
X$512 2985 150 273 109 299 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $514 r0 *1 574,65.52
X$514 2985 150 279 109 277 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $516 m0 *1 530.32,55.44
X$516 2985 150 254 109 263 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $518 m0 *1 511.28,65.52
X$518 2985 150 253 109 274 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $520 r0 *1 543.76,85.68
X$520 2985 150 312 109 328 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $523 m0 *1 520.8,105.84
X$523 2985 150 294 109 336 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $527 m0 *1 487.76,85.68
X$527 2985 2984 109 2986 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $529 r0 *1 470.96,85.68
X$529 2985 150 293 109 321 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $532 m0 *1 463.68,115.92
X$532 2985 150 379 109 362 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $535 m0 *1 552.72,45.36
X$535 2985 150 239 109 203 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $538 r0 *1 520.8,25.2
X$538 2985 150 137 109 177 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $557 m0 *1 220.64,136.08
X$557 448 2985 2984 110 404 438 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $562 r0 *1 203.28,136.08
X$562 435 2985 2984 111 432 457 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $571 m0 *1 215.04,196.56
X$571 655 2985 2984 113 656 605 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $576 m0 *1 519.12,15.12
X$576 115 2985 2984 114 154 131 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $589 r0 *1 448.56,398.16
X$589 2985 150 117 1188 1040 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $594 r0 *1 461.44,15.12
X$594 118 2984 2985 231 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $599 r0 *1 420.56,25.2
X$599 162 119 161 122 2985 2984 189 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $601 r0 *1 406.56,25.2
X$601 2985 159 2984 214 188 119 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $606 m0 *1 412.72,25.2
X$606 2985 120 2984 195 152 162 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $608 r0 *1 413.28,15.12
X$608 2985 120 162 151 121 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $610 m0 *1 418.32,105.84
X$610 2984 345 2985 121 358 268 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $612 m0 *1 413.28,95.76
X$612 2984 334 319 2985 121 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $617 r0 *1 415.52,25.2
X$617 2985 2984 162 196 122 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $631 m0 *1 441.28,25.2
X$631 2985 125 2984 164 155 126 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $633 r0 *1 441.28,15.12
X$633 2985 125 126 156 157 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $636 r0 *1 450.24,25.2
X$636 2985 2984 126 191 165 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $643 m0 *1 463.68,55.44
X$643 2984 273 249 2985 128 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $647 m0 *1 486.64,25.2
X$647 171 131 175 129 2985 2984 194 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $653 r0 *1 474.32,25.2
X$653 2985 2984 130 166 192 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $662 m0 *1 486.08,45.36
X$662 2984 2985 221 132 234 201 235 232 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $664 r0 *1 500.64,25.2
X$664 2984 133 221 174 171 175 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $668 r0 *1 510.16,25.2
X$668 133 2985 2984 176 219 174 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $671 r0 *1 540.4,25.2
X$671 2984 202 134 2985 136 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $673 r0 *1 548.24,25.2
X$673 2984 137 180 2985 134 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $679 r0 *1 484.96,95.76
X$679 2985 335 135 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $681 m0 *1 502.32,55.44
X$681 2984 250 2985 251 252 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $683 m0 *1 533.12,35.28
X$683 2984 179 2985 187 216 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $685 m0 *1 562.8,25.2
X$685 2984 179 2985 139 138 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $688 m0 *1 466.48,65.52
X$688 2984 250 2985 249 270 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $690 r0 *1 558.32,45.36
X$690 2984 179 2985 206 204 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $692 r0 *1 565.6,55.44
X$692 2984 179 2985 256 257 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $694 r0 *1 470.4,75.6
X$694 2984 250 2985 292 303 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $697 m0 *1 523.6,95.76
X$697 2984 250 2985 323 337 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $700 m0 *1 537.04,65.52
X$700 2984 179 2985 275 276 135 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $724 m0 *1 522.48,25.2
X$724 2984 137 187 2985 172 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $726 m0 *1 524.72,35.28
X$726 2985 2984 177 216 137 217 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $735 m0 *1 570.64,25.2
X$735 2984 202 139 2985 146 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $745 m0 *1 584.64,25.2
X$745 2985 145 2984 185 140 144 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $748 m0 *1 586.88,35.28
X$748 181 2984 140 208 2985 210 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $750 m0 *1 589.12,45.36
X$750 260 2985 2984 141 238 211 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $755 r0 *1 593.04,25.2
X$755 212 2985 2984 142 183 181 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $774 r0 *1 252.56,166.32
X$774 535 2985 2984 147 529 557 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $779 r0 *1 400.4,15.12
X$779 2985 2984 148 188 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $782 r0 *1 403.76,15.12
X$782 148 2985 2984 149 285 161 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $790 m0 *1 38.08,378
X$790 2985 150 944 906 962 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $792 m0 *1 169.12,448.56
X$792 2985 150 1181 1188 1319 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $794 m0 *1 156.8,509.04
X$794 2985 150 1390 1522 1722 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $797 r0 *1 225.12,428.4
X$797 2985 150 1155 1188 1235 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $799 r0 *1 149.52,488.88
X$799 2985 150 1328 1525 1591 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $802 m0 *1 87.36,146.16
X$802 2985 150 450 402 497 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $804 m0 *1 154,136.08
X$804 2985 150 433 408 425 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $807 r0 *1 24.64,216.72
X$807 2985 150 670 667 679 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $810 r0 *1 107.52,297.36
X$810 2985 150 758 691 760 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $813 m0 *1 92.96,176.4
X$813 2985 150 570 402 613 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $815 r0 *1 2.24,236.88
X$815 2985 150 698 667 708 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $817 r0 *1 135.52,226.8
X$817 2985 150 574 691 694 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $819 m0 *1 542.64,468.72
X$819 2985 150 1449 1498 1424 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $821 m0 *1 12.32,216.72
X$821 2985 150 668 667 678 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $823 m0 *1 489.44,398.16
X$823 2985 150 1041 1022 1057 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $826 m0 *1 543.2,398.16
X$826 2985 150 1026 1022 1025 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $829 m0 *1 111.44,327.6
X$829 2985 150 774 814 816 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $831 m0 *1 32.48,297.36
X$831 2985 150 727 667 737 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $834 m0 *1 39.2,246.96
X$834 2985 150 700 667 716 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $837 r0 *1 140,166.32
X$837 2985 150 485 408 593 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $839 m0 *1 472.64,468.72
X$839 2985 150 1274 1022 1443 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $841 m0 *1 511.28,408.24
X$841 2985 150 1067 1022 1066 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $843 m0 *1 520.24,398.16
X$843 2985 150 1024 1022 1023 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $846 m0 *1 97.44,297.36
X$846 2985 150 759 691 745 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $848 m0 *1 127.68,136.08
X$848 2985 150 407 408 423 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $850 m0 *1 2.24,297.36
X$850 2985 150 748 667 761 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $852 m0 *1 90.16,136.08
X$852 2985 150 403 402 420 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $854 m0 *1 10.08,277.2
X$854 2985 150 726 667 725 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $857 m0 *1 171.36,206.64
X$857 2985 150 662 408 650 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $859 r0 *1 53.2,297.36
X$859 2985 150 742 667 740 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $862 m0 *1 486.08,418.32
X$862 2985 150 1119 1022 1118 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $864 m0 *1 167.44,226.8
X$864 2985 150 624 691 696 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $867 r0 *1 172.48,226.8
X$867 2985 150 623 691 697 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $869 r0 *1 114.24,196.56
X$869 2985 150 486 691 643 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $871 r0 *1 78.96,246.96
X$871 2985 150 705 691 706 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $873 r0 *1 188.16,156.24
X$873 2985 150 540 408 530 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $875 m0 *1 515.2,458.64
X$875 2985 150 1263 1022 1333 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $877 r0 *1 472.64,438.48
X$877 2985 150 1221 1022 1272 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $879 r0 *1 192.64,206.64
X$879 2985 150 663 408 666 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $881 r0 *1 45.36,267.12
X$881 2985 150 729 667 734 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $883 r0 *1 66.64,206.64
X$883 2985 150 659 667 664 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $885 m0 *1 73.92,267.12
X$885 2985 150 731 691 724 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $887 m0 *1 171.36,176.4
X$887 2985 150 596 408 564 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $890 m0 *1 131.6,196.56
X$890 2985 150 620 402 652 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $892 r0 *1 117.6,176.4
X$892 2985 150 483 402 571 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $894 r0 *1 48.16,579.6
X$894 2985 150 1820 1695 2075 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $896 r0 *1 71.68,579.6
X$896 2985 150 2054 1695 2091 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $898 r0 *1 512.4,478.8
X$898 2985 150 1499 1498 1548 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $900 r0 *1 117.04,559.44
X$900 2985 150 1962 1522 2023 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $903 r0 *1 128.24,458.64
X$903 2985 150 1364 1188 1382 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $905 m0 *1 489.44,488.88
X$905 2985 150 1527 1525 1526 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $908 r0 *1 390.32,75.6
X$908 2985 150 300 246 317 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $911 m0 *1 109.76,468.72
X$911 2985 150 1447 814 1439 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $913 r0 *1 63.28,559.44
X$913 2985 150 1905 1695 1988 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $915 m0 *1 159.6,559.44
X$915 2985 150 1964 1522 1994 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $917 m0 *1 562.24,166.32
X$917 2985 150 515 366 537 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $920 r0 *1 161.84,549.36
X$920 2985 150 1881 1522 1909 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $922 r0 *1 165.76,428.4
X$922 2985 150 1186 814 1233 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $924 m0 *1 570.08,519.12
X$924 2985 150 1647 1498 1705 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $927 r0 *1 469.84,519.12
X$927 2985 150 1669 1525 1786 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $930 r0 *1 13.44,579.6
X$930 2985 150 2049 1695 2074 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $932 r0 *1 77.28,458.64
X$932 2985 150 1389 906 1359 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $934 m0 *1 530.88,126
X$934 2985 150 387 366 395 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $937 m0 *1 507.36,509.04
X$937 2985 150 1644 1525 1688 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $941 r0 *1 390.32,55.44
X$941 2985 150 266 246 265 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $943 r0 *1 101.92,539.28
X$943 2985 150 1821 1695 1850 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $945 r0 *1 151.76,408.24
X$945 2985 150 1064 814 1107 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $947 r0 *1 530.88,156.24
X$947 2985 150 520 366 522 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $950 m0 *1 130.48,589.68
X$950 2985 150 2076 1522 2125 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $952 m0 *1 110.32,428.4
X$952 2985 150 1082 814 1175 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $954 m0 *1 112,438.48
X$954 2985 150 1216 814 1238 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $956 m0 *1 18.48,589.68
X$956 2985 150 2048 1695 2123 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $958 m0 *1 137.76,569.52
X$958 2985 150 1996 1522 1995 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $960 r0 *1 118.72,378
X$960 2985 150 950 814 965 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $962 m0 *1 170.24,519.12
X$962 2985 150 1737 1522 1736 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $964 m0 *1 96.32,599.76
X$964 2985 150 2059 1695 2124 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $966 m0 *1 508.48,156.24
X$966 2985 150 441 366 523 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $968 r0 *1 568.96,478.8
X$968 2985 150 1502 1498 1544 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $970 m0 *1 212.24,498.96
X$970 2985 150 1628 1525 1588 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $972 m0 *1 77.28,630
X$972 2985 150 2272 1695 2293 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $974 r0 *1 142.8,619.92
X$974 2985 150 2297 1522 2307 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $977 m0 *1 122.08,650.16
X$977 2985 150 2310 1522 2357 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $980 m0 *1 91.28,650.16
X$980 2985 150 2309 1695 2355 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $983 m0 *1 122.64,519.12
X$983 2985 150 1761 1522 1733 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $985 m0 *1 449.68,579.6
X$985 2985 150 1997 1525 2060 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $990 r0 *1 120.4,619.92
X$990 2985 150 2242 1522 2289 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $993 r0 *1 431.76,105.84
X$993 2985 150 286 246 360 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $997 m0 *1 42,640.08
X$997 2985 150 2271 1695 2332 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $999 m0 *1 28,630
X$999 2985 150 2269 1695 2306 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1001 r0 *1 402.64,105.84
X$1001 2985 150 334 246 358 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1008 r0 *1 480.48,156.24
X$1008 2985 150 173 467 541 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1010 m0 *1 448.56,166.32
X$1010 2985 150 414 467 543 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1012 m0 *1 57.68,599.76
X$1012 2985 150 2131 1695 2132 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1014 r0 *1 430.08,146.16
X$1014 2985 150 382 467 505 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1017 m0 *1 215.04,458.64
X$1017 2985 150 1154 1188 1385 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1020 m0 *1 380.8,95.76
X$1020 2985 150 318 246 330 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1022 r0 *1 196,458.64
X$1022 2985 150 1411 1188 1383 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1024 m0 *1 535.92,519.12
X$1024 2985 150 1646 1498 1703 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1026 m0 *1 495.6,136.08
X$1026 2985 150 305 467 416 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1028 r0 *1 445.2,85.68
X$1028 2985 150 269 246 301 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1030 r0 *1 397.6,347.76
X$1030 2985 150 872 467 599 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1033 m0 *1 407.12,126
X$1033 2985 150 320 246 377 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1036 m0 *1 90.16,388.08
X$1036 2985 150 928 814 991 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1041 r0 *1 78.96,478.8
X$1041 2985 150 1495 906 1516 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1044 r0 *1 569.52,539.28
X$1044 2985 150 1826 1498 1898 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1046 m0 *1 96.32,488.88
X$1046 2985 150 1560 1522 1625 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1049 m0 *1 556.64,539.28
X$1049 2985 150 1828 1498 1857 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1051 r0 *1 81.76,398.16
X$1051 2985 150 969 814 1035 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1053 m0 *1 10.64,398.16
X$1053 2985 150 995 906 1033 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1055 r0 *1 502.88,579.6
X$1055 2985 150 2004 1498 2078 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1057 m0 *1 495.04,569.52
X$1057 2985 150 1998 1498 2001 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1059 r0 *1 10.64,398.16
X$1059 2985 150 994 906 969 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1062 m0 *1 39.2,519.12
X$1062 2985 150 1728 1695 1691 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1065 r0 *1 2.24,357.84
X$1065 2985 150 918 906 544 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1067 m0 *1 2.24,378
X$1067 2985 150 943 906 928 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1070 r0 *1 4.48,378
X$1070 2985 150 988 906 960 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1073 m0 *1 547.68,196.56
X$1073 2985 150 610 366 654 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1076 r0 *1 81.76,509.04
X$1076 2985 150 1635 1695 1696 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1078 m0 *1 82.32,378
X$1078 2985 150 929 814 948 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1080 r0 *1 518.56,176.4
X$1080 2985 150 560 467 580 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1082 r0 *1 52.08,488.88
X$1082 2985 150 1419 906 1584 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1084 m0 *1 528.64,589.68
X$1084 2985 150 2036 1498 2127 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1086 m0 *1 532,579.6
X$1086 2985 150 2003 1498 2002 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1089 m0 *1 454.72,488.88
X$1089 2985 150 1565 1022 1595 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1092 m0 *1 445.76,498.96
X$1092 2985 150 1606 1525 1605 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1094 r0 *1 500.64,105.84
X$1094 2985 150 306 366 353 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1097 r0 *1 58.8,519.12
X$1097 2985 150 1759 1695 1760 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1099 r0 *1 455.84,458.64
X$1099 2985 150 1273 1022 1413 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1101 r0 *1 560,569.52
X$1101 2985 150 2005 1498 2008 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1103 m0 *1 569.52,196.56
X$1103 2985 150 611 366 630 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1107 r0 *1 76.72,327.6
X$1107 2985 150 773 814 815 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1109 m0 *1 534.24,539.28
X$1109 2985 150 1825 1498 1839 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1111 m0 *1 63.84,398.16
X$1111 2985 150 1019 814 1001 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1113 r0 *1 402.64,488.88
X$1113 2985 150 1563 1188 1594 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1115 m0 *1 45.36,367.92
X$1115 2985 150 919 814 929 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1117 m0 *1 553.28,115.92
X$1117 2985 150 369 366 354 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1119 r0 *1 72.24,418.32
X$1119 2985 150 1170 814 1137 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1121 r0 *1 33.04,438.48
X$1121 2985 150 999 906 1259 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1124 r0 *1 2.24,418.32
X$1124 2985 150 1113 906 1148 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1126 m0 *1 40.88,559.44
X$1126 2985 150 1846 1695 1934 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1128 r0 *1 464.24,539.28
X$1128 2985 150 1769 1525 1884 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1130 m0 *1 57.12,438.48
X$1130 2985 150 1213 906 1215 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1132 m0 *1 62.16,418.32
X$1132 2985 150 998 814 1117 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1134 r0 *1 14,438.48
X$1134 2985 150 1266 906 1265 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1138 r0 *1 515.2,549.36
X$1138 2985 150 1914 1498 1927 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1142 r0 *1 43.12,458.64
X$1142 2985 150 1387 906 1376 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1144 m0 *1 491.12,539.28
X$1144 2985 150 1794 1525 1856 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1147 r0 *1 562.24,136.08
X$1147 2985 150 468 366 443 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1149 r0 *1 2.24,428.4
X$1149 2985 150 1212 906 1135 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1151 m0 *1 91.28,428.4
X$1151 2985 150 1206 814 1317 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1154 r0 *1 162.96,539.28
X$1154 2985 150 1852 1522 1855 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1156 m0 *1 435.12,55.44
X$1156 2985 150 229 246 226 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1159 m0 *1 481.6,579.6
X$1159 2985 150 1999 1525 2035 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1162 r0 *1 56.56,448.56
X$1162 2985 150 1325 906 1323 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1164 r0 *1 408.24,45.36
X$1164 2985 150 223 246 243 2984 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1372 r0 *1 421.12,85.68
X$1372 2984 320 333 2985 153 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1376 m0 *1 512.96,55.44
X$1376 2984 253 251 2985 154 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1382 r0 *1 431.2,25.2
X$1382 155 2985 2984 190 244 165 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1389 m0 *1 437.36,65.52
X$1389 2984 269 283 2985 157 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1403 r0 *1 406.56,35.28
X$1403 2985 2984 222 160 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1415 r0 *1 440.72,25.2
X$1415 2984 163 197 191 168 164 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1430 m0 *1 480.48,126
X$1430 2984 167 385 2985 357 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1433 r0 *1 473.2,126
X$1433 2984 2985 385 335 167 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $1435 m0 *1 458.08,136.08
X$1435 409 167 415 397 384 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1444 r0 *1 483.84,35.28
X$1444 2985 2984 168 245 200 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1446 m0 *1 487.76,35.28
X$1446 2985 170 2984 168 220 171 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1453 m0 *1 482.72,35.28
X$1453 2985 2984 169 200 194 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1472 m0 *1 493.36,156.24
X$1472 2985 2984 173 512 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1486 m0 *1 495.04,35.28
X$1486 220 2985 2984 193 236 175 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1495 r0 *1 530.32,428.4
X$1495 2985 1209 1164 178 1192 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1498 r0 *1 549.92,126
X$1498 2985 2984 419 179 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1506 r0 *1 555.52,115.92
X$1506 2984 179 2985 310 368 338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1508 m0 *1 551.04,95.76
X$1508 2984 179 2985 311 324 338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1511 r0 *1 565.6,126
X$1511 2984 179 2985 390 389 338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1514 m0 *1 565.6,95.76
X$1514 2984 179 2985 325 343 338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1530 m0 *1 564.48,85.68
X$1530 312 2984 180 295 2985 325 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1532 r0 *1 553.28,45.36
X$1532 2984 180 237 2985 206 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1535 m0 *1 538.16,85.68
X$1535 2984 292 307 2985 180 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1541 r0 *1 584.08,25.2
X$1541 2985 2984 181 184 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1549 r0 *1 593.04,45.36
X$1549 2985 240 207 182 242 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1553 r0 *1 570.64,35.28
X$1553 2984 239 206 2985 183 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1558 r0 *1 587.44,25.2
X$1558 2985 2984 209 184 185 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1565 r0 *1 234.64,186.48
X$1565 641 2985 2984 186 642 607 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1569 r0 *1 547.12,75.6
X$1569 2984 187 309 2985 310 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1571 r0 *1 554.4,75.6
X$1571 2984 187 295 2985 311 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1574 r0 *1 551.6,55.44
X$1574 239 2984 187 237 2985 275 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1576 r0 *1 527.52,35.28
X$1576 2984 202 187 2985 217 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1581 m0 *1 516.32,75.6
X$1581 283 2984 291 307 2985 187 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1596 m0 *1 451.92,35.28
X$1596 2985 2984 199 271 189 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1620 m0 *1 413.84,35.28
X$1620 2984 195 2985 196 215 214 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1624 m0 *1 444.64,35.28
X$1624 2985 197 2984 201 215 199 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1628 m0 *1 436.24,105.84
X$1628 2984 359 2985 198 360 268 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1630 m0 *1 434,95.76
X$1630 2984 286 289 2985 198 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1637 m0 *1 473.2,105.84
X$1637 346 200 234 271 2984 2985 347 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1641 r0 *1 472.64,95.76
X$1641 335 200 234 271 2984 2985 348 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1649 m0 *1 560,105.84
X$1649 2984 202 310 2985 356 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1651 m0 *1 531.44,95.76
X$1651 2984 202 323 2985 344 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1653 m0 *1 559.44,85.68
X$1653 2984 202 311 2985 327 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1655 r0 *1 575.68,85.68
X$1655 2984 202 325 2985 326 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1657 r0 *1 575.68,55.44
X$1657 2984 202 256 2985 278 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1660 r0 *1 546,55.44
X$1660 2984 202 275 2985 261 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1664 r0 *1 566.16,45.36
X$1664 2984 202 206 2985 205 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1666 r0 *1 519.68,105.84
X$1666 2985 2984 357 202 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1685 r0 *1 557.76,35.28
X$1685 2985 2984 203 204 239 205 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1695 m0 *1 560,55.44
X$1695 239 2984 254 206 2985 256 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1704 r0 *1 586.88,35.28
X$1704 211 207 213 281 2985 2984 208 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1706 m0 *1 586.32,55.44
X$1706 260 207 280 258 240 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1709 r0 *1 594.16,35.28
X$1709 2984 209 241 212 211 207 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1720 r0 *1 492.24,45.36
X$1720 2985 232 233 2984 245 210 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1723 m0 *1 492.24,55.44
X$1723 2985 2984 233 234 210 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1760 r0 *1 501.76,75.6
X$1760 305 2985 304 2984 219 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1771 r0 *1 402.08,85.68
X$1771 2985 318 2984 332 329 272 222 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1773 m0 *1 401.52,95.76
X$1773 2985 333 222 300 318 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1777 r0 *1 427.28,45.36
X$1777 2984 223 224 2985 244 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1779 r0 *1 430.08,65.52
X$1779 2984 266 223 2985 290 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1781 r0 *1 431.2,55.44
X$1781 223 2984 269 224 2985 248 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1783 m0 *1 410.48,55.44
X$1783 2985 2984 243 247 223 262 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1789 m0 *1 420,55.44
X$1789 2984 272 224 2985 262 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1792 r0 *1 423.36,65.52
X$1792 286 2984 266 289 2985 224 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1796 r0 *1 412.72,55.44
X$1796 2984 250 2985 224 247 268 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1802 m0 *1 426.72,65.52
X$1802 2984 266 267 2985 225 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1805 r0 *1 440.16,45.36
X$1805 2985 2984 226 227 229 228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1807 r0 *1 438.48,55.44
X$1807 2984 250 2985 248 227 268 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1810 r0 *1 446.32,55.44
X$1810 2984 272 248 2985 228 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1814 r0 *1 458.08,65.52
X$1814 269 2984 229 273 2985 291 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1816 m0 *1 457.52,65.52
X$1816 269 2984 229 283 2985 249 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1824 r0 *1 454.16,126
X$1824 2984 413 2985 399 230 411 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1827 r0 *1 440.16,136.08
X$1827 2985 2984 231 464 409 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1829 m0 *1 443.52,136.08
X$1829 2984 231 409 2985 410 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1831 r0 *1 449.12,146.16
X$1831 2985 2984 231 490 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1834 r0 *1 459.76,146.16
X$1834 2984 511 2985 463 506 231 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1843 r0 *1 593.04,65.52
X$1843 2984 233 2985 280 313 281 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1848 m0 *1 600.32,115.92
X$1848 370 342 372 373 2985 2984 233 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1863 r0 *1 477.68,105.84
X$1863 2984 348 2985 386 350 268 235 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1866 m0 *1 481.04,105.84
X$1866 346 2985 350 235 2984 363 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1872 r0 *1 490,85.68
X$1872 306 2985 322 2984 236 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1874 m0 *1 553.84,75.6
X$1874 2984 237 255 2985 295 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1877 m0 *1 558.88,75.6
X$1877 312 296 237 255 2985 2984 309 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1884 m0 *1 549.36,55.44
X$1884 2984 254 275 2985 238 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1895 r0 *1 559.44,55.44
X$1895 239 2984 254 279 2985 255 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1905 m0 *1 601.44,55.44
X$1905 2984 241 258 2985 259 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1910 r0 *1 585.2,55.44
X$1910 2984 279 256 2985 242 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1927 r0 *1 423.36,75.6
X$1927 2985 246 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1936 m0 *1 423.36,85.68
X$1936 2985 331 246 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1959 m0 *1 474.32,65.52
X$1959 2984 272 249 2985 284 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1968 r0 *1 532.56,126
X$1968 387 2984 250 388 2985 396 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1971 r0 *1 524.72,126
X$1971 2985 2984 419 250 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1975 m0 *1 418.32,115.92
X$1975 2984 250 2985 338 364 333 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1980 m0 *1 412.72,65.52
X$1980 2984 250 2985 267 282 268 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1983 m0 *1 448,75.6
X$1983 2984 250 2985 283 302 268 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1997 r0 *1 519.68,55.44
X$1997 2984 272 251 2985 264 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1999 m0 *1 509.04,75.6
X$1999 2985 304 253 2984 294 251 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2004 m0 *1 502.88,75.6
X$2004 293 2984 283 291 2985 251 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2012 r0 *1 511.28,55.44
X$2012 2985 2984 274 252 253 264 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2016 r0 *1 511.28,75.6
X$2016 293 253 294 305 2985 2984 315 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2021 r0 *1 515.2,85.68
X$2021 293 2984 253 292 2985 323 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2033 r0 *1 537.6,55.44
X$2033 2985 2984 263 276 254 261 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2054 m0 *1 574,65.52
X$2054 2985 2984 277 257 279 278 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2062 r0 *1 593.6,105.84
X$2062 2985 350 313 259 374 355 2984 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $2087 m0 *1 404.32,65.52
X$2087 2985 2984 265 282 266 298 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2100 r0 *1 411.04,65.52
X$2100 2984 272 267 2985 298 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2105 m0 *1 423.36,75.6
X$2105 286 2984 288 287 2985 267 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2111 m0 *1 498.4,105.84
X$2111 2984 352 2985 353 268 306 322 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $2114 r0 *1 487.76,126
X$2114 2985 2984 335 268 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2122 m0 *1 504,126
X$2122 2985 2984 401 268 304 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2124 r0 *1 515.2,136.08
X$2124 2985 2984 503 268 440 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2141 r0 *1 448.56,75.6
X$2141 2985 2984 301 302 269 314 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2152 r0 *1 468.16,65.52
X$2152 2985 2984 299 270 273 284 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2164 r0 *1 524.16,115.92
X$2164 2985 387 2984 367 398 272 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2167 m0 *1 504,115.92
X$2167 2985 2984 357 272 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2169 r0 *1 478.24,75.6
X$2169 2984 272 292 2985 316 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2171 r0 *1 457.52,75.6
X$2171 2984 272 283 2985 314 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2177 r0 *1 397.6,95.76
X$2177 2985 2984 317 332 300 272 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2247 m0 *1 429.52,75.6
X$2247 286 288 287 290 2985 2984 283 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2266 m0 *1 405.44,75.6
X$2266 2985 2984 300 285 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2269 r0 *1 434.56,95.76
X$2269 2985 2984 286 359 332 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2274 m0 *1 440.72,75.6
X$2274 286 289 290 291 2985 2984 292 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2287 r0 *1 422.8,95.76
X$2287 2984 320 334 2985 287 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2292 r0 *1 416.08,85.68
X$2292 2984 320 288 2985 319 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2294 r0 *1 411.04,85.68
X$2294 2984 300 318 2985 288 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2300 m0 *1 422.8,95.76
X$2300 320 2984 334 333 2985 289 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2323 r0 *1 537.6,75.6
X$2323 292 2984 307 309 2985 308 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2339 m0 *1 472.64,85.68
X$2339 2985 2984 321 303 293 316 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2350 m0 *1 505.68,95.76
X$2350 2985 322 294 2984 305 323 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2353 r0 *1 524.72,95.76
X$2353 2985 2984 336 337 294 344 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2368 m0 *1 588.56,95.76
X$2368 2984 296 325 2985 341 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2371 m0 *1 573.44,95.76
X$2371 2985 2984 339 343 296 326 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2378 r0 *1 560,75.6
X$2378 2984 312 311 2985 297 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2407 r0 *1 502.88,136.08
X$2407 2985 2984 417 304 365 418 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2420 r0 *1 501.2,126
X$2420 2985 2984 416 417 305 401 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2431 r0 *1 491.68,105.84
X$2431 2984 306 2985 351 352 332 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2433 r0 *1 519.12,75.6
X$2433 2984 306 315 2985 307 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2444 r0 *1 542.08,176.4
X$2444 2984 308 561 2985 608 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2447 m0 *1 542.08,136.08
X$2447 2984 308 442 2985 398 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2449 r0 *1 559.44,176.4
X$2449 2984 308 516 2985 609 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2452 m0 *1 563.36,146.16
X$2452 2984 369 308 2985 390 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2465 r0 *1 570.64,176.4
X$2465 610 2984 310 516 2985 616 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2467 r0 *1 541.52,166.32
X$2467 560 2984 310 561 2985 514 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2470 r0 *1 568.96,146.16
X$2470 369 2984 468 310 2985 494 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2472 r0 *1 537.04,136.08
X$2472 2985 440 387 2984 310 442 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2475 m0 *1 574.56,115.92
X$2475 2984 369 310 2985 376 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2495 m0 *1 551.04,85.68
X$2495 2985 2984 328 324 312 327 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2537 r0 *1 416.08,115.92
X$2537 2985 2984 377 364 320 378 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2543 m0 *1 493.92,115.92
X$2543 2984 365 322 2985 351 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2580 r0 *1 397.04,85.68
X$2580 2985 2984 329 330 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2589 r0 *1 137.2,257.04
X$2589 2985 331 691 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2592 r0 *1 412.16,529.2
X$2592 2985 331 1525 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2594 r0 *1 145.6,559.44
X$2594 2985 331 1522 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2596 r0 *1 110.88,398.16
X$2596 2985 331 814 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2600 m0 *1 458.64,428.4
X$2600 2985 331 1022 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2602 m0 *1 38.08,428.4
X$2602 2985 331 906 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2605 r0 *1 374.64,428.4
X$2605 2985 331 1188 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2612 r0 *1 170.24,166.32
X$2612 2985 331 408 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2615 m0 *1 290.64,337.68
X$2615 2985 850 331 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2619 m0 *1 470.4,186.48
X$2619 2985 331 467 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2623 m0 *1 477.68,519.12
X$2623 2985 331 1498 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2626 m0 *1 539.84,156.24
X$2626 2985 331 366 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2628 m0 *1 75.6,569.52
X$2628 2985 331 1695 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2630 m0 *1 57.68,257.04
X$2630 2985 331 667 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2633 r0 *1 105.28,166.32
X$2633 2985 331 402 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $2656 m0 *1 426.16,146.16
X$2656 2984 2985 461 462 332 464 505 463 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $2658 r0 *1 421.68,105.84
X$2658 2985 2984 334 345 332 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2663 m0 *1 489.44,136.08
X$2663 2984 335 418 2985 332 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2677 m0 *1 426.16,115.92
X$2677 2984 333 365 2985 378 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2696 m0 *1 529.2,115.92
X$2696 2985 335 338 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2700 m0 *1 517.44,136.08
X$2700 2984 2985 418 419 335 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $2709 m0 *1 531.44,136.08
X$2709 2985 335 398 2984 388 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2719 r0 *1 561.12,146.16
X$2719 2984 419 2985 494 493 338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2721 m0 *1 539.84,166.32
X$2721 2984 419 2985 514 513 338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2725 m0 *1 527.52,186.48
X$2725 2984 419 2985 608 581 338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2733 m0 *1 568.4,186.48
X$2733 2984 419 2985 616 635 338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2735 m0 *1 553.84,186.48
X$2735 2984 419 2985 609 629 338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2754 m0 *1 594.16,115.92
X$2754 2984 370 340 2985 371 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2773 m0 *1 459.76,126
X$2773 2985 383 2984 346 400 379 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2780 r0 *1 469.84,105.84
X$2780 2985 362 361 2984 363 347 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2788 m0 *1 474.88,126
X$2788 2985 385 383 2984 349 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2807 r0 *1 557.2,105.84
X$2807 2985 2984 354 368 369 356 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2809 r0 *1 596.4,126
X$2809 391 2984 445 392 2985 355 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2817 m0 *1 486.08,115.92
X$2817 2985 2984 357 365 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2838 r0 *1 446.88,126
X$2838 2985 397 2984 361 412 382 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2853 m0 *1 562.24,186.48
X$2853 2984 365 609 2985 639 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2858 m0 *1 576.8,186.48
X$2858 2984 365 616 2985 631 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2861 m0 *1 535.36,176.4
X$2861 2984 365 608 2985 597 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2863 r0 *1 549.92,146.16
X$2863 2984 365 514 2985 519 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2865 r0 *1 575.68,156.24
X$2865 2984 365 494 2985 518 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2867 m0 *1 514.08,146.16
X$2867 2985 2984 492 440 365 418 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2870 r0 *1 573.44,126
X$2870 2984 365 390 2985 424 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2899 r0 *1 539.84,146.16
X$2899 2985 2984 366 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $2915 r0 *1 531.44,115.92
X$2915 2985 2984 395 367 396 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2922 m0 *1 575.12,156.24
X$2922 369 2984 468 515 2985 516 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2939 r0 *1 596.96,115.92
X$2939 2984 371 392 375 372 373 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $2943 m0 *1 616.56,176.4
X$2943 584 632 587 588 2985 2984 372 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2949 m0 *1 606.48,146.16
X$2949 444 538 471 495 2985 2984 373 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2954 r0 *1 596.96,166.32
X$2954 2985 374 584 582 498 563 2984 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $2974 m0 *1 438.48,146.16
X$2974 2985 2984 379 463 382 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2976 r0 *1 459.2,136.08
X$2976 2985 2984 379 415 413 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2978 r0 *1 435.12,156.24
X$2978 2985 2984 379 439 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2980 r0 *1 424.48,166.32
X$2980 2985 2984 536 379 544 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $2983 r0 *1 436.8,166.32
X$2983 2985 549 559 379 512 510 2984 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2986 m0 *1 446.32,156.24
X$2986 510 379 382 490 2984 2985 511 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2989 m0 *1 449.68,136.08
X$2989 2985 2984 412 410 379 414 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2992 r0 *1 462,126
X$2992 2984 379 384 2985 399 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3003 r0 *1 133.84,126
X$3003 2984 405 2985 380 423 406 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3007 r0 *1 134.4,136.08
X$3007 2984 407 500 2985 380 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3011 m0 *1 201.6,146.16
X$3011 453 381 434 457 2985 2984 502 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3013 r0 *1 201.04,126
X$3013 393 2985 2984 394 428 381 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $3016 r0 *1 191.52,126
X$3016 426 381 393 436 435 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3020 m0 *1 437.36,156.24
X$3020 2985 2984 382 536 409 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3022 m0 *1 454.72,146.16
X$3022 2985 2984 382 413 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3025 r0 *1 445.2,136.08
X$3025 439 2984 382 414 2985 383 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3031 r0 *1 451.36,136.08
X$3031 2984 464 2985 384 400 382 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3048 r0 *1 452.48,146.16
X$3048 2984 490 414 2985 384 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3052 m0 *1 467.6,136.08
X$3052 2985 2984 385 414 415 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3060 m0 *1 479.92,156.24
X$3060 2985 386 2984 541 418 512 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3062 m0 *1 476,146.16
X$3062 2985 386 491 2984 504 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3069 r0 *1 544.32,136.08
X$3069 2984 387 398 2985 446 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3083 m0 *1 566.72,136.08
X$3083 2985 2984 443 389 468 424 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3089 m0 *1 572.32,146.16
X$3089 2984 468 390 2985 496 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3096 r0 *1 590.24,126
X$3096 2985 2984 422 391 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3145 m0 *1 105.28,166.32
X$3145 2985 402 2984 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $3157 r0 *1 109.2,136.08
X$3157 2985 2984 403 429 430 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3160 r0 *1 104.72,146.16
X$3160 403 450 480 481 2985 2984 545 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3163 r0 *1 114.24,136.08
X$3163 2984 403 482 2985 404 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3168 m0 *1 109.2,136.08
X$3168 2984 429 2985 404 420 406 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3175 r0 *1 129.36,136.08
X$3175 2985 2984 407 405 430 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3177 m0 *1 73.92,206.64
X$3177 2984 665 2985 664 406 659 658 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $3179 r0 *1 101.92,176.4
X$3179 2984 601 2985 613 525 570 406 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $3181 m0 *1 201.6,216.72
X$3181 2985 2984 666 681 406 651 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3183 r0 *1 90.72,146.16
X$3183 2984 507 2985 497 479 450 406 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $3185 r0 *1 159.6,136.08
X$3185 2984 431 2985 432 425 406 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3190 r0 *1 107.52,186.48
X$3190 2985 526 406 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3192 m0 *1 190.4,176.4
X$3192 2985 531 540 2984 406 547 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $3194 m0 *1 192.64,166.32
X$3194 2984 531 2985 551 530 406 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3196 m0 *1 180.32,166.32
X$3196 2984 550 2985 406 564 529 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3214 r0 *1 126,146.16
X$3214 2984 407 483 2985 480 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3225 m0 *1 170.24,166.32
X$3225 2985 408 2984 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $3244 m0 *1 464.8,146.16
X$3244 2985 2984 414 409 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $3249 r0 *1 467.6,146.16
X$3249 2985 2984 409 466 506 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3254 m0 *1 443.52,146.16
X$3254 465 2984 439 410 2985 411 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3267 m0 *1 449.68,146.16
X$3267 2985 2984 413 462 414 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3283 m0 *1 460.32,156.24
X$3283 2985 414 511 2984 418 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3339 r0 *1 524.72,136.08
X$3339 441 2985 440 2984 421 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $3365 r0 *1 159.04,146.16
X$3365 2984 486 484 2985 427 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3370 r0 *1 148.4,156.24
X$3370 485 2985 527 2984 428 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $3378 r0 *1 84.56,176.4
X$3378 2984 547 526 430 2985 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $3381 r0 *1 165.2,166.32
X$3381 2985 2984 596 550 430 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3385 r0 *1 154.56,136.08
X$3385 2985 2984 433 431 430 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3390 m0 *1 85.68,206.64
X$3390 2984 659 2985 660 665 430 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3392 m0 *1 97.44,186.48
X$3392 2984 570 2985 614 601 430 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3395 m0 *1 87.92,156.24
X$3395 2984 450 2985 517 507 430 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3397 r0 *1 174.16,196.56
X$3397 2985 2984 650 430 662 647 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3408 m0 *1 160.72,146.16
X$3408 2984 433 501 2985 432 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3413 r0 *1 146.72,146.16
X$3413 433 2984 485 486 2985 481 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3424 r0 *1 185.36,146.16
X$3424 2985 478 452 434 487 455 2984 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $3431 m0 *1 192.64,146.16
X$3431 2984 453 2985 435 456 457 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3437 r0 *1 194.88,136.08
X$3437 2984 454 2985 456 455 436 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3439 m0 *1 212.8,146.16
X$3439 2984 438 437 2985 458 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3442 m0 *1 217.84,146.16
X$3442 460 2984 476 438 2985 487 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3450 r0 *1 441.28,156.24
X$3450 2985 2984 439 509 559 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3453 r0 *1 425.04,146.16
X$3453 2985 2984 439 461 489 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3455 m0 *1 425.04,176.4
X$3455 2984 439 558 2985 599 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3473 r0 *1 512.96,146.16
X$3473 2985 2984 523 492 441 503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3479 m0 *1 547.68,166.32
X$3479 560 2984 520 561 2985 442 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3488 m0 *1 600.32,146.16
X$3488 444 2984 471 495 2985 498 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3492 r0 *1 591.92,136.08
X$3492 2984 444 2985 469 445 447 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3498 r0 *1 599.76,136.08
X$3498 447 2985 2984 446 472 471 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $3507 r0 *1 224,136.08
X$3507 2985 448 458 2984 477 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3513 r0 *1 103.6,156.24
X$3513 570 2985 525 2984 449 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $3519 m0 *1 106.96,146.16
X$3519 450 2985 479 2984 473 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $3524 r0 *1 112,146.16
X$3524 450 480 481 484 2985 2984 482 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3534 m0 *1 183.12,146.16
X$3534 2985 2984 454 452 451 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3565 m0 *1 227.36,146.16
X$3565 2985 459 2984 542 477 460 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3577 m0 *1 440.16,166.32
X$3577 2985 2984 462 559 536 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3579 m0 *1 422.8,166.32
X$3579 2984 536 2985 462 558 489 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3581 r0 *1 446.32,156.24
X$3581 2984 509 2985 462 543 490 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3602 m0 *1 445.2,166.32
X$3602 2985 2984 465 510 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3606 r0 *1 34.16,367.92
X$3606 2985 2984 942 465 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3621 r0 *1 470.4,176.4
X$3621 2985 467 2984 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $3654 m0 *1 594.16,146.16
X$3654 2984 471 470 2985 469 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3657 r0 *1 596.4,146.16
X$3657 470 2985 2984 499 848 495 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $3667 m0 *1 904.4,337.68
X$3667 2985 2984 838 472 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $3678 r0 *1 137.2,146.16
X$3678 483 2985 548 2984 474 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $3682 r0 *1 204.4,146.16
X$3682 475 2984 487 502 2985 488 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3697 m0 *1 73.36,327.6
X$3697 2985 792 824 2984 478 812 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $3704 m0 *1 110.32,156.24
X$3704 2985 479 480 2984 481 508 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $3706 m0 *1 95.76,156.24
X$3706 2984 479 524 2985 517 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3718 r0 *1 131.04,146.16
X$3718 483 2984 481 484 2985 500 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3720 m0 *1 142.24,166.32
X$3720 2985 2984 481 548 528 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3741 m0 *1 120.96,176.4
X$3741 2985 2984 571 546 483 591 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3744 m0 *1 109.2,216.72
X$3744 570 2984 545 484 2985 674 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3746 r0 *1 152.88,146.16
X$3746 485 2984 486 484 2985 501 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3751 r0 *1 156.24,196.56
X$3751 624 625 648 649 2985 2984 484 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3753 m0 *1 125.44,206.64
X$3753 2984 647 484 2985 645 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3759 m0 *1 117.6,206.64
X$3759 2984 661 2985 484 644 592 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3772 m0 *1 139.44,176.4
X$3772 2985 2984 593 572 485 573 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3779 m0 *1 148.4,166.32
X$3779 2985 2984 486 527 528 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3786 m0 *1 119.84,196.56
X$3786 2985 2984 643 644 486 645 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3802 r0 *1 62.72,317.52
X$3802 798 791 602 488 2985 2984 810 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3806 r0 *1 221.76,156.24
X$3806 2984 488 2985 521 533 532 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3812 m0 *1 18.48,357.84
X$3812 2985 2984 876 489 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3828 r0 *1 566.16,156.24
X$3828 2985 2984 537 493 515 518 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3834 r0 *1 580.72,156.24
X$3834 2984 515 494 2985 539 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3846 r0 *1 610.96,176.4
X$3846 585 2985 2984 833 496 587 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $3861 r0 *1 549.92,156.24
X$3861 2984 520 514 2985 499 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3888 r0 *1 92.96,216.72
X$3888 570 508 672 545 2985 2984 702 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3890 m0 *1 92.96,216.72
X$3890 570 2984 508 545 2985 673 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3892 r0 *1 95.76,166.32
X$3892 2985 2984 508 525 545 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3895 m0 *1 150.64,196.56
X$3895 620 574 621 648 2985 2984 508 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3921 m0 *1 531.44,156.24
X$3921 2985 2984 522 513 520 519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3942 r0 *1 564.48,176.4
X$3942 610 2984 611 516 2985 561 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3970 r0 *1 238.56,156.24
X$3970 2985 534 2984 521 569 600 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3983 r0 *1 35.84,206.64
X$3983 2984 684 524 2985 657 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3986 m0 *1 44.8,277.2
X$3986 2984 720 524 2985 735 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3989 r0 *1 85.68,206.64
X$3989 2984 524 658 2985 660 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3991 m0 *1 65.52,206.64
X$3991 2985 2984 524 647 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3993 r0 *1 28.56,388.08
X$3993 970 944 968 2985 2984 524 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $3995 r0 *1 94.08,176.4
X$3995 2984 525 524 2985 614 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3997 m0 *1 75.04,226.8
X$3997 2985 2984 524 671 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $4000 m0 *1 82.88,277.2
X$4000 2984 730 524 2985 733 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4019 m0 *1 133.84,287.28
X$4019 2985 526 675 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4021 r0 *1 50.96,378
X$4021 2985 1014 526 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4025 m0 *1 76.16,236.88
X$4025 2985 2984 526 687 547 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4027 m0 *1 122.08,166.32
X$4027 2985 2984 546 547 526 548 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4029 r0 *1 136.64,176.4
X$4029 2985 2984 572 547 526 527 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4031 m0 *1 138.88,317.52
X$4031 2985 526 592 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4034 m0 *1 28.56,226.8
X$4034 2984 683 2985 526 669 684 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4036 r0 *1 48.72,257.04
X$4036 2984 683 2985 526 721 720 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4057 r0 *1 146.72,176.4
X$4057 2985 2984 573 527 592 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4065 m0 *1 147.84,176.4
X$4065 2984 574 575 2985 528 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4068 r0 *1 180.88,176.4
X$4068 2984 596 637 2985 529 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4078 r0 *1 226.8,166.32
X$4078 2985 2984 567 532 566 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4085 m0 *1 218.4,166.32
X$4085 2985 542 565 533 552 2984 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $4088 m0 *1 242.48,166.32
X$4088 2985 2984 554 534 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4092 r0 *1 234.64,166.32
X$4092 2984 567 2985 568 606 534 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4095 m0 *1 247.52,166.32
X$4095 2985 556 2984 568 535 555 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4099 r0 *1 244.72,166.32
X$4099 2984 555 2985 535 569 557 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4112 m0 *1 600.32,186.48
X$4112 583 2985 2984 634 925 538 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $4114 m0 *1 609.84,186.48
X$4114 2984 538 2985 586 589 632 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4116 r0 *1 617.12,166.32
X$4116 562 2985 2984 677 539 588 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $4121 m0 *1 171.36,186.48
X$4121 623 2984 596 540 2985 648 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4123 r0 *1 190.4,176.4
X$4123 2984 540 636 2985 551 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4125 m0 *1 177.52,186.48
X$4125 623 2984 540 621 2985 637 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4157 m0 *1 195.44,216.72
X$4157 2984 663 547 2985 681 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4159 r0 *1 63.84,388.08
X$4159 2985 1000 2984 547 1001 813 647 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4165 m0 *1 47.04,398.16
X$4165 2985 1034 999 998 2984 547 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $4184 m0 *1 129.36,176.4
X$4184 2985 2984 591 548 592 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4188 m0 *1 128.24,398.16
X$4188 1021 1003 1039 549 2984 2985 949 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $4203 r0 *1 224,176.4
X$4203 2985 552 628 578 598 606 2984 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $4206 m0 *1 222.32,176.4
X$4206 604 2984 577 553 2985 578 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4208 m0 *1 213.36,176.4
X$4208 2985 2984 553 576 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4213 r0 *1 245.84,176.4
X$4213 607 554 557 555 2985 2984 619 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4227 m0 *1 241.92,176.4
X$4227 2985 2984 556 600 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4243 r0 *1 547.12,176.4
X$4243 2984 560 608 2985 615 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4248 m0 *1 526.96,176.4
X$4248 2985 2984 580 581 560 597 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4261 m0 *1 607.04,176.4
X$4261 588 585 586 590 562 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $4266 m0 *1 600.32,176.4
X$4266 582 2985 583 594 2984 563 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $4276 r0 *1 68.32,327.6
X$4276 2984 811 2985 792 813 565 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4318 m0 *1 157.92,176.4
X$4318 2984 574 575 2985 595 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4320 m0 *1 159.04,206.64
X$4320 2984 620 574 2985 649 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4324 m0 *1 141.68,226.8
X$4324 2985 2984 694 688 574 695 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4339 r0 *1 142.24,216.72
X$4339 2984 661 2985 675 688 575 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4343 r0 *1 154.56,186.48
X$4343 620 2984 621 648 2985 575 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4346 r0 *1 150.08,216.72
X$4346 2984 575 671 2985 695 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4352 m0 *1 216.72,176.4
X$4352 2985 2984 598 576 618 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4359 m0 *1 226.24,186.48
X$4359 605 2984 578 619 2985 602 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4362 r0 *1 162.96,186.48
X$4362 2984 620 622 2985 579 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4373 r0 *1 599.2,176.4
X$4373 2985 582 584 612 615 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4388 r0 *1 609.28,186.48
X$4388 586 2985 2984 633 900 632 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $4402 m0 *1 593.6,176.4
X$4402 2985 2984 594 590 589 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4417 m0 *1 45.92,226.8
X$4417 2984 683 2985 686 685 592 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4420 r0 *1 49.84,246.96
X$4420 2984 683 2985 701 713 592 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4424 m0 *1 64.96,297.36
X$4424 2984 683 2985 743 741 592 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4427 m0 *1 103.6,307.44
X$4427 2984 661 2985 674 782 592 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4429 m0 *1 138.88,206.64
X$4429 2984 661 2985 622 646 592 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4431 r0 *1 80.64,317.52
X$4431 2984 661 2985 772 793 592 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4433 m0 *1 103.6,327.6
X$4433 2984 661 2985 775 800 592 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4490 m0 *1 206.64,186.48
X$4490 2985 603 2984 618 640 604 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4501 m0 *1 224.56,196.56
X$4501 2985 2984 605 627 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4522 r0 *1 563.92,186.48
X$4522 2984 610 609 2985 633 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4532 r0 *1 553.84,186.48
X$4532 2985 2984 654 629 610 639 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4538 m0 *1 582.96,186.48
X$4538 2984 611 616 2985 634 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4542 r0 *1 573.44,186.48
X$4542 2985 2984 630 635 611 631 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4548 m0 *1 906.08,367.92
X$4548 2985 2984 940 612 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $4573 m0 *1 190.96,186.48
X$4573 2984 623 621 2985 617 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4592 r0 *1 141.68,196.56
X$4592 2985 2984 652 646 620 653 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4604 m0 *1 165.2,236.88
X$4604 2984 621 671 2985 692 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4606 r0 *1 156.24,226.8
X$4606 2984 661 2985 675 689 621 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4608 m0 *1 192.08,206.64
X$4608 624 2984 663 662 2985 621 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4617 r0 *1 150.08,196.56
X$4617 2984 647 622 2985 653 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4620 m0 *1 162.4,196.56
X$4620 624 2984 625 648 2985 622 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4629 r0 *1 190.4,186.48
X$4629 624 2984 623 625 2985 636 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4631 r0 *1 164.08,226.8
X$4631 2985 2984 697 689 623 692 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4647 r0 *1 196.56,186.48
X$4647 2984 624 625 2985 638 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4650 m0 *1 159.04,226.8
X$4650 2985 2984 696 676 624 690 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4659 r0 *1 162.96,216.72
X$4659 2984 625 671 2985 690 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4665 m0 *1 201.6,206.64
X$4665 2985 625 651 662 663 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $4668 r0 *1 155.12,216.72
X$4668 2984 661 2985 675 676 625 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4679 r0 *1 223.44,186.48
X$4679 2984 626 2985 641 628 627 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4681 r0 *1 220.64,196.56
X$4681 2985 2984 655 626 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4732 r0 *1 208.32,196.56
X$4732 2985 2984 662 642 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4744 r0 *1 113.68,307.44
X$4744 2984 647 674 2985 783 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4746 r0 *1 57.12,388.08
X$4746 2985 2984 647 1089 813 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4750 m0 *1 89.04,327.6
X$4750 2984 647 772 2985 826 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4753 r0 *1 109.76,317.52
X$4753 2984 647 775 2985 799 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4756 r0 *1 58.24,236.88
X$4756 2984 647 701 2985 711 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4761 r0 *1 71.68,287.28
X$4761 2984 647 743 2985 751 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4793 r0 *1 211.68,196.56
X$4793 2985 2984 651 656 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4819 m0 *1 31.36,216.72
X$4819 2985 2984 678 669 668 657 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4824 r0 *1 73.92,216.72
X$4824 659 2985 658 2984 682 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $4826 m0 *1 68.88,236.88
X$4826 2985 658 705 2984 702 703 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4845 r0 *1 77.84,226.8
X$4845 2985 687 661 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4848 m0 *1 96.32,287.28
X$4848 2984 661 2985 675 746 744 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4857 r0 *1 59.36,408.24
X$4857 661 2985 1103 1104 2984 1117 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $4908 r0 *1 57.68,246.96
X$4908 2985 667 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $4928 m0 *1 28,246.96
X$4928 668 698 670 700 2985 2984 715 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4934 r0 *1 26.32,226.8
X$4934 2984 668 684 2985 693 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4938 m0 *1 29.68,236.88
X$4938 698 670 700 702 2985 2984 684 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4940 r0 *1 43.68,216.72
X$4940 2985 2984 679 685 670 680 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4943 r0 *1 30.24,236.88
X$4943 670 2984 700 701 2985 699 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4945 r0 *1 36.4,236.88
X$4945 2984 670 686 2985 756 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4953 r0 *1 52.08,216.72
X$4953 2984 671 686 2985 680 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4955 m0 *1 21.84,267.12
X$4955 2984 671 718 2985 723 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4958 m0 *1 42,287.28
X$4958 2984 671 738 2985 750 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4961 r0 *1 19.04,287.28
X$4961 2984 671 754 2985 747 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4966 m0 *1 81.76,246.96
X$4966 2984 671 704 2985 707 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4968 r0 *1 92.96,287.28
X$4968 2984 744 671 2985 752 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4971 m0 *1 19.04,236.88
X$4971 2984 671 699 2985 710 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4989 r0 *1 39.2,277.2
X$4989 728 2984 672 673 2985 738 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4992 m0 *1 42,267.12
X$4992 719 2984 672 673 2985 720 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4994 r0 *1 67.76,267.12
X$4994 2984 672 674 2985 701 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4997 m0 *1 80.64,287.28
X$4997 731 2984 742 757 2985 672 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5005 r0 *1 91.84,307.44
X$5005 774 759 758 673 2985 2984 772 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5007 m0 *1 92.4,297.36
X$5007 2984 758 673 2985 744 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5009 m0 *1 74.48,287.28
X$5009 742 2984 757 673 2985 730 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5024 m0 *1 75.6,297.36
X$5024 2984 757 674 2985 743 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5028 r0 *1 81.76,307.44
X$5028 2984 758 674 2985 781 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5030 r0 *1 107.52,307.44
X$5030 759 2984 758 674 2985 775 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5040 r0 *1 21.28,267.12
X$5040 2984 683 2985 718 732 675 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5043 r0 *1 73.92,236.88
X$5043 2984 687 2985 704 712 675 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5048 m0 *1 75.04,277.2
X$5048 2984 683 2985 675 736 730 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5050 r0 *1 21.28,236.88
X$5050 2984 683 2985 699 709 675 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5052 m0 *1 21.28,297.36
X$5052 2984 683 2985 754 762 675 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5056 m0 *1 34.16,287.28
X$5056 2984 683 2985 738 749 675 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5072 m0 *1 894.32,357.84
X$5072 2985 2984 911 677 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $5092 m0 *1 26.88,347.76
X$5092 2985 873 857 871 682 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5102 r0 *1 70,226.8
X$5102 2985 2984 687 683 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5136 m0 *1 43.68,236.88
X$5136 2984 700 702 2985 686 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5155 m0 *1 137.2,257.04
X$5155 2985 691 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $5185 m0 *1 3.36,327.6
X$5185 2985 785 786 802 693 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5207 m0 *1 17.36,246.96
X$5207 2984 698 699 2985 714 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5211 m0 *1 9.52,236.88
X$5211 2985 2984 708 709 698 710 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5226 r0 *1 30.8,257.04
X$5226 2984 700 701 2985 739 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5230 r0 *1 49.84,236.88
X$5230 2985 2984 716 713 700 711 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5241 r0 *1 25.76,257.04
X$5241 2984 715 701 2985 718 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5243 r0 *1 67.2,236.88
X$5243 2984 701 703 2985 704 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5248 r0 *1 29.12,277.2
X$5248 727 2984 728 701 2985 754 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5262 m0 *1 58.24,267.12
X$5262 2984 729 719 2985 703 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5267 m0 *1 68.88,246.96
X$5267 2984 705 704 2985 717 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5276 r0 *1 81.76,236.88
X$5276 2985 2984 706 712 705 707 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5309 m0 *1 11.2,317.52
X$5309 794 2985 2984 788 714 768 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5315 m0 *1 29.12,277.2
X$5315 748 727 726 715 2985 2984 719 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5317 r0 *1 29.12,267.12
X$5317 2984 726 715 2985 728 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5329 r0 *1 38.08,337.68
X$5329 2985 855 860 847 717 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5337 m0 *1 11.2,267.12
X$5337 2984 726 718 2985 767 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5353 m0 *1 48.16,267.12
X$5353 2984 729 720 2985 722 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5360 m0 *1 49.84,277.2
X$5360 2985 2984 734 721 729 735 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5363 m0 *1 36.4,357.84
X$5363 2985 896 861 895 722 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5367 r0 *1 10.08,267.12
X$5367 2985 2984 725 732 726 723 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5372 r0 *1 75.6,267.12
X$5372 2985 2984 724 736 731 733 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5387 r0 *1 25.2,287.28
X$5387 2984 727 738 2985 753 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5392 r0 *1 35.28,287.28
X$5392 2985 2984 737 749 727 750 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5415 r0 *1 76.72,277.2
X$5415 2984 731 730 2985 780 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5457 r0 *1 34.16,307.44
X$5457 770 2985 2984 776 739 771 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5461 r0 *1 63.28,287.28
X$5461 2985 2984 740 741 742 751 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5467 r0 *1 72.24,297.36
X$5467 2984 742 743 2985 763 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5490 r0 *1 89.6,297.36
X$5490 2984 759 744 2985 764 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5496 r0 *1 101.92,287.28
X$5496 2985 2984 745 746 759 752 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5500 r0 *1 11.2,297.36
X$5500 2985 2984 761 762 748 747 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5506 r0 *1 19.6,297.36
X$5506 2984 748 754 2985 755 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5532 r0 *1 8.96,327.6
X$5532 2985 804 805 803 753 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5544 r0 *1 23.52,347.76
X$5544 894 2985 2984 877 755 858 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5548 r0 *1 22.4,307.44
X$5548 2985 779 769 778 756 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5555 m0 *1 90.16,307.44
X$5555 773 774 759 758 2985 2984 757 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5566 m0 *1 111.44,307.44
X$5566 2985 2984 760 782 758 783 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5596 m0 *1 74.48,347.76
X$5596 2985 875 864 856 763 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5599 m0 *1 62.16,357.84
X$5599 879 2985 2984 917 764 881 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5604 r0 *1 2.24,307.44
X$5604 765 2984 2985 776 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5607 r0 *1 10.64,307.44
X$5607 766 2984 2985 778 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5611 r0 *1 10.08,317.52
X$5611 2985 795 796 787 767 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $5615 m0 *1 15.12,327.6
X$5615 2985 796 768 786 805 807 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $5619 m0 *1 28,317.52
X$5619 2985 779 2984 822 770 769 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5621 r0 *1 42,317.52
X$5621 2985 797 769 2984 790 771 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $5624 r0 *1 33.04,317.52
X$5624 2985 821 769 2984 771 789 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $5636 r0 *1 88.48,317.52
X$5636 2984 773 772 2985 827 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5645 m0 *1 80.64,327.6
X$5645 2985 2984 815 793 773 826 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5652 m0 *1 94.08,327.6
X$5652 2984 774 775 2985 849 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5659 r0 *1 114.8,317.52
X$5659 2985 2984 816 800 774 799 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5674 m0 *1 39.76,317.52
X$5674 789 2985 2984 777 780 790 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5677 m0 *1 2.24,317.52
X$5677 784 2984 2985 777 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5692 r0 *1 73.36,357.84
X$5692 920 2985 2984 989 781 922 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5705 r0 *1 2.8,317.52
X$5705 2985 785 2984 845 794 786 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5715 m0 *1 3.36,347.76
X$5715 851 2984 2985 787 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5718 r0 *1 10.64,337.68
X$5718 828 2984 2985 788 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5725 m0 *1 68.88,347.76
X$5725 2985 2984 791 862 863 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5727 r0 *1 58.8,327.6
X$5727 791 798 809 825 808 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $5740 m0 *1 11.76,337.68
X$5740 2985 804 2984 829 795 805 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5746 r0 *1 20.72,327.6
X$5746 2985 2984 805 806 796 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5751 m0 *1 52.64,327.6
X$5751 798 2984 2985 807 823 797 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $5760 m0 *1 53.76,337.68
X$5760 2985 878 2984 830 812 832 798 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $5773 m0 *1 2.24,337.68
X$5773 801 2984 2985 802 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5779 r0 *1 2.24,337.68
X$5779 852 2984 2985 803 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5792 m0 *1 19.04,337.68
X$5792 2984 829 2985 806 830 845 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5797 m0 *1 32.48,327.6
X$5797 2985 809 822 821 823 807 2984 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $5801 m0 *1 60.48,327.6
X$5801 2985 2984 824 809 808 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5805 r0 *1 30.24,337.68
X$5805 2984 846 2985 831 808 854 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5814 m0 *1 66.08,327.6
X$5814 2985 810 2984 811 825 812 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5829 m0 *1 42.56,388.08
X$5829 996 973 813 974 997 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $5881 r0 *1 916.72,327.6
X$5881 2985 2984 817 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $5883 r0 *1 918.96,327.6
X$5883 817 839 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5885 m0 *1 930.72,327.6
X$5885 818 892 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5887 m0 *1 928.48,327.6
X$5887 2985 2984 818 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $5889 r0 *1 934.08,327.6
X$5889 820 819 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5894 r0 *1 930.72,327.6
X$5894 2985 2984 820 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $5903 r0 *1 38.64,347.76
X$5903 2985 860 858 861 857 823 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $5922 m0 *1 86.24,347.76
X$5922 865 2985 2984 859 827 883 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5937 m0 *1 38.64,347.76
X$5937 2984 857 2985 855 831 860 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5942 r0 *1 68.88,347.76
X$5942 2984 921 832 862 897 882 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $5948 m0 *1 896,347.76
X$5948 2985 2984 867 833 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $5952 m0 *1 911.68,347.76
X$5952 2985 2984 834 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $5954 r0 *1 912.8,337.68
X$5954 834 836 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5956 m0 *1 917.28,337.68
X$5956 2985 2984 835 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $5958 m0 *1 920.08,337.68
X$5958 835 891 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5962 r0 *1 924.56,337.68
X$5962 837 840 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5964 r0 *1 922.32,337.68
X$5964 2985 2984 837 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $5972 m0 *1 934.08,337.68
X$5972 841 844 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5975 m0 *1 929.6,337.68
X$5975 2985 2984 841 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $5978 m0 *1 931.84,337.68
X$5978 2985 2984 842 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $5980 r0 *1 934.08,337.68
X$5980 842 870 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5982 r0 *1 904.96,337.68
X$5982 2985 2984 843 848 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $5991 m0 *1 23.52,347.76
X$5991 2985 2984 873 846 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5996 m0 *1 5.04,357.84
X$5996 905 2984 2985 847 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6005 m0 *1 89.04,357.84
X$6005 898 2985 2984 880 849 899 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $6018 m0 *1 11.76,347.76
X$6018 853 2984 2985 871 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6021 m0 *1 26.88,357.84
X$6021 894 861 896 854 855 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $6032 r0 *1 34.72,398.16
X$6032 1037 2984 2985 856 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6037 m0 *1 48.16,357.84
X$6037 857 861 860 858 2985 2984 878 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6052 m0 *1 10.64,408.24
X$6052 1062 2984 2985 859 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6071 r0 *1 87.92,347.76
X$6071 2985 862 883 2984 864 899 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6078 m0 *1 73.92,357.84
X$6078 2985 2984 881 863 922 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6082 m0 *1 79.52,357.84
X$6082 2985 882 883 2984 864 898 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6087 r0 *1 79.52,347.76
X$6087 2985 875 2984 897 865 864 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6092 r0 *1 915.04,347.76
X$6092 866 893 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6094 r0 *1 912.8,347.76
X$6094 2985 2984 866 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6098 m0 *1 918.96,347.76
X$6098 874 868 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6103 m0 *1 932.4,347.76
X$6103 869 916 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6105 m0 *1 930.16,347.76
X$6105 2985 2984 869 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6113 r0 *1 11.76,347.76
X$6113 872 2984 2985 903 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6122 r0 *1 910.56,347.76
X$6122 2985 2984 874 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6134 m0 *1 15.68,367.92
X$6134 904 2984 2985 877 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6138 r0 *1 61.6,357.84
X$6138 2985 879 2984 921 920 881 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6143 m0 *1 2.24,408.24
X$6143 1061 2984 2985 880 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6162 m0 *1 902.16,357.84
X$6162 2985 2984 884 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6164 m0 *1 904.4,357.84
X$6164 884 914 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6166 m0 *1 918.4,357.84
X$6166 885 912 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6168 m0 *1 916.16,357.84
X$6168 2985 2984 885 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6170 r0 *1 924.56,347.76
X$6170 886 915 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6173 m0 *1 927.92,357.84
X$6173 2985 2984 886 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6176 r0 *1 934.08,347.76
X$6176 887 890 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6178 m0 *1 931.84,357.84
X$6178 2985 2984 887 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6180 r0 *1 934.64,357.84
X$6180 2985 2984 888 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6182 m0 *1 934.08,357.84
X$6182 888 889 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6199 r0 *1 21.28,357.84
X$6199 902 2984 2985 895 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6219 r0 *1 899.36,357.84
X$6219 2985 2984 910 900 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $6224 m0 *1 35.84,367.92
X$6224 919 2984 2985 901 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6242 r0 *1 36.96,428.4
X$6242 2985 2984 906 gf180mcu_fd_sc_mcu9t5v0__clkinv_1
* cell instance $6272 r0 *1 877.52,367.92
X$6272 2985 2984 907 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6274 m0 *1 876.96,367.92
X$6274 907 924 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6276 m0 *1 896.56,367.92
X$6276 908 935 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6278 m0 *1 893.2,367.92
X$6278 2985 2984 908 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6280 r0 *1 917.28,357.84
X$6280 909 913 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6283 m0 *1 913.92,357.84
X$6283 2985 2984 909 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6301 m0 *1 2.24,367.92
X$6301 927 2984 2985 917 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6305 r0 *1 2.24,398.16
X$6305 918 2984 2985 1016 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6326 m0 *1 930.16,367.92
X$6326 2985 2984 923 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6328 m0 *1 934.08,367.92
X$6328 923 938 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6336 r0 *1 926.8,357.84
X$6336 2985 2984 941 925 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $6341 m0 *1 917.84,367.92
X$6341 926 939 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6344 m0 *1 913.92,367.92
X$6344 2985 2984 926 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6349 r0 *1 94.64,378
X$6349 950 2984 928 929 2985 1015 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6351 m0 *1 102.48,378
X$6351 930 2985 928 2984 964 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6356 r0 *1 23.52,378
X$6356 928 2985 969 945 2984 960 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $6365 m0 *1 72.8,378
X$6365 2985 2984 929 947 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6367 r0 *1 101.92,367.92
X$6367 930 2985 2984 950 929 2988 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $6377 r0 *1 884.24,367.92
X$6377 931 956 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6379 r0 *1 882,367.92
X$6379 2985 2984 931 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6381 r0 *1 907.2,367.92
X$6381 2985 2984 932 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6383 r0 *1 909.44,367.92
X$6383 932 937 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6385 r0 *1 920.08,367.92
X$6385 2985 2984 933 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6387 r0 *1 922.32,367.92
X$6387 933 957 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6389 r0 *1 931.84,367.92
X$6389 934 936 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6391 m0 *1 938,378
X$6391 2985 2984 934 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6409 r0 *1 2.24,388.08
X$6409 943 2984 2985 966 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6414 m0 *1 29.12,428.4
X$6414 2985 2984 944 1087 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6416 r0 *1 29.68,398.16
X$6416 2985 2984 944 1020 970 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6419 r0 *1 47.6,408.24
X$6419 973 998 1088 944 2985 2984 1103 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6421 m0 *1 44.24,408.24
X$6421 2985 2984 944 1038 996 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6425 r0 *1 34.16,378
X$6425 2985 2984 961 971 944 972 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6427 r0 *1 40.88,388.08
X$6427 2985 2984 968 997 944 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6429 m0 *1 29.68,398.16
X$6429 2984 1020 2985 972 1033 944 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6431 r0 *1 27.44,418.32
X$6431 2985 2984 1135 944 1083 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6443 r0 *1 68.32,378
X$6443 2985 2984 946 945 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6449 r0 *1 71.68,378
X$6449 946 2985 2984 975 947 963 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $6453 r0 *1 81.2,378
X$6453 2984 963 949 2985 948 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6458 m0 *1 93.52,398.16
X$6458 2984 949 1002 2985 1035 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6460 r0 *1 105.84,378
X$6460 2984 949 964 2985 991 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6463 r0 *1 110.88,378
X$6463 2984 975 949 2985 965 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6472 r0 *1 101.92,378
X$6472 2985 2984 950 975 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6481 m0 *1 902.16,378
X$6481 951 959 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6483 m0 *1 899.92,378
X$6483 2985 2984 951 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6485 r0 *1 903.84,378
X$6485 952 979 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6487 r0 *1 901.6,378
X$6487 2985 2984 952 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6489 m0 *1 914.48,378
X$6489 953 958 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6491 m0 *1 912.24,378
X$6491 2985 2984 953 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6493 m0 *1 926.24,378
X$6493 2985 2984 954 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6495 m0 *1 928.48,378
X$6495 954 985 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6497 r0 *1 929.6,378
X$6497 955 984 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6499 r0 *1 927.36,378
X$6499 2985 2984 955 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6513 r0 *1 42.56,378
X$6513 2985 2984 962 961 974 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6534 m0 *1 10.64,388.08
X$6534 988 2984 2985 967 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6538 m0 *1 2.24,388.08
X$6538 993 2984 2985 968 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6544 r0 *1 87.92,388.08
X$6544 969 2985 1015 2984 1002 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6555 m0 *1 33.04,388.08
X$6555 2984 972 2985 970 971 973 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6557 m0 *1 35.84,418.32
X$6557 2984 1116 1088 2985 970 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6567 m0 *1 38.08,398.16
X$6567 2985 2984 998 972 999 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6574 r0 *1 21.28,408.24
X$6574 1110 2984 2985 973 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $6581 r0 *1 40.32,408.24
X$6581 2985 1034 973 2984 1063 1087 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6583 r0 *1 49.28,418.32
X$6583 2985 973 1087 2984 1136 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6597 m0 *1 868.56,388.08
X$6597 976 990 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6599 m0 *1 866.32,388.08
X$6599 2985 2984 976 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6601 m0 *1 880.88,388.08
X$6601 2985 2984 977 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6603 m0 *1 883.12,388.08
X$6603 977 986 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6605 m0 *1 901.6,388.08
X$6605 2985 2984 978 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6607 m0 *1 903.84,388.08
X$6607 978 987 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6611 r0 *1 916.16,378
X$6611 980 982 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6613 m0 *1 913.36,388.08
X$6613 2985 2984 980 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6615 m0 *1 917.28,388.08
X$6615 2985 2984 981 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6617 m0 *1 920.08,388.08
X$6617 981 1010 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6621 r0 *1 931.84,388.08
X$6621 2985 2984 983 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6623 m0 *1 932.96,388.08
X$6623 983 1012 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6638 m0 *1 19.04,388.08
X$6638 992 2984 2985 989 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6654 r0 *1 10.64,388.08
X$6654 994 2984 2985 1036 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6659 r0 *1 19.04,388.08
X$6659 995 2984 2985 1017 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6666 m0 *1 35.84,408.24
X$6666 2985 2984 1086 996 1083 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6671 r0 *1 48.16,388.08
X$6671 998 2985 999 997 2984 1014 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $6677 r0 *1 54.32,428.4
X$6677 2985 2984 998 1116 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6681 r0 *1 35.84,418.32
X$6681 2985 2984 998 1083 1088 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6688 m0 *1 32.48,428.4
X$6688 2985 998 1150 2984 1208 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6698 r0 *1 39.2,428.4
X$6698 1116 2984 999 1136 2985 1231 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6700 m0 *1 40.88,418.32
X$6700 1116 999 1087 1115 2985 2984 1104 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6702 r0 *1 35.28,408.24
X$6702 2985 2984 1116 1086 999 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6706 m0 *1 48.16,418.32
X$6706 2985 2984 999 1088 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6711 m0 *1 43.68,438.48
X$6711 2984 1213 2985 1214 1232 999 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6726 m0 *1 60.48,398.16
X$6726 2985 2984 1019 1000 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6733 m0 *1 129.36,428.4
X$6733 1154 2984 1133 1176 2985 1003 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6735 r0 *1 873.6,388.08
X$6735 1004 1011 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6737 r0 *1 871.36,388.08
X$6737 2985 2984 1004 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6739 r0 *1 886.48,388.08
X$6739 2985 2984 1005 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6741 r0 *1 888.72,388.08
X$6741 1005 1008 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6743 r0 *1 914.48,388.08
X$6743 2985 2984 1006 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6745 r0 *1 916.72,388.08
X$6745 1006 1032 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6747 m0 *1 912.24,398.16
X$6747 1028 1007 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6752 m0 *1 937.44,398.16
X$6752 2985 2984 1009 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6754 r0 *1 934.08,388.08
X$6754 1009 1013 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6774 m0 *1 2.24,398.16
X$6774 1019 2984 2985 1018 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6779 r0 *1 44.24,398.16
X$6779 1063 2984 1019 1038 2985 1021 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6798 r0 *1 458.64,418.32
X$6798 2985 1022 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $6822 r0 *1 525.84,398.16
X$6822 2985 2984 1023 1042 1024 1044 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6824 r0 *1 536.48,408.24
X$6824 2984 1024 1092 2985 1109 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6826 m0 *1 538.16,418.32
X$6826 1024 2984 1067 1120 2985 1069 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6833 r0 *1 547.68,398.16
X$6833 2985 2984 1025 1045 1026 1046 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6835 m0 *1 556.08,408.24
X$6835 2984 1026 1069 2985 1071 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6841 m0 *1 880.88,398.16
X$6841 1027 1031 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6843 r0 *1 881.44,398.16
X$6843 2985 2984 1027 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6846 m0 *1 910,398.16
X$6846 2985 2984 1028 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6848 m0 *1 927.92,398.16
X$6848 1029 1030 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6850 m0 *1 925.68,398.16
X$6850 2985 2984 1029 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6864 r0 *1 45.92,428.4
X$6864 2985 2984 1214 1034 1116 1136 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6866 r0 *1 40.88,418.32
X$6866 2985 2984 1150 1034 1088 1136 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6881 r0 *1 126,448.56
X$6881 1390 2984 1315 1345 2985 1039 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6885 m0 *1 225.12,428.4
X$6885 2985 2984 1040 1187 1156 1162 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6888 r0 *1 503.44,408.24
X$6888 2984 1041 1091 2985 1084 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6891 m0 *1 502.88,428.4
X$6891 1041 2984 1221 1119 2985 1191 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6894 m0 *1 495.04,408.24
X$6894 2985 2984 1057 1065 1041 1085 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6897 r0 *1 524.72,408.24
X$6897 2984 1090 2985 1092 1042 1068 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6900 m0 *1 551.04,408.24
X$6900 2984 1043 1069 2985 1046 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6902 m0 *1 530.32,408.24
X$6902 2984 1043 1092 2985 1044 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6904 m0 *1 503.44,408.24
X$6904 2984 1043 1091 2985 1085 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6906 m0 *1 552.72,478.8
X$6906 2984 1043 1464 2985 1486 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6909 m0 *1 542.08,509.04
X$6909 2984 1645 1043 2985 1704 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6911 r0 *1 491.68,468.72
X$6911 2984 1394 1043 2985 1465 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6913 m0 *1 482.16,458.64
X$6913 2984 1043 1299 2985 1384 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6915 r0 *1 523.6,498.96
X$6915 2984 1567 1043 2985 1664 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6917 r0 *1 481.04,428.4
X$6917 2984 1043 1139 2985 1138 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6919 m0 *1 495.6,478.8
X$6919 2985 2984 1244 1043 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $6921 m0 *1 533.68,559.44
X$6921 2984 1971 1043 2985 1973 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6938 r0 *1 546,408.24
X$6938 2984 1090 2985 1069 1045 1068 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6943 r0 *1 855.12,398.16
X$6943 2985 2984 1047 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6945 r0 *1 857.36,398.16
X$6945 1047 1055 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6947 r0 *1 867.44,398.16
X$6947 2985 2984 1048 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6949 r0 *1 870.8,398.16
X$6949 1048 1053 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6951 r0 *1 884.8,398.16
X$6951 2985 2984 1049 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6953 r0 *1 887.04,398.16
X$6953 1049 1050 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6957 r0 *1 917.28,398.16
X$6957 1056 1051 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6960 r0 *1 934.08,398.16
X$6960 1052 1080 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6962 r0 *1 931.84,398.16
X$6962 2985 2984 1052 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6966 m0 *1 879.76,408.24
X$6966 1073 1054 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6975 r0 *1 913.36,398.16
X$6975 2985 2984 1056 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $6982 r0 *1 10.64,408.24
X$6982 1064 2984 2985 1058 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6985 r0 *1 2.24,408.24
X$6985 1059 2984 2985 1063 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6988 m0 *1 26.32,408.24
X$6988 1082 2984 2985 1060 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7000 r0 *1 170.8,408.24
X$7000 2984 1064 1108 2985 1107 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7007 r0 *1 491.68,408.24
X$7007 2984 1090 2985 1091 1065 1068 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7011 m0 *1 518.56,428.4
X$7011 2985 2984 1066 1194 1067 1163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7015 m0 *1 544.32,418.32
X$7015 2984 1067 1120 2985 1134 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7018 m0 *1 510.72,428.4
X$7018 2984 1067 1191 2985 1193 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7025 r0 *1 509.04,438.48
X$7025 2985 1223 1068 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $7028 r0 *1 518.56,458.64
X$7028 2984 1090 2985 1068 1334 1300 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7030 r0 *1 485.52,458.64
X$7030 2984 1090 2985 1068 1393 1394 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7033 r0 *1 488.32,418.32
X$7033 2984 1090 2985 1139 1152 1068 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7038 m0 *1 526.4,509.04
X$7038 2984 1487 2985 1068 1665 1567 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7040 m0 *1 534.24,509.04
X$7040 2984 1487 2985 1068 1671 1645 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7042 m0 *1 530.88,488.88
X$7042 2984 1487 2985 1068 1596 1501 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7044 r0 *1 531.44,559.44
X$7044 2984 1487 2985 1068 1972 1971 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7069 m0 *1 577.92,418.32
X$7069 2985 1070 2984 1197 1106 1072 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7078 r0 *1 585.76,418.32
X$7078 2985 2984 1072 1226 1141 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7081 r0 *1 578.48,418.32
X$7081 1072 1121 1141 1094 2985 2984 1140 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7088 m0 *1 877.52,408.24
X$7088 2985 2984 1073 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7090 m0 *1 892.08,408.24
X$7090 2985 2984 1074 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7092 m0 *1 894.32,408.24
X$7092 1074 1102 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7094 m0 *1 910,408.24
X$7094 1075 1101 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7096 m0 *1 907.76,408.24
X$7096 2985 2984 1075 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7098 m0 *1 919.52,408.24
X$7098 1076 1078 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7100 r0 *1 921.76,408.24
X$7100 2985 2984 1076 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7102 m0 *1 931.28,408.24
X$7102 1077 1079 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7104 m0 *1 929.04,408.24
X$7104 2985 2984 1077 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7112 r0 *1 879.76,408.24
X$7112 1095 1081 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7123 m0 *1 27.44,418.32
X$7123 2984 1083 2985 1086 1149 1115 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7142 r0 *1 22.4,418.32
X$7142 2984 1087 1149 2985 1148 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7163 r0 *1 58.24,428.4
X$7163 2985 2984 1089 1215 1232 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7168 m0 *1 204.96,448.56
X$7168 2985 1090 1268 1270 1181 1186 2984 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $7171 m0 *1 544.88,478.8
X$7171 2984 1090 2985 1464 1471 1331 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7174 m0 *1 509.6,478.8
X$7174 2985 2984 1090 1487 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7177 r0 *1 517.44,428.4
X$7177 2984 1090 2985 1223 1194 1120 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7181 m0 *1 474.32,458.64
X$7181 2984 1090 2985 1299 1366 1331 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7198 r0 *1 492.24,428.4
X$7198 1263 1189 1218 1219 2985 2984 1091 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7207 r0 *1 510.16,428.4
X$7207 1189 1222 1218 1193 2985 2984 1092 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7217 r0 *1 571.2,418.32
X$7217 2985 1151 2984 1225 1093 1121 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7227 r0 *1 877.52,408.24
X$7227 2985 2984 1095 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7229 m0 *1 900.48,418.32
X$7229 2985 2984 1096 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7231 r0 *1 900.48,408.24
X$7231 1096 1099 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7233 m0 *1 910.56,418.32
X$7233 2985 2984 1097 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7235 r0 *1 912.24,408.24
X$7235 1097 1100 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7237 r0 *1 927.92,408.24
X$7237 1098 1147 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7239 m0 *1 927.92,418.32
X$7239 2985 2984 1098 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7257 r0 *1 577.92,408.24
X$7257 1106 2985 2984 1105 1109 1141 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $7269 m0 *1 180.88,428.4
X$7269 2985 1181 1177 2984 1108 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7279 m0 *1 19.04,418.32
X$7279 1111 2984 2985 1115 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7282 m0 *1 2.24,418.32
X$7282 1113 2984 2985 1112 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7289 m0 *1 10.64,418.32
X$7289 1114 2984 2985 1133 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7312 r0 *1 479.92,418.32
X$7312 2985 2984 1118 1152 1119 1138 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7317 m0 *1 488.88,438.48
X$7317 2985 1189 1222 1220 1119 1190 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $7319 r0 *1 492.24,438.48
X$7319 1221 1119 1273 1274 2985 2984 1219 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7323 m0 *1 493.36,428.4
X$7323 2984 1119 1139 2985 1174 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7334 m0 *1 523.04,438.48
X$7334 2984 1120 1244 2985 1163 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7336 m0 *1 508.48,438.48
X$7336 1220 1191 1189 1222 2985 2984 1120 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7351 m0 *1 854,418.32
X$7351 1122 1123 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7353 m0 *1 851.2,418.32
X$7353 2985 2984 1122 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7357 m0 *1 868,418.32
X$7357 1124 1129 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7359 m0 *1 865.76,418.32
X$7359 2985 2984 1124 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7361 m0 *1 885.92,418.32
X$7361 2985 2984 1125 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7363 m0 *1 888.16,418.32
X$7363 1125 1131 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7365 m0 *1 915.04,418.32
X$7365 1126 1132 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7367 m0 *1 912.8,418.32
X$7367 2985 2984 1126 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7369 r0 *1 931.84,418.32
X$7369 2985 2984 1127 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7371 m0 *1 934.08,418.32
X$7371 1127 1128 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7377 r0 *1 886.48,418.32
X$7377 1142 1130 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7388 m0 *1 140,428.4
X$7388 2984 1133 1156 2985 1182 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7400 m0 *1 26.88,438.48
X$7400 2985 1135 1231 2984 1259 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7415 r0 *1 145.04,428.4
X$7415 2984 1156 1210 2985 1137 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7421 r0 *1 486.08,428.4
X$7421 1189 2984 1222 1218 2985 1139 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7428 r0 *1 582.4,438.48
X$7428 2985 1248 2984 1249 1277 1140 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7430 r0 *1 575.12,438.48
X$7430 2985 1260 2984 1352 1277 1140 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7432 m0 *1 577.36,448.56
X$7432 1277 1140 1248 1349 1304 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $7434 m0 *1 572.32,448.56
X$7434 2984 1140 1289 2985 1304 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7447 r0 *1 884.24,418.32
X$7447 2985 2984 1142 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7449 r0 *1 918.96,418.32
X$7449 1143 1146 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7451 r0 *1 916.72,418.32
X$7451 2985 2984 1143 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7453 m0 *1 931.84,428.4
X$7453 2985 2984 1144 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7455 r0 *1 934.08,418.32
X$7455 1144 1145 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7483 m0 *1 19.04,428.4
X$7483 1170 2984 2985 1153 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7486 r0 *1 230.72,438.48
X$7486 2985 1154 2984 1386 1261 1162 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7490 r0 *1 2.24,468.72
X$7490 1154 2984 2985 1467 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7497 r0 *1 238,438.48
X$7497 2984 1269 1155 2985 1242 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7499 m0 *1 150.64,428.4
X$7499 2985 2984 1155 1176 1157 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7501 r0 *1 211.12,428.4
X$7501 2985 2984 1155 1156 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $7503 m0 *1 185.36,438.48
X$7503 2985 2984 1155 1239 1181 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7505 m0 *1 191.52,428.4
X$7505 2985 1155 2984 1161 1177 1184 1182 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $7508 r0 *1 207.76,438.48
X$7508 2985 2984 1269 1270 1155 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7510 r0 *1 216.72,428.4
X$7510 2985 2984 1217 1234 1155 1187 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7512 m0 *1 145.04,428.4
X$7512 2985 2984 1175 1155 1180 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $7524 m0 *1 165.76,438.48
X$7524 2985 2984 1156 1267 1207 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7528 m0 *1 160.16,428.4
X$7528 2985 2984 1156 1158 1157 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7541 r0 *1 157.92,428.4
X$7541 2985 2984 1159 1157 1180 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7544 m0 *1 165.2,428.4
X$7544 2984 1158 2985 1159 1233 1160 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7548 r0 *1 150.08,428.4
X$7548 2984 1180 2985 1159 1210 1207 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7552 r0 *1 170.8,438.48
X$7552 2984 1267 1319 1159 1286 1241 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $7554 m0 *1 172.48,438.48
X$7554 2985 1181 1183 2984 1159 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7560 m0 *1 186.48,428.4
X$7560 2984 1160 1186 2985 1161 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7562 m0 *1 182,438.48
X$7562 2985 2984 1240 1160 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7564 r0 *1 181.44,438.48
X$7564 1160 2985 1186 1239 2984 1286 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7566 r0 *1 188.72,438.48
X$7566 2985 2984 1287 1160 1239 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $7574 m0 *1 201.6,428.4
X$7574 2985 2984 1185 1181 1161 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $7581 r0 *1 446.32,438.48
X$7581 2984 1162 1242 2985 1244 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7584 r0 *1 261.52,438.48
X$7584 2985 1162 1271 1261 1242 2984 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $7587 m0 *1 207.2,428.4
X$7587 2985 2984 1186 1181 1162 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $7592 m0 *1 444.08,438.48
X$7592 2984 2985 1242 1223 1162 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $7600 m0 *1 538.16,428.4
X$7600 2985 1209 2984 1195 1173 1164 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7602 r0 *1 547.68,428.4
X$7602 2985 2984 1164 1224 1196 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7605 r0 *1 551.04,438.48
X$7605 1164 1302 1196 1276 2985 2984 1289 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7611 m0 *1 879.76,428.4
X$7611 1165 1168 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7613 m0 *1 877.52,428.4
X$7613 2985 2984 1165 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7615 m0 *1 896,428.4
X$7615 1166 1204 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7617 m0 *1 893.76,428.4
X$7617 2985 2984 1166 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7619 m0 *1 914.48,428.4
X$7619 1167 1203 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7621 r0 *1 913.36,428.4
X$7621 2985 2984 1167 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7625 m0 *1 934.08,428.4
X$7625 1171 1169 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7634 m0 *1 929.6,428.4
X$7634 2985 2984 1171 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7637 m0 *1 866.88,428.4
X$7637 1172 1205 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7640 m0 *1 863.52,428.4
X$7640 2985 2984 1172 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7663 r0 *1 21.28,428.4
X$7663 1178 2984 2985 1207 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $7666 m0 *1 10.64,428.4
X$7666 1206 2984 2985 1179 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7672 m0 *1 173.04,428.4
X$7672 2985 2984 1181 1180 1183 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7683 m0 *1 218.96,428.4
X$7683 2984 1181 1186 2985 1187 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7687 m0 *1 190.4,448.56
X$7687 2984 1240 2985 1239 1268 1296 1181 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $7703 r0 *1 201.04,438.48
X$7703 2984 1240 1182 2985 1261 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7705 r0 *1 195.44,438.48
X$7705 2985 2984 1240 1268 1182 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7712 r0 *1 197.12,448.56
X$7712 2985 2984 1183 1392 1296 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7715 r0 *1 192.64,428.4
X$7715 2985 2984 1186 1183 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7718 r0 *1 196,428.4
X$7718 2984 1240 1183 2985 1184 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7725 r0 *1 202.72,428.4
X$7725 2985 1184 1185 2984 1234 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7738 r0 *1 212.8,438.48
X$7738 1288 1186 1320 1287 2984 2985 1262 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $7758 m0 *1 374.64,428.4
X$7758 2985 1188 2984 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $7776 r0 *1 493.36,448.56
X$7776 1274 2984 1189 1218 2985 1299 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7784 r0 *1 532,478.8
X$7784 1449 1499 1500 1528 2985 2984 1189 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7786 r0 *1 500.64,468.72
X$7786 2984 1220 1189 2985 1394 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7796 m0 *1 475.44,438.48
X$7796 2984 1244 1190 2985 1243 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7801 r0 *1 500.64,428.4
X$7801 1221 2985 1190 2984 1192 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7803 m0 *1 471.52,448.56
X$7803 2984 1297 2985 1272 1298 1221 1190 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $7822 m0 *1 544.88,438.48
X$7822 2984 1195 2985 1224 1277 1245 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7830 m0 *1 575.68,438.48
X$7830 2984 2985 1247 1246 1197 1226 1260 1225 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $7833 r0 *1 579.04,428.4
X$7833 2984 1197 2985 1225 1248 1226 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7837 r0 *1 869.68,428.4
X$7837 1198 1228 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7839 r0 *1 867.44,428.4
X$7839 2985 2984 1198 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7841 r0 *1 883.68,428.4
X$7841 1199 1229 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7843 r0 *1 881.44,428.4
X$7843 2985 2984 1199 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7845 r0 *1 915.6,428.4
X$7845 2985 2984 1200 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7847 r0 *1 917.84,428.4
X$7847 1200 1227 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7849 r0 *1 929.6,428.4
X$7849 2985 2984 1201 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7851 r0 *1 931.84,428.4
X$7851 1201 1202 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7874 m0 *1 24.08,448.56
X$7874 2984 1266 1208 2985 1265 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7887 r0 *1 25.76,428.4
X$7887 1216 2984 2985 1211 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7890 m0 *1 17.36,438.48
X$7890 1212 2984 2985 1236 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7897 r0 *1 2.24,438.48
X$7897 1213 2984 2985 1237 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7909 m0 *1 218.4,438.48
X$7909 2984 1262 1217 2985 1235 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7912 r0 *1 502.32,519.12
X$7912 2985 2984 1770 1218 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $7914 m0 *1 505.68,559.44
X$7914 2984 1365 1218 2985 1970 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7916 m0 *1 471.52,569.52
X$7916 1999 2984 1998 1218 2985 2027 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7924 r0 *1 472.08,498.96
X$7924 2984 1642 1218 2985 1666 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7926 m0 *1 483.28,498.96
X$7926 2985 1608 1642 2984 1643 1218 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $7930 r0 *1 467.04,559.44
X$7930 2984 1998 1218 2985 2025 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7933 r0 *1 510.72,559.44
X$7933 2984 1487 2985 1218 1991 1331 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7949 r0 *1 534.8,498.96
X$7949 2984 1220 1500 2985 1645 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7955 m0 *1 481.6,529.2
X$7955 2985 1220 1701 1794 1769 1739 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $7957 m0 *1 474.32,498.96
X$7957 1606 2984 1220 1642 2985 1566 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7959 r0 *1 483.28,559.44
X$7959 2984 1998 1220 2985 2000 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7961 r0 *1 552.16,549.36
X$7961 1940 1828 1826 2985 2984 1220 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $7963 r0 *1 484.96,539.28
X$7963 2984 1220 1701 2985 1886 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7980 r0 *1 464.8,438.48
X$7980 2984 1221 2985 1243 1297 1271 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7990 r0 *1 500.64,438.48
X$7990 1263 2984 1273 1274 2985 1222 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7997 m0 *1 482.16,448.56
X$7997 2985 1223 1331 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8026 m0 *1 862.96,438.48
X$8026 1250 1230 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8052 r0 *1 115.92,448.56
X$8052 2985 2984 1238 1328 1327 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8060 r0 *1 22.96,448.56
X$8060 2985 2984 1322 1240 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $8076 m0 *1 523.04,559.44
X$8076 2985 2984 1914 1913 1241 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8078 r0 *1 492.8,539.28
X$8078 2985 2984 1794 1887 1241 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8080 r0 *1 450.8,498.96
X$8080 2985 2984 1606 1687 1241 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8083 r0 *1 522.48,529.2
X$8083 2985 2984 1825 1840 1241 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8085 r0 *1 524.16,579.6
X$8085 2985 2036 2984 1241 2079 1365 2080 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $8087 r0 *1 473.2,569.52
X$8087 2985 2984 1999 2034 1241 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8090 r0 *1 461.44,569.52
X$8090 2985 2984 1997 2073 1241 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8093 r0 *1 267.12,448.56
X$8093 2985 1271 1241 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8098 r0 *1 466.48,488.88
X$8098 2985 2984 1565 1629 1241 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8100 m0 *1 476,549.36
X$8100 2985 2984 1769 1928 1241 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8124 m0 *1 460.88,468.72
X$8124 2985 2984 1244 1365 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8129 r0 *1 523.04,488.88
X$8129 1502 1644 1567 1244 2985 2984 1597 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8131 m0 *1 472.64,519.12
X$8131 2984 1739 1244 2985 1670 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8133 m0 *1 498.4,498.96
X$8133 2984 1244 1608 2985 1627 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8136 m0 *1 520.8,448.56
X$8136 2984 1300 1244 2985 1354 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8151 r0 *1 543.76,438.48
X$8151 2985 1301 2984 1245 1275 1302 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8155 m0 *1 576.24,468.72
X$8155 1463 2984 2985 1246 1247 1426 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8158 r0 *1 584.08,488.88
X$8158 2985 1572 1569 1473 1571 1246 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $8164 r0 *1 604.24,448.56
X$8164 2985 1336 1305 1348 1337 1247 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $8173 m0 *1 584.08,458.64
X$8173 2985 2984 1303 1350 1249 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8176 m0 *1 860.72,438.48
X$8176 2985 2984 1250 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8178 m0 *1 881.44,438.48
X$8178 2985 2984 1251 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8180 m0 *1 883.68,438.48
X$8180 1251 1258 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8182 m0 *1 906.08,438.48
X$8182 1252 1283 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8184 r0 *1 901.04,438.48
X$8184 2985 2984 1252 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8186 m0 *1 920.08,438.48
X$8186 2985 2984 1253 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8188 m0 *1 922.32,438.48
X$8188 1253 1255 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8190 m0 *1 931.84,438.48
X$8190 1254 1257 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8192 r0 *1 935.76,438.48
X$8192 2985 2984 1254 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8196 r0 *1 904.96,438.48
X$8196 1278 1256 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8222 r0 *1 526.96,448.56
X$8222 2984 1263 1300 2985 1353 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8226 r0 *1 518.56,448.56
X$8226 2985 2984 1333 1334 1263 1354 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8234 m0 *1 10.64,448.56
X$8234 1266 2984 2985 1264 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8254 r0 *1 2.24,448.56
X$8254 1290 2984 2985 1269 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $8258 r0 *1 222.32,438.48
X$8258 2985 2984 1269 1288 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8271 m0 *1 475.44,509.04
X$8271 2984 1669 2985 1670 1723 1271 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8274 m0 *1 490.56,498.96
X$8274 2984 1527 2985 1627 1607 1271 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8278 m0 *1 509.04,579.6
X$8278 2985 2984 2078 1271 2004 1365 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8289 r0 *1 500.64,458.64
X$8289 1273 2984 1274 1394 2985 1300 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8291 m0 *1 496.72,448.56
X$8291 2984 1273 1299 2985 1321 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8294 r0 *1 474.88,458.64
X$8294 2985 2984 1413 1366 1273 1384 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8300 m0 *1 501.2,468.72
X$8300 2984 1274 1394 2985 1425 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8306 m0 *1 491.68,468.72
X$8306 2985 2984 1443 1393 1274 1465 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8316 m0 *1 548.8,448.56
X$8316 1275 2985 2984 1459 1321 1276 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8328 m0 *1 899.92,448.56
X$8328 2985 2984 1278 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8331 r0 *1 916.72,438.48
X$8331 1279 1281 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8333 m0 *1 914.48,448.56
X$8333 2985 2984 1279 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8335 m0 *1 925.68,448.56
X$8335 2985 2984 1280 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8337 r0 *1 926.24,438.48
X$8337 1280 1311 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8341 r0 *1 887.04,438.48
X$8341 1285 1282 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8346 r0 *1 934.08,448.56
X$8346 1309 1284 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8351 r0 *1 880.32,438.48
X$8351 2985 2984 1285 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8372 r0 *1 30.8,448.56
X$8372 1291 2984 2985 1293 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $8375 r0 *1 6.72,448.56
X$8375 1292 2984 2985 1315 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8378 r0 *1 132.16,448.56
X$8378 2985 2984 1295 1330 1293 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8380 r0 *1 108.08,448.56
X$8380 2984 1327 2985 1326 1294 1293 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8386 m0 *1 109.76,448.56
X$8386 2984 1295 1294 2985 1317 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8389 m0 *1 108.64,458.64
X$8389 2985 2984 1295 1362 1361 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8394 m0 *1 126.56,458.64
X$8394 2984 1315 1295 2985 1329 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8396 r0 *1 122.64,448.56
X$8396 2985 2984 1328 1295 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $8399 m0 *1 130.48,488.88
X$8399 1295 1364 1469 1587 2984 2985 1546 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8401 r0 *1 129.92,478.8
X$8401 1295 2984 1364 1447 2985 1496 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8415 r0 *1 489.44,488.88
X$8415 2984 1607 2985 1526 1298 1527 1608 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $8417 r0 *1 477.12,468.72
X$8417 2985 1331 1298 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8420 m0 *1 468.16,549.36
X$8420 2984 1928 2985 1885 1884 1298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8422 r0 *1 453.6,569.52
X$8422 2984 2073 2985 2033 2060 1298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8424 r0 *1 528.64,529.2
X$8424 2984 1840 2985 1772 1839 1298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8426 r0 *1 458.64,488.88
X$8426 2984 1629 2985 1564 1595 1298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8428 m0 *1 528.64,549.36
X$8428 2984 1913 2985 1888 1927 1298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8430 r0 *1 478.24,569.52
X$8430 2984 2034 2985 1298 2035 2061 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8433 m0 *1 449.12,509.04
X$8433 2984 1687 2985 1668 1605 1298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8435 m0 *1 493.92,549.36
X$8435 2984 1887 2985 1912 1856 1298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8469 r0 *1 545.44,448.56
X$8469 1301 2985 2984 1346 1353 1302 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8478 r0 *1 570.08,448.56
X$8478 2985 1351 1352 1303 1349 1335 2984 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $8480 r0 *1 602,458.64
X$8480 2985 1303 1396 1337 1395 1409 1380 2984 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $8487 r0 *1 577.92,458.64
X$8487 1304 1410 1533 1463 2985 2984 1335 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8492 m0 *1 615.44,468.72
X$8492 2984 1305 1367 2985 1369 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8494 r0 *1 603.68,468.72
X$8494 1337 1348 1305 1485 2985 2984 1395 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8497 r0 *1 610.96,468.72
X$8497 2985 1368 1305 1458 1462 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $8506 r0 *1 885.36,448.56
X$8506 1306 1344 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8508 r0 *1 883.12,448.56
X$8508 2985 2984 1306 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8510 m0 *1 917.28,458.64
X$8510 1307 2984 2985 1373 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $8515 m0 *1 931.28,448.56
X$8515 1308 1314 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8517 r0 *1 929.6,448.56
X$8517 2985 2984 1308 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8520 r0 *1 931.84,448.56
X$8520 2985 2984 1309 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8522 m0 *1 934.08,458.64
X$8522 1378 1310 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8527 m0 *1 916.72,448.56
X$8527 1312 2984 2985 1318 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $8530 r0 *1 925.12,448.56
X$8530 1313 2984 2985 1316 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $8542 r0 *1 614.88,488.88
X$8542 2985 1534 1572 1316 1623 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $8551 r0 *1 585.2,519.12
X$8551 2985 1785 1771 1318 1796 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $8556 m0 *1 564.48,458.64
X$8556 2985 1350 1351 1320 1332 1532 2984 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $8558 r0 *1 224.56,458.64
X$8558 2985 2984 1365 1412 1320 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8561 m0 *1 234.08,458.64
X$8561 2985 1386 2984 1385 1320 1365 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8575 m0 *1 59.92,458.64
X$8575 2984 1377 2985 1357 1323 1324 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8577 m0 *1 157.92,549.36
X$8577 2984 1908 2985 1909 1324 1881 1880 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $8579 m0 *1 159.04,539.28
X$8579 2984 1854 2985 1855 1324 1852 1824 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $8581 r0 *1 132.16,549.36
X$8581 2985 1823 1324 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8586 m0 *1 160.16,569.52
X$8586 2984 1963 2985 1324 1994 2031 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8588 m0 *1 84,488.88
X$8588 2984 1557 2985 1521 1516 1324 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8591 r0 *1 43.12,509.04
X$8591 2984 1692 2985 1693 1691 1324 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8594 m0 *1 59.36,519.12
X$8594 2984 1729 2985 1324 1760 1730 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8596 m0 *1 46.48,458.64
X$8596 2984 1355 2985 1324 1376 1356 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8600 m0 *1 75.6,458.64
X$8600 2984 1379 2985 1358 1359 1324 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8603 r0 *1 39.2,549.36
X$8603 2984 1933 2985 1324 1934 1878 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8614 r0 *1 70.56,468.72
X$8614 1325 1387 1389 1419 2985 2984 1694 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8616 m0 *1 69.44,458.64
X$8616 2985 2984 1325 1377 1360 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8618 r0 *1 67.76,458.64
X$8618 2984 1325 1388 2985 1357 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8621 m0 *1 131.6,458.64
X$8621 2984 2985 1330 1326 1360 1448 1382 1363 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $8623 r0 *1 113.12,458.64
X$8623 2985 2984 1326 1361 1327 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8626 m0 *1 133.84,468.72
X$8626 2985 2984 1441 1326 1447 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8628 r0 *1 120.4,458.64
X$8628 2984 1362 2985 1326 1439 1440 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8637 m0 *1 128.8,468.72
X$8637 2985 2984 1364 1327 1422 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8643 r0 *1 136.08,478.8
X$8643 2985 2984 1545 1448 1328 1422 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8645 r0 *1 152.32,478.8
X$8645 2985 1328 2984 1469 1547 1470 1329 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $8648 r0 *1 125.44,488.88
X$8648 2984 1328 1523 2985 1562 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8651 m0 *1 121.52,458.64
X$8651 2985 2984 1328 1345 1361 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8653 r0 *1 142.24,488.88
X$8653 2985 1496 2984 1589 1497 1328 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8655 m0 *1 147.84,458.64
X$8655 2985 2984 1328 1363 1364 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8669 m0 *1 149.52,468.72
X$8669 1441 2984 1421 1329 2985 1461 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8672 m0 *1 124.32,488.88
X$8672 1421 2984 1523 1329 2985 1561 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8685 r0 *1 471.52,509.04
X$8685 2984 1723 2985 1786 1739 1669 1331 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $8688 r0 *1 563.92,509.04
X$8688 2984 1487 2985 1672 1720 1331 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8690 r0 *1 569.52,488.88
X$8690 2984 1487 2985 1531 1568 1331 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8696 r0 *1 554.4,559.44
X$8696 2984 1487 2985 2006 1974 1331 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8698 r0 *1 549.36,539.28
X$8698 2984 1487 2985 1827 1875 1331 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8700 m0 *1 569.52,549.36
X$8700 2984 1487 2985 1859 1926 1331 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8714 m0 *1 450.24,519.12
X$8714 2985 2984 1755 1332 1754 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8724 m0 *1 619.36,498.96
X$8724 2985 1622 1336 1583 1648 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $8727 m0 *1 609.84,498.96
X$8727 1624 1336 1622 1590 1534 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $8736 m0 *1 603.68,468.72
X$8736 2985 1409 1337 1437 1425 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $8744 m0 *1 606.48,458.64
X$8744 1367 2985 2984 1338 1381 1348 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8747 r0 *1 918.4,458.64
X$8747 1404 2984 2985 1338 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $8750 m0 *1 910.56,458.64
X$8750 2985 2984 1339 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8752 r0 *1 911.12,448.56
X$8752 1339 1341 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8754 r0 *1 899.36,448.56
X$8754 1347 1340 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8759 m0 *1 894.88,458.64
X$8759 1372 1342 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8762 m0 *1 926.24,458.64
X$8762 1343 2984 2985 1370 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $8772 m0 *1 912.8,458.64
X$8772 1403 2984 2985 1346 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $8776 r0 *1 894.88,448.56
X$8776 2985 2984 1347 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8807 m0 *1 49.28,468.72
X$8807 2985 2984 1387 1355 1360 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8812 m0 *1 21.84,468.72
X$8812 1434 2985 2984 1433 1356 1436 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8814 m0 *1 54.32,468.72
X$8814 2984 1387 1457 2985 1356 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8820 r0 *1 22.4,458.64
X$8820 1407 2985 2984 1406 1357 1417 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8827 r0 *1 31.92,458.64
X$8827 1435 2985 2984 1405 1358 1418 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8830 m0 *1 81.2,468.72
X$8830 2984 1389 1438 2985 1358 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8837 m0 *1 35.84,559.44
X$8837 2985 2984 1846 1933 1360 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8842 m0 *1 27.44,579.6
X$8842 2985 2049 2984 1360 2089 1732 2050 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $8845 r0 *1 53.76,519.12
X$8845 2985 2984 1759 1729 1360 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8848 m0 *1 61.04,569.52
X$8848 2985 1851 1360 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8850 m0 *1 154.56,559.44
X$8850 2985 2984 1964 1963 1360 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8852 r0 *1 81.76,488.88
X$8852 2985 2984 1495 1557 1360 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8854 m0 *1 83.44,458.64
X$8854 2985 2984 1389 1379 1360 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8857 r0 *1 43.68,519.12
X$8857 2985 2984 1728 1692 1360 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8882 r0 *1 152.88,458.64
X$8882 2985 2984 1391 1421 1363 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8889 m0 *1 146.16,468.72
X$8889 2985 2984 1364 1441 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8893 r0 *1 124.32,478.8
X$8893 2985 2984 1523 1364 1447 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8895 m0 *1 159.6,488.88
X$8895 2985 1364 1547 2984 1524 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8897 r0 *1 144.48,478.8
X$8897 2984 1448 2985 1469 1497 1364 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8910 m0 *1 558.32,549.36
X$8910 2984 1365 1827 2985 1858 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8912 r0 *1 554.96,569.52
X$8912 2984 1365 2006 2985 2045 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8916 m0 *1 566.16,488.88
X$8916 2984 1365 1531 2985 1543 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8919 r0 *1 580.16,509.04
X$8919 2984 1365 1672 2985 1719 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8922 r0 *1 577.92,549.36
X$8922 2984 1365 1859 2985 1916 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8947 m0 *1 621.04,458.64
X$8947 2985 1368 1369 2984 1380 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8956 m0 *1 612.08,529.2
X$8956 1798 2985 2984 1370 1888 1773 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8961 m0 *1 879.76,458.64
X$8961 1371 1374 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8963 m0 *1 877.52,458.64
X$8963 2985 2984 1371 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8965 m0 *1 892.64,458.64
X$8965 2985 2984 1372 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8968 m0 *1 604.24,519.12
X$8968 1706 2985 2984 1373 1772 1740 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8977 r0 *1 923.44,458.64
X$8977 1375 2984 2985 1408 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $8990 m0 *1 930.72,458.64
X$8990 2985 2984 1378 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9002 r0 *1 539.28,478.8
X$9002 2984 1499 1501 2985 1381 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9011 m0 *1 202.16,458.64
X$9011 2985 2984 1412 1383 1442 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9028 m0 *1 68.32,468.72
X$9028 1387 1389 1419 1420 2985 2984 1388 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9039 r0 *1 63.84,468.72
X$9039 1389 2984 1419 1520 2985 1457 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9056 m0 *1 380.8,942.48
X$9056 1390 2984 2985 2950 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9058 r0 *1 137.2,509.04
X$9058 2985 1390 1561 2984 1721 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9067 m0 *1 155.68,468.72
X$9067 2984 1422 2985 1391 1423 1461 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9070 m0 *1 201.6,468.72
X$9070 2985 2984 1411 1442 1392 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9087 m0 *1 607.04,488.88
X$9087 2984 1592 2985 1541 1396 1590 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9090 r0 *1 882,458.64
X$9090 1397 1401 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9092 r0 *1 879.2,458.64
X$9092 2985 2984 1397 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9094 r0 *1 907.76,468.72
X$9094 2985 2984 1398 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9096 r0 *1 908.88,458.64
X$9096 1398 1402 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9098 r0 *1 931.84,458.64
X$9098 2985 2984 1399 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9100 r0 *1 934.08,458.64
X$9100 1399 1400 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9113 r0 *1 2.24,458.64
X$9113 1415 2984 2985 1405 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9119 r0 *1 10.64,458.64
X$9119 1414 2984 2985 1406 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9122 r0 *1 21.28,468.72
X$9122 2984 1445 2985 1482 1456 1407 1416 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $9129 r0 *1 601.44,488.88
X$9129 2985 1570 1571 1408 1593 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $9137 m0 *1 582.4,529.2
X$9137 2985 2984 1410 1814 1813 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9139 r0 *1 577.92,519.12
X$9139 2985 2984 1410 1815 1533 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9142 m0 *1 456.4,549.36
X$9142 1938 2984 1911 1883 2985 1410 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9153 r0 *1 10.64,468.72
X$9153 1411 2984 2985 1466 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9171 m0 *1 16.8,468.72
X$9171 2984 1417 1434 2985 1416 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9175 m0 *1 31.92,468.72
X$9175 1435 2984 1417 1436 2985 1456 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9178 r0 *1 31.36,468.72
X$9178 1446 1417 1418 1491 2985 2984 1483 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9184 m0 *1 76.16,468.72
X$9184 2984 1419 1420 2985 1438 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9189 m0 *1 57.12,498.96
X$9189 2984 1419 1520 2985 1634 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9197 m0 *1 57.68,488.88
X$9197 2985 2984 1584 1556 1419 1542 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9206 r0 *1 106.96,569.52
X$9206 2984 1907 1420 2985 2058 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9208 m0 *1 82.88,549.36
X$9208 2984 1847 1906 2985 1420 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9212 m0 *1 103.04,579.6
X$9212 2054 2056 1907 1420 2985 2984 2206 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9217 m0 *1 154.56,478.8
X$9217 2984 1421 1422 2985 1470 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9220 r0 *1 126,468.72
X$9220 2985 2984 1421 1440 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9223 r0 *1 139.44,468.72
X$9223 2985 2984 1421 1448 1422 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9227 m0 *1 10.64,478.8
X$9227 2985 2984 1512 1421 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $9239 r0 *1 129.36,468.72
X$9239 2985 2984 1447 1422 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $9245 r0 *1 131.04,488.88
X$9245 2984 1639 1422 2985 1587 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9251 r0 *1 166.88,509.04
X$9251 2985 2984 1737 1735 1423 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9257 r0 *1 545.44,468.72
X$9257 2985 2984 1424 1471 1449 1486 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9264 m0 *1 562.24,589.68
X$9264 2985 2103 2104 2102 2140 1426 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $9268 m0 *1 871.92,468.72
X$9268 2985 2984 1427 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9270 m0 *1 874.72,468.72
X$9270 1427 1428 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9274 r0 *1 902.72,468.72
X$9274 2985 2984 1429 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9276 m0 *1 902.72,468.72
X$9276 1429 1452 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9278 m0 *1 934.08,468.72
X$9278 1430 1453 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9280 m0 *1 931.84,468.72
X$9280 2985 2984 1430 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9282 m0 *1 884.24,468.72
X$9282 1460 1431 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9285 m0 *1 912.24,468.72
X$9285 1432 2984 2985 1459 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $9288 m0 *1 2.24,468.72
X$9288 1444 2984 2985 1433 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9299 m0 *1 28,478.8
X$9299 1490 1436 1445 1483 2985 2984 1555 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9303 m0 *1 910,478.8
X$9303 1480 2984 2985 1437 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $9314 m0 *1 127.68,478.8
X$9314 2984 1440 1447 2985 1469 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9320 m0 *1 142.24,488.88
X$9320 2984 2985 1545 1441 1546 1641 1591 1589 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $9337 m0 *1 21.28,478.8
X$9337 2984 1514 1468 2985 1445 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9343 r0 *1 36.4,488.88
X$9343 2985 1554 2984 1493 1582 1446 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9345 m0 *1 27.44,498.96
X$9345 2985 1554 1446 1658 1633 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $9370 r0 *1 556.08,468.72
X$9370 2984 1449 1464 2985 1462 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9377 r0 *1 913.36,468.72
X$9377 2985 2984 1450 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9379 m0 *1 920.64,468.72
X$9379 1450 1454 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9383 r0 *1 915.6,468.72
X$9383 2985 2984 1451 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9385 r0 *1 917.84,468.72
X$9385 1451 1475 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9393 r0 *1 934.08,468.72
X$9393 1476 1455 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9404 m0 *1 925.12,478.8
X$9404 1508 2984 2985 1458 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $9414 r0 *1 877.52,468.72
X$9414 2985 2984 1460 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9434 m0 *1 544.88,488.88
X$9434 1499 1502 1529 1530 2985 2984 1464 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9446 m0 *1 14,488.88
X$9446 2985 1581 1579 1490 1468 1580 1554 2984 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $9450 m0 *1 2.24,488.88
X$9450 2985 1578 1468 1552 1521 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $9466 m0 *1 604.24,478.8
X$9466 2985 1473 1472 2984 1485 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9468 m0 *1 601.44,488.88
X$9468 2985 2984 1592 1472 1570 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9470 r0 *1 599.76,478.8
X$9470 2985 1472 1473 1505 1518 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $9481 m0 *1 884.8,478.8
X$9481 1474 1509 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9483 m0 *1 882.56,478.8
X$9483 2985 2984 1474 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9488 m0 *1 931.84,478.8
X$9488 2985 2984 1476 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9490 r0 *1 932.96,478.8
X$9490 2985 2984 1477 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9492 m0 *1 934.08,478.8
X$9492 1477 1479 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9494 r0 *1 918.4,478.8
X$9494 1478 2984 2985 1505 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $9501 m0 *1 915.6,478.8
X$9501 1484 1481 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9505 r0 *1 28.56,478.8
X$9505 2985 1515 1581 1482 1492 1493 2984 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $9513 m0 *1 907.76,478.8
X$9513 2985 2984 1484 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9551 r0 *1 6.16,478.8
X$9551 2985 1512 1488 2984 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $9554 m0 *1 2.24,478.8
X$9554 1489 2984 2985 1519 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9557 m0 *1 41.44,488.88
X$9557 2985 2984 1490 1492 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9563 r0 *1 36.4,498.96
X$9563 2985 1685 1490 1660 1667 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $9567 r0 *1 18.48,478.8
X$9567 1553 2985 2984 1513 1494 1491 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $9569 r0 *1 30.24,488.88
X$9569 2985 1491 1553 2984 1582 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9580 r0 *1 91.28,488.88
X$9580 2984 1560 1558 2985 1494 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9583 r0 *1 103.04,509.04
X$9583 1560 1495 1635 1697 2985 2984 1762 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9586 m0 *1 101.92,519.12
X$9586 1761 1560 1495 1635 2985 2984 1848 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9588 m0 *1 85.68,498.96
X$9588 2984 1495 1603 2985 1521 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9591 r0 *1 94.64,498.96
X$9591 1495 2984 1635 1637 2985 1558 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9600 r0 *1 136.08,488.88
X$9600 2985 1562 1496 2984 1588 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9621 r0 *1 477.68,529.2
X$9621 2985 2984 1498 2987 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $9651 m0 *1 522.48,488.88
X$9651 2985 2984 1548 1596 1499 1597 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9655 m0 *1 530.88,519.12
X$9655 2984 1500 1770 2985 1530 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9657 m0 *1 490.56,509.04
X$9657 1527 1701 1702 1643 2985 2984 1500 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9668 r0 *1 538.72,488.88
X$9668 2984 1528 1645 2985 1501 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9672 m0 *1 539.84,488.88
X$9672 2984 1502 1529 2985 1528 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9675 m0 *1 579.6,488.88
X$9675 2984 1502 1531 2985 1518 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9678 m0 *1 571.2,488.88
X$9678 2985 2984 1544 1568 1502 1543 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9687 r0 *1 875.84,478.8
X$9687 1503 1507 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9689 r0 *1 873.6,478.8
X$9689 2985 2984 1503 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9691 r0 *1 908.88,478.8
X$9691 1504 1511 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9693 r0 *1 906.64,478.8
X$9693 2985 2984 1504 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9699 m0 *1 918.4,488.88
X$9699 2985 2984 1506 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9702 r0 *1 923.44,478.8
X$9702 1506 1539 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9711 r0 *1 885.36,478.8
X$9711 1517 1510 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9722 r0 *1 2.8,488.88
X$9722 1550 2984 2985 1513 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9726 r0 *1 17.92,488.88
X$9726 1579 2985 2984 1659 1619 1514 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $9732 m0 *1 30.8,509.04
X$9732 2985 1684 1750 1555 1515 1685 2984 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $9739 r0 *1 864.08,478.8
X$9739 2985 2984 1517 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9748 m0 *1 3.36,519.12
X$9748 1779 2985 2984 1519 1730 1725 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $9751 m0 *1 98,539.28
X$9751 1848 1694 1520 1698 2985 2984 1873 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9755 m0 *1 66.08,488.88
X$9755 2984 1520 1559 2985 1542 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9757 r0 *1 75.04,539.28
X$9757 1905 2984 1847 1879 2985 1520 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9759 r0 *1 57.12,498.96
X$9759 2984 1661 2985 1636 1556 1520 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9788 r0 *1 141.12,559.44
X$9788 2985 2984 1522 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $9808 r0 *1 397.6,488.88
X$9808 2984 1563 1524 2985 1594 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9816 m0 *1 412.16,529.2
X$9816 2985 1525 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $9851 m0 *1 506.8,498.96
X$9851 1527 2985 1608 2984 1626 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9867 m0 *1 553.84,488.88
X$9867 2984 1529 1530 2985 1531 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9874 r0 *1 547.68,498.96
X$9874 1644 2984 1647 1646 2985 1529 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9880 m0 *1 556.64,509.04
X$9880 2984 1646 1530 2985 1672 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9895 m0 *1 574.56,529.2
X$9895 2984 1814 2985 1795 1532 1815 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9897 r0 *1 613.76,519.12
X$9897 1771 1740 1741 1773 2985 2984 1533 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9904 m0 *1 614.88,488.88
X$9904 2984 1571 2985 1534 1541 1572 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9908 m0 *1 879.2,488.88
X$9908 1535 1536 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9910 m0 *1 875.28,488.88
X$9910 2985 2984 1535 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9914 m0 *1 926.24,488.88
X$9914 2985 2984 1537 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $9916 m0 *1 928.48,488.88
X$9916 1537 1538 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9922 m0 *1 892.64,488.88
X$9922 1586 1540 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9955 m0 *1 2.8,498.96
X$9955 1549 2984 2985 1631 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9960 m0 *1 19.6,498.96
X$9960 1551 2984 2985 1639 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $9963 m0 *1 2.24,509.04
X$9963 1601 2984 2985 1552 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9966 r0 *1 12.32,488.88
X$9966 2985 1578 1553 2984 1580 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9982 r0 *1 35.28,519.12
X$9982 2984 1555 1781 2985 1790 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9988 r0 *1 101.92,488.88
X$9988 2984 1558 1559 2985 1604 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9994 r0 *1 101.92,498.96
X$9994 2984 1661 2985 1636 1638 1558 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10000 r0 *1 90.72,519.12
X$10000 2984 1637 1559 2985 1731 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10005 r0 *1 115.92,509.04
X$10005 2985 2984 1698 1559 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10008 r0 *1 140.56,630
X$10008 2984 1559 2296 2985 2314 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10010 r0 *1 134.4,599.76
X$10010 2984 2030 1559 2985 2173 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10012 m0 *1 72.8,589.68
X$10012 2984 2055 1559 2985 2053 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10014 m0 *1 89.6,619.92
X$10014 2984 2274 1559 2985 2263 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10016 m0 *1 151.76,539.28
X$10016 2984 1559 1824 2985 1853 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10018 r0 *1 148.4,549.36
X$10018 2984 1559 1880 2985 1953 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10020 r0 *1 66.08,630
X$10020 2984 2291 1559 2985 2333 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10045 m0 *1 100.8,498.96
X$10045 2985 2984 1625 1638 1560 1604 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10050 m0 *1 129.36,539.28
X$10050 2985 2984 1561 1698 1851 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $10053 m0 *1 123.76,539.28
X$10053 2985 1698 1561 2984 1822 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10061 m0 *1 115.92,498.96
X$10061 2984 2985 1562 1640 1639 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $10063 m0 *1 124.88,498.96
X$10063 2984 1562 1639 1698 2985 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $10074 m0 *1 413.84,942.48
X$10074 1563 2984 2985 2954 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10081 m0 *1 435.12,519.12
X$10081 1756 2985 2984 1765 1564 1738 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $10083 r0 *1 471.52,488.88
X$10083 2984 1565 1566 2985 1564 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10090 m0 *1 468.72,498.96
X$10090 2984 1606 1565 2985 1643 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10102 r0 *1 548.24,488.88
X$10102 2984 1644 1567 2985 1593 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10104 m0 *1 550.48,509.04
X$10104 1647 2984 1646 1645 2985 1567 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10115 m0 *1 580.16,498.96
X$10115 1624 2985 2984 1620 1626 1569 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $10131 r0 *1 870.24,488.88
X$10131 1573 1621 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10133 r0 *1 868,488.88
X$10133 2985 2984 1573 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10135 m0 *1 908.88,488.88
X$10135 1585 1574 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10138 r0 *1 931.84,488.88
X$10138 2985 2984 1575 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10140 r0 *1 934.08,488.88
X$10140 1575 1618 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10142 r0 *1 924,488.88
X$10142 1576 2984 2985 1583 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $10145 r0 *1 919.52,488.88
X$10145 1577 2984 2985 1620 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $10172 r0 *1 903.28,488.88
X$10172 2985 2984 1585 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10178 m0 *1 888.72,488.88
X$10178 2985 2984 1586 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10220 r0 *1 2.24,509.04
X$10220 1598 2984 2985 1659 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10223 r0 *1 10.64,498.96
X$10223 1599 2984 2985 1658 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10226 r0 *1 2.24,498.96
X$10226 1600 2984 2985 1657 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10231 m0 *1 11.2,498.96
X$10231 1602 2984 2985 1632 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10234 m0 *1 85.68,509.04
X$10234 2984 1635 1697 2985 1603 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10242 r0 *1 455.84,498.96
X$10242 2984 1606 1666 2985 1668 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10263 m0 *1 866.32,498.96
X$10263 1609 1651 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10265 m0 *1 864.08,498.96
X$10265 2985 2984 1609 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10267 m0 *1 880.32,498.96
X$10267 2985 2984 1610 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10269 r0 *1 879.76,488.88
X$10269 1610 1617 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10271 m0 *1 891.52,498.96
X$10271 2985 2984 1611 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10273 m0 *1 893.76,498.96
X$10273 1611 1654 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10275 m0 *1 905.52,498.96
X$10275 2985 2984 1612 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10277 m0 *1 907.76,498.96
X$10277 1612 1616 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10279 m0 *1 929.6,498.96
X$10279 1613 1615 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10281 m0 *1 927.36,498.96
X$10281 2985 2984 1613 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10283 r0 *1 914.48,498.96
X$10283 1614 2984 2985 1662 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $10296 r0 *1 79.52,498.96
X$10296 2984 1635 1637 2985 1619 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10311 r0 *1 582.4,498.96
X$10311 2984 1647 1672 2985 1623 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10334 m0 *1 403.76,942.48
X$10334 1628 2984 2985 2953 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10343 r0 *1 19.04,498.96
X$10343 1630 2984 2985 1660 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10346 m0 *1 13.44,529.2
X$10346 1787 2985 2984 1631 1811 1748 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $10351 m0 *1 20.16,509.04
X$10351 1715 2985 2984 1632 1634 1690 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $10354 r0 *1 101.92,519.12
X$10354 2984 1761 1762 2985 1633 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10368 m0 *1 89.6,519.12
X$10368 2985 2984 1696 1753 1635 1731 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10377 r0 *1 119.28,498.96
X$10377 2985 2984 1640 1636 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10380 m0 *1 114.24,539.28
X$10380 2984 1822 2985 1636 1874 1849 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10382 m0 *1 115.36,599.76
X$10382 2985 1636 2093 2984 2133 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10385 r0 *1 53.2,569.52
X$10385 2984 1661 2985 1636 2052 1877 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10387 r0 *1 122.08,569.52
X$10387 2984 1822 2985 2058 2046 1636 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10389 m0 *1 127.68,569.52
X$10389 2984 1822 2985 2029 2021 1636 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10392 r0 *1 48.72,599.76
X$10392 2984 1661 2985 2206 2167 1636 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10394 r0 *1 48.72,609.84
X$10394 2985 1636 2239 2984 2261 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10398 m0 *1 81.76,519.12
X$10398 2984 1661 2985 1636 1753 1637 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10415 m0 *1 95.76,579.6
X$10415 2054 2056 1961 1637 2985 2984 2292 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10417 r0 *1 101.92,569.52
X$10417 2984 1961 1637 2985 2057 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10420 r0 *1 74.48,549.36
X$10420 1905 1694 1847 1879 2985 2984 1637 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10422 m0 *1 102.48,549.36
X$10422 2984 1848 1637 2985 1849 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10445 r0 *1 105.84,619.92
X$10445 2985 1640 1823 2984 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $10449 r0 *1 118.72,640.08
X$10449 2985 1640 2311 2984 2312 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10451 m0 *1 106.4,640.08
X$10451 2985 1640 2308 2984 2334 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10456 r0 *1 148.4,509.04
X$10456 2984 1700 2985 1699 1641 1684 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10461 r0 *1 486.64,509.04
X$10461 2984 1701 1702 2985 1642 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10479 r0 *1 514.08,498.96
X$10479 2985 2984 1688 1665 1644 1664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10488 r0 *1 553.84,498.96
X$10488 2984 1646 1645 2985 1648 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10501 r0 *1 540.4,509.04
X$10501 2985 2984 1703 1671 1646 1704 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10508 r0 *1 571.76,509.04
X$10508 2985 2984 1705 1720 1647 1719 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10520 r0 *1 879.76,498.96
X$10520 1649 1656 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10522 r0 *1 877.52,498.96
X$10522 2985 2984 1649 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10524 r0 *1 921.76,498.96
X$10524 1650 1679 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10526 r0 *1 918.96,498.96
X$10526 2985 2984 1650 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10530 r0 *1 931.28,498.96
X$10530 2985 2984 1652 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10532 r0 *1 934.08,498.96
X$10532 1652 1683 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10534 m0 *1 885.92,509.04
X$10534 1674 1653 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10539 m0 *1 917.28,498.96
X$10539 1663 1655 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10544 r0 *1 10.64,509.04
X$10544 1714 2985 2984 1657 1693 1689 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $10561 m0 *1 99.12,640.08
X$10561 2309 2984 1661 2334 2985 2348 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10564 m0 *1 117.6,640.08
X$10564 2310 2984 1661 2312 2985 2350 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10567 m0 *1 45.36,619.92
X$10567 2269 2984 1661 2261 2985 2287 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10569 r0 *1 115.92,589.68
X$10569 2059 2984 1661 2133 2985 2152 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10572 m0 *1 117.04,549.36
X$10572 2985 2984 1822 1661 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10576 r0 *1 66.64,549.36
X$10576 2984 1661 2985 1904 1935 1823 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10597 r0 *1 604.24,519.12
X$10597 1783 2985 2984 1662 1782 1741 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $10603 r0 *1 912.24,498.96
X$10603 2985 2984 1663 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10619 r0 *1 104.72,529.2
X$10619 2984 1821 1849 2985 1667 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10624 r0 *1 442.4,519.12
X$10624 1792 2985 2984 1939 1668 1768 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $10632 m0 *1 469.28,529.2
X$10632 1669 2985 1739 2984 1817 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10634 r0 *1 488.88,519.12
X$10634 1669 2984 1769 1794 2985 1702 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10660 r0 *1 602.56,509.04
X$10660 2985 1706 2984 1673 1798 1740 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10662 m0 *1 600.32,529.2
X$10662 2984 1797 2985 1673 1813 1752 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10667 r0 *1 886.48,509.04
X$10667 2985 2984 1674 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10669 m0 *1 899.36,509.04
X$10669 2985 2984 1675 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10671 m0 *1 901.6,509.04
X$10671 1675 1677 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10673 m0 *1 911.68,509.04
X$10673 2985 2984 1676 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10675 m0 *1 913.92,509.04
X$10675 1676 1682 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10679 m0 *1 927.36,509.04
X$10679 2985 2984 1678 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10681 m0 *1 929.6,509.04
X$10681 1678 1681 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10685 m0 *1 874.72,509.04
X$10685 1686 1680 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10696 m0 *1 148.4,519.12
X$10696 2984 1699 1734 1684 1700 1732 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $10708 m0 *1 865.2,509.04
X$10708 2985 2984 1686 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10720 m0 *1 13.44,519.12
X$10720 2985 1727 1689 1748 1690 2984 1725 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $10722 r0 *1 20.16,509.04
X$10722 2985 1715 2984 1726 1716 1690 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10739 r0 *1 41.44,529.2
X$10739 2984 1728 1819 2985 1693 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10744 r0 *1 82.32,549.36
X$10744 1694 2984 1847 1906 2985 1697 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10747 r0 *1 101.92,549.36
X$10747 1936 2984 1848 1694 2985 1907 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10777 r0 *1 80.08,569.52
X$10777 2985 2984 1695 gf180mcu_fd_sc_mcu9t5v0__clkinv_1
* cell instance $10803 m0 *1 112,569.52
X$10803 1961 2984 1698 1697 2985 2044 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10807 r0 *1 109.76,559.44
X$10807 2028 1961 1698 1697 2985 2984 2020 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10814 m0 *1 114.8,519.12
X$10814 2985 2984 1698 1732 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10818 r0 *1 127.68,609.84
X$10818 2984 2243 1698 2985 2264 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10837 r0 *1 147.84,519.12
X$10837 2985 1790 1764 2984 1699 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10841 r0 *1 153.44,519.12
X$10841 2984 1791 2985 1764 1700 1784 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10852 r0 *1 491.12,529.2
X$10852 1794 2984 1701 1770 2985 1841 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10855 m0 *1 477.68,569.52
X$10855 1997 2984 1999 1998 2985 1701 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10872 r0 *1 871.92,509.04
X$10872 2985 2984 1707 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10874 r0 *1 874.16,509.04
X$10874 1707 1717 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10876 r0 *1 888.72,509.04
X$10876 1708 1711 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10878 m0 *1 887.6,519.12
X$10878 2985 2984 1708 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10880 r0 *1 915.6,509.04
X$10880 1718 1709 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10883 r0 *1 931.84,509.04
X$10883 2985 2984 1710 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10885 r0 *1 934.08,509.04
X$10885 1710 1712 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10891 m0 *1 934.08,519.12
X$10891 1745 1713 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10894 r0 *1 7.28,519.12
X$10894 1714 2984 1748 1725 2985 1757 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10903 r0 *1 13.44,519.12
X$10903 1787 2985 1757 1780 2984 1716 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $10910 r0 *1 911.68,509.04
X$10910 2985 2984 1718 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10923 r0 *1 156.8,509.04
X$10923 2984 1734 1721 2985 1722 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10934 r0 *1 440.72,509.04
X$10934 2985 1756 2984 1754 1724 1738 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10937 m0 *1 436.24,529.2
X$10937 2985 1792 1766 2984 1724 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10944 m0 *1 23.52,519.12
X$10944 2984 1726 2985 1758 1750 1727 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $10948 r0 *1 23.52,519.12
X$10948 2985 2984 1781 1727 1902 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $10955 m0 *1 54.32,539.28
X$10955 1759 1728 1846 1820 2985 2984 1847 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10958 m0 *1 47.04,539.28
X$10958 1728 1846 1820 1879 2985 2984 1788 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10968 m0 *1 52.64,529.2
X$10968 2984 1759 1788 2985 1730 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10975 r0 *1 48.16,569.52
X$10975 2984 1877 1732 2985 2051 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10980 m0 *1 129.92,529.2
X$10980 2984 1732 1762 2985 1763 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10985 m0 *1 114.8,650.16
X$10985 2985 2310 2984 2335 2311 1732 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10987 m0 *1 35.28,619.92
X$10987 2985 2269 2984 2270 2239 1732 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10989 m0 *1 76.16,559.44
X$10989 2984 1732 1904 2985 1989 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10991 m0 *1 105.84,589.68
X$10991 2985 2059 2984 2095 2093 1732 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10993 r0 *1 32.48,579.6
X$10993 2985 2984 2123 1851 2048 1732 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10995 r0 *1 93.52,640.08
X$10995 2985 2309 2984 2356 2308 1732 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11014 r0 *1 127.12,519.12
X$11014 2985 2984 1733 1789 1761 1763 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11019 m0 *1 165.2,519.12
X$11019 2985 2984 1734 1736 1735 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11031 r0 *1 376.88,932.4
X$11031 1737 2984 2985 2918 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11039 m0 *1 451.36,529.2
X$11039 1738 2984 1793 1768 2985 1883 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11064 m0 *1 613.76,519.12
X$11064 2985 2984 1771 1752 1741 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11066 m0 *1 854,519.12
X$11066 2985 2984 1742 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11068 m0 *1 856.24,519.12
X$11068 1742 1749 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11070 m0 *1 870.8,519.12
X$11070 1743 1747 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11072 m0 *1 868.56,519.12
X$11072 2985 2984 1743 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11074 m0 *1 917.84,519.12
X$11074 1744 1778 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11076 m0 *1 914.48,519.12
X$11076 2985 2984 1744 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11079 m0 *1 931.84,519.12
X$11079 2985 2984 1745 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11081 m0 *1 899.36,519.12
X$11081 1751 1746 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11088 r0 *1 2.24,519.12
X$11088 2984 1748 1779 2985 1780 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11104 m0 *1 895.44,519.12
X$11104 2985 2984 1751 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11122 r0 *1 446.88,539.28
X$11122 2984 1910 1755 1882 1883 1899 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $11133 r0 *1 10.64,539.28
X$11133 2985 1895 2984 1843 1871 1894 1758 1845
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11149 r0 *1 136.08,529.2
X$11149 2985 1824 1821 2984 1761 1762 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $11158 r0 *1 127.12,529.2
X$11158 2984 1822 2985 1762 1789 1823 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11169 r0 *1 160.16,599.76
X$11169 2985 2195 2197 2136 2174 1764 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $11176 m0 *1 437.36,942.48
X$11176 2955 2984 2985 1765 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $11180 r0 *1 437.36,519.12
X$11180 2984 1768 1767 2985 1766 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11182 m0 *1 441.84,529.2
X$11182 1767 2985 2984 1816 1817 1793 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $11192 m0 *1 475.44,539.28
X$11192 2984 1769 1841 2985 1885 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11204 r0 *1 554.4,529.2
X$11204 1826 2984 1828 1827 2985 1770 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11213 r0 *1 596.96,519.12
X$11213 2985 1785 2984 1797 1783 1771 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11223 r0 *1 543.76,529.2
X$11223 2984 1825 1990 2985 1772 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11229 r0 *1 857.92,519.12
X$11229 1774 1776 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11231 r0 *1 855.68,519.12
X$11231 2985 2984 1774 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11233 r0 *1 880.32,519.12
X$11233 1775 1777 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11235 r0 *1 876.96,519.12
X$11235 2985 2984 1775 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11255 r0 *1 561.12,529.2
X$11255 2984 1828 1827 2985 1782 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11260 r0 *1 144.48,519.12
X$11260 2985 2984 1790 1784 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11285 r0 *1 150.08,609.84
X$11285 2984 2225 1791 2267 2266 2244 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $11300 m0 *1 484.4,549.36
X$11300 2984 1794 1886 2985 1912 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11303 m0 *1 561.68,599.76
X$11303 2985 1795 2193 2140 2139 2192 2105 2984
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $11307 m0 *1 578.48,539.28
X$11307 2984 1826 1859 2985 1796 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11315 m0 *1 856.8,529.2
X$11315 2985 2984 1799 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11317 m0 *1 859.6,529.2
X$11317 1799 1810 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11319 r0 *1 867.44,519.12
X$11319 1800 1806 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11321 m0 *1 869.12,529.2
X$11321 2985 2984 1800 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11323 m0 *1 884.8,529.2
X$11323 2985 2984 1801 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11325 m0 *1 887.6,529.2
X$11325 1801 1803 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11327 m0 *1 899.36,529.2
X$11327 2985 2984 1802 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11329 m0 *1 901.6,529.2
X$11329 1802 1805 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11333 m0 *1 927.36,529.2
X$11333 2985 2984 1804 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11335 m0 *1 929.6,529.2
X$11335 1804 1807 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11343 m0 *1 874.72,529.2
X$11343 1812 1808 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11346 m0 *1 911.12,529.2
X$11346 1838 1809 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11353 m0 *1 67.76,549.36
X$11353 2984 1905 1904 2985 1811 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11358 m0 *1 871.36,529.2
X$11358 2985 2984 1812 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11375 r0 *1 442.96,932.4
X$11375 2958 2984 2985 1816 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $11384 m0 *1 10.64,539.28
X$11384 1818 2984 2985 1844 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11387 r0 *1 39.76,539.28
X$11387 1846 2984 1820 1877 2985 1819 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11390 m0 *1 29.12,549.36
X$11390 2984 1820 1877 2985 1896 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11392 r0 *1 34.16,549.36
X$11392 2984 1820 1879 2985 1903 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11400 m0 *1 50.96,579.6
X$11400 2985 2984 2075 2052 1820 2051 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11408 m0 *1 143.92,549.36
X$11408 1881 2984 1852 1821 2985 1936 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11413 m0 *1 105.28,539.28
X$11413 2985 2984 1850 1874 1821 1873 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11415 r0 *1 144.48,539.28
X$11415 2985 1880 1852 2984 1821 1849 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $11440 r0 *1 78.4,619.92
X$11440 2984 2288 2985 2293 2274 2272 1823 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $11442 r0 *1 56,630
X$11442 2984 2331 2985 2332 2291 2271 1823 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $11444 m0 *1 139.44,630
X$11444 2984 2295 2985 2307 1823 2297 2296 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $11446 m0 *1 119.84,619.92
X$11446 2984 2241 2985 2289 2243 2242 1823 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $11449 r0 *1 132.16,589.68
X$11449 2984 2153 2985 2125 2030 2076 1823 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $11452 m0 *1 75.04,579.6
X$11452 2984 2072 2985 2091 2055 2054 1823 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $11455 r0 *1 56.56,599.76
X$11455 2984 2168 2985 2132 1823 2131 2169 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $11472 m0 *1 169.12,539.28
X$11472 1852 2985 1824 2984 1876 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11482 m0 *1 542.64,569.52
X$11482 2004 2036 1914 1825 2985 2984 2007 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11484 m0 *1 548.8,549.36
X$11484 1914 2984 1825 1915 2985 1827 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11494 m0 *1 577.36,549.36
X$11494 2985 2984 1898 1926 1826 1916 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11511 r0 *1 566.72,549.36
X$11511 2984 1828 1940 2985 1859 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11518 r0 *1 557.2,539.28
X$11518 2985 2984 1857 1875 1828 1858 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11526 r0 *1 885.36,529.2
X$11526 1829 1834 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11528 r0 *1 882,529.2
X$11528 2985 2984 1829 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11530 r0 *1 913.92,529.2
X$11530 2985 2984 1830 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11532 r0 *1 916.16,529.2
X$11532 1830 1831 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11536 r0 *1 929.6,529.2
X$11536 1832 1833 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11538 r0 *1 927.36,529.2
X$11538 2985 2984 1832 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11544 m0 *1 934.08,539.28
X$11544 1866 1835 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11547 m0 *1 934.08,549.36
X$11547 1921 1836 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11550 m0 *1 867.44,539.28
X$11550 1872 1837 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11555 r0 *1 910.56,529.2
X$11555 2985 2984 1838 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11570 r0 *1 2.24,539.28
X$11570 1842 2984 2985 1925 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11573 m0 *1 10.64,559.44
X$11573 2984 1957 2985 1951 1843 1930 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11576 r0 *1 22.96,539.28
X$11576 2985 1871 1845 1844 1878 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $11581 m0 *1 23.52,549.36
X$11581 2984 1845 1901 2985 1895 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11583 r0 *1 22.4,549.36
X$11583 2985 1902 1932 1931 1845 2984 1901 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $11590 m0 *1 38.64,549.36
X$11590 2984 1846 1903 2985 1878 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11607 r0 *1 69.44,539.28
X$11607 2984 1877 1847 2985 1904 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11620 m0 *1 102.48,559.44
X$11620 2984 1936 1848 2985 1961 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11627 m0 *1 136.08,559.44
X$11627 2985 1936 1849 2028 1962 2030 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $11641 r0 *1 72.24,569.52
X$11641 2984 2054 2985 2053 2072 1851 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11643 r0 *1 153.44,549.36
X$11643 2984 1881 2985 1953 1908 1851 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11646 m0 *1 129.92,599.76
X$11646 2984 2076 2985 2173 2153 1851 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11648 r0 *1 145.6,630
X$11648 2984 2297 2985 2314 2295 1851 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11650 r0 *1 119.84,609.84
X$11650 2984 2242 2985 2264 2241 1851 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11652 r0 *1 153.44,539.28
X$11652 2984 1852 2985 1853 1854 1851 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11655 m0 *1 61.04,640.08
X$11655 2984 2271 2985 2333 2331 1851 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11657 m0 *1 81.76,619.92
X$11657 2984 2272 2985 2263 2288 1851 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11709 r0 *1 854.56,539.28
X$11709 2985 2984 1860 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11711 r0 *1 856.8,539.28
X$11711 1860 1891 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11713 r0 *1 866.88,539.28
X$11713 1861 1893 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11715 m0 *1 865.76,549.36
X$11715 2985 2984 1861 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11717 m0 *1 888.16,539.28
X$11717 1862 1869 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11719 m0 *1 885.92,539.28
X$11719 2985 2984 1862 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11721 m0 *1 906.08,539.28
X$11721 2985 2984 1863 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11723 m0 *1 908.32,539.28
X$11723 1863 1865 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11725 m0 *1 919.52,539.28
X$11725 1864 1870 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11727 r0 *1 919.52,539.28
X$11727 2985 2984 1864 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11732 m0 *1 931.28,539.28
X$11732 2985 2984 1866 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11734 r0 *1 931.84,539.28
X$11734 2985 2984 1867 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11736 r0 *1 934.08,539.28
X$11736 1867 1868 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11748 m0 *1 863.52,539.28
X$11748 2985 2984 1872 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11765 r0 *1 196.56,599.76
X$11765 2177 2985 2984 2235 1876 2234 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $11776 m0 *1 77.28,549.36
X$11776 2984 1905 1877 2985 1906 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11780 r0 *1 24.64,569.52
X$11780 2985 1877 2050 2048 2049 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $11798 m0 *1 31.36,569.52
X$11798 2984 2049 2048 2985 1879 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11806 m0 *1 178.64,559.44
X$11806 1881 2985 1880 2984 1965 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11825 m0 *1 450.8,559.44
X$11825 1966 1882 1969 1992 2985 2984 1911 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11828 m0 *1 442.4,549.36
X$11828 1910 2985 2984 1955 1885 1882 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $11849 m0 *1 539.28,549.36
X$11849 2984 1914 1915 2985 1888 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11855 m0 *1 883.12,549.36
X$11855 2985 2984 1889 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11857 r0 *1 883.68,539.28
X$11857 1889 1892 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11859 m0 *1 885.92,549.36
X$11859 1917 1890 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11869 m0 *1 14,549.36
X$11869 1894 2985 2984 1925 1896 1901 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $11881 m0 *1 895.44,549.36
X$11881 1918 1897 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11890 m0 *1 435.12,559.44
X$11890 2984 1937 2985 1993 1899 1967 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11895 r0 *1 3.92,549.36
X$11895 1900 2984 2985 1950 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11913 m0 *1 67.76,559.44
X$11913 2985 2984 1988 1935 1905 1989 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11933 r0 *1 433.44,549.36
X$11933 2985 2984 1937 1910 1954 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $11941 r0 *1 439.04,549.36
X$11941 1954 2985 2984 2429 1912 1938 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $11954 r0 *1 546,559.44
X$11954 2005 2984 1914 2006 2985 1990 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11968 r0 *1 539.84,559.44
X$11968 1971 2984 2003 2005 2985 1915 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11973 r0 *1 885.92,549.36
X$11973 2985 2984 1917 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11976 r0 *1 894.32,549.36
X$11976 2985 2984 1918 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11979 r0 *1 904.4,549.36
X$11979 2985 2984 1919 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11981 m0 *1 906.64,549.36
X$11981 1919 1922 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11983 r0 *1 918.4,549.36
X$11983 2985 2984 1920 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11985 m0 *1 918.96,549.36
X$11985 1920 1946 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11988 m0 *1 931.84,549.36
X$11988 2985 2984 1921 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $11992 m0 *1 868,549.36
X$11992 1952 1923 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $11995 r0 *1 857.92,549.36
X$11995 1941 1924 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12014 m0 *1 2.24,559.44
X$12014 1929 2984 2985 1958 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12017 r0 *1 15.68,549.36
X$12017 2985 2984 1931 1930 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12023 r0 *1 7.84,559.44
X$12023 1956 2985 2984 1958 2043 1931 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12027 m0 *1 18.48,559.44
X$12027 1951 2985 2984 1959 1960 1932 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12049 m0 *1 442.96,559.44
X$12049 2984 1938 2985 1968 1993 1969 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12053 m0 *1 435.68,932.4
X$12053 2920 2984 2985 1939 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $12064 m0 *1 549.92,569.52
X$12064 2003 2984 2005 2007 2985 1940 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $12068 r0 *1 855.68,549.36
X$12068 2985 2984 1941 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12070 r0 *1 874.16,549.36
X$12070 2985 2984 1942 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12072 r0 *1 876.4,549.36
X$12072 1942 1944 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12074 r0 *1 906.64,549.36
X$12074 2985 2984 1943 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12076 r0 *1 908.88,549.36
X$12076 1943 1947 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12080 r0 *1 927.92,549.36
X$12080 1945 2017 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12082 m0 *1 929.04,569.52
X$12082 2985 2984 1945 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12088 m0 *1 906.08,559.44
X$12088 1978 1948 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12091 m0 *1 865.2,559.44
X$12091 1975 1949 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12094 r0 *1 17.92,559.44
X$12094 2985 2984 1950 1959 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12104 r0 *1 867.44,549.36
X$12104 2985 2984 1952 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12114 r0 *1 438.48,932.4
X$12114 2956 2984 2985 1955 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $12119 r0 *1 4.48,559.44
X$12119 2985 2984 1956 1957 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12131 m0 *1 24.64,569.52
X$12131 2985 2984 2048 1960 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12143 m0 *1 119.28,569.52
X$12143 2985 2984 2023 2021 1962 2020 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12146 r0 *1 114.24,579.6
X$12146 2076 1962 2028 2058 2985 2984 2093 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $12148 m0 *1 113.68,579.6
X$12148 2059 2076 1962 2028 2985 2984 2056 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $12152 r0 *1 137.2,579.6
X$12152 2984 1962 2029 2985 2077 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12163 r0 *1 148.4,569.52
X$12163 2984 1964 1996 2985 2028 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12166 r0 *1 157.36,569.52
X$12166 2984 1964 2047 2985 2031 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12174 m0 *1 183.68,599.76
X$12174 2199 2985 2984 2154 1965 2175 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12177 r0 *1 436.24,559.44
X$12177 2024 1966 2032 1967 1968 2984 2985 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $12181 r0 *1 441.84,569.52
X$12181 2032 2985 2984 2922 2061 1966 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12187 m0 *1 446.32,569.52
X$12187 1968 2985 2984 2924 2033 1969 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12198 r0 *1 502.32,559.44
X$12198 2985 2984 2001 1991 1998 1970 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12201 r0 *1 548.24,579.6
X$12201 2984 1971 2003 2985 2100 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12208 r0 *1 533.12,579.6
X$12208 2985 1971 2080 2004 2036 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12214 m0 *1 532.56,569.52
X$12214 2985 2984 2002 1972 2003 1973 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12219 m0 *1 558.32,569.52
X$12219 2985 2984 2008 1974 2005 2045 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12221 m0 *1 862.96,559.44
X$12221 2985 2984 1975 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12224 r0 *1 877.52,559.44
X$12224 1976 2018 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12226 r0 *1 875.28,559.44
X$12226 2985 2984 1976 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12228 m0 *1 882.56,559.44
X$12228 2985 2984 1977 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12230 m0 *1 885.36,559.44
X$12230 1977 1986 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12233 m0 *1 903.84,559.44
X$12233 2985 2984 1978 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12235 r0 *1 916.16,559.44
X$12235 2985 2984 1979 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12237 r0 *1 921.2,559.44
X$12237 1979 1987 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12239 m0 *1 920.08,559.44
X$12239 2985 2984 1980 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12241 m0 *1 922.32,559.44
X$12241 1980 1983 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12243 m0 *1 934.08,559.44
X$12243 1981 1985 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12245 m0 *1 931.84,559.44
X$12245 2985 2984 1981 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12247 r0 *1 931.84,559.44
X$12247 2985 2984 1982 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12249 r0 *1 934.08,559.44
X$12249 1982 1984 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12278 r0 *1 445.76,559.44
X$12278 2024 2985 2984 2026 2025 1992 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12288 r0 *1 134.96,569.52
X$12288 2985 2984 1995 2046 1996 2044 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12291 m0 *1 146.72,579.6
X$12291 2984 1996 2058 2985 2156 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12294 r0 *1 143.36,569.52
X$12294 2984 1996 2057 2985 2047 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12304 m0 *1 462,569.52
X$12304 2984 1997 2027 2985 2033 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12326 m0 *1 483.84,569.52
X$12326 2984 1999 2000 2985 2061 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12345 r0 *1 541.52,569.52
X$12345 2004 2984 2036 2003 2985 2006 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $12354 m0 *1 553.28,589.68
X$12354 2985 2984 2004 2099 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12364 m0 *1 560.56,579.6
X$12364 2984 2005 2006 2985 2081 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12393 m0 *1 854,569.52
X$12393 2009 2010 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12395 m0 *1 851.76,569.52
X$12395 2985 2984 2009 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12399 m0 *1 899.92,569.52
X$12399 2985 2984 2011 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12401 m0 *1 902.16,569.52
X$12401 2011 2041 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12403 m0 *1 919.52,569.52
X$12403 2012 2019 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12405 r0 *1 918.96,569.52
X$12405 2985 2984 2012 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12407 m0 *1 888.16,569.52
X$12407 2022 2013 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12410 m0 *1 934.08,569.52
X$12410 2014 2015 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12412 m0 *1 931.84,569.52
X$12412 2985 2984 2014 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12416 r0 *1 927.36,569.52
X$12416 2040 2016 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12435 m0 *1 872.48,569.52
X$12435 2985 2984 2022 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12448 m0 *1 451.36,942.48
X$12448 2960 2984 2985 2026 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $12457 m0 *1 133.84,579.6
X$12457 2984 2028 2058 2985 2029 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12473 m0 *1 139.44,599.76
X$12473 2076 2985 2030 2984 2157 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12481 m0 *1 179.76,589.68
X$12481 2985 2098 2174 2126 2031 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12506 r0 *1 870.24,569.52
X$12506 2037 2067 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12508 r0 *1 868,569.52
X$12508 2985 2984 2037 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12510 m0 *1 874.72,579.6
X$12510 2985 2984 2038 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12512 r0 *1 879.76,569.52
X$12512 2038 2069 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12514 r0 *1 905.52,569.52
X$12514 2985 2984 2039 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12516 r0 *1 907.76,569.52
X$12516 2039 2068 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12519 r0 *1 925.12,569.52
X$12519 2985 2984 2040 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12523 m0 *1 903.28,579.6
X$12523 2090 2042 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12527 r0 *1 17.92,569.52
X$12527 2985 2984 2050 2043 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12575 m0 *1 77.84,589.68
X$12575 2054 2985 2055 2984 2094 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12592 m0 *1 90.72,579.6
X$12592 2985 2984 2056 2055 2057 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12621 r0 *1 103.04,599.76
X$12621 2984 2059 2093 2985 2227 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12637 m0 *1 845.6,579.6
X$12637 2062 2064 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12639 m0 *1 842.24,579.6
X$12639 2985 2984 2062 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12641 m0 *1 857.92,579.6
X$12641 2063 2071 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12643 r0 *1 858.48,579.6
X$12643 2985 2984 2063 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12647 m0 *1 915.04,579.6
X$12647 2985 2984 2065 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12649 m0 *1 922.32,579.6
X$12649 2065 2070 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12651 m0 *1 893.76,579.6
X$12651 2092 2066 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12675 m0 *1 20.16,579.6
X$12675 2985 2984 2089 2074 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12695 m0 *1 166.32,599.76
X$12695 2985 2137 2136 2198 2077 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12700 m0 *1 525.28,589.68
X$12700 2985 2984 2079 2127 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12704 m0 *1 545.44,599.76
X$12704 2985 2984 2080 2178 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12711 r0 *1 562.24,599.76
X$12711 2985 2192 2140 2179 2081 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12714 r0 *1 865.2,579.6
X$12714 2985 2984 2082 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12716 r0 *1 867.44,579.6
X$12716 2082 2088 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12718 r0 *1 888.72,579.6
X$12718 2083 2084 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12720 r0 *1 886.48,579.6
X$12720 2985 2984 2083 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12724 r0 *1 931.84,579.6
X$12724 2985 2984 2085 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12726 r0 *1 934.08,579.6
X$12726 2085 2116 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12728 r0 *1 921.2,579.6
X$12728 2112 2086 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12731 r0 *1 876.96,579.6
X$12731 2107 2087 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12742 m0 *1 891.52,579.6
X$12742 2985 2984 2090 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12749 m0 *1 876.96,579.6
X$12749 2985 2984 2092 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12765 m0 *1 79.52,599.76
X$12765 2170 2985 2984 2122 2094 2171 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12769 r0 *1 108.08,589.68
X$12769 2985 2984 2124 2095 2152 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $12771 m0 *1 164.08,609.84
X$12771 2985 2984 2096 2229 2097 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12773 r0 *1 162.96,589.68
X$12773 2985 2984 2134 2096 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12775 r0 *1 168.56,589.68
X$12775 2984 2135 2985 2136 2097 2137 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12780 r0 *1 177.52,599.76
X$12780 2137 2134 2098 2138 2984 2985 2231 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $12783 m0 *1 552.16,599.76
X$12783 2194 2985 2984 2290 2099 2103 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12786 r0 *1 554.96,589.68
X$12786 2105 2985 2984 2430 2100 2104 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12789 r0 *1 554.4,599.76
X$12789 2984 2196 2985 2194 2193 2101 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12791 m0 *1 558.88,589.68
X$12791 2985 2984 2102 2101 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12796 m0 *1 547.12,609.84
X$12796 2985 2209 2102 2210 2178 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $12805 r0 *1 564.48,589.68
X$12805 2984 2140 2104 2985 2139 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12812 r0 *1 848.96,589.68
X$12812 2106 2142 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12814 r0 *1 846.72,589.68
X$12814 2985 2984 2106 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12817 m0 *1 870.8,589.68
X$12817 2985 2984 2107 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12821 r0 *1 885.92,589.68
X$12821 2108 2146 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12823 r0 *1 883.68,589.68
X$12823 2985 2984 2108 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12825 m0 *1 890.96,589.68
X$12825 2985 2984 2109 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12827 m0 *1 893.2,589.68
X$12827 2109 2119 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12829 m0 *1 908.88,589.68
X$12829 2985 2984 2110 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12831 m0 *1 911.12,589.68
X$12831 2110 2115 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12833 r0 *1 921.76,589.68
X$12833 2111 2118 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12835 r0 *1 919.52,589.68
X$12835 2985 2984 2111 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12837 m0 *1 920.64,589.68
X$12837 2985 2984 2112 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12840 m0 *1 927.36,589.68
X$12840 2985 2984 2113 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12842 m0 *1 929.6,589.68
X$12842 2113 2120 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12844 r0 *1 934.08,589.68
X$12844 2114 2121 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12846 r0 *1 931.84,589.68
X$12846 2985 2984 2114 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12852 m0 *1 929.6,599.76
X$12852 2147 2117 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12864 r0 *1 2.8,589.68
X$12864 2128 2984 2985 2122 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12880 m0 *1 363.44,942.48
X$12880 2985 2984 2948 2126 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $12891 m0 *1 10.08,599.76
X$12891 2129 2984 2130 2165 2985 2164 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $12893 m0 *1 16.24,599.76
X$12893 2129 2985 2984 2166 2151 2187 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12897 r0 *1 18.48,599.76
X$12897 2203 2130 2187 2165 2985 2984 2204 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $12900 r0 *1 3.92,599.76
X$12900 2984 2130 2201 2985 2162 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12902 r0 *1 8.96,599.76
X$12902 2163 2985 2984 2202 2205 2130 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12907 r0 *1 72.8,619.92
X$12907 2985 2984 2131 2274 2292 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12909 r0 *1 64.4,619.92
X$12909 2271 2269 2272 2131 2985 2984 2273 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $12911 m0 *1 59.92,630
X$12911 2985 2131 2292 2272 2269 2291 2984 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $12913 m0 *1 52.64,599.76
X$12913 2985 2984 2131 2168 2167 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $12916 m0 *1 43.12,599.76
X$12916 2984 2131 2206 2985 2151 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12920 m0 *1 57.68,619.92
X$12920 2272 2984 2131 2206 2985 2239 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $12938 m0 *1 173.6,609.84
X$12938 2134 2985 2984 2230 2157 2135 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12942 m0 *1 193.2,609.84
X$12942 2176 2175 2234 2135 2985 2984 2197 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $12959 r0 *1 179.76,589.68
X$12959 2984 2174 2158 2985 2138 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12972 r0 *1 858.48,589.68
X$12972 2141 2148 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12974 m0 *1 852.88,599.76
X$12974 2985 2984 2141 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12980 m0 *1 897.68,599.76
X$12980 2985 2984 2143 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12982 m0 *1 899.92,599.76
X$12982 2143 2145 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12984 m0 *1 913.92,599.76
X$12984 2985 2984 2144 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $12986 m0 *1 916.16,599.76
X$12986 2144 2149 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $12992 m0 *1 927.36,599.76
X$12992 2985 2984 2147 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13001 m0 *1 866.32,599.76
X$13001 2191 2150 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13016 r0 *1 392.56,932.4
X$13016 2985 2984 2952 2154 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $13021 r0 *1 357.28,932.4
X$13021 2985 2984 2917 2155 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $13023 r0 *1 188.16,589.68
X$13023 2158 2985 2984 2155 2156 2176 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13039 r0 *1 21.84,609.84
X$13039 2159 2984 2985 2260 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13042 m0 *1 10.64,609.84
X$13042 2160 2984 2985 2166 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13045 m0 *1 2.24,609.84
X$13045 2161 2984 2985 2202 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13048 m0 *1 12.32,619.92
X$13048 2163 2985 2164 2162 2984 2224 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13060 r0 *1 5.6,609.84
X$13060 2201 2985 2984 2237 2240 2165 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13072 m0 *1 60.48,609.84
X$13072 2985 2984 2206 2169 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13075 r0 *1 78.96,599.76
X$13075 2985 2170 2189 2984 2190 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $13077 r0 *1 148.96,599.76
X$13077 2171 2207 2208 2204 2985 2984 2195 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13079 m0 *1 148.96,609.84
X$13079 2171 2207 2208 2204 2985 2984 2228 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13081 r0 *1 90.16,599.76
X$13081 2984 2171 2172 2985 2189 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13088 m0 *1 93.52,609.84
X$13088 2172 2985 2984 2260 2227 2207 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13093 r0 *1 187.04,599.76
X$13093 2985 2984 2174 2232 2176 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13101 m0 *1 193.2,599.76
X$13101 2985 2199 2984 2233 2175 2177 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13116 m0 *1 564.48,942.48
X$13116 2962 2984 2985 2179 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $13119 r0 *1 886.48,599.76
X$13119 2985 2984 2180 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13121 r0 *1 888.72,599.76
X$13121 2180 2186 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13123 r0 *1 902.16,599.76
X$13123 2985 2984 2181 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13125 r0 *1 904.4,599.76
X$13125 2181 2185 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13127 m0 *1 884.24,599.76
X$13127 2188 2182 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13130 r0 *1 929.04,599.76
X$13130 2183 2184 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13132 r0 *1 926.8,599.76
X$13132 2985 2984 2183 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13144 m0 *1 878.64,599.76
X$13144 2985 2984 2188 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13153 m0 *1 19.6,609.84
X$13153 2985 2225 2224 2204 2203 2259 2190 2984
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $13158 m0 *1 862.96,599.76
X$13158 2985 2984 2191 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13179 r0 *1 549.36,599.76
X$13179 2985 2984 2209 2196 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13188 m0 *1 348.32,942.48
X$13188 2985 2984 2947 2198 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $13197 m0 *1 2.24,619.92
X$13197 2200 2984 2985 2237 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13207 m0 *1 19.04,619.92
X$13207 2985 2259 2203 2268 2238 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13220 r0 *1 33.6,609.84
X$13220 2984 2269 2239 2985 2205 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13224 r0 *1 95.76,630
X$13224 2984 2273 2206 2985 2308 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13227 r0 *1 117.04,630
X$13227 2984 2206 2313 2985 2311 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13245 r0 *1 159.6,650.16
X$13245 2361 2362 2381 2363 2985 2984 2208 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13249 r0 *1 146.72,609.84
X$13249 2985 2984 2208 2267 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13256 r0 *1 549.92,932.4
X$13256 2961 2984 2985 2210 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $13259 m0 *1 860.72,609.84
X$13259 2985 2984 2211 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13261 m0 *1 862.96,609.84
X$13261 2211 2226 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13263 m0 *1 875.28,609.84
X$13263 2212 2216 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13265 m0 *1 873.04,609.84
X$13265 2985 2984 2212 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13267 m0 *1 891.52,609.84
X$13267 2985 2984 2213 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13269 m0 *1 893.76,609.84
X$13269 2213 2217 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13271 m0 *1 915.04,609.84
X$13271 2985 2984 2214 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13273 r0 *1 915.6,599.76
X$13273 2214 2219 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13275 m0 *1 917.28,609.84
X$13275 2985 2984 2215 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13277 m0 *1 919.52,609.84
X$13277 2215 2223 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13283 m0 *1 931.84,609.84
X$13283 2985 2984 2218 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13285 m0 *1 934.08,609.84
X$13285 2218 2220 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13291 r0 *1 882.56,609.84
X$13291 2249 2221 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13294 r0 *1 929.04,609.84
X$13294 2253 2222 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13317 r0 *1 164.64,609.84
X$13317 2984 2231 2266 2265 2228 2229 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $13326 m0 *1 371.84,942.48
X$13326 2985 2984 2949 2230 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $13334 m0 *1 187.6,609.84
X$13334 2985 2984 2265 2233 2232 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $13346 m0 *1 389.2,942.48
X$13346 2985 2984 2951 2235 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $13349 r0 *1 14,619.92
X$13349 2236 2984 2985 2268 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13356 r0 *1 52.08,619.92
X$13356 2271 2985 2291 2984 2238 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13369 m0 *1 66.64,619.92
X$13369 2272 2985 2274 2984 2240 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13375 m0 *1 129.92,630
X$13375 2242 2985 2243 2984 2379 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13379 m0 *1 120.96,630
X$13379 2984 2242 2294 2985 2313 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13388 m0 *1 115.92,630
X$13388 2985 2984 2294 2243 2292 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13397 m0 *1 155.12,640.08
X$13397 2984 2359 2336 2985 2244 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13399 m0 *1 847.28,619.92
X$13399 2245 2247 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13401 m0 *1 845.04,619.92
X$13401 2985 2984 2245 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13403 m0 *1 859.04,619.92
X$13403 2246 2258 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13405 m0 *1 856.8,619.92
X$13405 2985 2984 2246 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13409 m0 *1 881.44,619.92
X$13409 2248 2278 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13411 m0 *1 878.64,619.92
X$13411 2985 2984 2248 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13414 r0 *1 880.32,609.84
X$13414 2985 2984 2249 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13416 m0 *1 896,619.92
X$13416 2250 2285 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13418 m0 *1 893.76,619.92
X$13418 2985 2984 2250 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13420 r0 *1 914.48,609.84
X$13420 2985 2984 2251 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13422 r0 *1 917.28,609.84
X$13422 2251 2255 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13424 m0 *1 917.28,619.92
X$13424 2252 2284 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13426 m0 *1 915.04,619.92
X$13426 2985 2984 2252 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13428 r0 *1 926.8,609.84
X$13428 2985 2984 2253 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13431 m0 *1 931.84,619.92
X$13431 2985 2984 2254 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13433 m0 *1 934.08,619.92
X$13433 2254 2256 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13439 r0 *1 857.36,609.84
X$13439 2262 2257 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13456 r0 *1 853.44,609.84
X$13456 2985 2984 2262 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13497 r0 *1 36.96,619.92
X$13497 2985 2984 2306 2270 2287 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $13523 r0 *1 101.92,630
X$13523 2984 2309 2273 2985 2294 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13539 r0 *1 866.88,619.92
X$13539 2275 2280 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13541 r0 *1 864.64,619.92
X$13541 2985 2984 2275 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13543 r0 *1 883.68,619.92
X$13543 2985 2984 2276 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13545 r0 *1 885.92,619.92
X$13545 2276 2286 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13547 r0 *1 908.32,619.92
X$13547 2985 2984 2277 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13549 r0 *1 910.56,619.92
X$13549 2277 2283 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13553 r0 *1 929.6,619.92
X$13553 2279 2281 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13555 r0 *1 927.36,619.92
X$13555 2985 2984 2279 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13561 m0 *1 903.28,630
X$13561 2299 2282 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13583 r0 *1 554.96,619.92
X$13583 2985 2984 2744 2290 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13596 r0 *1 122.08,630
X$13596 2985 2296 2310 2984 2292 2313 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $13617 r0 *1 153.44,630
X$13617 2297 2985 2296 2984 2338 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13630 m0 *1 882,630
X$13630 2298 2305 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13632 m0 *1 879.76,630
X$13632 2985 2984 2298 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13634 m0 *1 901.04,630
X$13634 2985 2984 2299 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13637 m0 *1 915.6,630
X$13637 2300 2304 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13639 m0 *1 913.36,630
X$13639 2985 2984 2300 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13641 m0 *1 927.36,630
X$13641 2985 2984 2301 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13643 m0 *1 929.6,630
X$13643 2301 2302 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13647 r0 *1 874.72,630
X$13647 2318 2303 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13662 r0 *1 103.6,640.08
X$13662 2984 2309 2308 2985 2349 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13676 r0 *1 132.16,640.08
X$13676 2984 2310 2311 2985 2351 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13703 m0 *1 855.12,640.08
X$13703 2315 2317 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13705 m0 *1 852.88,640.08
X$13705 2985 2984 2315 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13707 r0 *1 862.96,630
X$13707 2316 2330 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13709 r0 *1 860.72,630
X$13709 2985 2984 2316 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13715 r0 *1 872.48,630
X$13715 2985 2984 2318 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13718 r0 *1 888.16,630
X$13718 2319 2325 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13720 r0 *1 885.92,630
X$13720 2985 2984 2319 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13722 m0 *1 882.56,640.08
X$13722 2354 2320 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13725 m0 *1 901.6,640.08
X$13725 2985 2984 2321 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13727 m0 *1 904.96,640.08
X$13727 2321 2342 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13729 m0 *1 917.84,640.08
X$13729 2985 2984 2322 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13731 m0 *1 920.08,640.08
X$13731 2322 2326 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13733 r0 *1 926.8,630
X$13733 2323 2328 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13735 r0 *1 924.56,630
X$13735 2985 2984 2323 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13737 m0 *1 933.52,640.08
X$13737 2324 2327 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13739 m0 *1 931.28,640.08
X$13739 2985 2984 2324 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13749 r0 *1 928.48,640.08
X$13749 2341 2329 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13772 r0 *1 124.32,640.08
X$13772 2985 2984 2357 2335 2350 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $13775 m0 *1 160.16,650.16
X$13775 2985 2337 2984 2336 2382 2361 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13781 r0 *1 155.68,640.08
X$13781 2985 2337 2361 2352 2338 2984 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $13785 r0 *1 860.16,640.08
X$13785 2985 2984 2339 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13787 r0 *1 862.4,640.08
X$13787 2339 2347 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13789 m0 *1 862.96,650.16
X$13789 2985 2984 2340 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13791 r0 *1 881.44,640.08
X$13791 2340 2343 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13795 r0 *1 926.24,640.08
X$13795 2985 2984 2341 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13802 r0 *1 934.08,650.16
X$13802 2372 2344 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13805 m0 *1 927.92,650.16
X$13805 2371 2345 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13808 m0 *1 892.08,640.08
X$13808 2353 2346 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13813 r0 *1 95.2,650.16
X$13813 2985 2984 2355 2356 2348 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $13818 m0 *1 150.64,650.16
X$13818 2358 2985 2984 2380 2349 2381 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13827 m0 *1 168,650.16
X$13827 2382 2985 2984 2981 2351 2362 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13832 m0 *1 340.48,942.48
X$13832 2985 2984 2946 2352 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $13839 r0 *1 891.52,640.08
X$13839 2985 2984 2353 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13842 m0 *1 878.64,640.08
X$13842 2985 2984 2354 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13853 m0 *1 150.08,660.24
X$13853 2984 2358 2363 2985 2384 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13856 r0 *1 150.08,650.16
X$13856 2984 2384 2359 2360 2361 2362 2985 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $13860 m0 *1 155.68,660.24
X$13860 2360 2985 2984 2400 2379 2363 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $13881 m0 *1 869.12,650.16
X$13881 2364 2370 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13883 m0 *1 866.88,650.16
X$13883 2985 2984 2364 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13885 m0 *1 880.32,650.16
X$13885 2985 2984 2365 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13887 m0 *1 882.56,650.16
X$13887 2365 2369 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13889 r0 *1 882.56,650.16
X$13889 2985 2984 2366 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13891 r0 *1 884.8,650.16
X$13891 2366 2374 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13893 m0 *1 913.92,650.16
X$13893 2985 2984 2367 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13895 m0 *1 916.16,650.16
X$13895 2367 2377 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13897 r0 *1 915.04,650.16
X$13897 2985 2984 2368 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13899 r0 *1 918.4,650.16
X$13899 2368 2376 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13905 m0 *1 925.68,650.16
X$13905 2985 2984 2371 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13908 r0 *1 931.84,650.16
X$13908 2985 2984 2372 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13911 m0 *1 915.6,660.24
X$13911 2401 2373 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13916 m0 *1 934.08,660.24
X$13916 2394 2375 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13923 r0 *1 900.48,650.16
X$13923 2383 2378 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13930 m0 *1 331.52,942.48
X$13930 2944 2984 2985 2380 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $13945 r0 *1 894.32,650.16
X$13945 2985 2984 2383 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13950 m0 *1 856.8,660.24
X$13950 2385 2387 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13952 m0 *1 854.56,660.24
X$13952 2985 2984 2385 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13954 m0 *1 866.32,660.24
X$13954 2386 2396 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13956 r0 *1 863.52,660.24
X$13956 2985 2984 2386 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13960 m0 *1 876.96,660.24
X$13960 2985 2984 2388 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13962 m0 *1 879.2,660.24
X$13962 2388 2399 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13964 r0 *1 886.48,660.24
X$13964 2985 2984 2389 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13966 r0 *1 888.72,660.24
X$13966 2389 2398 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13968 m0 *1 894.32,660.24
X$13968 2985 2984 2390 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13970 m0 *1 896.56,660.24
X$13970 2390 2397 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13972 r0 *1 867.44,660.24
X$13972 2404 2391 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13977 r0 *1 913.36,660.24
X$13977 2410 2392 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13980 r0 *1 926.8,660.24
X$13980 2985 2984 2393 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13982 r0 *1 929.04,660.24
X$13982 2393 2426 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $13984 m0 *1 931.84,660.24
X$13984 2985 2984 2394 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $13987 r0 *1 901.04,660.24
X$13987 2408 2395 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14002 m0 *1 322.56,942.48
X$14002 2943 2984 2985 2400 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $14007 m0 *1 911.68,660.24
X$14007 2985 2984 2401 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14012 r0 *1 861.28,670.32
X$14012 2402 2425 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14014 r0 *1 859.04,670.32
X$14014 2985 2984 2402 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14016 m0 *1 862.96,680.4
X$14016 2403 2416 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14018 m0 *1 860.16,680.4
X$14018 2985 2984 2403 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14020 m0 *1 869.68,670.32
X$14020 2985 2984 2404 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14023 r0 *1 874.16,670.32
X$14023 2405 2424 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14025 r0 *1 871.92,670.32
X$14025 2985 2984 2405 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14027 r0 *1 883.68,670.32
X$14027 2985 2984 2406 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14029 r0 *1 885.92,670.32
X$14029 2406 2415 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14031 m0 *1 897.68,680.4
X$14031 2407 2449 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14033 m0 *1 895.44,680.4
X$14033 2985 2984 2407 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14035 m0 *1 897.68,670.32
X$14035 2985 2984 2408 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14038 m0 *1 903.28,670.32
X$14038 2409 2412 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14040 m0 *1 901.04,670.32
X$14040 2985 2984 2409 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14042 m0 *1 912.8,670.32
X$14042 2985 2984 2410 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14045 m0 *1 918.4,670.32
X$14045 2985 2984 2411 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14047 m0 *1 920.64,670.32
X$14047 2411 2420 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14051 m0 *1 924.56,680.4
X$14051 2985 2984 2413 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14053 m0 *1 926.8,680.4
X$14053 2413 2419 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14055 r0 *1 928.48,670.32
X$14055 2414 2421 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14057 r0 *1 926.24,670.32
X$14057 2985 2984 2414 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14063 m0 *1 928.48,690.48
X$14063 2442 2417 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14066 r0 *1 933.52,680.4
X$14066 2443 2418 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14075 m0 *1 934.08,670.32
X$14075 2427 2422 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14078 m0 *1 860.16,670.32
X$14078 2428 2423 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14089 m0 *1 930.16,670.32
X$14089 2985 2984 2427 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14093 r0 *1 855.12,670.32
X$14093 2985 2984 2428 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14097 m0 *1 440.16,932.4
X$14097 2921 2984 2985 2429 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $14101 m0 *1 558.32,942.48
X$14101 2964 2984 2985 2430 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $14103 r0 *1 851.76,680.4
X$14103 2985 2984 2431 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14105 r0 *1 854,680.4
X$14105 2431 2432 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14109 r0 *1 864.64,680.4
X$14109 2433 2446 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14111 m0 *1 865.2,690.48
X$14111 2985 2984 2433 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14113 m0 *1 867.44,690.48
X$14113 2434 2447 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14115 r0 *1 865.2,690.48
X$14115 2985 2984 2434 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14117 r0 *1 881.44,680.4
X$14117 2985 2984 2435 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14119 r0 *1 883.68,680.4
X$14119 2435 2448 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14121 m0 *1 884.24,690.48
X$14121 2985 2984 2436 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14123 m0 *1 886.48,690.48
X$14123 2436 2445 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14125 m0 *1 898.24,690.48
X$14125 2437 2466 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14127 m0 *1 896,690.48
X$14127 2985 2984 2437 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14129 m0 *1 908.32,690.48
X$14129 2985 2984 2438 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14131 m0 *1 910.56,690.48
X$14131 2438 2440 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14133 r0 *1 914.48,680.4
X$14133 2439 2444 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14135 r0 *1 912.24,680.4
X$14135 2985 2984 2439 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14139 m0 *1 907.2,680.4
X$14139 2450 2441 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14143 m0 *1 926.24,690.48
X$14143 2985 2984 2442 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14145 r0 *1 931.28,680.4
X$14145 2985 2984 2443 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14161 r0 *1 906.64,680.4
X$14161 2985 2984 2450 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14163 r0 *1 875.84,690.48
X$14163 2451 2464 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14165 r0 *1 873.6,690.48
X$14165 2985 2984 2451 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14167 m0 *1 902.72,700.56
X$14167 2452 2453 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14169 m0 *1 900.48,700.56
X$14169 2985 2984 2452 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14173 r0 *1 911.68,690.48
X$14173 2454 2458 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14175 r0 *1 908.88,690.48
X$14175 2985 2984 2454 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14177 m0 *1 918.96,700.56
X$14177 2455 2467 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14179 m0 *1 916.72,700.56
X$14179 2985 2984 2455 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14181 r0 *1 877.52,700.56
X$14181 2474 2456 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14184 r0 *1 866.32,700.56
X$14184 2473 2457 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14189 r0 *1 926.8,690.48
X$14189 2985 2984 2459 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14191 r0 *1 929.04,690.48
X$14191 2459 2461 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14193 m0 *1 931.84,700.56
X$14193 2985 2984 2460 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14195 m0 *1 934.08,700.56
X$14195 2460 2463 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14199 m0 *1 890.96,700.56
X$14199 2493 2462 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14206 r0 *1 927.36,700.56
X$14206 2481 2465 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14213 r0 *1 852.32,700.56
X$14213 2985 2984 2468 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14215 r0 *1 854.56,700.56
X$14215 2468 2472 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14217 m0 *1 857.92,710.64
X$14217 2985 2984 2469 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14219 m0 *1 860.16,710.64
X$14219 2469 2485 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14221 r0 *1 865.2,710.64
X$14221 2470 2505 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14223 r0 *1 862.96,710.64
X$14223 2985 2984 2470 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14225 m0 *1 848.4,710.64
X$14225 2495 2471 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14230 r0 *1 864.08,700.56
X$14230 2985 2984 2473 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14233 m0 *1 877.52,710.64
X$14233 2985 2984 2474 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14236 r0 *1 886.48,710.64
X$14236 2985 2984 2475 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14238 r0 *1 888.72,710.64
X$14238 2475 2511 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14240 r0 *1 901.04,710.64
X$14240 2985 2984 2476 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14242 r0 *1 903.28,710.64
X$14242 2476 2507 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14244 m0 *1 903.84,710.64
X$14244 2985 2984 2477 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14246 m0 *1 906.08,710.64
X$14246 2477 2489 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14248 r0 *1 912.24,700.56
X$14248 2478 2487 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14250 r0 *1 910,700.56
X$14250 2985 2984 2478 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14252 r0 *1 915.6,710.64
X$14252 2985 2984 2479 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14254 r0 *1 917.84,710.64
X$14254 2479 2491 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14256 m0 *1 925.12,720.72
X$14256 2985 2984 2480 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14258 m0 *1 924.56,710.64
X$14258 2480 2486 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14260 r0 *1 925.12,700.56
X$14260 2985 2984 2481 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14263 r0 *1 927.36,710.64
X$14263 2482 2488 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14265 m0 *1 927.36,720.72
X$14265 2985 2984 2482 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14267 r0 *1 936.88,710.64
X$14267 2985 2984 2483 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14269 m0 *1 934.08,710.64
X$14269 2483 2484 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14283 m0 *1 934.08,720.72
X$14283 2504 2490 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14288 r0 *1 900.48,700.56
X$14288 2494 2492 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14291 r0 *1 890.4,700.56
X$14291 2985 2984 2493 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14296 r0 *1 894.88,700.56
X$14296 2985 2984 2494 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14299 m0 *1 844.48,710.64
X$14299 2985 2984 2495 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14304 r0 *1 842.8,720.72
X$14304 2985 2984 2496 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14306 r0 *1 845.04,720.72
X$14306 2496 2498 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14308 r0 *1 859.6,720.72
X$14308 2985 2984 2497 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14310 r0 *1 861.84,720.72
X$14310 2497 2530 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14314 m0 *1 869.68,720.72
X$14314 2985 2984 2499 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14316 m0 *1 871.92,720.72
X$14316 2499 2502 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14318 r0 *1 871.36,720.72
X$14318 2985 2984 2500 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14320 r0 *1 873.6,720.72
X$14320 2500 2506 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14322 m0 *1 909.44,720.72
X$14322 2501 2508 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14324 m0 *1 907.2,720.72
X$14324 2985 2984 2501 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14328 r0 *1 927.36,720.72
X$14328 2985 2984 2503 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14330 r0 *1 929.6,720.72
X$14330 2503 2509 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14333 m0 *1 931.84,720.72
X$14333 2985 2984 2504 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14345 m0 *1 890.96,720.72
X$14345 2513 2510 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14350 r0 *1 883.12,720.72
X$14350 2518 2512 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14353 m0 *1 887.6,720.72
X$14353 2985 2984 2513 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14358 r0 *1 846.16,730.8
X$14358 2985 2984 2514 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14360 r0 *1 848.4,730.8
X$14360 2514 2528 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14362 r0 *1 857.92,730.8
X$14362 2985 2984 2515 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14364 m0 *1 856.24,730.8
X$14364 2515 2535 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14366 m0 *1 865.76,730.8
X$14366 2516 2529 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14368 r0 *1 866.88,730.8
X$14368 2985 2984 2516 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14370 r0 *1 872.48,730.8
X$14370 2985 2984 2517 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14372 r0 *1 874.72,730.8
X$14372 2517 2539 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14374 m0 *1 882.56,730.8
X$14374 2985 2984 2518 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14377 r0 *1 886.48,730.8
X$14377 2985 2984 2519 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14379 r0 *1 888.72,730.8
X$14379 2519 2537 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14381 m0 *1 894.88,730.8
X$14381 2520 2538 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14383 m0 *1 892.64,730.8
X$14383 2985 2984 2520 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14385 m0 *1 910.56,730.8
X$14385 2521 2532 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14387 m0 *1 908.32,730.8
X$14387 2985 2984 2521 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14389 r0 *1 908.32,730.8
X$14389 2985 2984 2522 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14391 r0 *1 910.56,730.8
X$14391 2522 2524 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14393 m0 *1 917.84,740.88
X$14393 2523 2533 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14395 m0 *1 915.6,740.88
X$14395 2985 2984 2523 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14399 r0 *1 925.68,730.8
X$14399 2985 2984 2525 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14401 m0 *1 925.68,730.8
X$14401 2525 2536 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14403 r0 *1 929.6,740.88
X$14403 2985 2984 2526 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14405 r0 *1 930.72,730.8
X$14405 2526 2555 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14407 m0 *1 934.08,740.88
X$14407 2527 2534 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14409 m0 *1 931.84,740.88
X$14409 2985 2984 2527 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14417 r0 *1 934.08,740.88
X$14417 2553 2531 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14438 r0 *1 857.36,740.88
X$14438 2985 2984 2540 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14440 r0 *1 859.6,740.88
X$14440 2540 2546 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14442 m0 *1 854.56,750.96
X$14442 2558 2541 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14447 m0 *1 868.56,750.96
X$14447 2985 2984 2542 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14449 m0 *1 870.8,750.96
X$14449 2542 2547 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14451 r0 *1 874.16,740.88
X$14451 2543 2557 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14453 r0 *1 871.92,740.88
X$14453 2985 2984 2543 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14455 r0 *1 888.72,740.88
X$14455 2544 2554 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14457 r0 *1 886.48,740.88
X$14457 2985 2984 2544 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14459 m0 *1 888.72,750.96
X$14459 2985 2984 2545 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14461 m0 *1 891.52,750.96
X$14461 2545 2576 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14471 m0 *1 910.56,750.96
X$14471 2548 2551 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14473 m0 *1 908.32,750.96
X$14473 2985 2984 2548 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14475 r0 *1 915.6,740.88
X$14475 2985 2984 2549 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14477 r0 *1 917.84,740.88
X$14477 2549 2556 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14479 m0 *1 925.12,750.96
X$14479 2550 2552 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14481 m0 *1 922.88,750.96
X$14481 2985 2984 2550 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14488 r0 *1 931.84,740.88
X$14488 2985 2984 2553 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14498 m0 *1 842.8,750.96
X$14498 2985 2984 2558 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14503 r0 *1 846.72,750.96
X$14503 2559 2560 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14505 r0 *1 844.48,750.96
X$14505 2985 2984 2559 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14511 r0 *1 866.32,750.96
X$14511 2561 2569 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14513 r0 *1 864.08,750.96
X$14513 2985 2984 2561 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14515 m0 *1 875.84,761.04
X$14515 2562 2574 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14517 m0 *1 872.48,761.04
X$14517 2985 2984 2562 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14519 r0 *1 882.56,750.96
X$14519 2563 2577 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14521 r0 *1 880.32,750.96
X$14521 2985 2984 2563 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14523 m0 *1 889.28,761.04
X$14523 2985 2984 2564 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14525 m0 *1 891.52,761.04
X$14525 2564 2584 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14527 m0 *1 853.44,761.04
X$14527 2596 2565 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14530 r0 *1 899.92,761.04
X$14530 2985 2984 2566 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14532 m0 *1 901.04,761.04
X$14532 2566 2575 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14534 r0 *1 908.88,750.96
X$14534 2567 2572 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14536 r0 *1 906.64,750.96
X$14536 2985 2984 2567 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14538 m0 *1 918.4,761.04
X$14538 2985 2984 2568 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14540 r0 *1 918.96,750.96
X$14540 2568 2578 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14544 m0 *1 923.44,761.04
X$14544 2985 2984 2570 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14546 m0 *1 925.68,761.04
X$14546 2570 2573 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14548 r0 *1 929.04,750.96
X$14548 2571 2594 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14550 m0 *1 926.8,771.12
X$14550 2985 2984 2571 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14568 r0 *1 864.64,761.04
X$14568 2579 2591 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14570 r0 *1 862.4,761.04
X$14570 2985 2984 2579 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14572 m0 *1 867.44,771.12
X$14572 2580 2581 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14574 m0 *1 865.2,771.12
X$14574 2985 2984 2580 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14578 m0 *1 893.2,771.12
X$14578 2582 2586 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14580 m0 *1 890.96,771.12
X$14580 2985 2984 2582 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14582 m0 *1 907.76,771.12
X$14582 2583 2609 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14584 m0 *1 905.52,771.12
X$14584 2985 2984 2583 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14588 r0 *1 922.32,761.04
X$14588 2585 2592 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14590 m0 *1 921.76,771.12
X$14590 2985 2984 2585 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14594 m0 *1 934.08,771.12
X$14594 2587 2590 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14596 m0 *1 931.28,771.12
X$14596 2985 2984 2587 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14598 r0 *1 934.08,761.04
X$14598 2588 2589 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14600 r0 *1 931.84,761.04
X$14600 2985 2984 2588 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14610 r0 *1 934.08,771.12
X$14610 2608 2593 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14615 m0 *1 934.08,781.2
X$14615 2607 2595 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14618 r0 *1 846.16,761.04
X$14618 2985 2984 2596 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14623 m0 *1 850.64,781.2
X$14623 2597 2600 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14625 m0 *1 848.4,781.2
X$14625 2985 2984 2597 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14627 r0 *1 859.6,781.2
X$14627 2985 2984 2598 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14629 r0 *1 861.84,781.2
X$14629 2598 2630 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14631 m0 *1 864.64,781.2
X$14631 2599 2605 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14633 m0 *1 862.4,781.2
X$14633 2985 2984 2599 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14637 r0 *1 874.72,781.2
X$14637 2985 2984 2601 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14639 m0 *1 881.44,781.2
X$14639 2601 2615 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14643 r0 *1 888.16,771.12
X$14643 2602 2611 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14645 r0 *1 885.92,771.12
X$14645 2985 2984 2602 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14647 r0 *1 904.4,781.2
X$14647 2985 2984 2603 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14649 r0 *1 906.64,781.2
X$14649 2603 2628 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14651 m0 *1 918.4,781.2
X$14651 2604 2610 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14653 m0 *1 916.16,781.2
X$14653 2985 2984 2604 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14657 m0 *1 890.96,781.2
X$14657 2618 2606 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14662 m0 *1 929.04,771.12
X$14662 2985 2984 2607 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14666 r0 *1 931.84,771.12
X$14666 2985 2984 2608 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14674 r0 *1 919.52,771.12
X$14674 2616 2612 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14677 r0 *1 878.08,781.2
X$14677 2620 2613 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14680 m0 *1 906.64,781.2
X$14680 2617 2614 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14689 r0 *1 910,771.12
X$14689 2985 2984 2616 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14694 m0 *1 902.72,781.2
X$14694 2985 2984 2617 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14698 r0 *1 890.4,781.2
X$14698 2985 2984 2618 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14700 r0 *1 865.76,791.28
X$14700 2619 2650 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14702 r0 *1 863.52,791.28
X$14702 2985 2984 2619 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14705 m0 *1 878.64,791.28
X$14705 2985 2984 2620 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14707 r0 *1 888.72,791.28
X$14707 2621 2648 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14709 r0 *1 885.36,791.28
X$14709 2985 2984 2621 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14711 m0 *1 920.64,791.28
X$14711 2622 2633 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14713 m0 *1 918.4,791.28
X$14713 2985 2984 2622 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14715 r0 *1 924,791.28
X$14715 2985 2984 2623 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14717 r0 *1 926.24,791.28
X$14717 2623 2629 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14719 m0 *1 931.84,791.28
X$14719 2985 2984 2624 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14721 r0 *1 934.08,781.2
X$14721 2624 2626 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14723 m0 *1 934.08,791.28
X$14723 2625 2632 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14725 r0 *1 935.76,791.28
X$14725 2985 2984 2625 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14729 m0 *1 898.8,791.28
X$14729 2637 2627 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14738 r0 *1 930.72,801.36
X$14738 2647 2631 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14745 m0 *1 925.12,801.36
X$14745 2646 2634 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14748 m0 *1 908.88,791.28
X$14748 2636 2635 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14752 r0 *1 905.52,791.28
X$14752 2985 2984 2636 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14757 m0 *1 895.44,791.28
X$14757 2985 2984 2637 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14761 r0 *1 851.2,801.36
X$14761 2638 2640 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14763 r0 *1 848.96,801.36
X$14763 2985 2984 2638 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14765 m0 *1 863.52,801.36
X$14765 2985 2984 2639 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14767 m0 *1 866.32,801.36
X$14767 2639 2651 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14771 m0 *1 878.08,801.36
X$14771 2985 2984 2641 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14773 m0 *1 880.32,801.36
X$14773 2641 2645 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14775 r0 *1 883.68,801.36
X$14775 2642 2655 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14777 r0 *1 880.88,801.36
X$14777 2985 2984 2642 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14779 m0 *1 889.84,801.36
X$14779 2643 2654 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14781 r0 *1 893.2,801.36
X$14781 2985 2984 2643 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14783 m0 *1 906.64,801.36
X$14783 2985 2984 2644 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14785 m0 *1 908.88,801.36
X$14785 2644 2653 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14789 m0 *1 922.88,801.36
X$14789 2985 2984 2646 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14793 r0 *1 928.48,801.36
X$14793 2985 2984 2647 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14797 m0 *1 885.92,811.44
X$14797 2659 2649 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14804 m0 *1 934.08,811.44
X$14804 2669 2652 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14815 m0 *1 862.4,811.44
X$14815 2656 2666 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14817 m0 *1 860.16,811.44
X$14817 2985 2984 2656 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14819 r0 *1 865.76,811.44
X$14819 2657 2675 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14821 r0 *1 863.52,811.44
X$14821 2985 2984 2657 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14823 m0 *1 878.08,821.52
X$14823 2985 2984 2658 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14825 m0 *1 880.32,821.52
X$14825 2658 2679 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14827 m0 *1 883.12,811.44
X$14827 2985 2984 2659 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14830 r0 *1 887.04,811.44
X$14830 2660 2671 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14832 r0 *1 884.8,811.44
X$14832 2985 2984 2660 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14834 m0 *1 899.92,811.44
X$14834 2661 2680 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14836 m0 *1 897.68,811.44
X$14836 2985 2984 2661 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14838 m0 *1 902.16,821.52
X$14838 2985 2984 2662 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14840 m0 *1 904.4,821.52
X$14840 2662 2670 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14842 m0 *1 913.92,811.44
X$14842 2985 2984 2663 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14844 m0 *1 916.16,811.44
X$14844 2663 2672 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14846 r0 *1 913.92,821.52
X$14846 2985 2984 2664 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14848 m0 *1 916.72,821.52
X$14848 2664 2694 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14850 r0 *1 920.64,811.44
X$14850 2665 2677 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14852 r0 *1 917.84,811.44
X$14852 2985 2984 2665 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14856 m0 *1 926.24,821.52
X$14856 2985 2984 2667 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14858 m0 *1 928.48,821.52
X$14858 2667 2678 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14860 r0 *1 934.08,811.44
X$14860 2668 2673 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14862 r0 *1 931.84,811.44
X$14862 2985 2984 2668 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14865 m0 *1 931.84,811.44
X$14865 2985 2984 2669 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14875 r0 *1 916.16,821.52
X$14875 2699 2674 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14880 r0 *1 906.64,811.44
X$14880 2681 2676 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14891 r0 *1 903.28,811.44
X$14891 2985 2984 2681 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14896 m0 *1 865.2,831.6
X$14896 2985 2984 2682 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14898 m0 *1 867.44,831.6
X$14898 2682 2693 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14900 r0 *1 883.68,821.52
X$14900 2683 2695 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14902 r0 *1 881.44,821.52
X$14902 2985 2984 2683 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14904 m0 *1 884.24,831.6
X$14904 2684 2692 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14906 m0 *1 882,831.6
X$14906 2985 2984 2684 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14908 m0 *1 903.28,831.6
X$14908 2685 2691 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14910 m0 *1 901.04,831.6
X$14910 2985 2984 2685 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14912 r0 *1 871.92,821.52
X$14912 2700 2686 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14915 m0 *1 917.84,831.6
X$14915 2985 2984 2687 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14917 m0 *1 920.08,831.6
X$14917 2687 2696 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14919 m0 *1 866.88,821.52
X$14919 2701 2688 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14922 r0 *1 929.6,821.52
X$14922 2689 2697 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14924 r0 *1 927.36,821.52
X$14924 2985 2984 2689 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14926 m0 *1 934.08,831.6
X$14926 2690 2698 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14928 m0 *1 931.84,831.6
X$14928 2985 2984 2690 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14950 r0 *1 910.56,821.52
X$14950 2985 2984 2699 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14955 r0 *1 860.16,821.52
X$14955 2985 2984 2700 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14962 m0 *1 856.8,821.52
X$14962 2985 2984 2701 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14965 r0 *1 854.56,831.6
X$14965 2702 2704 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14967 r0 *1 852.32,831.6
X$14967 2985 2984 2702 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14969 m0 *1 859.04,841.68
X$14969 2985 2984 2703 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14971 m0 *1 861.28,841.68
X$14971 2703 2724 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14975 r0 *1 870.8,841.68
X$14975 2985 2984 2705 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14977 m0 *1 870.8,841.68
X$14977 2705 2706 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14981 r0 *1 885.36,841.68
X$14981 2985 2984 2707 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14983 r0 *1 887.6,841.68
X$14983 2707 2735 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14985 r0 *1 888.72,831.6
X$14985 2708 2719 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14987 r0 *1 886.48,831.6
X$14987 2985 2984 2708 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14989 m0 *1 890.96,841.68
X$14989 2709 2712 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14991 m0 *1 888.16,841.68
X$14991 2985 2984 2709 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14993 m0 *1 905.52,841.68
X$14993 2710 2716 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $14995 m0 *1 903.28,841.68
X$14995 2985 2984 2710 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14997 r0 *1 915.6,841.68
X$14997 2985 2984 2711 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $14999 m0 *1 916.72,841.68
X$14999 2711 2723 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15003 r0 *1 925.68,841.68
X$15003 2985 2984 2713 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15005 r0 *1 927.92,841.68
X$15005 2713 2717 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15007 m0 *1 929.6,841.68
X$15007 2714 2721 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15009 m0 *1 927.36,841.68
X$15009 2985 2984 2714 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15011 r0 *1 934.08,831.6
X$15011 2715 2722 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15013 r0 *1 931.84,831.6
X$15013 2985 2984 2715 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15019 m0 *1 934.08,851.76
X$15019 2732 2718 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15024 r0 *1 874.16,831.6
X$15024 2725 2720 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15035 r0 *1 870.8,831.6
X$15035 2985 2984 2725 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15040 m0 *1 868,851.76
X$15040 2726 2738 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15042 m0 *1 865.76,851.76
X$15042 2985 2984 2726 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15044 r0 *1 875.84,851.76
X$15044 2727 2743 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15046 r0 *1 873.6,851.76
X$15046 2985 2984 2727 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15048 m0 *1 885.92,851.76
X$15048 2985 2984 2728 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15050 m0 *1 888.16,851.76
X$15050 2728 2734 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15052 m0 *1 907.2,851.76
X$15052 2729 2739 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15054 m0 *1 904.4,851.76
X$15054 2985 2984 2729 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15056 m0 *1 918.96,851.76
X$15056 2985 2984 2730 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15058 m0 *1 921.2,851.76
X$15058 2730 2737 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15060 r0 *1 927.36,851.76
X$15060 2985 2984 2731 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15062 r0 *1 929.6,851.76
X$15062 2731 2736 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15065 m0 *1 931.84,851.76
X$15065 2985 2984 2732 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15067 r0 *1 911.12,851.76
X$15067 2752 2733 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15082 r0 *1 885.36,851.76
X$15082 2748 2740 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15085 m0 *1 869.12,861.84
X$15085 2745 2741 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15090 r0 *1 913.92,861.84
X$15090 2754 2742 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15096 m0 *1 553.84,942.48
X$15096 2963 2984 2985 2744 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $15099 m0 *1 866.88,861.84
X$15099 2985 2984 2745 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15101 r0 *1 869.68,861.84
X$15101 2746 2755 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15103 m0 *1 868,871.92
X$15103 2985 2984 2746 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15105 r0 *1 879.2,861.84
X$15105 2747 2749 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15107 m0 *1 877.52,871.92
X$15107 2985 2984 2747 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15109 m0 *1 884.8,861.84
X$15109 2985 2984 2748 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15114 m0 *1 889.28,871.92
X$15114 2985 2984 2750 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15116 r0 *1 888.72,861.84
X$15116 2750 2764 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15118 m0 *1 896.56,861.84
X$15118 2985 2984 2751 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15120 m0 *1 898.8,861.84
X$15120 2751 2758 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15122 m0 *1 910.56,861.84
X$15122 2985 2984 2752 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15125 m0 *1 912.8,861.84
X$15125 2753 2760 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15127 r0 *1 911.68,861.84
X$15127 2985 2984 2753 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15130 r0 *1 913.36,871.92
X$15130 2985 2984 2754 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15136 m0 *1 929.6,861.84
X$15136 2756 2763 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15138 m0 *1 927.36,861.84
X$15138 2985 2984 2756 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15140 r0 *1 927.36,861.84
X$15140 2985 2984 2757 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15142 r0 *1 929.6,861.84
X$15142 2757 2759 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15150 r0 *1 934.08,871.92
X$15150 2786 2761 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15153 m0 *1 934.08,882
X$15153 2773 2762 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15160 m0 *1 927.92,871.92
X$15160 2772 2765 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15163 r0 *1 877.52,871.92
X$15163 2766 2785 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15165 r0 *1 875.28,871.92
X$15165 2985 2984 2766 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15167 m0 *1 879.76,871.92
X$15167 2767 2780 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15169 m0 *1 875.28,871.92
X$15169 2985 2984 2767 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15171 m0 *1 892.64,871.92
X$15171 2768 2778 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15173 r0 *1 890.96,871.92
X$15173 2985 2984 2768 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15175 m0 *1 901.04,882
X$15175 2769 2774 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15177 m0 *1 898.8,882
X$15177 2985 2984 2769 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15179 m0 *1 912.24,882
X$15179 2985 2984 2770 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15181 m0 *1 914.48,882
X$15181 2770 2779 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15183 r0 *1 915.6,871.92
X$15183 2985 2984 2771 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15185 r0 *1 918.4,871.92
X$15185 2771 2775 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15188 m0 *1 925.68,871.92
X$15188 2985 2984 2772 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15190 m0 *1 931.84,882
X$15190 2985 2984 2773 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15197 m0 *1 909.44,871.92
X$15197 2787 2776 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15200 m0 *1 934.08,892.08
X$15200 2797 2777 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15209 m0 *1 933.52,902.16
X$15209 2827 2781 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15212 r0 *1 922.32,882
X$15212 2795 2782 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15215 r0 *1 926.8,892.08
X$15215 2824 2783 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15218 r0 *1 934.08,882
X$15218 2798 2784 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15223 r0 *1 930.16,871.92
X$15223 2985 2984 2786 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15229 r0 *1 908.88,871.92
X$15229 2985 2984 2787 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15231 m0 *1 655.76,892.08
X$15231 2985 2984 2788 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15233 m0 *1 660.24,892.08
X$15233 2788 2895 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15235 m0 *1 658,892.08
X$15235 2985 2984 2789 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15237 r0 *1 660.8,882
X$15237 2789 2939 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15239 r0 *1 673.12,882
X$15239 2985 2984 2790 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15241 r0 *1 675.36,882
X$15241 2790 2937 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15243 r0 *1 684.88,882
X$15243 2791 2808 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15245 m0 *1 685.44,882
X$15245 2985 2984 2791 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15247 m0 *1 694.4,892.08
X$15247 2792 2833 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15249 m0 *1 692.16,892.08
X$15249 2985 2984 2792 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15251 m0 *1 913.92,892.08
X$15251 2793 2804 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15253 r0 *1 911.12,892.08
X$15253 2985 2984 2793 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15255 m0 *1 911.68,902.16
X$15255 2831 2794 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15258 r0 *1 919.52,882
X$15258 2985 2984 2795 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15261 r0 *1 913.36,892.08
X$15261 2821 2796 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15267 m0 *1 931.84,892.08
X$15267 2985 2984 2797 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15270 r0 *1 931.84,882
X$15270 2985 2984 2798 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15272 r0 *1 915.6,902.16
X$15272 2822 2799 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15275 m0 *1 934.08,932.4
X$15275 2885 2800 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15278 m0 *1 903.84,892.08
X$15278 2832 2801 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15281 r0 *1 934.08,932.4
X$15281 2914 2802 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15284 r0 *1 918.96,922.32
X$15284 2884 2803 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15289 m0 *1 924,902.16
X$15289 2823 2805 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15292 m0 *1 932.4,922.32
X$15292 2854 2806 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15295 r0 *1 934.08,922.32
X$15295 2855 2807 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15301 m0 *1 669.76,892.08
X$15301 2985 2984 2809 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15304 m0 *1 673.12,892.08
X$15304 2809 2940 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15307 r0 *1 640.64,902.16
X$15307 2985 2984 2810 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15309 r0 *1 642.88,902.16
X$15309 2810 2867 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15311 m0 *1 642.32,902.16
X$15311 2985 2984 2811 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15313 m0 *1 644.56,902.16
X$15313 2811 2812 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15318 r0 *1 652.4,902.16
X$15318 2813 2815 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15320 m0 *1 652.4,912.24
X$15320 2985 2984 2813 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15322 r0 *1 652.4,892.08
X$15322 2985 2984 2814 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15324 r0 *1 654.64,892.08
X$15324 2814 2866 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15329 m0 *1 662.48,902.16
X$15329 2985 2984 2816 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15331 m0 *1 664.72,902.16
X$15331 2816 2876 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15333 r0 *1 673.12,892.08
X$15333 2817 2864 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15335 r0 *1 670.88,892.08
X$15335 2985 2984 2817 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15337 m0 *1 676.48,902.16
X$15337 2818 2862 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15339 m0 *1 674.24,902.16
X$15339 2985 2984 2818 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15341 m0 *1 679.28,912.24
X$15341 2985 2984 2819 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15343 r0 *1 679.84,902.16
X$15343 2819 2861 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15345 r0 *1 687.68,892.08
X$15345 2820 2834 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15347 r0 *1 685.44,892.08
X$15347 2985 2984 2820 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15350 m0 *1 909.44,902.16
X$15350 2985 2984 2821 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15352 r0 *1 913.36,902.16
X$15352 2985 2984 2822 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15356 m0 *1 921.76,902.16
X$15356 2985 2984 2823 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15359 r0 *1 922.88,892.08
X$15359 2985 2984 2824 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15361 m0 *1 925.68,912.24
X$15361 2985 2984 2825 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15363 r0 *1 926.24,902.16
X$15363 2825 2826 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15368 r0 *1 936.32,892.08
X$15368 2985 2984 2827 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15370 r0 *1 934.08,912.24
X$15370 2857 2828 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15373 m0 *1 929.6,942.48
X$15373 2980 2829 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15376 m0 *1 934.08,912.24
X$15376 2856 2830 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15380 r0 *1 911.12,902.16
X$15380 2985 2984 2831 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15383 r0 *1 903.28,892.08
X$15383 2985 2984 2832 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15393 r0 *1 689.36,902.16
X$15393 2835 2859 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15395 m0 *1 688.8,902.16
X$15395 2985 2984 2835 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15397 r0 *1 636.72,912.24
X$15397 2836 2965 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15399 r0 *1 632.8,912.24
X$15399 2985 2984 2836 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15401 r0 *1 640.08,922.32
X$15401 2837 2899 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15403 m0 *1 640.08,922.32
X$15403 2985 2984 2837 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15405 r0 *1 647.36,912.24
X$15405 2838 2839 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15407 m0 *1 647.36,922.32
X$15407 2985 2984 2838 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15412 m0 *1 656.88,912.24
X$15412 2840 2843 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15414 m0 *1 654.64,912.24
X$15414 2985 2984 2840 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15416 r0 *1 656.88,912.24
X$15416 2985 2984 2841 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15418 r0 *1 659.12,912.24
X$15418 2841 2896 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15420 m0 *1 662.48,922.32
X$15420 2985 2984 2842 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15422 m0 *1 664.72,922.32
X$15422 2842 2865 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15427 m0 *1 674.24,922.32
X$15427 2844 2863 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15429 r0 *1 672,932.4
X$15429 2985 2984 2844 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15431 r0 *1 677.6,912.24
X$15431 2845 2936 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15433 r0 *1 675.36,912.24
X$15433 2985 2984 2845 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15435 m0 *1 685.44,922.32
X$15435 2846 2972 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15437 r0 *1 686,922.32
X$15437 2985 2984 2846 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15439 r0 *1 689.36,912.24
X$15439 2847 2848 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15441 r0 *1 687.12,912.24
X$15441 2985 2984 2847 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15446 m0 *1 694.96,922.32
X$15446 2985 2984 2849 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15448 m0 *1 697.2,922.32
X$15448 2849 2851 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15450 m0 *1 690.48,912.24
X$15450 2860 2850 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15457 m0 *1 703.92,912.24
X$15457 2985 2984 2852 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15459 r0 *1 701.12,912.24
X$15459 2852 2858 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15461 r0 *1 706.16,922.32
X$15461 2853 2878 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15463 r0 *1 703.92,922.32
X$15463 2985 2984 2853 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15465 m0 *1 930.16,922.32
X$15465 2985 2984 2854 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15469 r0 *1 931.84,922.32
X$15469 2985 2984 2855 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15471 m0 *1 931.84,912.24
X$15471 2985 2984 2856 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15475 r0 *1 931.84,912.24
X$15475 2985 2984 2857 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15487 m0 *1 700,912.24
X$15487 2985 2984 2860 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15513 m0 *1 618.24,932.4
X$15513 2868 2966 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15515 m0 *1 616,932.4
X$15515 2985 2984 2868 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15517 m0 *1 630,932.4
X$15517 2985 2984 2869 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15519 r0 *1 629.44,922.32
X$15519 2869 2870 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15526 m0 *1 636.16,932.4
X$15526 2985 2984 2871 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15528 m0 *1 638.4,932.4
X$15528 2871 2900 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15530 m0 *1 647.92,932.4
X$15530 2985 2984 2872 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15532 r0 *1 649.6,922.32
X$15532 2872 2898 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15534 m0 *1 655.2,932.4
X$15534 2873 2897 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15536 m0 *1 652.96,932.4
X$15536 2985 2984 2873 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15538 m0 *1 666.96,932.4
X$15538 2874 2941 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15540 m0 *1 664.72,932.4
X$15540 2985 2984 2874 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15542 r0 *1 670.88,922.32
X$15542 2875 2894 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15544 r0 *1 668.08,932.4
X$15544 2985 2984 2875 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15549 m0 *1 698.88,932.4
X$15549 2877 2974 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15551 r0 *1 700,932.4
X$15551 2985 2984 2877 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15556 r0 *1 715.12,932.4
X$15556 2985 2984 2879 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15558 m0 *1 713.44,932.4
X$15558 2879 2926 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15560 m0 *1 732.48,932.4
X$15560 2891 2880 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15564 m0 *1 754.32,932.4
X$15564 2881 2890 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15566 m0 *1 752.08,932.4
X$15566 2985 2984 2881 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15568 m0 *1 821.52,932.4
X$15568 2985 2984 2882 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15570 m0 *1 823.76,932.4
X$15570 2882 2887 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15572 m0 *1 835.52,932.4
X$15572 2985 2984 2883 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15574 m0 *1 838.32,932.4
X$15574 2883 2886 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15576 m0 *1 919.52,932.4
X$15576 2985 2984 2884 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15579 m0 *1 931.84,932.4
X$15579 2985 2984 2885 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15588 m0 *1 800.24,932.4
X$15588 2889 2888 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15592 m0 *1 796.32,932.4
X$15592 2985 2984 2889 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15600 m0 *1 728.56,932.4
X$15600 2985 2984 2891 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15605 m0 *1 689.36,932.4
X$15605 2893 2892 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15609 m0 *1 686,932.4
X$15609 2985 2984 2893 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15637 m0 *1 618.24,942.48
X$15637 2985 2984 2901 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15639 r0 *1 618.8,932.4
X$15639 2901 2929 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15641 m0 *1 627.76,942.48
X$15641 2985 2984 2902 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15643 r0 *1 628.32,932.4
X$15643 2902 2969 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15645 r0 *1 646.8,932.4
X$15645 2903 2930 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15647 r0 *1 644,932.4
X$15647 2985 2984 2903 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15649 r0 *1 656.32,932.4
X$15649 2985 2984 2904 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15651 r0 *1 658.56,932.4
X$15651 2904 2938 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15653 m0 *1 687.68,942.48
X$15653 2985 2984 2905 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15655 r0 *1 688.8,932.4
X$15655 2905 2931 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15657 r0 *1 704.48,932.4
X$15657 2906 2973 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15659 r0 *1 702.24,932.4
X$15659 2985 2984 2906 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15661 r0 *1 720.72,932.4
X$15661 2907 2927 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15663 r0 *1 718.48,932.4
X$15663 2985 2984 2907 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15665 r0 *1 775.6,932.4
X$15665 2908 2977 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15667 r0 *1 773.36,932.4
X$15667 2985 2984 2908 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15669 m0 *1 785.68,942.48
X$15669 2985 2984 2909 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15671 r0 *1 786.24,932.4
X$15671 2909 2978 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15673 r0 *1 805.28,932.4
X$15673 2910 2919 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15675 r0 *1 803.04,932.4
X$15675 2985 2984 2910 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15677 r0 *1 821.52,932.4
X$15677 2911 2916 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15679 r0 *1 818.72,932.4
X$15679 2985 2984 2911 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15681 m0 *1 821.52,942.48
X$15681 2979 2912 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15685 r0 *1 836.08,932.4
X$15685 2985 2984 2913 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $15687 r0 *1 838.32,932.4
X$15687 2913 2915 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $15690 r0 *1 931.84,932.4
X$15690 2985 2984 2914 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $64688 m0 *1 441.84,942.48
X$64688 2957 2984 2985 2922 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $64691 r0 *1 730.24,932.4
X$64691 2925 2923 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $64695 m0 *1 446.32,942.48
X$64695 2959 2984 2985 2924 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $64700 r0 *1 740.32,932.4
X$64700 2985 2984 2925 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $74504 m0 *1 705.04,942.48
X$74504 2982 2928 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $84314 m0 *1 650.16,942.48
X$84314 2967 2932 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $84318 r0 *1 679.28,932.4
X$84318 2934 2933 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $84322 m0 *1 685.44,942.48
X$84322 2985 2984 2934 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $84327 m0 *1 675.92,942.48
X$84327 2970 2935 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $84349 m0 *1 676.48,932.4
X$84349 2942 2971 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $84351 r0 *1 675.92,932.4
X$84351 2985 2984 2942 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $84360 m0 *1 327.04,942.48
X$84360 2945 2984 2985 2981 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $84427 m0 *1 647.92,942.48
X$84427 2985 2984 2967 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $84429 m0 *1 630,942.48
X$84429 2983 2968 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $84437 m0 *1 673.68,942.48
X$84437 2985 2984 2970 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $84452 m0 *1 719.6,942.48
X$84452 2976 2975 2984 2985 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $84455 m0 *1 717.36,942.48
X$84455 2985 2984 2976 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $84465 m0 *1 819.28,942.48
X$84465 2985 2984 2979 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $84468 m0 *1 927.36,942.48
X$84468 2985 2984 2980 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $130674 m0 *1 714.56,942.48
X$130674 2985 2984 2982 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $140579 m0 *1 625.52,942.48
X$140579 2985 2984 2983 gf180mcu_fd_sc_mcu9t5v0__tiel
.ENDS dma_controller

* cell gf180mcu_fd_sc_mcu9t5v0__oai32_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
* pin B2
* pin ZN
* pin B1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai32_2 1 2 3 4 5 7 8 9
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 A1
* net 5 A3
* net 7 B2
* net 8 ZN
* net 9 B1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 15 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 14 3 15 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 13 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 11 3 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 5 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.6588P PS=2.45U PD=2.55U
* device instance $7 r0 *1 7.69,3.78 pmos_5p0
M$7 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 8 9 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.88,3.78 pmos_5p0
M$9 10 9 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 1 7 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 5 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $12 r0 *1 2.04,1.005 nmos_5p0
M$12 6 3 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 3.16,1.005 nmos_5p0
M$13 2 4 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.64,1.005 nmos_5p0
M$17 8 7 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2408P PS=3.68U PD=5.84U
* device instance $18 r0 *1 8.76,1.005 nmos_5p0
M$18 6 9 8 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai32_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_8 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.3 nmos_5p0
M$9 4 3 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.6498P AD=1.6498P PS=11.09U PD=11.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_8

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_4 1 2 3 5 6 7 9
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 3 B
* net 5 ZN
* net 6 A2
* net 7 A1
* net 9 NWELL,VDD
* device instance $1 r0 *1 14.93,3.872 pmos_5p0
M$1 5 3 9 9 pmos_5p0 L=0.5U W=6.58U AS=2.212525P AD=2.212525P PS=10.915U
+ PD=10.915U
* device instance $5 r0 *1 0.97,3.78 pmos_5p0
M$5 9 2 8 9 pmos_5p0 L=0.5U W=5.49U AS=1.89405P AD=1.65615P PS=9.39U PD=7.3U
* device instance $8 r0 *1 4.28,3.78 pmos_5p0
M$8 11 2 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 5.4,3.78 pmos_5p0
M$9 10 6 11 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 6.52,3.78 pmos_5p0
M$10 5 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 7.64,3.78 pmos_5p0
M$11 13 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.61305P PS=2.45U PD=2.5U
* device instance $12 r0 *1 8.81,3.78 pmos_5p0
M$12 8 6 13 9 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $13 r0 *1 9.88,3.78 pmos_5p0
M$13 12 6 8 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $14 r0 *1 11,3.78 pmos_5p0
M$14 5 7 12 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $15 r0 *1 12.12,3.78 pmos_5p0
M$15 14 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $16 r0 *1 13.19,3.78 pmos_5p0
M$16 8 6 14 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 5 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $21 r0 *1 5.4,1.005 nmos_5p0
M$21 5 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.716P PS=7.36U PD=7.88U
* device instance $22 r0 *1 6.52,1.005 nmos_5p0
M$22 4 7 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $29 r0 *1 14.88,1.005 nmos_5p0
M$29 1 3 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.716P AD=1.6104P PS=7.88U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.673P PS=26.59U PD=24.5U
* device instance $11 r0 *1 12.07,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.346P AD=11.5839P PS=49U PD=51.09U
* device instance $31 r0 *1 0.92,1.005 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=13.2U AS=3.6696P AD=3.432P PS=20.08U PD=18.4U
* device instance $41 r0 *1 12.12,1.005 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=6.864P AD=7.1016P PS=36.8U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_20

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_4 1 3 4 5 6 7 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 ZN
* net 4 A2
* net 5 A1
* net 6 B
* net 7 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 13 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 3 5 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 14 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 12 4 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 15 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 3 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 16 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 12 4 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $9 r0 *1 9.91,3.965 pmos_5p0
M$9 3 6 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.7238P AD=1.7812P PS=8.47U PD=9.74U
* device instance $10 r0 *1 10.93,3.965 pmos_5p0
M$10 12 7 3 12 pmos_5p0 L=0.5U W=5.84U AS=1.5184P AD=1.5184P PS=7.92U PD=7.92U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 3 4 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3926P PS=9.04U PD=7.39U
* device instance $18 r0 *1 2.04,1.005 nmos_5p0
M$18 2 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $25 r0 *1 9.91,1.005 nmos_5p0
M$25 10 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $26 r0 *1 10.88,1.005 nmos_5p0
M$26 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 12,1.005 nmos_5p0
M$27 11 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.92,1.005 nmos_5p0
M$28 2 6 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 14.04,1.005 nmos_5p0
M$29 9 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.96,1.005 nmos_5p0
M$30 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 16.08,1.005 nmos_5p0
M$31 8 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 17,1.005 nmos_5p0
M$32 2 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_12 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=21.96U AS=7.0455P AD=7.0455P PS=31.49U PD=31.49U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=8.76U AS=2.409P AD=2.409P PS=16.09U PD=16.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_12

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_16 1 2 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7031P PS=21.69U PD=19.78U
* device instance $9 r0 *1 10.01,3.78 pmos_5p0
M$9 4 3 5 5 pmos_5p0 L=0.5U W=29.28U AS=9.2415P AD=9.3147P PS=39.38U PD=41.29U
* device instance $25 r0 *1 0.92,1.3 nmos_5p0
M$25 3 2 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.7295P AD=1.5184P PS=11.34U PD=10U
* device instance $33 r0 *1 10.06,1.265 nmos_5p0
M$33 4 3 1 1 nmos_5p0 L=0.6U W=12.8U AS=3.3895P AD=3.472P PS=21.3U PD=22.28U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_2
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_2 1 2 3 4 5 6
* net 1 ZN
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A1
* net 6 A3
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 6 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 9 4 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 1 5 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 8 5 1 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 4 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 6 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 3 6 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.553P PS=3.77U PD=3.77U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 1 4 3 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 3 5 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__or3_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 2 6 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 4 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 3 5 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 9 5 3 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 6 2 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8235P PS=2.4U PD=2.73U
* device instance $7 r0 *1 7.87,3.78 pmos_5p0
M$7 7 3 6 6 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.4156P PS=9.98U PD=11.79U
* device instance $11 r0 *1 0.92,0.87 nmos_5p0
M$11 3 2 1 1 nmos_5p0 L=0.6U W=2.1U AS=0.735P AD=0.6945P PS=4.55U PD=3.59U
* device instance $12 r0 *1 2.04,0.87 nmos_5p0
M$12 1 4 3 1 nmos_5p0 L=0.6U W=2.1U AS=0.546P AD=0.546P PS=3.14U PD=3.14U
* device instance $13 r0 *1 3.16,0.87 nmos_5p0
M$13 3 5 1 1 nmos_5p0 L=0.6U W=2.1U AS=0.546P AD=0.546P PS=3.14U PD=3.14U
* device instance $17 r0 *1 7.82,1.005 nmos_5p0
M$17 7 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4511P AD=1.6104P PS=7.54U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.7385P PS=7.02U PD=7.39U
* device instance $3 r0 *1 0.92,1.005 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.9438P AD=0.9438P PS=5.39U PD=5.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_2
* pin NWELL,VDD
* pin B2
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B2
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.4758P PS=4.54U PD=2.35U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 6 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $5 r0 *1 5.45,3.78 pmos_5p0
M$5 11 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 6 7 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 10 7 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 6 5 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $14 r0 *1 6.52,1.005 nmos_5p0
M$14 8 7 6 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 4 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 10 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 5 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 9 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 4 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 11 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 5 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6292P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.872 pmos_5p0
M$9 4 2 7 7 pmos_5p0 L=0.5U W=6.58U AS=2.117925P AD=2.212525P PS=9.295U
+ PD=10.915U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 4 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 3 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $21 r0 *1 9.88,1.005 nmos_5p0
M$21 1 2 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_4

* cell gf180mcu_fd_sc_mcu9t5v0__and2_4
* pin NWELL,VDD
* pin A2
* pin A1
* pin Z
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_4 1 2 3 5 6
* net 1 NWELL,VDD
* net 2 A2
* net 3 A1
* net 5 Z
* net 6 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.875 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.28U AS=1.3336P AD=0.8528P PS=6.69U PD=4.32U
* device instance $2 r0 *1 1.89,3.875 pmos_5p0
M$2 1 3 4 1 pmos_5p0 L=0.5U W=3.28U AS=0.8528P AD=0.8528P PS=4.32U PD=4.32U
* device instance $5 r0 *1 5.13,3.78 pmos_5p0
M$5 5 4 1 1 pmos_5p0 L=0.5U W=7.32U AS=2.0394P AD=2.2326P PS=9.58U PD=11.59U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 8 2 6 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 3 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 7 3 4 6 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 6 2 7 6 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 5 4 6 6 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai221_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin B2
* pin C
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai221_2 1 3 4 5 6 8 9 10
* net 1 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 B2
* net 6 C
* net 8 A1
* net 9 ZN
* net 10 A2
* device instance $1 r0 *1 0.92,3.965 pmos_5p0
M$1 9 6 1 1 pmos_5p0 L=0.5U W=2.92U AS=1.17P AD=1.2274P PS=5.06U PD=6.33U
* device instance $2 r0 *1 2.12,3.78 pmos_5p0
M$2 14 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.4758P PS=2.53U PD=2.35U
* device instance $3 r0 *1 3.14,3.78 pmos_5p0
M$3 9 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $4 r0 *1 4.31,3.78 pmos_5p0
M$4 13 4 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $5 r0 *1 5.38,3.78 pmos_5p0
M$5 1 5 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $7 r0 *1 7.78,3.78 pmos_5p0
M$7 12 8 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.52155P PS=2.53U PD=2.4U
* device instance $8 r0 *1 8.85,3.78 pmos_5p0
M$8 1 10 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.97,3.78 pmos_5p0
M$9 11 10 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 11.04,3.78 pmos_5p0
M$10 9 8 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 6 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7458P PS=5.36U PD=3.77U
* device instance $12 r0 *1 2.07,1.005 nmos_5p0
M$12 3 5 2 3 nmos_5p0 L=0.6U W=2.64U AS=0.7062P AD=0.6864P PS=3.71U PD=3.68U
* device instance $13 r0 *1 3.19,1.005 nmos_5p0
M$13 2 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.73,1.005 nmos_5p0
M$17 9 8 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.726P AD=0.924P PS=3.74U PD=5.36U
* device instance $18 r0 *1 8.85,1.005 nmos_5p0
M$18 7 10 9 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai221_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A2
* pin A1
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A2
* net 4 A1
* net 5 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.61305P PS=4.54U PD=2.5U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 5 4 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 3 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 5 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 6 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 2 3 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $9 r0 *1 0.92,1.04 nmos_5p0
M$9 5 3 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1224P AD=1.1224P PS=7.04U PD=7.04U
* device instance $10 r0 *1 2.04,1.04 nmos_5p0
M$10 1 4 5 1 nmos_5p0 L=0.6U W=3.68U AS=0.9568P AD=0.9568P PS=5.76U PD=5.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_3 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=3.96U AS=1.2672P AD=1.2672P PS=7.2U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_3

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_4 1 2 3 4 5 6 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A2
* net 4 A1
* net 5 B
* net 6 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 1.54,3.78 pmos_5p0
M$1 2 3 11 12 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1411P PS=11.59U PD=9.66U
* device instance $2 r0 *1 2.56,3.78 pmos_5p0
M$2 11 4 2 12 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.96,3.78 pmos_5p0
M$9 13 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.5673P PS=2.61U PD=2.45U
* device instance $10 r0 *1 11.08,3.78 pmos_5p0
M$10 12 6 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $11 r0 *1 12.62,3.78 pmos_5p0
M$11 14 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $12 r0 *1 13.74,3.78 pmos_5p0
M$12 11 5 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $13 r0 *1 15.28,3.78 pmos_5p0
M$13 16 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $14 r0 *1 16.4,3.78 pmos_5p0
M$14 12 6 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $15 r0 *1 17.94,3.78 pmos_5p0
M$15 15 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $16 r0 *1 19.06,3.78 pmos_5p0
M$16 11 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $17 r0 *1 9.96,1.08 nmos_5p0
M$17 2 5 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.33065P AD=0.9638P PS=6.745U PD=6.39U
* device instance $18 r0 *1 11.08,1.08 nmos_5p0
M$18 2 6 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.5056P AD=0.8216P PS=7.04U PD=5.24U
* device instance $25 r0 *1 1.54,0.937 nmos_5p0
M$25 7 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.74655P AD=0.219225P PS=3.63U
+ PD=1.555U
* device instance $26 r0 *1 2.51,0.937 nmos_5p0
M$26 2 4 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.63,0.937 nmos_5p0
M$27 9 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 4.55,0.937 nmos_5p0
M$28 1 3 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.67,0.937 nmos_5p0
M$29 8 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 6.59,0.937 nmos_5p0
M$30 2 4 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.71,0.937 nmos_5p0
M$31 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $32 r0 *1 8.63,0.937 nmos_5p0
M$32 1 3 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.37245P PS=1.505U
+ PD=1.915U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin C
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_2 1 3 4 5 6 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 NWELL,VDD
* net 5 B1
* net 6 C
* net 8 A2
* net 9 ZN
* net 10 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 2 6 7 4 pmos_5p0 L=0.5U W=3.66U AS=1.4457P AD=0.983625P PS=7.07U PD=4.735U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.1163P PS=4.7U PD=4.88U
* device instance $3 r0 *1 3.01,3.78 pmos_5p0
M$3 2 5 4 4 pmos_5p0 L=0.5U W=3.66U AS=0.9699P AD=0.9699P PS=4.72U PD=4.72U
* device instance $7 r0 *1 7.325,3.78 pmos_5p0
M$7 9 10 7 4 pmos_5p0 L=0.5U W=3.66U AS=0.983625P AD=1.281P PS=4.735U PD=6.89U
* device instance $8 r0 *1 8.345,3.78 pmos_5p0
M$8 7 8 9 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $11 r0 *1 6.32,0.875 nmos_5p0
M$11 9 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.711P AD=0.709025P PS=3.77U PD=4.36U
* device instance $13 r0 *1 2.22,1.072 nmos_5p0
M$13 14 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1422P PS=1.885U PD=1.425U
* device instance $14 r0 *1 3.06,1.072 nmos_5p0
M$14 9 5 14 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 4.18,1.072 nmos_5p0
M$15 12 5 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 5.02,1.072 nmos_5p0
M$16 1 3 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
* device instance $17 r0 *1 7.635,1.072 nmos_5p0
M$17 13 10 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.361425P AD=0.1422P PS=1.9U
+ PD=1.425U
* device instance $18 r0 *1 8.475,1.072 nmos_5p0
M$18 1 8 13 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $19 r0 *1 9.595,1.072 nmos_5p0
M$19 11 8 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $20 r0 *1 10.435,1.072 nmos_5p0
M$20 9 10 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.5214P PS=1.425U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin A4
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 A4
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 6 7 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.896P PS=5.24U PD=5.24U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 2 3 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.91,4.055 pmos_5p0
M$3 6 4 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.93,4.055 pmos_5p0
M$4 2 5 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 13 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2442P PS=3.52U PD=1.69U
* device instance $10 r0 *1 1.89,1.005 nmos_5p0
M$10 12 3 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2442P PS=1.69U PD=1.69U
* device instance $11 r0 *1 2.86,1.005 nmos_5p0
M$11 11 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 9 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $14 r0 *1 5.97,1.005 nmos_5p0
M$14 8 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $15 r0 *1 6.99,1.005 nmos_5p0
M$15 10 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.5808P PS=1.69U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_1 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.8052P PS=4.54U PD=4.54U
* device instance $2 r0 *1 0.92,1.3 nmos_5p0
M$2 4 3 1 1 nmos_5p0 L=0.6U W=0.73U AS=0.3212P AD=0.3212P PS=2.34U PD=2.34U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_1

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_2
* pin NWELL,VDD
* pin A2
* pin ZN
* pin A1
* pin B
* pin C
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 A2
* net 3 ZN
* net 4 A1
* net 5 B
* net 6 C
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 11 4 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $5 r0 *1 5.43,3.965 pmos_5p0
M$5 3 5 1 1 pmos_5p0 L=0.5U W=2.92U AS=0.9646P AD=1.022P PS=4.51U PD=5.78U
* device instance $6 r0 *1 6.45,3.965 pmos_5p0
M$6 1 6 3 1 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7062P PS=5.36U PD=3.71U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 7 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.43,1.005 nmos_5p0
M$13 9 5 8 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $14 r0 *1 6.4,1.005 nmos_5p0
M$14 7 6 9 7 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $15 r0 *1 7.52,1.005 nmos_5p0
M$15 10 6 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 8.44,1.005 nmos_5p0
M$16 8 5 10 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* pin A2
* pin A1
* pin B
* pin ZN
* pin C
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_2 1 2 4 5 6 7 8
* net 1 A2
* net 2 A1
* net 4 B
* net 5 ZN
* net 6 C
* net 7 NWELL,VDD
* net 8 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 5 1 3 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.3359P PS=6.89U PD=5.12U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 3 2 5 7 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.37,3.78 pmos_5p0
M$5 12 4 3 7 pmos_5p0 L=0.5U W=1.83U AS=0.8601P AD=0.2196P PS=2.77U PD=2.07U
* device instance $6 r0 *1 6.11,3.78 pmos_5p0
M$6 7 6 12 7 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.549P PS=2.07U PD=2.43U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 11 6 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.549P AD=0.4392P PS=2.43U PD=2.31U
* device instance $8 r0 *1 8.19,3.78 pmos_5p0
M$8 3 4 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.4392P AD=0.8052P PS=2.31U PD=4.54U
* device instance $9 r0 *1 5.02,0.745 nmos_5p0
M$9 5 4 8 8 nmos_5p0 L=0.6U W=1.58U AS=0.5609P AD=0.553P PS=3.195U PD=3.77U
* device instance $10 r0 *1 6.14,0.745 nmos_5p0
M$10 8 6 5 8 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $13 r0 *1 0.92,0.942 nmos_5p0
M$13 10 1 8 8 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.1422P PS=3.25U PD=1.425U
* device instance $14 r0 *1 1.76,0.942 nmos_5p0
M$14 5 2 10 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 2.88,0.942 nmos_5p0
M$15 9 2 5 8 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 3.72,0.942 nmos_5p0
M$16 8 1 9 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin B1
* pin A1
* pin B2
* pin C
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_4 1 2 3 4 13 14 15 16
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 B1
* net 4 A1
* net 13 B2
* net 14 C
* net 15 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 9.8,3.78 pmos_5p0
M$1 17 14 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.27835P AD=2.20515P PS=11.64U
+ PD=9.73U
* device instance $5 r0 *1 14.21,3.78 pmos_5p0
M$5 2 4 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $6 r0 *1 15.23,3.78 pmos_5p0
M$6 18 15 2 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $13 r0 *1 0.92,3.78 pmos_5p0
M$13 17 3 16 16 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U
+ PD=11.59U
* device instance $14 r0 *1 1.94,3.78 pmos_5p0
M$14 16 13 17 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $21 r0 *1 9.6,0.74 nmos_5p0
M$21 1 14 2 1 nmos_5p0 L=0.6U W=3.16U AS=1.04675P AD=0.9717P PS=6.005U PD=5.815U
* device instance $25 r0 *1 0.92,0.937 nmos_5p0
M$25 5 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.219225P PS=3.25U PD=1.555U
* device instance $26 r0 *1 1.89,0.937 nmos_5p0
M$26 1 13 5 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.01,0.937 nmos_5p0
M$27 7 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 3.93,0.937 nmos_5p0
M$28 2 3 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.05,0.937 nmos_5p0
M$29 9 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 5.97,0.937 nmos_5p0
M$30 1 13 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.09,0.937 nmos_5p0
M$31 8 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.24885P PS=1.705U
+ PD=1.605U
* device instance $32 r0 *1 8.11,0.937 nmos_5p0
M$32 2 3 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.24885P AD=0.43055P PS=1.605U
+ PD=2.075U
* device instance $33 r0 *1 14.26,0.937 nmos_5p0
M$33 12 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1896P PS=1.885U PD=1.505U
* device instance $34 r0 *1 15.18,0.937 nmos_5p0
M$34 1 15 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $35 r0 *1 16.3,0.937 nmos_5p0
M$35 11 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U
+ PD=1.505U
* device instance $36 r0 *1 17.22,0.937 nmos_5p0
M$36 2 4 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $37 r0 *1 18.34,0.937 nmos_5p0
M$37 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $38 r0 *1 19.26,0.937 nmos_5p0
M$38 1 15 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $39 r0 *1 20.38,0.937 nmos_5p0
M$39 6 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $40 r0 *1 21.3,0.937 nmos_5p0
M$40 2 4 6 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.5214P PS=1.505U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A4
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_4 1 3 4 5 6 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A3
* net 4 A4
* net 5 A2
* net 6 A1
* net 16 ZN
* net 17 NWELL,VDD
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 16 3 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.5616P AD=1.3312P PS=8.84U PD=7.2U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 17 4 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $9 r0 *1 9.03,4.055 pmos_5p0
M$9 16 5 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.5616P PS=7.2U PD=8.84U
* device instance $10 r0 *1 10.05,4.055 pmos_5p0
M$10 17 6 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 7 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $18 r0 *1 1.84,1.005 nmos_5p0
M$18 1 4 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $19 r0 *1 2.96,1.005 nmos_5p0
M$19 9 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 3.88,1.005 nmos_5p0
M$20 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $21 r0 *1 5,1.005 nmos_5p0
M$21 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 5.92,1.005 nmos_5p0
M$22 1 4 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 7.04,1.005 nmos_5p0
M$23 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $24 r0 *1 8.01,1.005 nmos_5p0
M$24 11 3 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $25 r0 *1 9.03,1.005 nmos_5p0
M$25 14 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $26 r0 *1 10,1.005 nmos_5p0
M$26 16 6 14 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 11.12,1.005 nmos_5p0
M$27 15 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.04,1.005 nmos_5p0
M$28 2 5 15 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 13.16,1.005 nmos_5p0
M$29 10 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.08,1.005 nmos_5p0
M$30 16 6 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 15.2,1.005 nmos_5p0
M$31 13 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 16.12,1.005 nmos_5p0
M$32 2 5 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.732P PS=4.54U PD=2.63U
* device instance $2 r0 *1 2.17,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.2993P AD=1.3725P PS=5.08U PD=6.99U
* device instance $4 r0 *1 0.92,1.23 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=0.73U AS=0.3212P AD=0.2695P PS=2.34U PD=1.5U
* device instance $5 r0 *1 2.22,1.265 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=1.6U AS=0.4775P AD=0.56P PS=2.82U PD=3.8U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1346P AD=1.3725P PS=4.9U PD=6.99U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $5 r0 *1 2.04,1.005 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_3 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.552 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=2.75U AS=1.03125P AD=0.97625P PS=5.625U PD=4.17U
* device instance $3 r0 *1 3.29,3.552 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=5.5U AS=1.82875P AD=1.88375P PS=8.16U PD=9.615U
* device instance $7 r0 *1 0.92,1.34 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.1U AS=0.385P AD=0.3455P PS=3.05U PD=2.37U
* device instance $9 r0 *1 3.34,1.365 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=2.4U AS=0.6705P AD=0.732P PS=4.66U PD=5.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 10 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 10 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 11 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 11 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 8 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 8 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyc_2 1 7 11 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* net 11 I
* net 13 NWELL,VDD
* device instance $1 r0 *1 8.34,3.365 pmos_5p0
M$1 6 5 17 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 8.34,4.085 pmos_5p0
M$2 17 5 13 13 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 10.14,3.785 pmos_5p0
M$3 7 6 13 13 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 4.34,3.365 pmos_5p0
M$5 4 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $6 r0 *1 6.18,3.365 pmos_5p0
M$6 16 4 5 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $7 r0 *1 4.34,4.085 pmos_5p0
M$7 13 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $8 r0 *1 6.18,4.085 pmos_5p0
M$8 13 4 16 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $9 r0 *1 2.18,3.365 pmos_5p0
M$9 15 2 3 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $10 r0 *1 0.87,4.085 pmos_5p0
M$10 13 11 2 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $11 r0 *1 2.18,4.085 pmos_5p0
M$11 13 2 15 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $12 r0 *1 0.92,0.795 nmos_5p0
M$12 1 11 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $13 r0 *1 2.23,0.795 nmos_5p0
M$13 12 2 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $14 r0 *1 2.23,1.515 nmos_5p0
M$14 3 2 12 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $15 r0 *1 4.39,0.52 nmos_5p0
M$15 1 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.2232P PS=1.98U PD=1.6U
* device instance $16 r0 *1 6.23,0.52 nmos_5p0
M$16 10 4 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.2232P AD=0.27P PS=1.6U PD=1.98U
* device instance $17 r0 *1 4.39,1.24 nmos_5p0
M$17 4 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $18 r0 *1 6.23,1.24 nmos_5p0
M$18 5 4 10 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $19 r0 *1 8.39,0.525 nmos_5p0
M$19 1 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $20 r0 *1 8.39,1.245 nmos_5p0
M$20 6 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $21 r0 *1 10.19,1.005 nmos_5p0
M$21 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyc_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__inv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_8 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.9832P AD=2.9832P PS=16.4U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_8

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.8377P PS=26.59U PD=24.68U
* device instance $11 r0 *1 12.25,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.5107P AD=11.5839P PS=49.18U PD=51.09U
* device instance $31 r0 *1 0.92,1.3 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=7.3U AS=2.1091P AD=1.898P PS=13.84U PD=12.5U
* device instance $41 r0 *1 12.3,1.265 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=16U AS=4.2215P AD=4.304P PS=26.58U PD=27.56U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_4 1 3 4 5 6 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 RN
* net 4 Q
* net 5 CLK
* net 6 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 16.975,3.78 pmos_5p0
M$1 4 13 17 17 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U PD=11.59U
* device instance $5 r0 *1 9.55,3.71 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.285P PS=2.88U PD=1.57U
* device instance $6 r0 *1 10.62,3.71 pmos_5p0
M$6 11 2 10 17 pmos_5p0 L=0.5U W=1U AS=0.285P AD=0.26P PS=1.57U PD=1.52U
* device instance $7 r0 *1 11.64,3.71 pmos_5p0
M$7 12 8 11 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2875P PS=1.52U PD=1.575U
* device instance $8 r0 *1 12.715,3.71 pmos_5p0
M$8 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.5457P AD=0.2875P PS=2.57U PD=1.575U
* device instance $9 r0 *1 13.955,3.78 pmos_5p0
M$9 13 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5457P AD=0.4758P PS=2.57U PD=2.35U
* device instance $10 r0 *1 14.975,3.78 pmos_5p0
M$10 17 11 13 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $11 r0 *1 3.73,3.41 pmos_5p0
M$11 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $12 r0 *1 4.75,3.41 pmos_5p0
M$12 9 8 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 5.77,3.41 pmos_5p0
M$13 18 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $14 r0 *1 6.79,3.41 pmos_5p0
M$14 17 10 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $15 r0 *1 7.81,3.41 pmos_5p0
M$15 18 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $16 r0 *1 0.97,3.555 pmos_5p0
M$16 17 5 2 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $17 r0 *1 1.99,3.555 pmos_5p0
M$17 8 2 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $18 r0 *1 16.925,1.005 nmos_5p0
M$18 4 13 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $22 r0 *1 3.9,1.315 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $23 r0 *1 5.02,1.315 nmos_5p0
M$23 9 2 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $24 r0 *1 6.14,1.315 nmos_5p0
M$24 15 8 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $25 r0 *1 6.98,1.315 nmos_5p0
M$25 14 10 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0826P PS=0.83U PD=0.87U
* device instance $26 r0 *1 7.86,1.315 nmos_5p0
M$26 1 3 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.0826P AD=0.2124P PS=0.87U PD=1.31U
* device instance $27 r0 *1 9.18,1.315 nmos_5p0
M$27 10 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2124P AD=0.190275P PS=1.31U PD=1.235U
* device instance $28 r0 *1 10.425,1.315 nmos_5p0
M$28 11 8 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.190275P AD=0.1534P PS=1.235U
+ PD=1.11U
* device instance $29 r0 *1 11.545,1.315 nmos_5p0
M$29 12 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $30 r0 *1 12.665,1.315 nmos_5p0
M$30 1 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 13.785,1.315 nmos_5p0
M$31 1 3 16 1 nmos_5p0 L=0.6U W=0.59U AS=0.3525P AD=0.1534P PS=2.02U PD=1.11U
* device instance $32 r0 *1 15.085,1.005 nmos_5p0
M$32 13 11 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3525P AD=0.5808P PS=2.02U PD=3.52U
* device instance $33 r0 *1 0.92,1.27 nmos_5p0
M$33 1 5 2 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $34 r0 *1 2.04,1.27 nmos_5p0
M$34 8 2 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__tiel
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__tiel 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.97,3.315 pmos_5p0
M$1 3 3 2 2 pmos_5p0 L=0.5U W=0.9U AS=0.396P AD=0.396P PS=2.68U PD=2.68U
* device instance $2 r0 *1 0.92,1.335 nmos_5p0
M$2 4 3 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.2904P PS=2.2U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__tiel

* cell gf180mcu_fd_sc_mcu9t5v0__dlya_4
* pin I
* pin Z
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlya_4 1 5 6 7
* net 1 I
* net 5 Z
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 3.885,3.61 pmos_5p0
M$1 4 3 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.429P AD=0.1584P PS=2.58U PD=1.6U
* device instance $2 r0 *1 5.135,3.78 pmos_5p0
M$2 5 4 6 6 pmos_5p0 L=0.5U W=7.32U AS=2.1309P AD=2.5071P PS=9.93U PD=11.89U
* device instance $6 r0 *1 0.875,3.61 pmos_5p0
M$6 6 1 2 6 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1116P PS=1.6U PD=0.98U
* device instance $7 r0 *1 1.995,3.61 pmos_5p0
M$7 3 2 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.1116P AD=0.1584P PS=0.98U PD=1.6U
* device instance $8 r0 *1 3.885,0.94 nmos_5p0
M$8 4 3 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.318P AD=0.1584P PS=2.02U PD=1.6U
* device instance $9 r0 *1 5.185,1.005 nmos_5p0
M$9 5 4 7 7 nmos_5p0 L=0.6U W=5.28U AS=1.3476P AD=1.6104P PS=7.54U PD=9.04U
* device instance $13 r0 *1 0.925,0.94 nmos_5p0
M$13 7 1 2 7 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $14 r0 *1 2.045,0.94 nmos_5p0
M$14 3 2 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.0936P AD=0.1584P PS=0.88U PD=1.6U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlya_4

* cell gf180mcu_fd_sc_mcu9t5v0__addh_2
* pin PWELL,VSS,gf180mcu_gnd
* pin CO
* pin S
* pin A
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_2 1 2 6 7 8 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 CO
* net 6 S
* net 7 A
* net 8 B
* net 10 NWELL,VDD
* device instance $1 r0 *1 5.99,3.78 pmos_5p0
M$1 11 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 7.06,3.78 pmos_5p0
M$2 5 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.52155P PS=2.4U PD=2.4U
* device instance $3 r0 *1 8.13,3.78 pmos_5p0
M$3 10 3 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8784P PS=2.4U PD=2.79U
* device instance $4 r0 *1 9.59,3.78 pmos_5p0
M$4 6 5 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.32675P PS=5.19U PD=6.94U
* device instance $6 r0 *1 0.94,3.78 pmos_5p0
M$6 2 3 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.08885P PS=6.99U PD=4.85U
* device instance $8 r0 *1 3.13,3.78 pmos_5p0
M$8 3 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.4758P PS=2.4U PD=2.35U
* device instance $9 r0 *1 4.15,3.78 pmos_5p0
M$9 10 8 3 10 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 5.94,1.005 nmos_5p0
M$10 5 8 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $11 r0 *1 7.06,1.005 nmos_5p0
M$11 4 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $12 r0 *1 8.18,1.005 nmos_5p0
M$12 1 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5016P PS=1.84U PD=2.08U
* device instance $13 r0 *1 9.54,1.005 nmos_5p0
M$13 6 5 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.8448P AD=0.924P PS=3.92U PD=5.36U
* device instance $15 r0 *1 0.94,1.005 nmos_5p0
M$15 2 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $17 r0 *1 3.18,1.005 nmos_5p0
M$17 9 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 4.1,1.005 nmos_5p0
M$18 3 8 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_2

* cell gf180mcu_fd_sc_mcu9t5v0__addh_1
* pin CO
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A
* pin B
* pin S
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_1 1 2 3 4 5 9
* net 1 CO
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 NWELL,VDD
* net 4 A
* net 5 B
* net 9 S
* device instance $1 r0 *1 5.01,3.912 pmos_5p0
M$1 11 5 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 6.03,3.912 pmos_5p0
M$2 8 4 11 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.3294P PS=1.435U PD=1.635U
* device instance $3 r0 *1 7.25,3.912 pmos_5p0
M$3 8 6 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.50325P AD=0.3294P PS=2.53U PD=1.635U
* device instance $4 r0 *1 8.45,3.78 pmos_5p0
M$4 9 8 3 3 pmos_5p0 L=0.5U W=1.83U AS=0.50325P AD=0.8052P PS=2.53U PD=4.54U
* device instance $5 r0 *1 2.23,3.912 pmos_5p0
M$5 6 4 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.5307P AD=0.2379P PS=2.59U PD=1.435U
* device instance $6 r0 *1 3.25,3.912 pmos_5p0
M$6 3 5 6 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $7 r0 *1 0.97,3.78 pmos_5p0
M$7 3 6 1 3 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5307P PS=4.54U PD=2.59U
* device instance $8 r0 *1 4.96,1.335 nmos_5p0
M$8 8 5 7 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $9 r0 *1 6.08,1.335 nmos_5p0
M$9 7 4 8 2 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1716P PS=1.18U PD=1.18U
* device instance $10 r0 *1 7.2,1.335 nmos_5p0
M$10 7 6 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $11 r0 *1 8.5,1.005 nmos_5p0
M$11 9 8 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.5808P PS=2.02U PD=3.52U
* device instance $12 r0 *1 0.92,1.005 nmos_5p0
M$12 2 6 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3828P PS=3.52U PD=2.08U
* device instance $13 r0 *1 2.28,1.335 nmos_5p0
M$13 10 4 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.3828P AD=0.0792P PS=2.08U PD=0.9U
* device instance $14 r0 *1 3.12,1.335 nmos_5p0
M$14 6 5 10 2 nmos_5p0 L=0.6U W=0.66U AS=0.0792P AD=0.2904P PS=0.9U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_1

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.2993P PS=6.99U PD=5.08U
* device instance $3 r0 *1 3.29,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.5071P PS=9.98U PD=11.89U
* device instance $7 r0 *1 0.92,1.23 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.4593P PS=3.59U PD=2.75U
* device instance $9 r0 *1 3.34,1.265 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.8935P AD=0.976P PS=5.46U PD=6.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_4 1 2 3 4 5
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 ZN
* net 5 A1
* device instance $1 r0 *1 0.87,3.687 pmos_5p0
M$1 4 3 1 1 pmos_5p0 L=0.5U W=6.58U AS=2.0069P AD=2.0069P PS=10.665U PD=10.665U
* device instance $2 r0 *1 1.89,3.687 pmos_5p0
M$2 1 5 4 1 pmos_5p0 L=0.5U W=6.58U AS=1.7108P AD=1.7108P PS=8.66U PD=8.66U
* device instance $9 r0 *1 1,1.005 nmos_5p0
M$9 9 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 5 9 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3729P PS=1.56U PD=1.885U
* device instance $11 r0 *1 3.005,1.005 nmos_5p0
M$11 8 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3729P AD=0.1584P PS=1.885U PD=1.56U
* device instance $12 r0 *1 3.845,1.005 nmos_5p0
M$12 2 3 8 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3663P PS=1.56U PD=1.875U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 7 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.2112P PS=1.875U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 4 5 7 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 6 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 2 3 6 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 11 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 10 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 9 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_2 1 2 3 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 NWELL,VDD
* net 5 A2
* net 6 A3
* device instance $1 r0 *1 0.87,3.85 pmos_5p0
M$1 2 6 4 4 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.022P PS=5.78U PD=5.78U
* device instance $2 r0 *1 1.89,3.85 pmos_5p0
M$2 4 5 2 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.85 pmos_5p0
M$3 2 3 4 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 1.06,1 nmos_5p0
M$7 10 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1848P PS=3.52U PD=1.6U
* device instance $8 r0 *1 1.94,1 nmos_5p0
M$8 9 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1848P AD=0.2112P PS=1.6U PD=1.64U
* device instance $9 r0 *1 2.86,1 nmos_5p0
M$9 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $10 r0 *1 3.98,1 nmos_5p0
M$10 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $11 r0 *1 4.9,1 nmos_5p0
M$11 7 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $12 r0 *1 5.92,1 nmos_5p0
M$12 1 6 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.5808P PS=1.74U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_2 1 5 6 7 8
* net 1 NWELL,VDD
* net 5 A1
* net 6 A2
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 ZN
* device instance $1 r0 *1 0.97,3.327 pmos_5p0
M$1 10 6 2 1 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.260775P PS=2.71U PD=1.485U
* device instance $2 r0 *1 2.04,3.327 pmos_5p0
M$2 1 5 10 1 pmos_5p0 L=0.5U W=0.915U AS=0.260775P AD=0.571875P PS=1.485U
+ PD=2.68U
* device instance $3 r0 *1 3.39,3.785 pmos_5p0
M$3 4 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.4758P PS=2.68U PD=2.35U
* device instance $4 r0 *1 4.41,3.785 pmos_5p0
M$4 3 5 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.4758P PS=2.35U PD=2.35U
* device instance $5 r0 *1 5.43,3.785 pmos_5p0
M$5 4 6 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.17,3.78 pmos_5p0
M$6 8 3 1 1 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 3 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,0.675 nmos_5p0
M$10 2 6 7 7 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $11 r0 *1 2.04,0.675 nmos_5p0
M$11 7 5 2 7 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.363P PS=1.18U PD=2.02U
* device instance $12 r0 *1 3.34,1.005 nmos_5p0
M$12 3 2 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.46,1.005 nmos_5p0
M$13 9 5 3 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 7 6 9 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__xor2_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xor2_2 1 2 6 7 8
* net 1 A1
* net 2 PWELL,VSS,gf180mcu_gnd
* net 6 A2
* net 7 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.87,3.947 pmos_5p0
M$1 3 6 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 1.89,3.947 pmos_5p0
M$2 3 1 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.526125P AD=0.2379P PS=2.58U PD=1.435U
* device instance $3 r0 *1 3.14,3.785 pmos_5p0
M$3 5 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.526125P AD=0.61305P PS=2.58U PD=2.5U
* device instance $4 r0 *1 4.31,3.785 pmos_5p0
M$4 10 1 5 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $5 r0 *1 5.33,3.785 pmos_5p0
M$5 7 6 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.27,3.78 pmos_5p0
M$6 8 5 7 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 5 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,1.16 nmos_5p0
M$10 9 6 3 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1056P PS=2.2U PD=0.98U
* device instance $11 r0 *1 1.84,1.16 nmos_5p0
M$11 9 1 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1056P PS=2.02U PD=0.98U
* device instance $12 r0 *1 3.14,1.005 nmos_5p0
M$12 4 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.26,1.005 nmos_5p0
M$13 5 1 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 4 6 5 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__and4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_2 1 2 3 4 5 6 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.925,4.055 pmos_5p0
M$1 7 1 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $2 r0 *1 1.945,4.055 pmos_5p0
M$2 6 2 7 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $3 r0 *1 2.965,4.055 pmos_5p0
M$3 7 3 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $4 r0 *1 3.985,4.055 pmos_5p0
M$4 7 4 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.558P AD=0.3328P PS=2.53U PD=1.8U
* device instance $5 r0 *1 5.185,3.78 pmos_5p0
M$5 8 7 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.0338P AD=1.281P PS=4.88U PD=6.89U
* device instance $7 r0 *1 0.975,1.005 nmos_5p0
M$7 11 1 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $8 r0 *1 1.895,1.005 nmos_5p0
M$8 10 2 11 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $9 r0 *1 2.915,1.005 nmos_5p0
M$9 9 3 10 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $10 r0 *1 3.935,1.005 nmos_5p0
M$10 5 4 9 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $11 r0 *1 5.055,1.005 nmos_5p0
M$11 8 7 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_2
