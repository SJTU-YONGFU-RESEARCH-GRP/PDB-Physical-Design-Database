* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_spi_master clk rst_n rx_data[0] rx_data[1]
+ rx_data[2] rx_data[3] rx_data[4] rx_data[5] rx_data[6] rx_data[7]
+ rx_valid spi_clk spi_cs_n spi_miso spi_mosi tx_data[0] tx_data[1]
+ tx_data[2] tx_data[3] tx_data[4] tx_data[5] tx_data[6] tx_data[7]
+ tx_ready tx_valid
X_220_ net1 _039_ VDD VSS INV_X2
X_221_ state\[0\] _040_ VDD VSS BUF_X2
X_222_ _195_ _041_ VDD VSS BUF_X2
X_223_ clk_divider\[2\] _042_ VDD VSS INV_X1
X_224_ _003_ _043_ VDD VSS BUF_X2
X_225_ net21 _044_ VDD VSS INV_X1
X_226_ bit_count\[3\] _199_ _045_ VDD VSS NAND2_X1
X_227_ bit_count\[2\] _046_ VDD VSS CLKBUF_X2
X_228_ _044_ _045_ _046_ _047_ VDD VSS OAI21_X1
X_229_ _041_ _042_ _043_ _047_ _048_ VDD VSS NAND4_X1
X_230_ state\[2\] _049_ VDD VSS BUF_X4
X_231_ _049_ _050_ VDD VSS CLKBUF_X3
X_232_ net11 _040_ _048_ _050_ _051_ VDD VSS AOI22_X1
X_233_ _039_ _051_ _002_ VDD VSS NOR2_X1
X_234_ _046_ _052_ VDD VSS INV_X1
X_235_ _201_ _053_ VDD VSS CLKBUF_X2
X_236_ _053_ _054_ VDD VSS INV_X1
X_237_ _052_ bit_count\[3\] _054_ _214_ VDD VSS NOR3_X4
X_238_ state\[1\] _055_ VDD VSS CLKBUF_X3
X_239_ net1 _056_ VDD VSS BUF_X2
X_240_ _040_ _057_ VDD VSS INV_X1
X_241_ _056_ _057_ net11 _058_ VDD VSS OAI21_X1
X_242_ _055_ _058_ _001_ VDD VSS OR2_X1
X_243_ state\[2\] _059_ VDD VSS INV_X2
X_244_ _041_ _042_ _060_ VDD VSS NAND2_X1
X_245_ _046_ net21 _039_ _045_ _061_ VDD VSS OR4_X1
X_246_ _059_ _060_ _061_ _000_ VDD VSS NOR3_X1
X_247_ bit_count\[0\] _062_ VDD VSS BUF_X1
X_248_ _046_ _062_ bit_count\[1\] _204_ VDD VSS NAND3_X1
X_249_ _214_ _207_ VDD VSS INV_X1
X_250_ bit_count\[3\] _204_ _217_ VDD VSS OR2_X1
X_251_ _049_ _040_ _063_ VDD VSS NOR2_X2
X_252_ net11 _064_ VDD VSS INV_X1
X_253_ _063_ _040_ _064_ _065_ VDD VSS AOI21_X2
X_254_ _041_ _066_ VDD VSS INV_X1
X_255_ _066_ clk_divider\[2\] _043_ _067_ VDD VSS NOR3_X2
X_256_ _065_ _067_ _059_ _068_ VDD VSS OAI21_X2
X_257_ _066_ clk_divider\[2\] _059_ _210_ _069_ VDD VSS OR4_X2
X_258_ _043_ _214_ _069_ _070_ VDD VSS NOR3_X4
X_259_ _059_ _062_ _068_ _070_ _071_ VDD VSS OR4_X1
X_260_ _062_ _068_ _070_ _072_ VDD VSS OAI21_X1
X_261_ _039_ _071_ _072_ _004_ VDD VSS AOI21_X1
X_262_ bit_count\[1\] _068_ _070_ _073_ VDD VSS OAI21_X1
X_263_ _200_ _074_ VDD VSS BUF_X1
X_264_ _049_ _040_ _075_ VDD VSS OR2_X1
X_265_ _075_ _057_ net11 _076_ VDD VSS OAI21_X1
X_266_ _066_ clk_divider\[2\] _043_ _077_ VDD VSS OR3_X1
X_267_ _076_ _077_ _050_ _078_ VDD VSS AOI21_X2
X_268_ _043_ _214_ _069_ _079_ VDD VSS OR3_X1
X_269_ _050_ _074_ _078_ _079_ _080_ VDD VSS NAND4_X1
X_270_ _039_ _073_ _080_ _005_ VDD VSS AOI21_X1
X_271_ _059_ _053_ _081_ VDD VSS NOR2_X1
X_272_ _068_ _070_ _081_ _082_ VDD VSS NOR3_X1
X_273_ _056_ _083_ VDD VSS BUF_X2
X_274_ _052_ _083_ _050_ _053_ _084_ VDD VSS NAND4_X1
X_275_ _052_ _039_ _082_ _084_ _068_ _070_ _006_ VDD VSS OAI33_X1
X_276_ bit_count\[3\] _068_ _070_ _085_ VDD VSS OAI21_X1
X_277_ _050_ _206_ _078_ _079_ _086_ VDD VSS NAND4_X1
X_278_ _039_ _085_ _086_ _007_ VDD VSS AOI21_X1
X_279_ _059_ _075_ clk_divider\[0\] _087_ VDD VSS MUX2_X1
X_280_ _039_ _087_ _008_ VDD VSS NOR2_X1
X_281_ _050_ _196_ _060_ _088_ VDD VSS NAND3_X1
X_282_ clk_divider\[1\] _063_ _089_ VDD VSS NAND2_X1
X_283_ _039_ _088_ _089_ _009_ VDD VSS AOI21_X1
X_284_ _063_ _050_ _066_ _090_ VDD VSS AOI21_X1
X_285_ _042_ _039_ _090_ _010_ VDD VSS NOR3_X1
X_286_ _083_ _091_ VDD VSS BUF_X2
X_287_ net12 rx_shift\[0\] _055_ _092_ VDD VSS MUX2_X1
X_288_ _091_ _092_ _011_ VDD VSS AND2_X1
X_289_ net13 rx_shift\[1\] _055_ _093_ VDD VSS MUX2_X1
X_290_ _091_ _093_ _012_ VDD VSS AND2_X1
X_291_ net14 rx_shift\[2\] _055_ _094_ VDD VSS MUX2_X1
X_292_ _091_ _094_ _013_ VDD VSS AND2_X1
X_293_ net15 rx_shift\[3\] _055_ _095_ VDD VSS MUX2_X1
X_294_ _091_ _095_ _014_ VDD VSS AND2_X1
X_295_ net16 rx_shift\[4\] _055_ _096_ VDD VSS MUX2_X1
X_296_ _091_ _096_ _015_ VDD VSS AND2_X1
X_297_ net17 rx_shift\[5\] _055_ _097_ VDD VSS MUX2_X1
X_298_ _091_ _097_ _016_ VDD VSS AND2_X1
X_299_ net18 rx_shift\[6\] _055_ _098_ VDD VSS MUX2_X1
X_300_ _091_ _098_ _017_ VDD VSS AND2_X1
X_301_ net19 rx_shift\[7\] _055_ _099_ VDD VSS MUX2_X1
X_302_ _091_ _099_ _018_ VDD VSS AND2_X1
X_303_ _056_ net2 _100_ VDD VSS AND2_X1
X_304_ _083_ rx_shift\[0\] _101_ VDD VSS AND2_X1
X_305_ _215_ _212_ _197_ _074_ _102_ VDD VSS NOR4_X1
X_306_ _046_ _053_ _103_ VDD VSS XNOR2_X2
X_307_ _049_ _043_ _104_ VDD VSS AND2_X1
X_308_ _041_ _042_ _103_ _104_ _105_ VDD VSS NAND4_X1
X_309_ _205_ _218_ _106_ VDD VSS NOR2_X1
X_310_ _209_ _219_ _106_ _107_ VDD VSS NAND3_X1
X_311_ _209_ _219_ _108_ VDD VSS NOR2_X1
X_312_ _205_ _218_ _108_ _109_ VDD VSS NAND3_X1
X_313_ _105_ _107_ _109_ _110_ VDD VSS AOI21_X1
X_314_ _209_ _206_ _102_ _110_ _111_ VDD VSS NAND4_X1
X_315_ _100_ _101_ _111_ _019_ VDD VSS MUX2_X1
X_316_ _056_ rx_shift\[1\] _112_ VDD VSS AND2_X1
X_317_ _041_ _042_ _104_ _113_ VDD VSS NAND3_X1
X_318_ _206_ _103_ _113_ _114_ VDD VSS NOR3_X2
X_319_ _074_ _115_ VDD VSS INV_X1
X_320_ _215_ _212_ _116_ VDD VSS NOR2_X1
X_321_ _205_ _218_ _116_ _108_ _117_ VDD VSS NAND4_X2
X_322_ _062_ _115_ _117_ _118_ VDD VSS NOR3_X1
X_323_ _114_ _118_ _119_ VDD VSS NAND2_X1
X_324_ _100_ _112_ _119_ _020_ VDD VSS MUX2_X1
X_325_ _056_ rx_shift\[2\] _120_ VDD VSS AND2_X1
X_326_ _197_ _115_ _117_ _121_ VDD VSS NOR3_X1
X_327_ _114_ _121_ _122_ VDD VSS NAND2_X1
X_328_ _100_ _120_ _122_ _021_ VDD VSS MUX2_X1
X_329_ _056_ rx_shift\[3\] _123_ VDD VSS AND2_X1
X_330_ _062_ _074_ _117_ _124_ VDD VSS NOR3_X1
X_331_ _114_ _124_ _125_ VDD VSS NAND2_X1
X_332_ _100_ _123_ _125_ _022_ VDD VSS MUX2_X1
X_333_ _056_ rx_shift\[4\] _126_ VDD VSS AND2_X1
X_334_ _197_ _074_ _117_ _127_ VDD VSS NOR3_X1
X_335_ _114_ _127_ _128_ VDD VSS NAND2_X1
X_336_ _100_ _126_ _128_ _023_ VDD VSS MUX2_X1
X_337_ _056_ rx_shift\[5\] _129_ VDD VSS AND2_X1
X_338_ _206_ _105_ _130_ VDD VSS NOR2_X1
X_339_ _118_ _130_ _131_ VDD VSS NAND2_X1
X_340_ _100_ _129_ _131_ _024_ VDD VSS MUX2_X1
X_341_ _056_ rx_shift\[6\] _132_ VDD VSS AND2_X1
X_342_ _121_ _130_ _133_ VDD VSS NAND2_X1
X_343_ _100_ _132_ _133_ _025_ VDD VSS MUX2_X1
X_344_ _056_ rx_shift\[7\] _134_ VDD VSS AND2_X1
X_345_ _124_ _130_ _135_ VDD VSS NAND2_X1
X_346_ _100_ _134_ _135_ _026_ VDD VSS MUX2_X1
X_347_ _091_ _055_ _027_ VDD VSS AND2_X1
X_348_ _040_ state\[1\] _113_ _136_ VDD VSS OR3_X1
X_349_ _050_ _040_ state\[1\] _137_ VDD VSS NOR3_X1
X_350_ _137_ _060_ _050_ _138_ VDD VSS AOI21_X1
X_351_ _136_ _138_ _044_ _139_ VDD VSS OAI21_X1
X_352_ _091_ _139_ _028_ VDD VSS AND2_X1
X_353_ _057_ net22 _140_ VDD VSS AND2_X1
X_354_ _001_ _140_ _029_ VDD VSS OR2_X1
X_355_ net10 tx_shift\[6\] _050_ _141_ VDD VSS MUX2_X1
X_356_ _065_ _069_ _044_ _059_ _067_ _142_ VDD VSS OAI221_X2
X_357_ _142_ _143_ VDD VSS BUF_X4
X_358_ _141_ net23 _143_ _144_ VDD VSS MUX2_X1
X_359_ _083_ _144_ _030_ VDD VSS AND2_X1
X_360_ _058_ _145_ VDD VSS INV_X1
X_361_ net24 _146_ VDD VSS INV_X1
X_362_ _145_ _146_ _040_ _031_ VDD VSS OAI21_X1
X_363_ tx_shift\[0\] _143_ _147_ VDD VSS NAND2_X1
X_364_ _059_ net3 _078_ _148_ VDD VSS NAND3_X1
X_365_ _039_ _147_ _148_ _032_ VDD VSS AOI21_X1
X_366_ net4 tx_shift\[0\] _049_ _149_ VDD VSS MUX2_X1
X_367_ _149_ tx_shift\[1\] _143_ _150_ VDD VSS MUX2_X1
X_368_ _083_ _150_ _033_ VDD VSS AND2_X1
X_369_ net5 tx_shift\[1\] _049_ _151_ VDD VSS MUX2_X1
X_370_ _151_ tx_shift\[2\] _143_ _152_ VDD VSS MUX2_X1
X_371_ _083_ _152_ _034_ VDD VSS AND2_X1
X_372_ net6 tx_shift\[2\] _049_ _153_ VDD VSS MUX2_X1
X_373_ _153_ tx_shift\[3\] _143_ _154_ VDD VSS MUX2_X1
X_374_ _083_ _154_ _035_ VDD VSS AND2_X1
X_375_ net7 tx_shift\[3\] _049_ _155_ VDD VSS MUX2_X1
X_376_ _155_ tx_shift\[4\] _143_ _156_ VDD VSS MUX2_X1
X_377_ _083_ _156_ _036_ VDD VSS AND2_X1
X_378_ net8 tx_shift\[4\] _049_ _157_ VDD VSS MUX2_X1
X_379_ _157_ tx_shift\[5\] _143_ _158_ VDD VSS MUX2_X1
X_380_ _083_ _158_ _037_ VDD VSS AND2_X1
X_381_ net9 tx_shift\[5\] _049_ _159_ VDD VSS MUX2_X1
X_382_ _159_ tx_shift\[6\] _143_ _160_ VDD VSS MUX2_X1
X_383_ _083_ _160_ _038_ VDD VSS AND2_X1
X_384_ clk_divider\[0\] clk_divider\[1\] _195_ _196_ VDD VSS
+ HA_X1
X_385_ _197_ _198_ _199_ _200_ VDD VSS HA_X1
X_386_ bit_count\[0\] bit_count\[1\] _201_ _202_ VDD VSS HA_X1
X_387_ _203_ _204_ _205_ _206_ VDD VSS HA_X1
X_388_ _203_ _207_ _208_ _209_ VDD VSS HA_X1
X_389_ _203_ _207_ _210_ _211_ VDD VSS HA_X1
X_390_ bit_count\[3\] _207_ _212_ _213_ VDD VSS HA_X1
X_391_ bit_count\[3\] _214_ _215_ _216_ VDD VSS HA_X1
X_392_ _203_ _217_ _218_ _219_ VDD VSS HA_X1
Xbit_count\[0\]$_SDFFE_PN0P_ _004_ clknet_2_2__leaf_clk bit_count\[0\]
+ _197_ VDD VSS DFF_X2
Xbit_count\[1\]$_SDFFE_PN0P_ _005_ clknet_2_2__leaf_clk bit_count\[1\]
+ _198_ VDD VSS DFF_X1
Xbit_count\[2\]$_SDFFE_PN0P_ _006_ clknet_2_2__leaf_clk bit_count\[2\]
+ _191_ VDD VSS DFF_X1
Xbit_count\[3\]$_SDFFE_PN0P_ _007_ clknet_2_2__leaf_clk bit_count\[3\]
+ _203_ VDD VSS DFF_X2
Xclk_divider\[0\]$_SDFFE_PN0P_ _008_ clknet_2_1__leaf_clk
+ clk_divider\[0\] _190_ VDD VSS DFF_X1
Xclk_divider\[1\]$_SDFFE_PN0P_ _009_ clknet_2_1__leaf_clk
+ clk_divider\[1\] _189_ VDD VSS DFF_X1
Xclk_divider\[2\]$_SDFFE_PN0P_ _010_ clknet_2_0__leaf_clk
+ clk_divider\[2\] _188_ VDD VSS DFF_X2
Xrx_data\[0\]$_SDFFE_PN0P_ _011_ clknet_2_3__leaf_clk net12
+ _187_ VDD VSS DFF_X1
Xrx_data\[1\]$_SDFFE_PN0P_ _012_ clknet_2_3__leaf_clk net13
+ _186_ VDD VSS DFF_X1
Xrx_data\[2\]$_SDFFE_PN0P_ _013_ clknet_2_3__leaf_clk net14
+ _185_ VDD VSS DFF_X1
Xrx_data\[3\]$_SDFFE_PN0P_ _014_ clknet_2_3__leaf_clk net15
+ _184_ VDD VSS DFF_X1
Xrx_data\[4\]$_SDFFE_PN0P_ _015_ clknet_2_3__leaf_clk net16
+ _183_ VDD VSS DFF_X1
Xrx_data\[5\]$_SDFFE_PN0P_ _016_ clknet_2_3__leaf_clk net17
+ _182_ VDD VSS DFF_X1
Xrx_data\[6\]$_SDFFE_PN0P_ _017_ clknet_2_2__leaf_clk net18
+ _181_ VDD VSS DFF_X1
Xrx_data\[7\]$_SDFFE_PN0P_ _018_ clknet_2_2__leaf_clk net19
+ _180_ VDD VSS DFF_X1
Xrx_shift\[0\]$_SDFFE_PN0P_ _019_ clknet_2_3__leaf_clk rx_shift\[0\]
+ _179_ VDD VSS DFF_X1
Xrx_shift\[1\]$_SDFFE_PN0P_ _020_ clknet_2_3__leaf_clk rx_shift\[1\]
+ _178_ VDD VSS DFF_X1
Xrx_shift\[2\]$_SDFFE_PN0P_ _021_ clknet_2_3__leaf_clk rx_shift\[2\]
+ _177_ VDD VSS DFF_X1
Xrx_shift\[3\]$_SDFFE_PN0P_ _022_ clknet_2_2__leaf_clk rx_shift\[3\]
+ _176_ VDD VSS DFF_X1
Xrx_shift\[4\]$_SDFFE_PN0P_ _023_ clknet_2_3__leaf_clk rx_shift\[4\]
+ _175_ VDD VSS DFF_X1
Xrx_shift\[5\]$_SDFFE_PN0P_ _024_ clknet_2_3__leaf_clk rx_shift\[5\]
+ _174_ VDD VSS DFF_X1
Xrx_shift\[6\]$_SDFFE_PN0P_ _025_ clknet_2_2__leaf_clk rx_shift\[6\]
+ _173_ VDD VSS DFF_X1
Xrx_shift\[7\]$_SDFFE_PN0P_ _026_ clknet_2_2__leaf_clk rx_shift\[7\]
+ _172_ VDD VSS DFF_X1
Xrx_valid$_SDFF_PN0_ _027_ clknet_2_3__leaf_clk net20 _171_
+ VDD VSS DFF_X1
Xspi_clk$_SDFFE_PN0P_ _028_ clknet_2_0__leaf_clk net21 _003_
+ VDD VSS DFF_X1
Xspi_cs_n$_SDFFE_PN1P_ _029_ clknet_2_3__leaf_clk net22 _170_
+ VDD VSS DFF_X1
Xspi_mosi$_SDFFE_PN0P_ _030_ clknet_2_1__leaf_clk net23 _192_
+ VDD VSS DFF_X1
Xstate\[0\]$_DFF_P_ _001_ clknet_2_1__leaf_clk state\[0\]
+ _193_ VDD VSS DFF_X1
Xstate\[1\]$_DFF_P_ _000_ clknet_2_1__leaf_clk state\[1\]
+ _194_ VDD VSS DFF_X1
Xstate\[2\]$_DFF_P_ _002_ clknet_2_0__leaf_clk state\[2\]
+ _169_ VDD VSS DFF_X1
Xtx_ready$_SDFFE_PN1P_ _031_ clknet_2_1__leaf_clk net24 _168_
+ VDD VSS DFF_X1
Xtx_shift\[0\]$_SDFFE_PN0P_ _032_ clknet_2_0__leaf_clk tx_shift\[0\]
+ _167_ VDD VSS DFF_X1
Xtx_shift\[1\]$_SDFFE_PN0P_ _033_ clknet_2_0__leaf_clk tx_shift\[1\]
+ _166_ VDD VSS DFF_X1
Xtx_shift\[2\]$_SDFFE_PN0P_ _034_ clknet_2_0__leaf_clk tx_shift\[2\]
+ _165_ VDD VSS DFF_X1
Xtx_shift\[3\]$_SDFFE_PN0P_ _035_ clknet_2_0__leaf_clk tx_shift\[3\]
+ _164_ VDD VSS DFF_X1
Xtx_shift\[4\]$_SDFFE_PN0P_ _036_ clknet_2_0__leaf_clk tx_shift\[4\]
+ _163_ VDD VSS DFF_X1
Xtx_shift\[5\]$_SDFFE_PN0P_ _037_ clknet_2_0__leaf_clk tx_shift\[5\]
+ _162_ VDD VSS DFF_X1
Xtx_shift\[6\]$_SDFFE_PN0P_ _038_ clknet_2_1__leaf_clk tx_shift\[6\]
+ _161_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_89 VDD VSS TAPCELL_X1
Xinput1 rst_n net1 VDD VSS BUF_X1
Xinput2 spi_miso net2 VDD VSS BUF_X1
Xinput3 tx_data[0] net3 VDD VSS BUF_X1
Xinput4 tx_data[1] net4 VDD VSS BUF_X1
Xinput5 tx_data[2] net5 VDD VSS BUF_X1
Xinput6 tx_data[3] net6 VDD VSS BUF_X1
Xinput7 tx_data[4] net7 VDD VSS BUF_X1
Xinput8 tx_data[5] net8 VDD VSS BUF_X1
Xinput9 tx_data[6] net9 VDD VSS BUF_X1
Xinput10 tx_data[7] net10 VDD VSS BUF_X1
Xinput11 tx_valid net11 VDD VSS CLKBUF_X2
Xoutput12 net12 rx_data[0] VDD VSS BUF_X1
Xoutput13 net13 rx_data[1] VDD VSS BUF_X1
Xoutput14 net14 rx_data[2] VDD VSS BUF_X1
Xoutput15 net15 rx_data[3] VDD VSS BUF_X1
Xoutput16 net16 rx_data[4] VDD VSS BUF_X1
Xoutput17 net17 rx_data[5] VDD VSS BUF_X1
Xoutput18 net18 rx_data[6] VDD VSS BUF_X1
Xoutput19 net19 rx_data[7] VDD VSS BUF_X1
Xoutput20 net20 rx_valid VDD VSS BUF_X1
Xoutput21 net21 spi_clk VDD VSS BUF_X1
Xoutput22 net22 spi_cs_n VDD VSS BUF_X1
Xoutput23 net23 spi_mosi VDD VSS BUF_X1
Xoutput24 net24 tx_ready VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_2_0__f_clk clknet_0_clk clknet_2_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_2_1__f_clk clknet_0_clk clknet_2_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_2_2__f_clk clknet_0_clk clknet_2_2__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_2_3__f_clk clknet_0_clk clknet_2_3__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_2_0__leaf_clk _unconnected_0 VDD VSS INV_X2
Xclkload1 clknet_2_1__leaf_clk _unconnected_1 VDD VSS INV_X4
Xclkload2 clknet_2_2__leaf_clk _unconnected_2 VDD VSS INV_X2
.ENDS parameterized_spi_master
