* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_deserializer clk enable load parallel_out[0]
+ parallel_out[1] parallel_out[2] parallel_out[3] parallel_out[4]
+ parallel_out[5] parallel_out[6] parallel_out[7] rst_n rx_busy
+ rx_done serial_in sync_detected
X_082_ net2 _046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_083_ net2 state\[1\] _047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_084_ _047_ _048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_085_ state\[0\] _049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_086_ _046_ net3 _048_ _049_ _000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_087_ bit_counter\[3\] _050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_088_ clk_div_counter\[2\] _051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_089_ bit_counter\[2\] _071_ _051_ _075_ _052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_090_ _046_ _050_ state\[2\] _052_ _053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_091_ net3 _054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_092_ _046_ _054_ _055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_093_ state\[1\] _055_ _056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_094_ _053_ _056_ _001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_095_ state\[2\] _057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_096_ _046_ _050_ _052_ _058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_097_ state\[0\] net2 _059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_098_ _057_ _058_ _059_ _054_ _002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_099_ clk_div_counter\[0\] _073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_100_ clk_div_counter\[1\] _074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_101_ net2 _051_ state\[2\] _075_ _060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_102_ _060_ _061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_103_ state\[2\] _059_ _062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_104_ bit_counter\[0\] _060_ _062_ _063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_105_ bit_counter\[0\] _061_ _063_ _003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_106_ _072_ _064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_107_ _060_ _062_ _065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_108_ bit_counter\[1\] _066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_109_ _064_ _061_ _065_ _066_ _004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_110_ _071_ _051_ _075_ _067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_111_ _046_ _067_ bit_counter\[2\] _068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_112_ state\[0\] state\[2\] _046_ _069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_113_ bit_counter\[2\] _069_ _070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_114_ _057_ _052_ _068_ _070_ _005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_115_ bit_counter\[2\] bit_counter\[0\] bit_counter\[1\]
+ _028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_116_ _060_ _028_ _062_ bit_counter\[3\] _029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_117_ bit_counter\[3\] _060_ _028_ _029_ _006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_118_ clk_div_counter\[0\] _079_ _030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_119_ clk_div_counter\[0\] _030_ _046_ _007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_120_ _046_ _076_ _031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_121_ _046_ _074_ _079_ _031_ _008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_122_ clk_div_counter\[2\] _080_ _046_ _009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_123_ shift_reg\[0\] net6 _048_ _010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_124_ shift_reg\[1\] net7 _048_ _011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_125_ shift_reg\[2\] net8 _048_ _012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_126_ shift_reg\[3\] net9 _048_ _013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_127_ shift_reg\[4\] net10 _048_ _014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_128_ shift_reg\[5\] net11 _048_ _015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_129_ shift_reg\[6\] net12 _048_ _016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_130_ shift_reg\[7\] net13 _047_ _017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_131_ net14 _032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_132_ net2 net3 _033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_133_ net3 _032_ _033_ state\[1\] _034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_134_ net14 _048_ _034_ state\[0\] _035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_135_ _035_ _018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_136_ net15 _059_ _036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_137_ _048_ _036_ _019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_138_ net5 _037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_139_ shift_reg\[0\] _038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_140_ _037_ _061_ _065_ _038_ _020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_141_ shift_reg\[1\] _039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_142_ _038_ _061_ _065_ _039_ _021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_143_ shift_reg\[2\] _040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_144_ _039_ _061_ _065_ _040_ _022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_145_ shift_reg\[3\] _041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_146_ _040_ _061_ _065_ _041_ _023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_147_ shift_reg\[4\] _042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_148_ _041_ _061_ _065_ _042_ _024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_149_ shift_reg\[5\] _043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_150_ _042_ _061_ _065_ _043_ _025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_151_ shift_reg\[6\] _044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_152_ _043_ _061_ _065_ _044_ _026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_153_ shift_reg\[7\] _045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_154_ _044_ _061_ _065_ _045_ _027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_155_ bit_counter\[0\] bit_counter\[1\] _071_ _072_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_1
X_156_ _073_ _074_ _075_ _076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_157_ clk_div_counter\[0\] clk_div_counter\[1\] _077_ _078_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_158_ clk_div_counter\[2\] _077_ _079_ _080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_160_ net16 sync_detected VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xbit_counter\[0\]$_DFFE_PN0P_ _003_ net1 clknet_1_1__leaf_clk
+ bit_counter\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_counter\[1\]$_DFFE_PN0P_ _004_ net1 clknet_1_0__leaf_clk
+ bit_counter\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_counter\[2\]$_DFFE_PN0P_ _005_ net1 clknet_1_1__leaf_clk
+ bit_counter\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_counter\[3\]$_DFFE_PN0P_ _006_ net1 clknet_1_1__leaf_clk
+ bit_counter\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_div_counter\[0\]$_DFFE_PN0P_ _007_ net1 clknet_1_0__leaf_clk
+ clk_div_counter\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_div_counter\[1\]$_DFFE_PN0P_ _008_ net1 clknet_1_0__leaf_clk
+ clk_div_counter\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_div_counter\[2\]$_DFFE_PN0P_ _009_ net1 clknet_1_0__leaf_clk
+ clk_div_counter\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[0\]$_DFFE_PN0P_ _010_ net1 clknet_1_0__leaf_clk
+ net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[1\]$_DFFE_PN0P_ _011_ net1 clknet_1_0__leaf_clk
+ net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[2\]$_DFFE_PN0P_ _012_ net1 clknet_1_0__leaf_clk
+ net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[3\]$_DFFE_PN0P_ _013_ net1 clknet_1_0__leaf_clk
+ net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[4\]$_DFFE_PN0P_ _014_ net1 clknet_1_1__leaf_clk
+ net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[5\]$_DFFE_PN0P_ _015_ net1 clknet_1_1__leaf_clk
+ net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[6\]$_DFFE_PN0P_ _016_ net1 clknet_1_1__leaf_clk
+ net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xparallel_out\[7\]$_DFFE_PN0P_ _017_ net1 clknet_1_1__leaf_clk
+ net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_busy$_DFFE_PN0P_ _018_ net1 clknet_1_1__leaf_clk net14
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrx_done$_DFFE_PN0P_ _019_ net1 clknet_1_1__leaf_clk net15
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xshift_reg\[0\]$_DFFE_PN0P_ _020_ net1 clknet_1_0__leaf_clk
+ shift_reg\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xshift_reg\[1\]$_DFFE_PN0P_ _021_ net1 clknet_1_0__leaf_clk
+ shift_reg\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xshift_reg\[2\]$_DFFE_PN0P_ _022_ net1 clknet_1_0__leaf_clk
+ shift_reg\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xshift_reg\[3\]$_DFFE_PN0P_ _023_ net1 clknet_1_0__leaf_clk
+ shift_reg\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xshift_reg\[4\]$_DFFE_PN0P_ _024_ net1 clknet_1_1__leaf_clk
+ shift_reg\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xshift_reg\[5\]$_DFFE_PN0P_ _025_ net1 clknet_1_1__leaf_clk
+ shift_reg\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xshift_reg\[6\]$_DFFE_PN0P_ _026_ net1 clknet_1_1__leaf_clk
+ shift_reg\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xshift_reg\[7\]$_DFFE_PN0P_ _027_ net1 clknet_1_1__leaf_clk
+ shift_reg\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xstate\[0\]$_DFF_PN1_ _000_ net4 clknet_1_1__leaf_clk state\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xstate\[1\]$_DFF_PN0_ _001_ net1 clknet_1_1__leaf_clk state\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xstate\[2\]$_DFF_PN0_ _002_ net1 clknet_1_1__leaf_clk state\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xhold1 net4 net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 enable net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xinput2 net18 net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput3 net17 net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xinput4 serial_in net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput5 net6 parallel_out[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput6 net7 parallel_out[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput7 net8 parallel_out[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput8 net9 parallel_out[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput9 net10 parallel_out[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput10 net11 parallel_out[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput11 net12 parallel_out[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput12 net13 parallel_out[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput13 net14 rx_busy VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput14 net15 rx_done VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_160__15 net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkload0 clknet_1_0__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xhold2 rst_n net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
Xhold3 load net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS parameterized_deserializer
