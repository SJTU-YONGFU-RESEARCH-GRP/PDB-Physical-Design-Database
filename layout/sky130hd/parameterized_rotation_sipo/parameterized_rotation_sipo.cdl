* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_rotation_sipo clk enable load parallel_out[0]
+ parallel_out[1] parallel_out[2] parallel_out[3] parallel_out[4]
+ parallel_out[5] parallel_out[6] parallel_out[7] rst_n serial_in
+ VSS VDD
X_02_ net9 net4 VSS VSS VDD VDD _00_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput8 net9 VSS VSS VDD VDD parallel_out[3] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput7 net9 VSS VSS VDD VDD parallel_out[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput6 rst_n VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput5 load VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkdlybuf4s50_1
Xparallel_out\[1\]$_DFFE_PN0P_ clk _00_ net5 VSS VSS VDD VDD
+ net9 sky130_fd_sc_hd__dfrtp_1
X_04__1 VSS VSS VDD VDD _unconnected_0 parallel_out[0] sky130_fd_sc_hd__conb_1
X_06__2 VSS VSS VDD VDD _unconnected_1 parallel_out[2] sky130_fd_sc_hd__conb_1
X_09__3 VSS VSS VDD VDD _unconnected_2 parallel_out[5] sky130_fd_sc_hd__conb_1
X_10__4 VSS VSS VDD VDD _unconnected_3 parallel_out[7] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput9 net9 VSS VSS VDD VDD parallel_out[4] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput10 net9 VSS VSS VDD VDD parallel_out[6] sky130_fd_sc_hd__clkdlybuf4s50_1
.ENDS parameterized_rotation_sipo
