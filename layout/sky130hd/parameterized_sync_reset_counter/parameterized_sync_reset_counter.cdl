* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_sync_reset_counter clk count[0] count[1]
+ count[2] count[3] count[4] count[5] count[6] count[7] enable
+ sync_rst tc
X_34_ sync_rst VSS VSS VDD VDD _08_ sky130_fd_sc_hd__clkbuf_2
X_35_ enable VSS VSS VDD VDD _09_ sky130_fd_sc_hd__buf_4
X_36_ _09_ net1 VSS VSS VDD VDD _10_ sky130_fd_sc_hd__nand2b_1
X_37_ net4 net6 net5 net7 VSS VSS VDD VDD _11_ sky130_fd_sc_hd__and4_1
X_38_ net3 _32_ net8 _11_ VSS VSS VDD VDD net9 sky130_fd_sc_hd__and4_1
X_39_ net1 _08_ _09_ VSS VSS VDD VDD _12_ sky130_fd_sc_hd__or3b_1
X_40_ _08_ _10_ net9 _12_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__o22ai_1
X_41_ net2 _33_ _09_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__mux2i_1
X_42_ _08_ _13_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__nor2_1
X_43_ _32_ _09_ VSS VSS VDD VDD _14_ sky130_fd_sc_hd__nand2_1
X_44_ net3 _14_ VSS VSS VDD VDD _15_ sky130_fd_sc_hd__xor2_1
X_45_ _08_ _15_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__nor2_1
X_46_ net3 _32_ _09_ VSS VSS VDD VDD _16_ sky130_fd_sc_hd__and3_1
X_47_ net8 _11_ _16_ _08_ VSS VSS VDD VDD _17_ sky130_fd_sc_hd__a31o_1
X_48_ net3 net1 net2 _09_ VSS VSS VDD VDD _18_ sky130_fd_sc_hd__and4_1
X_49_ net4 _18_ VSS VSS VDD VDD _19_ sky130_fd_sc_hd__xnor2_1
X_50_ _17_ _19_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__nor2_1
X_51_ net4 net3 _32_ _09_ VSS VSS VDD VDD _20_ sky130_fd_sc_hd__nand4_1
X_52_ net5 _20_ VSS VSS VDD VDD _21_ sky130_fd_sc_hd__xor2_1
X_53_ _08_ _21_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__nor2_1
X_54_ net4 net5 VSS VSS VDD VDD _22_ sky130_fd_sc_hd__nand2_1
X_55_ net3 net1 net2 _09_ VSS VSS VDD VDD _23_ sky130_fd_sc_hd__nand4_1
X_56_ _22_ _23_ net6 VSS VSS VDD VDD _24_ sky130_fd_sc_hd__o21ai_0
X_57_ net6 _22_ _23_ VSS VSS VDD VDD _25_ sky130_fd_sc_hd__or3_1
X_58_ _24_ _25_ _17_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__a21oi_1
X_59_ net4 net6 net5 VSS VSS VDD VDD _26_ sky130_fd_sc_hd__nand3_1
X_60_ net3 _32_ _09_ VSS VSS VDD VDD _27_ sky130_fd_sc_hd__nand3_1
X_61_ _26_ _27_ net7 VSS VSS VDD VDD _28_ sky130_fd_sc_hd__o21ai_0
X_62_ net7 _26_ _27_ VSS VSS VDD VDD _29_ sky130_fd_sc_hd__or3_1
X_63_ _28_ _29_ _08_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__a21oi_1
X_64_ _27_ _23_ VSS VSS VDD VDD _30_ sky130_fd_sc_hd__nand2_1
X_65_ _11_ _18_ net8 VSS VSS VDD VDD _31_ sky130_fd_sc_hd__a21oi_1
X_66_ net8 _11_ _30_ _31_ _08_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__a311oi_1
X_67_ net1 net2 VSS VSS VDD VDD _32_ _33_ sky130_fd_sc_hd__ha_1
Xcounter_reg\[0\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _00_ VSS
+ VSS VDD VDD net1 sky130_fd_sc_hd__dfxtp_1
Xcounter_reg\[1\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _01_ VSS
+ VSS VDD VDD net2 sky130_fd_sc_hd__dfxtp_1
Xcounter_reg\[2\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _02_ VSS
+ VSS VDD VDD net3 sky130_fd_sc_hd__dfxtp_2
Xcounter_reg\[3\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _03_ VSS
+ VSS VDD VDD net4 sky130_fd_sc_hd__dfxtp_1
Xcounter_reg\[4\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _04_ VSS
+ VSS VDD VDD net5 sky130_fd_sc_hd__dfxtp_1
Xcounter_reg\[5\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _05_ VSS
+ VSS VDD VDD net6 sky130_fd_sc_hd__dfxtp_1
Xcounter_reg\[6\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _06_ VSS
+ VSS VDD VDD net7 sky130_fd_sc_hd__dfxtp_1
Xcounter_reg\[7\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _07_ VSS
+ VSS VDD VDD net8 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput1 net1 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput2 net2 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput3 net3 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net4 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net5 VSS VSS VDD VDD count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net6 VSS VSS VDD VDD count[5] sky130_fd_sc_hd__clkbuf_1
Xoutput7 net7 VSS VSS VDD VDD count[6] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net8 VSS VSS VDD VDD count[7] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net9 VSS VSS VDD VDD tc sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
.ENDS parameterized_sync_reset_counter
