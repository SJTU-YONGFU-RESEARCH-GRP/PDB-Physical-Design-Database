* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_crc_generator clk crc_init crc_out[0]
+ crc_out[1] crc_out[2] crc_out[3] crc_out[4] crc_out[5] crc_out[6]
+ crc_out[7] data_in[0] data_in[1] data_in[2] data_in[3] data_in[4]
+ data_in[5] data_in[6] data_in[7] data_valid rst_n
X_47_ net11 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_2
X_48_ net9 crc_reflected\[6\] VSS VSS VDD VDD _09_ sky130_fd_sc_hd__xnor2_4
X_49_ crc_reflected\[0\] net3 VSS VSS VDD VDD _10_ sky130_fd_sc_hd__xnor2_1
X_50_ _09_ _10_ VSS VSS VDD VDD _11_ sky130_fd_sc_hd__xnor2_1
X_51_ net10 crc_reflected\[7\] VSS VSS VDD VDD _12_ sky130_fd_sc_hd__xnor2_1
X_52_ _11_ _12_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__xnor2_1
X_53_ _08_ crc_reflected\[0\] VSS VSS VDD VDD _14_ sky130_fd_sc_hd__nor2_1
X_54_ net2 VSS VSS VDD VDD _15_ sky130_fd_sc_hd__buf_2
X_55_ _08_ _13_ _14_ _15_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__a211oi_1
X_56_ _15_ crc_reflected\[1\] VSS VSS VDD VDD _16_ sky130_fd_sc_hd__nor2b_1
X_57_ _15_ crc_reflected\[1\] VSS VSS VDD VDD _17_ sky130_fd_sc_hd__nor2_1
X_58_ net11 VSS VSS VDD VDD _18_ sky130_fd_sc_hd__inv_1
X_59_ net4 _09_ _10_ VSS VSS VDD VDD _19_ sky130_fd_sc_hd__xnor3_1
X_60_ _18_ _19_ VSS VSS VDD VDD _20_ sky130_fd_sc_hd__nor2_1
X_61_ _16_ _17_ _20_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__mux2_1
X_62_ net5 crc_reflected\[2\] VSS VSS VDD VDD _21_ sky130_fd_sc_hd__xor2_2
X_63_ crc_reflected\[1\] net4 VSS VSS VDD VDD _22_ sky130_fd_sc_hd__xnor2_1
X_64_ _21_ _22_ VSS VSS VDD VDD _23_ sky130_fd_sc_hd__xor2_1
X_65_ _11_ _23_ VSS VSS VDD VDD _24_ sky130_fd_sc_hd__xnor2_1
X_66_ _08_ crc_reflected\[2\] VSS VSS VDD VDD _25_ sky130_fd_sc_hd__nor2_1
X_67_ _08_ _24_ _25_ _15_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__a211oi_1
X_68_ net10 crc_reflected\[7\] net6 VSS VSS VDD VDD _26_ sky130_fd_sc_hd__xor3_1
X_69_ _21_ _22_ _26_ VSS VSS VDD VDD _27_ sky130_fd_sc_hd__xnor3_1
X_70_ _15_ crc_reflected\[3\] VSS VSS VDD VDD _28_ sky130_fd_sc_hd__nor2_1
X_71_ _15_ crc_reflected\[3\] VSS VSS VDD VDD _29_ sky130_fd_sc_hd__nand2b_1
X_72_ net11 _27_ _29_ VSS VSS VDD VDD _30_ sky130_fd_sc_hd__a21oi_1
X_73_ _08_ _27_ _28_ _30_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__a31o_1
X_74_ net7 crc_reflected\[4\] VSS VSS VDD VDD _31_ sky130_fd_sc_hd__xor2_2
X_75_ net6 crc_reflected\[3\] VSS VSS VDD VDD _32_ sky130_fd_sc_hd__xnor2_1
X_76_ _31_ _32_ VSS VSS VDD VDD _33_ sky130_fd_sc_hd__xnor2_1
X_77_ _21_ _33_ VSS VSS VDD VDD _34_ sky130_fd_sc_hd__xnor2_1
X_78_ _08_ crc_reflected\[4\] VSS VSS VDD VDD _35_ sky130_fd_sc_hd__nor2_1
X_79_ _08_ _34_ _35_ _15_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__a211oi_1
X_80_ net8 _31_ _32_ VSS VSS VDD VDD _36_ sky130_fd_sc_hd__xor3_1
X_81_ _18_ _36_ crc_reflected\[5\] VSS VSS VDD VDD _37_ sky130_fd_sc_hd__o21ai_0
X_82_ _18_ crc_reflected\[5\] _36_ VSS VSS VDD VDD _38_ sky130_fd_sc_hd__or3_1
X_83_ _37_ _38_ _15_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__a21oi_1
X_84_ net8 crc_reflected\[5\] VSS VSS VDD VDD _39_ sky130_fd_sc_hd__xnor2_1
X_85_ _09_ _39_ VSS VSS VDD VDD _40_ sky130_fd_sc_hd__xor2_1
X_86_ _31_ _40_ VSS VSS VDD VDD _41_ sky130_fd_sc_hd__xnor2_1
X_87_ _08_ crc_reflected\[6\] VSS VSS VDD VDD _42_ sky130_fd_sc_hd__nor2_1
X_88_ _08_ _41_ _42_ _15_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__a211oi_1
X_89_ net10 _09_ _39_ VSS VSS VDD VDD _43_ sky130_fd_sc_hd__xor3_1
X_90_ _15_ crc_reflected\[7\] VSS VSS VDD VDD _44_ sky130_fd_sc_hd__nor2_1
X_91_ net2 crc_reflected\[7\] VSS VSS VDD VDD _45_ sky130_fd_sc_hd__nand2b_1
X_92_ net11 _43_ _45_ VSS VSS VDD VDD _46_ sky130_fd_sc_hd__a21oi_1
X_93_ _08_ _43_ _44_ _46_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__a31o_1
Xcrc_out\[0\]$_DFF_PN0_ clknet_1_1__leaf_clk crc_reflected\[0\]
+ net1 VSS VSS VDD VDD net12 sky130_fd_sc_hd__dfrtp_1
Xcrc_out\[1\]$_DFF_PN0_ clknet_1_0__leaf_clk crc_reflected\[1\]
+ net1 VSS VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xcrc_out\[2\]$_DFF_PN0_ clknet_1_1__leaf_clk crc_reflected\[2\]
+ net1 VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xcrc_out\[3\]$_DFF_PN0_ clknet_1_0__leaf_clk crc_reflected\[3\]
+ net1 VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xcrc_out\[4\]$_DFF_PN0_ clknet_1_1__leaf_clk crc_reflected\[4\]
+ net1 VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xcrc_out\[5\]$_DFF_PN0_ clknet_1_0__leaf_clk crc_reflected\[5\]
+ net1 VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xcrc_out\[6\]$_DFF_PN0_ clknet_1_1__leaf_clk crc_reflected\[6\]
+ net1 VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xcrc_out\[7\]$_DFF_PN0_ clknet_1_1__leaf_clk crc_reflected\[7\]
+ net1 VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_1
Xcrc_reg\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _00_ net1 VSS
+ VSS VDD VDD crc_reflected\[0\] sky130_fd_sc_hd__dfrtp_1
Xcrc_reg\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1 VSS
+ VSS VDD VDD crc_reflected\[1\] sky130_fd_sc_hd__dfrtp_1
Xcrc_reg\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _02_ net1 VSS
+ VSS VDD VDD crc_reflected\[2\] sky130_fd_sc_hd__dfrtp_1
Xcrc_reg\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _03_ net1 VSS
+ VSS VDD VDD crc_reflected\[3\] sky130_fd_sc_hd__dfrtp_1
Xcrc_reg\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _04_ net1 VSS
+ VSS VDD VDD crc_reflected\[4\] sky130_fd_sc_hd__dfrtp_1
Xcrc_reg\[5\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _05_ net1 VSS
+ VSS VDD VDD crc_reflected\[5\] sky130_fd_sc_hd__dfrtp_1
Xcrc_reg\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _06_ net1 VSS
+ VSS VDD VDD crc_reflected\[6\] sky130_fd_sc_hd__dfrtp_2
Xcrc_reg\[7\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _07_ net1 VSS
+ VSS VDD VDD crc_reflected\[7\] sky130_fd_sc_hd__dfrtp_2
Xhold1 net20 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 crc_init VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 data_in[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 data_in[1] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 data_in[2] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 data_in[3] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 data_in[4] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 data_in[5] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 data_in[6] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_2
Xinput9 data_in[7] VSS VSS VDD VDD net10 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput10 data_valid VSS VSS VDD VDD net11 sky130_fd_sc_hd__dlymetal6s2s_1
Xoutput11 net12 VSS VSS VDD VDD crc_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD crc_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD crc_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD crc_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD crc_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD crc_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD crc_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD crc_out[7] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_8
Xhold2 rst_n VSS VSS VDD VDD net20 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_crc_generator
