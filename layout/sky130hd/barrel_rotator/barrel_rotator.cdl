* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT barrel_rotator data_in[0] data_in[1] data_in[2] data_in[3]
+ data_in[4] data_in[5] data_in[6] data_in[7] data_out[0] data_out[1]
+ data_out[2] data_out[3] data_out[4] data_out[5] data_out[6]
+ data_out[7] direction rotate_amount[0] rotate_amount[1] rotate_amount[2]
X_119_ net8 VSS VSS VDD VDD _044_ sky130_fd_sc_hd__buf_2
X_120_ _044_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__inv_2
X_121_ data_in[1] VSS VSS VDD VDD _046_ sky130_fd_sc_hd__clkbuf_4
X_122_ rotate_amount[2] VSS VSS VDD VDD _047_ sky130_fd_sc_hd__buf_6
X_123_ net4 _046_ _047_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__mux2i_4
X_124_ net5 net2 _047_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__mux2i_4
X_125_ rotate_amount[0] VSS VSS VDD VDD _050_ sky130_fd_sc_hd__buf_6
X_126_ _050_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__inv_2
X_127_ _048_ _049_ _051_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__mux2_1
X_128_ net6 net3 _047_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__mux2i_4
X_129_ net8 _051_ _053_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__or3_1
X_130_ _047_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__buf_6
X_131_ _055_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__buf_2
X_132_ data_in[4] VSS VSS VDD VDD _057_ sky130_fd_sc_hd__clkbuf_4
X_133_ _050_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__buf_6
X_134_ _044_ _058_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__nor2_2
X_135_ net7 VSS VSS VDD VDD _060_ sky130_fd_sc_hd__inv_2
X_136_ _056_ _057_ _059_ _060_ VSS VSS VDD VDD _061_ sky130_fd_sc_hd__a31oi_1
X_137_ _045_ _052_ _054_ _061_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__o211a_1
X_138_ _044_ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__buf_2
X_139_ _050_ VSS VSS VDD VDD _064_ sky130_fd_sc_hd__buf_6
X_140_ net5 net6 _064_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__mux2i_1
X_141_ _056_ _065_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nand2_1
X_142_ _064_ net2 VSS VSS VDD VDD _067_ sky130_fd_sc_hd__nor2_1
X_143_ net3 VSS VSS VDD VDD _068_ sky130_fd_sc_hd__clkbuf_4
X_144_ _068_ _058_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__nor2b_1
X_145_ _056_ VSS VSS VDD VDD _070_ sky130_fd_sc_hd__inv_1
X_146_ _067_ _069_ _070_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__o21ai_0
X_147_ _064_ VSS VSS VDD VDD _072_ sky130_fd_sc_hd__buf_2
X_148_ _055_ VSS VSS VDD VDD _073_ sky130_fd_sc_hd__buf_6
X_149_ _046_ net4 _073_ VSS VSS VDD VDD _074_ sky130_fd_sc_hd__mux2i_2
X_150_ _072_ _060_ _074_ VSS VSS VDD VDD _075_ sky130_fd_sc_hd__nand3_1
X_151_ net7 VSS VSS VDD VDD _076_ sky130_fd_sc_hd__clkbuf_4
X_152_ _044_ _056_ _057_ _076_ VSS VSS VDD VDD _077_ sky130_fd_sc_hd__o22ai_1
X_153_ _063_ _060_ _077_ _051_ VSS VSS VDD VDD _078_ sky130_fd_sc_hd__a22oi_1
X_154_ _063_ _066_ _071_ _075_ _078_ VSS VSS VDD VDD _079_
+ sky130_fd_sc_hd__a32oi_1
X_155_ _070_ _059_ VSS VSS VDD VDD _080_ sky130_fd_sc_hd__nand2_2
X_156_ net1 VSS VSS VDD VDD _081_ sky130_fd_sc_hd__inv_1
X_157_ _062_ _079_ _080_ _081_ VSS VSS VDD VDD net9 sky130_fd_sc_hd__o22ai_1
X_158_ _068_ VSS VSS VDD VDD _082_ sky130_fd_sc_hd__inv_1
X_159_ _056_ net6 _072_ VSS VSS VDD VDD _083_ sky130_fd_sc_hd__a21oi_1
X_160_ _056_ _082_ _083_ VSS VSS VDD VDD _084_ sky130_fd_sc_hd__o21ai_0
X_161_ _057_ net1 _055_ VSS VSS VDD VDD _085_ sky130_fd_sc_hd__mux2i_2
X_162_ _072_ _085_ VSS VSS VDD VDD _086_ sky130_fd_sc_hd__nand2_1
X_163_ net8 _058_ VSS VSS VDD VDD _087_ sky130_fd_sc_hd__or2_1
X_164_ net4 _055_ VSS VSS VDD VDD _088_ sky130_fd_sc_hd__nor2b_1
X_165_ net2 net5 _056_ VSS VSS VDD VDD _089_ sky130_fd_sc_hd__mux2i_1
X_166_ net8 _064_ VSS VSS VDD VDD _090_ sky130_fd_sc_hd__nand2b_1
X_167_ _087_ _088_ _089_ _090_ _060_ VSS VSS VDD VDD _091_
+ sky130_fd_sc_hd__o221ai_1
X_168_ _063_ _084_ _086_ _091_ VSS VSS VDD VDD _092_ sky130_fd_sc_hd__a31oi_1
X_169_ net1 _057_ _047_ VSS VSS VDD VDD _093_ sky130_fd_sc_hd__mux2i_4
X_170_ _049_ _053_ _093_ _088_ _051_ _045_ VSS VSS VDD VDD
+ _094_ sky130_fd_sc_hd__mux4_1
X_171_ _076_ _094_ _080_ _046_ VSS VSS VDD VDD _095_ sky130_fd_sc_hd__o2bb2ai_1
X_172_ _092_ _095_ VSS VSS VDD VDD net10 sky130_fd_sc_hd__nor2_1
X_173_ _058_ _048_ VSS VSS VDD VDD _096_ sky130_fd_sc_hd__nand2_1
X_174_ _051_ _085_ VSS VSS VDD VDD _097_ sky130_fd_sc_hd__nand2_1
X_175_ _055_ _068_ _064_ VSS VSS VDD VDD _098_ sky130_fd_sc_hd__nor3b_1
X_176_ _073_ _065_ _098_ _044_ VSS VSS VDD VDD _099_ sky130_fd_sc_hd__a211oi_1
X_177_ _063_ _096_ _097_ _099_ _076_ VSS VSS VDD VDD _100_
+ sky130_fd_sc_hd__a311o_1
X_178_ _072_ _053_ VSS VSS VDD VDD _101_ sky130_fd_sc_hd__nand2_1
X_179_ _051_ _093_ _045_ VSS VSS VDD VDD _102_ sky130_fd_sc_hd__a21oi_1
X_180_ net5 net4 _064_ VSS VSS VDD VDD _103_ sky130_fd_sc_hd__mux2i_1
X_181_ _055_ _046_ _064_ VSS VSS VDD VDD _104_ sky130_fd_sc_hd__nor3b_1
X_182_ _073_ _103_ _104_ _044_ VSS VSS VDD VDD _105_ sky130_fd_sc_hd__a211oi_1
X_183_ _101_ _102_ _105_ _060_ VSS VSS VDD VDD _106_ sky130_fd_sc_hd__a211o_1
X_184_ net2 _080_ _100_ _106_ VSS VSS VDD VDD net11 sky130_fd_sc_hd__o211a_1
X_185_ _072_ _049_ VSS VSS VDD VDD _107_ sky130_fd_sc_hd__nand2_1
X_186_ _051_ _048_ VSS VSS VDD VDD _108_ sky130_fd_sc_hd__nand2_1
X_187_ _063_ _083_ VSS VSS VDD VDD _109_ sky130_fd_sc_hd__nor2_1
X_188_ _063_ _107_ _108_ _086_ _109_ VSS VSS VDD VDD _110_
+ sky130_fd_sc_hd__a32oi_1
X_189_ _056_ _087_ VSS VSS VDD VDD _111_ sky130_fd_sc_hd__nor2_1
X_190_ _068_ _111_ _076_ VSS VSS VDD VDD _112_ sky130_fd_sc_hd__a21oi_1
X_191_ _068_ _111_ _060_ VSS VSS VDD VDD _113_ sky130_fd_sc_hd__a21oi_1
X_192_ _074_ _093_ _072_ VSS VSS VDD VDD _114_ sky130_fd_sc_hd__mux2i_1
X_193_ net6 net5 _058_ VSS VSS VDD VDD _115_ sky130_fd_sc_hd__mux2i_1
X_194_ _056_ _072_ net2 VSS VSS VDD VDD _116_ sky130_fd_sc_hd__nand3b_1
X_195_ _070_ _115_ _116_ _045_ VSS VSS VDD VDD _117_ sky130_fd_sc_hd__o211ai_1
X_196_ _045_ _114_ _117_ VSS VSS VDD VDD _118_ sky130_fd_sc_hd__o21ai_1
X_197_ _110_ _112_ _113_ _118_ VSS VSS VDD VDD net12 sky130_fd_sc_hd__a22oi_2
X_198_ _070_ net1 _059_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__o21ai_0
X_199_ _072_ _049_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__nor2_1
X_200_ _051_ _053_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__nor2_1
X_201_ _051_ _048_ _045_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__o21ai_0
X_202_ _045_ _001_ _002_ _003_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__o31ai_1
X_203_ net2 net8 VSS VSS VDD VDD _005_ sky130_fd_sc_hd__nor2b_1
X_204_ _044_ _058_ _046_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__nand3_1
X_205_ _058_ _005_ _006_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__o21ai_0
X_206_ _072_ _068_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__nand2_1
X_207_ net1 net6 _058_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__mux2i_1
X_208_ _008_ _009_ _073_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__mux2i_1
X_209_ _044_ _073_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__nand2_1
X_210_ _103_ _011_ _076_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__o21ai_1
X_211_ _070_ _007_ _010_ _045_ _012_ VSS VSS VDD VDD _013_
+ sky130_fd_sc_hd__a221oi_2
X_212_ _057_ _080_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__nor2_1
X_213_ _060_ _000_ _004_ _013_ _014_ VSS VSS VDD VDD net13
+ sky130_fd_sc_hd__a311oi_2
X_214_ _055_ _064_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__nor2b_1
X_215_ _046_ net1 _050_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__mux2_1
X_216_ _057_ _015_ _016_ _073_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__a22oi_1
X_217_ net8 net2 VSS VSS VDD VDD _018_ sky130_fd_sc_hd__nand2_1
X_218_ _064_ _068_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__nor2_1
X_219_ _058_ _018_ _019_ net8 _073_ VSS VSS VDD VDD _020_
+ sky130_fd_sc_hd__a221o_1
X_220_ _115_ _011_ _017_ _044_ _020_ VSS VSS VDD VDD _021_
+ sky130_fd_sc_hd__o221a_1
X_221_ _072_ _093_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__nand2_1
X_222_ _051_ _053_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__nand2_1
X_223_ _046_ _055_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__nor2b_1
X_224_ _049_ _090_ _024_ _087_ _060_ VSS VSS VDD VDD _025_
+ sky130_fd_sc_hd__o221ai_1
X_225_ _063_ _022_ _023_ _025_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__a31oi_1
X_226_ net4 _080_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nor2_1
X_227_ _076_ _021_ _026_ _027_ VSS VSS VDD VDD net14 sky130_fd_sc_hd__a211oi_2
X_228_ _076_ _048_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__nand2_1
X_229_ _060_ _053_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__nand2_1
X_230_ _028_ _029_ _090_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__a21oi_1
X_231_ _073_ _067_ _044_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__a21oi_1
X_232_ _057_ _068_ net1 net6 _050_ _055_ VSS VSS VDD VDD _032_
+ sky130_fd_sc_hd__mux4_1
X_233_ _096_ _031_ _032_ _060_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__a211oi_1
X_234_ net1 _046_ _057_ net4 _050_ _055_ VSS VSS VDD VDD _034_
+ sky130_fd_sc_hd__mux4_1
X_235_ _101_ _031_ _034_ _076_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__a211oi_1
X_236_ _059_ _049_ _030_ _033_ _035_ VSS VSS VDD VDD net15
+ sky130_fd_sc_hd__a2111oi_2
X_237_ net6 _080_ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nor2_1
X_238_ _068_ _073_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nor2b_1
X_239_ _049_ _090_ _037_ _087_ _076_ VSS VSS VDD VDD _038_
+ sky130_fd_sc_hd__o221ai_1
X_240_ _063_ _086_ _108_ _038_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__a31oi_1
X_241_ _046_ net2 net4 net5 _064_ _073_ VSS VSS VDD VDD _040_
+ sky130_fd_sc_hd__mux4_1
X_242_ _068_ _057_ _058_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__mux2i_1
X_243_ _081_ _015_ _041_ _056_ _063_ VSS VSS VDD VDD _042_
+ sky130_fd_sc_hd__a221oi_1
X_244_ _063_ _040_ _042_ _076_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__a211oi_1
X_245_ _036_ _039_ _043_ VSS VSS VDD VDD net16 sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_2
Xinput2 data_in[2] VSS VSS VDD VDD net2 sky130_fd_sc_hd__buf_2
Xinput3 data_in[3] VSS VSS VDD VDD net3 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput4 data_in[5] VSS VSS VDD VDD net4 sky130_fd_sc_hd__buf_2
Xinput5 data_in[6] VSS VSS VDD VDD net5 sky130_fd_sc_hd__buf_2
Xinput6 data_in[7] VSS VSS VDD VDD net6 sky130_fd_sc_hd__buf_2
Xinput7 direction VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput8 rotate_amount[1] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_2
Xoutput9 net9 VSS VSS VDD VDD data_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net10 VSS VSS VDD VDD data_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net11 VSS VSS VDD VDD data_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net12 VSS VSS VDD VDD data_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net13 VSS VSS VDD VDD data_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net14 VSS VSS VDD VDD data_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net15 VSS VSS VDD VDD data_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net16 VSS VSS VDD VDD data_out[7] sky130_fd_sc_hd__clkbuf_1
.ENDS barrel_rotator
