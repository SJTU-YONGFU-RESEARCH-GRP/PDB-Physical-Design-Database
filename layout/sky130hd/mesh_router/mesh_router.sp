* cell mesh_router
* pin east_in_data[27]
* pin north_in_data[6]
* pin west_in_data[8]
* pin east_in_data[8]
* pin north_in_data[8]
* pin south_in_data[8]
* pin north_out_data[5]
* pin north_out_data[7]
* pin east_in_data[9]
* pin south_in_data[9]
* pin north_in_data[9]
* pin west_in_data[9]
* pin local_out_data[8]
* pin east_out_data[8]
* pin south_in_data[25]
* pin east_in_data[25]
* pin south_out_data[8]
* pin north_out_data[8]
* pin north_in_data[26]
* pin east_in_data[29]
* pin north_out_data[9]
* pin local_out_data[9]
* pin north_in_data[25]
* pin south_out_data[9]
* pin west_out_data[9]
* pin north_in_data[29]
* pin east_in_data[28]
* pin east_out_data[9]
* pin east_in_data[24]
* pin east_in_data[31]
* pin east_in_data[26]
* pin north_in_data[24]
* pin east_in_data[30]
* pin north_in_data[28]
* pin north_in_data[30]
* pin south_in_data[28]
* pin local_out_data[26]
* pin south_in_data[30]
* pin local_out_valid
* pin south_in_data[29]
* pin south_in_data[31]
* pin north_in_ready
* pin east_out_valid
* pin south_in_data[26]
* pin north_in_valid
* pin south_in_data[24]
* pin south_in_data[27]
* pin south_in_ready
* pin south_in_valid
* pin west_in_data[31]
* pin west_in_data[30]
* pin north_out_data[31]
* pin north_out_data[29]
* pin north_out_data[28]
* pin local_out_data[30]
* pin local_out_data[31]
* pin west_in_data[29]
* pin north_in_data[27]
* pin north_in_data[31]
* pin east_out_data[26]
* pin north_out_data[30]
* pin west_in_data[28]
* pin east_in_data[5]
* pin east_in_data[7]
* pin south_in_data[5]
* pin west_in_valid
* pin west_in_data[5]
* pin east_in_data[4]
* pin local_out_data[24]
* pin west_in_ready
* pin local_out_data[29]
* pin south_in_data[7]
* pin east_in_data[6]
* pin local_in_data[29]
* pin local_in_data[31]
* pin south_out_valid
* pin local_in_data[5]
* pin east_in_valid
* pin west_out_valid
* pin north_in_data[7]
* pin local_in_data[30]
* pin local_in_data[7]
* pin south_out_data[7]
* pin local_out_data[28]
* pin local_in_data[28]
* pin rst_n
* pin west_in_data[7]
* pin local_out_data[5]
* pin north_out_ready
* pin local_in_valid
* pin local_out_data[7]
* pin local_out_ready
* pin west_in_data[24]
* pin west_in_data[6]
* pin west_in_data[27]
* pin local_out_data[6]
* pin east_out_data[7]
* pin local_in_data[6]
* pin west_in_data[26]
* pin north_in_data[5]
* pin north_out_valid
* pin local_in_ready
* pin west_out_ready
* pin east_out_data[0]
* pin north_out_data[6]
* pin east_out_data[6]
* pin south_in_data[6]
* pin west_out_data[6]
* pin east_out_ready
* pin south_out_ready
* pin south_out_data[6]
* pin local_in_data[4]
* pin west_out_data[7]
* pin south_in_data[0]
* pin west_out_data[8]
* pin west_in_data[4]
* pin local_in_data[8]
* pin local_in_data[9]
* pin north_out_data[4]
* pin south_out_data[5]
* pin local_in_data[26]
* pin south_out_data[4]
* pin east_in_ready
* pin north_in_data[4]
* pin west_out_data[5]
* pin east_out_data[5]
* pin local_out_data[4]
* pin south_in_data[3]
* pin south_in_data[4]
* pin local_in_data[27]
* pin east_out_data[4]
* pin west_out_data[25]
* pin east_out_data[25]
* pin local_in_data[25]
* pin west_out_data[4]
* pin local_in_data[0]
* pin north_in_data[3]
* pin east_out_data[24]
* pin west_in_data[3]
* pin west_out_data[26]
* pin west_out_data[24]
* pin south_out_data[27]
* pin south_out_data[3]
* pin north_out_data[3]
* pin south_out_data[26]
* pin west_in_data[25]
* pin local_in_data[24]
* pin local_out_data[3]
* pin local_out_data[27]
* pin west_out_data[3]
* pin west_out_data[27]
* pin south_out_data[24]
* pin east_out_data[3]
* pin north_out_data[27]
* pin clk
* pin east_out_data[27]
* pin local_out_data[0]
* pin west_in_data[2]
* pin north_out_data[2]
* pin north_out_data[0]
* pin west_out_data[0]
* pin north_out_data[25]
* pin local_in_data[2]
* pin south_out_data[0]
* pin west_in_data[0]
* pin east_out_data[2]
* pin south_out_data[2]
* pin west_out_data[13]
* pin west_in_data[13]
* pin west_out_data[2]
* pin south_in_data[2]
* pin local_in_data[13]
* pin local_out_data[13]
* pin east_in_data[2]
* pin north_out_data[13]
* pin north_in_data[2]
* pin local_out_data[2]
* pin west_out_data[23]
* pin south_out_data[13]
* pin east_in_data[23]
* pin east_out_data[13]
* pin south_in_data[13]
* pin north_in_data[21]
* pin south_in_data[23]
* pin local_in_data[17]
* pin west_in_data[17]
* pin local_out_data[21]
* pin west_out_data[10]
* pin local_out_data[10]
* pin south_out_data[21]
* pin south_in_data[10]
* pin north_out_data[21]
* pin south_out_data[10]
* pin local_in_data[21]
* pin west_out_data[21]
* pin north_out_data[10]
* pin east_out_data[10]
* pin east_out_data[21]
* pin south_in_data[21]
* pin west_in_data[10]
* pin local_in_data[10]
* pin north_out_data[24]
* pin north_out_data[12]
* pin west_in_data[21]
* pin west_out_data[12]
* pin west_out_data[20]
* pin south_out_data[20]
* pin south_out_data[12]
* pin local_out_data[12]
* pin west_out_data[22]
* pin south_out_data[22]
* pin local_in_data[12]
* pin east_out_data[12]
* pin south_in_data[22]
* pin south_in_data[12]
* pin east_in_data[3]
* pin west_in_data[12]
* pin west_in_data[22]
* pin local_out_data[22]
* pin south_out_data[11]
* pin south_out_data[14]
* pin east_in_data[22]
* pin west_in_data[11]
* pin east_in_data[21]
* pin local_in_data[15]
* pin north_out_data[26]
* pin west_in_data[20]
* pin local_in_data[11]
* pin east_out_data[14]
* pin west_out_data[19]
* pin local_in_data[22]
* pin south_in_data[20]
* pin south_out_data[23]
* pin east_out_data[11]
* pin local_in_data[14]
* pin north_out_data[19]
* pin local_in_data[3]
* pin local_in_data[20]
* pin north_out_data[23]
* pin local_out_data[23]
* pin west_out_data[18]
* pin west_out_data[16]
* pin north_out_data[1]
* pin east_out_data[19]
* pin east_out_data[23]
* pin north_out_data[15]
* pin local_out_data[15]
* pin east_in_data[20]
* pin north_out_data[22]
* pin west_out_data[31]
* pin west_out_data[29]
* pin local_in_data[19]
* pin west_out_data[1]
* pin north_in_data[18]
* pin local_in_data[18]
* pin south_in_data[19]
* pin east_out_data[15]
* pin north_in_data[13]
* pin east_in_data[0]
* pin east_out_data[29]
* pin south_out_data[31]
* pin north_out_data[11]
* pin south_in_data[1]
* pin east_out_data[1]
* pin west_in_data[23]
* pin north_in_data[14]
* pin west_in_data[19]
* pin local_out_data[1]
* pin south_out_data[15]
* pin east_out_data[17]
* pin north_out_data[16]
* pin north_in_data[17]
* pin west_in_data[18]
* pin north_in_data[10]
* pin north_in_data[11]
* pin east_out_data[31]
* pin south_out_data[1]
* pin north_out_data[14]
* pin local_out_data[14]
* pin local_out_data[11]
* pin west_out_data[11]
* pin north_in_data[12]
* pin local_out_data[25]
* pin local_out_data[16]
* pin east_out_data[20]
* pin south_in_data[18]
* pin north_out_data[18]
* pin south_out_data[17]
* pin north_in_data[0]
* pin east_out_data[16]
* pin east_in_data[10]
* pin east_in_data[14]
* pin west_out_data[15]
* pin south_out_data[30]
* pin local_in_data[1]
* pin west_out_data[14]
* pin south_out_data[16]
* pin south_out_data[25]
* pin east_out_data[18]
* pin east_out_data[22]
* pin north_in_data[22]
* pin east_in_data[18]
* pin local_out_data[18]
* pin west_in_data[15]
* pin local_out_data[17]
* pin west_out_data[28]
* pin north_in_data[1]
* pin west_out_data[30]
* pin west_in_data[14]
* pin south_in_data[11]
* pin north_in_data[19]
* pin south_out_data[19]
* pin south_out_data[18]
* pin east_in_data[1]
* pin south_in_data[17]
* pin north_in_data[15]
* pin east_in_data[15]
* pin east_in_data[13]
* pin east_in_data[12]
* pin east_out_data[30]
* pin east_out_data[28]
* pin south_out_data[28]
* pin west_in_data[1]
* pin north_in_data[20]
* pin north_in_data[23]
* pin local_in_data[23]
* pin local_out_data[20]
* pin south_out_data[29]
* pin south_in_data[14]
* pin east_in_data[11]
* pin east_in_data[17]
* pin north_in_data[16]
* pin east_in_data[16]
* pin west_in_data[16]
* pin north_out_data[17]
* pin local_in_data[16]
* pin north_out_data[20]
* pin east_in_data[19]
* pin local_out_data[19]
* pin south_in_data[16]
* pin west_out_data[17]
* pin south_in_data[15]
.SUBCKT mesh_router 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23
+ 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49
+ 50 51 52 53 54 55 56 57 59 60 61 62 63 141 184 186 194 195 230 242 246 247
+ 248 260 276 277 281 306 315 342 345 359 377 378 399 400 401 425 426 440 445
+ 453 472 473 484 504 505 517 518 543 562 579 582 583 586 605 606 653 654 670
+ 671 672 687 727 741 744 756 767 768 779 780 799 814 824 832 833 864 865 888
+ 889 899 909 910 911 926 953 959 969 970 971 991 992 993 1010 1011 1032 1033
+ 1034 1047 1082 1083 1102 1103 1115 1116 1127 1133 1134 1151 1152 1169 1170
+ 1191 1192 1211 1212 1228 1229 1246 1247 1248 1261 1279 1280 1295 1304 1306
+ 1319 1320 1329 1340 1354 1355 1360 1361 1375 1376 1394 1408 1409 1432 1441
+ 1459 1474 1489 1490 1508 1509 1530 1531 1547 1548 1557 1574 1586 1607 1619
+ 1620 1639 1640 1642 1659 1678 1679 1713 1731 1742 1756 1778 1779 1799 1800
+ 1823 1837 1847 1859 1877 1878 1890 1891 1906 1916 1917 1920 1932 1933 1943
+ 1949 1950 1954 1955 1956 1957 1975 1978 1979 1981 1982 1984 1985 1990 1991
+ 2001 2002 2004 2007 2009 2010 2012 2014 2016 2017 2022 2023 2024 2026 2027
+ 2028 2031 2034 2035 2037 2039 2040 2048 2049 2051 2055 2056 2059 2061 2062
+ 2064 2066 2069 2073 2074 2076 2077 2079 2080 2081 2083 2084 2086 2088 2090
+ 2094 2096 2098 2099 2101 2103 2105 2107 2108 2111 2113 2114 2115 2116 2118
+ 2119 2122 2123 2126 2127 2128 2130 2132 2134 2135 2136 2138 2139 2140 2141
+ 2142 2143 2144 2146 2147 2148 2149 2150 2152 2154 2155 2156 2157 2158 2159
+ 2160
* net 1 east_in_data[27]
* net 2 north_in_data[6]
* net 3 west_in_data[8]
* net 4 east_in_data[8]
* net 5 north_in_data[8]
* net 6 south_in_data[8]
* net 7 north_out_data[5]
* net 8 north_out_data[7]
* net 9 east_in_data[9]
* net 10 south_in_data[9]
* net 11 north_in_data[9]
* net 12 west_in_data[9]
* net 13 local_out_data[8]
* net 14 east_out_data[8]
* net 15 south_in_data[25]
* net 16 east_in_data[25]
* net 17 south_out_data[8]
* net 18 north_out_data[8]
* net 19 north_in_data[26]
* net 20 east_in_data[29]
* net 21 north_out_data[9]
* net 22 local_out_data[9]
* net 23 north_in_data[25]
* net 24 south_out_data[9]
* net 25 west_out_data[9]
* net 26 north_in_data[29]
* net 27 east_in_data[28]
* net 28 east_out_data[9]
* net 29 east_in_data[24]
* net 30 east_in_data[31]
* net 31 east_in_data[26]
* net 32 north_in_data[24]
* net 33 east_in_data[30]
* net 34 north_in_data[28]
* net 35 north_in_data[30]
* net 36 south_in_data[28]
* net 37 local_out_data[26]
* net 38 south_in_data[30]
* net 39 local_out_valid
* net 40 south_in_data[29]
* net 41 south_in_data[31]
* net 42 north_in_ready
* net 43 east_out_valid
* net 44 south_in_data[26]
* net 45 north_in_valid
* net 46 south_in_data[24]
* net 47 south_in_data[27]
* net 48 south_in_ready
* net 49 south_in_valid
* net 50 west_in_data[31]
* net 51 west_in_data[30]
* net 52 north_out_data[31]
* net 53 north_out_data[29]
* net 54 north_out_data[28]
* net 55 local_out_data[30]
* net 56 local_out_data[31]
* net 57 west_in_data[29]
* net 59 north_in_data[27]
* net 60 north_in_data[31]
* net 61 east_out_data[26]
* net 62 north_out_data[30]
* net 63 west_in_data[28]
* net 141 east_in_data[5]
* net 184 east_in_data[7]
* net 186 south_in_data[5]
* net 194 west_in_valid
* net 195 west_in_data[5]
* net 230 east_in_data[4]
* net 242 local_out_data[24]
* net 246 west_in_ready
* net 247 local_out_data[29]
* net 248 south_in_data[7]
* net 260 east_in_data[6]
* net 276 local_in_data[29]
* net 277 local_in_data[31]
* net 281 south_out_valid
* net 306 local_in_data[5]
* net 315 east_in_valid
* net 342 west_out_valid
* net 345 north_in_data[7]
* net 359 local_in_data[30]
* net 377 local_in_data[7]
* net 378 south_out_data[7]
* net 399 local_out_data[28]
* net 400 local_in_data[28]
* net 401 rst_n
* net 425 west_in_data[7]
* net 426 local_out_data[5]
* net 440 north_out_ready
* net 445 local_in_valid
* net 453 local_out_data[7]
* net 472 local_out_ready
* net 473 west_in_data[24]
* net 484 west_in_data[6]
* net 504 west_in_data[27]
* net 505 local_out_data[6]
* net 517 east_out_data[7]
* net 518 local_in_data[6]
* net 543 west_in_data[26]
* net 562 north_in_data[5]
* net 579 north_out_valid
* net 582 local_in_ready
* net 583 west_out_ready
* net 586 east_out_data[0]
* net 605 north_out_data[6]
* net 606 east_out_data[6]
* net 653 south_in_data[6]
* net 654 west_out_data[6]
* net 670 east_out_ready
* net 671 south_out_ready
* net 672 south_out_data[6]
* net 687 local_in_data[4]
* net 727 west_out_data[7]
* net 741 south_in_data[0]
* net 744 west_out_data[8]
* net 756 west_in_data[4]
* net 767 local_in_data[8]
* net 768 local_in_data[9]
* net 779 north_out_data[4]
* net 780 south_out_data[5]
* net 799 local_in_data[26]
* net 814 south_out_data[4]
* net 824 east_in_ready
* net 832 north_in_data[4]
* net 833 west_out_data[5]
* net 864 east_out_data[5]
* net 865 local_out_data[4]
* net 888 south_in_data[3]
* net 889 south_in_data[4]
* net 899 local_in_data[27]
* net 909 east_out_data[4]
* net 910 west_out_data[25]
* net 911 east_out_data[25]
* net 926 local_in_data[25]
* net 953 west_out_data[4]
* net 959 local_in_data[0]
* net 969 north_in_data[3]
* net 970 east_out_data[24]
* net 971 west_in_data[3]
* net 991 west_out_data[26]
* net 992 west_out_data[24]
* net 993 south_out_data[27]
* net 1010 south_out_data[3]
* net 1011 north_out_data[3]
* net 1032 south_out_data[26]
* net 1033 west_in_data[25]
* net 1034 local_in_data[24]
* net 1047 local_out_data[3]
* net 1082 local_out_data[27]
* net 1083 west_out_data[3]
* net 1102 west_out_data[27]
* net 1103 south_out_data[24]
* net 1115 east_out_data[3]
* net 1116 north_out_data[27]
* net 1127 clk
* net 1133 east_out_data[27]
* net 1134 local_out_data[0]
* net 1151 west_in_data[2]
* net 1152 north_out_data[2]
* net 1169 north_out_data[0]
* net 1170 west_out_data[0]
* net 1191 north_out_data[25]
* net 1192 local_in_data[2]
* net 1211 south_out_data[0]
* net 1212 west_in_data[0]
* net 1228 east_out_data[2]
* net 1229 south_out_data[2]
* net 1246 west_out_data[13]
* net 1247 west_in_data[13]
* net 1248 west_out_data[2]
* net 1261 south_in_data[2]
* net 1279 local_in_data[13]
* net 1280 local_out_data[13]
* net 1295 east_in_data[2]
* net 1304 north_out_data[13]
* net 1306 north_in_data[2]
* net 1319 local_out_data[2]
* net 1320 west_out_data[23]
* net 1329 south_out_data[13]
* net 1340 east_in_data[23]
* net 1354 east_out_data[13]
* net 1355 south_in_data[13]
* net 1360 north_in_data[21]
* net 1361 south_in_data[23]
* net 1375 local_in_data[17]
* net 1376 west_in_data[17]
* net 1394 local_out_data[21]
* net 1408 west_out_data[10]
* net 1409 local_out_data[10]
* net 1432 south_out_data[21]
* net 1441 south_in_data[10]
* net 1459 north_out_data[21]
* net 1474 south_out_data[10]
* net 1489 local_in_data[21]
* net 1490 west_out_data[21]
* net 1508 north_out_data[10]
* net 1509 east_out_data[10]
* net 1530 east_out_data[21]
* net 1531 south_in_data[21]
* net 1547 west_in_data[10]
* net 1548 local_in_data[10]
* net 1557 north_out_data[24]
* net 1574 north_out_data[12]
* net 1586 west_in_data[21]
* net 1607 west_out_data[12]
* net 1619 west_out_data[20]
* net 1620 south_out_data[20]
* net 1639 south_out_data[12]
* net 1640 local_out_data[12]
* net 1642 west_out_data[22]
* net 1659 south_out_data[22]
* net 1678 local_in_data[12]
* net 1679 east_out_data[12]
* net 1713 south_in_data[22]
* net 1731 south_in_data[12]
* net 1742 east_in_data[3]
* net 1756 west_in_data[12]
* net 1778 west_in_data[22]
* net 1779 local_out_data[22]
* net 1799 south_out_data[11]
* net 1800 south_out_data[14]
* net 1823 east_in_data[22]
* net 1837 west_in_data[11]
* net 1847 east_in_data[21]
* net 1859 local_in_data[15]
* net 1877 north_out_data[26]
* net 1878 west_in_data[20]
* net 1890 local_in_data[11]
* net 1891 east_out_data[14]
* net 1906 west_out_data[19]
* net 1916 local_in_data[22]
* net 1917 south_in_data[20]
* net 1920 south_out_data[23]
* net 1932 east_out_data[11]
* net 1933 local_in_data[14]
* net 1943 north_out_data[19]
* net 1949 local_in_data[3]
* net 1950 local_in_data[20]
* net 1954 north_out_data[23]
* net 1955 local_out_data[23]
* net 1956 west_out_data[18]
* net 1957 west_out_data[16]
* net 1975 north_out_data[1]
* net 1978 east_out_data[19]
* net 1979 east_out_data[23]
* net 1981 north_out_data[15]
* net 1982 local_out_data[15]
* net 1984 east_in_data[20]
* net 1985 north_out_data[22]
* net 1990 west_out_data[31]
* net 1991 west_out_data[29]
* net 2001 local_in_data[19]
* net 2002 west_out_data[1]
* net 2004 north_in_data[18]
* net 2007 local_in_data[18]
* net 2009 south_in_data[19]
* net 2010 east_out_data[15]
* net 2012 north_in_data[13]
* net 2014 east_in_data[0]
* net 2016 east_out_data[29]
* net 2017 south_out_data[31]
* net 2022 north_out_data[11]
* net 2023 south_in_data[1]
* net 2024 east_out_data[1]
* net 2026 west_in_data[23]
* net 2027 north_in_data[14]
* net 2028 west_in_data[19]
* net 2031 local_out_data[1]
* net 2034 south_out_data[15]
* net 2035 east_out_data[17]
* net 2037 north_out_data[16]
* net 2039 north_in_data[17]
* net 2040 west_in_data[18]
* net 2048 north_in_data[10]
* net 2049 north_in_data[11]
* net 2051 east_out_data[31]
* net 2055 south_out_data[1]
* net 2056 north_out_data[14]
* net 2059 local_out_data[14]
* net 2061 local_out_data[11]
* net 2062 west_out_data[11]
* net 2064 north_in_data[12]
* net 2066 local_out_data[25]
* net 2069 local_out_data[16]
* net 2073 east_out_data[20]
* net 2074 south_in_data[18]
* net 2076 north_out_data[18]
* net 2077 south_out_data[17]
* net 2079 north_in_data[0]
* net 2080 east_out_data[16]
* net 2081 east_in_data[10]
* net 2083 east_in_data[14]
* net 2084 west_out_data[15]
* net 2086 south_out_data[30]
* net 2088 local_in_data[1]
* net 2090 west_out_data[14]
* net 2094 south_out_data[16]
* net 2096 south_out_data[25]
* net 2098 east_out_data[18]
* net 2099 east_out_data[22]
* net 2101 north_in_data[22]
* net 2103 east_in_data[18]
* net 2105 local_out_data[18]
* net 2107 west_in_data[15]
* net 2108 local_out_data[17]
* net 2111 west_out_data[28]
* net 2113 north_in_data[1]
* net 2114 west_out_data[30]
* net 2115 west_in_data[14]
* net 2116 south_in_data[11]
* net 2118 north_in_data[19]
* net 2119 south_out_data[19]
* net 2122 south_out_data[18]
* net 2123 east_in_data[1]
* net 2126 south_in_data[17]
* net 2127 north_in_data[15]
* net 2128 east_in_data[15]
* net 2130 east_in_data[13]
* net 2132 east_in_data[12]
* net 2134 east_out_data[30]
* net 2135 east_out_data[28]
* net 2136 south_out_data[28]
* net 2138 west_in_data[1]
* net 2139 north_in_data[20]
* net 2140 north_in_data[23]
* net 2141 local_in_data[23]
* net 2142 local_out_data[20]
* net 2143 south_out_data[29]
* net 2144 south_in_data[14]
* net 2146 east_in_data[11]
* net 2147 east_in_data[17]
* net 2148 north_in_data[16]
* net 2149 east_in_data[16]
* net 2150 west_in_data[16]
* net 2152 north_out_data[17]
* net 2154 local_in_data[16]
* net 2155 north_out_data[20]
* net 2156 east_in_data[19]
* net 2157 local_out_data[19]
* net 2158 south_in_data[16]
* net 2159 west_out_data[17]
* net 2160 south_in_data[15]
* cell instance $3 m0 *1 14.26,8.16
X$3 94 1 94 145 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $6 m0 *1 21.62,13.6
X$6 94 2 94 89 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $9 r0 *1 11.5,2.72
X$9 94 3 94 108 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $12 m0 *1 25.3,13.6
X$12 94 4 94 163 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $15 r0 *1 17.94,2.72
X$15 94 5 94 287 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $18 m0 *1 17.94,8.16
X$18 94 6 94 123 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $21 m0 *1 35.88,24.48
X$21 94 335 7 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $25 r0 *1 8.74,2.72
X$25 94 58 8 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $29 r0 *1 35.42,13.6
X$29 94 9 94 110 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $33 m0 *1 21.62,8.16
X$33 94 10 94 146 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $38 r0 *1 25.3,2.72
X$38 94 11 94 99 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $44 m0 *1 25.3,8.16
X$44 94 12 94 121 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $49 m0 *1 27.6,19.04
X$49 94 320 13 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $52 m0 *1 44.16,19.04
X$52 94 461 14 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $57 r0 *1 21.62,2.72
X$57 94 15 94 67 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $61 m0 *1 30.82,8.16
X$61 94 16 94 125 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $69 r0 *1 28.98,8.16
X$69 94 148 17 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $74 m0 *1 40.48,13.6
X$74 94 203 18 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $77 r0 *1 47.84,19.04
X$77 94 19 94 294 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $80 r0 *1 55.2,19.04
X$80 94 20 94 259 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $83 r0 *1 44.62,13.6
X$83 94 228 21 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $86 m0 *1 57.04,19.04
X$86 94 232 22 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $91 m0 *1 45.54,13.6
X$91 94 23 94 149 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $94 m0 *1 57.04,13.6
X$94 94 187 24 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $97 r0 *1 55.66,8.16
X$97 94 155 25 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $102 m0 *1 41.86,13.6
X$102 94 26 94 206 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $107 m0 *1 49.22,13.6
X$107 94 27 94 85 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $110 r0 *1 72.22,8.16
X$110 94 161 28 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $113 m0 *1 58.42,19.04
X$113 94 29 94 157 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $116 r0 *1 57.04,13.6
X$116 94 30 94 211 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $121 m0 *1 52.9,13.6
X$121 94 31 94 180 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $124 r0 *1 60.72,13.6
X$124 94 32 94 132 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $126 r0 *1 64.4,13.6
X$126 94 33 94 88 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $132 r0 *1 59.34,2.72
X$132 94 34 94 106 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $135 r0 *1 66.7,2.72
X$135 94 35 94 105 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $138 r0 *1 73.6,8.16
X$138 94 36 94 160 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $141 r0 *1 81.88,2.72
X$141 94 87 37 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $144 r0 *1 84.64,2.72
X$144 94 38 94 72 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $147 r0 *1 98.44,2.72
X$147 94 84 39 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $150 r0 *1 88.32,2.72
X$150 94 40 94 100 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $153 r0 *1 92,2.72
X$153 94 41 94 98 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $157 r0 *1 94.3,8.16
X$157 94 135 42 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $161 r0 *1 95.68,8.16
X$161 94 152 43 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $164 r0 *1 98.44,8.16
X$164 94 44 94 176 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $167 m0 *1 109.02,8.16
X$167 94 45 150 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $170 r0 *1 102.12,8.16
X$170 94 46 94 139 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $173 r0 *1 113.16,2.72
X$173 94 47 94 81 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $176 r0 *1 118.22,2.72
X$176 94 73 48 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $179 r0 *1 123.28,2.72
X$179 94 49 96 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $181 r0 *1 119.6,2.72
X$181 94 50 94 74 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $185 m0 *1 123.28,8.16
X$185 94 51 94 120 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $188 m0 *1 128.34,8.16
X$188 94 173 52 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $193 m0 *1 131.1,8.16
X$193 94 250 53 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $196 m0 *1 129.72,8.16
X$196 94 115 54 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $199 m0 *1 133.86,8.16
X$199 94 117 55 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $202 m0 *1 135.24,8.16
X$202 94 116 56 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $204 r0 *1 133.4,2.72
X$204 94 57 94 78 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $212 m0 *1 27.14,35.36
X$212 94 488 299 523 75 94 58 75 sky130_fd_sc_hd__a21oi_1
* cell instance $215 r0 *1 39.1,13.6
X$215 94 59 94 291 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $218 r0 *1 63.02,2.72
X$218 94 60 94 90 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $221 r0 *1 69,8.16
X$221 94 158 61 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $224 r0 *1 131.1,2.72
X$224 94 77 62 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $226 r0 *1 127.42,2.72
X$226 94 63 94 95 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $234 r0 *1 16.56,2.72
X$234 94 121 64 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $237 r0 *1 43.24,24.48
X$237 75 138 415 104 64 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $243 r0 *1 58.42,24.48
X$243 75 197 385 164 65 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $245 r0 *1 41.4,2.72
X$245 94 85 65 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $251 m0 *1 62.1,19.04
X$251 75 197 301 164 66 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $253 r0 *1 55.2,2.72
X$253 94 88 66 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $256 r0 *1 10.12,2.72
X$256 94 67 76 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $260 r0 *1 29.44,2.72
X$260 75 80 103 111 68 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $262 r0 *1 16.56,8.16
X$262 94 123 68 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $266 m0 *1 29.44,8.16
X$266 94 99 69 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $268 r0 *1 43.24,2.72
X$268 75 70 107 104 69 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $326 m0 *1 11.96,95.2
X$326 75 70 1298 1155 1309 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $328 r0 *1 17.94,8.16
X$328 75 70 175 111 142 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $331 r0 *1 30.36,8.16
X$331 75 70 178 111 147 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $333 m0 *1 34.5,8.16
X$333 75 70 127 111 126 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $336 r0 *1 18.4,24.48
X$336 75 70 406 111 278 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $338 r0 *1 109.48,144.16
X$338 75 70 1391 1402 2091 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $340 r0 *1 98.44,144.16
X$340 75 70 1471 1539 2013 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $342 r0 *1 100.74,149.6
X$342 75 70 1790 1539 2082 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $344 m0 *1 99.36,149.6
X$344 75 70 1323 1539 2078 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $347 m0 *1 99.82,138.72
X$347 75 70 1727 1402 1998 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $349 r0 *1 98.44,138.72
X$349 75 70 1322 1539 2032 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $351 m0 *1 84.64,149.6
X$351 75 70 1654 1539 2121 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $353 m0 *1 59.8,13.6
X$353 75 70 181 164 154 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $355 r0 *1 70.84,2.72
X$355 75 70 102 104 71 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $358 m0 *1 60.26,8.16
X$358 75 70 131 104 112 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $360 r0 *1 57.04,8.16
X$360 75 70 159 164 153 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $362 m0 *1 45.54,8.16
X$362 75 70 133 104 129 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $368 m0 *1 70.84,13.6
X$368 75 70 209 164 182 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $372 r0 *1 44.62,8.16
X$372 75 70 183 104 151 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $374 m0 *1 45.54,149.6
X$374 75 70 1488 1554 2120 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $376 r0 *1 58.42,144.16
X$376 75 70 1628 1401 2045 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $378 m0 *1 70.84,149.6
X$378 75 70 1653 1401 2106 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $380 m0 *1 57.04,149.6
X$380 75 70 1536 1401 1944 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $382 m0 *1 32.66,144.16
X$382 75 70 1553 1480 2043 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $385 m0 *1 17.94,149.6
X$385 75 70 1716 1480 2100 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $388 m0 *1 33.12,149.6
X$388 75 70 1694 1480 2102 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $391 m0 *1 16.1,144.16
X$391 75 70 1686 1480 2054 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $393 m0 *1 101.66,13.6
X$393 75 135 70 166 150 94 94 75 sky130_fd_sc_hd__and3_4
* cell instance $395 r0 *1 4.14,40.8
X$395 75 70 632 210 647 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $398 m0 *1 17.48,100.64
X$398 75 70 1363 1155 1379 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $401 r0 *1 4.14,57.12
X$401 75 70 870 210 847 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $403 m0 *1 4.6,73.44
X$403 75 70 1017 210 972 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $406 r0 *1 57.96,2.72
X$406 94 90 71 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $409 r0 *1 95.68,2.72
X$409 94 72 86 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $415 m0 *1 112.24,13.6
X$415 94 190 94 75 73 75 sky130_fd_sc_hd__inv_1
* cell instance $417 m0 *1 114.08,13.6
X$417 75 73 80 166 96 94 94 75 sky130_fd_sc_hd__and3_4
* cell instance $419 r0 *1 126.04,2.72
X$419 94 74 122 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $467 r0 *1 146.28,138.72
X$467 94 75 94 75 1991 75 sky130_fd_sc_hd__buf_4
* cell instance $469 m0 *1 147.2,138.72
X$469 94 75 94 75 1990 75 sky130_fd_sc_hd__buf_4
* cell instance $471 m0 *1 150.88,144.16
X$471 94 75 94 75 2017 75 sky130_fd_sc_hd__buf_4
* cell instance $473 r0 *1 150.42,138.72
X$473 94 75 94 75 2016 75 sky130_fd_sc_hd__buf_4
* cell instance $476 r0 *1 150.42,144.16
X$476 94 75 94 75 2051 75 sky130_fd_sc_hd__buf_4
* cell instance $478 r0 *1 149.5,149.6
X$478 94 75 94 75 2136 75 sky130_fd_sc_hd__buf_4
* cell instance $480 r0 *1 146.74,149.6
X$480 94 75 94 75 2143 75 sky130_fd_sc_hd__buf_4
* cell instance $483 m0 *1 139.84,149.6
X$483 94 75 94 75 2114 75 sky130_fd_sc_hd__buf_4
* cell instance $485 r0 *1 145.36,144.16
X$485 94 75 94 75 2086 75 sky130_fd_sc_hd__buf_4
* cell instance $488 m0 *1 142.6,149.6
X$488 94 75 94 75 2111 75 sky130_fd_sc_hd__buf_4
* cell instance $490 r0 *1 142.6,149.6
X$490 94 75 94 75 2135 75 sky130_fd_sc_hd__buf_4
* cell instance $492 r0 *1 139.84,149.6
X$492 94 75 94 75 2134 75 sky130_fd_sc_hd__buf_4
* cell instance $496 r0 *1 7.36,2.72
X$496 94 89 142 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $515 r0 *1 100.74,2.72
X$515 75 80 82 91 83 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $518 r0 *1 116.84,2.72
X$518 94 81 97 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $523 r0 *1 137.08,2.72
X$523 94 78 79 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $545 m0 *1 1.38,8.16
X$545 94 118 140 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $548 m0 *1 10.12,8.16
X$548 94 108 109 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $549 m0 *1 11.5,8.16
X$549 94 163 119 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $550 m0 *1 12.88,8.16
X$550 94 110 198 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $554 m0 *1 57.5,8.16
X$554 94 132 112 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $555 m0 *1 58.88,8.16
X$555 94 106 154 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $557 m0 *1 71.76,8.16
X$557 94 160 113 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $558 m0 *1 73.14,8.16
X$558 75 80 101 104 113 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $561 m0 *1 85.56,8.16
X$561 75 80 156 91 130 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $562 m0 *1 96.6,8.16
X$562 75 80 137 91 128 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $563 m0 *1 107.64,8.16
X$563 94 124 165 213 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $564 m0 *1 110.4,8.16
X$564 94 139 83 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $566 m0 *1 112.24,8.16
X$566 75 80 114 92 97 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $567 m0 *1 126.96,8.16
X$567 94 120 199 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $568 m0 *1 132.48,8.16
X$568 94 95 93 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $578 r0 *1 2.3,8.16
X$578 94 144 221 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $579 r0 *1 3.68,8.16
X$579 94 141 94 172 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $583 r0 *1 13.8,8.16
X$583 94 145 143 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $587 r0 *1 41.4,8.16
X$587 94 180 179 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $590 r0 *1 43.24,8.16
X$590 94 149 129 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $594 r0 *1 70.84,8.16
X$594 94 105 182 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $595 r0 *1 77.28,8.16
X$595 94 157 134 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $597 r0 *1 80.5,8.16
X$597 75 80 136 91 86 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $598 r0 *1 91.54,8.16
X$598 94 100 130 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $599 r0 *1 92.92,8.16
X$599 94 98 207 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $603 r0 *1 105.8,8.16
X$603 94 82 165 137 202 94 75 75 sky130_fd_sc_hd__or3b_1
* cell instance $604 r0 *1 109.02,8.16
X$604 94 82 94 75 124 75 sky130_fd_sc_hd__buf_4
* cell instance $605 r0 *1 111.78,8.16
X$605 94 114 75 165 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $606 r0 *1 114.54,8.16
X$606 75 138 174 392 122 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $609 r0 *1 126.04,8.16
X$609 75 138 171 92 93 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $615 r0 *1 151.8,8.16
X$615 94 280 168 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $629 m0 *1 1.38,13.6
X$629 94 172 162 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $630 m0 *1 2.76,13.6
X$630 94 195 94 185 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $631 m0 *1 6.44,13.6
X$631 94 186 94 196 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $632 m0 *1 10.12,13.6
X$632 75 197 200 210 162 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $635 m0 *1 29.44,13.6
X$635 75 80 205 111 201 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $637 m0 *1 58.42,13.6
X$637 94 259 208 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $642 m0 *1 86.48,13.6
X$642 75 80 177 91 207 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $643 m0 *1 97.52,13.6
X$643 75 136 188 177 101 156 94 94 75 sky130_fd_sc_hd__or4_4
* cell instance $644 m0 *1 105.8,13.6
X$644 94 137 94 75 204 75 sky130_fd_sc_hd__buf_4
* cell instance $645 m0 *1 108.56,13.6
X$645 94 202 94 75 189 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $650 m0 *1 118.22,13.6
X$650 75 138 191 92 199 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $658 m0 *1 147.2,13.6
X$658 94 220 283 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $659 m0 *1 148.58,13.6
X$659 94 167 170 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $660 m0 *1 149.96,13.6
X$660 94 193 192 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $662 m0 *1 151.8,13.6
X$662 94 194 169 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $664 r0 *1 1.38,13.6
X$664 94 231 222 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $665 r0 *1 2.76,13.6
X$665 94 196 245 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $666 r0 *1 4.14,13.6
X$666 75 197 249 210 140 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $669 r0 *1 15.64,13.6
X$669 94 184 94 144 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $671 r0 *1 23,13.6
X$671 94 146 201 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $672 r0 *1 24.38,13.6
X$672 75 138 227 210 109 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $675 r0 *1 43.24,13.6
X$675 94 125 295 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $676 r0 *1 46,13.6
X$676 75 80 239 104 76 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $677 r0 *1 68.08,13.6
X$677 94 211 258 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $683 r0 *1 76.36,13.6
X$683 75 102 229 159 181 209 94 94 75 sky130_fd_sc_hd__nor4_4
* cell instance $687 r0 *1 90.16,13.6
X$687 75 177 255 156 101 136 94 94 75 sky130_fd_sc_hd__nor4_4
* cell instance $690 r0 *1 98.44,13.6
X$690 94 176 128 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $692 r0 *1 100.28,13.6
X$692 94 204 213 189 94 254 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $693 r0 *1 102.12,13.6
X$693 75 226 124 165 204 94 94 75 sky130_fd_sc_hd__nor3b_2
* cell instance $694 r0 *1 106.72,13.6
X$694 75 2172 253 215 214 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $695 r0 *1 111.32,13.6
X$695 75 2174 252 215 216 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $696 r0 *1 115.92,13.6
X$696 94 215 94 75 251 75 sky130_fd_sc_hd__inv_1
* cell instance $697 r0 *1 117.3,13.6
X$697 94 190 96 416 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $698 r0 *1 118.68,13.6
X$698 94 216 94 75 214 75 sky130_fd_sc_hd__inv_1
* cell instance $705 r0 *1 130.64,13.6
X$705 75 138 217 224 79 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $706 r0 *1 141.68,13.6
X$706 94 223 247 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $709 r0 *1 145.82,13.6
X$709 94 218 503 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $710 r0 *1 147.2,13.6
X$710 94 219 246 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $712 r0 *1 149.5,13.6
X$712 94 276 94 220 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $727 m0 *1 1.38,19.04
X$727 94 316 278 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $728 m0 *1 2.76,19.04
X$728 75 197 282 210 221 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $729 m0 *1 13.8,19.04
X$729 94 248 94 285 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $730 m0 *1 17.48,19.04
X$730 94 230 94 118 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $734 m0 *1 26.22,19.04
X$734 94 287 147 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $737 m0 *1 29.9,19.04
X$737 75 197 292 111 119 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $738 m0 *1 40.94,19.04
X$738 94 291 126 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $740 m0 *1 42.78,19.04
X$740 94 294 151 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $741 m0 *1 45.54,19.04
X$741 75 197 297 104 295 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $746 m0 *1 79.58,19.04
X$746 94 264 209 257 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $748 m0 *1 81.42,19.04
X$748 94 304 266 209 265 94 267 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $751 m0 *1 84.64,19.04
X$751 75 236 233 267 234 235 268 94 94 75 sky130_fd_sc_hd__a311oi_2
* cell instance $753 m0 *1 91.08,19.04
X$753 94 177 190 237 331 75 94 75 sky130_fd_sc_hd__nand3b_1
* cell instance $754 m0 *1 93.84,19.04
X$754 75 225 270 238 256 376 272 94 94 75 sky130_fd_sc_hd__o311ai_2
* cell instance $756 m0 *1 100.28,19.04
X$756 94 239 94 75 305 75 sky130_fd_sc_hd__inv_1
* cell instance $757 m0 *1 101.66,19.04
X$757 75 255 215 305 254 94 94 75 sky130_fd_sc_hd__and3_1
* cell instance $759 m0 *1 104.88,19.04
X$759 75 239 204 303 124 94 94 75 sky130_fd_sc_hd__nor3b_4
* cell instance $761 m0 *1 112.24,19.04
X$761 75 302 300 251 216 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $762 m0 *1 116.84,19.04
X$762 75 2169 324 251 214 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $764 m0 *1 121.9,19.04
X$764 94 298 299 274 75 94 77 75 sky130_fd_sc_hd__a21oi_1
* cell instance $765 m0 *1 123.74,19.04
X$765 94 293 240 298 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $766 m0 *1 125.12,19.04
X$766 94 296 299 343 75 94 250 75 sky130_fd_sc_hd__a21oi_1
* cell instance $767 m0 *1 126.96,19.04
X$767 94 243 240 296 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $769 m0 *1 129.26,19.04
X$769 94 241 191 367 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $771 m0 *1 132.48,19.04
X$771 94 241 217 290 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $772 m0 *1 133.86,19.04
X$772 94 191 174 171 217 75 94 289 75 sky130_fd_sc_hd__or4_2
* cell instance $774 m0 *1 138,19.04
X$774 94 243 286 288 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $776 m0 *1 139.84,19.04
X$776 75 275 243 92 283 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $777 m0 *1 150.88,19.04
X$777 94 244 281 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $778 m0 *1 152.26,19.04
X$778 94 279 242 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $779 r0 *1 1.38,19.04
X$779 75 80 261 210 245 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $780 r0 *1 12.42,19.04
X$780 94 185 317 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $781 r0 *1 13.8,19.04
X$781 94 307 262 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $785 r0 *1 16.1,19.04
X$785 75 197 319 210 262 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $788 r0 *1 31.74,19.04
X$788 75 197 322 111 198 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $794 r0 *1 52.44,19.04
X$794 94 297 75 308 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $796 r0 *1 59.34,19.04
X$796 75 197 309 164 258 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $799 r0 *1 70.84,19.04
X$799 94 311 309 269 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $800 r0 *1 73.14,19.04
X$800 94 309 310 263 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $801 r0 *1 74.52,19.04
X$801 94 301 310 233 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $803 r0 *1 76.36,19.04
X$803 94 311 301 256 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $804 r0 *1 78.66,19.04
X$804 94 304 266 102 265 94 312 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $805 r0 *1 80.96,19.04
X$805 75 271 263 312 234 344 268 94 94 75 sky130_fd_sc_hd__a311oi_2
* cell instance $806 r0 *1 86.48,19.04
X$806 94 264 102 330 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $808 r0 *1 88.78,19.04
X$808 75 314 270 422 269 331 272 94 94 75 sky130_fd_sc_hd__o311ai_2
* cell instance $810 r0 *1 95.22,19.04
X$810 94 156 190 237 329 75 94 75 sky130_fd_sc_hd__nand3b_1
* cell instance $813 r0 *1 98.44,19.04
X$813 75 273 327 94 328 94 75 sky130_fd_sc_hd__nand2_8
* cell instance $814 r0 *1 105.8,19.04
X$814 75 226 255 303 237 94 94 75 sky130_fd_sc_hd__o21ai_4
* cell instance $815 r0 *1 111.78,19.04
X$815 94 188 189 216 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $817 r0 *1 113.62,19.04
X$817 94 237 94 75 326 75 sky130_fd_sc_hd__inv_1
* cell instance $819 r0 *1 115.46,19.04
X$819 75 325 273 326 324 94 94 75 sky130_fd_sc_hd__ha_2
* cell instance $821 r0 *1 121.44,19.04
X$821 94 236 191 212 75 94 274 75 sky130_fd_sc_hd__a21oi_1
* cell instance $824 r0 *1 123.74,19.04
X$824 94 271 174 212 75 94 323 75 sky130_fd_sc_hd__a21oi_1
* cell instance $827 r0 *1 126.96,19.04
X$827 75 174 397 217 171 191 94 94 75 sky130_fd_sc_hd__nor4_4
* cell instance $828 r0 *1 134.78,19.04
X$828 94 241 174 321 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $830 r0 *1 136.62,19.04
X$830 75 275 318 224 168 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $832 r0 *1 148.12,19.04
X$832 94 315 284 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $833 r0 *1 149.5,19.04
X$833 94 277 94 280 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $848 m0 *1 1.38,24.48
X$848 94 332 426 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $850 m0 *1 3.22,24.48
X$850 94 260 94 307 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $851 m0 *1 6.9,24.48
X$851 75 275 333 210 222 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $852 m0 *1 17.94,24.48
X$852 94 345 94 316 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $853 m0 *1 21.62,24.48
X$853 94 306 94 231 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $858 m0 *1 30.82,24.48
X$858 94 333 240 365 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $859 m0 *1 32.2,24.48
X$859 94 365 299 334 75 94 335 75 sky130_fd_sc_hd__a21oi_1
* cell instance $860 m0 *1 34.04,24.48
X$860 94 347 366 212 75 94 334 75 sky130_fd_sc_hd__a21oi_1
* cell instance $868 m0 *1 55.2,24.48
X$868 94 206 153 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $870 m0 *1 57.04,24.48
X$870 75 197 336 164 208 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $873 m0 *1 72.68,24.48
X$873 94 336 346 348 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $874 m0 *1 74.06,24.48
X$874 94 311 336 337 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $875 m0 *1 76.36,24.48
X$875 94 304 266 159 265 94 349 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $876 m0 *1 78.66,24.48
X$876 75 338 348 349 234 372 268 94 94 75 sky130_fd_sc_hd__a311oi_2
* cell instance $878 m0 *1 84.64,24.48
X$878 94 177 313 344 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $880 m0 *1 86.94,24.48
X$880 94 156 313 372 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $881 m0 *1 88.32,24.48
X$881 94 136 313 235 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $883 m0 *1 90.16,24.48
X$883 75 270 351 337 329 272 94 355 94 75 sky130_fd_sc_hd__o311ai_4
* cell instance $885 m0 *1 100.74,24.48
X$885 75 255 226 375 300 327 303 94 94 75 sky130_fd_sc_hd__o2111ai_4
* cell instance $890 m0 *1 113.16,24.48
X$890 94 253 300 273 252 75 339 94 75 sky130_fd_sc_hd__nor4_1
* cell instance $891 m0 *1 115.46,24.48
X$891 94 190 325 300 626 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $892 m0 *1 117.3,24.48
X$892 94 190 325 252 340 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $893 m0 *1 119.14,24.48
X$893 94 327 75 190 94 75 sky130_fd_sc_hd__buf_2
* cell instance $895 m0 *1 122.82,24.48
X$895 94 369 299 323 75 94 173 75 sky130_fd_sc_hd__a21oi_1
* cell instance $896 m0 *1 124.66,24.48
X$896 94 318 240 369 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $897 m0 *1 126.04,24.48
X$897 94 338 217 212 75 94 343 75 sky130_fd_sc_hd__a21oi_1
* cell instance $898 m0 *1 127.88,24.48
X$898 94 356 240 354 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $900 m0 *1 129.72,24.48
X$900 94 367 225 286 357 75 94 117 75 sky130_fd_sc_hd__a31oi_1
* cell instance $901 m0 *1 132.02,24.48
X$901 94 293 286 357 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $902 m0 *1 133.4,24.48
X$902 94 321 314 286 341 75 94 116 75 sky130_fd_sc_hd__a31oi_1
* cell instance $903 m0 *1 135.7,24.48
X$903 94 318 286 341 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $904 m0 *1 137.08,24.48
X$904 94 290 355 286 288 75 94 223 75 sky130_fd_sc_hd__a31oi_1
* cell instance $906 m0 *1 139.84,24.48
X$906 94 363 342 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $907 m0 *1 141.22,24.48
X$907 94 361 546 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $908 m0 *1 142.6,24.48
X$908 75 275 293 224 360 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $909 r0 *1 1.38,24.48
X$909 94 380 379 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $910 r0 *1 2.76,24.48
X$910 94 439 438 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $911 r0 *1 4.14,24.48
X$911 75 138 366 210 317 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $915 r0 *1 15.64,24.48
X$915 94 285 403 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $919 r0 *1 30.36,24.48
X$919 94 200 346 364 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $920 r0 *1 31.74,24.48
X$920 94 477 364 407 234 268 94 347 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $921 r0 *1 34.96,24.48
X$921 94 261 313 407 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $934 r0 *1 70.84,24.48
X$934 75 370 336 385 309 301 94 94 75 sky130_fd_sc_hd__nor4_2
* cell instance $935 r0 *1 75.44,24.48
X$935 94 301 309 385 336 75 94 420 75 sky130_fd_sc_hd__or4_2
* cell instance $936 r0 *1 78.66,24.48
X$936 94 350 159 374 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $938 r0 *1 80.96,24.48
X$938 94 350 181 419 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $939 r0 *1 82.34,24.48
X$939 94 101 313 421 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $940 r0 *1 83.72,24.48
X$940 94 374 311 352 75 94 351 75 sky130_fd_sc_hd__a21oi_1
* cell instance $942 r0 *1 86.02,24.48
X$942 94 257 311 352 75 94 238 75 sky130_fd_sc_hd__a21oi_1
* cell instance $943 r0 *1 87.86,24.48
X$943 94 330 311 352 75 94 422 75 sky130_fd_sc_hd__a21oi_1
* cell instance $945 r0 *1 91.54,24.48
X$945 94 101 190 237 450 75 94 75 sky130_fd_sc_hd__nand3b_1
* cell instance $946 r0 *1 94.3,24.48
X$946 94 136 190 237 376 75 94 75 sky130_fd_sc_hd__nand3b_1
* cell instance $951 r0 *1 98.44,24.48
X$951 75 237 327 94 382 94 75 sky130_fd_sc_hd__nand2_8
* cell instance $952 r0 *1 105.8,24.48
X$952 94 327 253 388 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $953 r0 *1 107.18,24.48
X$953 94 389 226 424 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $954 r0 *1 108.56,24.48
X$954 94 327 252 423 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $955 r0 *1 109.94,24.48
X$955 94 165 188 373 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $956 r0 *1 111.32,24.48
X$956 94 373 190 303 390 94 418 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $957 r0 *1 113.62,24.48
X$957 94 237 339 480 94 371 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $958 r0 *1 115.46,24.48
X$958 94 353 371 190 416 75 94 446 75 sky130_fd_sc_hd__a31oi_1
* cell instance $960 r0 *1 118.22,24.48
X$960 94 325 302 390 75 94 75 sky130_fd_sc_hd__nor2b_1
* cell instance $966 r0 *1 123.74,24.48
X$966 94 354 299 393 75 94 115 75 sky130_fd_sc_hd__a21oi_1
* cell instance $968 r0 *1 126.04,24.48
X$968 94 413 171 212 75 94 393 75 sky130_fd_sc_hd__a21oi_1
* cell instance $969 r0 *1 127.88,24.48
X$969 75 436 243 356 318 293 94 94 75 sky130_fd_sc_hd__nor4_2
* cell instance $970 r0 *1 132.48,24.48
X$970 94 396 360 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $971 r0 *1 133.86,24.48
X$971 94 241 171 409 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $973 r0 *1 136.16,24.48
X$973 94 356 286 408 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $975 r0 *1 138,24.48
X$975 94 243 356 318 293 404 94 75 75 sky130_fd_sc_hd__or4_1
* cell instance $976 r0 *1 140.76,24.48
X$976 94 358 362 405 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $977 r0 *1 142.14,24.48
X$977 94 359 94 396 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $978 r0 *1 145.82,24.48
X$978 94 400 94 193 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $979 r0 *1 149.5,24.48
X$979 94 401 94 402 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $990 m0 *1 1.84,29.92
X$990 94 484 94 427 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $991 m0 *1 5.52,29.92
X$991 94 377 94 439 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $992 m0 *1 9.2,29.92
X$992 94 442 378 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $993 m0 *1 10.58,29.92
X$993 75 275 444 111 438 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $995 m0 *1 22.54,29.92
X$995 94 261 382 475 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1001 m0 *1 33.12,29.92
X$1001 75 197 410 111 143 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1002 m0 *1 44.16,29.92
X$1002 94 410 94 75 368 75 sky130_fd_sc_hd__buf_4
* cell instance $1005 m0 *1 51.06,29.92
X$1005 94 205 382 414 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1006 m0 *1 52.44,29.92
X$1006 94 384 449 414 430 94 75 232 75 sky130_fd_sc_hd__o31ai_1
* cell instance $1010 m0 *1 57.04,29.92
X$1010 75 197 452 164 179 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1013 m0 *1 72.68,29.92
X$1013 94 385 346 432 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1014 m0 *1 74.06,29.92
X$1014 94 311 385 387 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1015 m0 *1 76.36,29.92
X$1015 94 304 266 181 265 94 433 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $1016 m0 *1 78.66,29.92
X$1016 75 413 432 433 234 421 268 94 94 75 sky130_fd_sc_hd__a311oi_2
* cell instance $1019 m0 *1 85.1,29.92
X$1019 94 419 496 352 75 94 386 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1020 m0 *1 86.94,29.92
X$1020 75 428 386 387 450 272 94 417 94 75 sky130_fd_sc_hd__o311ai_4
* cell instance $1021 m0 *1 96.6,29.92
X$1021 75 388 451 237 94 94 75 sky130_fd_sc_hd__nor2_4
* cell instance $1022 m0 *1 100.74,29.92
X$1022 94 327 237 448 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1024 m0 *1 106.72,29.92
X$1024 94 482 373 424 447 215 353 75 94 75 sky130_fd_sc_hd__a32oi_1
* cell instance $1026 m0 *1 110.4,29.92
X$1026 94 435 189 447 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1028 m0 *1 112.24,29.92
X$1028 94 481 373 302 391 75 434 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1029 m0 *1 115,29.92
X$1029 94 327 325 391 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1031 m0 *1 116.84,29.92
X$1031 75 395 394 392 446 94 94 75 sky130_fd_sc_hd__dfrtp_1
* cell instance $1032 m0 *1 126.04,29.92
X$1032 94 394 94 75 327 75 sky130_fd_sc_hd__buf_4
* cell instance $1034 m0 *1 129.26,29.92
X$1034 94 445 412 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1035 m0 *1 130.64,29.92
X$1035 94 437 399 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1036 m0 *1 132.02,29.92
X$1036 94 166 75 395 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1037 m0 *1 133.86,29.92
X$1037 94 409 417 286 408 75 94 437 75 sky130_fd_sc_hd__a31oi_1
* cell instance $1038 m0 *1 136.16,29.92
X$1038 94 435 398 443 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1039 m0 *1 137.54,29.92
X$1039 94 402 75 166 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1042 m0 *1 140.76,29.92
X$1042 94 440 94 75 441 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $1043 m0 *1 142.6,29.92
X$1043 75 275 356 92 192 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1044 r0 *1 1.38,29.92
X$1044 94 427 519 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1045 r0 *1 2.76,29.92
X$1045 94 454 453 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1046 r0 *1 4.14,29.92
X$1046 75 138 474 210 379 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1049 r0 *1 15.64,29.92
X$1049 94 425 94 380 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1052 r0 *1 21.62,29.92
X$1052 94 384 455 475 456 94 75 332 75 sky130_fd_sc_hd__o31ai_1
* cell instance $1053 r0 *1 24.38,29.92
X$1053 94 366 429 333 411 94 456 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1054 r0 *1 27.14,29.92
X$1054 75 455 467 200 428 457 383 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $1055 r0 *1 30.36,29.92
X$1055 94 304 457 265 477 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1057 r0 *1 34.04,29.92
X$1057 94 282 346 552 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1061 r0 *1 38.64,29.92
X$1061 94 103 382 458 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1062 r0 *1 40.02,29.92
X$1062 94 384 515 458 460 94 75 320 75 sky130_fd_sc_hd__o31ai_1
* cell instance $1065 r0 *1 43.24,29.92
X$1065 75 515 467 292 428 459 383 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $1066 r0 *1 46.46,29.92
X$1066 94 227 429 462 411 94 460 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1068 r0 *1 49.68,29.92
X$1068 94 322 346 463 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1070 r0 *1 51.52,29.92
X$1070 75 449 467 322 428 466 383 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $1071 r0 *1 54.74,29.92
X$1071 94 415 429 431 411 94 430 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1072 r0 *1 57.5,29.92
X$1072 94 183 75 516 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1075 r0 *1 64.86,29.92
X$1075 94 310 75 346 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1086 r0 *1 91.08,29.92
X$1086 75 270 428 94 94 75 sky130_fd_sc_hd__buf_6
* cell instance $1089 r0 *1 96.14,29.92
X$1089 94 448 75 270 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1091 r0 *1 98.44,29.92
X$1091 75 189 468 469 423 188 94 94 75 sky130_fd_sc_hd__a211oi_4
* cell instance $1092 r0 *1 105.8,29.92
X$1092 75 468 482 441 470 305 497 94 94 75 sky130_fd_sc_hd__o32ai_1
* cell instance $1093 r0 *1 109.02,29.92
X$1093 94 204 124 470 75 94 75 sky130_fd_sc_hd__nand2b_1
* cell instance $1094 r0 *1 111.32,29.92
X$1094 94 468 470 481 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1096 r0 *1 114.54,29.92
X$1096 94 471 237 480 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1100 r0 *1 120.98,29.92
X$1100 75 510 499 479 476 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1103 r0 *1 126.04,29.92
X$1103 75 2173 479 478 509 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1105 r0 *1 131.1,29.92
X$1105 94 241 169 502 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1106 r0 *1 132.48,29.92
X$1106 94 471 476 548 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1108 r0 *1 134.32,29.92
X$1108 75 395 506 392 507 94 94 75 sky130_fd_sc_hd__dfrtp_1
* cell instance $1109 r0 *1 143.52,29.92
X$1109 94 472 75 471 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1111 r0 *1 145.82,29.92
X$1111 94 543 94 361 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1112 r0 *1 149.5,29.92
X$1112 94 473 94 167 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1129 m0 *1 2.76,35.36
X$1129 94 545 544 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1130 m0 *1 4.14,35.36
X$1130 75 80 381 111 403 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1132 m0 *1 15.64,35.36
X$1132 94 547 505 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1134 m0 *1 20.7,35.36
X$1134 94 384 486 485 487 94 75 454 75 sky130_fd_sc_hd__o31ai_1
* cell instance $1135 m0 *1 23.46,35.36
X$1135 94 474 429 444 411 94 487 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1138 m0 *1 29.44,35.36
X$1138 94 489 474 212 75 94 523 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1139 m0 *1 31.28,35.36
X$1139 94 444 464 488 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1140 m0 *1 32.66,35.36
X$1140 94 381 328 512 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1141 m0 *1 34.04,35.36
X$1141 94 525 552 512 234 511 94 489 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $1143 m0 *1 39.1,35.36
X$1143 94 483 94 75 527 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $1144 m0 *1 40.94,35.36
X$1144 94 292 346 529 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1146 m0 *1 42.78,35.36
X$1146 94 557 94 75 459 75 sky130_fd_sc_hd__inv_1
* cell instance $1147 m0 *1 44.16,35.36
X$1147 94 103 328 558 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1148 m0 *1 45.54,35.36
X$1148 94 462 464 531 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1149 m0 *1 46.92,35.36
X$1149 94 531 465 559 75 94 203 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1150 m0 *1 48.76,35.36
X$1150 94 304 466 265 533 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1151 m0 *1 50.6,35.36
X$1151 94 490 465 492 75 94 228 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1152 m0 *1 52.44,35.36
X$1152 94 491 107 466 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1153 m0 *1 54.74,35.36
X$1153 94 493 415 534 75 94 492 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1155 m0 *1 57.04,35.36
X$1155 94 431 464 490 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1156 m0 *1 58.42,35.36
X$1156 75 197 561 164 134 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1160 m0 *1 75.9,35.36
X$1160 94 464 94 75 465 75 sky130_fd_sc_hd__buf_4
* cell instance $1161 m0 *1 78.66,35.36
X$1161 75 495 483 560 494 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1164 m0 *1 84.64,35.36
X$1164 94 135 514 494 94 75 84 75 sky130_fd_sc_hd__o21ai_1
* cell instance $1165 m0 *1 86.48,35.36
X$1165 94 311 75 496 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1169 m0 *1 94.3,35.36
X$1169 94 204 239 124 468 75 94 75 sky130_fd_sc_hd__or3b_2
* cell instance $1170 m0 *1 97.52,35.36
X$1170 75 513 189 468 388 188 94 94 75 sky130_fd_sc_hd__a211o_2
* cell instance $1173 m0 *1 103.96,35.36
X$1173 75 1093 189 468 423 188 94 94 75 sky130_fd_sc_hd__a211o_2
* cell instance $1174 m0 *1 107.64,35.36
X$1174 75 554 497 441 553 94 94 75 sky130_fd_sc_hd__mux2i_1
* cell instance $1178 m0 *1 114.08,35.36
X$1178 75 498 272 476 94 94 75 sky130_fd_sc_hd__nand2b_4
* cell instance $1179 m0 *1 119.14,35.36
X$1179 94 551 94 75 511 75 sky130_fd_sc_hd__buf_4
* cell instance $1181 m0 *1 122.36,35.36
X$1181 94 498 499 551 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1182 m0 *1 124.66,35.36
X$1182 75 2163 508 500 539 94 94 75 sky130_fd_sc_hd__ha_2
* cell instance $1183 m0 *1 130.18,35.36
X$1183 94 500 94 75 509 75 sky130_fd_sc_hd__inv_1
* cell instance $1185 m0 *1 132.02,35.36
X$1185 94 548 476 540 75 94 501 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1187 m0 *1 134.78,35.36
X$1187 94 541 501 241 502 75 94 507 75 sky130_fd_sc_hd__a31oi_1
* cell instance $1188 m0 *1 137.08,35.36
X$1188 94 362 289 581 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1191 m0 *1 139.84,35.36
X$1191 94 506 94 75 498 75 sky130_fd_sc_hd__buf_4
* cell instance $1192 m0 *1 142.6,35.36
X$1192 75 138 362 92 503 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1193 r0 *1 1.38,35.36
X$1193 94 584 606 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1194 r0 *1 2.76,35.36
X$1194 94 520 647 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1195 r0 *1 4.14,35.36
X$1195 75 275 524 111 544 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1198 r0 *1 15.64,35.36
X$1198 94 518 94 545 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1199 r0 *1 19.32,35.36
X$1199 94 674 517 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1201 r0 *1 21.16,35.36
X$1201 94 381 382 485 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1202 r0 *1 22.54,35.36
X$1202 94 550 94 75 521 75 sky130_fd_sc_hd__inv_1
* cell instance $1204 r0 *1 24.38,35.36
X$1204 75 486 467 282 428 521 383 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $1206 r0 *1 28.06,35.36
X$1206 94 549 299 522 75 94 590 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1207 r0 *1 29.9,35.36
X$1207 94 524 464 549 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1208 r0 *1 31.28,35.36
X$1208 94 526 406 550 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1209 r0 *1 32.66,35.36
X$1209 94 319 346 609 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1211 r0 *1 34.5,35.36
X$1211 94 527 350 175 566 94 593 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $1212 r0 *1 36.8,35.36
X$1212 94 527 350 406 594 94 525 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $1213 r0 *1 39.1,35.36
X$1213 94 527 350 178 594 94 528 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $1214 r0 *1 41.4,35.36
X$1214 94 526 178 557 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1217 r0 *1 43.24,35.36
X$1217 94 528 529 558 530 511 94 532 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $1218 r0 *1 46.46,35.36
X$1218 94 532 227 534 75 94 559 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1219 r0 *1 48.3,35.36
X$1219 94 328 94 75 530 75 sky130_fd_sc_hd__buf_4
* cell instance $1220 r0 *1 51.06,35.36
X$1220 94 533 463 596 530 511 94 493 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $1222 r0 *1 54.74,35.36
X$1222 94 205 597 567 94 568 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1223 r0 *1 56.58,35.36
X$1223 94 535 107 569 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1224 r0 *1 57.96,35.36
X$1224 75 275 431 164 601 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1229 r0 *1 70.84,35.36
X$1229 94 491 94 75 264 75 sky130_fd_sc_hd__buf_4
* cell instance $1231 r0 *1 77.28,35.36
X$1231 75 2175 560 553 570 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1234 r0 *1 84.18,35.36
X$1234 94 536 94 75 570 75 sky130_fd_sc_hd__inv_1
* cell instance $1235 r0 *1 85.56,35.36
X$1235 75 536 603 604 94 94 75 sky130_fd_sc_hd__ha_4
* cell instance $1236 r0 *1 94.76,35.36
X$1236 94 553 94 75 604 75 sky130_fd_sc_hd__inv_1
* cell instance $1242 r0 *1 99.82,35.36
X$1242 94 491 94 75 135 75 sky130_fd_sc_hd__clkinvlp_4
* cell instance $1243 r0 *1 102.58,35.36
X$1243 94 266 150 602 94 556 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1244 r0 *1 104.42,35.36
X$1244 94 556 555 537 75 94 598 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1245 r0 *1 106.26,35.36
X$1245 75 555 554 599 536 94 94 75 sky130_fd_sc_hd__mux2i_1
* cell instance $1246 r0 *1 109.94,35.36
X$1246 75 395 574 392 598 94 94 75 sky130_fd_sc_hd__dfrtp_1
* cell instance $1247 r0 *1 119.14,35.36
X$1247 94 574 75 491 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1249 r0 *1 121.9,35.36
X$1249 94 538 575 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1251 r0 *1 123.28,35.36
X$1251 94 576 578 499 508 75 540 94 75 sky130_fd_sc_hd__nor4_1
* cell instance $1254 r0 *1 126.5,35.36
X$1254 75 2171 576 539 509 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1255 r0 *1 131.1,35.36
X$1255 94 539 94 75 478 75 sky130_fd_sc_hd__inv_1
* cell instance $1257 r0 *1 133.4,35.36
X$1257 75 397 539 591 542 94 94 75 sky130_fd_sc_hd__and3_1
* cell instance $1258 r0 *1 135.7,35.36
X$1258 94 289 398 500 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1260 r0 *1 138,35.36
X$1260 94 573 582 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1261 r0 *1 139.38,35.36
X$1261 94 441 740 587 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1262 r0 *1 140.76,35.36
X$1262 94 739 586 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1263 r0 *1 142.14,35.36
X$1263 75 138 585 92 546 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1278 m0 *1 1.38,40.8
X$1278 94 607 617 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1279 m0 *1 2.76,40.8
X$1279 75 138 589 111 519 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1280 m0 *1 13.8,40.8
X$1280 94 562 94 520 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1282 m0 *1 18.4,40.8
X$1282 94 590 605 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1284 m0 *1 20.24,40.8
X$1284 94 384 588 619 608 94 75 547 75 sky130_fd_sc_hd__o31ai_1
* cell instance $1285 m0 *1 23,40.8
X$1285 94 589 429 524 411 94 608 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1286 m0 *1 25.76,40.8
X$1286 75 588 467 319 428 651 383 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $1289 m0 *1 29.9,40.8
X$1289 94 564 589 212 75 94 522 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1291 m0 *1 32.66,40.8
X$1291 94 524 565 621 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1293 m0 *1 34.5,40.8
X$1293 94 593 609 622 234 511 94 564 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $1295 m0 *1 38.18,40.8
X$1295 75 275 462 164 615 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1297 m0 *1 50.14,40.8
X$1297 94 511 94 75 534 75 sky130_fd_sc_hd__buf_4
* cell instance $1299 m0 *1 53.36,40.8
X$1299 94 491 75 563 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1302 m0 *1 57.04,40.8
X$1302 94 415 610 600 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1303 m0 *1 58.42,40.8
X$1303 94 491 94 75 535 75 sky130_fd_sc_hd__buf_4
* cell instance $1304 m0 *1 61.18,40.8
X$1304 94 205 328 596 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1306 m0 *1 63.02,40.8
X$1306 94 491 94 75 526 75 sky130_fd_sc_hd__buf_4
* cell instance $1308 m0 *1 66.7,40.8
X$1308 94 452 75 641 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1309 m0 *1 69.46,40.8
X$1309 94 491 94 75 350 75 sky130_fd_sc_hd__buf_4
* cell instance $1311 m0 *1 73.14,40.8
X$1311 75 131 127 629 516 94 94 75 sky130_fd_sc_hd__nor3b_4
* cell instance $1312 m0 *1 80.04,40.8
X$1312 75 75 629 553 229 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $1317 m0 *1 86.94,40.8
X$1317 75 630 571 570 604 94 94 75 sky130_fd_sc_hd__ha_2
* cell instance $1318 m0 *1 92.46,40.8
X$1318 75 2165 572 536 553 94 94 75 sky130_fd_sc_hd__ha_2
* cell instance $1321 m0 *1 99.36,40.8
X$1321 94 628 603 571 572 75 627 94 75 sky130_fd_sc_hd__nor4_1
* cell instance $1322 m0 *1 101.66,40.8
X$1322 94 135 611 627 537 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1323 m0 *1 103.5,40.8
X$1323 94 266 471 611 602 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1326 m0 *1 108.1,40.8
X$1326 75 599 389 435 553 94 94 75 sky130_fd_sc_hd__mux2i_1
* cell instance $1331 m0 *1 115.46,40.8
X$1331 94 626 613 612 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1332 m0 *1 116.84,40.8
X$1332 94 625 94 75 573 75 sky130_fd_sc_hd__inv_1
* cell instance $1333 m0 *1 118.22,40.8
X$1333 94 241 510 578 613 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1334 m0 *1 120.06,40.8
X$1334 94 241 510 679 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1335 m0 *1 121.44,40.8
X$1335 94 389 592 616 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1336 m0 *1 122.82,40.8
X$1336 94 577 614 624 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1337 m0 *1 124.2,40.8
X$1337 94 623 579 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1338 m0 *1 125.58,40.8
X$1338 75 645 578 478 500 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1340 m0 *1 131.1,40.8
X$1340 75 577 580 441 614 591 497 94 94 75 sky130_fd_sc_hd__o32ai_1
* cell instance $1341 m0 *1 134.32,40.8
X$1341 94 620 94 75 591 75 sky130_fd_sc_hd__inv_1
* cell instance $1343 m0 *1 136.16,40.8
X$1343 94 580 581 616 443 539 541 75 94 75 sky130_fd_sc_hd__a32oi_1
* cell instance $1346 m0 *1 140.76,40.8
X$1346 94 583 94 75 389 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $1347 m0 *1 142.6,40.8
X$1347 75 219 138 166 169 94 94 75 sky130_fd_sc_hd__and3_4
* cell instance $1348 m0 *1 146.74,40.8
X$1348 94 585 94 75 618 75 sky130_fd_sc_hd__buf_4
* cell instance $1350 m0 *1 149.96,40.8
X$1350 94 504 94 218 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1352 r0 *1 2.3,40.8
X$1352 94 649 672 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1356 r0 *1 15.64,40.8
X$1356 94 650 654 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1358 r0 *1 20.7,40.8
X$1358 94 631 382 619 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1361 r0 *1 23.46,40.8
X$1361 94 563 632 457 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1362 r0 *1 25.76,40.8
X$1362 94 634 94 75 651 75 sky130_fd_sc_hd__inv_1
* cell instance $1364 r0 *1 27.6,40.8
X$1364 94 474 610 675 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1365 r0 *1 28.98,40.8
X$1365 94 589 610 635 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1366 r0 *1 30.36,40.8
X$1366 94 635 636 657 621 75 94 584 75 sky130_fd_sc_hd__a31oi_1
* cell instance $1367 r0 *1 32.66,40.8
X$1367 94 526 175 634 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1368 r0 *1 34.04,40.8
X$1368 94 444 565 717 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1370 r0 *1 35.88,40.8
X$1370 94 631 328 622 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1372 r0 *1 38.18,40.8
X$1372 94 103 633 678 94 677 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1373 r0 *1 40.02,40.8
X$1373 94 227 610 680 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1374 r0 *1 41.4,40.8
X$1374 94 462 565 661 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1378 r0 *1 44.16,40.8
X$1378 94 103 597 567 94 659 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1379 r0 *1 46,40.8
X$1379 94 227 595 462 637 94 660 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1380 r0 *1 48.76,40.8
X$1380 75 104 94 94 75 sky130_fd_sc_hd__inv_8
* cell instance $1382 r0 *1 53.82,40.8
X$1382 94 415 638 431 639 94 640 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1384 r0 *1 57.04,40.8
X$1384 94 812 683 568 94 75 187 75 sky130_fd_sc_hd__o21ai_1
* cell instance $1385 r0 *1 58.88,40.8
X$1385 94 415 595 431 637 94 683 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1386 r0 *1 61.64,40.8
X$1386 94 431 565 662 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1387 r0 *1 63.02,40.8
X$1387 75 732 643 368 452 94 94 75 sky130_fd_sc_hd__nor3b_2
* cell instance $1388 r0 *1 67.62,40.8
X$1388 94 561 75 643 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1393 r0 *1 72.22,40.8
X$1393 94 611 494 94 75 75 sky130_fd_sc_hd__clkinv_2
* cell instance $1395 r0 *1 77.74,40.8
X$1395 94 229 133 75 94 642 75 sky130_fd_sc_hd__nor2b_2
* cell instance $1396 r0 *1 80.96,40.8
X$1396 94 642 686 629 75 94 536 75 sky130_fd_sc_hd__o21a_2
* cell instance $1399 r0 *1 85.56,40.8
X$1399 94 131 94 75 663 75 sky130_fd_sc_hd__inv_1
* cell instance $1401 r0 *1 87.86,40.8
X$1401 94 495 516 127 630 75 685 94 75 sky130_fd_sc_hd__nor4b_1
* cell instance $1410 r0 *1 99.82,40.8
X$1410 94 641 643 368 684 75 94 75 sky130_fd_sc_hd__nand3b_1
* cell instance $1413 r0 *1 104.88,40.8
X$1413 94 368 420 682 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1416 r0 *1 113.62,40.8
X$1416 94 652 94 75 610 75 sky130_fd_sc_hd__buf_4
* cell instance $1418 r0 *1 117.3,40.8
X$1418 75 578 652 498 476 94 94 75 sky130_fd_sc_hd__and3_1
* cell instance $1420 r0 *1 120.06,40.8
X$1420 94 510 577 219 645 75 668 94 75 sky130_fd_sc_hd__nor4b_1
* cell instance $1422 r0 *1 123.28,40.8
X$1422 94 669 644 716 709 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1425 r0 *1 126.04,40.8
X$1425 75 397 592 667 576 498 710 94 94 75 sky130_fd_sc_hd__o2111ai_4
* cell instance $1426 r0 *1 135.7,40.8
X$1426 75 476 289 398 577 94 94 75 sky130_fd_sc_hd__a21oi_4
* cell instance $1427 r0 *1 141.68,40.8
X$1427 94 618 405 398 94 542 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1429 r0 *1 144.44,40.8
X$1429 94 618 620 646 577 75 94 75 sky130_fd_sc_hd__or3b_2
* cell instance $1431 r0 *1 148.58,40.8
X$1431 94 362 646 585 398 75 94 75 sky130_fd_sc_hd__or3b_2
* cell instance $1433 r0 *1 151.8,40.8
X$1433 94 648 673 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1447 m0 *1 1.38,46.24
X$1447 94 769 711 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1449 m0 *1 3.68,46.24
X$1449 75 80 631 210 617 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1450 m0 *1 14.72,46.24
X$1450 94 631 597 567 94 746 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1451 m0 *1 16.56,46.24
X$1451 94 589 595 524 637 94 747 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1452 m0 *1 19.32,46.24
X$1452 94 589 712 524 639 94 655 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1454 m0 *1 23,46.24
X$1454 94 713 690 655 94 650 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1456 m0 *1 25.3,46.24
X$1456 94 631 633 678 94 690 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1457 m0 *1 27.14,46.24
X$1457 94 691 715 656 94 75 689 75 sky130_fd_sc_hd__o21ai_1
* cell instance $1459 m0 *1 29.44,46.24
X$1459 75 674 675 752 657 717 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $1461 m0 *1 34.5,46.24
X$1461 94 631 676 692 826 636 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $1463 m0 *1 38.18,46.24
X$1463 94 693 718 677 94 75 658 75 sky130_fd_sc_hd__o21ai_1
* cell instance $1464 m0 *1 40.02,46.24
X$1464 94 776 660 659 94 75 148 75 sky130_fd_sc_hd__o21ai_1
* cell instance $1465 m0 *1 41.86,46.24
X$1465 75 461 680 719 657 661 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $1467 m0 *1 47.38,46.24
X$1467 75 721 104 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $1469 m0 *1 57.04,46.24
X$1469 75 161 600 778 657 662 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $1470 m0 *1 61.64,46.24
X$1470 94 695 640 731 94 75 155 75 sky130_fd_sc_hd__o21ai_1
* cell instance $1471 m0 *1 63.48,46.24
X$1471 75 733 308 641 561 94 94 75 sky130_fd_sc_hd__nor3b_2
* cell instance $1473 m0 *1 69,46.24
X$1473 94 723 75 352 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1476 m0 *1 74.52,46.24
X$1476 75 133 516 734 131 94 94 75 sky130_fd_sc_hd__nor3b_4
* cell instance $1478 m0 *1 82.34,46.24
X$1478 94 663 697 516 686 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1480 m0 *1 84.64,46.24
X$1480 94 127 94 75 697 75 sky130_fd_sc_hd__inv_1
* cell instance $1481 m0 *1 86.02,46.24
X$1481 75 726 135 663 697 516 94 94 75 sky130_fd_sc_hd__nor4_2
* cell instance $1484 m0 *1 95.22,46.24
X$1484 94 642 266 131 685 94 665 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $1485 m0 *1 97.52,46.24
X$1485 94 643 368 641 664 94 75 75 sky130_fd_sc_hd__or3b_1
* cell instance $1486 m0 *1 100.74,46.24
X$1486 94 308 420 664 684 94 725 75 75 sky130_fd_sc_hd__a211o_1
* cell instance $1488 m0 *1 104.88,46.24
X$1488 94 724 736 702 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1489 m0 *1 106.26,46.24
X$1489 94 308 641 700 703 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1490 m0 *1 108.1,46.24
X$1490 75 828 441 435 722 94 94 75 sky130_fd_sc_hd__mux2i_1
* cell instance $1493 m0 *1 113.16,46.24
X$1493 94 581 668 682 703 94 666 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1494 m0 *1 115.92,46.24
X$1494 94 418 704 666 665 94 623 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $1496 m0 *1 119.14,46.24
X$1496 94 669 644 706 681 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1497 m0 *1 120.98,46.24
X$1497 94 624 581 645 679 75 707 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1498 m0 *1 123.74,46.24
X$1498 94 618 358 614 75 94 75 sky130_fd_sc_hd__nand2b_1
* cell instance $1499 m0 *1 126.04,46.24
X$1499 75 397 592 692 578 498 710 94 94 75 sky130_fd_sc_hd__o2111ai_4
* cell instance $1500 m0 *1 135.7,46.24
X$1500 94 498 219 94 75 75 sky130_fd_sc_hd__clkinv_2
* cell instance $1501 m0 *1 137.54,46.24
X$1501 94 498 75 241 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1503 m0 *1 139.84,46.24
X$1503 94 646 94 75 358 75 sky130_fd_sc_hd__buf_4
* cell instance $1504 m0 *1 142.6,46.24
X$1504 75 138 646 224 170 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1505 r0 *1 1.38,46.24
X$1505 94 688 743 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1506 r0 *1 2.76,46.24
X$1506 94 687 94 688 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1507 r0 *1 6.44,46.24
X$1507 94 653 94 607 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1508 r0 *1 10.12,46.24
X$1508 94 658 744 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1509 r0 *1 11.5,46.24
X$1509 94 689 727 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1516 r0 *1 15.64,46.24
X$1516 94 745 746 747 94 649 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1517 r0 *1 17.48,46.24
X$1517 94 749 750 748 94 75 442 75 sky130_fd_sc_hd__o21ai_1
* cell instance $1518 r0 *1 19.32,46.24
X$1518 94 474 595 444 637 94 750 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1519 r0 *1 22.08,46.24
X$1519 94 535 632 751 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1520 r0 *1 23.46,46.24
X$1520 94 381 633 678 94 656 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1521 r0 *1 25.3,46.24
X$1521 94 474 638 444 639 94 715 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1522 r0 *1 28.06,46.24
X$1522 94 381 676 692 729 752 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $1523 r0 *1 30.82,46.24
X$1523 94 111 94 75 2161 75 sky130_fd_sc_hd__clkinvlp_4
* cell instance $1524 r0 *1 33.58,46.24
X$1524 75 728 729 753 819 550 774 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $1526 r0 *1 37.26,46.24
X$1526 94 103 676 692 829 719 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $1527 r0 *1 40.02,46.24
X$1527 94 227 638 462 639 94 718 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1532 r0 *1 43.24,46.24
X$1532 94 694 292 730 469 75 693 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1534 r0 *1 46.46,46.24
X$1534 94 205 633 678 94 731 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1535 r0 *1 48.3,46.24
X$1535 94 164 94 75 75 sky130_fd_sc_hd__inv_6
* cell instance $1536 r0 *1 51.52,46.24
X$1536 75 721 164 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $1539 r0 *1 65.32,46.24
X$1539 94 733 732 370 75 723 94 75 sky130_fd_sc_hd__o21ai_2
* cell instance $1546 r0 *1 71.3,46.24
X$1546 75 467 494 723 696 94 94 75 sky130_fd_sc_hd__a21oi_4
* cell instance $1549 r0 *1 78.66,46.24
X$1549 75 629 734 229 571 94 728 94 75 sky130_fd_sc_hd__o211ai_4
* cell instance $1551 r0 *1 86.94,46.24
X$1551 75 735 777 229 697 698 630 94 94 75 sky130_fd_sc_hd__a311oi_2
* cell instance $1553 r0 *1 92.92,46.24
X$1553 94 266 495 698 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1558 r0 *1 96.14,46.24
X$1558 94 266 495 603 705 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1561 r0 *1 102.12,46.24
X$1561 94 736 699 496 643 94 700 75 75 sky130_fd_sc_hd__nand4b_1
* cell instance $1562 r0 *1 105.34,46.24
X$1562 75 721 91 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $1563 r0 *1 114.54,46.24
X$1563 94 701 682 699 702 75 755 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1564 r0 *1 117.3,46.24
X$1564 94 755 735 707 434 75 720 94 75 sky130_fd_sc_hd__nor4_1
* cell instance $1565 r0 *1 119.6,46.24
X$1565 94 508 510 241 773 75 94 737 75 sky130_fd_sc_hd__a31oi_1
* cell instance $1566 r0 *1 121.9,46.24
X$1566 94 705 709 340 737 94 363 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $1570 r0 *1 124.2,46.24
X$1570 94 644 708 714 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1572 r0 *1 126.04,46.24
X$1572 94 669 794 708 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1573 r0 *1 127.42,46.24
X$1573 75 397 592 754 508 498 710 94 94 75 sky130_fd_sc_hd__o2111ai_4
* cell instance $1574 r0 *1 137.08,46.24
X$1574 75 358 362 592 618 94 94 75 sky130_fd_sc_hd__nor3b_4
* cell instance $1575 r0 *1 143.98,46.24
X$1575 94 669 644 738 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1577 r0 *1 145.82,46.24
X$1577 94 670 94 75 497 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $1579 r0 *1 148.12,46.24
X$1579 94 767 94 75 615 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $1580 r0 *1 149.96,46.24
X$1580 94 741 742 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1584 r0 *1 151.34,46.24
X$1584 94 671 94 75 435 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $1586 m0 *1 1.38,51.68
X$1586 94 756 94 769 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1587 m0 *1 5.06,51.68
X$1587 75 275 802 210 743 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1588 m0 *1 16.1,51.68
X$1588 94 381 597 567 94 748 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1591 m0 *1 20.24,51.68
X$1591 94 634 757 758 803 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1593 m0 *1 23,51.68
X$1593 94 550 757 758 804 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1595 m0 *1 25.3,51.68
X$1595 94 634 772 759 805 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1596 m0 *1 27.14,51.68
X$1596 94 550 772 759 807 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1599 m0 *1 31.28,51.68
X$1599 75 721 111 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $1600 m0 *1 40.48,51.68
X$1600 94 282 784 785 763 760 94 774 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $1601 m0 *1 43.7,51.68
X$1601 94 557 762 758 809 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1602 m0 *1 45.54,51.68
X$1602 94 694 322 761 469 75 695 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1603 m0 *1 48.3,51.68
X$1603 94 569 772 759 761 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1605 m0 *1 50.6,51.68
X$1605 94 569 762 758 810 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1607 m0 *1 52.9,51.68
X$1607 75 787 728 819 569 830 811 94 94 75 sky130_fd_sc_hd__o311ai_1
* cell instance $1610 m0 *1 57.04,51.68
X$1610 94 205 676 692 787 778 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $1611 m0 *1 59.8,51.68
X$1611 94 375 75 811 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1613 m0 *1 64.4,51.68
X$1613 94 732 94 75 763 75 sky130_fd_sc_hd__buf_4
* cell instance $1616 m0 *1 69.46,51.68
X$1616 94 696 723 813 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1617 m0 *1 71.76,51.68
X$1617 94 813 94 75 383 75 sky130_fd_sc_hd__buf_4
* cell instance $1618 m0 *1 74.52,51.68
X$1618 75 629 734 229 572 94 762 94 75 sky130_fd_sc_hd__o211ai_4
* cell instance $1623 m0 *1 86.02,51.68
X$1623 94 663 516 734 75 94 777 75 sky130_fd_sc_hd__a21o_1
* cell instance $1626 m0 *1 91.54,51.68
X$1626 75 152 764 681 788 698 94 94 75 sky130_fd_sc_hd__o211ai_2
* cell instance $1628 m0 *1 96.6,51.68
X$1628 94 775 736 724 612 75 94 788 75 sky130_fd_sc_hd__a31oi_1
* cell instance $1630 m0 *1 99.82,51.68
X$1630 75 699 775 789 725 94 94 75 sky130_fd_sc_hd__ha_2
* cell instance $1631 m0 *1 105.34,51.68
X$1631 75 91 94 94 75 sky130_fd_sc_hd__clkinv_8
* cell instance $1634 m0 *1 112.24,51.68
X$1634 75 736 773 724 790 94 94 75 sky130_fd_sc_hd__and3_1
* cell instance $1636 m0 *1 115.46,51.68
X$1636 75 392 94 94 75 sky130_fd_sc_hd__clkinv_8
* cell instance $1637 m0 *1 121.44,51.68
X$1637 75 856 241 508 476 94 94 75 sky130_fd_sc_hd__nand3_2
* cell instance $1638 m0 *1 125.12,51.68
X$1638 75 508 1060 498 476 94 94 75 sky130_fd_sc_hd__and3_1
* cell instance $1639 m0 *1 127.42,51.68
X$1639 94 792 94 75 797 75 sky130_fd_sc_hd__inv_1
* cell instance $1640 m0 *1 128.8,51.68
X$1640 75 620 618 710 358 94 94 75 sky130_fd_sc_hd__nor3b_4
* cell instance $1642 m0 *1 136.16,51.68
X$1642 75 244 720 738 765 771 794 94 94 75 sky130_fd_sc_hd__o41ai_1
* cell instance $1644 m0 *1 139.84,51.68
X$1644 94 740 765 714 704 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1646 m0 *1 142.6,51.68
X$1646 75 808 766 770 796 669 412 94 94 75 sky130_fd_sc_hd__o32a_1
* cell instance $1647 m0 *1 146.28,51.68
X$1647 94 471 797 669 94 796 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1648 m0 *1 148.12,51.68
X$1648 94 768 94 75 601 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $1649 m0 *1 149.96,51.68
X$1649 94 799 94 538 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1650 r0 *1 1.38,51.68
X$1650 94 815 780 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1651 r0 *1 2.76,51.68
X$1651 94 800 779 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1652 r0 *1 4.14,51.68
X$1652 75 138 801 210 711 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1656 r0 *1 16.1,51.68
X$1656 94 781 282 804 782 75 749 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1657 r0 *1 18.86,51.68
X$1657 94 781 319 803 782 75 745 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1658 r0 *1 21.62,51.68
X$1658 94 783 319 805 806 75 713 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1661 r0 *1 25.76,51.68
X$1661 94 783 282 807 806 75 691 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1663 r0 *1 28.98,51.68
X$1663 75 721 210 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $1664 r0 *1 38.18,51.68
X$1664 94 319 784 785 763 760 94 827 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $1669 r0 *1 43.24,51.68
X$1669 94 292 784 785 763 760 94 855 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $1670 r0 *1 46.46,51.68
X$1670 94 786 292 809 451 75 776 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1672 r0 *1 50.14,51.68
X$1672 94 786 322 810 451 75 812 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1673 r0 *1 52.9,51.68
X$1673 94 322 784 785 763 760 94 830 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $1675 r0 *1 57.04,51.68
X$1675 94 375 75 753 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1677 r0 *1 60.72,51.68
X$1677 94 858 94 75 785 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $1678 r0 *1 62.56,51.68
X$1678 75 831 790 370 696 732 733 94 94 75 sky130_fd_sc_hd__o2111a_2
* cell instance $1680 r0 *1 67.62,51.68
X$1680 94 370 94 75 784 75 sky130_fd_sc_hd__buf_4
* cell instance $1684 r0 *1 71.3,51.68
X$1684 75 629 734 229 603 94 772 94 75 sky130_fd_sc_hd__o211ai_4
* cell instance $1685 r0 *1 79.12,51.68
X$1685 75 734 229 629 611 94 94 75 sky130_fd_sc_hd__o21ai_4
* cell instance $1687 r0 *1 85.56,51.68
X$1687 94 571 94 75 764 75 sky130_fd_sc_hd__clkinvlp_4
* cell instance $1690 r0 *1 91.08,51.68
X$1690 94 513 75 597 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1695 r0 *1 98.44,51.68
X$1695 75 789 790 722 94 94 75 sky130_fd_sc_hd__ha_4
* cell instance $1696 r0 *1 107.64,51.68
X$1696 75 861 497 389 722 94 94 75 sky130_fd_sc_hd__mux2i_1
* cell instance $1697 r0 *1 111.32,51.68
X$1697 75 791 197 166 284 94 94 75 sky130_fd_sc_hd__and3_4
* cell instance $1698 r0 *1 115.46,51.68
X$1698 75 721 392 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $1702 r0 *1 126.04,51.68
X$1702 75 792 669 429 476 219 94 94 75 sky130_fd_sc_hd__a211oi_4
* cell instance $1703 r0 *1 133.4,51.68
X$1703 75 794 706 793 771 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1704 r0 *1 138,51.68
X$1704 75 766 740 389 793 435 795 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $1705 r0 *1 141.22,51.68
X$1705 75 395 625 392 808 94 94 75 sky130_fd_sc_hd__dfrtp_1
* cell instance $1707 r0 *1 150.42,51.68
X$1707 94 791 824 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1708 r0 *1 151.8,51.68
X$1708 94 996 798 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1724 m0 *1 2.76,57.12
X$1724 94 832 94 834 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1725 m0 *1 6.44,57.12
X$1725 94 838 864 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1726 m0 *1 7.82,57.12
X$1726 94 834 847 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1730 m0 *1 12.42,57.12
X$1730 94 893 814 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1731 m0 *1 13.8,57.12
X$1731 94 261 597 836 94 816 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1732 m0 *1 15.64,57.12
X$1732 94 817 816 825 94 815 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1733 m0 *1 17.48,57.12
X$1733 94 366 595 333 637 94 825 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1734 m0 *1 20.24,57.12
X$1734 94 781 200 818 782 75 817 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1735 m0 *1 23,57.12
X$1735 94 751 757 758 818 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1737 m0 *1 25.3,57.12
X$1737 94 802 240 851 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1739 m0 *1 27.14,57.12
X$1739 94 366 610 852 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1744 m0 *1 33.58,57.12
X$1744 75 826 728 819 634 827 753 94 94 75 sky130_fd_sc_hd__o311ai_1
* cell instance $1747 m0 *1 41.4,57.12
X$1747 75 728 829 753 819 557 855 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $1748 m0 *1 44.62,57.12
X$1748 94 557 772 759 730 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1751 m0 *1 49.22,57.12
X$1751 94 831 75 759 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1758 m0 *1 60.26,57.12
X$1758 75 841 733 732 785 370 94 94 75 sky130_fd_sc_hd__o211a_1
* cell instance $1759 m0 *1 63.94,57.12
X$1759 94 696 775 858 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1760 m0 *1 66.24,57.12
X$1760 94 733 94 75 760 75 sky130_fd_sc_hd__buf_4
* cell instance $1763 m0 *1 74.52,57.12
X$1763 94 496 641 775 862 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1764 m0 *1 76.36,57.12
X$1764 75 734 350 229 131 94 984 94 75 sky130_fd_sc_hd__nand4_4
* cell instance $1766 m0 *1 84.64,57.12
X$1766 94 696 75 311 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1769 m0 *1 87.86,57.12
X$1769 94 311 75 724 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1772 m0 *1 97.06,57.12
X$1772 75 2166 863 725 820 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1773 m0 *1 101.66,57.12
X$1773 94 820 94 75 789 75 sky130_fd_sc_hd__inv_1
* cell instance $1775 m0 *1 103.5,57.12
X$1775 94 725 94 75 722 75 sky130_fd_sc_hd__clkinvlp_4
* cell instance $1777 m0 *1 108.1,57.12
X$1777 75 859 861 828 820 94 94 75 sky130_fd_sc_hd__mux2i_1
* cell instance $1780 m0 *1 112.7,57.12
X$1780 75 395 821 392 881 94 94 75 sky130_fd_sc_hd__dfrtp_1
* cell instance $1782 m0 *1 122.36,57.12
X$1782 94 821 94 75 696 75 sky130_fd_sc_hd__buf_4
* cell instance $1783 m0 *1 125.12,57.12
X$1783 75 436 795 822 706 669 854 94 94 75 sky130_fd_sc_hd__o2111ai_4
* cell instance $1784 m0 *1 134.78,57.12
X$1784 94 854 795 436 75 792 94 75 sky130_fd_sc_hd__o21ai_2
* cell instance $1785 m0 *1 138,57.12
X$1785 94 771 94 75 740 75 sky130_fd_sc_hd__inv_1
* cell instance $1787 m0 *1 139.84,57.12
X$1787 75 75 792 286 669 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $1788 m0 *1 142.14,57.12
X$1788 94 497 771 850 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1789 m0 *1 143.52,57.12
X$1789 94 625 94 75 669 75 sky130_fd_sc_hd__buf_4
* cell instance $1790 m0 *1 146.28,57.12
X$1790 75 412 275 573 166 94 94 75 sky130_fd_sc_hd__and3_4
* cell instance $1792 m0 *1 150.88,57.12
X$1792 94 823 94 75 848 75 sky130_fd_sc_hd__buf_4
* cell instance $1793 r0 *1 1.38,57.12
X$1793 94 846 865 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1794 r0 *1 2.76,57.12
X$1794 94 835 833 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1797 r0 *1 15.64,57.12
X$1797 94 366 712 333 639 94 874 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1798 r0 *1 18.4,57.12
X$1798 94 783 200 873 806 75 849 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1799 r0 *1 21.16,57.12
X$1799 94 849 837 874 94 835 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1801 r0 *1 23.92,57.12
X$1801 94 261 875 678 94 837 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1803 r0 *1 26.22,57.12
X$1803 94 851 299 866 75 94 800 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1804 r0 *1 28.06,57.12
X$1804 94 852 853 657 839 75 94 838 75 sky130_fd_sc_hd__a31oi_1
* cell instance $1805 r0 *1 30.36,57.12
X$1805 94 333 878 839 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1806 r0 *1 31.74,57.12
X$1806 94 249 346 880 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $1808 r0 *1 33.58,57.12
X$1808 94 261 676 692 883 853 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $1809 r0 *1 36.34,57.12
X$1809 94 200 784 840 763 760 94 884 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $1816 r0 *1 43.7,57.12
X$1816 94 785 75 840 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1818 r0 *1 46.92,57.12
X$1818 94 594 94 75 265 75 sky130_fd_sc_hd__buf_4
* cell instance $1822 r0 *1 56.12,57.12
X$1822 94 841 75 819 94 75 sky130_fd_sc_hd__buf_2
* cell instance $1823 r0 *1 57.96,57.12
X$1823 94 841 75 886 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1824 r0 *1 60.72,57.12
X$1824 94 785 75 860 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1827 r0 *1 65.78,57.12
X$1827 75 75 842 594 696 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $1833 r0 *1 71.3,57.12
X$1833 94 696 842 908 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1834 r0 *1 73.6,57.12
X$1834 94 352 862 811 94 887 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1837 r0 *1 76.82,57.12
X$1837 75 784 763 868 867 311 760 94 94 75 sky130_fd_sc_hd__o2111ai_4
* cell instance $1840 r0 *1 93.84,57.12
X$1840 94 526 75 266 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1845 r0 *1 98.44,57.12
X$1845 75 736 842 863 885 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1846 r0 *1 103.04,57.12
X$1846 94 867 775 842 790 75 845 94 75 sky130_fd_sc_hd__nor4_1
* cell instance $1849 r0 *1 109.48,57.12
X$1849 94 724 471 843 877 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1850 r0 *1 111.32,57.12
X$1850 94 791 843 845 844 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1851 r0 *1 113.16,57.12
X$1851 94 857 859 844 75 94 881 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1852 r0 *1 115,57.12
X$1852 94 724 284 877 94 857 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1854 r0 *1 117.3,57.12
X$1854 94 476 219 797 573 876 75 94 75 sky130_fd_sc_hd__o22ai_1
* cell instance $1855 r0 *1 119.6,57.12
X$1855 75 92 94 94 75 sky130_fd_sc_hd__clkinv_8
* cell instance $1858 r0 *1 126.04,57.12
X$1858 75 721 92 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $1859 r0 *1 135.24,57.12
X$1859 75 644 872 871 797 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1860 r0 *1 139.84,57.12
X$1860 75 587 770 765 850 94 94 75 sky130_fd_sc_hd__and3_1
* cell instance $1861 r0 *1 142.14,57.12
X$1861 75 275 823 224 575 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1877 m0 *1 2.3,62.56
X$1877 75 80 892 210 890 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $1880 m0 *1 14.72,62.56
X$1880 94 892 597 836 94 930 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1881 m0 *1 16.56,62.56
X$1881 94 801 595 802 637 94 932 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1884 m0 *1 21.62,62.56
X$1884 94 751 902 759 873 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1888 m0 *1 29.44,62.56
X$1888 94 905 801 212 75 94 866 75 sky130_fd_sc_hd__a21oi_1
* cell instance $1889 m0 *1 31.28,62.56
X$1889 94 892 313 906 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $1891 m0 *1 33.58,62.56
X$1891 75 907 883 753 819 751 884 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $1892 m0 *1 36.8,62.56
X$1892 94 594 94 75 566 75 sky130_fd_sc_hd__buf_4
* cell instance $1903 m0 *1 63.48,62.56
X$1903 94 496 308 775 943 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1906 m0 *1 66.7,62.56
X$1906 94 352 75 843 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1909 m0 *1 72.22,62.56
X$1909 94 908 94 75 310 75 sky130_fd_sc_hd__clkbuf_2
* cell instance $1919 m0 *1 97.52,62.56
X$1919 94 843 94 75 885 75 sky130_fd_sc_hd__inv_1
* cell instance $1920 m0 *1 98.9,62.56
X$1920 75 2164 867 820 722 94 94 75 sky130_fd_sc_hd__ha_2
* cell instance $1922 m0 *1 106.26,62.56
X$1922 94 124 382 384 882 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1924 m0 *1 108.56,62.56
X$1924 94 358 879 869 131 266 894 75 94 75 sky130_fd_sc_hd__a32oi_1
* cell instance $1926 m0 *1 112.24,62.56
X$1926 94 894 904 903 882 75 279 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1927 m0 *1 115,62.56
X$1927 94 876 94 75 384 75 sky130_fd_sc_hd__buf_4
* cell instance $1928 m0 *1 117.76,62.56
X$1928 94 876 94 75 895 75 sky130_fd_sc_hd__buf_4
* cell instance $1929 m0 *1 120.52,62.56
X$1929 75 224 94 94 75 sky130_fd_sc_hd__inv_8
* cell instance $1930 m0 *1 124.66,62.56
X$1930 75 721 224 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $1931 m0 *1 133.86,62.56
X$1931 75 2168 871 793 740 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1934 m0 *1 139.84,62.56
X$1934 75 2170 901 898 740 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $1935 m0 *1 144.44,62.56
X$1935 94 404 75 924 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1936 m0 *1 147.2,62.56
X$1936 94 900 75 896 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $1937 m0 *1 149.96,62.56
X$1937 94 899 94 648 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1938 r0 *1 1.38,62.56
X$1938 94 891 890 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1939 r0 *1 2.76,62.56
X$1939 94 889 94 891 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1940 r0 *1 6.44,62.56
X$1940 94 888 94 928 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1941 r0 *1 10.12,62.56
X$1941 94 928 927 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1943 r0 *1 13.34,62.56
X$1943 94 929 910 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $1947 r0 *1 15.64,62.56
X$1947 94 913 930 932 94 893 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1949 r0 *1 17.94,62.56
X$1949 94 781 249 914 782 75 913 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $1950 r0 *1 20.7,62.56
X$1950 94 955 757 758 914 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1953 r0 *1 25.3,62.56
X$1953 94 563 870 917 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1954 r0 *1 27.6,62.56
X$1954 94 801 429 802 411 94 915 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $1955 r0 *1 30.36,62.56
X$1955 94 304 917 265 919 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1956 r0 *1 32.2,62.56
X$1956 94 919 880 906 234 268 94 905 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $1958 r0 *1 37.26,62.56
X$1958 94 527 94 75 304 75 sky130_fd_sc_hd__buf_4
* cell instance $1966 r0 *1 46.46,62.56
X$1966 94 563 127 1161 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $1971 r0 *1 61.64,62.56
X$1971 94 496 643 775 941 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1972 r0 *1 63.48,62.56
X$1972 94 352 943 811 94 942 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1981 r0 *1 74.06,62.56
X$1981 94 887 951 949 94 945 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $1982 r0 *1 75.9,62.56
X$1982 94 692 811 204 94 949 75 75 sky130_fd_sc_hd__o21a_1
* cell instance $1986 r0 *1 85.1,62.56
X$1986 94 952 922 895 514 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $1990 r0 *1 92.92,62.56
X$1990 94 496 641 867 950 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $1998 r0 *1 102.58,62.56
X$1998 94 496 641 790 947 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $2001 r0 *1 109.02,62.56
X$2001 94 843 643 411 724 922 94 904 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $2003 r0 *1 112.7,62.56
X$2003 94 358 411 272 923 94 75 903 75 sky130_fd_sc_hd__o31ai_1
* cell instance $2004 r0 *1 115.46,62.56
X$2004 94 219 476 879 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2005 r0 *1 116.84,62.56
X$2005 94 724 94 75 791 75 sky130_fd_sc_hd__inv_1
* cell instance $2007 r0 *1 119.14,62.56
X$2007 94 896 924 925 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2008 r0 *1 120.52,62.56
X$2008 94 573 897 848 925 94 923 75 75 sky130_fd_sc_hd__a211o_1
* cell instance $2010 r0 *1 123.74,62.56
X$2010 94 573 797 939 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2014 r0 *1 126.96,62.56
X$2014 75 854 938 848 897 94 94 75 sky130_fd_sc_hd__nor3b_2
* cell instance $2016 r0 *1 132.02,62.56
X$2016 94 848 897 896 935 75 94 75 sky130_fd_sc_hd__nand3b_1
* cell instance $2017 r0 *1 134.78,62.56
X$2017 75 872 669 94 464 94 75 sky130_fd_sc_hd__nand2_8
* cell instance $2018 r0 *1 142.14,62.56
X$2018 75 275 900 224 673 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2033 m0 *1 1.38,68
X$2033 75 80 961 210 927 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2035 m0 *1 13.34,68
X$2035 94 912 909 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2036 m0 *1 14.72,68
X$2036 94 801 712 802 639 94 931 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2039 m0 *1 19.78,68
X$2039 94 963 911 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2042 m0 *1 23.46,68
X$2042 94 892 382 936 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2043 m0 *1 24.84,68
X$2043 94 535 870 955 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2044 m0 *1 26.22,68
X$2044 94 384 937 936 915 94 75 846 75 sky130_fd_sc_hd__o31ai_1
* cell instance $2046 m0 *1 29.44,68
X$2046 94 801 610 916 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2047 m0 *1 30.82,68
X$2047 94 916 967 657 918 75 94 912 75 sky130_fd_sc_hd__a31oi_1
* cell instance $2048 m0 *1 33.12,68
X$2048 94 802 878 918 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2053 m0 *1 43.24,68
X$2053 94 594 75 1160 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2054 m0 *1 46,68
X$2054 94 565 94 75 657 75 sky130_fd_sc_hd__buf_4
* cell instance $2057 m0 *1 50.14,68
X$2057 75 963 968 920 921 940 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $2058 m0 *1 54.74,68
X$2058 94 938 878 940 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2062 m0 *1 58.88,68
X$2062 94 843 941 676 94 1009 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2064 m0 *1 62.56,68
X$2064 94 942 957 944 94 920 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2065 m0 *1 64.4,68
X$2065 94 692 811 239 94 944 75 75 sky130_fd_sc_hd__o21a_1
* cell instance $2066 m0 *1 67.16,68
X$2066 75 158 946 945 921 948 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $2067 m0 *1 71.76,68
X$2067 94 848 878 948 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2075 m0 *1 92.92,68
X$2075 94 352 950 513 94 966 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2079 m0 *1 103.04,68
X$2079 94 843 947 633 94 965 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2087 m0 *1 116.84,68
X$2087 75 667 637 595 94 94 75 sky130_fd_sc_hd__nor2_8
* cell instance $2088 m0 *1 124.2,68
X$2088 75 639 754 638 94 94 75 sky130_fd_sc_hd__nor2_8
* cell instance $2089 m0 *1 131.56,68
X$2089 94 625 716 964 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2090 m0 *1 132.94,68
X$2090 75 2167 716 898 771 94 94 75 sky130_fd_sc_hd__ha_1
* cell instance $2091 m0 *1 137.54,68
X$2091 94 625 901 934 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2094 m0 *1 139.84,68
X$2094 75 75 771 94 924 933 94 sky130_fd_sc_hd__nor2_2
* cell instance $2095 m0 *1 142.14,68
X$2095 75 275 960 224 962 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2098 r0 *1 1.84,68
X$2098 94 994 972 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2099 r0 *1 3.22,68
X$2099 94 969 94 994 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2100 r0 *1 6.9,68
X$2100 94 971 94 995 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2102 r0 *1 11.5,68
X$2102 94 892 875 973 94 974 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2103 r0 *1 13.34,68
X$2103 94 954 974 931 94 975 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2106 r0 *1 15.64,68
X$2106 94 975 953 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2107 r0 *1 17.02,68
X$2107 94 783 249 976 806 75 954 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $2110 r0 *1 21.16,68
X$2110 94 955 902 759 976 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2113 r0 *1 25.76,68
X$2113 75 937 977 249 428 917 383 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $2114 r0 *1 28.98,68
X$2114 94 678 75 973 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2115 r0 *1 31.74,68
X$2115 75 907 980 753 819 955 1001 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $2116 r0 *1 34.96,68
X$2116 94 527 75 1020 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2119 r0 *1 40.02,68
X$2119 94 527 94 75 628 75 sky130_fd_sc_hd__buf_4
* cell instance $2124 r0 *1 45.54,68
X$2124 94 358 956 1003 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2126 r0 *1 50.6,68
X$2126 94 620 956 968 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2131 r0 *1 58.88,68
X$2131 94 764 981 984 1007 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2134 r0 *1 65.32,68
X$2134 94 618 956 946 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2137 r0 *1 68.08,68
X$2137 94 982 611 764 981 75 957 94 75 sky130_fd_sc_hd__nor4_1
* cell instance $2141 r0 *1 74.52,68
X$2141 94 958 611 764 981 75 951 94 75 sky130_fd_sc_hd__nor4_1
* cell instance $2144 r0 *1 78.2,68
X$2144 94 611 958 985 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2150 r0 *1 95.22,68
X$2150 94 270 94 75 922 75 sky130_fd_sc_hd__buf_4
* cell instance $2157 r0 *1 108.56,68
X$2157 94 724 643 790 988 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $2158 r0 *1 110.4,68
X$2158 94 843 988 633 94 1004 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2162 r0 *1 120.52,68
X$2162 94 989 754 94 678 75 75 sky130_fd_sc_hd__and2_2
* cell instance $2165 r0 *1 124.2,68
X$2165 94 990 962 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2168 r0 *1 126.5,68
X$2168 75 933 998 639 964 924 94 94 75 sky130_fd_sc_hd__a211oi_4
* cell instance $2169 r0 *1 133.86,68
X$2169 94 938 924 933 935 94 793 75 75 sky130_fd_sc_hd__a211o_1
* cell instance $2170 r0 *1 137.08,68
X$2170 75 765 924 896 998 997 94 94 75 sky130_fd_sc_hd__a211oi_2
* cell instance $2171 r0 *1 141.68,68
X$2171 75 795 897 896 848 94 94 75 sky130_fd_sc_hd__nor3b_2
* cell instance $2173 r0 *1 146.74,68
X$2173 94 1061 94 75 620 75 sky130_fd_sc_hd__buf_4
* cell instance $2174 r0 *1 149.5,68
X$2174 94 959 94 996 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2189 m0 *1 1.38,73.44
X$2189 94 995 1012 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2191 m0 *1 3.22,73.44
X$2191 94 1013 1010 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2192 m0 *1 15.64,73.44
X$2192 94 961 597 836 94 1035 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2193 m0 *1 17.48,73.44
X$2193 94 1005 970 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2196 m0 *1 21.62,73.44
X$2196 94 961 382 1036 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2197 m0 *1 23,73.44
X$2197 94 567 75 836 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2199 m0 *1 27.6,73.44
X$2199 94 1016 240 1000 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2202 m0 *1 29.9,73.44
X$2202 94 978 346 1039 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2203 m0 *1 31.28,73.44
X$2203 94 892 979 1002 980 967 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $2206 m0 *1 38.64,73.44
X$2206 75 610 956 94 94 75 sky130_fd_sc_hd__buf_6
* cell instance $2209 m0 *1 45.08,73.44
X$2209 75 1005 1003 1021 921 1006 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $2210 m0 *1 49.68,73.44
X$2210 94 897 878 1006 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2216 m0 *1 59.8,73.44
X$2216 94 1007 1009 1008 94 1021 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2219 m0 *1 67.16,73.44
X$2219 94 350 133 982 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2221 m0 *1 69,73.44
X$2221 94 352 496 982 494 75 983 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $2223 m0 *1 72.68,73.44
X$2223 94 352 496 958 494 75 1045 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $2224 m0 *1 75.44,73.44
X$2224 94 350 516 958 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2225 m0 *1 76.82,73.44
X$2225 94 204 973 875 94 75 1023 75 sky130_fd_sc_hd__o21ai_1
* cell instance $2230 m0 *1 85.56,73.44
X$2230 94 270 94 75 1046 75 sky130_fd_sc_hd__buf_4
* cell instance $2234 m0 *1 91.54,73.44
X$2234 94 868 985 572 966 75 94 1022 75 sky130_fd_sc_hd__a31oi_1
* cell instance $2238 m0 *1 98.9,73.44
X$2238 94 984 759 603 1024 75 94 75 sky130_fd_sc_hd__nor3b_1
* cell instance $2239 m0 *1 101.66,73.44
X$2239 94 1043 985 603 965 75 94 986 75 sky130_fd_sc_hd__a31oi_1
* cell instance $2242 m0 *1 106.72,73.44
X$2242 94 986 987 1023 94 75 1038 75 sky130_fd_sc_hd__o21ai_1
* cell instance $2243 m0 *1 108.56,73.44
X$2243 94 856 1024 633 124 1004 1041 94 75 75 sky130_fd_sc_hd__o221ai_1
* cell instance $2246 m0 *1 115.92,73.44
X$2246 94 1028 618 638 75 94 987 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2248 m0 *1 118.22,73.44
X$2248 94 667 1027 94 567 75 75 sky130_fd_sc_hd__and2_2
* cell instance $2250 m0 *1 121.44,73.44
X$2250 94 897 989 1028 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2252 m0 *1 123.74,73.44
X$2252 94 1028 1041 1070 75 94 999 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2254 m0 *1 126.5,73.44
X$2254 75 933 998 637 934 924 94 94 75 sky130_fd_sc_hd__a211oi_4
* cell instance $2256 m0 *1 134.78,73.44
X$2256 94 793 94 75 898 75 sky130_fd_sc_hd__inv_1
* cell instance $2257 m0 *1 136.16,73.44
X$2257 94 1030 896 848 1037 94 75 75 sky130_fd_sc_hd__or3b_1
* cell instance $2259 m0 *1 139.84,73.44
X$2259 94 897 848 938 997 75 94 75 sky130_fd_sc_hd__nand3b_1
* cell instance $2260 m0 *1 142.6,73.44
X$2260 94 960 75 938 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2262 m0 *1 146.28,73.44
X$2262 94 926 94 990 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2263 m0 *1 149.96,73.44
X$2263 94 1034 94 1029 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2264 r0 *1 1.38,73.44
X$2264 75 138 1015 210 1012 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2271 r0 *1 15.64,73.44
X$2271 94 1049 1035 1064 94 1013 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2272 r0 *1 17.48,73.44
X$2272 94 781 978 1050 782 75 1049 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $2274 r0 *1 21.16,73.44
X$2274 94 1014 757 758 1050 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2275 r0 *1 23,73.44
X$2275 94 1014 94 75 1067 75 sky130_fd_sc_hd__inv_1
* cell instance $2276 r0 *1 24.38,73.44
X$2276 94 1015 429 1016 411 94 1051 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2278 r0 *1 27.6,73.44
X$2278 94 1000 299 1018 75 94 1068 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2279 r0 *1 29.44,73.44
X$2279 94 1019 1015 212 75 94 1018 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2280 r0 *1 31.28,73.44
X$2280 94 1052 1039 1040 234 268 94 1019 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $2282 r0 *1 35.42,73.44
X$2282 94 1020 350 1017 566 94 1052 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $2290 r0 *1 43.24,73.44
X$2290 94 511 94 75 212 75 sky130_fd_sc_hd__buf_4
* cell instance $2292 r0 *1 46.46,73.44
X$2292 94 467 75 977 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2293 r0 *1 49.22,73.44
X$2293 94 692 75 1002 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2296 r0 *1 54.28,73.44
X$2296 94 511 94 75 268 75 sky130_fd_sc_hd__buf_4
* cell instance $2300 r0 *1 60.26,73.44
X$2300 94 1020 350 516 566 94 1077 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $2301 r0 *1 62.56,73.44
X$2301 94 692 811 124 94 1008 75 75 sky130_fd_sc_hd__o21a_1
* cell instance $2311 r0 *1 72.22,73.44
X$2311 94 611 982 1079 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2314 r0 *1 74.98,73.44
X$2314 94 204 1055 1080 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2320 r0 *1 92,73.44
X$2320 94 724 643 867 1076 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $2327 r0 *1 98.44,73.44
X$2327 94 984 786 572 1044 75 94 75 sky130_fd_sc_hd__nor3b_1
* cell instance $2329 r0 *1 104.88,73.44
X$2329 94 567 75 1075 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2330 r0 *1 107.64,73.44
X$2330 94 643 94 75 1074 75 sky130_fd_sc_hd__inv_1
* cell instance $2332 r0 *1 112.7,73.44
X$2332 75 1025 1022 1073 1062 1026 94 94 75 sky130_fd_sc_hd__o31ai_2
* cell instance $2333 r0 *1 117.3,73.44
X$2333 94 1042 618 1096 75 94 1026 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2334 r0 *1 119.14,73.44
X$2334 94 897 1027 1042 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2335 r0 *1 120.52,73.44
X$2335 75 75 1027 1025 667 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $2336 r0 *1 122.82,73.44
X$2336 94 678 75 1069 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2342 r0 *1 127.88,73.44
X$2342 94 934 924 998 933 94 1027 75 75 sky130_fd_sc_hd__a211o_1
* cell instance $2343 r0 *1 131.1,73.44
X$2343 94 964 924 998 933 94 989 75 75 sky130_fd_sc_hd__a211o_1
* cell instance $2344 r0 *1 134.32,73.44
X$2344 94 1029 1031 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2345 r0 *1 135.7,73.44
X$2345 94 938 848 1030 1065 94 75 75 sky130_fd_sc_hd__or3b_1
* cell instance $2346 r0 *1 138.92,73.44
X$2346 94 1037 94 75 933 75 sky130_fd_sc_hd__buf_4
* cell instance $2347 r0 *1 141.68,73.44
X$2347 75 275 1030 224 1031 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2354 m0 *1 1.84,78.88
X$2354 94 1048 1047 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2355 m0 *1 3.22,78.88
X$2355 75 275 1016 1155 1104 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2356 m0 *1 14.26,78.88
X$2356 94 1015 712 1016 1085 94 1063 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2357 m0 *1 17.02,78.88
X$2357 94 1015 595 1016 1086 94 1064 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2359 m0 *1 20.7,78.88
X$2359 94 384 1066 1036 1051 94 75 1048 75 sky130_fd_sc_hd__o31ai_1
* cell instance $2361 m0 *1 24.38,78.88
X$2361 75 1066 977 978 1046 1067 383 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $2362 m0 *1 27.6,78.88
X$2362 94 1015 610 1107 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2365 m0 *1 30.36,78.88
X$2365 94 1016 878 1071 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2367 m0 *1 32.2,78.88
X$2367 94 961 313 1040 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2368 m0 *1 33.58,78.88
X$2368 94 526 1017 1014 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2371 m0 *1 39.1,78.88
X$2371 94 328 75 313 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2375 m0 *1 46.92,78.88
X$2375 94 368 1054 1147 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2377 m0 *1 49.22,78.88
X$2377 94 464 94 75 299 75 sky130_fd_sc_hd__buf_4
* cell instance $2382 m0 *1 60.72,78.88
X$2382 94 643 1054 1111 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2383 m0 *1 62.1,78.88
X$2383 94 641 1054 1081 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2384 m0 *1 63.48,78.88
X$2384 94 204 313 1112 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2387 m0 *1 72.22,78.88
X$2387 94 952 641 1045 428 75 1113 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $2388 m0 *1 74.98,78.88
X$2388 75 1127 721 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $2390 m0 *1 84.64,78.88
X$2390 94 939 94 75 1078 75 sky130_fd_sc_hd__buf_4
* cell instance $2391 m0 *1 87.4,78.88
X$2391 94 724 308 867 1114 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $2395 m0 *1 92.46,78.88
X$2395 94 843 1076 597 94 1092 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2399 m0 *1 97.52,78.88
X$2399 75 1075 1057 1044 1092 124 1056 94 94 75 sky130_fd_sc_hd__o221ai_2
* cell instance $2401 m0 *1 103.96,78.88
X$2401 94 939 94 75 411 75 sky130_fd_sc_hd__buf_4
* cell instance $2402 m0 *1 106.72,78.88
X$2402 94 1074 641 1109 75 94 701 75 sky130_fd_sc_hd__a21o_1
* cell instance $2403 m0 *1 109.48,78.88
X$2403 94 204 1056 1073 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2407 m0 *1 113.16,78.88
X$2407 94 896 565 1094 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2408 m0 *1 114.54,78.88
X$2408 94 565 610 1058 1094 75 94 1108 75 sky130_fd_sc_hd__a31oi_1
* cell instance $2409 m0 *1 116.84,78.88
X$2409 94 1058 595 1095 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2411 m0 *1 119.14,78.88
X$2411 75 1100 1095 1025 1072 1027 896 94 94 75 sky130_fd_sc_hd__o221a_1
* cell instance $2413 m0 *1 124.2,78.88
X$2413 94 1059 358 1060 75 94 1070 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2415 m0 *1 127.88,78.88
X$2415 94 639 75 1059 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2419 m0 *1 136.62,78.88
X$2419 94 1030 75 897 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2421 m0 *1 139.84,78.88
X$2421 94 1065 75 998 94 75 sky130_fd_sc_hd__buf_2
* cell instance $2423 m0 *1 142.14,78.88
X$2423 75 138 1061 224 1105 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2425 r0 *1 1.38,78.88
X$2425 94 1123 1116 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2426 r0 *1 2.76,78.88
X$2426 94 1117 1082 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2429 r0 *1 6.9,78.88
X$2429 94 1068 1011 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2431 r0 *1 10.12,78.88
X$2431 94 1084 1083 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2432 r0 *1 11.5,78.88
X$2432 94 961 875 973 94 1106 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2433 r0 *1 13.34,78.88
X$2433 94 1119 1106 1063 94 1084 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2439 r0 *1 24.84,78.88
X$2439 94 637 75 1086 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2441 r0 *1 29.44,78.88
X$2441 94 1107 1087 921 1071 75 94 1118 75 sky130_fd_sc_hd__a31oi_1
* cell instance $2442 r0 *1 31.74,78.88
X$2442 94 961 979 1002 1145 1087 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $2443 r0 *1 34.5,78.88
X$2443 94 429 94 75 1053 75 sky130_fd_sc_hd__buf_4
* cell instance $2444 r0 *1 37.26,78.88
X$2444 94 464 94 75 240 75 sky130_fd_sc_hd__buf_4
* cell instance $2445 r0 *1 40.02,78.88
X$2445 94 328 94 75 234 75 sky130_fd_sc_hd__buf_4
* cell instance $2449 r0 *1 43.7,78.88
X$2449 94 639 94 75 1085 75 sky130_fd_sc_hd__buf_4
* cell instance $2450 r0 *1 46.46,78.88
X$2450 94 896 240 1146 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2451 r0 *1 47.84,78.88
X$2451 75 1088 1181 1089 1117 1090 94 94 75 sky130_fd_sc_hd__o31ai_2
* cell instance $2452 r0 *1 52.44,78.88
X$2452 94 362 1053 896 1078 94 1090 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2455 r0 *1 60.72,78.88
X$2455 94 1077 1081 1112 1110 268 94 1187 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $2457 r0 *1 64.4,78.88
X$2457 94 848 240 1150 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2458 r0 *1 65.78,78.88
X$2458 75 618 1053 1091 848 1078 94 94 75 sky130_fd_sc_hd__a22oi_2
* cell instance $2461 r0 *1 70.84,78.88
X$2461 75 1091 87 1088 1113 1080 94 94 75 sky130_fd_sc_hd__o31ai_4
* cell instance $2472 r0 *1 100.74,78.88
X$2472 94 981 726 571 642 94 1184 75 75 sky130_fd_sc_hd__nand4b_1
* cell instance $2474 r0 *1 105.8,78.88
X$2474 94 368 759 1143 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2475 r0 *1 107.18,78.88
X$2475 94 165 1093 1142 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2478 r0 *1 114.08,78.88
X$2478 94 1108 1140 1139 94 1135 75 75 sky130_fd_sc_hd__o21a_1
* cell instance $2480 r0 *1 117.3,78.88
X$2480 94 362 94 75 1058 75 sky130_fd_sc_hd__inv_1
* cell instance $2481 r0 *1 118.68,78.88
X$2481 94 896 989 1138 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2482 r0 *1 120.06,78.88
X$2482 75 1138 1099 1069 1180 638 1058 94 94 75 sky130_fd_sc_hd__a221oi_2
* cell instance $2488 r0 *1 129.26,78.88
X$2488 94 637 94 75 1097 75 sky130_fd_sc_hd__buf_4
* cell instance $2491 r0 *1 134.32,78.88
X$2491 94 358 1096 897 1097 94 1098 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2492 r0 *1 137.08,78.88
X$2492 94 1057 1098 1136 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2495 r0 *1 140.76,78.88
X$2495 94 1038 991 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2496 r0 *1 142.14,78.88
X$2496 94 999 992 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2497 r0 *1 143.52,78.88
X$2497 94 1062 1032 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2498 r0 *1 144.9,78.88
X$2498 94 1100 993 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2499 r0 *1 146.28,78.88
X$2499 94 1101 1105 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2500 r0 *1 147.66,78.88
X$2500 94 1099 1102 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2502 r0 *1 149.5,78.88
X$2502 94 1033 94 1101 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2517 m0 *1 1.38,84.32
X$2517 94 1151 94 1153 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2518 m0 *1 5.06,84.32
X$2518 94 1118 1115 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2520 m0 *1 6.9,84.32
X$2520 75 275 1156 1155 1171 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2522 m0 *1 18.4,84.32
X$2522 94 783 978 1120 806 75 1119 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $2523 m0 *1 21.16,84.32
X$2523 94 1014 902 1173 1120 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2526 m0 *1 24.38,84.32
X$2526 94 1156 240 1174 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2531 m0 *1 29.44,84.32
X$2531 94 1121 346 1177 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2532 m0 *1 30.82,84.32
X$2532 94 1122 1177 1144 234 268 94 1159 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $2533 m0 *1 34.04,84.32
X$2533 75 907 1145 753 819 1014 1179 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $2534 m0 *1 37.26,84.32
X$2534 94 511 75 1125 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2537 m0 *1 42.32,84.32
X$2537 94 382 75 1055 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2539 m0 *1 46,84.32
X$2539 94 1146 1126 1124 75 94 1123 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2540 m0 *1 47.84,84.32
X$2540 94 1223 1147 1149 1110 268 94 1182 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $2541 m0 *1 51.06,84.32
X$2541 94 1182 362 1125 75 94 1124 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2542 m0 *1 52.9,84.32
X$2542 94 165 313 1149 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2543 m0 *1 54.28,84.32
X$2543 94 165 1055 1089 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2548 m0 *1 59.34,84.32
X$2548 94 1126 1150 1163 94 1186 75 75 sky130_fd_sc_hd__a21oi_2
* cell instance $2549 m0 *1 62.56,84.32
X$2549 94 1187 618 1125 75 94 1163 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2553 m0 *1 70.84,84.32
X$2553 94 496 308 790 1148 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $2554 m0 *1 72.68,84.32
X$2554 94 843 633 1148 94 75 1189 75 sky130_fd_sc_hd__o21ai_1
* cell instance $2558 m0 *1 80.5,84.32
X$2558 94 843 1114 597 94 1190 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2564 m0 *1 87.86,84.32
X$2564 94 368 758 1188 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2565 m0 *1 89.24,84.32
X$2565 94 726 572 642 868 94 1128 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $2566 m0 *1 91.54,84.32
X$2566 94 1128 1188 597 1129 75 94 1072 75 sky130_fd_sc_hd__a31oi_1
* cell instance $2567 m0 *1 93.84,84.32
X$2567 94 165 513 1129 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2571 m0 *1 100.28,84.32
X$2571 94 726 603 642 1043 94 1130 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $2574 m0 *1 103.96,84.32
X$2574 94 368 981 1185 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2575 m0 *1 105.34,84.32
X$2575 75 1180 1130 1143 1093 1142 94 94 75 sky130_fd_sc_hd__a31o_1
* cell instance $2578 m0 *1 109.94,84.32
X$2578 94 165 676 1141 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2583 m0 *1 115,84.32
X$2583 94 1131 565 1139 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2587 m0 *1 119.6,84.32
X$2587 75 595 1096 94 94 75 sky130_fd_sc_hd__buf_6
* cell instance $2588 m0 *1 123.74,84.32
X$2588 94 692 75 1131 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2590 m0 *1 128.34,84.32
X$2590 75 80 1137 1132 742 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2592 m0 *1 139.84,84.32
X$2592 94 1214 1134 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2595 m0 *1 142.6,84.32
X$2595 75 275 1172 1132 798 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2596 r0 *1 1.38,84.32
X$2596 94 1153 1154 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2597 r0 *1 2.76,84.32
X$2597 75 138 1176 1155 1154 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2604 r0 *1 19.32,84.32
X$2604 75 595 1193 94 94 75 sky130_fd_sc_hd__buf_6
* cell instance $2607 r0 *1 24.84,84.32
X$2607 94 1174 299 1158 75 94 1215 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2609 r0 *1 27.14,84.32
X$2609 94 1176 956 1194 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2611 r0 *1 28.98,84.32
X$2611 94 1159 1176 212 75 94 1158 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2612 r0 *1 30.82,84.32
X$2612 94 1157 313 1144 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2614 r0 *1 32.66,84.32
X$2614 94 304 1221 1160 1122 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $2615 r0 *1 34.5,84.32
X$2615 94 464 75 1126 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2616 r0 *1 37.26,84.32
X$2616 75 384 1088 94 94 75 sky130_fd_sc_hd__buf_6
* cell instance $2623 r0 *1 46.92,84.32
X$2623 94 628 1161 1160 1223 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $2624 r0 *1 48.76,84.32
X$2624 75 1181 977 368 1046 1161 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $2628 r0 *1 57.04,84.32
X$2628 94 1020 1201 133 566 94 1227 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $2629 r0 *1 59.34,84.32
X$2629 94 239 1162 1226 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2631 r0 *1 61.64,84.32
X$2631 94 124 1162 1225 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2632 r0 *1 63.02,84.32
X$2632 94 1020 1201 131 566 94 1202 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $2642 r0 *1 80.04,84.32
X$2642 94 868 1079 572 1190 75 94 1224 75 sky130_fd_sc_hd__a31oi_1
* cell instance $2644 r0 *1 86.02,84.32
X$2644 94 467 94 75 869 75 sky130_fd_sc_hd__buf_4
* cell instance $2652 r0 *1 100.28,84.32
X$2652 94 382 75 1164 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2655 r0 *1 107.64,84.32
X$2655 94 1184 1185 1240 1141 75 94 1140 75 sky130_fd_sc_hd__a31oi_1
* cell instance $2657 r0 *1 110.86,84.32
X$2657 94 411 75 1206 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2658 r0 *1 113.62,84.32
X$2658 75 610 1217 94 94 75 sky130_fd_sc_hd__buf_6
* cell instance $2662 r0 *1 122.82,84.32
X$2662 94 429 75 1205 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2667 r0 *1 126.96,84.32
X$2667 94 1172 989 1178 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2669 r0 *1 128.8,84.32
X$2669 94 1178 1165 1216 75 94 1207 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2670 r0 *1 130.64,84.32
X$2670 94 1059 1166 1060 75 94 1216 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2671 r0 *1 132.48,84.32
X$2671 94 1172 657 1175 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2672 r0 *1 133.86,84.32
X$2672 75 138 1166 1132 1167 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2675 r0 *1 147.2,84.32
X$2675 94 1207 1170 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2676 r0 *1 148.58,84.32
X$2676 94 1168 1167 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2680 r0 *1 150.42,84.32
X$2680 94 1136 1103 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2681 r0 *1 151.8,84.32
X$2681 94 1135 1133 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2689 m0 *1 1.38,89.76
X$2689 94 1249 1248 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2690 m0 *1 2.76,89.76
X$2690 94 1215 1152 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2692 m0 *1 4.6,89.76
X$2692 94 1192 94 1250 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2693 m0 *1 8.28,89.76
X$2693 94 1250 1171 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2694 m0 *1 9.66,89.76
X$2694 94 1196 1191 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2697 m0 *1 12.42,89.76
X$2697 94 1157 875 973 94 1230 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2699 m0 *1 15.18,89.76
X$2699 94 1176 712 1156 1085 94 1213 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2703 m0 *1 21.16,89.76
X$2703 94 1157 1231 836 94 1252 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2704 m0 *1 23,89.76
X$2704 94 1176 1193 1156 1086 94 1284 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2705 m0 *1 25.76,89.76
X$2705 75 1287 977 1121 1046 1221 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $2707 m0 *1 29.44,89.76
X$2707 94 1176 1053 1156 1078 94 1219 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2708 m0 *1 32.2,89.76
X$2708 94 1156 878 1254 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2709 m0 *1 33.58,89.76
X$2709 94 464 75 1234 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2711 m0 *1 40.02,89.76
X$2711 94 511 75 1200 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2712 m0 *1 42.78,89.76
X$2712 94 383 94 75 1183 75 sky130_fd_sc_hd__buf_4
* cell instance $2714 m0 *1 46.46,89.76
X$2714 94 1195 358 1125 75 94 1222 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2716 m0 *1 48.76,89.76
X$2716 94 897 1234 1235 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2718 m0 *1 51.06,89.76
X$2718 94 1198 1126 1197 75 94 1196 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2720 m0 *1 53.36,89.76
X$2720 94 938 1234 1198 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2721 m0 *1 54.74,89.76
X$2721 94 1199 620 1125 75 94 1197 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2723 m0 *1 57.04,89.76
X$2723 94 1227 1260 1226 1110 1200 94 1199 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $2724 m0 *1 60.26,89.76
X$2724 94 1202 1111 1225 1110 1200 94 1195 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $2727 m0 *1 69,89.76
X$2727 94 952 308 983 428 75 1238 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $2737 m0 *1 91.08,89.76
X$2737 94 513 75 1231 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2738 m0 *1 93.84,89.76
X$2738 94 383 94 75 952 75 sky130_fd_sc_hd__buf_4
* cell instance $2740 m0 *1 97.06,89.76
X$2740 94 513 75 1056 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2741 m0 *1 99.82,89.76
X$2741 75 1241 467 1203 428 1259 383 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $2745 m0 *1 109.02,89.76
X$2745 94 1203 759 469 75 94 1258 75 sky130_fd_sc_hd__a21o_1
* cell instance $2749 m0 *1 113.62,89.76
X$2749 94 511 75 1256 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2753 m0 *1 122.82,89.76
X$2753 94 1137 1164 1218 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2754 m0 *1 124.2,89.76
X$2754 94 1241 895 1218 1204 94 75 1214 75 sky130_fd_sc_hd__o31ai_1
* cell instance $2755 m0 *1 126.96,89.76
X$2755 94 1166 1205 1172 1206 94 1204 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2756 m0 *1 129.72,89.76
X$2756 75 739 1255 657 1275 1175 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $2757 m0 *1 134.32,89.76
X$2757 94 464 75 1244 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2758 m0 *1 137.08,89.76
X$2758 94 1137 1056 1075 94 1251 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2761 m0 *1 139.84,89.76
X$2761 94 1166 1096 1172 1097 94 1209 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2762 m0 *1 142.6,89.76
X$2762 94 1208 1251 1209 94 1210 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2764 m0 *1 145.36,89.76
X$2764 94 1210 1211 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2767 m0 *1 148.12,89.76
X$2767 94 1282 1169 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2769 m0 *1 149.96,89.76
X$2769 94 1212 94 1168 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2770 r0 *1 1.38,89.76
X$2770 75 80 1157 1155 1281 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2772 r0 *1 13.34,89.76
X$2772 94 1263 1230 1213 94 1249 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2777 r0 *1 16.1,89.76
X$2777 94 783 1121 1264 806 75 1263 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $2778 r0 *1 18.86,89.76
X$2778 94 781 1121 1333 782 75 1285 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $2779 r0 *1 21.62,89.76
X$2779 94 1285 1252 1284 94 1262 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2782 r0 *1 26.22,89.76
X$2782 94 384 1287 1265 1219 94 75 1233 75 sky130_fd_sc_hd__o31ai_1
* cell instance $2783 r0 *1 28.98,89.76
X$2783 94 1194 1232 921 1254 75 94 1286 75 sky130_fd_sc_hd__a31oi_1
* cell instance $2784 r0 *1 31.28,89.76
X$2784 94 1157 979 1002 1314 1232 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $2785 r0 *1 34.04,89.76
X$2785 94 249 1289 840 1288 1290 94 1001 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $2786 r0 *1 37.26,89.76
X$2786 94 978 1289 840 1288 1290 94 1179 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $2793 r0 *1 43.7,89.76
X$2793 94 1126 1235 1222 94 1266 75 75 sky130_fd_sc_hd__a21oi_2
* cell instance $2794 r0 *1 46.92,89.76
X$2794 94 1237 1236 1267 75 929 94 75 sky130_fd_sc_hd__o21ai_2
* cell instance $2796 r0 *1 50.6,89.76
X$2796 94 620 712 938 1085 94 1267 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2799 r0 *1 55.66,89.76
X$2799 94 239 875 973 94 1236 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2800 r0 *1 57.5,89.76
X$2800 94 308 1054 1260 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2802 r0 *1 59.8,89.76
X$2802 94 811 75 979 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2805 r0 *1 63.94,89.76
X$2805 94 310 75 1054 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2806 r0 *1 66.7,89.76
X$2806 94 620 1053 938 1078 94 1294 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2811 r0 *1 70.84,89.76
X$2811 94 239 1055 1318 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2815 r0 *1 74.52,89.76
X$2815 75 1237 1043 1079 603 1189 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $2816 r0 *1 79.12,89.76
X$2816 94 239 1231 836 94 1239 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $2818 r0 *1 81.42,89.76
X$2818 94 1224 1239 1268 75 1339 94 75 sky130_fd_sc_hd__o21ai_2
* cell instance $2819 r0 *1 84.64,89.76
X$2819 94 620 1193 938 1086 94 1268 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2829 r0 *1 102.12,89.76
X$2829 94 1242 94 75 1259 75 sky130_fd_sc_hd__inv_1
* cell instance $2832 r0 *1 106.26,89.76
X$2832 94 1093 75 633 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2833 r0 *1 109.02,89.76
X$2833 94 1257 759 469 75 94 1292 75 sky130_fd_sc_hd__a21o_1
* cell instance $2834 r0 *1 111.78,89.76
X$2834 94 1242 1293 694 1271 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2836 r0 *1 114.54,89.76
X$2836 94 856 1258 633 1137 1271 1165 94 75 75 sky130_fd_sc_hd__o221ai_1
* cell instance $2837 r0 *1 117.76,89.76
X$2837 94 1137 530 1291 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2840 r0 *1 121.44,89.76
X$2840 94 1137 1240 1220 1131 1275 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $2847 r0 *1 126.5,89.76
X$2847 94 1166 1217 1255 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2848 r0 *1 127.88,89.76
X$2848 94 1302 989 1311 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2849 r0 *1 129.26,89.76
X$2849 94 1059 1274 1060 75 94 1310 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2850 r0 *1 131.1,89.76
X$2850 94 1243 1166 1256 75 94 1278 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2852 r0 *1 133.4,89.76
X$2852 94 1172 465 1253 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2853 r0 *1 134.78,89.76
X$2853 94 1253 1244 1278 75 94 1282 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2856 r0 *1 142.14,89.76
X$2856 75 138 1274 1132 1245 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2867 m0 *1 2.3,95.2
X$2867 94 1261 94 1296 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2868 m0 *1 5.98,95.2
X$2868 94 1306 94 1307 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2869 m0 *1 9.66,95.2
X$2869 94 1262 1229 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2871 m0 *1 23,95.2
X$2871 94 1297 902 1173 1264 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2872 m0 *1 24.84,95.2
X$2872 94 563 1298 1221 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $2873 m0 *1 27.14,95.2
X$2873 94 535 1298 1297 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2876 m0 *1 29.44,95.2
X$2876 94 1157 1055 1265 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2877 m0 *1 30.82,95.2
X$2877 75 907 1314 753 819 1297 1315 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $2878 m0 *1 34.04,95.2
X$2878 94 1121 1289 840 1288 1290 94 1315 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $2880 m0 *1 39.1,95.2
X$2880 94 784 75 1289 94 75 sky130_fd_sc_hd__buf_2
* cell instance $2882 m0 *1 41.4,95.2
X$2882 94 772 75 902 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2883 m0 *1 44.16,95.2
X$2883 94 763 75 1288 94 75 sky130_fd_sc_hd__buf_2
* cell instance $2886 m0 *1 47.38,95.2
X$2886 94 728 75 907 94 75 sky130_fd_sc_hd__buf_2
* cell instance $2887 m0 *1 49.22,95.2
X$2887 94 328 75 1110 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2889 m0 *1 53.82,95.2
X$2889 94 328 75 1162 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2892 m0 *1 57.96,95.2
X$2892 94 811 94 75 676 75 sky130_fd_sc_hd__buf_4
* cell instance $2893 m0 *1 60.72,95.2
X$2893 94 831 75 1173 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2896 m0 *1 64.86,95.2
X$2896 75 1321 867 696 784 763 760 94 94 75 sky130_fd_sc_hd__o2111a_1
* cell instance $2897 m0 *1 69,95.2
X$2897 75 1088 1238 1318 2067 1294 94 94 75 sky130_fd_sc_hd__o31ai_2
* cell instance $2898 m0 *1 73.6,95.2
X$2898 94 310 75 1269 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2899 m0 *1 76.36,95.2
X$2899 94 772 75 1293 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2902 m0 *1 81.88,95.2
X$2902 94 784 75 1270 94 75 sky130_fd_sc_hd__buf_2
* cell instance $2905 m0 *1 84.64,95.2
X$2905 75 784 763 1043 790 696 760 94 94 75 sky130_fd_sc_hd__o2111ai_4
* cell instance $2907 m0 *1 94.76,95.2
X$2907 94 328 75 1317 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2910 m0 *1 100.28,95.2
X$2910 75 75 1299 820 1270 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $2913 m0 *1 103.96,95.2
X$2913 94 304 1201 1323 265 94 1272 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $2915 m0 *1 107.18,95.2
X$2915 94 1203 1270 860 1299 1109 94 1338 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $2916 m0 *1 110.4,95.2
X$2916 94 1203 1269 1337 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2918 m0 *1 112.24,95.2
X$2918 94 1272 1337 1291 1317 534 94 1243 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $2919 m0 *1 115.46,95.2
X$2919 94 856 1316 633 1300 1292 1273 94 75 75 sky130_fd_sc_hd__o221ai_1
* cell instance $2921 m0 *1 120.52,95.2
X$2921 94 1257 1269 1336 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2923 m0 *1 123.74,95.2
X$2923 94 1300 1164 1312 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2924 m0 *1 125.12,95.2
X$2924 94 895 1313 1312 1358 94 75 1277 75 sky130_fd_sc_hd__o31ai_1
* cell instance $2925 m0 *1 127.88,95.2
X$2925 94 1311 1273 1310 75 94 1301 75 sky130_fd_sc_hd__a21oi_1
* cell instance $2927 m0 *1 131.56,95.2
X$2927 94 1302 465 1334 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $2929 m0 *1 134.78,95.2
X$2929 94 1274 1096 1302 1097 94 1276 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $2932 m0 *1 139.84,95.2
X$2932 75 275 1302 1132 1308 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2933 m0 *1 150.88,95.2
X$2933 94 1305 1304 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2934 m0 *1 152.26,95.2
X$2934 94 1303 1245 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2935 r0 *1 1.38,95.2
X$2935 94 1296 1281 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2936 r0 *1 2.76,95.2
X$2936 94 1286 1228 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2937 r0 *1 4.14,95.2
X$2937 75 197 1121 1155 1331 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $2941 r0 *1 16.1,95.2
X$2941 94 1332 1320 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $2944 r0 *1 22.08,95.2
X$2944 94 1297 757 1342 1333 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2948 r0 *1 32.2,95.2
X$2948 75 638 712 94 94 75 sky130_fd_sc_hd__buf_6
* cell instance $2950 r0 *1 37.26,95.2
X$2950 94 451 75 782 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2951 r0 *1 40.02,95.2
X$2951 94 762 75 757 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2954 r0 *1 43.24,95.2
X$2954 94 1321 75 781 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2955 r0 *1 46,95.2
X$2955 94 1321 75 758 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2956 r0 *1 48.76,95.2
X$2956 94 831 75 783 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2957 r0 *1 51.52,95.2
X$2957 94 760 75 1290 94 75 sky130_fd_sc_hd__buf_2
* cell instance $2959 r0 *1 54.28,95.2
X$2959 94 831 94 75 694 75 sky130_fd_sc_hd__buf_4
* cell instance $2960 r0 *1 57.04,95.2
X$2960 94 1321 75 1342 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2969 r0 *1 74.52,95.2
X$2969 94 728 75 1343 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2971 r0 *1 80.96,95.2
X$2971 94 811 75 1344 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2973 r0 *1 85.56,95.2
X$2973 94 822 94 75 565 75 sky130_fd_sc_hd__buf_4
* cell instance $2974 r0 *1 88.32,95.2
X$2974 94 811 75 1240 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $2975 r0 *1 91.08,95.2
X$2975 94 763 75 1299 94 75 sky130_fd_sc_hd__buf_2
* cell instance $2976 r0 *1 92.92,95.2
X$2976 94 760 75 1109 94 75 sky130_fd_sc_hd__buf_2
* cell instance $2983 r0 *1 102.12,95.2
X$2983 94 1020 1201 1322 566 94 1326 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $2985 r0 *1 105.34,95.2
X$2985 94 535 1322 1325 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2986 r0 *1 106.72,95.2
X$2986 94 535 1323 1242 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $2987 r0 *1 108.1,95.2
X$2987 75 1220 1343 981 1242 676 1338 94 94 75 sky130_fd_sc_hd__o311ai_1
* cell instance $2989 r0 *1 112.24,95.2
X$2989 94 1242 1324 786 1345 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2990 r0 *1 114.08,95.2
X$2990 94 1325 1293 694 1316 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2991 r0 *1 115.92,95.2
X$2991 94 1325 1324 786 1387 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $2995 r0 *1 120.98,95.2
X$2995 94 1326 1336 1359 1317 534 94 1327 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $2997 r0 *1 124.2,95.2
X$2997 94 1300 530 1359 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3001 r0 *1 127.42,95.2
X$3001 94 1274 1205 1302 1206 94 1358 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3003 r0 *1 130.64,95.2
X$3003 94 1327 1274 1256 75 94 1328 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3004 r0 *1 132.48,95.2
X$3004 94 1334 1244 1328 75 94 1305 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3006 r0 *1 134.78,95.2
X$3006 75 80 1300 1132 1283 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3007 r0 *1 145.82,95.2
X$3007 94 1279 94 1330 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3008 r0 *1 149.5,95.2
X$3008 94 1247 94 1303 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3023 m0 *1 1.38,100.64
X$3023 94 1307 1309 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3024 m0 *1 2.76,100.64
X$3024 94 1295 94 1377 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3025 m0 *1 6.44,100.64
X$3025 75 197 978 1155 1362 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3028 m0 *1 29.44,100.64
X$3028 94 1341 94 75 1382 75 sky130_fd_sc_hd__inv_1
* cell instance $3031 m0 *1 33.12,100.64
X$3031 94 565 94 75 921 75 sky130_fd_sc_hd__buf_4
* cell instance $3032 m0 *1 35.88,100.64
X$3032 94 1020 1201 1363 566 94 1384 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $3033 m0 *1 38.18,100.64
X$3033 94 526 1363 1341 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3036 m0 *1 41.86,100.64
X$3036 94 469 75 806 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3038 m0 *1 45.54,100.64
X$3038 94 1364 902 1173 1385 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3039 m0 *1 47.38,100.64
X$3039 75 1449 907 819 1364 1386 753 94 94 75 sky130_fd_sc_hd__o311ai_1
* cell instance $3040 m0 *1 50.6,100.64
X$3040 94 1335 1289 840 1288 1290 94 1386 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3041 m0 *1 53.82,100.64
X$3041 94 786 1335 1388 451 75 1390 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3043 m0 *1 57.04,100.64
X$3043 94 819 75 981 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3045 m0 *1 60.72,100.64
X$3045 94 1321 94 75 786 75 sky130_fd_sc_hd__buf_4
* cell instance $3046 m0 *1 63.48,100.64
X$3046 94 1321 75 1346 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3047 m0 *1 66.24,100.64
X$3047 94 565 75 1350 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3049 m0 *1 70.84,100.64
X$3049 75 638 1392 94 94 75 sky130_fd_sc_hd__buf_6
* cell instance $3052 m0 *1 77.74,100.64
X$3052 94 1393 762 758 1428 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3054 m0 *1 81.42,100.64
X$3054 94 822 94 75 878 75 sky130_fd_sc_hd__buf_4
* cell instance $3064 m0 *1 106.26,100.64
X$3064 75 1348 1343 981 1325 1389 1344 94 94 75 sky130_fd_sc_hd__o311ai_1
* cell instance $3068 m0 *1 112.24,100.64
X$3068 94 1346 1203 1345 1347 75 1208 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3069 m0 *1 115,100.64
X$3069 94 1346 1257 1387 1347 75 1352 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3070 m0 *1 117.76,100.64
X$3070 94 1325 94 75 1366 75 sky130_fd_sc_hd__inv_1
* cell instance $3071 m0 *1 119.14,100.64
X$3071 75 1313 869 1257 922 1366 952 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3073 m0 *1 122.82,100.64
X$3073 94 1300 1240 1131 1348 1383 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3074 m0 *1 125.58,100.64
X$3074 94 822 94 75 1357 75 sky130_fd_sc_hd__buf_4
* cell instance $3075 m0 *1 128.34,100.64
X$3075 94 1274 1217 1349 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3076 m0 *1 129.72,100.64
X$3076 94 1349 1383 1350 1351 75 94 1371 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3077 m0 *1 132.02,100.64
X$3077 94 1302 1357 1351 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3079 m0 *1 133.86,100.64
X$3079 94 1300 1056 1075 94 1370 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3080 m0 *1 135.7,100.64
X$3080 94 1352 1370 1276 94 1372 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3085 m0 *1 142.6,100.64
X$3085 75 275 1356 1132 1373 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3086 r0 *1 1.38,100.64
X$3086 94 1233 1319 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3087 r0 *1 2.76,100.64
X$3087 94 1377 1331 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3088 r0 *1 4.14,100.64
X$3088 75 197 1335 1155 1378 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3091 r0 *1 15.64,100.64
X$3091 94 1361 94 1413 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3092 r0 *1 19.32,100.64
X$3092 94 781 1380 1381 782 75 1445 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3094 r0 *1 22.54,100.64
X$3094 94 1341 757 1342 1381 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3096 r0 *1 25.3,100.64
X$3096 94 1155 75 94 75 sky130_fd_sc_hd__clkinv_4
* cell instance $3097 r0 *1 28.52,100.64
X$3097 75 721 1155 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $3098 r0 *1 37.72,100.64
X$3098 94 1380 1289 840 1288 1290 94 1416 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3102 r0 *1 43.24,100.64
X$3102 94 783 1335 1385 806 75 1422 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3103 r0 *1 46,100.64
X$3103 94 1466 712 1365 1085 94 1398 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3106 r0 *1 50.14,100.64
X$3106 94 1364 94 75 1399 75 sky130_fd_sc_hd__inv_1
* cell instance $3107 r0 *1 51.52,100.64
X$3107 75 1467 977 1335 1046 1399 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3108 r0 *1 54.74,100.64
X$3108 94 1364 762 758 1388 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3110 r0 *1 57.04,100.64
X$3110 94 831 75 1427 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3111 r0 *1 59.8,100.64
X$3111 94 1466 1096 1365 1097 94 1456 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3120 r0 *1 75.9,100.64
X$3120 94 786 1437 1428 451 75 1429 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3121 r0 *1 78.66,100.64
X$3121 94 762 75 1324 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3123 r0 *1 82.34,100.64
X$3123 94 1368 1096 1356 1097 94 1430 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3126 r0 *1 89.7,100.64
X$3126 94 451 75 1347 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3132 r0 *1 100.28,100.64
X$3132 94 1093 75 875 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3134 r0 *1 103.96,100.64
X$3134 94 304 1201 1391 265 94 1426 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $3136 r0 *1 106.72,100.64
X$3136 94 1257 1270 860 1299 1109 94 1389 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3139 r0 *1 114.08,100.64
X$3139 94 1404 1293 694 1424 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3141 r0 *1 117.76,100.64
X$3141 94 1404 94 75 1423 75 sky130_fd_sc_hd__inv_1
* cell instance $3142 r0 *1 119.14,100.64
X$3142 94 1367 1164 1405 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3143 r0 *1 120.52,100.64
X$3143 94 1403 1269 1421 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3144 r0 *1 121.9,100.64
X$3144 94 1367 530 1418 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3146 r0 *1 123.28,100.64
X$3146 94 1367 1419 1069 94 1417 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3149 r0 *1 126.04,100.64
X$3149 94 895 1415 1405 1406 94 75 1353 75 sky130_fd_sc_hd__o31ai_1
* cell instance $3151 r0 *1 129.72,100.64
X$3151 75 138 1368 1132 1369 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3152 r0 *1 140.76,100.64
X$3152 94 1371 1354 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3153 r0 *1 142.14,100.64
X$3153 94 1410 1369 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3155 r0 *1 143.98,100.64
X$3155 94 1372 1329 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3156 r0 *1 145.36,100.64
X$3156 94 1374 1283 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3157 r0 *1 146.74,100.64
X$3157 94 1277 1280 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3158 r0 *1 148.12,100.64
X$3158 94 1301 1246 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3159 r0 *1 149.5,100.64
X$3159 94 1355 94 1374 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3174 m0 *1 1.38,106.08
X$3174 75 80 1397 1155 1442 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3175 m0 *1 12.42,106.08
X$3175 94 1340 94 1411 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3176 m0 *1 16.1,106.08
X$3176 94 1433 712 1434 1085 94 1412 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3177 m0 *1 18.86,106.08
X$3177 94 1445 1395 1511 94 1477 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3178 m0 *1 20.7,106.08
X$3178 94 1396 1231 836 94 1395 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3182 m0 *1 25.76,106.08
X$3182 75 1479 977 1380 1046 1382 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3185 m0 *1 29.9,106.08
X$3185 75 721 1480 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $3186 m0 *1 39.1,106.08
X$3186 94 1384 1518 1447 1110 1200 94 1420 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3187 m0 *1 42.32,106.08
X$3187 94 1335 1054 1484 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3188 m0 *1 43.7,106.08
X$3188 94 1422 1398 1435 94 75 1332 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3189 m0 *1 45.54,106.08
X$3189 94 1397 875 973 94 1435 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3191 m0 *1 48.3,106.08
X$3191 94 1397 979 1002 1449 1451 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3192 m0 *1 51.06,106.08
X$3192 75 1453 1452 1451 921 1454 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $3196 m0 *1 57.5,106.08
X$3196 75 1025 1390 1436 1400 1456 94 94 75 sky130_fd_sc_hd__o31ai_2
* cell instance $3197 m0 *1 62.1,106.08
X$3197 94 1397 1056 1436 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3199 m0 *1 64.4,106.08
X$3199 75 197 1437 1401 1458 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3202 m0 *1 77.74,106.08
X$3202 75 1025 1429 1438 1457 1430 94 94 75 sky130_fd_sc_hd__o31ai_2
* cell instance $3203 m0 *1 82.34,106.08
X$3203 94 1455 1056 1438 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3206 m0 *1 84.64,106.08
X$3206 94 1368 1392 1356 1059 94 1431 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3207 m0 *1 87.4,106.08
X$3207 94 1368 1205 1356 1206 94 1470 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3209 m0 *1 90.62,106.08
X$3209 94 1437 1270 860 1299 1109 94 1487 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3212 m0 *1 96.14,106.08
X$3212 75 197 1203 1402 1450 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3213 m0 *1 107.18,106.08
X$3213 94 535 1391 1404 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3214 m0 *1 108.56,106.08
X$3214 94 1403 1270 860 1299 1109 94 1485 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3217 m0 *1 112.7,106.08
X$3217 94 1427 1403 1424 1448 75 1425 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3218 m0 *1 115.46,106.08
X$3218 94 1404 1324 786 1482 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3220 m0 *1 117.76,106.08
X$3220 75 1415 869 1403 922 1423 952 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3221 m0 *1 120.98,106.08
X$3221 94 1426 1421 1418 1317 534 94 1478 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3222 m0 *1 124.2,106.08
X$3222 94 1425 1444 1417 94 75 1407 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3223 m0 *1 126.04,106.08
X$3223 75 721 1132 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $3224 m0 *1 135.24,106.08
X$3224 94 1446 1392 1439 1059 94 1444 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3225 m0 *1 138,106.08
X$3225 94 1439 465 1543 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3227 m0 *1 139.84,106.08
X$3227 94 1446 1096 1439 1097 94 1414 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3228 m0 *1 142.6,106.08
X$3228 94 1407 1408 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3229 m0 *1 143.98,106.08
X$3229 94 1443 1476 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3230 m0 *1 145.36,106.08
X$3230 94 1440 1373 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3231 m0 *1 146.74,106.08
X$3231 94 1353 1409 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3233 m0 *1 148.58,106.08
X$3233 94 1376 94 1410 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3234 m0 *1 152.26,106.08
X$3234 94 1330 1308 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3235 r0 *1 1.38,106.08
X$3235 75 80 1396 1155 1475 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3237 r0 *1 13.34,106.08
X$3237 94 1396 875 973 94 1460 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3240 r0 *1 15.64,106.08
X$3240 94 1461 1460 1412 94 1491 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3241 r0 *1 17.48,106.08
X$3241 94 783 1380 1462 806 75 1461 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3242 r0 *1 20.24,106.08
X$3242 94 1433 1193 1434 1086 94 1511 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3244 r0 *1 23.46,106.08
X$3244 94 1341 902 1173 1462 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3246 r0 *1 26.22,106.08
X$3246 94 1088 1479 1514 1464 94 75 1492 75 sky130_fd_sc_hd__o31ai_1
* cell instance $3248 r0 *1 29.44,106.08
X$3248 94 1433 1053 1434 1078 94 1464 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3250 r0 *1 32.66,106.08
X$3250 94 1515 1126 1465 75 94 1463 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3251 r0 *1 34.5,106.08
X$3251 94 1420 1433 1125 75 94 1465 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3252 r0 *1 36.34,106.08
X$3252 75 907 1517 753 886 1341 1416 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $3253 r0 *1 39.56,106.08
X$3253 94 1396 1162 1447 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3258 r0 *1 44.16,106.08
X$3258 94 1483 1484 1495 1110 1200 94 1486 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3259 r0 *1 47.38,106.08
X$3259 94 1397 1162 1495 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3261 r0 *1 49.22,106.08
X$3261 94 1466 956 1452 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3262 r0 *1 50.6,106.08
X$3262 75 721 1401 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $3263 r0 *1 59.8,106.08
X$3263 75 1088 1467 1468 1529 1527 94 94 75 sky130_fd_sc_hd__o31ai_2
* cell instance $3264 r0 *1 64.4,106.08
X$3264 94 1397 1055 1468 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3267 r0 *1 67.16,106.08
X$3267 94 469 75 1448 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3273 r0 *1 73.14,106.08
X$3273 94 535 1536 1393 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3274 r0 *1 74.52,106.08
X$3274 94 1437 1269 1497 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3275 r0 *1 75.9,106.08
X$3275 94 1393 1293 1173 1498 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3277 r0 *1 78.66,106.08
X$3277 94 1427 1437 1498 1448 75 1526 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3279 r0 *1 82.34,106.08
X$3279 75 1469 869 1437 922 1499 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3280 r0 *1 85.56,106.08
X$3280 75 895 1469 1523 1501 1470 94 94 75 sky130_fd_sc_hd__o31ai_2
* cell instance $3281 r0 *1 90.16,106.08
X$3281 75 1343 1521 1344 886 1393 1487 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $3282 r0 *1 93.38,106.08
X$3282 94 1368 1217 1522 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3286 r0 *1 96.14,106.08
X$3286 94 1356 1357 1520 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3289 r0 *1 98.44,106.08
X$3289 94 526 75 1201 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3292 r0 *1 102.58,106.08
X$3292 94 1093 75 1419 94 75 sky130_fd_sc_hd__clkbuf_4
* cell instance $3294 r0 *1 105.8,106.08
X$3294 94 535 1471 1541 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3297 r0 *1 109.94,106.08
X$3297 75 1473 1343 981 1404 1485 676 94 94 75 sky130_fd_sc_hd__o311ai_1
* cell instance $3299 r0 *1 114.08,106.08
X$3299 94 1346 1403 1482 1347 75 1507 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3300 r0 *1 116.84,106.08
X$3300 94 1427 1481 1516 1448 75 1472 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3302 r0 *1 120.06,106.08
X$3302 94 1505 94 75 2162 75 sky130_fd_sc_hd__clkinvlp_4
* cell instance $3303 r0 *1 122.82,106.08
X$3303 94 1367 1240 1131 1473 1512 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3306 r0 *1 126.04,106.08
X$3306 75 1132 94 94 75 sky130_fd_sc_hd__inv_8
* cell instance $3307 r0 *1 130.18,106.08
X$3307 94 1446 1205 1439 1206 94 1406 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3308 r0 *1 132.94,106.08
X$3308 94 1478 1446 1256 75 94 1510 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3309 r0 *1 134.78,106.08
X$3309 75 80 1367 1132 1476 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3310 r0 *1 145.82,106.08
X$3310 94 1441 94 1443 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3311 r0 *1 149.5,106.08
X$3311 94 1375 94 1440 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3326 m0 *1 1.38,111.52
X$3326 94 1411 1378 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3327 m0 *1 2.76,111.52
X$3327 94 1413 1442 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3329 m0 *1 4.6,111.52
X$3329 75 275 1434 1155 1549 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3330 m0 *1 15.64,111.52
X$3330 94 1463 1459 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3331 m0 *1 17.02,111.52
X$3331 94 1477 1432 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3332 m0 *1 18.4,111.52
X$3332 94 1491 1490 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3336 m0 *1 27.6,111.52
X$3336 94 1433 956 1562 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3338 m0 *1 29.44,111.52
X$3338 94 1396 1055 1514 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3339 m0 *1 30.82,111.52
X$3339 94 1434 1234 1515 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3340 m0 *1 32.2,111.52
X$3340 94 1434 878 1493 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3342 m0 *1 34.5,111.52
X$3342 94 1396 979 1002 1517 1534 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3343 m0 *1 37.26,111.52
X$3343 94 1380 1054 1518 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3347 m0 *1 41.86,111.52
X$3347 94 526 1553 1364 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3348 m0 *1 43.24,111.52
X$3348 94 1020 1201 1553 566 94 1483 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $3349 m0 *1 45.54,111.52
X$3349 94 1486 1466 1125 75 94 1494 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3350 m0 *1 47.38,111.52
X$3350 75 1554 94 94 75 sky130_fd_sc_hd__inv_8
* cell instance $3351 m0 *1 51.52,111.52
X$3351 94 1401 94 75 75 sky130_fd_sc_hd__inv_6
* cell instance $3353 m0 *1 55.2,111.52
X$3353 94 1365 878 1454 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3355 m0 *1 57.04,111.52
X$3355 94 1020 1201 1488 566 94 1496 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $3357 m0 *1 59.8,111.52
X$3357 94 1466 1053 1365 1078 94 1527 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3362 m0 *1 72.22,111.52
X$3362 94 1020 1201 1536 566 94 1537 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $3363 m0 *1 74.52,111.52
X$3363 94 1537 1497 1528 1317 1200 94 1538 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3364 m0 *1 77.74,111.52
X$3364 94 1455 1162 1528 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3365 m0 *1 79.12,111.52
X$3365 94 1356 1234 1525 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3366 m0 *1 80.5,111.52
X$3366 94 1538 1368 1256 75 94 1556 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3367 m0 *1 82.34,111.52
X$3367 94 1455 1419 1069 94 1524 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3369 m0 *1 84.64,111.52
X$3369 94 1526 1431 1524 94 75 1500 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3370 m0 *1 86.48,111.52
X$3370 94 1393 94 75 1499 75 sky130_fd_sc_hd__inv_1
* cell instance $3371 m0 *1 87.86,111.52
X$3371 94 1455 1164 1523 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3373 m0 *1 89.7,111.52
X$3373 94 1455 1240 1131 1521 1502 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3374 m0 *1 92.46,111.52
X$3374 75 1555 1522 1502 1350 1520 94 94 75 sky130_fd_sc_hd__a31oi_2
* cell instance $3377 m0 *1 98.44,111.52
X$3377 94 1020 1201 1471 265 94 1506 75 75 sky130_fd_sc_hd__nand4_1
* cell instance $3378 m0 *1 100.74,111.52
X$3378 94 1503 1270 860 1299 1109 94 1519 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3379 m0 *1 103.96,111.52
X$3379 75 1539 94 94 75 sky130_fd_sc_hd__inv_8
* cell instance $3380 m0 *1 108.1,111.52
X$3380 94 1481 1270 860 1299 1109 94 1599 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3383 m0 *1 112.24,111.52
X$3383 75 1552 1343 981 1540 1504 676 94 94 75 sky130_fd_sc_hd__o311ai_2
* cell instance $3384 m0 *1 118.22,111.52
X$3384 94 1541 1293 694 1516 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3386 m0 *1 120.52,111.52
X$3386 94 1506 1613 1513 1317 534 94 1542 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3388 m0 *1 124.2,111.52
X$3388 75 721 1505 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $3389 m0 *1 133.4,111.52
X$3389 94 1551 1512 1350 1611 75 94 1545 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3390 m0 *1 135.7,111.52
X$3390 94 1367 1056 1075 94 1544 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3391 m0 *1 137.54,111.52
X$3391 94 1507 1544 1414 94 1546 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3393 m0 *1 139.84,111.52
X$3393 94 1545 1509 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3394 m0 *1 141.22,111.52
X$3394 94 1546 1474 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3395 m0 *1 142.6,111.52
X$3395 75 275 1439 1402 1550 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3396 r0 *1 1.38,111.52
X$3396 94 1489 94 1681 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3397 r0 *1 5.06,111.52
X$3397 94 1360 94 1558 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3398 r0 *1 8.74,111.52
X$3398 94 1531 94 1559 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3399 r0 *1 12.42,111.52
X$3399 94 1532 1530 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3400 r0 *1 13.8,111.52
X$3400 94 1558 1379 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3403 r0 *1 15.64,111.52
X$3403 94 1492 1394 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3404 r0 *1 17.02,111.52
X$3404 94 1559 1475 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3407 r0 *1 21.16,111.52
X$3407 94 1560 902 1173 1609 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3408 r0 *1 23,111.52
X$3408 94 783 1533 1561 806 75 1590 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3409 r0 *1 25.76,111.52
X$3409 94 1579 902 1173 1561 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3412 r0 *1 30.36,111.52
X$3412 94 1562 1534 921 1493 75 94 1532 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3414 r0 *1 33.12,111.52
X$3414 94 1533 1289 840 1288 1290 94 1647 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3415 r0 *1 36.34,111.52
X$3415 94 1580 1289 840 1288 1290 94 1563 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3422 r0 *1 44.16,111.52
X$3422 94 1582 1289 840 1288 1290 94 1583 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3423 r0 *1 47.38,111.52
X$3423 75 721 1554 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $3424 r0 *1 56.58,111.52
X$3424 94 1614 1289 860 1288 1290 94 1535 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3426 r0 *1 60.72,111.52
X$3426 94 1496 1564 1616 1110 1200 94 1565 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3427 r0 *1 63.94,111.52
X$3427 94 1566 1054 1564 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3428 r0 *1 65.32,111.52
X$3428 94 535 1488 1593 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3435 r0 *1 78.66,111.52
X$3435 94 1525 1244 1556 75 94 1617 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3440 r0 *1 90.16,111.52
X$3440 94 1585 1270 860 1299 1109 94 1658 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3445 r0 *1 98.44,111.52
X$3445 94 1598 1270 860 1299 1109 94 1567 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3448 r0 *1 103.96,111.52
X$3448 75 721 1539 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $3450 r0 *1 113.62,111.52
X$3450 75 721 1402 94 94 75 sky130_fd_sc_hd__clkbuf_16
* cell instance $3451 r0 *1 122.82,111.52
X$3451 94 1541 1324 786 1584 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3455 r0 *1 126.04,111.52
X$3455 94 1570 1419 1069 94 1568 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3457 r0 *1 128.34,111.52
X$3457 94 1577 1392 1581 1059 94 1569 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3458 r0 *1 131.1,111.52
X$3458 94 1472 1569 1568 94 75 1576 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3459 r0 *1 132.94,111.52
X$3459 94 1543 1244 1510 75 94 1606 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3460 r0 *1 134.78,111.52
X$3460 94 1542 1577 1256 75 94 1571 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3461 r0 *1 136.62,111.52
X$3461 94 1570 1056 1075 94 1578 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3463 r0 *1 139.38,111.52
X$3463 75 138 1446 1402 1572 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3465 r0 *1 150.42,111.52
X$3465 94 1573 1572 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3466 r0 *1 151.8,111.52
X$3466 94 1575 1639 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3480 m0 *1 1.38,116.96
X$3480 75 138 1433 1480 1641 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3481 m0 *1 12.42,116.96
X$3481 94 1589 875 973 94 1622 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3482 m0 *1 14.26,116.96
X$3482 94 1587 875 973 94 1643 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3483 m0 *1 16.1,116.96
X$3483 94 783 1580 1609 806 75 1682 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3484 m0 *1 18.86,116.96
X$3484 94 781 1580 1588 782 75 1644 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3485 m0 *1 21.62,116.96
X$3485 94 1560 757 1342 1588 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3487 m0 *1 23.92,116.96
X$3487 94 781 1533 1591 782 75 1645 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3489 m0 *1 27.14,116.96
X$3489 94 1579 757 1342 1591 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3494 m0 *1 32.66,116.96
X$3494 75 907 1689 753 886 1579 1647 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $3495 m0 *1 35.88,116.96
X$3495 75 907 1691 1344 886 1560 1563 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $3497 m0 *1 40.02,116.96
X$3497 94 781 1582 1592 782 75 1624 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3498 m0 *1 42.78,116.96
X$3498 94 1625 757 1342 1592 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3499 m0 *1 44.62,116.96
X$3499 75 907 1696 1344 886 1625 1583 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $3501 m0 *1 48.3,116.96
X$3501 94 1625 902 1173 1649 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3502 m0 *1 50.14,116.96
X$3502 94 1566 1289 840 1288 1290 94 1650 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3503 m0 *1 53.36,116.96
X$3503 75 1594 907 886 1593 1650 1344 94 94 75 sky130_fd_sc_hd__o311ai_1
* cell instance $3505 m0 *1 57.04,116.96
X$3505 94 1593 902 1173 1651 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3506 m0 *1 58.88,116.96
X$3506 94 1627 979 1002 1594 1769 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3507 m0 *1 61.64,116.96
X$3507 94 1627 1162 1616 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3509 m0 *1 63.48,116.96
X$3509 94 1346 1566 1595 1347 75 1741 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3511 m0 *1 66.7,116.96
X$3511 94 1593 1324 1342 1595 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3513 m0 *1 69,116.96
X$3513 75 1343 1618 1344 886 1596 1535 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $3515 m0 *1 73.14,116.96
X$3515 94 1596 1293 1173 1703 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3518 m0 *1 82.34,116.96
X$3518 94 264 1653 1597 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3521 m0 *1 84.64,116.96
X$3521 94 1597 1324 1342 1655 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3522 m0 *1 86.48,116.96
X$3522 94 1597 1293 694 1657 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3523 m0 *1 88.32,116.96
X$3523 75 1343 1656 1344 886 1597 1658 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $3525 m0 *1 92,116.96
X$3525 94 1630 1324 1342 1615 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3527 m0 *1 94.3,116.96
X$3527 94 264 1654 1630 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3530 m0 *1 97.06,116.96
X$3530 75 1343 1631 1344 886 1630 1567 94 94 75 sky130_fd_sc_hd__o311ai_0
* cell instance $3531 m0 *1 100.28,116.96
X$3531 94 1630 1293 694 1707 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3532 m0 *1 102.12,116.96
X$3532 75 1600 1343 886 1652 1519 1344 94 94 75 sky130_fd_sc_hd__o311ai_2
* cell instance $3533 m0 *1 108.1,116.96
X$3533 75 1601 1343 981 1541 1599 1344 94 94 75 sky130_fd_sc_hd__o311ai_1
* cell instance $3538 m0 *1 113.62,116.96
X$3538 75 1402 94 94 75 sky130_fd_sc_hd__clkinv_8
* cell instance $3539 m0 *1 119.6,116.96
X$3539 75 1602 869 1481 922 1634 952 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3540 m0 *1 122.82,116.96
X$3540 94 1481 1269 1613 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3541 m0 *1 124.2,116.96
X$3541 94 1541 94 75 1634 75 sky130_fd_sc_hd__inv_1
* cell instance $3543 m0 *1 126.04,116.96
X$3543 94 895 1602 1612 1603 94 75 1637 75 sky130_fd_sc_hd__o31ai_1
* cell instance $3544 m0 *1 128.8,116.96
X$3544 94 1577 1205 1581 1206 94 1603 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3545 m0 *1 131.56,116.96
X$3545 94 1570 1164 1612 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3546 m0 *1 132.94,116.96
X$3546 94 1439 657 1611 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3547 m0 *1 134.32,116.96
X$3547 94 1581 465 1604 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3548 m0 *1 135.7,116.96
X$3548 94 1604 1244 1571 75 94 1610 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3549 m0 *1 137.54,116.96
X$3549 94 1605 1578 1608 94 1575 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3551 m0 *1 139.84,116.96
X$3551 94 1577 1096 1581 1097 94 1608 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3553 m0 *1 143.52,116.96
X$3553 94 1638 1550 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3554 m0 *1 144.9,116.96
X$3554 94 1606 1508 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3555 m0 *1 146.28,116.96
X$3555 94 1548 94 1638 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3556 m0 *1 149.96,116.96
X$3556 94 1547 94 1573 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3558 r0 *1 2.3,116.96
X$3558 94 1586 94 1680 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3559 r0 *1 5.98,116.96
X$3559 94 1681 1549 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3561 r0 *1 8.28,116.96
X$3561 94 1621 1659 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3562 r0 *1 9.66,116.96
X$3562 94 1660 1642 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3563 r0 *1 11.04,116.96
X$3563 94 1266 1557 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3565 r0 *1 13.34,116.96
X$3565 94 1682 1622 1623 94 1663 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3568 r0 *1 15.64,116.96
X$3568 94 1590 1643 1662 94 1660 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3569 r0 *1 17.48,116.96
X$3569 94 1663 1619 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3570 r0 *1 18.86,116.96
X$3570 94 1644 1664 1683 94 1661 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3571 r0 *1 20.7,116.96
X$3571 94 1589 1231 836 94 1664 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3573 r0 *1 23.46,116.96
X$3573 94 1645 1646 1685 94 1621 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3574 r0 *1 25.3,116.96
X$3574 94 1587 1231 836 94 1646 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3575 r0 *1 27.14,116.96
X$3575 94 264 1686 1560 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3578 r0 *1 33.12,116.96
X$3578 94 1587 979 1002 1689 1687 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3579 r0 *1 35.88,116.96
X$3579 94 1665 878 1735 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3581 r0 *1 39.1,116.96
X$3581 94 1589 979 1002 1691 1736 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3585 r0 *1 43.24,116.96
X$3585 94 264 1694 1625 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3587 r0 *1 45.08,116.96
X$3587 94 1626 979 1002 1696 1695 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3588 r0 *1 47.84,116.96
X$3588 94 1626 1231 836 94 1692 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3591 r0 *1 51.98,116.96
X$3591 94 1427 1582 1649 1448 75 1666 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3592 r0 *1 54.74,116.96
X$3592 94 1626 1419 973 94 1698 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3595 r0 *1 57.96,116.96
X$3595 94 1427 1566 1651 1448 75 1667 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3598 r0 *1 63.02,116.96
X$3598 94 1627 1231 836 94 1739 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3599 r0 *1 64.86,116.96
X$3599 94 1668 979 1002 1618 1700 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3603 r0 *1 69,116.96
X$3603 94 264 1628 1596 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3606 r0 *1 71.3,116.96
X$3606 94 1427 1614 1703 1448 75 1702 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3609 r0 *1 75.44,116.96
X$3609 94 1596 1324 1342 1671 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3610 r0 *1 77.28,116.96
X$3610 94 1346 1614 1671 1347 75 1708 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3614 r0 *1 83.26,116.96
X$3614 94 1346 1585 1655 1347 75 1710 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3616 r0 *1 86.94,116.96
X$3616 94 1427 1585 1657 1448 75 1629 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3618 r0 *1 90.62,116.96
X$3618 94 1712 1240 1131 1656 1774 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3620 r0 *1 93.84,116.96
X$3620 94 1346 1598 1615 1347 75 1711 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3625 r0 *1 98.44,116.96
X$3625 94 1427 1598 1707 1448 75 1705 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3627 r0 *1 104.88,116.96
X$3627 94 1652 1324 1342 1632 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3630 r0 *1 108.1,116.96
X$3630 94 1673 1270 860 1299 1109 94 1504 75 75 sky130_fd_sc_hd__o2111ai_1
* cell instance $3631 r0 *1 111.32,116.96
X$3631 94 1346 1503 1632 1347 75 1633 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3633 r0 *1 114.54,116.96
X$3633 94 1346 1481 1584 1347 75 1605 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3634 r0 *1 117.3,116.96
X$3634 94 1346 1673 1676 1347 75 1635 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3635 r0 *1 120.06,116.96
X$3635 94 1540 1324 786 1676 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3636 r0 *1 121.9,116.96
X$3636 94 1570 1240 1131 1601 1648 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3640 r0 *1 126.04,116.96
X$3640 94 1446 1217 1551 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3641 r0 *1 127.42,116.96
X$3641 94 1570 530 1513 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3643 r0 *1 129.72,116.96
X$3643 94 1636 1648 1350 1677 75 94 1688 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3644 r0 *1 132.02,116.96
X$3644 94 1577 1217 1636 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3645 r0 *1 133.4,116.96
X$3645 94 1581 1357 1677 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3647 r0 *1 135.24,116.96
X$3647 75 80 1570 1505 1684 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3649 r0 *1 147.2,116.96
X$3649 94 1637 1640 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3651 r0 *1 149.5,116.96
X$3651 94 1678 94 1801 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3666 m0 *1 1.38,122.4
X$3666 75 80 1587 1480 1757 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3667 m0 *1 12.42,122.4
X$3667 94 1661 1620 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3669 m0 *1 14.26,122.4
X$3669 94 1714 712 1693 1085 94 1623 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3670 m0 *1 17.02,122.4
X$3670 94 1715 712 1665 1085 94 1662 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3671 m0 *1 19.78,122.4
X$3671 94 1714 1193 1693 1086 94 1683 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3673 m0 *1 23.46,122.4
X$3673 94 1715 1193 1665 1086 94 1685 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3676 m0 *1 27.6,122.4
X$3676 94 264 1716 1579 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3679 m0 *1 29.9,122.4
X$3679 94 1715 1053 1665 1078 94 1806 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3681 m0 *1 33.12,122.4
X$3681 94 1715 956 1717 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3682 m0 *1 34.5,122.4
X$3682 94 1717 1687 921 1735 75 94 1734 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3684 m0 *1 37.26,122.4
X$3684 94 1714 956 1690 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3685 m0 *1 38.64,122.4
X$3685 94 1690 1736 921 1718 75 94 1951 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3686 m0 *1 40.94,122.4
X$3686 94 1693 1357 1718 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3687 m0 *1 42.32,122.4
X$3687 94 1624 1697 1692 94 75 1765 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3688 m0 *1 44.16,122.4
X$3688 94 1719 956 1720 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3689 m0 *1 45.54,122.4
X$3689 94 1720 1695 921 1721 75 94 1743 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3690 m0 *1 47.84,122.4
X$3690 94 1722 1357 1721 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3691 m0 *1 49.22,122.4
X$3691 94 1719 1193 1722 1086 94 1697 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3692 m0 *1 51.98,122.4
X$3692 94 1719 1392 1722 1085 94 1737 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3693 m0 *1 54.74,122.4
X$3693 94 1666 1737 1698 94 75 1768 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3696 m0 *1 57.5,122.4
X$3696 94 1627 1419 1069 94 1699 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3697 m0 *1 59.34,122.4
X$3697 94 1667 1814 1699 94 75 1770 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3698 m0 *1 61.18,122.4
X$3698 94 1723 956 1771 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3699 m0 *1 62.56,122.4
X$3699 94 1723 1193 1744 1086 94 1740 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3700 m0 *1 65.32,122.4
X$3700 94 1741 1740 1739 94 75 1945 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3702 m0 *1 68.08,122.4
X$3702 94 1668 1419 1069 94 1701 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3703 m0 *1 69.92,122.4
X$3703 94 1702 1669 1701 94 75 1773 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3704 m0 *1 71.76,122.4
X$3704 94 1670 1392 1724 1085 94 1669 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3706 m0 *1 75.44,122.4
X$3706 94 1724 1357 1819 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3708 m0 *1 77.74,122.4
X$3708 94 1670 1193 1724 1086 94 1672 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3709 m0 *1 80.5,122.4
X$3709 94 1708 1672 1738 94 75 1709 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3710 m0 *1 82.34,122.4
X$3710 94 1668 1231 1075 94 1738 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3712 m0 *1 84.64,122.4
X$3712 94 1747 1193 1725 1086 94 1820 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3714 m0 *1 89.24,122.4
X$3714 94 1712 1419 1069 94 1776 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3716 m0 *1 92,122.4
X$3716 94 1725 1357 1772 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3719 m0 *1 94.76,122.4
X$3719 94 1726 1231 1075 94 1748 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3722 m0 *1 97.98,122.4
X$3722 94 1726 1240 1131 1631 1706 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3724 m0 *1 101.66,122.4
X$3724 94 1726 1419 1069 94 1704 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3725 m0 *1 103.5,122.4
X$3725 94 1705 1816 1704 94 75 1767 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3729 m0 *1 108.56,122.4
X$3729 94 264 1727 1652 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3730 m0 *1 109.94,122.4
X$3730 94 1652 1293 694 1674 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3732 m0 *1 112.24,122.4
X$3732 94 1427 1503 1674 1448 75 1751 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3733 m0 *1 115,122.4
X$3733 94 1427 1673 1675 1448 75 1810 94 75 sky130_fd_sc_hd__a211oi_1
* cell instance $3734 m0 *1 117.76,122.4
X$3734 94 1540 1293 694 1675 75 94 75 sky130_fd_sc_hd__nor3_1
* cell instance $3735 m0 *1 119.6,122.4
X$3735 94 1733 1240 1131 1552 1841 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3736 m0 *1 122.36,122.4
X$3736 94 1763 1240 1131 1600 1762 94 75 75 sky130_fd_sc_hd__o211ai_1
* cell instance $3740 m0 *1 128.34,122.4
X$3740 94 1761 1762 1350 1729 75 94 1760 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3741 m0 *1 130.64,122.4
X$3741 94 1728 1357 1729 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3743 m0 *1 135.7,122.4
X$3743 94 1733 1056 1075 94 1759 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3744 m0 *1 137.54,122.4
X$3744 94 1633 1732 1803 94 1758 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3746 m0 *1 139.84,122.4
X$3746 94 1688 1679 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3747 m0 *1 141.22,122.4
X$3747 94 1610 1574 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3748 m0 *1 142.6,122.4
X$3748 75 275 1581 1505 1730 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3749 r0 *1 1.38,122.4
X$3749 94 1680 1641 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3750 r0 *1 2.76,122.4
X$3750 75 197 1380 1480 1802 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3760 r0 *1 28.06,122.4
X$3760 94 1088 1804 1780 1806 94 75 1805 75 sky130_fd_sc_hd__o31ai_1
* cell instance $3761 r0 *1 30.82,122.4
X$3761 94 1587 1055 1780 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3764 r0 *1 33.58,122.4
X$3764 94 1533 1054 1783 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3766 r0 *1 35.42,122.4
X$3766 94 1580 1054 1862 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3767 r0 *1 36.8,122.4
X$3767 94 1587 1162 1784 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3770 r0 *1 40.48,122.4
X$3770 94 563 1694 1766 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $3775 r0 *1 44.62,122.4
X$3775 94 628 1766 1160 1808 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $3776 r0 *1 46.46,122.4
X$3776 94 1582 1054 1842 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3781 r0 *1 54.74,122.4
X$3781 94 1593 94 75 1811 75 sky130_fd_sc_hd__inv_1
* cell instance $3784 r0 *1 58.88,122.4
X$3784 94 1565 1723 1125 75 94 1813 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3785 r0 *1 60.72,122.4
X$3785 94 1723 1392 1744 1085 94 1814 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3787 r0 *1 64.4,122.4
X$3787 94 1771 1769 1350 1745 75 94 1815 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3788 r0 *1 66.7,122.4
X$3788 94 1744 1357 1745 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3795 r0 *1 73.6,122.4
X$3795 94 1775 1700 1350 1819 75 94 2097 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3797 r0 *1 76.36,122.4
X$3797 94 1614 1269 1818 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3798 r0 *1 77.74,122.4
X$3798 94 1670 1217 1775 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3802 r0 *1 82.34,122.4
X$3802 94 1712 1231 1075 94 1746 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3803 r0 *1 84.18,122.4
X$3803 94 1710 1820 1746 94 75 1777 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3805 r0 *1 86.48,122.4
X$3805 94 1747 1392 1725 1059 94 1787 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3806 r0 *1 89.24,122.4
X$3806 94 1629 1787 1776 94 75 1822 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3807 r0 *1 91.08,122.4
X$3807 94 1747 1217 1788 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3808 r0 *1 92.46,122.4
X$3808 94 1788 1774 1350 1772 75 94 1845 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3812 r0 *1 96.14,122.4
X$3812 94 1711 1821 1748 94 75 1876 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3814 r0 *1 98.44,122.4
X$3814 94 1749 1193 1750 1097 94 1821 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3815 r0 *1 101.2,122.4
X$3815 94 1726 530 1817 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3816 r0 *1 102.58,122.4
X$3816 94 1750 1357 1844 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3819 r0 *1 105.34,122.4
X$3819 94 1749 1392 1750 1059 94 1816 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3822 r0 *1 110.4,122.4
X$3822 94 264 1790 1540 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3826 r0 *1 117.76,122.4
X$3826 94 1810 1792 1752 94 75 1791 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3827 r0 *1 119.6,122.4
X$3827 94 1733 1419 1069 94 1752 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3828 r0 *1 121.44,122.4
X$3828 94 1751 1794 1764 94 75 1809 75 sky130_fd_sc_hd__o21ai_1
* cell instance $3830 r0 *1 123.28,122.4
X$3830 94 1763 1419 1069 94 1764 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3833 r0 *1 126.04,122.4
X$3833 94 1753 1392 1728 1059 94 1794 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3834 r0 *1 128.8,122.4
X$3834 94 1753 1217 1761 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3835 r0 *1 130.18,122.4
X$3835 94 1754 657 1795 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3836 r0 *1 131.56,122.4
X$3836 94 1796 1392 1754 1059 94 1792 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3838 r0 *1 135.24,122.4
X$3838 94 1763 1056 1075 94 1732 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3840 r0 *1 138,122.4
X$3840 94 1753 1096 1728 1097 94 1803 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3841 r0 *1 140.76,122.4
X$3841 94 1801 1730 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3842 r0 *1 142.14,122.4
X$3842 75 138 1577 1505 1755 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3858 m0 *1 1.84,127.84
X$3858 75 138 1715 1480 1838 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3859 m0 *1 12.88,127.84
X$3859 75 197 1533 1480 1840 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3862 m0 *1 26.68,127.84
X$3862 94 563 1716 1781 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $3864 m0 *1 29.44,127.84
X$3864 75 1804 977 1533 1046 1781 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3865 m0 *1 32.66,127.84
X$3865 94 628 1781 1160 1824 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $3866 m0 *1 34.5,127.84
X$3866 94 1782 1715 1125 75 94 1825 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3867 m0 *1 36.34,127.84
X$3867 94 1824 1783 1784 1110 1200 94 1782 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3869 m0 *1 40.02,127.84
X$3869 75 1826 977 1582 1046 1766 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3871 m0 *1 43.7,127.84
X$3871 94 1719 1053 1722 1078 94 1827 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3872 m0 *1 46.46,127.84
X$3872 94 1808 1842 1828 1110 1200 94 1866 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3873 m0 *1 49.68,127.84
X$3873 94 1626 1162 1828 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3875 m0 *1 51.52,127.84
X$3875 75 1829 977 1566 1046 1811 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3877 m0 *1 55.2,127.84
X$3877 94 1627 1055 1812 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3880 m0 *1 57.5,127.84
X$3880 94 1088 1829 1812 1830 94 75 1843 75 sky130_fd_sc_hd__o31ai_1
* cell instance $3881 m0 *1 60.26,127.84
X$3881 94 1723 1053 1744 1078 94 1830 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3886 m0 *1 69.92,127.84
X$3886 94 563 1628 1831 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $3887 m0 *1 72.22,127.84
X$3887 94 628 1831 1160 1785 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $3889 m0 *1 74.52,127.84
X$3889 94 1785 1818 1786 1317 1200 94 1870 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3891 m0 *1 78.2,127.84
X$3891 94 1668 1162 1786 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3894 m0 *1 81.88,127.84
X$3894 94 563 1653 1846 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $3896 m0 *1 84.64,127.84
X$3896 94 628 1846 1160 1873 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $3899 m0 *1 87.86,127.84
X$3899 94 1585 1269 1874 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3900 m0 *1 89.24,127.84
X$3900 94 1712 530 1875 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3905 m0 *1 97.52,127.84
X$3905 94 1598 1269 1872 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3907 m0 *1 99.36,127.84
X$3907 94 1749 1217 1832 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3908 m0 *1 100.74,127.84
X$3908 94 1832 1706 1350 1844 75 94 1789 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3910 m0 *1 104.88,127.84
X$3910 94 1750 465 1871 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3914 m0 *1 109.48,127.84
X$3914 94 526 1790 1833 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $3916 m0 *1 112.24,127.84
X$3916 94 628 1833 1160 1834 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $3918 m0 *1 115.92,127.84
X$3918 94 1673 1269 1868 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3920 m0 *1 117.76,127.84
X$3920 94 1834 1868 1793 1317 534 94 1807 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3921 m0 *1 120.98,127.84
X$3921 94 1733 530 1793 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3922 m0 *1 122.36,127.84
X$3922 94 1503 1269 1835 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3923 m0 *1 123.74,127.84
X$3923 94 1763 530 1865 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3926 m0 *1 127.88,127.84
X$3926 94 1796 1217 1836 94 75 75 sky130_fd_sc_hd__nand2_1
* cell instance $3927 m0 *1 129.26,127.84
X$3927 94 1836 1841 1350 1795 75 94 1861 75 sky130_fd_sc_hd__a31oi_1
* cell instance $3929 m0 *1 132.02,127.84
X$3929 94 1857 1755 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3930 m0 *1 133.4,127.84
X$3930 94 1796 1096 1754 1097 94 1797 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3931 m0 *1 136.16,127.84
X$3931 94 1635 1759 1797 94 1798 75 75 sky130_fd_sc_hd__o21ai_0
* cell instance $3932 m0 *1 138,127.84
X$3932 94 1798 1799 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3934 m0 *1 139.84,127.84
X$3934 94 1758 1800 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3935 m0 *1 141.22,127.84
X$3935 75 138 1796 1505 1839 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3936 m0 *1 152.26,127.84
X$3936 94 1576 1607 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3938 r0 *1 1.84,127.84
X$3938 94 1742 94 1892 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3939 r0 *1 5.52,127.84
X$3939 94 1823 94 1848 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3940 r0 *1 9.2,127.84
X$3940 94 1713 94 1894 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3941 r0 *1 12.88,127.84
X$3941 94 1848 1840 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3945 r0 *1 15.64,127.84
X$3945 94 1778 94 1893 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $3946 r0 *1 19.32,127.84
X$3946 94 1805 1779 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3947 r0 *1 20.7,127.84
X$3947 94 1849 1802 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $3950 r0 *1 24.84,127.84
X$3950 94 563 1686 1850 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $3951 r0 *1 27.14,127.84
X$3951 75 1896 977 1580 1046 1850 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3952 r0 *1 30.36,127.84
X$3952 94 1714 1053 1693 1078 94 1939 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3953 r0 *1 33.12,127.84
X$3953 94 628 1850 1160 1851 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $3955 r0 *1 35.42,127.84
X$3955 94 1851 1862 1879 1110 1200 94 1863 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3956 r0 *1 38.64,127.84
X$3956 94 1863 1714 1125 75 94 1897 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3957 r0 *1 40.48,127.84
X$3957 94 1589 1162 1879 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3961 r0 *1 43.24,127.84
X$3961 94 1088 1826 1900 1827 94 75 1880 75 sky130_fd_sc_hd__o31ai_1
* cell instance $3963 r0 *1 46.92,127.84
X$3963 94 1626 1055 1900 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3966 r0 *1 49.68,127.84
X$3966 94 1866 1719 1125 75 94 1902 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3969 r0 *1 56.12,127.84
X$3969 94 1867 1126 1813 75 94 1905 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3970 r0 *1 57.96,127.84
X$3970 94 1744 1234 1867 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3971 r0 *1 59.34,127.84
X$3971 75 138 1670 1401 1869 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $3976 r0 *1 73.14,127.84
X$3976 75 1909 869 1614 1046 1831 1183 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3978 r0 *1 76.82,127.84
X$3978 94 1870 1670 1256 75 94 1912 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3979 r0 *1 78.66,127.84
X$3979 94 1670 1205 1724 1206 94 1911 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $3981 r0 *1 81.88,127.84
X$3981 94 1668 1164 1910 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $3984 r0 *1 84.64,127.84
X$3984 75 1883 869 1585 922 1846 952 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3985 r0 *1 87.86,127.84
X$3985 94 1873 1874 1875 1317 534 94 1852 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3986 r0 *1 91.08,127.84
X$3986 94 1852 1747 1256 75 94 1915 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3988 r0 *1 93.84,127.84
X$3988 94 563 1654 1853 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $3990 r0 *1 96.14,127.84
X$3990 94 628 1853 1160 1885 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $3992 r0 *1 98.44,127.84
X$3992 75 1886 869 1598 922 1853 952 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $3993 r0 *1 101.66,127.84
X$3993 94 1885 1872 1817 1317 534 94 1854 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $3994 r0 *1 104.88,127.84
X$3994 94 1871 1244 1855 75 94 1908 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3995 r0 *1 106.72,127.84
X$3995 94 1854 1749 1256 75 94 1855 75 sky130_fd_sc_hd__a21oi_1
* cell instance $3998 r0 *1 109.94,127.84
X$3998 94 526 1727 1856 94 75 75 sky130_fd_sc_hd__and2_0
* cell instance $3999 r0 *1 112.24,127.84
X$3999 94 628 1856 1160 1898 94 75 75 sky130_fd_sc_hd__nand3_1
* cell instance $4000 r0 *1 114.08,127.84
X$4000 75 1904 869 1673 922 1833 952 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $4001 r0 *1 117.3,127.84
X$4001 75 1899 869 1503 922 1856 952 94 94 75 sky130_fd_sc_hd__a221oi_1
* cell instance $4003 r0 *1 122.36,127.84
X$4003 94 1898 1835 1865 1317 534 94 1864 75 75 sky130_fd_sc_hd__a311oi_1
* cell instance $4006 r0 *1 126.04,127.84
X$4006 94 1728 465 1888 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4007 r0 *1 127.42,127.84
X$4007 94 1796 1205 1754 1206 94 1887 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $4008 r0 *1 130.18,127.84
X$4008 94 1754 465 1895 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4010 r0 *1 132.48,127.84
X$4010 75 275 1754 1505 1860 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4011 r0 *1 143.52,127.84
X$4011 94 1858 1839 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4013 r0 *1 145.82,127.84
X$4013 94 1837 94 1858 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4014 r0 *1 149.5,127.84
X$4014 94 1756 94 1857 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4030 m0 *1 1.84,133.28
X$4030 75 80 1589 1480 1936 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4031 m0 *1 12.88,133.28
X$4031 75 275 1665 1480 1918 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4032 m0 *1 23.92,133.28
X$4032 94 1589 1055 1937 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4034 m0 *1 26.22,133.28
X$4034 94 1088 1896 1937 1939 94 75 1938 75 sky130_fd_sc_hd__o31ai_1
* cell instance $4038 m0 *1 32.2,133.28
X$4038 94 1665 1234 1940 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4039 m0 *1 33.58,133.28
X$4039 94 1940 1126 1825 75 94 1995 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4040 m0 *1 35.42,133.28
X$4040 75 275 1365 1554 1941 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4042 m0 *1 46.92,133.28
X$4042 94 1365 1234 1971 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4043 m0 *1 48.3,133.28
X$4043 94 1722 1234 1881 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4044 m0 *1 49.68,133.28
X$4044 94 1881 1126 1902 75 94 1903 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4046 m0 *1 55.2,133.28
X$4046 94 1905 1943 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4049 m0 *1 57.96,133.28
X$4049 94 1770 1906 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4050 m0 *1 59.34,133.28
X$4050 94 1923 1944 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4051 m0 *1 60.72,133.28
X$4051 94 1922 1907 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4053 m0 *1 63.94,133.28
X$4053 75 275 1724 1401 1921 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4054 m0 *1 74.98,133.28
X$4054 94 1088 1909 1910 1911 94 75 1924 75 sky130_fd_sc_hd__o31ai_1
* cell instance $4055 m0 *1 77.74,133.28
X$4055 94 1724 1234 1882 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4057 m0 *1 79.58,133.28
X$4057 94 1882 1244 1912 75 94 1913 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4061 m0 *1 84.64,133.28
X$4061 94 1712 1164 1914 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4062 m0 *1 86.02,133.28
X$4062 94 895 1883 1914 1884 94 75 1948 75 sky130_fd_sc_hd__o31ai_1
* cell instance $4063 m0 *1 88.78,133.28
X$4063 94 1747 1205 1725 1206 94 1884 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $4064 m0 *1 91.54,133.28
X$4064 94 1725 465 1947 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4065 m0 *1 92.92,133.28
X$4065 75 138 1749 1539 1946 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4066 m0 *1 103.96,133.28
X$4066 94 1749 1205 1750 1206 94 1927 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $4073 m0 *1 116.38,133.28
X$4073 94 895 1904 1901 1887 94 75 1958 75 sky130_fd_sc_hd__o31ai_1
* cell instance $4075 m0 *1 119.6,133.28
X$4075 94 1733 1164 1901 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4078 m0 *1 122.36,133.28
X$4078 94 1864 1753 1256 75 94 1942 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4080 m0 *1 124.66,133.28
X$4080 94 1753 1205 1728 1206 94 1929 75 75 sky130_fd_sc_hd__a22oi_1
* cell instance $4082 m0 *1 128.34,133.28
X$4082 75 275 1728 1505 1930 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4085 m0 *1 140.76,133.28
X$4085 94 1861 1932 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4086 m0 *1 142.14,133.28
X$4086 94 1889 1684 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4087 m0 *1 143.52,133.28
X$4087 94 1931 1960 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4088 m0 *1 144.9,133.28
X$4088 94 1934 1930 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4089 m0 *1 146.28,133.28
X$4089 94 1890 94 1935 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4090 m0 *1 149.96,133.28
X$4090 94 1731 94 1889 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4091 r0 *1 1.38,133.28
X$4091 94 1892 1362 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4092 r0 *1 2.76,133.28
X$4092 75 138 1714 1480 1961 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4093 r0 *1 13.8,133.28
X$4093 94 1186 1877 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4096 r0 *1 15.64,133.28
X$4096 94 1878 94 1962 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4097 r0 *1 19.32,133.28
X$4097 94 1963 1936 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4101 r0 *1 25.76,133.28
X$4101 75 275 1722 1480 1964 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4102 r0 *1 36.8,133.28
X$4102 94 1693 1234 1967 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4103 r0 *1 38.18,133.28
X$4103 94 1967 1126 1897 75 94 1966 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4104 r0 *1 40.02,133.28
X$4104 94 1952 1968 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4105 r0 *1 41.4,133.28
X$4105 94 1953 1954 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4108 r0 *1 43.24,133.28
X$4108 94 1400 1920 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4109 r0 *1 44.62,133.28
X$4109 94 1919 1970 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4111 r0 *1 46.92,133.28
X$4111 94 1971 1126 1494 75 94 1953 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4112 r0 *1 48.76,133.28
X$4112 94 2029 1974 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4113 r0 *1 50.14,133.28
X$4113 94 1903 1975 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4114 r0 *1 51.52,133.28
X$4114 94 2093 2120 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4115 r0 *1 52.9,133.28
X$4115 75 275 1744 1401 1976 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4117 r0 *1 64.86,133.28
X$4117 94 1815 1978 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4118 r0 *1 66.24,133.28
X$4118 94 1453 1979 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4127 r0 *1 79.58,133.28
X$4127 75 275 1725 1539 1925 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4129 r0 *1 91.08,133.28
X$4129 94 1947 1244 1915 75 94 1983 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4132 r0 *1 94.3,133.28
X$4132 94 1822 1957 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4135 r0 *1 96.6,133.28
X$4135 94 1926 1982 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4137 r0 *1 98.44,133.28
X$4137 94 895 1886 1980 1927 94 75 1926 75 sky130_fd_sc_hd__o31ai_1
* cell instance $4138 r0 *1 101.2,133.28
X$4138 94 1726 1164 1980 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4140 r0 *1 103.04,133.28
X$4140 94 1908 1981 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4142 r0 *1 104.88,133.28
X$4142 75 197 1673 1402 1928 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4145 r0 *1 121.44,133.28
X$4145 94 1763 1164 1972 75 94 75 sky130_fd_sc_hd__nor2_1
* cell instance $4146 r0 *1 122.82,133.28
X$4146 94 895 1899 1972 1929 94 75 1973 75 sky130_fd_sc_hd__o31ai_1
* cell instance $4149 r0 *1 126.04,133.28
X$4149 94 1888 1244 1942 75 94 1969 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4150 r0 *1 127.88,133.28
X$4150 94 1807 1796 1256 75 94 1959 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4151 r0 *1 129.72,133.28
X$4151 94 1895 1244 1959 75 94 1965 75 sky130_fd_sc_hd__a21oi_1
* cell instance $4155 r0 *1 138,133.28
X$4155 75 275 1750 1505 1960 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4157 r0 *1 149.5,133.28
X$4157 94 1859 94 1931 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4172 m0 *1 1.38,138.72
X$4172 94 1893 1838 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4173 m0 *1 2.76,138.72
X$4173 94 1847 94 1849 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4174 m0 *1 6.44,138.72
X$4174 94 1917 94 1963 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4175 m0 *1 10.12,138.72
X$4175 75 275 1693 1480 1992 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4179 m0 *1 26.22,138.72
X$4179 94 1993 1994 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4185 m0 *1 31.74,138.72
X$4185 94 1996 1941 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4189 m0 *1 36.34,138.72
X$4189 94 1995 1985 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4190 m0 *1 37.72,138.72
X$4190 94 1951 2073 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4191 m0 *1 39.1,138.72
X$4191 75 138 1466 1554 1968 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4192 m0 *1 50.14,138.72
X$4192 94 2033 2030 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4193 m0 *1 51.52,138.72
X$4193 94 1999 1976 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4194 m0 *1 52.9,138.72
X$4194 94 2001 94 1999 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4197 m0 *1 57.96,138.72
X$4197 94 1768 2002 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4198 m0 *1 59.34,138.72
X$4198 94 2004 94 2005 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4199 m0 *1 63.02,138.72
X$4199 94 2007 94 1977 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4200 m0 *1 66.7,138.72
X$4200 94 1986 1458 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4201 m0 *1 68.08,138.72
X$4201 94 1773 1956 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4202 m0 *1 69.46,138.72
X$4202 94 1987 2006 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4203 m0 *1 70.84,138.72
X$4203 94 1529 1955 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4205 m0 *1 73.14,138.72
X$4205 75 138 1747 1554 2003 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4209 m0 *1 86.94,138.72
X$4209 75 80 1726 1539 2000 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4210 m0 *1 97.98,138.72
X$4210 94 2065 2032 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4214 m0 *1 112.24,138.72
X$4214 75 197 1503 1402 1997 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4218 m0 *1 128.34,138.72
X$4218 75 138 1753 1505 1989 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4223 m0 *1 145.82,138.72
X$4223 94 1935 1860 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4224 m0 *1 149.96,138.72
X$4224 94 1933 94 1934 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4226 r0 *1 1.38,138.72
X$4226 94 1894 1757 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4228 r0 *1 3.68,138.72
X$4228 75 197 1580 1480 2018 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4233 r0 *1 19.32,138.72
X$4233 94 2020 2008 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4235 r0 *1 21.16,138.72
X$4235 75 138 1719 1480 2008 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4236 r0 *1 32.2,138.72
X$4236 94 2023 94 2092 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4238 r0 *1 36.34,138.72
X$4238 94 1880 2031 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4239 r0 *1 37.72,138.72
X$4239 94 1743 2024 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4240 r0 *1 39.1,138.72
X$4240 94 2026 94 1952 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4244 r0 *1 43.7,138.72
X$4244 94 2009 94 2029 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4245 r0 *1 47.38,138.72
X$4245 94 2028 94 2033 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4246 r0 *1 51.06,138.72
X$4246 75 138 1723 1401 2030 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4248 r0 *1 62.56,138.72
X$4248 94 2039 94 1923 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4249 r0 *1 66.24,138.72
X$4249 94 2040 94 2044 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4253 r0 *1 70.84,138.72
X$4253 75 80 1455 1554 2006 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4256 r0 *1 86.02,138.72
X$4256 94 1789 2010 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4257 r0 *1 87.4,138.72
X$4257 94 2038 2078 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4258 r0 *1 88.78,138.72
X$4258 94 2068 2000 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4259 r0 *1 90.16,138.72
X$4259 94 2011 2013 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4260 r0 *1 91.54,138.72
X$4260 94 1983 2037 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4261 r0 *1 92.92,138.72
X$4261 94 2036 1946 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4262 r0 *1 94.3,138.72
X$4262 94 1555 2035 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4265 r0 *1 96.6,138.72
X$4265 94 1876 2034 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4267 r0 *1 109.48,138.72
X$4267 94 2027 94 2025 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4268 r0 *1 113.16,138.72
X$4268 94 1988 1928 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4269 r0 *1 114.54,138.72
X$4269 75 197 1481 1505 2015 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4274 r0 *1 127.42,138.72
X$4274 94 2117 2015 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4275 r0 *1 128.8,138.72
X$4275 94 1965 2022 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4276 r0 *1 130.18,138.72
X$4276 94 2145 2021 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4277 r0 *1 131.56,138.72
X$4277 94 2019 1989 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4283 r0 *1 149.04,138.72
X$4283 94 1760 1891 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4300 m0 *1 2.3,144.16
X$4300 94 1949 1104 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4301 m0 *1 3.68,144.16
X$4301 94 1916 94 2052 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4302 m0 *1 7.36,144.16
X$4302 94 1950 94 2053 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4303 m0 *1 11.04,144.16
X$4303 94 2053 1992 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4306 m0 *1 27.6,144.16
X$4306 94 2089 2043 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4309 m0 *1 29.9,144.16
X$4309 94 1765 2055 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4310 m0 *1 31.28,144.16
X$4310 94 2042 2058 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4312 m0 *1 44.16,144.16
X$4312 94 2005 2045 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4313 m0 *1 45.54,144.16
X$4313 75 80 1627 1554 1974 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4316 m0 *1 57.96,144.16
X$4316 94 1843 2157 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4317 m0 *1 59.34,144.16
X$4317 75 80 1668 1401 1907 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4318 m0 *1 70.38,144.16
X$4318 94 2067 2066 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4319 m0 *1 71.76,144.16
X$4319 94 2151 2003 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4320 m0 *1 73.14,144.16
X$4320 75 197 1585 1401 2046 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4323 m0 *1 85.1,144.16
X$4323 94 1948 2069 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4324 m0 *1 86.48,144.16
X$4324 75 197 1598 1539 2047 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4325 m0 *1 97.52,144.16
X$4325 94 2012 94 2065 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4326 m0 *1 101.2,144.16
X$4326 94 2064 94 2011 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4327 m0 *1 104.88,144.16
X$4327 94 2048 94 2050 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4328 m0 *1 108.56,144.16
X$4328 94 2025 1998 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4329 m0 *1 109.94,144.16
X$4329 94 2063 1450 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4332 m0 *1 112.24,144.16
X$4332 94 2014 94 2063 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4333 m0 *1 115.92,144.16
X$4333 94 2049 94 2057 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4334 m0 *1 119.6,144.16
X$4334 94 2050 2091 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4335 m0 *1 120.98,144.16
X$4335 94 2060 1997 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4336 m0 *1 122.36,144.16
X$4336 94 1791 2062 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4337 m0 *1 123.74,144.16
X$4337 94 1958 2061 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4338 m0 *1 125.12,144.16
X$4338 94 1973 2059 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4339 m0 *1 126.5,144.16
X$4339 94 1969 2056 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4341 m0 *1 128.34,144.16
X$4341 75 80 1763 1505 2021 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4351 r0 *1 1.38,144.16
X$4351 94 1984 94 2070 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4353 r0 *1 5.52,144.16
X$4353 94 2052 1918 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4354 r0 *1 6.9,144.16
X$4354 94 1962 1961 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4357 r0 *1 12.42,144.16
X$4357 94 2071 2102 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4358 r0 *1 13.8,144.16
X$4358 94 1734 2099 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4362 r0 *1 16.1,144.16
X$4362 94 2041 1964 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4363 r0 *1 17.48,144.16
X$4363 94 1966 2155 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4364 r0 *1 18.86,144.16
X$4364 94 2088 94 2041 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4365 r0 *1 22.54,144.16
X$4365 94 2140 94 2089 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4366 r0 *1 26.22,144.16
X$4366 75 80 1626 1480 2072 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4368 r0 *1 37.72,144.16
X$4368 94 2044 1869 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4369 r0 *1 39.1,144.16
X$4369 94 2118 94 2093 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4373 r0 *1 43.7,144.16
X$4373 75 197 1614 1554 1970 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4374 r0 *1 54.74,144.16
X$4374 94 2074 94 1922 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4378 r0 *1 70.84,144.16
X$4378 94 2097 2098 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4379 r0 *1 72.22,144.16
X$4379 75 80 1712 1401 2075 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4380 r0 *1 83.26,144.16
X$4380 94 1913 2076 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4381 r0 *1 84.64,144.16
X$4381 94 1457 2077 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4382 r0 *1 86.02,144.16
X$4382 94 2095 1925 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4383 r0 *1 87.4,144.16
X$4383 94 1339 2096 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4384 r0 *1 88.78,144.16
X$4384 94 1777 2094 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4385 r0 *1 90.16,144.16
X$4385 94 2160 94 2068 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4386 r0 *1 93.84,144.16
X$4386 94 2079 94 2038 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4390 r0 *1 120.52,144.16
X$4390 94 2083 94 2060 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4392 r0 *1 124.2,144.16
X$4392 94 1767 2084 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4394 r0 *1 126.04,144.16
X$4394 94 2057 2082 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4395 r0 *1 127.42,144.16
X$4395 94 1809 2090 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4396 r0 *1 128.8,144.16
X$4396 75 80 1733 1505 2085 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4397 r0 *1 139.84,144.16
X$4397 94 2087 2085 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4418 m0 *1 1.38,149.6
X$4418 94 2070 2018 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4422 m0 *1 7.82,149.6
X$4422 94 2137 2054 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4423 m0 *1 9.2,149.6
X$4423 94 2110 2100 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4424 m0 *1 10.58,149.6
X$4424 94 2101 94 2110 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4425 m0 *1 14.26,149.6
X$4425 94 2113 94 2071 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4427 m0 *1 29.44,149.6
X$4427 94 2103 94 1919 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4428 m0 *1 44.16,149.6
X$4428 94 1945 2119 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4430 m0 *1 68.08,149.6
X$4430 94 2104 2075 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4431 m0 *1 69.46,149.6
X$4431 94 1924 2105 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4432 m0 *1 81.88,149.6
X$4432 94 1709 2122 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4435 m0 *1 95.68,149.6
X$4435 94 2107 94 2036 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4436 m0 *1 110.4,149.6
X$4436 94 2153 2047 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4438 m0 *1 112.24,149.6
X$4438 94 1845 2080 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4439 m0 *1 113.62,149.6
X$4439 75 197 1257 1505 2109 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4440 m0 *1 124.66,149.6
X$4440 94 2132 94 2117 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4441 m0 *1 128.34,149.6
X$4441 94 2081 94 2112 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4442 m0 *1 132.02,149.6
X$4442 94 2116 94 2087 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4443 m0 *1 135.7,149.6
X$4443 94 2115 94 2019 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4463 r0 *1 6.44,149.6
X$4463 94 1938 2142 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4464 r0 *1 7.82,149.6
X$4464 94 2139 94 2137 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4465 r0 *1 11.5,149.6
X$4465 94 2138 94 2020 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4469 r0 *1 16.56,149.6
X$4469 94 2092 2072 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4470 r0 *1 17.94,149.6
X$4470 94 2123 94 1993 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4471 r0 *1 21.62,149.6
X$4471 94 2141 94 1996 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4472 r0 *1 25.3,149.6
X$4472 94 2156 94 2042 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4475 r0 *1 30.36,149.6
X$4475 75 197 1582 1480 1994 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4476 r0 *1 41.4,149.6
X$4476 94 1977 1921 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4479 r0 *1 43.24,149.6
X$4479 75 197 1566 1554 2058 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4481 r0 *1 55.2,149.6
X$4481 94 2124 2106 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4484 r0 *1 57.96,149.6
X$4484 94 2125 2046 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4485 r0 *1 59.34,149.6
X$4485 94 2126 94 1987 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4486 r0 *1 63.02,149.6
X$4486 94 2148 94 2124 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4487 r0 *1 66.7,149.6
X$4487 94 2147 94 1986 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4491 r0 *1 71.76,149.6
X$4491 94 2150 94 2151 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4492 r0 *1 75.44,149.6
X$4492 94 2158 94 2104 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4493 r0 *1 79.12,149.6
X$4493 94 2149 94 2125 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4494 r0 *1 82.8,149.6
X$4494 94 1617 2152 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4496 r0 *1 84.64,149.6
X$4496 94 2154 94 2095 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4497 r0 *1 88.32,149.6
X$4497 94 2127 94 2129 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4498 r0 *1 92,149.6
X$4498 94 2128 94 2153 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4499 r0 *1 95.68,149.6
X$4499 94 2129 2121 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4503 r0 *1 98.44,149.6
X$4503 94 1501 2108 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4506 r0 *1 112.24,149.6
X$4506 94 1500 2159 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4508 r0 *1 114.54,149.6
X$4508 75 197 1403 1505 2131 94 94 75 sky130_fd_sc_hd__edfxtp_1
* cell instance $4511 r0 *1 126.04,149.6
X$4511 94 2146 94 1988 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4512 r0 *1 129.72,149.6
X$4512 94 2130 94 2133 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4513 r0 *1 133.4,149.6
X$4513 94 2144 94 2145 75 75 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $4514 r0 *1 137.08,149.6
X$4514 94 2133 2109 75 94 75 sky130_fd_sc_hd__clkbuf_1
* cell instance $4517 r0 *1 145.36,149.6
X$4517 94 2112 2131 75 94 75 sky130_fd_sc_hd__clkbuf_1
.ENDS mesh_router

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__or4_1
* pin VPB
* pin A
* pin B
* pin C
* pin D
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or4_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 D
* net 7 X
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 13 5 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $2 r0 *1 0.95,1.695 pfet_01v8_hvt
M$2 12 4 13 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $3 r0 *1 1.31,1.695 pfet_01v8_hvt
M$3 11 3 12 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $4 r0 *1 1.79,1.695 pfet_01v8_hvt
M$4 8 2 11 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $5 r0 *1 2.28,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=270000000000P PS=1340000U PD=2540000U
* device instance $6 r0 *1 0.47,0.475 nfet_01v8
M$6 6 5 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $7 r0 *1 0.95,0.475 nfet_01v8
M$7 9 4 6 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $8 r0 *1 1.37,0.475 nfet_01v8
M$8 6 3 9 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $9 r0 *1 1.79,0.475 nfet_01v8
M$9 6 2 9 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $10 r0 *1 2.28,0.56 nfet_01v8
M$10 7 6 9 10 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=175500000000P
+ PS=990000U PD=1840000U
.ENDS sky130_fd_sc_hd__or4_1

* cell sky130_fd_sc_hd__or4_4
* pin VGND
* pin D
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or4_4 1 2 4 5 6 7 8 9 13
* net 1 VGND
* net 2 D
* net 4 X
* net 5 C
* net 6 B
* net 7 A
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 2 3 9 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=190000000000P PS=2520000U PD=1380000U
* device instance $2 r0 *1 1.025,1.985 pfet_01v8_hvt
M$2 12 5 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $3 r0 *1 1.445,1.985 pfet_01v8_hvt
M$3 11 6 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.865,1.985 pfet_01v8_hvt
M$4 8 7 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=190000000000P PS=1270000U PD=1380000U
* device instance $5 r0 *1 2.395,1.985 pfet_01v8_hvt
M$5 4 3 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=595000000000P
+ AD=675000000000P PS=5190000U PD=6350000U
* device instance $9 r0 *1 0.495,0.56 nfet_01v8
M$9 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=123500000000P
+ PS=1820000U PD=1030000U
* device instance $10 r0 *1 1.025,0.56 nfet_01v8
M$10 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=87750000000P
+ PS=1030000U PD=920000U
* device instance $11 r0 *1 1.445,0.56 nfet_01v8
M$11 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $12 r0 *1 1.865,0.56 nfet_01v8
M$12 1 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $13 r0 *1 2.395,0.56 nfet_01v8
M$13 4 3 1 13 nfet_01v8 L=150000U W=2600000U AS=386750000000P AD=442000000000P
+ PS=3790000U PD=4610000U
.ENDS sky130_fd_sc_hd__or4_4

* cell sky130_fd_sc_hd__a211o_2
* pin VGND
* pin X
* pin A2
* pin A1
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a211o_2 1 2 5 6 7 8 9 11 12
* net 1 VGND
* net 2 X
* net 5 A2
* net 6 A1
* net 7 B1
* net 8 C1
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 9 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=195000000000P PS=2520000U PD=1390000U
* device instance $2 r0 *1 2.37,1.985 pfet_01v8_hvt
M$2 10 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=165000000000P PS=1390000U PD=1330000U
* device instance $3 r0 *1 2.85,1.985 pfet_01v8_hvt
M$3 13 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=105000000000P PS=1330000U PD=1210000U
* device instance $4 r0 *1 3.21,1.985 pfet_01v8_hvt
M$4 3 8 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 2 3 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 2 3 1 12 nfet_01v8 L=150000U W=1300000U AS=260000000000P AD=290875000000P
+ PS=2750000U PD=2195000U
* device instance $9 r0 *1 1.665,0.56 nfet_01v8
M$9 4 5 1 12 nfet_01v8 L=150000U W=650000U AS=199875000000P AD=133250000000P
+ PS=1265000U PD=1060000U
* device instance $10 r0 *1 2.225,0.56 nfet_01v8
M$10 3 6 4 12 nfet_01v8 L=150000U W=650000U AS=133250000000P AD=115375000000P
+ PS=1060000U PD=1005000U
* device instance $11 r0 *1 2.73,0.56 nfet_01v8
M$11 1 7 3 12 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=107250000000P
+ PS=1005000U PD=980000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 3 8 1 12 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a211o_2

* cell sky130_fd_sc_hd__o311ai_4
* pin VGND
* pin A1
* pin A2
* pin A3
* pin B1
* pin C1
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_4 1 2 4 5 7 8 10 12 13 14
* net 1 VGND
* net 2 A1
* net 4 A2
* net 5 A3
* net 7 B1
* net 8 C1
* net 10 VPWR
* net 12 Y
* net 13 VPB
* device instance $1 r0 *1 4.43,1.985 pfet_01v8_hvt
M$1 11 5 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=550000000000P PS=6330000U PD=5100000U
* device instance $5 r0 *1 6.13,1.985 pfet_01v8_hvt
M$5 10 7 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=550000000000P
+ AD=540000000000P PS=5100000U PD=5080000U
* device instance $9 r0 *1 7.81,1.985 pfet_01v8_hvt
M$9 10 8 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 0.55,1.985 pfet_01v8_hvt
M$13 10 2 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $17 r0 *1 2.23,1.985 pfet_01v8_hvt
M$17 11 4 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 6.17,0.56 nfet_01v8
M$21 3 7 6 14 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $25 r0 *1 7.85,0.56 nfet_01v8
M$25 12 8 6 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=445250000000P
+ PS=3680000U PD=4620000U
* device instance $29 r0 *1 0.55,0.56 nfet_01v8
M$29 3 2 1 14 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $33 r0 *1 2.23,0.56 nfet_01v8
M$33 3 4 1 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=357500000000P
+ PS=3680000U PD=3700000U
* device instance $37 r0 *1 3.93,0.56 nfet_01v8
M$37 3 5 1 14 nfet_01v8 L=150000U W=2600000U AS=357500000000P AD=445250000000P
+ PS=3700000U PD=4620000U
.ENDS sky130_fd_sc_hd__o311ai_4

* cell sky130_fd_sc_hd__nor2_4
* pin VGND
* pin B
* pin Y
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor2_4 1 2 3 4 6 7 8
* net 1 VGND
* net 2 B
* net 3 Y
* net 4 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 4 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $5 r0 *1 2.17,1.985 pfet_01v8_hvt
M$5 3 2 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=675000000000P PS=5080000U PD=6350000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 3 4 1 8 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $13 r0 *1 2.17,0.56 nfet_01v8
M$13 3 2 1 8 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor2_4

* cell sky130_fd_sc_hd__ha_4
* pin VGND
* pin B
* pin COUT
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_4 1 5 7 8 11 12 15
* net 1 VGND
* net 3 SUM
* net 5 B
* net 7 COUT
* net 8 A
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=787500000000P PS=6330000U PD=5575000U
* device instance $5 r0 *1 2.645,1.985 pfet_01v8_hvt
M$5 2 6 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=517500000000P
+ AD=282500000000P PS=3035000U PD=2565000U
* device instance $7 r0 *1 3.51,1.985 pfet_01v8_hvt
M$7 13 8 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=147500000000P PS=1295000U PD=1295000U
* device instance $8 r0 *1 3.955,1.985 pfet_01v8_hvt
M$8 2 5 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=135000000000P PS=1295000U PD=1270000U
* device instance $9 r0 *1 4.375,1.985 pfet_01v8_hvt
M$9 14 5 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=287500000000P PS=1270000U PD=1575000U
* device instance $10 r0 *1 5.1,1.985 pfet_01v8_hvt
M$10 11 8 14 12 pfet_01v8_hvt L=150000U W=1000000U AS=287500000000P
+ AD=230000000000P PS=1575000U PD=1460000U
* device instance $11 r0 *1 5.71,1.985 pfet_01v8_hvt
M$11 6 8 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=365000000000P
+ AD=310000000000P PS=2730000U PD=2620000U
* device instance $12 r0 *1 6.13,1.985 pfet_01v8_hvt
M$12 11 5 6 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $15 r0 *1 7.47,1.985 pfet_01v8_hvt
M$15 7 6 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=580000000000P
+ AD=665000000000P PS=5160000U PD=6330000U
* device instance $19 r0 *1 5.34,0.56 nfet_01v8
M$19 1 8 4 15 nfet_01v8 L=150000U W=1300000U AS=273000000000P AD=183625000000P
+ PS=2790000U PD=1865000U
* device instance $20 r0 *1 5.76,0.56 nfet_01v8
M$20 10 8 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=71500000000P
+ PS=920000U PD=870000U
* device instance $21 r0 *1 6.13,0.56 nfet_01v8
M$21 6 5 10 15 nfet_01v8 L=150000U W=650000U AS=71500000000P AD=87750000000P
+ PS=870000U PD=920000U
* device instance $22 r0 *1 6.55,0.56 nfet_01v8
M$22 9 5 6 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $23 r0 *1 6.97,0.56 nfet_01v8
M$23 1 8 9 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $24 r0 *1 7.47,0.56 nfet_01v8
M$24 7 6 1 15 nfet_01v8 L=150000U W=2600000U AS=377000000000P AD=432250000000P
+ PS=3760000U PD=4580000U
* device instance $28 r0 *1 0.47,0.56 nfet_01v8
M$28 3 2 1 15 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=432250000000P
+ PS=4580000U PD=4580000U
* device instance $32 r0 *1 2.67,0.56 nfet_01v8
M$32 2 6 4 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $35 r0 *1 3.955,0.56 nfet_01v8
M$35 4 5 1 15 nfet_01v8 L=150000U W=1300000U AS=183625000000P AD=256750000000P
+ PS=1865000U PD=2740000U
.ENDS sky130_fd_sc_hd__ha_4

* cell sky130_fd_sc_hd__o21a_2
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__o21a_2 1 3 4 5 6 7 8 10
* net 1 VPB
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=397500000000P
+ AD=537500000000P PS=3795000U PD=3075000U
* device instance $3 r0 *1 1.845,1.985 pfet_01v8_hvt
M$3 2 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=400000000000P
+ AD=140000000000P PS=1800000U PD=1280000U
* device instance $4 r0 *1 2.275,1.985 pfet_01v8_hvt
M$4 11 4 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=160000000000P PS=1280000U PD=1320000U
* device instance $5 r0 *1 2.745,1.985 pfet_01v8_hvt
M$5 7 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=265000000000P PS=1320000U PD=2530000U
* device instance $6 r0 *1 1.845,0.56 nfet_01v8
M$6 9 3 2 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $7 r0 *1 2.275,0.56 nfet_01v8
M$7 6 4 9 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=104000000000P
+ PS=930000U PD=970000U
* device instance $8 r0 *1 2.745,0.56 nfet_01v8
M$8 9 5 6 10 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=172250000000P
+ PS=970000U PD=1830000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 8 2 6 10 nfet_01v8 L=150000U W=1300000U AS=258375000000P AD=261625000000P
+ PS=2745000U PD=2755000U
.ENDS sky130_fd_sc_hd__o21a_2

* cell sky130_fd_sc_hd__nor2b_2
* pin VPB
* pin B_N
* pin A
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_2 1 2 4 5 7 8 9
* net 1 VPB
* net 2 B_N
* net 4 A
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 2.69,2.275 pfet_01v8_hvt
M$1 7 2 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 7 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $4 r0 *1 1.33,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $6 r0 *1 2.69,0.675 nfet_01v8
M$6 5 2 3 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $7 r0 *1 0.49,0.56 nfet_01v8
M$7 8 4 5 9 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $9 r0 *1 1.33,0.56 nfet_01v8
M$9 8 3 5 9 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor2b_2

* cell sky130_fd_sc_hd__a311oi_2
* pin VGND
* pin Y
* pin A3
* pin A2
* pin A1
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_2 1 4 5 6 7 8 9 10 13 14
* net 1 VGND
* net 4 Y
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 B1
* net 9 C1
* net 10 VPWR
* net 13 VPB
* device instance $1 r0 *1 3.54,1.985 pfet_01v8_hvt
M$1 11 8 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=2790000U
* device instance $3 r0 *1 4.63,1.985 pfet_01v8_hvt
M$3 4 9 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=2790000U PD=3790000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 11 5 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 11 6 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=275000000000P
+ AD=285000000000P PS=2550000U PD=2570000U
* device instance $9 r0 *1 2.18,1.985 pfet_01v8_hvt
M$9 11 7 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=395000000000P PS=2560000U PD=3790000U
* device instance $11 r0 *1 2.67,0.56 nfet_01v8
M$11 3 7 4 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=185250000000P
+ PS=2740000U PD=1870000U
* device instance $13 r0 *1 3.54,0.56 nfet_01v8
M$13 1 8 4 14 nfet_01v8 L=150000U W=1300000U AS=185250000000P AD=256750000000P
+ PS=1870000U PD=2090000U
* device instance $15 r0 *1 4.63,0.56 nfet_01v8
M$15 1 9 4 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2090000U PD=2740000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 1 5 2 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $19 r0 *1 1.31,0.56 nfet_01v8
M$19 3 6 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a311oi_2

* cell sky130_fd_sc_hd__o211ai_2
* pin VGND
* pin Y
* pin A1
* pin C1
* pin B1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_2 1 3 5 6 7 8 9 11 12
* net 1 VGND
* net 3 Y
* net 5 A1
* net 6 C1
* net 7 B1
* net 8 A2
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.775,1.985 pfet_01v8_hvt
M$1 3 8 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 3.635,1.985 pfet_01v8_hvt
M$3 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $5 r0 *1 0.495,1.985 pfet_01v8_hvt
M$5 3 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $7 r0 *1 1.355,1.985 pfet_01v8_hvt
M$7 3 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $9 r0 *1 2.775,0.56 nfet_01v8
M$9 4 8 1 12 nfet_01v8 L=150000U W=1300000U AS=276250000000P AD=182000000000P
+ PS=2800000U PD=1860000U
* device instance $11 r0 *1 3.635,0.56 nfet_01v8
M$11 4 5 1 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=276250000000P
+ PS=1860000U PD=2800000U
* device instance $13 r0 *1 0.495,0.56 nfet_01v8
M$13 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=276250000000P AD=182000000000P
+ PS=2800000U PD=1860000U
* device instance $15 r0 *1 1.355,0.56 nfet_01v8
M$15 4 7 2 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=276250000000P
+ PS=1860000U PD=2800000U
.ENDS sky130_fd_sc_hd__o211ai_2

* cell sky130_fd_sc_hd__o21ai_4
* pin VGND
* pin A2
* pin B1
* pin A1
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_4 1 2 3 5 6 7 8 10
* net 1 VGND
* net 2 A2
* net 3 B1
* net 5 A1
* net 6 Y
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.5,1.985 pfet_01v8_hvt
M$1 9 5 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=580000000000P PS=6370000U PD=5160000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 2 9 8 pfet_01v8_hvt L=150000U W=4000000U AS=560000000000P
+ AD=560000000000P PS=5120000U PD=5120000U
* device instance $9 r0 *1 3.98,1.985 pfet_01v8_hvt
M$9 6 3 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=580000000000P
+ AD=685000000000P PS=5160000U PD=6370000U
* device instance $13 r0 *1 0.5,0.56 nfet_01v8
M$13 1 5 4 10 nfet_01v8 L=150000U W=2600000U AS=458250000000P AD=364000000000P
+ PS=4660000U PD=3720000U
* device instance $16 r0 *1 1.79,0.56 nfet_01v8
M$16 4 2 1 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=377000000000P
+ PS=3720000U PD=3760000U
* device instance $21 r0 *1 3.98,0.56 nfet_01v8
M$21 6 3 4 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=458250000000P
+ PS=3720000U PD=4660000U
.ENDS sky130_fd_sc_hd__o21ai_4

* cell sky130_fd_sc_hd__nor3b_1
* pin VPB
* pin B
* pin A
* pin C_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 C_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 2.055,1.86 pfet_01v8_hvt
M$1 8 4 7 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 11 8 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=320000000000P
+ AD=135000000000P PS=2640000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 10 2 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.57,1.985 pfet_01v8_hvt
M$4 7 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $5 r0 *1 0.73,0.56 nfet_01v8
M$5 6 8 5 9 nfet_01v8 L=150000U W=650000U AS=221000000000P AD=87750000000P
+ PS=1980000U PD=920000U
* device instance $6 r0 *1 1.15,0.56 nfet_01v8
M$6 5 2 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.57,0.56 nfet_01v8
M$7 6 3 5 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $8 r0 *1 2.055,0.675 nfet_01v8
M$8 8 4 6 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor3b_1

* cell sky130_fd_sc_hd__or3b_2
* pin VPB
* pin B
* pin A
* pin C_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or3b_2 1 2 3 5 6 8 9 10
* net 1 VPB
* net 2 B
* net 3 A
* net 5 C_N
* net 6 X
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 1.865,1.695 pfet_01v8_hvt
M$1 12 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=148250000000P AD=56700000000P
+ PS=1340000U PD=690000U
* device instance $2 r0 *1 2.285,1.695 pfet_01v8_hvt
M$2 11 2 12 1 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $3 r0 *1 2.705,1.695 pfet_01v8_hvt
M$3 7 4 11 1 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $4 r0 *1 0.47,2.01 pfet_01v8_hvt
M$4 4 5 9 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $5 r0 *1 0.955,1.985 pfet_01v8_hvt
M$5 6 7 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=280750000000P
+ AD=283250000000P PS=2605000U PD=2610000U
* device instance $7 r0 *1 0.47,0.445 nfet_01v8
M$7 8 5 4 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $8 r0 *1 1.865,0.475 nfet_01v8
M$8 7 3 8 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $9 r0 *1 2.285,0.475 nfet_01v8
M$9 8 2 7 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $10 r0 *1 2.705,0.475 nfet_01v8
M$10 7 4 8 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $11 r0 *1 0.955,0.56 nfet_01v8
M$11 6 7 8 10 nfet_01v8 L=150000U W=1300000U AS=188000000000P AD=189625000000P
+ PS=1905000U PD=1910000U
.ENDS sky130_fd_sc_hd__or3b_2

* cell sky130_fd_sc_hd__o32a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B2
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32a_1 1 2 5 6 7 8 9 10 11 15
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B2
* net 9 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=335000000000P
+ AD=135000000000P PS=2670000U PD=1270000U
* device instance $2 r0 *1 1.06,1.985 pfet_01v8_hvt
M$2 13 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.54,1.985 pfet_01v8_hvt
M$3 12 6 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=195000000000P PS=1330000U PD=1390000U
* device instance $4 r0 *1 2.08,1.985 pfet_01v8_hvt
M$4 4 7 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $5 r0 *1 2.62,1.985 pfet_01v8_hvt
M$5 14 8 4 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=205000000000P PS=1390000U PD=1410000U
* device instance $6 r0 *1 3.18,1.985 pfet_01v8_hvt
M$6 10 9 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=290000000000P PS=1410000U PD=2580000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 1 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 1.06,0.56 nfet_01v8
M$8 3 5 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 1.54,0.56 nfet_01v8
M$9 1 6 3 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=126750000000P
+ PS=980000U PD=1040000U
* device instance $10 r0 *1 2.08,0.56 nfet_01v8
M$10 3 7 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 2.62,0.56 nfet_01v8
M$11 4 8 3 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=133250000000P
+ PS=1040000U PD=1060000U
* device instance $12 r0 *1 3.18,0.56 nfet_01v8
M$12 3 9 4 15 nfet_01v8 L=150000U W=650000U AS=133250000000P AD=188500000000P
+ PS=1060000U PD=1880000U
.ENDS sky130_fd_sc_hd__o32a_1

* cell sky130_fd_sc_hd__o41ai_1
* pin VGND
* pin Y
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o41ai_1 1 2 4 5 6 7 8 9 10 14
* net 1 VGND
* net 2 Y
* net 4 B1
* net 5 A4
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=312500000000P PS=1270000U PD=1625000U
* device instance $3 r0 *1 1.665,1.985 pfet_01v8_hvt
M$3 13 6 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=312500000000P
+ AD=135000000000P PS=1625000U PD=1270000U
* device instance $4 r0 *1 2.085,1.985 pfet_01v8_hvt
M$4 12 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=175000000000P PS=1270000U PD=1350000U
* device instance $5 r0 *1 2.585,1.985 pfet_01v8_hvt
M$5 9 8 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=280000000000P PS=1350000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 3 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=203125000000P
+ PS=1820000U PD=1275000U
* device instance $7 r0 *1 1.245,0.56 nfet_01v8
M$7 1 5 3 14 nfet_01v8 L=150000U W=650000U AS=203125000000P AD=87750000000P
+ PS=1275000U PD=920000U
* device instance $8 r0 *1 1.665,0.56 nfet_01v8
M$8 3 6 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 2.085,0.56 nfet_01v8
M$9 1 7 3 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $10 r0 *1 2.585,0.56 nfet_01v8
M$10 3 8 1 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=182000000000P
+ PS=1000000U PD=1860000U
.ENDS sky130_fd_sc_hd__o41ai_1

* cell sky130_fd_sc_hd__nor4b_1
* pin VPB
* pin C
* pin B
* pin A
* pin D_N
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_1 1 2 3 4 5 6 7 8 10
* net 1 VPB
* net 2 C
* net 3 B
* net 4 A
* net 5 D_N
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 2.535,1.89 pfet_01v8_hvt
M$1 9 5 8 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 13 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=520000000000P
+ AD=135000000000P PS=3040000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 12 2 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.63,1.985 pfet_01v8_hvt
M$4 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=135000000000P PS=1330000U PD=1270000U
* device instance $5 r0 *1 2.05,1.985 pfet_01v8_hvt
M$5 8 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $6 r0 *1 0.73,0.56 nfet_01v8
M$6 7 9 6 10 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $7 r0 *1 1.15,0.56 nfet_01v8
M$7 6 2 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.63,0.56 nfet_01v8
M$8 7 3 6 10 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $9 r0 *1 2.05,0.56 nfet_01v8
M$9 6 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $10 r0 *1 2.535,0.675 nfet_01v8
M$10 9 5 6 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor4b_1

* cell sky130_fd_sc_hd__nand3_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_2 1 3 5 6 7 8 9 10
* net 1 VGND
* net 3 Y
* net 5 A
* net 6 B
* net 7 C
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 3 7 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=445000000000P PS=3790000U PD=3890000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 3 6 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $7 r0 *1 2.67,0.56 nfet_01v8
M$7 4 7 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=289250000000P
+ PS=2740000U PD=2840000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 5 2 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.31,0.56 nfet_01v8
M$11 4 6 2 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand3_2

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__and2_2
* pin VPB
* pin A
* pin B
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_2 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 VPWR
* net 6 X
* net 7 VGND
* device instance $1 r0 *1 0.66,2.065 pfet_01v8_hvt
M$1 4 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $2 r0 *1 1.08,2.065 pfet_01v8_hvt
M$2 4 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=166550000000P AD=56700000000P
+ PS=1390000U PD=690000U
* device instance $3 r0 *1 1.62,1.985 pfet_01v8_hvt
M$3 6 4 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=361550000000P
+ AD=575000000000P PS=2780000U PD=4150000U
* device instance $5 r0 *1 0.66,0.585 nfet_01v8
M$5 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $6 r0 *1 1.08,0.585 nfet_01v8
M$6 9 3 7 8 nfet_01v8 L=150000U W=420000U AS=111800000000P AD=56700000000P
+ PS=1040000U PD=690000U
* device instance $7 r0 *1 1.62,0.56 nfet_01v8
M$7 6 4 7 8 nfet_01v8 L=150000U W=1300000U AS=238550000000P AD=373750000000P
+ PS=2080000U PD=3100000U
.ENDS sky130_fd_sc_hd__and2_2

* cell sky130_fd_sc_hd__nor2_8
* pin VGND
* pin A
* pin B
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor2_8 1 2 3 4 6 7 8
* net 1 VGND
* net 2 A
* net 3 B
* net 4 Y
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 5 7 pfet_01v8_hvt L=150000U W=8000000U AS=1.225e+12P AD=1.08e+12P
+ PS=11450000U PD=10160000U
* device instance $9 r0 *1 3.85,1.985 pfet_01v8_hvt
M$9 4 3 5 7 pfet_01v8_hvt L=150000U W=8000000U AS=1.08e+12P AD=1.215e+12P
+ PS=10160000U PD=11430000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 4 2 1 8 nfet_01v8 L=150000U W=5200000U AS=796250000000P AD=702000000000P
+ PS=8300000U PD=7360000U
* device instance $25 r0 *1 3.85,0.56 nfet_01v8
M$25 4 3 1 8 nfet_01v8 L=150000U W=5200000U AS=702000000000P AD=783250000000P
+ PS=7360000U PD=8260000U
.ENDS sky130_fd_sc_hd__nor2_8

* cell sky130_fd_sc_hd__a211oi_4
* pin VGND
* pin A2
* pin A1
* pin Y
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_4 1 2 4 5 6 7 8 9 14
* net 1 VGND
* net 2 A2
* net 4 A1
* net 5 Y
* net 6 B1
* net 7 C1
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 10 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 10 4 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $9 r0 *1 3.83,1.985 pfet_01v8_hvt
M$9 11 6 10 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $11 r0 *1 4.67,1.985 pfet_01v8_hvt
M$11 13 6 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=150000000000P PS=1270000U PD=1300000U
* device instance $12 r0 *1 5.12,1.985 pfet_01v8_hvt
M$12 5 7 13 9 pfet_01v8_hvt L=150000U W=1000000U AS=150000000000P
+ AD=140000000000P PS=1300000U PD=1280000U
* device instance $13 r0 *1 5.55,1.985 pfet_01v8_hvt
M$13 11 7 5 9 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=290000000000P PS=2560000U PD=2580000U
* device instance $15 r0 *1 6.43,1.985 pfet_01v8_hvt
M$15 12 7 5 9 pfet_01v8_hvt L=150000U W=1000000U AS=150000000000P
+ AD=155000000000P PS=1300000U PD=1310000U
* device instance $16 r0 *1 6.89,1.985 pfet_01v8_hvt
M$16 10 6 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 3 2 1 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $20 r0 *1 1.73,0.56 nfet_01v8
M$20 5 4 3 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
* device instance $25 r0 *1 3.83,0.56 nfet_01v8
M$25 5 6 1 14 nfet_01v8 L=150000U W=2600000U AS=378625000000P AD=477750000000P
+ PS=3765000U PD=4720000U
* device instance $28 r0 *1 5.17,0.56 nfet_01v8
M$28 1 7 5 14 nfet_01v8 L=150000U W=2600000U AS=352625000000P AD=354250000000P
+ PS=3685000U PD=3690000U
.ENDS sky130_fd_sc_hd__a211oi_4

* cell sky130_fd_sc_hd__or3b_1
* pin VPB
* pin A
* pin B
* pin C_N
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3b_1 1 2 3 5 6 7 8 10
* net 1 VPB
* net 2 A
* net 3 B
* net 5 C_N
* net 6 X
* net 7 VPWR
* net 8 VGND
* device instance $1 r0 *1 1.41,1.695 pfet_01v8_hvt
M$1 11 4 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.77,1.695 pfet_01v8_hvt
M$2 12 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=68250000000P
+ PS=630000U PD=745000U
* device instance $3 r0 *1 2.245,1.695 pfet_01v8_hvt
M$3 7 2 12 1 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=148250000000P
+ PS=745000U PD=1340000U
* device instance $4 r0 *1 2.735,1.985 pfet_01v8_hvt
M$4 6 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=275000000000P PS=1340000U PD=2550000U
* device instance $5 r0 *1 0.47,1.695 pfet_01v8_hvt
M$5 4 5 7 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.41,0.475 nfet_01v8
M$6 8 4 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $7 r0 *1 1.83,0.475 nfet_01v8
M$7 9 3 8 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 2.25,0.475 nfet_01v8
M$8 9 2 8 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=56700000000P
+ PS=985000U PD=690000U
* device instance $9 r0 *1 2.735,0.56 nfet_01v8
M$9 6 9 8 10 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=178750000000P
+ PS=985000U PD=1850000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or3b_1

* cell sky130_fd_sc_hd__a211oi_2
* pin VGND
* pin Y
* pin C1
* pin B1
* pin A1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_2 1 2 4 5 6 7 10 11 12
* net 1 VGND
* net 2 Y
* net 4 C1
* net 5 B1
* net 6 A1
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.765,1.985 pfet_01v8_hvt
M$1 9 6 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 3.625,1.985 pfet_01v8_hvt
M$3 9 7 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $5 r0 *1 0.525,1.985 pfet_01v8_hvt
M$5 2 4 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $7 r0 *1 1.385,1.985 pfet_01v8_hvt
M$7 9 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $9 r0 *1 2.765,0.56 nfet_01v8
M$9 2 6 3 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $11 r0 *1 3.625,0.56 nfet_01v8
M$11 1 7 3 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
* device instance $13 r0 *1 0.525,0.56 nfet_01v8
M$13 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $15 r0 *1 1.385,0.56 nfet_01v8
M$15 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__a211oi_2

* cell sky130_fd_sc_hd__nor2_2
* pin VGND
* pin
* pin Y
* pin VPB
* pin A
* pin B
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nor2_2 1 2 3 4 5 6 8
* net 1 VGND
* net 3 Y
* net 4 VPB
* net 5 A
* net 6 B
* net 8 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 8 5 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 1.33,1.985 pfet_01v8_hvt
M$3 3 6 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,0.56 nfet_01v8
M$5 3 5 1 2 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $7 r0 *1 1.33,0.56 nfet_01v8
M$7 3 6 1 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor2_2

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__nand2_8
* pin VGND
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand2_8 1 2 3 5 6 7 8
* net 1 VGND
* net 2 B
* net 3 A
* net 5 VPWR
* net 6 Y
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 2 5 7 pfet_01v8_hvt L=150000U W=8000000U AS=1.205e+12P AD=1.08e+12P
+ PS=11410000U PD=10160000U
* device instance $9 r0 *1 3.83,1.985 pfet_01v8_hvt
M$9 6 3 5 7 pfet_01v8_hvt L=150000U W=8000000U AS=1.08e+12P AD=1.325e+12P
+ PS=10160000U PD=11650000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 1 2 4 8 nfet_01v8 L=150000U W=5200000U AS=783250000000P AD=702000000000P
+ PS=8260000U PD=7360000U
* device instance $25 r0 *1 3.83,0.56 nfet_01v8
M$25 6 3 4 8 nfet_01v8 L=150000U W=5200000U AS=702000000000P AD=861250000000P
+ PS=7360000U PD=8500000U
.ENDS sky130_fd_sc_hd__nand2_8

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__a211o_1
* pin VPB
* pin B1
* pin C1
* pin A1
* pin A2
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a211o_1 1 2 3 4 5 7 8 9 11
* net 1 VPB
* net 2 B1
* net 3 C1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 X
* net 9 VGND
* device instance $1 r0 *1 1.425,1.985 pfet_01v8_hvt
M$1 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.855,1.985 pfet_01v8_hvt
M$2 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 2.285,1.985 pfet_01v8_hvt
M$3 12 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 2.745,1.985 pfet_01v8_hvt
M$4 6 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.475,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=265000000000P PS=2530000U PD=2530000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 9 6 8 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=260000000000P
+ PS=1830000U PD=1450000U
* device instance $7 r0 *1 1.425,0.56 nfet_01v8
M$7 13 5 9 11 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=91000000000P
+ PS=1450000U PD=930000U
* device instance $8 r0 *1 1.855,0.56 nfet_01v8
M$8 6 4 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $9 r0 *1 2.285,0.56 nfet_01v8
M$9 9 2 6 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $10 r0 *1 2.745,0.56 nfet_01v8
M$10 6 3 9 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211o_1

* cell sky130_fd_sc_hd__nand3b_1
* pin VPB
* pin A_N
* pin C
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A_N
* net 3 C
* net 4 B
* net 5 Y
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 8 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 8 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 5 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=280000000000P PS=1385000U PD=2560000U
* device instance $5 r0 *1 0.6,0.675 nfet_01v8
M$5 6 2 7 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $6 r0 *1 1.085,0.56 nfet_01v8
M$6 11 3 7 9 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $8 r0 *1 2.04,0.56 nfet_01v8
M$8 5 6 10 9 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=182000000000P
+ PS=1035000U PD=1860000U
.ENDS sky130_fd_sc_hd__nand3b_1

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 0.47,0.445 nfet_01v8
M$16 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 0.89,0.445 nfet_01v8
M$17 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__nand2b_4
* pin VGND
* pin B
* pin Y
* pin A_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_4 1 2 5 6 7 8 9
* net 1 VGND
* net 2 B
* net 5 Y
* net 6 A_N
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 5 3 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=547500000000P PS=6330000U PD=5095000U
* device instance $5 r0 *1 3.105,1.985 pfet_01v8_hvt
M$5 5 2 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=547500000000P
+ AD=795000000000P PS=5095000U PD=6590000U
* device instance $9 r0 *1 0.47,1.985 pfet_01v8_hvt
M$9 7 6 3 8 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $10 r0 *1 1.41,0.56 nfet_01v8
M$10 5 3 4 9 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=355875000000P
+ PS=4580000U PD=3695000U
* device instance $14 r0 *1 3.105,0.56 nfet_01v8
M$14 1 2 4 9 nfet_01v8 L=150000U W=2600000U AS=355875000000P AD=516750000000P
+ PS=3695000U PD=4840000U
* device instance $18 r0 *1 0.47,0.56 nfet_01v8
M$18 1 6 3 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_4

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 1.85,0.56 nfet_01v8
M$7 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.27,0.56 nfet_01v8
M$8 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 0.89,0.56 nfet_01v8
M$10 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__a32oi_1
* pin VPB
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a32oi_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A3
* net 5 A2
* net 6 A1
* net 8 Y
* net 9 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=215000000000P PS=1270000U PD=1430000U
* device instance $3 r0 *1 1.47,1.985 pfet_01v8_hvt
M$3 10 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=135000000000P PS=1430000U PD=1270000U
* device instance $4 r0 *1 1.89,1.985 pfet_01v8_hvt
M$4 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=140000000000P PS=1270000U PD=1280000U
* device instance $5 r0 *1 2.32,1.985 pfet_01v8_hvt
M$5 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=260000000000P PS=1280000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $7 r0 *1 0.85,0.56 nfet_01v8
M$7 8 3 14 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=152750000000P
+ PS=880000U PD=1120000U
* device instance $8 r0 *1 1.47,0.56 nfet_01v8
M$8 12 6 8 11 nfet_01v8 L=150000U W=650000U AS=152750000000P AD=71500000000P
+ PS=1120000U PD=870000U
* device instance $9 r0 *1 1.84,0.56 nfet_01v8
M$9 13 5 12 11 nfet_01v8 L=150000U W=650000U AS=71500000000P AD=107250000000P
+ PS=870000U PD=980000U
* device instance $10 r0 *1 2.32,0.56 nfet_01v8
M$10 9 4 13 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a32oi_1

* cell sky130_fd_sc_hd__o32ai_1
* pin VGND
* pin B1
* pin Y
* pin B2
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32ai_1 1 2 4 5 6 7 8 9 10 12
* net 1 VGND
* net 2 B1
* net 4 Y
* net 5 B2
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 4 5 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=305000000000P PS=1210000U PD=1610000U
* device instance $3 r0 *1 1.59,1.985 pfet_01v8_hvt
M$3 13 6 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=245000000000P PS=1610000U PD=1490000U
* device instance $4 r0 *1 2.23,1.985 pfet_01v8_hvt
M$4 14 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=245000000000P
+ AD=135000000000P PS=1490000U PD=1270000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 9 8 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=280000000000P PS=1270000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 4 2 3 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 0.945,0.56 nfet_01v8
M$7 3 5 4 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=100750000000P
+ PS=975000U PD=960000U
* device instance $8 r0 *1 1.405,0.56 nfet_01v8
M$8 1 6 3 12 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=219375000000P
+ PS=960000U PD=1325000U
* device instance $9 r0 *1 2.23,0.56 nfet_01v8
M$9 3 7 1 12 nfet_01v8 L=150000U W=650000U AS=219375000000P AD=87750000000P
+ PS=1325000U PD=920000U
* device instance $10 r0 *1 2.65,0.56 nfet_01v8
M$10 1 8 3 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=234000000000P
+ PS=920000U PD=2020000U
.ENDS sky130_fd_sc_hd__o32ai_1

* cell sky130_fd_sc_hd__ha_2
* pin VGND
* pin SUM
* pin COUT
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_2 1 2 6 7 8 10 11 13
* net 1 VGND
* net 2 SUM
* net 6 COUT
* net 7 B
* net 8 A
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=446600000000P PS=3830000U PD=3075000U
* device instance $3 r0 *1 1.845,2.165 pfet_01v8_hvt
M$3 3 5 10 11 pfet_01v8_hvt L=150000U W=640000U AS=291600000000P
+ AD=86400000000P PS=1765000U PD=910000U
* device instance $4 r0 *1 2.265,2.165 pfet_01v8_hvt
M$4 12 7 3 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=128000000000P PS=910000U PD=1040000U
* device instance $5 r0 *1 2.815,2.165 pfet_01v8_hvt
M$5 10 8 12 11 pfet_01v8_hvt L=150000U W=640000U AS=128000000000P
+ AD=227200000000P PS=1040000U PD=1350000U
* device instance $6 r0 *1 3.675,2.165 pfet_01v8_hvt
M$6 5 7 10 11 pfet_01v8_hvt L=150000U W=640000U AS=227200000000P
+ AD=92800000000P PS=1350000U PD=930000U
* device instance $7 r0 *1 4.115,2.165 pfet_01v8_hvt
M$7 5 8 10 11 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P
+ AD=92800000000P PS=1325000U PD=930000U
* device instance $8 r0 *1 4.59,1.985 pfet_01v8_hvt
M$8 6 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=304000000000P
+ AD=415000000000P PS=2635000U PD=3830000U
* device instance $10 r0 *1 3.755,0.445 nfet_01v8
M$10 9 7 5 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $11 r0 *1 4.115,0.445 nfet_01v8
M$11 1 8 9 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $12 r0 *1 4.59,0.56 nfet_01v8
M$12 6 5 1 13 nfet_01v8 L=150000U W=1300000U AS=197750000000P AD=269750000000P
+ PS=1935000U PD=2780000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 2 3 1 13 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=269750000000P
+ PS=2780000U PD=2780000U
* device instance $16 r0 *1 1.87,0.445 nfet_01v8
M$16 4 5 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 2.29,0.445 nfet_01v8
M$17 1 7 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $18 r0 *1 2.71,0.445 nfet_01v8
M$18 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__ha_2

* cell sky130_fd_sc_hd__and3_4
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_4 1 3 4 5 6 9 10 11
* net 1 VGND
* net 3 B
* net 4 X
* net 5 A
* net 6 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.85,1.985 pfet_01v8_hvt
M$1 9 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=197500000000P PS=2610000U PD=1395000U
* device instance $2 r0 *1 1.395,1.985 pfet_01v8_hvt
M$2 2 3 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=140000000000P PS=1395000U PD=1280000U
* device instance $3 r0 *1 1.825,1.985 pfet_01v8_hvt
M$3 9 6 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=177500000000P PS=1280000U PD=1355000U
* device instance $4 r0 *1 2.33,1.985 pfet_01v8_hvt
M$4 4 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=597500000000P
+ AD=705000000000P PS=5195000U PD=6410000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 5 2 11 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=128375000000P
+ PS=1910000U PD=1045000U
* device instance $9 r0 *1 1.395,0.56 nfet_01v8
M$9 7 3 8 11 nfet_01v8 L=150000U W=650000U AS=128375000000P AD=68250000000P
+ PS=1045000U PD=860000U
* device instance $10 r0 *1 1.755,0.56 nfet_01v8
M$10 1 6 7 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=138125000000P
+ PS=860000U PD=1075000U
* device instance $11 r0 *1 2.33,0.56 nfet_01v8
M$11 4 2 1 11 nfet_01v8 L=150000U W=2600000U AS=411125000000P AD=458250000000P
+ PS=3865000U PD=4660000U
.ENDS sky130_fd_sc_hd__and3_4

* cell sky130_fd_sc_hd__nor4_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_2 1 2 3 4 5 6 8 11 12
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 5 C
* net 6 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.57,1.985 pfet_01v8_hvt
M$3 2 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 8 3 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 9 4 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.57,0.56 nfet_01v8
M$11 2 6 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 2 3 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $15 r0 *1 1.33,0.56 nfet_01v8
M$15 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nor4_2

* cell sky130_fd_sc_hd__nor3b_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_2 1 2 3 4 6 9 10 11
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 6 C_N
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 2 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=415000000000P PS=3830000U PD=3830000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 9 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 4.13,1.695 pfet_01v8_hvt
M$7 9 6 5 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $8 r0 *1 4.13,0.675 nfet_01v8
M$8 1 6 5 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=269750000000P
+ PS=2740000U PD=2780000U
* device instance $11 r0 *1 0.49,0.56 nfet_01v8
M$11 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $13 r0 *1 1.33,0.56 nfet_01v8
M$13 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3b_2

* cell sky130_fd_sc_hd__o2111a_2
* pin VGND
* pin X
* pin C1
* pin D1
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2111a_2 1 2 4 6 7 8 9 12 13 15
* net 1 VGND
* net 2 X
* net 4 C1
* net 6 D1
* net 7 B1
* net 8 A2
* net 9 A1
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=505000000000P PS=3810000U PD=3010000U
* device instance $3 r0 *1 1.785,1.985 pfet_01v8_hvt
M$3 3 6 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=140000000000P PS=1730000U PD=1280000U
* device instance $4 r0 *1 2.215,1.985 pfet_01v8_hvt
M$4 12 4 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=195000000000P PS=1280000U PD=1390000U
* device instance $5 r0 *1 2.755,1.985 pfet_01v8_hvt
M$5 3 7 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $6 r0 *1 3.295,1.985 pfet_01v8_hvt
M$6 14 8 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $7 r0 *1 3.835,1.985 pfet_01v8_hvt
M$7 12 9 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=265000000000P PS=1390000U PD=2530000U
* device instance $8 r0 *1 1.855,0.56 nfet_01v8
M$8 10 6 3 15 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $9 r0 *1 2.215,0.56 nfet_01v8
M$9 11 4 10 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=126750000000P
+ PS=860000U PD=1040000U
* device instance $10 r0 *1 2.755,0.56 nfet_01v8
M$10 5 7 11 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 3.295,0.56 nfet_01v8
M$11 1 8 5 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $12 r0 *1 3.835,0.56 nfet_01v8
M$12 5 9 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=172250000000P
+ PS=1040000U PD=1830000U
* device instance $13 r0 *1 0.475,0.56 nfet_01v8
M$13 2 3 1 15 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=263250000000P
+ PS=2760000U PD=2760000U
.ENDS sky130_fd_sc_hd__o2111a_2

* cell sky130_fd_sc_hd__clkinv_2
* pin VPB
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_2 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 4 2 3 1 pfet_01v8_hvt L=150000U W=3000000U AS=545000000000P
+ AD=545000000000P PS=5090000U PD=5090000U
* device instance $4 r0 *1 0.94,0.445 nfet_01v8
M$4 3 2 5 6 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=168000000000P
+ PS=2070000U PD=2060000U
.ENDS sky130_fd_sc_hd__clkinv_2

* cell sky130_fd_sc_hd__o211a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211a_1 1 2 5 6 7 8 10 11 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 B1
* net 8 C1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 12 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=162500000000P PS=2520000U PD=1325000U
* device instance $2 r0 *1 1.885,1.985 pfet_01v8_hvt
M$2 4 6 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=220000000000P PS=1325000U PD=1440000U
* device instance $3 r0 *1 2.475,1.985 pfet_01v8_hvt
M$3 10 7 4 11 pfet_01v8_hvt L=150000U W=1000000U AS=220000000000P
+ AD=175000000000P PS=1440000U PD=1350000U
* device instance $4 r0 *1 2.975,1.985 pfet_01v8_hvt
M$4 4 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=300000000000P PS=1350000U PD=2600000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 1.885,0.56 nfet_01v8
M$7 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=143000000000P
+ PS=975000U PD=1090000U
* device instance $8 r0 *1 2.475,0.56 nfet_01v8
M$8 9 7 3 13 nfet_01v8 L=150000U W=650000U AS=143000000000P AD=113750000000P
+ PS=1090000U PD=1000000U
* device instance $9 r0 *1 2.975,0.56 nfet_01v8
M$9 4 8 9 13 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=195000000000P
+ PS=1000000U PD=1900000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o211a_1

* cell sky130_fd_sc_hd__a21oi_4
* pin VGND
* pin Y
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_4 1 2 4 5 6 7 8 10
* net 1 VGND
* net 2 Y
* net 4 B1
* net 5 A2
* net 6 A1
* net 7 VPWR
* net 8 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 4 9 8 pfet_01v8_hvt L=150000U W=4000000U AS=680000000000P
+ AD=575000000000P PS=6360000U PD=5150000U
* device instance $5 r0 *1 2.225,1.985 pfet_01v8_hvt
M$5 7 5 9 8 pfet_01v8_hvt L=150000U W=4000000U AS=575000000000P
+ AD=690000000000P PS=5150000U PD=6380000U
* device instance $6 r0 *1 2.665,1.985 pfet_01v8_hvt
M$6 9 6 7 8 pfet_01v8_hvt L=150000U W=4000000U AS=565000000000P
+ AD=560000000000P PS=5130000U PD=5120000U
* device instance $13 r0 *1 0.475,0.56 nfet_01v8
M$13 2 4 1 10 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=377000000000P
+ PS=4620000U PD=3760000U
* device instance $17 r0 *1 2.235,0.56 nfet_01v8
M$17 3 5 1 10 nfet_01v8 L=150000U W=2600000U AS=377000000000P AD=445250000000P
+ PS=3760000U PD=4620000U
* device instance $18 r0 *1 2.665,0.56 nfet_01v8
M$18 2 6 3 10 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=364000000000P
+ PS=3720000U PD=3720000U
.ENDS sky130_fd_sc_hd__a21oi_4

* cell sky130_fd_sc_hd__nor4_1
* pin VPB
* pin D
* pin B
* pin A
* pin C
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 D
* net 3 B
* net 4 A
* net 5 C
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=130000000000P PS=2520000U PD=1260000U
* device instance $2 r0 *1 0.88,1.985 pfet_01v8_hvt
M$2 10 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=130000000000P
+ AD=190000000000P PS=1260000U PD=1380000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 12 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 8 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=118625000000P
+ PS=1820000U PD=1015000U
* device instance $6 r0 *1 0.985,0.56 nfet_01v8
M$6 6 5 7 9 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=89375000000P
+ PS=1015000U PD=925000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 7 3 6 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=87750000000P
+ PS=925000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor4_1

* cell sky130_fd_sc_hd__clkbuf_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_2 1 2 3 4 6 7
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 6 X
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=162500000000P PS=2530000U PD=1325000U
* device instance $2 r0 *1 0.95,1.985 pfet_01v8_hvt
M$2 6 5 3 1 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=395000000000P PS=2595000U PD=3790000U
* device instance $4 r0 *1 0.475,0.445 nfet_01v8
M$4 4 2 5 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=68250000000P
+ PS=1370000U PD=745000U
* device instance $5 r0 *1 0.95,0.445 nfet_01v8
M$5 6 5 4 7 nfet_01v8 L=150000U W=840000U AS=124950000000P AD=165900000000P
+ PS=1435000U PD=2050000U
.ENDS sky130_fd_sc_hd__clkbuf_2

* cell sky130_fd_sc_hd__a22oi_2
* pin VGND
* pin B2
* pin B1
* pin Y
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_2 1 3 4 5 7 8 10 11 12
* net 1 VGND
* net 3 B2
* net 4 B1
* net 5 Y
* net 7 A1
* net 8 A2
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 3.51,1.985 pfet_01v8_hvt
M$3 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 9 3 5 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 9 4 5 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 2.67,0.56 nfet_01v8
M$9 5 7 6 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 3.51,0.56 nfet_01v8
M$11 1 8 6 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 3 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 5 4 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a22oi_2

* cell sky130_fd_sc_hd__o2111a_1
* pin VGND
* pin X
* pin C1
* pin B1
* pin D1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2111a_1 1 2 4 5 7 8 9 12 13 14
* net 1 VGND
* net 2 X
* net 4 C1
* net 5 B1
* net 7 D1
* net 8 A2
* net 9 A1
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 3 2 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=382500000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,1.985 pfet_01v8_hvt
M$2 3 7 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=382500000000P
+ AD=217500000000P PS=1765000U PD=1435000U
* device instance $3 r0 *1 1.97,1.985 pfet_01v8_hvt
M$3 12 4 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=217500000000P
+ AD=305000000000P PS=1435000U PD=1610000U
* device instance $4 r0 *1 2.73,1.985 pfet_01v8_hvt
M$4 3 5 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=212500000000P PS=1610000U PD=1425000U
* device instance $5 r0 *1 3.305,1.985 pfet_01v8_hvt
M$5 15 8 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=105000000000P PS=1425000U PD=1210000U
* device instance $6 r0 *1 3.665,1.985 pfet_01v8_hvt
M$6 12 9 15 13 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=265000000000P PS=1210000U PD=2530000U
* device instance $7 r0 *1 1.455,0.56 nfet_01v8
M$7 11 7 3 14 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=118625000000P
+ PS=1910000U PD=1015000U
* device instance $8 r0 *1 1.97,0.56 nfet_01v8
M$8 10 4 11 14 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=118625000000P
+ PS=1015000U PD=1015000U
* device instance $9 r0 *1 2.485,0.56 nfet_01v8
M$9 6 5 10 14 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=198250000000P
+ PS=1015000U PD=1260000U
* device instance $10 r0 *1 3.245,0.56 nfet_01v8
M$10 1 8 6 14 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=87750000000P
+ PS=1260000U PD=920000U
* device instance $11 r0 *1 3.665,0.56 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=172250000000P
+ PS=920000U PD=1830000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 3 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o2111a_1

* cell sky130_fd_sc_hd__a21oi_2
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_2 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=275000000000P PS=3830000U PD=2550000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 6 2 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=275000000000P PS=2560000U PD=2550000U
* device instance $5 r0 *1 2.19,1.985 pfet_01v8_hvt
M$5 7 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=495000000000P PS=2540000U PD=3990000U
* device instance $7 r0 *1 0.495,0.56 nfet_01v8
M$7 10 4 8 9 nfet_01v8 L=150000U W=650000U AS=185250000000P AD=89375000000P
+ PS=1870000U PD=925000U
* device instance $8 r0 *1 0.92,0.56 nfet_01v8
M$8 7 2 10 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $9 r0 *1 1.35,0.56 nfet_01v8
M$9 11 2 7 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=68250000000P
+ PS=930000U PD=860000U
* device instance $10 r0 *1 1.71,0.56 nfet_01v8
M$10 8 4 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=107250000000P
+ PS=860000U PD=980000U
* device instance $11 r0 *1 2.19,0.56 nfet_01v8
M$11 7 3 8 9 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=347750000000P
+ PS=1900000U PD=3020000U
.ENDS sky130_fd_sc_hd__a21oi_2

* cell sky130_fd_sc_hd__inv_6
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__inv_6 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 3 2 4 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.105e+12P AD=945000000000P
+ PS=9210000U PD=8890000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 3 2 5 6 nfet_01v8 L=150000U W=3900000U AS=685750000000P AD=614250000000P
+ PS=6660000U PD=6440000U
.ENDS sky130_fd_sc_hd__inv_6

* cell sky130_fd_sc_hd__clkinv_4
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_4 1 2 3 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 Y
* net 5 VPWR
* device instance $1 r0 *1 0.515,1.985 pfet_01v8_hvt
M$1 4 2 5 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.005e+12P AD=1.045e+12P
+ PS=9010000U PD=9090000U
* device instance $7 r0 *1 0.945,0.445 nfet_01v8
M$7 4 2 3 6 nfet_01v8 L=150000U W=1680000U AS=315000000000P AD=342300000000P
+ PS=3600000U PD=3730000U
.ENDS sky130_fd_sc_hd__clkinv_4

* cell sky130_fd_sc_hd__a221oi_2
* pin VGND
* pin C1
* pin Y
* pin B2
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_2 1 2 3 4 6 7 9 10 11 14
* net 1 VGND
* net 2 C1
* net 3 Y
* net 4 B2
* net 6 B1
* net 7 A2
* net 9 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.84,1.985 pfet_01v8_hvt
M$1 12 4 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=310000000000P PS=3790000U PD=2620000U
* device instance $2 r0 *1 2.26,1.985 pfet_01v8_hvt
M$2 13 6 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 3.6,1.985 pfet_01v8_hvt
M$5 10 7 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $6 r0 *1 4.02,1.985 pfet_01v8_hvt
M$6 13 9 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 0.48,1.985 pfet_01v8_hvt
M$9 3 2 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=395000000000P PS=3810000U PD=3790000U
* device instance $11 r0 *1 0.48,0.56 nfet_01v8
M$11 3 2 1 14 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=344500000000P
+ PS=2760000U PD=2360000U
* device instance $13 r0 *1 1.84,0.56 nfet_01v8
M$13 5 4 1 14 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=201500000000P
+ PS=2360000U PD=1920000U
* device instance $14 r0 *1 2.26,0.56 nfet_01v8
M$14 3 6 5 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 3.6,0.56 nfet_01v8
M$17 8 7 1 14 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $18 r0 *1 4.02,0.56 nfet_01v8
M$18 3 9 8 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
.ENDS sky130_fd_sc_hd__a221oi_2

* cell sky130_fd_sc_hd__clkinvlp_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__clkinvlp_4 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.525,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=250000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 0.475,0.51 nfet_01v8
M$5 8 2 4 6 nfet_01v8 L=150000U W=550000U AS=145750000000P AD=57750000000P
+ PS=1630000U PD=760000U
* device instance $6 r0 *1 0.835,0.51 nfet_01v8
M$6 5 2 8 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=77000000000P
+ PS=760000U PD=830000U
* device instance $7 r0 *1 1.265,0.51 nfet_01v8
M$7 7 2 5 6 nfet_01v8 L=150000U W=550000U AS=77000000000P AD=57750000000P
+ PS=830000U PD=760000U
* device instance $8 r0 *1 1.625,0.51 nfet_01v8
M$8 4 2 7 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=145750000000P
+ PS=760000U PD=1630000U
.ENDS sky130_fd_sc_hd__clkinvlp_4

* cell sky130_fd_sc_hd__nand4b_1
* pin VPB
* pin A_N
* pin B
* pin C
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_1 1 2 3 4 6 7 8 9 10
* net 1 VPB
* net 2 A_N
* net 3 B
* net 4 C
* net 6 D
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=195000000000P PS=1385000U PD=1390000U
* device instance $5 r0 *1 2.58,1.985 pfet_01v8_hvt
M$5 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $6 r0 *1 0.545,0.675 nfet_01v8
M$6 5 2 9 10 nfet_01v8 L=150000U W=420000U AS=118125000000P AD=111300000000P
+ PS=1040000U PD=1370000U
* device instance $7 r0 *1 1.085,0.56 nfet_01v8
M$7 11 6 9 10 nfet_01v8 L=150000U W=650000U AS=118125000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.505,0.56 nfet_01v8
M$8 13 4 11 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $9 r0 *1 2.04,0.56 nfet_01v8
M$9 12 3 13 10 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=126750000000P
+ PS=1035000U PD=1040000U
* device instance $10 r0 *1 2.58,0.56 nfet_01v8
M$10 8 5 12 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=227500000000P
+ PS=1040000U PD=2000000U
.ENDS sky130_fd_sc_hd__nand4b_1

* cell sky130_fd_sc_hd__a31o_1
* pin VGND
* pin X
* pin A3
* pin A2
* pin A1
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31o_1 1 2 6 7 8 9 11 12 13
* net 1 VGND
* net 2 X
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 B1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 3 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=172500000000P PS=2530000U PD=1345000U
* device instance $2 r0 *1 0.97,1.985 pfet_01v8_hvt
M$2 10 6 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=160000000000P PS=1345000U PD=1320000U
* device instance $3 r0 *1 1.44,1.985 pfet_01v8_hvt
M$3 11 7 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=165000000000P PS=1320000U PD=1330000U
* device instance $4 r0 *1 1.92,1.985 pfet_01v8_hvt
M$4 10 8 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $5 r0 *1 2.4,1.985 pfet_01v8_hvt
M$5 3 9 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=320000000000P PS=1330000U PD=2640000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=112125000000P
+ PS=1830000U PD=995000U
* device instance $7 r0 *1 0.97,0.56 nfet_01v8
M$7 4 6 1 13 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=104000000000P
+ PS=995000U PD=970000U
* device instance $8 r0 *1 1.44,0.56 nfet_01v8
M$8 5 7 4 13 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=107250000000P
+ PS=970000U PD=980000U
* device instance $9 r0 *1 1.92,0.56 nfet_01v8
M$9 3 8 5 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.4,0.56 nfet_01v8
M$10 1 9 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=208000000000P
+ PS=980000U PD=1940000U
.ENDS sky130_fd_sc_hd__a31o_1

* cell sky130_fd_sc_hd__nand2_2
* pin VGND
* pin
* pin B
* pin Y
* pin A
* pin VPB
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nand2_2 1 2 4 5 6 7 8
* net 1 VGND
* net 4 B
* net 5 Y
* net 6 A
* net 7 VPB
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 5 6 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 1 4 3 2 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 5 6 3 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand2_2

* cell sky130_fd_sc_hd__o21ai_2
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_2 1 2 3 4 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 7 VGND
* net 8 Y
* net 9 VPWR
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 6 2 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=440000000000P
+ AD=300000000000P PS=3880000U PD=2600000U
* device instance $2 r0 *1 0.915,1.985 pfet_01v8_hvt
M$2 8 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=315000000000P PS=2560000U PD=2630000U
* device instance $5 r0 *1 2.315,1.985 pfet_01v8_hvt
M$5 8 4 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=405000000000P PS=2600000U PD=3810000U
* device instance $7 r0 *1 0.485,0.56 nfet_01v8
M$7 7 2 5 10 nfet_01v8 L=150000U W=1300000U AS=299000000000P AD=182000000000P
+ PS=2870000U PD=1860000U
* device instance $8 r0 *1 0.915,0.56 nfet_01v8
M$8 5 3 7 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=217750000000P
+ PS=1860000U PD=1970000U
* device instance $11 r0 *1 2.315,0.56 nfet_01v8
M$11 8 4 5 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__o21ai_2

* cell sky130_fd_sc_hd__o31ai_2
* pin VGND
* pin A1
* pin A2
* pin A3
* pin Y
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_2 1 3 4 5 6 7 9 11 12
* net 1 VGND
* net 3 A1
* net 4 A2
* net 5 A3
* net 6 Y
* net 7 B1
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 10 5 6 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.55,1.985 pfet_01v8_hvt
M$3 9 7 6 11 pfet_01v8_hvt L=150000U W=2000000U AS=330000000000P
+ AD=455000000000P PS=2660000U PD=3910000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 9 3 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 10 4 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 1 3 2 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 1.33,0.56 nfet_01v8
M$11 1 4 2 12 nfet_01v8 L=150000U W=1300000U AS=286000000000P AD=325000000000P
+ PS=2180000U PD=2300000U
* device instance $13 r0 *1 2.63,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=240500000000P AD=201500000000P
+ PS=2040000U PD=1920000U
* device instance $15 r0 *1 3.55,0.56 nfet_01v8
M$15 6 7 2 12 nfet_01v8 L=150000U W=1300000U AS=214500000000P AD=295750000000P
+ PS=1960000U PD=2860000U
.ENDS sky130_fd_sc_hd__o31ai_2

* cell sky130_fd_sc_hd__inv_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__inv_8 1 2 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.635,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=8000000U AS=1.205e+12P AD=1.205e+12P
+ PS=11410000U PD=11410000U
* device instance $9 r0 *1 0.635,0.56 nfet_01v8
M$9 3 2 1 6 nfet_01v8 L=150000U W=5200000U AS=783250000000P AD=783250000000P
+ PS=8260000U PD=8260000U
.ENDS sky130_fd_sc_hd__inv_8

* cell sky130_fd_sc_hd__o2111ai_1
* pin VPB
* pin D1
* pin C1
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2111ai_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 D1
* net 3 C1
* net 4 B1
* net 5 A2
* net 6 A1
* net 8 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.67,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.1,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=195000000000P PS=1280000U PD=1390000U
* device instance $3 r0 *1 1.64,1.985 pfet_01v8_hvt
M$3 9 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=202500000000P PS=1390000U PD=1405000U
* device instance $4 r0 *1 2.195,1.985 pfet_01v8_hvt
M$4 12 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=202500000000P
+ AD=195000000000P PS=1405000U PD=1390000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 8 6 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=265000000000P PS=1390000U PD=2530000U
* device instance $6 r0 *1 0.74,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $7 r0 *1 1.1,0.56 nfet_01v8
M$7 13 3 14 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=126750000000P
+ PS=860000U PD=1040000U
* device instance $8 r0 *1 1.64,0.56 nfet_01v8
M$8 7 4 13 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=131625000000P
+ PS=1040000U PD=1055000U
* device instance $9 r0 *1 2.195,0.56 nfet_01v8
M$9 10 5 7 11 nfet_01v8 L=150000U W=650000U AS=131625000000P AD=126750000000P
+ PS=1055000U PD=1040000U
* device instance $10 r0 *1 2.735,0.56 nfet_01v8
M$10 7 6 10 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=172250000000P
+ PS=1040000U PD=1830000U
.ENDS sky130_fd_sc_hd__o2111ai_1

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__clkinv_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_8 1 3 4 5 6
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 4 5 pfet_01v8_hvt L=150000U W=12000000U AS=1.7475e+12P AD=1.7475e+12P
+ PS=16495000U PD=16495000U
* device instance $13 r0 *1 1.415,0.445 nfet_01v8
M$13 2 3 1 6 nfet_01v8 L=150000U W=3360000U AS=522900000000P AD=522900000000P
+ PS=6270000U PD=6270000U
.ENDS sky130_fd_sc_hd__clkinv_8

* cell sky130_fd_sc_hd__o221ai_1
* pin VPB
* pin C1
* pin B1
* pin A2
* pin A1
* pin B2
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o221ai_1 1 2 3 4 5 6 8 10 11 12
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 B2
* net 8 Y
* net 10 VPWR
* net 11 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=380000000000P PS=2560000U PD=1760000U
* device instance $2 r0 *1 1.4,1.985 pfet_01v8_hvt
M$2 14 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=380000000000P
+ AD=120000000000P PS=1760000U PD=1240000U
* device instance $3 r0 *1 1.79,1.985 pfet_01v8_hvt
M$3 8 6 14 1 pfet_01v8_hvt L=150000U W=1000000U AS=120000000000P
+ AD=225000000000P PS=1240000U PD=1450000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 13 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=105000000000P PS=1450000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.4,0.56 nfet_01v8
M$6 9 3 7 12 nfet_01v8 L=150000U W=650000U AS=165200000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.82,0.56 nfet_01v8
M$7 7 6 9 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=117000000000P
+ PS=920000U PD=1010000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 11 4 7 12 nfet_01v8 L=150000U W=650000U AS=117000000000P AD=87750000000P
+ PS=1010000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 5 11 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 9 2 8 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=165400000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221ai_1

* cell sky130_fd_sc_hd__o311ai_0
* pin VGND
* pin A1
* pin Y
* pin C1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_0 1 2 4 5 7 8 9 10 11 14
* net 1 VGND
* net 2 A1
* net 4 Y
* net 5 C1
* net 7 A2
* net 8 A3
* net 9 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.615,2.165 pfet_01v8_hvt
M$1 12 2 10 11 pfet_01v8_hvt L=150000U W=640000U AS=179200000000P
+ AD=86400000000P PS=1840000U PD=910000U
* device instance $2 r0 *1 1.035,2.165 pfet_01v8_hvt
M$2 13 7 12 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=86400000000P PS=910000U PD=910000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 4 8 13 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=144000000000P PS=910000U PD=1090000U
* device instance $4 r0 *1 2.055,2.165 pfet_01v8_hvt
M$4 10 9 4 11 pfet_01v8_hvt L=150000U W=640000U AS=144000000000P
+ AD=118400000000P PS=1090000U PD=1010000U
* device instance $5 r0 *1 2.575,2.165 pfet_01v8_hvt
M$5 4 5 10 11 pfet_01v8_hvt L=150000U W=640000U AS=118400000000P
+ AD=198400000000P PS=1010000U PD=1900000U
* device instance $6 r0 *1 0.615,0.445 nfet_01v8
M$6 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $7 r0 *1 1.035,0.445 nfet_01v8
M$7 1 7 3 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 1.455,0.445 nfet_01v8
M$8 3 8 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=128100000000P
+ PS=690000U PD=1030000U
* device instance $9 r0 *1 2.215,0.445 nfet_01v8
M$9 6 9 3 14 nfet_01v8 L=150000U W=420000U AS=128100000000P AD=44100000000P
+ PS=1030000U PD=630000U
* device instance $10 r0 *1 2.575,0.445 nfet_01v8
M$10 4 5 6 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=117600000000P
+ PS=630000U PD=1400000U
.ENDS sky130_fd_sc_hd__o311ai_0

* cell sky130_fd_sc_hd__o311ai_2
* pin VGND
* pin Y
* pin A1
* pin A2
* pin A3
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_2 1 4 5 6 7 8 9 11 13 14
* net 1 VGND
* net 4 Y
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 C1
* net 11 VPWR
* net 13 VPB
* device instance $1 r0 *1 2.79,1.985 pfet_01v8_hvt
M$1 12 7 4 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 3.63,1.985 pfet_01v8_hvt
M$3 11 8 4 13 pfet_01v8_hvt L=150000U W=2000000U AS=440000000000P
+ AD=510000000000P PS=2880000U PD=3020000U
* device instance $5 r0 *1 4.95,1.985 pfet_01v8_hvt
M$5 11 9 4 13 pfet_01v8_hvt L=150000U W=2000000U AS=340000000000P
+ AD=395000000000P PS=2680000U PD=3790000U
* device instance $7 r0 *1 0.59,1.985 pfet_01v8_hvt
M$7 11 5 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $9 r0 *1 1.43,1.985 pfet_01v8_hvt
M$9 12 6 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 4.97,0.56 nfet_01v8
M$11 3 9 4 14 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=256750000000P
+ PS=2780000U PD=2740000U
* device instance $13 r0 *1 0.61,0.56 nfet_01v8
M$13 1 5 2 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.45,0.56 nfet_01v8
M$15 1 6 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 2.29,0.56 nfet_01v8
M$17 1 7 2 14 nfet_01v8 L=150000U W=1300000U AS=318500000000P AD=318500000000P
+ PS=2280000U PD=2280000U
* device instance $19 r0 *1 3.57,0.56 nfet_01v8
M$19 3 8 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__o311ai_2

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6

* cell sky130_fd_sc_hd__o311ai_1
* pin VGND
* pin Y
* pin A1
* pin A2
* pin A3
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_1 1 3 4 5 6 7 8 10 11 14
* net 1 VGND
* net 3 Y
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 B1
* net 8 C1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.615,1.985 pfet_01v8_hvt
M$1 12 4 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=135000000000P PS=2560000U PD=1270000U
* device instance $2 r0 *1 1.035,1.985 pfet_01v8_hvt
M$2 13 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.455,1.985 pfet_01v8_hvt
M$3 3 6 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=225000000000P PS=1270000U PD=1450000U
* device instance $4 r0 *1 2.055,1.985 pfet_01v8_hvt
M$4 10 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=185000000000P PS=1450000U PD=1370000U
* device instance $5 r0 *1 2.575,1.985 pfet_01v8_hvt
M$5 3 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=185000000000P
+ AD=310000000000P PS=1370000U PD=2620000U
* device instance $6 r0 *1 0.615,0.56 nfet_01v8
M$6 2 4 1 14 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $7 r0 *1 1.035,0.56 nfet_01v8
M$7 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.455,0.56 nfet_01v8
M$8 2 6 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $9 r0 *1 2.215,0.56 nfet_01v8
M$9 9 7 2 14 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=68250000000P
+ PS=1260000U PD=860000U
* device instance $10 r0 *1 2.575,0.56 nfet_01v8
M$10 3 8 9 14 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=182000000000P
+ PS=860000U PD=1860000U
.ENDS sky130_fd_sc_hd__o311ai_1

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__edfxtp_1
* pin VGND
* pin DE
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__edfxtp_1 1 5 11 17 18 19 20 26
* net 1 VGND
* net 5 DE
* net 11 Q
* net 17 CLK
* net 18 D
* net 19 VPWR
* net 20 VPB
* device instance $1 r0 *1 9.925,2.165 pfet_01v8_hvt
M$1 7 10 19 20 pfet_01v8_hvt L=150000U W=640000U AS=154000000000P
+ AD=172800000000P PS=1335000U PD=1820000U
* device instance $2 r0 *1 10.41,1.985 pfet_01v8_hvt
M$2 11 10 19 20 pfet_01v8_hvt L=150000U W=1000000U AS=154000000000P
+ AD=280000000000P PS=1335000U PD=2560000U
* device instance $3 r0 *1 7.425,2.275 pfet_01v8_hvt
M$3 24 9 19 20 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=64050000000P PS=1360000U PD=725000U
* device instance $4 r0 *1 7.88,2.275 pfet_01v8_hvt
M$4 10 2 24 20 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P
+ AD=56700000000P PS=725000U PD=690000U
* device instance $5 r0 *1 8.3,2.275 pfet_01v8_hvt
M$5 25 3 10 20 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=88200000000P PS=690000U PD=840000U
* device instance $6 r0 *1 8.87,2.275 pfet_01v8_hvt
M$6 19 7 25 20 pfet_01v8_hvt L=150000U W=420000U AS=88200000000P
+ AD=111300000000P PS=840000U PD=1370000U
* device instance $7 r0 *1 1.83,2.165 pfet_01v8_hvt
M$7 21 18 4 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=67200000000P PS=1800000U PD=850000U
* device instance $8 r0 *1 2.19,2.165 pfet_01v8_hvt
M$8 19 6 21 20 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=166400000000P PS=850000U PD=1800000U
* device instance $9 r0 *1 0.47,2.135 pfet_01v8_hvt
M$9 19 17 2 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $10 r0 *1 0.89,2.135 pfet_01v8_hvt
M$10 3 2 19 20 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $11 r0 *1 3.13,2.165 pfet_01v8_hvt
M$11 19 5 6 20 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=92800000000P PS=1800000U PD=930000U
* device instance $12 r0 *1 3.57,2.165 pfet_01v8_hvt
M$12 22 5 19 20 pfet_01v8_hvt L=150000U W=640000U AS=92800000000P
+ AD=115200000000P PS=930000U PD=1000000U
* device instance $13 r0 *1 4.08,2.165 pfet_01v8_hvt
M$13 4 7 22 20 pfet_01v8_hvt L=150000U W=640000U AS=115200000000P
+ AD=159850000000P PS=1000000U PD=1265000U
* device instance $14 r0 *1 4.855,2.275 pfet_01v8_hvt
M$14 8 3 4 20 pfet_01v8_hvt L=150000U W=420000U AS=159850000000P
+ AD=64050000000P PS=1265000U PD=725000U
* device instance $15 r0 *1 5.31,2.275 pfet_01v8_hvt
M$15 23 2 8 20 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P
+ AD=76650000000P PS=725000U PD=785000U
* device instance $16 r0 *1 5.825,2.275 pfet_01v8_hvt
M$16 23 9 19 20 pfet_01v8_hvt L=150000U W=420000U AS=178875000000P
+ AD=76650000000P PS=1260000U PD=785000U
* device instance $17 r0 *1 6.485,2.11 pfet_01v8_hvt
M$17 9 8 19 20 pfet_01v8_hvt L=150000U W=750000U AS=178875000000P
+ AD=195000000000P PS=1260000U PD=2020000U
* device instance $18 r0 *1 9.925,0.445 nfet_01v8
M$18 1 10 7 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $19 r0 *1 10.41,0.56 nfet_01v8
M$19 11 10 1 26 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=182000000000P
+ PS=985000U PD=1860000U
* device instance $20 r0 *1 7.98,0.415 nfet_01v8
M$20 10 3 15 26 nfet_01v8 L=150000U W=360000U AS=67800000000P AD=68400000000P
+ PS=755000U PD=740000U
* device instance $21 r0 *1 8.51,0.415 nfet_01v8
M$21 13 2 10 26 nfet_01v8 L=150000U W=360000U AS=68400000000P AD=66000000000P
+ PS=740000U PD=745000U
* device instance $22 r0 *1 7.495,0.445 nfet_01v8
M$22 15 9 1 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=67800000000P
+ PS=1360000U PD=755000U
* device instance $23 r0 *1 8.985,0.445 nfet_01v8
M$23 1 7 13 26 nfet_01v8 L=150000U W=420000U AS=66000000000P AD=109200000000P
+ PS=745000U PD=1360000U
* device instance $24 r0 *1 0.47,0.445 nfet_01v8
M$24 1 17 2 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $25 r0 *1 0.89,0.445 nfet_01v8
M$25 3 2 1 26 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $26 r0 *1 4.99,0.415 nfet_01v8
M$26 8 2 4 26 nfet_01v8 L=150000U W=360000U AS=144600000000P AD=52200000000P
+ PS=1180000U PD=650000U
* device instance $27 r0 *1 5.43,0.415 nfet_01v8
M$27 16 3 8 26 nfet_01v8 L=150000U W=360000U AS=52200000000P AD=75900000000P
+ PS=650000U PD=800000U
* device instance $28 r0 *1 3.13,0.445 nfet_01v8
M$28 1 5 6 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $29 r0 *1 3.57,0.445 nfet_01v8
M$29 14 6 1 26 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=75600000000P
+ PS=710000U PD=780000U
* device instance $30 r0 *1 4.08,0.445 nfet_01v8
M$30 4 7 14 26 nfet_01v8 L=150000U W=420000U AS=75600000000P AD=144600000000P
+ PS=780000U PD=1180000U
* device instance $31 r0 *1 5.96,0.445 nfet_01v8
M$31 1 9 16 26 nfet_01v8 L=150000U W=420000U AS=75900000000P AD=120950000000P
+ PS=800000U PD=1085000U
* device instance $32 r0 *1 6.555,0.555 nfet_01v8
M$32 9 8 1 26 nfet_01v8 L=150000U W=640000U AS=120950000000P AD=166400000000P
+ PS=1085000U PD=1800000U
* device instance $33 r0 *1 1.83,0.445 nfet_01v8
M$33 12 18 4 26 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $34 r0 *1 2.19,0.445 nfet_01v8
M$34 1 5 12 26 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=109200000000P
+ PS=630000U PD=1360000U
.ENDS sky130_fd_sc_hd__edfxtp_1

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__clkbuf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_16 1 3 4 5 6 7
* net 1 VGND
* net 3 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $5 r0 *1 2.195,1.985 pfet_01v8_hvt
M$5 4 2 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.2375e+12P AD=2.3625e+12P
+ PS=20475000U PD=21725000U
* device instance $21 r0 *1 0.475,0.445 nfet_01v8
M$21 2 3 1 7 nfet_01v8 L=150000U W=1680000U AS=287700000000P AD=235200000000P
+ PS=3470000U PD=2800000U
* device instance $25 r0 *1 2.195,0.445 nfet_01v8
M$25 4 2 1 7 nfet_01v8 L=150000U W=6720000U AS=939750000000P AD=992250000000P
+ PS=11195000U PD=11865000U
.ENDS sky130_fd_sc_hd__clkbuf_16

* cell sky130_fd_sc_hd__ha_1
* pin VGND
* pin SUM
* pin COUT
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_1 1 2 5 8 9 10 11 13
* net 1 VGND
* net 2 SUM
* net 5 COUT
* net 8 A
* net 9 B
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=236050000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,2.275 pfet_01v8_hvt
M$2 3 7 10 11 pfet_01v8_hvt L=150000U W=420000U AS=236050000000P
+ AD=56700000000P PS=1765000U PD=690000U
* device instance $3 r0 *1 1.805,2.275 pfet_01v8_hvt
M$3 12 9 3 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=84000000000P
+ PS=690000U PD=820000U
* device instance $4 r0 *1 2.355,2.275 pfet_01v8_hvt
M$4 10 8 12 11 pfet_01v8_hvt L=150000U W=420000U AS=84000000000P
+ AD=149100000000P PS=820000U PD=1130000U
* device instance $5 r0 *1 3.215,2.275 pfet_01v8_hvt
M$5 7 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=149100000000P
+ AD=60900000000P PS=1130000U PD=710000U
* device instance $6 r0 *1 3.655,2.275 pfet_01v8_hvt
M$6 7 8 10 11 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=60900000000P PS=1325000U PD=710000U
* device instance $7 r0 *1 4.13,1.985 pfet_01v8_hvt
M$7 5 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $8 r0 *1 3.295,0.445 nfet_01v8
M$8 6 9 7 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 3.655,0.445 nfet_01v8
M$9 1 8 6 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $10 r0 *1 4.13,0.56 nfet_01v8
M$10 5 7 1 13 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 1.41,0.445 nfet_01v8
M$11 4 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $12 r0 *1 1.83,0.445 nfet_01v8
M$12 1 9 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $13 r0 *1 2.25,0.445 nfet_01v8
M$13 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__ha_1

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__o221a_1
* pin VGND
* pin X
* pin C1
* pin B1
* pin B2
* pin A2
* pin A1
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o221a_1 1 5 6 7 8 9 10 11 12 15
* net 1 VGND
* net 5 X
* net 6 C1
* net 7 B1
* net 8 B2
* net 9 A2
* net 10 A1
* net 11 VPB
* net 12 VPWR
* device instance $1 r0 *1 0.67,1.985 pfet_01v8_hvt
M$1 12 6 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=340000000000P
+ AD=165000000000P PS=2680000U PD=1330000U
* device instance $2 r0 *1 1.15,1.985 pfet_01v8_hvt
M$2 13 7 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=105000000000P PS=1330000U PD=1210000U
* device instance $3 r0 *1 1.51,1.985 pfet_01v8_hvt
M$3 2 8 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=412500000000P PS=1210000U PD=1825000U
* device instance $4 r0 *1 2.485,1.985 pfet_01v8_hvt
M$4 14 9 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=412500000000P
+ AD=105000000000P PS=1825000U PD=1210000U
* device instance $5 r0 *1 2.845,1.985 pfet_01v8_hvt
M$5 12 10 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $6 r0 *1 3.325,1.985 pfet_01v8_hvt
M$6 5 2 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=280000000000P PS=1330000U PD=2560000U
* device instance $7 r0 *1 2.485,0.56 nfet_01v8
M$7 4 9 1 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.905,0.56 nfet_01v8
M$8 1 10 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 3.325,0.56 nfet_01v8
M$9 5 2 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
* device instance $10 r0 *1 0.67,0.56 nfet_01v8
M$10 3 6 2 15 nfet_01v8 L=150000U W=650000U AS=201500000000P AD=99125000000P
+ PS=1920000U PD=955000U
* device instance $11 r0 *1 1.125,0.56 nfet_01v8
M$11 4 7 3 15 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=87750000000P
+ PS=955000U PD=920000U
* device instance $12 r0 *1 1.545,0.56 nfet_01v8
M$12 3 8 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221a_1

* cell sky130_fd_sc_hd__o221ai_2
* pin VGND
* pin C1
* pin Y
* pin B1
* pin B2
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o221ai_2 1 3 4 6 7 8 9 10 13 14
* net 1 VGND
* net 3 C1
* net 4 Y
* net 6 B1
* net 7 B2
* net 8 A1
* net 9 A2
* net 10 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 4 3 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=530000000000P PS=3790000U PD=3060000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 6 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=530000000000P
+ AD=310000000000P PS=3060000U PD=2620000U
* device instance $4 r0 *1 2.255,1.985 pfet_01v8_hvt
M$4 4 7 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $7 r0 *1 3.595,1.985 pfet_01v8_hvt
M$7 12 8 10 13 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $8 r0 *1 4.015,1.985 pfet_01v8_hvt
M$8 4 9 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $11 r0 *1 1.835,0.56 nfet_01v8
M$11 2 6 5 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=201500000000P
+ PS=2740000U PD=1920000U
* device instance $12 r0 *1 2.255,0.56 nfet_01v8
M$12 5 7 2 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $15 r0 *1 3.595,0.56 nfet_01v8
M$15 1 8 5 14 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $16 r0 *1 4.015,0.56 nfet_01v8
M$16 5 9 1 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $19 r0 *1 0.475,0.56 nfet_01v8
M$19 4 3 2 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__o221ai_2

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__o21ai_1
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 VGND
* net 8 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 8 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=174000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.37,2.135 pfet_01v8_hvt
M$3 5 3 8 1 pfet_01v8_hvt L=150000U W=700000U AS=174000000000P AD=182000000000P
+ PS=1390000U PD=1920000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $5 r0 *1 0.95,0.56 nfet_01v8
M$5 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 8 3 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21ai_1

* cell sky130_fd_sc_hd__o31ai_4
* pin VGND
* pin B1
* pin Y
* pin A1
* pin A2
* pin A3
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_4 1 2 4 5 6 7 10 11 12
* net 1 VGND
* net 2 B1
* net 4 Y
* net 5 A1
* net 6 A2
* net 7 A3
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.385,1.985 pfet_01v8_hvt
M$1 9 7 4 11 pfet_01v8_hvt L=150000U W=4000000U AS=667800000000P
+ AD=540000000000P PS=6380000U PD=5080000U
* device instance $5 r0 *1 6.065,1.985 pfet_01v8_hvt
M$5 10 2 4 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 10 5 8 11 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $13 r0 *1 2.17,1.985 pfet_01v8_hvt
M$13 9 6 8 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665500000000P PS=5080000U PD=6370000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 1 5 3 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 2.17,0.56 nfet_01v8
M$21 1 6 3 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
* device instance $25 r0 *1 3.85,0.56 nfet_01v8
M$25 1 7 3 12 nfet_01v8 L=150000U W=2600000U AS=524875000000P AD=524875000000P
+ PS=4215000U PD=4215000U
* device instance $29 r0 *1 6.065,0.56 nfet_01v8
M$29 4 2 3 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o31ai_4

* cell sky130_fd_sc_hd__a211oi_1
* pin VPB
* pin A2
* pin A1
* pin C1
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A2
* net 3 A1
* net 4 C1
* net 5 B1
* net 6 VGND
* net 7 Y
* net 9 VPWR
* device instance $1 r0 *1 0.62,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.05,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 1.48,1.985 pfet_01v8_hvt
M$3 11 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 1.94,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.62,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=266500000000P AD=91000000000P
+ PS=2120000U PD=930000U
* device instance $6 r0 *1 1.05,0.56 nfet_01v8
M$6 7 3 12 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $7 r0 *1 1.48,0.56 nfet_01v8
M$7 6 5 7 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $8 r0 *1 1.94,0.56 nfet_01v8
M$8 7 4 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211oi_1

* cell sky130_fd_sc_hd__a311oi_1
* pin VPB
* pin A3
* pin A2
* pin B1
* pin A1
* pin C1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_1 1 2 3 4 5 6 7 9 10 11
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 B1
* net 5 A1
* net 6 C1
* net 7 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 0.895,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 1.325,1.985 pfet_01v8_hvt
M$3 8 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=165000000000P PS=1280000U PD=1330000U
* device instance $4 r0 *1 1.805,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=172500000000P PS=1330000U PD=1345000U
* device instance $5 r0 *1 2.3,1.985 pfet_01v8_hvt
M$5 9 6 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=260000000000P PS=1345000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 10 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=89375000000P
+ PS=1820000U PD=925000U
* device instance $7 r0 *1 0.895,0.56 nfet_01v8
M$7 13 3 14 11 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 1.325,0.56 nfet_01v8
M$8 9 5 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=115375000000P
+ PS=930000U PD=1005000U
* device instance $9 r0 *1 1.83,0.56 nfet_01v8
M$9 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=112125000000P
+ PS=1005000U PD=995000U
* device instance $10 r0 *1 2.325,0.56 nfet_01v8
M$10 9 6 10 11 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=169000000000P
+ PS=995000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311oi_1

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__a22oi_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=300000000000P PS=1270000U PD=2600000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 1.83,0.56 nfet_01v8
M$5 11 4 8 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 2.19,0.56 nfet_01v8
M$6 9 5 11 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=234000000000P
+ PS=860000U PD=2020000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 12 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 3 12 10 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22oi_1

* cell sky130_fd_sc_hd__o21a_1
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21a_1 1 2 3 4 5 7 8 10
* net 1 VPB
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=327500000000P PS=2560000U PD=1655000U
* device instance $2 r0 *1 1.295,1.985 pfet_01v8_hvt
M$2 9 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=327500000000P
+ AD=195000000000P PS=1655000U PD=1390000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=152500000000P PS=1390000U PD=1305000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 5 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=260000000000P PS=1305000U PD=2520000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 3 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 8 9 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21a_1

* cell sky130_fd_sc_hd__nand4_4
* pin VGND
* pin D
* pin A
* pin C
* pin B
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4_4 1 2 3 5 7 9 10 11 12
* net 1 VGND
* net 2 D
* net 3 A
* net 5 C
* net 7 B
* net 9 VPWR
* net 10 Y
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 10 5 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=800000000000P PS=5080000U PD=5600000U
* device instance $9 r0 *1 4.35,1.985 pfet_01v8_hvt
M$9 10 7 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=570000000000P PS=5600000U PD=5140000U
* device instance $13 r0 *1 6.09,1.985 pfet_01v8_hvt
M$13 10 3 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=570000000000P
+ AD=665000000000P PS=5140000U PD=6330000U
* device instance $17 r0 *1 4.35,0.56 nfet_01v8
M$17 6 7 8 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=370500000000P
+ PS=4580000U PD=3740000U
* device instance $21 r0 *1 6.09,0.56 nfet_01v8
M$21 10 3 8 12 nfet_01v8 L=150000U W=2600000U AS=370500000000P AD=432250000000P
+ PS=3740000U PD=4580000U
* device instance $25 r0 *1 0.47,0.56 nfet_01v8
M$25 1 2 4 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 2.15,0.56 nfet_01v8
M$29 6 5 4 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand4_4

* cell sky130_fd_sc_hd__a31oi_2
* pin VGND
* pin Y
* pin A3
* pin A2
* pin A1
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_2 1 4 5 6 7 8 10 11 12
* net 1 VGND
* net 4 Y
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=545000000000P
+ AD=590000000000P PS=3090000U PD=3180000U
* device instance $7 r0 *1 3.63,1.985 pfet_01v8_hvt
M$7 4 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=355000000000P
+ AD=435000000000P PS=2710000U PD=3870000U
* device instance $9 r0 *1 2.67,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=214500000000P
+ PS=2770000U PD=1960000U
* device instance $11 r0 *1 3.63,0.56 nfet_01v8
M$11 1 8 4 12 nfet_01v8 L=150000U W=1300000U AS=230750000000P AD=282750000000P
+ PS=2010000U PD=2820000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a31oi_2

* cell sky130_fd_sc_hd__and2_0
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_0 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.54,2.275 pfet_01v8_hvt
M$1 4 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=60900000000P
+ PS=1370000U PD=710000U
* device instance $2 r0 *1 0.98,2.275 pfet_01v8_hvt
M$2 4 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=184100000000P AD=60900000000P
+ PS=1260000U PD=710000U
* device instance $3 r0 *1 1.75,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=184100000000P AD=169600000000P
+ PS=1260000U PD=1810000U
* device instance $4 r0 *1 0.54,0.445 nfet_01v8
M$4 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=1370000U PD=630000U
* device instance $5 r0 *1 0.9,0.445 nfet_01v8
M$5 7 3 9 8 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=96600000000P
+ PS=630000U PD=880000U
* device instance $6 r0 *1 1.51,0.445 nfet_01v8
M$6 5 4 7 8 nfet_01v8 L=150000U W=420000U AS=96600000000P AD=111300000000P
+ PS=880000U PD=1370000U
.ENDS sky130_fd_sc_hd__and2_0

* cell sky130_fd_sc_hd__o211ai_4
* pin VGND
* pin A1
* pin A2
* pin C1
* pin B1
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_4 1 2 3 4 6 10 11 12 14
* net 1 VGND
* net 2 A1
* net 3 A2
* net 4 C1
* net 6 B1
* net 10 VPWR
* net 11 Y
* net 12 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 13 2 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=580000000000P PS=6370000U PD=5160000U
* device instance $4 r0 *1 1.765,1.985 pfet_01v8_hvt
M$4 11 3 13 12 pfet_01v8_hvt L=150000U W=4000000U AS=560000000000P
+ AD=560000000000P PS=5120000U PD=5120000U
* device instance $9 r0 *1 3.955,1.985 pfet_01v8_hvt
M$9 11 6 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=575000000000P AD=1.09e+12P
+ PS=5150000U PD=7180000U
* device instance $12 r0 *1 5.235,1.985 pfet_01v8_hvt
M$12 10 4 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $17 r0 *1 0.475,0.56 nfet_01v8
M$17 1 2 5 14 nfet_01v8 L=150000U W=2600000U AS=448500000000P AD=373750000000P
+ PS=4630000U PD=3750000U
* device instance $20 r0 *1 1.765,0.56 nfet_01v8
M$20 5 3 1 14 nfet_01v8 L=150000U W=2600000U AS=364000000000P AD=367250000000P
+ PS=3720000U PD=3730000U
* device instance $25 r0 *1 3.955,0.56 nfet_01v8
M$25 7 6 5 14 nfet_01v8 L=150000U W=1300000U AS=191750000000P AD=182000000000P
+ PS=1890000U PD=1860000U
* device instance $27 r0 *1 4.815,0.56 nfet_01v8
M$27 9 6 5 14 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=87750000000P
+ PS=930000U PD=920000U
* device instance $28 r0 *1 5.235,0.56 nfet_01v8
M$28 11 4 9 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $29 r0 *1 5.655,0.56 nfet_01v8
M$29 7 4 11 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $31 r0 *1 6.495,0.56 nfet_01v8
M$31 8 4 11 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=104000000000P
+ PS=920000U PD=970000U
* device instance $32 r0 *1 6.965,0.56 nfet_01v8
M$32 5 6 8 14 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=256750000000P
+ PS=970000U PD=2090000U
.ENDS sky130_fd_sc_hd__o211ai_4

* cell sky130_fd_sc_hd__o2111ai_4
* pin VGND
* pin D1
* pin A2
* pin Y
* pin C1
* pin B1
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2111ai_4 1 2 3 4 6 9 10 11 13 14
* net 1 VGND
* net 2 D1
* net 3 A2
* net 4 Y
* net 6 C1
* net 9 B1
* net 10 A1
* net 11 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 11 6 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=642500000000P PS=5080000U PD=5285000U
* device instance $9 r0 *1 4.035,1.985 pfet_01v8_hvt
M$9 11 9 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=642500000000P
+ AD=552500000000P PS=5285000U PD=5105000U
* device instance $13 r0 *1 5.74,1.985 pfet_01v8_hvt
M$13 12 3 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=552500000000P
+ AD=658350000000P PS=5105000U PD=6330000U
* device instance $17 r0 *1 7.93,1.985 pfet_01v8_hvt
M$17 12 10 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=657850000000P
+ AD=665000000000P PS=6330000U PD=6330000U
* device instance $21 r0 *1 4.35,0.56 nfet_01v8
M$21 7 9 8 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=359125000000P
+ PS=4580000U PD=3705000U
* device instance $25 r0 *1 6.055,0.56 nfet_01v8
M$25 1 3 8 14 nfet_01v8 L=150000U W=2600000U AS=365625000000P AD=365625000000P
+ PS=3725000U PD=3725000U
* device instance $29 r0 *1 7.78,0.56 nfet_01v8
M$29 1 10 8 14 nfet_01v8 L=150000U W=2600000U AS=359125000000P AD=448500000000P
+ PS=3705000U PD=4630000U
* device instance $33 r0 *1 0.47,0.56 nfet_01v8
M$33 4 2 5 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $37 r0 *1 2.15,0.56 nfet_01v8
M$37 7 6 5 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o2111ai_4

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__nor3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 6 4 5 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $6 r0 *1 1.31,0.56 nfet_01v8
M$6 6 2 5 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor3_1

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__nor3b_4
* pin VGND
* pin A
* pin B
* pin Y
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_4 1 2 3 4 5 7 10 11
* net 1 VGND
* net 2 A
* net 3 B
* net 4 Y
* net 5 C_N
* net 7 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.11,1.985 pfet_01v8_hvt
M$1 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 4.79,1.985 pfet_01v8_hvt
M$5 4 6 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 7 5 6 10 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=135000000000P PS=2560000U PD=1270000U
* device instance $10 r0 *1 0.91,1.985 pfet_01v8_hvt
M$10 8 2 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $14 r0 *1 0.49,0.56 nfet_01v8
M$14 1 5 6 11 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $15 r0 *1 0.91,0.56 nfet_01v8
M$15 4 2 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $19 r0 *1 3.11,0.56 nfet_01v8
M$19 4 3 1 11 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $23 r0 *1 4.79,0.56 nfet_01v8
M$23 4 6 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor3b_4

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__nor4_4
* pin VGND
* pin C
* pin Y
* pin A
* pin B
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_4 1 2 3 4 6 7 8 11 12
* net 1 VGND
* net 2 C
* net 3 Y
* net 4 A
* net 6 B
* net 7 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.37,1.985 pfet_01v8_hvt
M$1 9 2 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.05,1.985 pfet_01v8_hvt
M$5 3 7 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 8 4 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $13 r0 *1 2.17,1.985 pfet_01v8_hvt
M$13 9 6 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 3 4 1 12 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $21 r0 *1 2.17,0.56 nfet_01v8
M$21 3 6 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $25 r0 *1 4.37,0.56 nfet_01v8
M$25 3 2 1 12 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $29 r0 *1 6.05,0.56 nfet_01v8
M$29 3 7 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor4_4

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__or4_2
* pin VPB
* pin D
* pin C
* pin B
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or4_2 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 D
* net 3 C
* net 4 B
* net 5 A
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 13 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $2 r0 *1 0.95,1.695 pfet_01v8_hvt
M$2 12 3 13 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $3 r0 *1 1.31,1.695 pfet_01v8_hvt
M$3 11 4 12 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $4 r0 *1 1.79,1.695 pfet_01v8_hvt
M$4 8 5 11 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $5 r0 *1 2.28,1.985 pfet_01v8_hvt
M$5 9 6 8 1 pfet_01v8_hvt L=150000U W=2000000U AS=283250000000P
+ AD=440000000000P PS=2610000U PD=3880000U
* device instance $7 r0 *1 0.47,0.475 nfet_01v8
M$7 6 2 7 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $8 r0 *1 0.95,0.475 nfet_01v8
M$8 7 3 6 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $9 r0 *1 1.37,0.475 nfet_01v8
M$9 6 4 7 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $10 r0 *1 1.79,0.475 nfet_01v8
M$10 6 5 7 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $11 r0 *1 2.28,0.56 nfet_01v8
M$11 9 6 7 10 nfet_01v8 L=150000U W=1300000U AS=189625000000P AD=286000000000P
+ PS=1910000U PD=2830000U
.ENDS sky130_fd_sc_hd__or4_2

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__a221oi_1
* pin VGND
* pin Y
* pin B1
* pin A1
* pin C1
* pin B2
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_1 1 2 3 4 5 6 7 10 11 14
* net 1 VGND
* net 2 Y
* net 3 B1
* net 4 A1
* net 5 C1
* net 6 B2
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 13 4 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=152500000000P PS=2520000U PD=1305000U
* device instance $2 r0 *1 2.705,1.985 pfet_01v8_hvt
M$2 11 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=305000000000P PS=1305000U PD=2610000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 12 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 13 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 12 3 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 2.25,0.56 nfet_01v8
M$6 9 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=99125000000P
+ PS=1820000U PD=955000U
* device instance $7 r0 *1 2.705,0.56 nfet_01v8
M$7 1 7 9 14 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=198250000000P
+ PS=955000U PD=1910000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $9 r0 *1 0.945,0.56 nfet_01v8
M$9 8 6 1 14 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=69875000000P
+ PS=975000U PD=865000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 2 3 8 14 nfet_01v8 L=150000U W=650000U AS=69875000000P AD=169000000000P
+ PS=865000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221oi_1

* cell sky130_fd_sc_hd__clkbuf_4
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 6 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=165000000000P PS=2530000U PD=1330000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=4000000U AS=585000000000P
+ AD=720000000000P PS=5170000U PD=6440000U
* device instance $6 r0 *1 0.475,0.445 nfet_01v8
M$6 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=70350000000P
+ PS=1370000U PD=755000U
* device instance $7 r0 *1 0.96,0.445 nfet_01v8
M$7 5 2 4 7 nfet_01v8 L=150000U W=1680000U AS=246750000000P AD=298200000000P
+ PS=2855000U PD=3520000U
.ENDS sky130_fd_sc_hd__clkbuf_4

* cell sky130_fd_sc_hd__buf_2
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_2 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.125 pfet_01v8_hvt
M$1 2 3 6 1 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P AD=166400000000P
+ PS=1325000U PD=1800000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=284000000000P
+ AD=400000000000P PS=2595000U PD=3800000U
* device instance $4 r0 *1 0.47,0.445 nfet_01v8
M$4 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $5 r0 *1 0.945,0.56 nfet_01v8
M$5 5 2 4 7 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=260000000000P
+ PS=1895000U PD=2750000U
.ENDS sky130_fd_sc_hd__buf_2

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4
