* cell network_interface_cdc
* pin dst_rst_n
* pin mem_rdata[14]
* pin mem_rdata[12]
* pin router_out_data[13]
* pin mem_read
* pin mem_write
* pin router_out_data[15]
* pin mem_rdata[13]
* pin mem_rdata[15]
* pin router_out_data[11]
* pin mem_wdata[20]
* pin mem_ready
* pin mem_rdata[11]
* pin router_out_data[10]
* pin mem_rdata[10]
* pin router_out_data[0]
* pin mem_rdata[0]
* pin router_out_data[17]
* pin mem_rdata[17]
* pin router_out_data[7]
* pin mem_rdata[7]
* pin router_out_data[9]
* pin router_out_data[8]
* pin mem_rdata[9]
* pin mem_rdata[8]
* pin router_out_data[6]
* pin mem_rdata[6]
* pin router_out_data[30]
* pin mem_rdata[30]
* pin router_out_data[31]
* pin mem_rdata[31]
* pin router_out_data[2]
* pin mem_rdata[2]
* pin router_out_data[5]
* pin mem_rdata[5]
* pin mem_rdata[29]
* pin mem_rdata[28]
* pin mem_rdata[16]
* pin router_out_data[16]
* pin router_out_data[28]
* pin router_out_data[14]
* pin router_out_data[27]
* pin mem_rdata[3]
* pin mem_rdata[4]
* pin router_out_data[4]
* pin router_out_data[29]
* pin router_out_data[26]
* pin router_out_data[3]
* pin mem_rdata[27]
* pin router_out_data[25]
* pin router_out_data[12]
* pin mem_rdata[25]
* pin router_out_valid
* pin mem_rdata[26]
* pin router_out_data[19]
* pin router_out_data[24]
* pin mem_rdata[22]
* pin router_out_ready
* pin mem_rdata[19]
* pin router_in_ready
* pin router_in_valid
* pin router_out_data[18]
* pin router_out_data[22]
* pin mem_rdata[18]
* pin mem_rdata[24]
* pin mem_addr[20]
* pin router_out_data[20]
* pin mem_rdata[1]
* pin mem_rdata[23]
* pin mem_rdata[20]
* pin router_out_data[23]
* pin router_out_data[1]
* pin router_out_data[21]
* pin router_in_data[9]
* pin mem_addr[9]
* pin mem_wdata[9]
* pin router_in_data[20]
* pin mem_rdata[21]
* pin router_in_data[27]
* pin router_in_data[8]
* pin router_in_data[15]
* pin mem_addr[7]
* pin mem_wdata[8]
* pin mem_wdata[27]
* pin mem_wdata[7]
* pin dest_id[3]
* pin mem_addr[8]
* pin router_in_data[21]
* pin msg_type[0]
* pin router_in_data[30]
* pin mem_wdata[5]
* pin mem_wdata[21]
* pin mem_addr[5]
* pin dest_id[6]
* pin mem_wdata[1]
* pin mem_wdata[30]
* pin mem_addr[1]
* pin router_in_data[6]
* pin mem_wdata[23]
* pin router_in_data[1]
* pin msg_type[2]
* pin router_in_data[23]
* pin dest_id[4]
* pin router_in_data[25]
* pin mem_wdata[25]
* pin mem_wdata[2]
* pin dest_id[1]
* pin mem_addr[2]
* pin mem_addr[6]
* pin mem_wdata[6]
* pin router_in_data[28]
* pin mem_wdata[28]
* pin router_in_data[24]
* pin router_in_data[14]
* pin src_rst_n
* pin mem_wdata[22]
* pin dest_id[2]
* pin dest_id[0]
* pin mem_addr[19]
* pin dest_id[5]
* pin mem_wdata[29]
* pin mem_wdata[4]
* pin msg_type[1]
* pin mem_wdata[26]
* pin mem_wdata[19]
* pin src_clk
* pin mem_wdata[24]
* pin dst_clk
* pin mem_wdata[18]
* pin mem_wdata[14]
* pin mem_addr[14]
* pin mem_addr[11]
* pin mem_addr[10]
* pin mem_addr[0]
* pin router_in_data[13]
* pin mem_wdata[13]
* pin mem_wdata[12]
* pin router_in_data[18]
* pin mem_wdata[11]
* pin mem_addr[16]
* pin router_in_data[26]
* pin router_in_data[22]
* pin router_in_data[19]
* pin router_in_data[29]
* pin mem_addr[4]
* pin router_in_data[4]
* pin mem_wdata[31]
* pin dest_id[7]
* pin mem_addr[3]
* pin router_in_data[31]
* pin mem_wdata[3]
* pin router_in_data[2]
* pin router_in_data[3]
* pin mem_addr[12]
* pin mem_addr[13]
* pin mem_addr[18]
* pin router_in_data[12]
* pin mem_wdata[0]
* pin mem_wdata[16]
* pin mem_addr[15]
* pin router_in_data[0]
* pin router_in_data[11]
* pin mem_wdata[15]
* pin mem_wdata[10]
* pin mem_wdata[17]
* pin router_in_data[10]
* pin mem_addr[17]
* pin router_in_data[17]
* pin router_in_data[7]
* pin router_in_data[5]
* pin router_in_data[16]
* pin PWELL,gf180mcu_gnd
* pin NWELL
.SUBCKT network_interface_cdc 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19
+ 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 129 130 133 134 142 147 152
+ 157 158 159 160 178 181 182 183 192 233 234 235 257 259 261 262 263 264 265
+ 282 285 287 299 306 316 320 321 322 332 335 336 337 338 339 345 358 362 363
+ 374 380 381 382 383 384 385 386 387 410 411 412 413 414 415 416 417 438 439
+ 440 441 442 463 464 465 466 467 468 469 470 471 489 490 499 511 512 513 514
+ 515 516 517 518 519 520 521 522 523 540 621 625 633 658 670 677 681 684 685
+ 686 688 689 691 692 693 694 695 697 698 699 701 703 704 706 708 710 713 714
+ 715 716 717 718 719 720 722 723 725 727 728 729 730 731 732 733 734
* net 1 dst_rst_n
* net 2 mem_rdata[14]
* net 3 mem_rdata[12]
* net 4 router_out_data[13]
* net 5 mem_read
* net 6 mem_write
* net 7 router_out_data[15]
* net 8 mem_rdata[13]
* net 9 mem_rdata[15]
* net 10 router_out_data[11]
* net 11 mem_wdata[20]
* net 12 mem_ready
* net 13 mem_rdata[11]
* net 14 router_out_data[10]
* net 15 mem_rdata[10]
* net 16 router_out_data[0]
* net 17 mem_rdata[0]
* net 18 router_out_data[17]
* net 19 mem_rdata[17]
* net 20 router_out_data[7]
* net 21 mem_rdata[7]
* net 22 router_out_data[9]
* net 23 router_out_data[8]
* net 24 mem_rdata[9]
* net 25 mem_rdata[8]
* net 26 router_out_data[6]
* net 27 mem_rdata[6]
* net 28 router_out_data[30]
* net 29 mem_rdata[30]
* net 30 router_out_data[31]
* net 31 mem_rdata[31]
* net 32 router_out_data[2]
* net 33 mem_rdata[2]
* net 34 router_out_data[5]
* net 35 mem_rdata[5]
* net 129 mem_rdata[29]
* net 130 mem_rdata[28]
* net 133 mem_rdata[16]
* net 134 router_out_data[16]
* net 142 router_out_data[28]
* net 147 router_out_data[14]
* net 152 router_out_data[27]
* net 157 mem_rdata[3]
* net 158 mem_rdata[4]
* net 159 router_out_data[4]
* net 160 router_out_data[29]
* net 178 router_out_data[26]
* net 181 router_out_data[3]
* net 182 mem_rdata[27]
* net 183 router_out_data[25]
* net 192 router_out_data[12]
* net 233 mem_rdata[25]
* net 234 router_out_valid
* net 235 mem_rdata[26]
* net 257 router_out_data[19]
* net 259 router_out_data[24]
* net 261 mem_rdata[22]
* net 262 router_out_ready
* net 263 mem_rdata[19]
* net 264 router_in_ready
* net 265 router_in_valid
* net 282 router_out_data[18]
* net 285 router_out_data[22]
* net 287 mem_rdata[18]
* net 299 mem_rdata[24]
* net 306 mem_addr[20]
* net 316 router_out_data[20]
* net 320 mem_rdata[1]
* net 321 mem_rdata[23]
* net 322 mem_rdata[20]
* net 332 router_out_data[23]
* net 335 router_out_data[1]
* net 336 router_out_data[21]
* net 337 router_in_data[9]
* net 338 mem_addr[9]
* net 339 mem_wdata[9]
* net 345 router_in_data[20]
* net 358 mem_rdata[21]
* net 362 router_in_data[27]
* net 363 router_in_data[8]
* net 374 router_in_data[15]
* net 380 mem_addr[7]
* net 381 mem_wdata[8]
* net 382 mem_wdata[27]
* net 383 mem_wdata[7]
* net 384 dest_id[3]
* net 385 mem_addr[8]
* net 386 router_in_data[21]
* net 387 msg_type[0]
* net 410 router_in_data[30]
* net 411 mem_wdata[5]
* net 412 mem_wdata[21]
* net 413 mem_addr[5]
* net 414 dest_id[6]
* net 415 mem_wdata[1]
* net 416 mem_wdata[30]
* net 417 mem_addr[1]
* net 438 router_in_data[6]
* net 439 mem_wdata[23]
* net 440 router_in_data[1]
* net 441 msg_type[2]
* net 442 router_in_data[23]
* net 463 dest_id[4]
* net 464 router_in_data[25]
* net 465 mem_wdata[25]
* net 466 mem_wdata[2]
* net 467 dest_id[1]
* net 468 mem_addr[2]
* net 469 mem_addr[6]
* net 470 mem_wdata[6]
* net 471 router_in_data[28]
* net 489 mem_wdata[28]
* net 490 router_in_data[24]
* net 499 router_in_data[14]
* net 511 src_rst_n
* net 512 mem_wdata[22]
* net 513 dest_id[2]
* net 514 dest_id[0]
* net 515 mem_addr[19]
* net 516 dest_id[5]
* net 517 mem_wdata[29]
* net 518 mem_wdata[4]
* net 519 msg_type[1]
* net 520 mem_wdata[26]
* net 521 mem_wdata[19]
* net 522 src_clk
* net 523 mem_wdata[24]
* net 540 dst_clk
* net 621 mem_wdata[18]
* net 625 mem_wdata[14]
* net 633 mem_addr[14]
* net 658 mem_addr[11]
* net 670 mem_addr[10]
* net 677 mem_addr[0]
* net 681 router_in_data[13]
* net 684 mem_wdata[13]
* net 685 mem_wdata[12]
* net 686 router_in_data[18]
* net 688 mem_wdata[11]
* net 689 mem_addr[16]
* net 691 router_in_data[26]
* net 692 router_in_data[22]
* net 693 router_in_data[19]
* net 694 router_in_data[29]
* net 695 mem_addr[4]
* net 697 router_in_data[4]
* net 698 mem_wdata[31]
* net 699 dest_id[7]
* net 701 mem_addr[3]
* net 703 router_in_data[31]
* net 704 mem_wdata[3]
* net 706 router_in_data[2]
* net 708 router_in_data[3]
* net 710 mem_addr[12]
* net 713 mem_addr[13]
* net 714 mem_addr[18]
* net 715 router_in_data[12]
* net 716 mem_wdata[0]
* net 717 mem_wdata[16]
* net 718 mem_addr[15]
* net 719 router_in_data[0]
* net 720 router_in_data[11]
* net 722 mem_wdata[15]
* net 723 mem_wdata[10]
* net 725 mem_wdata[17]
* net 727 router_in_data[10]
* net 728 mem_addr[17]
* net 729 router_in_data[17]
* net 730 router_in_data[7]
* net 731 router_in_data[5]
* net 732 router_in_data[16]
* net 733 PWELL,gf180mcu_gnd
* net 734 NWELL
* cell instance $2 r0 *1 963.2,5.04
X$2 733 1 52 734 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $7 m0 *1 949.76,15.12
X$7 36 734 733 2 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10 r0 *1 954.8,5.04
X$10 47 734 733 3 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15 m0 *1 958.16,15.12
X$15 4 734 733 48 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $19 m0 *1 983.36,15.12
X$19 733 5 213 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $22 r0 *1 999.04,5.04
X$22 733 6 37 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $26 m0 *1 966.56,15.12
X$26 7 734 733 49 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $31 m0 *1 974.96,15.12
X$31 51 734 733 8 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $34 r0 *1 998.48,25.2
X$34 93 734 733 9 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $38 r0 *1 995.68,15.12
X$38 10 734 733 94 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $42 r0 *1 1007.44,25.2
X$42 733 734 11 117 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $46 m0 *1 1001.84,25.2
X$46 108 734 733 12 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50 m0 *1 1007.44,35.28
X$50 110 734 733 13 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55 m0 *1 1000.16,15.12
X$55 14 734 733 83 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $59 r0 *1 1017.52,5.04
X$59 38 734 733 15 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $62 r0 *1 1025.92,5.04
X$62 16 734 733 39 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66 r0 *1 1034.32,5.04
X$66 57 734 733 17 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $70 m0 *1 1046.08,15.12
X$70 18 734 733 60 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $74 r0 *1 1042.72,5.04
X$74 59 734 733 19 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $78 r0 *1 1051.12,5.04
X$78 20 734 733 40 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $83 r0 *1 1059.52,5.04
X$83 41 734 733 21 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $86 r0 *1 1067.92,5.04
X$86 22 734 733 99 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $91 r0 *1 1076.32,5.04
X$91 23 734 733 62 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $95 r0 *1 1084.72,5.04
X$95 65 734 733 24 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99 r0 *1 1088.08,15.12
X$99 102 734 733 25 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $103 r0 *1 1099.84,5.04
X$103 26 734 733 67 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $106 r0 *1 1109.92,5.04
X$106 68 734 733 27 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $111 r0 *1 1119.44,5.04
X$111 28 734 733 42 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $115 r0 *1 1128.96,5.04
X$115 71 734 733 29 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $118 r0 *1 1138.48,5.04
X$118 30 734 733 43 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $122 r0 *1 1148.56,5.04
X$122 46 734 733 31 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $126 r0 *1 1157.52,5.04
X$126 32 734 733 44 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $131 r0 *1 1167.6,5.04
X$131 80 734 733 33 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $135 r0 *1 1181.04,5.04
X$135 34 734 733 45 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $138 r0 *1 1198.4,5.04
X$138 81 734 733 35 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $142 r0 *1 945.28,972.72
X$142 733 64 36 77 146 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $144 m0 *1 949.76,972.72
X$144 733 734 146 136 55 36 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $157 m0 *1 1000.72,1033.2
X$157 733 215 734 214 243 37 169 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $161 m0 *1 1000.72,1023.12
X$161 733 734 216 37 213 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $163 m0 *1 992.32,1033.2
X$163 733 37 213 734 246 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $166 r0 *1 992.32,1033.2
X$166 733 37 269 734 270 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $170 m0 *1 1016.96,15.12
X$170 733 734 85 54 55 38 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $172 m0 *1 1010.24,25.2
X$172 733 64 38 77 85 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $177 m0 *1 1028.16,15.12
X$177 733 734 56 39 53 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $180 m0 *1 1054.48,15.12
X$180 733 734 61 40 63 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $183 m0 *1 1055.6,25.2
X$183 733 734 96 97 101 41 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $186 r0 *1 1055.6,25.2
X$186 733 64 41 77 96 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $191 m0 *1 1120,15.12
X$191 733 734 86 42 74 70 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $195 m0 *1 1138.48,15.12
X$195 733 734 73 43 74 75 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $200 m0 *1 1155.28,15.12
X$200 733 734 76 44 74 79 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $205 m0 *1 1180.48,25.2
X$205 733 734 103 45 74 104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $208 m0 *1 1146.88,15.12
X$208 733 734 82 75 72 46 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $210 r0 *1 1134.56,15.12
X$210 733 64 46 77 82 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $215 m0 *1 945.28,982.8
X$215 733 64 47 77 137 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $218 m0 *1 950.32,992.88
X$218 733 734 137 149 55 47 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $229 m0 *1 962.08,25.2
X$229 733 734 88 48 53 90 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $231 m0 *1 974.4,35.28
X$231 733 734 91 49 53 92 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $236 m0 *1 2130.8,982.8
X$236 733 52 141 50 139 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $239 r0 *1 47.6,1154.16
X$239 733 52 474 50 475 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $241 m0 *1 43.68,1174.32
X$241 733 52 495 50 507 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $243 r0 *1 955.36,15.12
X$243 733 52 90 50 88 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $245 r0 *1 1076.88,1033.2
X$245 733 52 249 50 274 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $247 m0 *1 2129.12,1013.04
X$247 733 52 177 50 175 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $249 r0 *1 2103.36,982.8
X$249 733 52 151 50 164 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $251 m0 *1 1199.52,2152.08
X$251 733 52 664 50 663 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $253 m0 *1 1067.36,1053.36
X$253 733 52 294 50 293 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $256 r0 *1 11.76,1164.24
X$256 733 52 529 50 492 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $259 m0 *1 1114.4,2131.92
X$259 733 52 603 50 602 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $261 r0 *1 1066.24,15.12
X$261 733 52 100 50 98 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $263 r0 *1 992.32,35.28
X$263 733 52 111 50 116 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $265 m0 *1 1115.52,2152.08
X$265 733 52 655 50 679 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $267 m0 *1 1125.6,1023.12
X$267 733 52 222 50 228 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $269 m0 *1 24.64,1103.76
X$269 733 52 369 50 367 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $271 m0 *1 932.4,1002.96
X$271 733 52 149 50 166 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $274 r0 *1 1197.28,1648.08
X$274 733 52 373 50 575 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $276 r0 *1 1056.72,1033.2
X$276 733 52 274 50 273 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $278 m0 *1 11.2,1093.68
X$278 733 52 348 50 359 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $281 m0 *1 1090.32,1013.04
X$281 733 52 202 50 242 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $283 r0 *1 1004.08,15.12
X$283 733 52 54 50 84 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $285 r0 *1 1064,1023.12
X$285 733 52 240 50 241 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $288 r0 *1 954.24,1053.36
X$288 733 52 308 50 324 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $290 m0 *1 1111.6,25.2
X$290 733 52 70 50 86 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $293 m0 *1 2133.04,962.64
X$293 733 52 127 50 125 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $295 r0 *1 27.44,1134
X$295 733 52 422 50 420 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $297 m0 *1 1130.08,2101.68
X$297 733 52 580 50 588 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $300 m0 *1 1160.88,2101.68
X$300 733 52 584 50 583 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $302 m0 *1 1020.88,1204.56
X$302 733 52 551 50 550 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $305 r0 *1 974.4,15.12
X$305 733 52 92 50 91 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $307 m0 *1 1081.92,1023.12
X$307 733 52 209 50 220 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $309 m0 *1 48.72,1144.08
X$309 733 52 447 50 434 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $312 r0 *1 55.44,1103.76
X$312 733 52 372 50 370 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $314 m0 *1 45.36,1093.68
X$314 733 52 350 50 360 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $316 r0 *1 1122.24,1013.04
X$316 733 52 207 50 254 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $319 r0 *1 1039.36,45.36
X$319 733 52 118 50 119 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $321 m0 *1 1092.56,25.2
X$321 733 52 69 50 66 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $324 m0 *1 2099.44,1013.04
X$324 733 52 173 50 172 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $326 m0 *1 1121.12,1083.6
X$326 733 52 312 50 330 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $328 r0 *1 1047.2,15.12
X$328 733 52 97 50 61 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $330 r0 *1 1023.12,15.12
X$330 733 52 58 50 56 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $332 r0 *1 917.28,972.72
X$332 733 52 124 50 122 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $334 m0 *1 1147.44,2152.08
X$334 733 52 661 50 673 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $336 r0 *1 931.28,982.8
X$336 733 52 136 50 148 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $338 m0 *1 105.28,1184.4
X$338 733 52 498 50 497 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $340 m0 *1 67.2,1224.72
X$340 733 52 565 50 564 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $342 m0 *1 2110.64,1073.52
X$342 733 52 314 50 341 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $345 r0 *1 1197.28,2071.44
X$345 733 52 481 50 577 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $347 r0 *1 2096.64,1053.36
X$347 733 52 295 50 303 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $350 r0 *1 67.76,1224.72
X$350 733 52 571 50 568 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $352 r0 *1 278.88,1164.24
X$352 733 52 480 50 479 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $355 m0 *1 2124.64,1083.6
X$355 733 52 333 50 331 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $357 m0 *1 1151.92,25.2
X$357 733 52 79 50 76 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $360 m0 *1 1051.12,1063.44
X$360 733 52 293 50 292 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $362 m0 *1 1038.24,2152.08
X$362 733 52 647 50 646 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $364 r0 *1 1106,1043.28
X$364 733 253 50 250 52 734 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $366 m0 *1 1206.8,2142
X$366 733 52 631 50 632 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $368 r0 *1 1176,15.12
X$368 733 52 104 50 103 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $370 m0 *1 1132.88,25.2
X$370 733 52 75 50 73 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $373 r0 *1 2120.72,1083.6
X$373 733 52 352 50 361 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $375 m0 *1 1069.6,2152.08
X$375 733 52 651 50 676 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $377 r0 *1 1155.28,1023.12
X$377 733 52 255 50 237 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $380 m0 *1 2132.48,1103.76
X$380 733 52 356 50 351 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $382 r0 *1 22.4,1214.64
X$382 733 52 530 50 567 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $385 m0 *1 1075.76,2131.92
X$385 733 52 601 50 600 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $388 m0 *1 40.88,1234.8
X$388 733 52 570 50 569 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $391 r0 *1 2.24,1204.56
X$391 733 540 50 734 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $394 m0 *1 108.64,1154.16
X$394 733 52 451 50 450 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $396 r0 *1 1155.28,2121.84
X$396 733 52 609 50 614 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $398 r0 *1 1067.36,35.28
X$398 733 52 114 50 113 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $400 m0 *1 2131.92,992.88
X$400 733 52 155 50 161 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $402 r0 *1 2127.44,1053.36
X$402 733 52 297 50 300 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $404 m0 *1 2127.44,1053.36
X$404 733 52 283 50 302 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $406 r0 *1 17.92,1144.08
X$406 733 52 446 50 456 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $412 r0 *1 2131.36,1023.12
X$412 733 52 230 50 236 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $416 r0 *1 1078.56,1053.36
X$416 733 52 305 50 294 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $418 r0 *1 1045.52,1002.96
X$418 733 52 190 50 189 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $420 r0 *1 1043.28,1023.12
X$420 733 52 241 50 215 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $427 m0 *1 2100.56,1043.28
X$427 733 52 281 50 280 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $511 r0 *1 969.92,25.2
X$511 733 64 51 77 89 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $514 m0 *1 970.48,25.2
X$514 733 734 89 90 55 51 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $710 m0 *1 934.64,982.8
X$710 733 734 148 145 53 136 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $712 r0 *1 1076.32,650.16
X$712 733 63 53 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $715 r0 *1 935.2,1002.96
X$715 733 734 166 187 53 149 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $717 m0 *1 999.04,35.28
X$717 733 734 116 94 53 111 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $719 m0 *1 1101.52,1023.12
X$719 200 733 224 53 734 242 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $721 r0 *1 921.76,962.64
X$721 733 734 122 132 53 124 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $723 m0 *1 1065.68,1002.96
X$723 733 53 191 734 189 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $728 m0 *1 1008.56,15.12
X$728 733 734 84 83 53 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $750 r0 *1 988.96,25.2
X$750 733 734 115 92 55 93 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $752 r0 *1 980.56,992.88
X$752 733 64 150 77 55 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $754 m0 *1 1038.8,55.44
X$754 733 734 112 118 55 59 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $756 m0 *1 1038.8,25.2
X$756 733 734 95 58 55 57 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $759 r0 *1 930.16,962.64
X$759 733 734 123 124 55 135 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $765 m0 *1 1005.76,45.36
X$765 733 734 109 111 55 110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $770 m0 *1 1033.2,619.92
X$770 733 101 55 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $786 r0 *1 1034.32,25.2
X$786 733 64 57 77 95 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $796 m0 *1 1036.56,45.36
X$796 733 64 59 77 112 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $801 m0 *1 1047.2,55.44
X$801 733 734 119 60 121 118 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $807 m0 *1 1073.52,35.28
X$807 733 734 113 62 63 114 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $809 r0 *1 1107.12,992.88
X$809 733 208 63 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $813 m0 *1 1116.08,992.88
X$813 733 63 74 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $815 r0 *1 1069.6,992.88
X$815 733 63 121 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $819 m0 *1 1098.72,15.12
X$819 733 734 66 67 63 69 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $821 m0 *1 1070.16,25.2
X$821 733 734 98 99 63 100 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $830 m0 *1 963.2,1083.6
X$830 733 64 327 77 343 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $833 m0 *1 2.24,1184.4
X$833 733 511 64 734 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $838 r0 *1 1013.6,1002.96
X$838 733 169 77 171 64 734 gf180mcu_fd_sc_mcu9t5v0__dffsnq_4
* cell instance $840 m0 *1 921.76,972.72
X$840 733 64 135 77 123 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $843 r0 *1 75.04,1194.48
X$843 733 64 549 77 558 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $845 m0 *1 999.04,992.88
X$845 733 64 108 77 165 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $847 m0 *1 1056.72,2131.92
X$847 733 64 599 77 639 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $849 r0 *1 1114.4,25.2
X$849 733 64 71 77 106 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $851 r0 *1 973.28,1053.36
X$851 733 64 289 77 288 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $854 r0 *1 1004.64,45.36
X$854 733 64 110 77 109 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $857 r0 *1 1038.8,1013.04
X$857 733 64 199 77 210 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $860 r0 *1 1156.4,15.12
X$860 733 64 80 77 78 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $864 r0 *1 1037.68,1033.2
X$864 733 64 273 77 272 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $866 r0 *1 1100.4,15.12
X$866 733 64 68 77 87 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $868 r0 *1 8.96,1083.6
X$868 733 64 347 77 346 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $870 r0 *1 1186.08,2131.92
X$870 733 64 630 77 628 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $872 m0 *1 1051.68,1013.04
X$872 733 64 210 77 190 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $874 m0 *1 2144.8,1063.44
X$874 733 64 260 77 296 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $879 m0 *1 978.88,25.2
X$879 733 64 93 77 115 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $881 r0 *1 15.12,1103.76
X$881 733 64 368 77 364 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $884 m0 *1 52.64,1113.84
X$884 733 64 371 77 407 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $887 r0 *1 1137.92,2142
X$887 733 64 622 77 623 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $892 r0 *1 2144.8,952.56
X$892 733 64 128 77 126 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $894 m0 *1 11.76,1134
X$894 733 64 421 77 404 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $896 r0 *1 2144.8,1103.76
X$896 733 64 357 77 378 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $898 m0 *1 26.88,1224.72
X$898 733 64 542 77 566 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $900 r0 *1 1181.04,2101.68
X$900 733 64 574 77 596 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $905 r0 *1 2105.04,1002.96
X$905 733 64 174 77 186 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $907 m0 *1 1073.52,45.36
X$907 733 64 102 77 120 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $912 r0 *1 1117.76,2111.76
X$912 733 64 579 77 598 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $915 r0 *1 2144.24,982.8
X$915 733 64 143 77 154 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $917 m0 *1 1028.72,2142
X$917 733 64 618 77 638 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $920 r0 *1 2143.68,972.72
X$920 733 64 144 77 140 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $922 m0 *1 6.16,1144.08
X$922 733 64 419 77 452 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $924 r0 *1 2140.88,1083.6
X$924 733 64 319 77 354 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $926 r0 *1 1052.24,2142
X$926 733 64 649 77 640 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $928 m0 *1 1178.24,2142
X$928 733 64 629 77 627 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $930 r0 *1 2144.8,1043.28
X$930 733 64 286 77 284 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $933 r0 *1 1155.28,2101.68
X$933 733 64 581 77 592 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $936 m0 *1 1178.24,15.12
X$936 733 64 81 77 105 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $938 r0 *1 49.28,1204.56
X$938 733 64 563 77 555 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $940 m0 *1 86.8,1174.32
X$940 733 64 496 77 509 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $942 r0 *1 1018.64,1013.04
X$942 733 64 198 77 195 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $944 r0 *1 1177.68,2091.6
X$944 733 64 578 77 585 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $946 r0 *1 1108.24,2142
X$946 733 64 654 77 707 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $949 m0 *1 86.8,1134
X$949 733 64 427 77 437 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $952 m0 *1 48.72,1204.56
X$952 733 64 548 77 556 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $955 r0 *1 81.76,1144.08
X$955 733 64 449 77 460 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $957 r0 *1 1100.4,2131.92
X$957 733 64 620 77 619 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $960 r0 *1 980.56,1023.12
X$960 733 64 215 77 212 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $962 m0 *1 4.48,1214.64
X$962 733 64 562 77 541 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $965 m0 *1 1147.44,2131.92
X$965 733 64 608 77 605 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $967 m0 *1 963.2,1053.36
X$967 733 64 288 77 308 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $970 r0 *1 2.24,1174.32
X$970 733 64 527 77 500 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $972 r0 *1 1039.92,1053.36
X$972 733 64 292 77 291 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $975 m0 *1 2144.24,1023.12
X$975 733 64 232 77 205 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $977 r0 *1 1026.48,1043.28
X$977 733 64 219 77 277 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $980 m0 *1 1067.92,15.12
X$980 733 64 65 77 107 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $982 m0 *1 2110.08,982.8
X$982 733 64 138 77 163 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $984 m0 *1 54.32,1134
X$984 733 64 425 77 433 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $989 r0 *1 2110.08,1033.2
X$989 733 64 256 77 268 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $992 r0 *1 2122.96,1063.44
X$992 733 64 317 77 313 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $997 m0 *1 1106,1073.52
X$997 733 64 311 77 325 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $999 r0 *1 2142.56,1013.04
X$999 733 64 180 77 179 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1001 r0 *1 2097.2,1043.28
X$1001 733 64 279 77 304 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1003 r0 *1 992.32,1053.36
X$1003 733 64 290 77 289 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1005 r0 *1 57.12,1164.24
X$1005 733 64 476 77 508 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1007 m0 *1 2144.8,1083.6
X$1007 733 64 318 77 334 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1009 m0 *1 24.64,1174.32
X$1009 733 64 494 77 504 734 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1095 m0 *1 1078.56,25.2
X$1095 733 734 107 100 101 65 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1101 m0 *1 1109.36,15.12
X$1101 733 734 87 69 72 68 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1114 r0 *1 1123.92,15.12
X$1114 733 734 106 70 72 71 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1120 m0 *1 2091.6,599.76
X$1120 733 101 72 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $1124 m0 *1 2149.84,982.8
X$1124 733 734 154 155 72 143 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1127 m0 *1 2148.72,952.56
X$1127 733 734 126 127 72 128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1131 m0 *1 1163.68,15.12
X$1131 733 734 78 79 72 80 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1133 m0 *1 2116.8,1002.96
X$1133 733 734 186 173 72 174 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1136 m0 *1 2147.6,972.72
X$1136 733 734 140 141 72 144 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1139 m0 *1 1188.88,25.2
X$1139 733 734 105 104 72 81 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1142 r0 *1 2122.4,982.8
X$1142 733 734 163 151 72 138 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1157 r0 *1 2139.76,962.64
X$1157 733 734 125 131 74 127 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1161 r0 *1 2135.84,982.8
X$1161 733 734 139 153 74 141 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1166 m0 *1 2112.32,992.88
X$1166 733 734 164 162 74 151 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1168 m0 *1 2108.4,1002.96
X$1168 733 734 172 185 74 173 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1170 m0 *1 2150.96,992.88
X$1170 733 734 161 156 74 155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1174 m0 *1 2139.76,1002.96
X$1174 733 734 175 184 74 177 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1205 r0 *1 2.24,1194.48
X$1205 733 522 77 734 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $1467 m0 *1 1032.08,1013.04
X$1467 199 198 197 733 734 101 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $1473 r0 *1 2098.88,1013.04
X$1473 733 101 206 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1476 r0 *1 1079.12,45.36
X$1476 733 734 120 114 101 102 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1509 r0 *1 1006.32,992.88
X$1509 733 734 108 170 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1555 r0 *1 999.04,1033.2
X$1555 733 734 244 270 196 117 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1581 r0 *1 2142.56,1093.68
X$1581 733 734 351 355 121 356 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1583 m0 *1 2116.8,1053.36
X$1583 733 734 303 301 121 295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1585 r0 *1 2117.36,1073.52
X$1585 733 734 341 315 121 314 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1587 m0 *1 2146.48,1053.36
X$1587 733 734 300 298 121 297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1589 m0 *1 2131.36,1093.68
X$1589 733 734 361 340 121 352 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1591 m0 *1 2139.76,1093.68
X$1591 733 734 331 353 121 333 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1595 m0 *1 2141.44,1033.2
X$1595 733 734 236 176 121 230 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1597 r0 *1 2116.24,1043.28
X$1597 733 734 280 258 121 281 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1599 r0 *1 2136.4,1043.28
X$1599 733 734 302 266 121 283 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1630 m0 *1 2156.56,962.64
X$1630 128 734 733 130 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1636 r0 *1 2156.56,962.64
X$1636 144 734 733 129 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1643 r0 *1 2148.16,962.64
X$1643 142 734 733 131 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1646 m0 *1 5.6,972.72
X$1646 733 734 134 132 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1651 m0 *1 18.48,972.72
X$1651 135 734 733 133 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1670 r0 *1 2125.2,992.88
X$1670 138 734 733 157 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1688 m0 *1 2156.56,972.72
X$1688 143 734 733 158 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1700 m0 *1 3.36,992.88
X$1700 733 734 147 145 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1719 r0 *1 1000.16,1013.04
X$1719 733 150 734 211 216 169 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1722 r0 *1 1000.72,1002.96
X$1722 733 150 169 734 168 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1733 r0 *1 2133.6,992.88
X$1733 152 734 733 185 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1737 r0 *1 2142,992.88
X$1737 160 734 733 153 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1751 r0 *1 2150.4,992.88
X$1751 159 734 733 156 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1766 m0 *1 2131.36,1002.96
X$1766 181 734 733 162 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1780 m0 *1 1001.28,1002.96
X$1780 734 167 733 188 168 165 170 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1786 m0 *1 1025.36,1013.04
X$1786 733 734 198 167 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1789 r0 *1 1008.56,1013.04
X$1789 734 211 733 171 167 197 194 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1792 m0 *1 1015.28,1013.04
X$1792 734 167 733 193 194 195 196 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1797 m0 *1 1012.48,1002.96
X$1797 733 734 188 168 193 170 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1804 r0 *1 1016.4,1033.2
X$1804 733 734 169 247 246 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1807 r0 *1 1011.36,1033.2
X$1807 734 169 196 733 245 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1810 r0 *1 999.6,1023.12
X$1810 733 734 169 214 213 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1813 r0 *1 1005.2,1023.12
X$1813 733 734 169 217 216 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1845 r0 *1 2131.36,1002.96
X$1845 174 734 733 182 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1853 r0 *1 2139.76,1002.96
X$1853 183 734 733 176 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1856 r0 *1 2148.16,1002.96
X$1856 733 734 179 177 206 180 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1861 m0 *1 2148.16,1002.96
X$1861 178 734 733 184 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1867 r0 *1 2156.56,1002.96
X$1867 180 734 733 235 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $1892 m0 *1 11.2,1013.04
X$1892 733 734 192 187 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1909 r0 *1 1100.96,1023.12
X$1909 734 202 201 733 191 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1919 m0 *1 1019.76,1023.12
X$1919 733 734 193 218 215 199 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1922 r0 *1 1025.36,1023.12
X$1922 733 219 734 271 194 198 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1924 r0 *1 1028.72,1033.2
X$1924 733 734 219 248 194 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1927 m0 *1 1006.32,1053.36
X$1927 734 290 289 733 194 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1939 m0 *1 1016.96,1033.2
X$1939 733 734 219 196 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1945 m0 *1 1028.72,1023.12
X$1945 733 734 215 197 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1950 m0 *1 1023.12,1033.2
X$1950 734 271 272 197 248 247 733 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1970 r0 *1 1099.84,1013.04
X$1970 734 202 221 733 200 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1973 r0 *1 1108.24,1013.04
X$1973 222 734 201 204 733 208 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1976 r0 *1 1104.88,1013.04
X$1976 733 734 209 201 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1981 m0 *1 1114.96,1023.12
X$1981 734 202 209 733 203 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1983 m0 *1 1110.48,1033.2
X$1983 733 734 202 251 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1992 r0 *1 1114.4,1013.04
X$1992 225 227 224 203 734 733 237 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1994 m0 *1 2157.12,1013.04
X$1994 733 734 234 204 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1996 r0 *1 1112.72,1023.12
X$1996 733 734 239 223 209 204 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2003 m0 *1 2148.72,1013.04
X$2003 733 734 205 230 206 232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2005 m0 *1 2151.52,1103.76
X$2005 733 734 378 356 206 357 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2007 m0 *1 2148.16,1093.68
X$2007 733 734 354 352 206 319 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2010 r0 *1 2146.48,1053.36
X$2010 733 734 296 297 206 260 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2012 r0 *1 2125.76,1073.52
X$2012 733 734 313 314 206 317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2014 m0 *1 2108.4,1053.36
X$2014 733 734 304 295 206 279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2017 m0 *1 2148.16,1043.28
X$2017 733 734 284 283 206 286 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2021 m0 *1 2119.6,1043.28
X$2021 733 734 268 281 206 256 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2023 r0 *1 2145.92,1073.52
X$2023 733 734 334 333 206 318 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2032 m0 *1 1120.56,1023.12
X$2032 734 207 226 733 227 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2035 r0 *1 1131.2,1023.12
X$2035 733 734 207 229 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2043 r0 *1 1088.64,1023.12
X$2043 733 734 220 240 225 209 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2047 m0 *1 1108.24,1023.12
X$2047 222 734 209 223 733 224 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2052 r0 *1 1114.4,1033.2
X$2052 733 734 252 209 222 253 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2054 m0 *1 1100.96,1033.2
X$2054 733 734 221 226 209 249 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2071 r0 *1 988.96,1033.2
X$2071 733 734 243 212 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2086 m0 *1 1013.6,1043.28
X$2086 215 734 219 218 733 276 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2097 r0 *1 1011.36,1053.36
X$2097 733 217 309 245 276 734 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $2100 m0 *1 1011.92,1063.44
X$2100 734 276 217 328 733 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $2105 r0 *1 1006.88,1043.28
X$2105 290 733 289 734 218 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2128 r0 *1 1104.32,1033.2
X$2128 734 251 733 221 223 250 275 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2130 m0 *1 1128.4,1033.2
X$2130 733 734 222 238 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2143 m0 *1 1115.52,1033.2
X$2143 734 253 223 733 225 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2145 m0 *1 1112.72,1043.28
X$2145 734 252 223 307 733 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $2152 m0 *1 1106,1043.28
X$2152 734 249 278 733 223 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2164 m0 *1 1121.12,1033.2
X$2164 733 225 227 734 254 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2172 r0 *1 1121.12,1023.12
X$2172 734 238 733 239 226 228 229 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2175 m0 *1 1172.08,1033.2
X$2175 733 734 255 226 267 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2196 r0 *1 1125.6,1033.2
X$2196 734 733 238 231 251 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $2198 m0 *1 2149.84,1033.2
X$2198 231 734 733 262 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2204 r0 *1 2156.56,1023.12
X$2204 232 734 733 233 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2248 r0 *1 972.72,1073.52
X$2248 733 734 343 327 309 244 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2253 r0 *1 1016.4,1043.28
X$2253 734 245 246 329 733 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $2262 m0 *1 1027.04,1043.28
X$2262 733 734 247 277 248 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2288 m0 *1 1122.24,1043.28
X$2288 733 734 253 275 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2300 m0 *1 2124.64,1033.2
X$2300 255 734 733 265 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2306 m0 *1 2131.36,1043.28
X$2306 256 734 733 263 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2311 m0 *1 2133.04,1033.2
X$2311 257 734 733 258 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2318 r0 *1 2148.16,1033.2
X$2318 259 734 733 266 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2324 r0 *1 2156.56,1033.2
X$2324 260 734 733 261 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2334 m0 *1 2108.96,1033.2
X$2334 733 734 264 267 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2351 m0 *1 3.36,1073.52
X$2351 733 734 306 269 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2386 m0 *1 1089.2,1053.36
X$2386 305 733 294 734 278 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2391 r0 *1 2128,1043.28
X$2391 279 734 733 287 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2403 m0 *1 2139.76,1043.28
X$2403 282 734 733 301 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2414 m0 *1 2156.56,1043.28
X$2414 285 734 733 298 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2418 r0 *1 2156.56,1053.36
X$2418 286 734 733 299 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2439 m0 *1 1041.6,1063.44
X$2439 734 292 309 733 291 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2501 r0 *1 65.52,1093.68
X$2501 733 307 349 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2503 m0 *1 1118.32,1638
X$2503 733 307 573 734 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $2506 m0 *1 957.6,1063.44
X$2506 308 733 307 734 324 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2509 r0 *1 627.76,1144.08
X$2509 733 307 448 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $2511 m0 *1 62.72,1103.76
X$2511 733 734 370 371 307 372 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2514 r0 *1 1122.8,1073.52
X$2514 733 734 330 311 307 312 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2527 m0 *1 968.24,1123.92
X$2527 733 309 391 734 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $2531 r0 *1 994.56,1134
X$2531 733 309 424 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $2533 r0 *1 1103.2,1073.52
X$2533 733 325 309 326 328 329 310 344 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2536 r0 *1 1101.52,1144.08
X$2536 733 309 462 734 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $2551 m0 *1 1102.64,1073.52
X$2551 733 734 311 310 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2562 m0 *1 2140.32,1073.52
X$2562 312 734 733 337 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2576 m0 *1 2129.68,1073.52
X$2576 316 734 733 315 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2583 m0 *1 2136.4,1063.44
X$2583 317 734 733 322 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2593 m0 *1 2156.56,1073.52
X$2593 318 734 733 321 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2600 r0 *1 2156.56,1063.44
X$2600 319 734 733 320 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2609 m0 *1 1125.6,1073.52
X$2609 733 734 323 326 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2612 m0 *1 2148.72,1073.52
X$2612 733 734 339 323 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2626 r0 *1 53.2,1083.6
X$2626 733 734 360 327 349 350 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2632 r0 *1 705.6,1123.92
X$2632 733 328 397 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $2635 r0 *1 63.28,1123.92
X$2635 733 734 328 392 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2639 r0 *1 1101.52,1134
X$2639 733 328 576 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $2647 m0 *1 497.84,1134
X$2647 733 329 377 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2650 m0 *1 770.56,1134
X$2650 733 329 398 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $2653 m0 *1 1109.92,1144.08
X$2653 733 329 461 734 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $2665 r0 *1 2136.4,1073.52
X$2665 332 734 733 353 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2676 r0 *1 2156.56,1073.52
X$2676 335 734 733 340 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2681 m0 *1 2156.56,1093.68
X$2681 336 734 733 355 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2686 r0 *1 2109.52,1073.52
X$2686 733 734 338 342 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2699 r0 *1 1135.68,1073.52
X$2699 733 734 342 344 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2712 r0 *1 21.84,1093.68
X$2712 350 734 733 345 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2715 m0 *1 6.16,1113.84
X$2715 733 346 391 402 392 377 375 376 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2718 r0 *1 7.84,1103.76
X$2718 733 734 347 375 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2720 r0 *1 13.44,1093.68
X$2720 733 734 359 347 349 348 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2728 r0 *1 2.24,1113.84
X$2728 348 734 733 362 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2736 m0 *1 27.44,1113.84
X$2736 733 734 367 368 349 369 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2738 r0 *1 69.44,1214.64
X$2738 733 734 564 548 349 565 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2741 r0 *1 42.56,1224.72
X$2741 733 734 569 542 349 570 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2744 m0 *1 19.6,1154.16
X$2744 733 734 456 419 349 446 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2746 r0 *1 59.36,1224.72
X$2746 733 734 568 563 349 571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2749 m0 *1 31.92,1214.64
X$2749 733 734 567 562 349 530 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2752 r0 *1 19.6,1184.4
X$2752 733 734 492 527 349 529 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2754 m0 *1 30.8,1134
X$2754 733 734 420 421 349 422 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2800 r0 *1 2156.56,1093.68
X$2800 357 734 733 358 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2819 m0 *1 15.12,1103.76
X$2819 372 734 733 363 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2822 r0 *1 22.4,1113.84
X$2822 733 364 391 379 392 377 366 400 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2827 m0 *1 20.16,1113.84
X$2827 733 734 365 379 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2829 r0 *1 10.64,1134
X$2829 412 734 733 365 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2832 m0 *1 24.08,1113.84
X$2832 733 734 368 366 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2842 r0 *1 14,1113.84
X$2842 369 734 733 386 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2851 r0 *1 49.84,1113.84
X$2851 733 734 371 396 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2865 m0 *1 1199.52,1648.08
X$2865 733 734 575 574 573 373 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2870 m0 *1 2142,1113.84
X$2870 373 734 733 374 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2882 m0 *1 2.8,1113.84
X$2882 733 734 388 376 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2887 r0 *1 2.24,1184.4
X$2887 733 541 391 525 392 377 524 526 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2889 m0 *1 14,1204.56
X$2889 733 566 391 561 392 377 553 552 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2891 m0 *1 2.24,1154.16
X$2891 733 452 391 454 392 377 443 444 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2894 r0 *1 19.04,1123.92
X$2894 733 404 391 401 392 377 403 394 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2896 m0 *1 34.72,1204.56
X$2896 733 556 391 543 392 377 545 546 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2900 m0 *1 2.8,1174.32
X$2900 733 500 391 445 392 377 491 502 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2902 r0 *1 21.28,1174.32
X$2902 733 504 391 493 392 377 505 506 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2904 r0 *1 45.36,1194.48
X$2904 733 555 391 531 392 377 547 557 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $2931 m0 *1 31.92,1123.92
X$2931 380 734 733 395 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2934 r0 *1 2.24,1123.92
X$2934 381 734 733 399 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2937 m0 *1 3.36,1134
X$2937 382 734 733 389 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2940 m0 *1 5.6,1123.92
X$2940 383 734 733 390 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2943 r0 *1 2.24,1134
X$2943 384 734 733 388 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2946 r0 *1 19.04,1134
X$2946 385 734 733 428 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2951 r0 *1 2.24,1144.08
X$2951 387 734 733 453 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2958 r0 *1 10.64,1113.84
X$2958 733 734 389 402 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2961 m0 *1 73.36,1123.92
X$2961 733 734 390 408 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3019 m0 *1 28.56,1123.92
X$3019 733 734 393 394 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3021 m0 *1 2.24,1164.24
X$3021 417 734 733 393 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3029 m0 *1 80.08,1123.92
X$3029 733 734 395 409 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3034 r0 *1 53.2,1113.84
X$3034 733 407 424 405 397 398 396 406 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3037 m0 *1 79.52,1144.08
X$3037 733 460 424 436 397 398 435 459 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3039 r0 *1 85.12,1123.92
X$3039 733 437 424 408 397 398 426 409 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3041 r0 *1 53.2,1134
X$3041 733 433 424 430 397 398 423 432 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3044 r0 *1 1062.88,2131.92
X$3044 733 639 424 650 397 398 617 652 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3046 m0 *1 62.72,1174.32
X$3046 733 508 424 486 397 398 477 478 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3049 m0 *1 69.44,1194.48
X$3049 733 558 424 538 397 398 534 539 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3051 m0 *1 1061.76,2142
X$3051 733 640 424 674 397 398 648 675 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3053 r0 *1 81.76,1164.24
X$3053 733 509 424 487 397 398 510 488 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3055 r0 *1 1030.4,2131.92
X$3055 733 638 424 616 397 398 637 672 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3097 m0 *1 47.04,1123.92
X$3097 733 734 399 405 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3102 m0 *1 14,1123.92
X$3102 733 734 453 400 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3109 r0 *1 10.64,1123.92
X$3109 733 734 418 401 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3116 r0 *1 33.04,1123.92
X$3116 733 734 421 403 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3127 r0 *1 58.8,1123.92
X$3127 733 734 428 406 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3142 r0 *1 45.36,1144.08
X$3142 447 734 733 410 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3145 m0 *1 29.12,1154.16
X$3145 411 734 733 457 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3150 r0 *1 3.36,1164.24
X$3150 413 734 733 458 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3153 r0 *1 35.84,1154.16
X$3153 414 734 733 431 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3156 r0 *1 2.24,1154.16
X$3156 415 734 733 418 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3159 m0 *1 33.6,1144.08
X$3159 416 734 733 429 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3168 m0 *1 2.8,1144.08
X$3168 733 734 419 443 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3183 r0 *1 27.44,1154.16
X$3183 422 734 733 440 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3190 m0 *1 50.96,1134
X$3190 733 734 425 423 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3220 m0 *1 67.76,1144.08
X$3220 733 734 434 425 448 447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3224 r0 *1 86.8,1134
X$3224 733 734 427 426 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3228 r0 *1 110.32,1144.08
X$3228 733 734 450 427 448 451 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3237 r0 *1 46.48,1134
X$3237 733 734 429 430 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3246 r0 *1 49.84,1134
X$3246 733 734 431 432 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3263 m0 *1 96.32,1144.08
X$3263 733 734 449 435 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3267 r0 *1 76.16,1134
X$3267 733 734 457 436 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3273 m0 *1 27.44,1164.24
X$3273 474 734 733 438 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3276 r0 *1 10.64,1154.16
X$3276 439 734 733 482 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3281 m0 *1 25.2,1144.08
X$3281 441 734 733 455 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3284 r0 *1 19.04,1154.16
X$3284 446 734 733 442 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3291 r0 *1 14.56,1144.08
X$3291 733 734 455 444 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3295 m0 *1 16.24,1154.16
X$3295 733 734 472 445 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3311 m0 *1 52.08,1164.24
X$3311 733 734 475 476 448 474 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3313 r0 *1 1076.88,2121.84
X$3313 733 734 600 599 448 601 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3316 r0 *1 1042.72,2142
X$3316 733 734 646 618 448 647 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3318 m0 *1 282.8,1164.24
X$3318 733 734 479 449 448 480 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3321 r0 *1 1023.68,1204.56
X$3321 733 734 550 549 448 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3323 r0 *1 107.52,1174.32
X$3323 733 734 497 496 448 498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3325 r0 *1 1071.28,2142
X$3325 733 734 676 649 448 651 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3329 r0 *1 45.92,1174.32
X$3329 733 734 507 494 448 495 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3362 r0 *1 1100.4,2152.08
X$3362 451 734 733 730 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3373 r0 *1 11.2,1144.08
X$3373 733 734 482 454 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3387 m0 *1 76.16,1144.08
X$3387 733 734 458 459 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3400 m0 *1 1108.8,2142
X$3400 733 619 462 643 576 461 642 644 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3403 m0 *1 1130.64,2121.84
X$3403 733 598 462 615 576 461 590 604 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3407 m0 *1 1150.8,2111.76
X$3407 733 592 462 597 576 461 582 591 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3409 r0 *1 1151.36,2131.92
X$3409 733 605 462 636 576 461 606 635 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3411 r0 *1 1182.72,2142
X$3411 733 628 462 668 576 461 666 665 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3413 m0 *1 1179.92,2101.68
X$3413 733 585 462 586 576 461 589 587 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3415 m0 *1 1131.76,2142
X$3415 733 623 462 657 576 461 641 634 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3418 r0 *1 1109.92,2152.08
X$3418 733 707 462 705 576 461 653 711 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3420 m0 *1 1175.44,2152.08
X$3420 733 627 462 667 576 461 626 669 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3422 m0 *1 1175.44,2111.76
X$3422 733 596 462 595 576 461 593 594 734 gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $3458 r0 *1 36.96,1184.4
X$3458 463 734 733 535 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3463 m0 *1 2.24,1204.56
X$3463 529 734 733 464 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3466 m0 *1 10.64,1164.24
X$3466 465 734 733 472 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3469 m0 *1 19.04,1164.24
X$3469 466 734 733 473 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3472 r0 *1 28,1184.4
X$3472 467 734 733 503 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3475 m0 *1 35.84,1164.24
X$3475 468 734 733 485 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3478 r0 *1 39.2,1164.24
X$3478 469 734 733 484 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3481 r0 *1 30.8,1164.24
X$3481 470 734 733 483 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3484 r0 *1 47.6,1164.24
X$3484 495 734 733 471 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3489 m0 *1 67.2,1164.24
X$3489 733 734 473 487 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3502 m0 *1 60.48,1164.24
X$3502 733 734 476 477 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3513 m0 *1 71.68,1164.24
X$3513 733 734 484 478 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3526 m0 *1 1098.72,2162.16
X$3526 480 734 733 731 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3532 m0 *1 1198.4,2081.52
X$3532 733 734 577 578 573 481 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3534 m0 *1 2156.56,1174.32
X$3534 481 734 733 499 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3549 m0 *1 47.04,1164.24
X$3549 733 734 483 486 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3560 m0 *1 76.16,1164.24
X$3560 733 734 485 488 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3575 m0 *1 25.2,1194.48
X$3575 489 734 733 501 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3578 m0 *1 36.96,1184.4
X$3578 530 734 733 490 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3581 r0 *1 16.24,1184.4
X$3581 733 734 527 491 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3592 m0 *1 20.72,1174.32
X$3592 733 734 501 493 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3595 r0 *1 39.2,1174.32
X$3595 733 734 494 505 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3609 m0 *1 83.44,1174.32
X$3609 733 734 496 510 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3622 m0 *1 1107.12,2162.16
X$3622 498 734 733 706 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3640 m0 *1 17.36,1174.32
X$3640 733 734 503 502 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3653 r0 *1 35.28,1174.32
X$3653 733 734 535 506 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3670 m0 *1 45.36,1184.4
X$3670 512 734 733 532 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3673 m0 *1 23.52,1214.64
X$3673 513 734 733 544 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3678 r0 *1 2.24,1214.64
X$3678 514 734 733 559 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3681 r0 *1 2.24,1224.72
X$3681 515 734 733 560 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3684 r0 *1 54.88,1184.4
X$3684 516 734 733 533 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3687 m0 *1 18.48,1224.72
X$3687 517 734 733 537 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3690 m0 *1 2.24,1194.48
X$3690 733 518 613 734 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3693 m0 *1 33.6,1194.48
X$3693 519 734 733 536 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3696 r0 *1 10.64,1214.64
X$3696 520 734 733 554 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3699 m0 *1 16.8,1194.48
X$3699 521 734 733 528 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3704 m0 *1 5.04,1234.8
X$3704 523 734 733 572 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3708 m0 *1 13.44,1224.72
X$3708 733 734 562 524 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3713 r0 *1 10.64,1224.72
X$3713 733 734 572 525 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3718 m0 *1 10.08,1224.72
X$3718 733 734 559 526 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3726 r0 *1 19.04,1214.64
X$3726 733 734 528 561 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3738 m0 *1 50.4,1194.48
X$3738 733 734 532 531 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3743 r0 *1 63.28,1184.4
X$3743 733 734 533 539 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3746 r0 *1 71.68,1194.48
X$3746 733 734 549 534 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3752 m0 *1 45.36,1194.48
X$3752 733 734 536 557 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3757 r0 *1 45.36,1184.4
X$3757 733 734 537 538 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3774 m0 *1 28.56,1204.56
X$3774 733 734 542 553 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3781 r0 *1 36.96,1204.56
X$3781 733 734 554 543 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3783 r0 *1 42,1194.48
X$3783 733 734 544 546 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3790 r0 *1 42.56,1204.56
X$3790 733 734 548 545 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3796 m0 *1 47.04,1214.64
X$3796 733 734 563 547 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3816 m0 *1 1037.68,2162.16
X$3816 551 734 733 694 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3821 m0 *1 10.64,1204.56
X$3821 733 734 560 552 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3876 r0 *1 958.72,2152.08
X$3876 565 734 733 691 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3898 m0 *1 1007.44,2162.16
X$3898 570 734 733 693 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3916 m0 *1 959.28,2162.16
X$3916 571 734 733 692 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3924 r0 *1 1119.44,2131.92
X$3924 733 734 602 620 573 603 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3926 r0 *1 1200.64,2142
X$3926 733 734 663 630 573 664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3928 m0 *1 1161.44,2121.84
X$3928 733 734 614 608 573 609 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3930 r0 *1 1127.28,2142
X$3930 733 734 679 654 573 655 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3933 r0 *1 1137.36,2101.68
X$3933 733 734 588 579 573 580 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3935 m0 *1 1166.48,2152.08
X$3935 733 734 673 622 573 661 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3938 r0 *1 1163.68,2091.6
X$3938 733 734 583 581 573 584 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3940 m0 *1 1198.4,2142
X$3940 733 734 632 629 573 631 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3954 r0 *1 1177.68,2101.68
X$3954 733 734 574 593 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3989 m0 *1 1183.28,2091.6
X$3989 733 734 578 589 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3997 r0 *1 1127.84,2101.68
X$3997 733 734 579 590 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4006 r0 *1 1148.56,2152.08
X$4006 580 734 733 686 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4008 m0 *1 1156.4,2101.68
X$4008 733 734 581 582 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4019 r0 *1 1184.4,2152.08
X$4019 584 734 733 720 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4028 r0 *1 1181.04,2111.76
X$4028 733 734 610 586 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4031 m0 *1 1189.44,2111.76
X$4031 733 734 611 587 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4045 r0 *1 1154.72,2111.76
X$4045 733 734 624 591 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4053 m0 *1 1186.08,2121.84
X$4053 733 734 690 594 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4055 m0 *1 1191.12,2121.84
X$4055 733 734 612 595 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4062 r0 *1 1161.44,2111.76
X$4062 733 734 607 597 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4071 r0 *1 1072.4,2121.84
X$4071 733 734 599 617 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4081 m0 *1 1115.52,2162.16
X$4081 601 734 733 708 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4092 r0 *1 1135.68,2152.08
X$4092 603 734 733 715 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4096 m0 *1 1144.08,2131.92
X$4096 733 734 656 604 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4102 r0 *1 1151.92,2121.84
X$4102 733 734 608 606 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4105 r0 *1 1158.64,2152.08
X$4105 688 734 733 607 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4113 r0 *1 1175.44,2152.08
X$4113 609 734 733 732 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4119 r0 *1 1173.2,2131.92
X$4119 625 734 733 610 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4122 m0 *1 1181.04,2131.92
X$4122 633 734 733 611 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4125 r0 *1 1201.2,2152.08
X$4125 722 734 733 612 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4130 r0 *1 1018.64,2121.84
X$4130 733 734 613 616 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4139 m0 *1 1135.12,2131.92
X$4139 733 734 645 615 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4149 r0 *1 1044.4,2131.92
X$4149 733 734 618 637 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4157 m0 *1 1101.52,2142
X$4157 733 734 620 642 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4165 r0 *1 1128.96,2131.92
X$4165 621 734 733 645 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4169 r0 *1 1140.72,2131.92
X$4169 733 734 622 641 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4179 m0 *1 1146.88,2142
X$4179 658 734 733 624 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4185 m0 *1 1173.2,2142
X$4185 733 734 629 626 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4197 m0 *1 1190,2131.92
X$4197 733 734 630 666 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4205 m0 *1 1215.2,2162.16
X$4205 631 734 733 729 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4217 m0 *1 1163.12,2142
X$4217 733 734 659 634 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4222 m0 *1 1167.6,2142
X$4222 733 734 671 635 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4229 r0 *1 1165.36,2131.92
X$4229 733 734 660 636 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4254 m0 *1 1122.8,2142
X$4254 733 734 680 643 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4259 m0 *1 1126.16,2142
X$4259 733 734 709 644 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4271 m0 *1 1060.08,2162.16
X$4271 647 734 733 697 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4276 m0 *1 1062.88,2152.08
X$4276 733 734 649 648 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4286 m0 *1 1073.52,2162.16
X$4286 733 734 700 650 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4293 r0 *1 1082.48,2152.08
X$4293 651 734 733 703 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4298 r0 *1 1083.6,2142
X$4298 733 734 683 652 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4304 r0 *1 1103.76,2142
X$4304 733 734 654 653 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4313 m0 *1 1134.56,2152.08
X$4313 655 734 733 681 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4318 m0 *1 1142.4,2162.16
X$4318 714 734 733 656 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4321 r0 *1 1144.08,2152.08
X$4321 733 734 687 657 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4329 r0 *1 1159.76,2142
X$4329 677 734 733 659 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4332 m0 *1 1162.56,2162.16
X$4332 717 734 733 660 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4338 m0 *1 1170.96,2162.16
X$4338 661 734 733 719 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4340 r0 *1 1182.72,2131.92
X$4340 733 734 662 665 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4342 r0 *1 1174.32,2142
X$4342 670 734 733 662 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4347 r0 *1 1212.4,2152.08
X$4347 664 734 733 727 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4361 m0 *1 1189.44,2152.08
X$4361 733 734 721 667 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4366 r0 *1 1196.72,2142
X$4366 733 734 724 668 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4371 m0 *1 1191.12,2162.16
X$4371 733 734 726 669 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4380 r0 *1 1167.04,2152.08
X$4380 689 734 733 671 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4384 m0 *1 1048.32,2162.16
X$4384 733 734 696 672 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4394 m0 *1 1066.24,2152.08
X$4394 733 734 682 674 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4396 r0 *1 1079.68,2142
X$4396 733 734 702 675 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4406 m0 *1 1103.76,2152.08
X$4406 733 734 678 705 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4409 m0 *1 1090.32,2152.08
X$4409 684 734 733 678 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4417 r0 *1 1123.92,2152.08
X$4417 685 734 733 680 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4425 r0 *1 1065.68,2152.08
X$4425 698 734 733 682 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4428 m0 *1 1080.8,2162.16
X$4428 701 734 733 683 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4440 m0 *1 1154.16,2162.16
X$4440 716 734 733 687 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4451 m0 *1 1182.16,2162.16
X$4451 718 734 733 690 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $365977 m0 *1 1051.68,2162.16
X$365977 695 734 733 696 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $381054 r0 *1 1074.08,2152.08
X$381054 699 734 733 702 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $381058 m0 *1 1089.2,2162.16
X$381058 704 734 733 700 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $433825 m0 *1 1123.92,2162.16
X$433825 710 734 733 709 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $448895 r0 *1 1132.32,2152.08
X$448895 733 734 712 711 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $448901 m0 *1 1132.32,2162.16
X$448901 713 734 733 712 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $561885 r0 *1 1192.8,2152.08
X$561885 725 734 733 721 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $569441 m0 *1 1198.4,2162.16
X$569441 723 734 733 724 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $576966 m0 *1 1206.8,2162.16
X$576966 728 734 733 726 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS network_interface_cdc

* cell gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin SETN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffsnq_2 1 5 7 8 13 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 5 Q
* net 7 CLK
* net 8 D
* net 13 SETN
* net 17 NWELL,VDD
* device instance $1 r0 *1 18.73,3.78 pmos_5p0
M$1 5 4 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 14.48,3.365 pmos_5p0
M$3 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 15.5,3.365 pmos_5p0
M$4 17 4 12 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.536P PS=1.52U PD=2.57U
* device instance $5 r0 *1 16.74,3.78 pmos_5p0
M$5 4 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.536P AD=0.8052P PS=2.57U PD=4.54U
* device instance $6 r0 *1 0.97,3.555 pmos_5p0
M$6 17 7 6 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $7 r0 *1 1.99,3.555 pmos_5p0
M$7 2 6 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $8 r0 *1 11.4,3.365 pmos_5p0
M$8 3 6 11 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.42P PS=2.88U PD=1.84U
* device instance $9 r0 *1 12.74,3.365 pmos_5p0
M$9 12 2 3 17 pmos_5p0 L=0.5U W=1U AS=0.42P AD=0.44P PS=1.84U PD=2.88U
* device instance $10 r0 *1 3.93,3.465 pmos_5p0
M$10 9 8 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.3825P PS=2.88U PD=1.765U
* device instance $11 r0 *1 5.195,3.465 pmos_5p0
M$11 10 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.3825P AD=0.26P PS=1.765U PD=1.52U
* device instance $12 r0 *1 6.215,3.465 pmos_5p0
M$12 18 6 10 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.1825P PS=1.52U PD=1.365U
* device instance $13 r0 *1 7.08,3.465 pmos_5p0
M$13 17 11 18 17 pmos_5p0 L=0.5U W=1U AS=0.1825P AD=0.3P PS=1.365U PD=1.6U
* device instance $14 r0 *1 8.18,3.465 pmos_5p0
M$14 11 10 17 17 pmos_5p0 L=0.5U W=1U AS=0.3P AD=0.29P PS=1.6U PD=1.58U
* device instance $15 r0 *1 9.26,3.465 pmos_5p0
M$15 17 13 11 17 pmos_5p0 L=0.5U W=1U AS=0.29P AD=0.7374P PS=1.58U PD=3.75U
* device instance $16 r0 *1 18.68,1.005 nmos_5p0
M$16 5 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $18 r0 *1 3.88,1.265 nmos_5p0
M$18 9 8 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $19 r0 *1 5,1.265 nmos_5p0
M$19 10 6 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1711P PS=1.11U PD=1.17U
* device instance $20 r0 *1 6.18,1.265 nmos_5p0
M$20 14 2 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.1711P AD=0.07375P PS=1.17U PD=0.84U
* device instance $21 r0 *1 7.03,1.265 nmos_5p0
M$21 1 11 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.07375P AD=0.22355P PS=0.84U
+ PD=1.435U
* device instance $22 r0 *1 8.37,1.37 nmos_5p0
M$22 15 10 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.22355P AD=0.0708P PS=1.435U PD=0.83U
* device instance $23 r0 *1 9.21,1.37 nmos_5p0
M$23 11 13 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.1534P PS=0.83U PD=1.11U
* device instance $24 r0 *1 10.33,1.37 nmos_5p0
M$24 3 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $25 r0 *1 11.45,1.37 nmos_5p0
M$25 12 6 3 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.2596P PS=1.11U PD=2.06U
* device instance $26 r0 *1 0.92,1.27 nmos_5p0
M$26 1 7 6 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $27 r0 *1 2.04,1.27 nmos_5p0
M$27 2 6 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $28 r0 *1 14.61,1.37 nmos_5p0
M$28 16 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.0708P PS=2.06U PD=0.83U
* device instance $29 r0 *1 15.45,1.37 nmos_5p0
M$29 16 4 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3789P AD=0.0708P PS=2.06U PD=0.83U
* device instance $30 r0 *1 16.79,1.005 nmos_5p0
M$30 4 3 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3789P AD=0.5808P PS=2.06U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_4 1 2 3 4 5
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 ZN
* net 5 A1
* device instance $1 r0 *1 0.87,3.687 pmos_5p0
M$1 4 3 1 1 pmos_5p0 L=0.5U W=6.58U AS=2.0069P AD=2.0069P PS=10.665U PD=10.665U
* device instance $2 r0 *1 1.89,3.687 pmos_5p0
M$2 1 5 4 1 pmos_5p0 L=0.5U W=6.58U AS=1.7108P AD=1.7108P PS=8.66U PD=8.66U
* device instance $9 r0 *1 1,1.005 nmos_5p0
M$9 9 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 5 9 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3729P PS=1.56U PD=1.885U
* device instance $11 r0 *1 3.005,1.005 nmos_5p0
M$11 8 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3729P AD=0.1584P PS=1.885U PD=1.56U
* device instance $12 r0 *1 3.845,1.005 nmos_5p0
M$12 2 3 8 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3663P PS=1.56U PD=1.875U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 7 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.2112P PS=1.875U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 4 5 7 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 6 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 2 3 6 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_4

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_2
* pin NWELL,VDD
* pin A2
* pin ZN
* pin A1
* pin B
* pin C
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 A2
* net 3 ZN
* net 4 A1
* net 5 B
* net 6 C
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $5 r0 *1 5.43,3.965 pmos_5p0
M$5 3 5 1 1 pmos_5p0 L=0.5U W=2.92U AS=0.9646P AD=1.022P PS=4.51U PD=5.78U
* device instance $6 r0 *1 6.45,3.965 pmos_5p0
M$6 1 6 3 1 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7062P PS=5.36U PD=3.71U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 7 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.43,1.005 nmos_5p0
M$13 11 5 8 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $14 r0 *1 6.4,1.005 nmos_5p0
M$14 7 6 11 7 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $15 r0 *1 7.52,1.005 nmos_5p0
M$15 12 6 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 8.44,1.005 nmos_5p0
M$16 8 5 12 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffsnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin SETN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffsnq_4 1 10 11 12 13 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 10 Q
* net 11 CLK
* net 12 D
* net 13 SETN
* net 17 NWELL,VDD
* device instance $1 r0 *1 14.415,3.365 pmos_5p0
M$1 8 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $2 r0 *1 15.435,3.365 pmos_5p0
M$2 17 9 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.536P PS=1.52U PD=2.57U
* device instance $3 r0 *1 16.675,3.78 pmos_5p0
M$3 9 2 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.0118P AD=0.9516P PS=4.92U PD=4.7U
* device instance $5 r0 *1 18.715,3.78 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=2.2326P PS=9.4U PD=11.59U
* device instance $9 r0 *1 11.335,3.365 pmos_5p0
M$9 2 3 7 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.42P PS=2.88U PD=1.84U
* device instance $10 r0 *1 12.675,3.365 pmos_5p0
M$10 8 4 2 17 pmos_5p0 L=0.5U W=1U AS=0.42P AD=0.44P PS=1.84U PD=2.88U
* device instance $11 r0 *1 0.97,3.555 pmos_5p0
M$11 17 11 3 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $12 r0 *1 1.99,3.555 pmos_5p0
M$12 4 3 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $13 r0 *1 3.93,3.465 pmos_5p0
M$13 5 12 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.3825P PS=2.88U PD=1.765U
* device instance $14 r0 *1 5.195,3.465 pmos_5p0
M$14 6 4 5 17 pmos_5p0 L=0.5U W=1U AS=0.3825P AD=0.26P PS=1.765U PD=1.52U
* device instance $15 r0 *1 6.215,3.465 pmos_5p0
M$15 18 3 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2P PS=1.52U PD=1.4U
* device instance $16 r0 *1 7.115,3.465 pmos_5p0
M$16 17 7 18 17 pmos_5p0 L=0.5U W=1U AS=0.2P AD=0.26P PS=1.4U PD=1.52U
* device instance $17 r0 *1 8.135,3.465 pmos_5p0
M$17 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $18 r0 *1 9.155,3.465 pmos_5p0
M$18 17 13 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.7374P PS=1.52U PD=3.75U
* device instance $19 r0 *1 14.545,1.37 nmos_5p0
M$19 16 13 8 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.0708P PS=2.06U PD=0.83U
* device instance $20 r0 *1 15.385,1.37 nmos_5p0
M$20 16 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3789P AD=0.0708P PS=2.06U PD=0.83U
* device instance $21 r0 *1 16.725,1.005 nmos_5p0
M$21 9 2 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7221P AD=0.6864P PS=3.9U PD=3.68U
* device instance $23 r0 *1 18.965,1.005 nmos_5p0
M$23 10 9 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
* device instance $27 r0 *1 0.92,1.27 nmos_5p0
M$27 1 11 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $28 r0 *1 2.04,1.27 nmos_5p0
M$28 4 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $29 r0 *1 3.88,1.37 nmos_5p0
M$29 5 12 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $30 r0 *1 5,1.37 nmos_5p0
M$30 6 3 5 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 6.12,1.37 nmos_5p0
M$31 14 4 6 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.101775P PS=1.11U PD=0.935U
* device instance $32 r0 *1 7.065,1.37 nmos_5p0
M$32 1 7 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.101775P AD=0.1534P PS=0.935U PD=1.11U
* device instance $33 r0 *1 8.185,1.37 nmos_5p0
M$33 15 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0944P PS=1.11U PD=0.91U
* device instance $34 r0 *1 9.105,1.37 nmos_5p0
M$34 7 13 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0944P AD=0.1652P PS=0.91U PD=1.15U
* device instance $35 r0 *1 10.265,1.37 nmos_5p0
M$35 2 4 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1652P AD=0.1534P PS=1.15U PD=1.11U
* device instance $36 r0 *1 11.385,1.37 nmos_5p0
M$36 8 3 2 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.2596P PS=1.11U PD=2.06U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffsnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 4 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 10 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 5 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 9 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 4 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 11 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 5 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6292P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.872 pmos_5p0
M$9 4 2 7 7 pmos_5p0 L=0.5U W=6.58U AS=2.117925P AD=2.212525P PS=9.295U
+ PD=10.915U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 4 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 3 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $21 r0 *1 9.88,1.005 nmos_5p0
M$21 1 2 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_4

* cell gf180mcu_fd_sc_mcu9t5v0__and2_4
* pin NWELL,VDD
* pin A2
* pin A1
* pin Z
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_4 1 2 3 5 6
* net 1 NWELL,VDD
* net 2 A2
* net 3 A1
* net 5 Z
* net 6 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.875 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.28U AS=1.3336P AD=0.8528P PS=6.69U PD=4.32U
* device instance $2 r0 *1 1.89,3.875 pmos_5p0
M$2 1 3 4 1 pmos_5p0 L=0.5U W=3.28U AS=0.8528P AD=0.8528P PS=4.32U PD=4.32U
* device instance $5 r0 *1 5.13,3.78 pmos_5p0
M$5 5 4 1 1 pmos_5p0 L=0.5U W=7.32U AS=2.0394P AD=2.2326P PS=9.58U PD=11.59U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 8 2 6 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 3 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 7 3 4 6 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 6 2 7 6 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 5 4 6 6 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_4

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_2
* pin NWELL,VDD
* pin B2
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B2
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.4758P PS=4.54U PD=2.35U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 6 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $5 r0 *1 5.45,3.78 pmos_5p0
M$5 11 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 6 7 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 10 7 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 6 5 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $14 r0 *1 6.52,1.005 nmos_5p0
M$14 8 7 6 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_2 1 5 6 7 8
* net 1 NWELL,VDD
* net 5 A1
* net 6 A2
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 ZN
* device instance $1 r0 *1 0.97,3.327 pmos_5p0
M$1 9 6 2 1 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.260775P PS=2.71U PD=1.485U
* device instance $2 r0 *1 2.04,3.327 pmos_5p0
M$2 1 5 9 1 pmos_5p0 L=0.5U W=0.915U AS=0.260775P AD=0.571875P PS=1.485U
+ PD=2.68U
* device instance $3 r0 *1 3.39,3.785 pmos_5p0
M$3 4 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.4758P PS=2.68U PD=2.35U
* device instance $4 r0 *1 4.41,3.785 pmos_5p0
M$4 3 5 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.4758P PS=2.35U PD=2.35U
* device instance $5 r0 *1 5.43,3.785 pmos_5p0
M$5 4 6 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.17,3.78 pmos_5p0
M$6 8 3 1 1 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 3 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,0.675 nmos_5p0
M$10 2 6 7 7 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $11 r0 *1 2.04,0.675 nmos_5p0
M$11 7 5 2 7 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.363P PS=1.18U PD=2.02U
* device instance $12 r0 *1 3.34,1.005 nmos_5p0
M$12 3 2 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.46,1.005 nmos_5p0
M$13 10 5 3 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 7 6 10 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__xor2_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xor2_2 1 2 6 7 8
* net 1 A1
* net 2 PWELL,VSS,gf180mcu_gnd
* net 6 A2
* net 7 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.87,3.947 pmos_5p0
M$1 3 6 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 1.89,3.947 pmos_5p0
M$2 3 1 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.526125P AD=0.2379P PS=2.58U PD=1.435U
* device instance $3 r0 *1 3.14,3.785 pmos_5p0
M$3 5 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.526125P AD=0.61305P PS=2.58U PD=2.5U
* device instance $4 r0 *1 4.31,3.785 pmos_5p0
M$4 9 1 5 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $5 r0 *1 5.33,3.785 pmos_5p0
M$5 7 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.27,3.78 pmos_5p0
M$6 8 5 7 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 5 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,1.16 nmos_5p0
M$10 10 6 3 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1056P PS=2.2U PD=0.98U
* device instance $11 r0 *1 1.84,1.16 nmos_5p0
M$11 10 1 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1056P PS=2.02U PD=0.98U
* device instance $12 r0 *1 3.14,1.005 nmos_5p0
M$12 4 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.26,1.005 nmos_5p0
M$13 5 1 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 4 6 5 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.673P PS=26.59U PD=24.5U
* device instance $11 r0 *1 12.07,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.346P AD=11.5839P PS=49U PD=51.09U
* device instance $31 r0 *1 0.92,1.005 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=13.2U AS=3.6696P AD=3.432P PS=20.08U PD=18.4U
* device instance $41 r0 *1 12.12,1.005 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=6.864P AD=7.1016P PS=36.8U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_20

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__buf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.2692P PS=11.89U PD=9.8U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.5384P AD=4.7763P PS=19.6U PD=21.69U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $17 r0 *1 5.4,1.005 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.7456P AD=2.9832P PS=14.72U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_8

* cell gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin C2
* pin B2
* pin B1
* pin A2
* pin C1
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi222_2 1 2 3 4 5 6 13 14 15
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 C2
* net 4 B2
* net 5 B1
* net 6 A2
* net 13 C1
* net 14 A1
* net 15 NWELL,VDD
* device instance $1 r0 *1 0.905,3.78 pmos_5p0
M$1 16 13 15 15 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $2 r0 *1 1.925,3.78 pmos_5p0
M$2 15 3 16 15 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.705,3.78 pmos_5p0
M$5 16 5 17 15 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.965325P PS=6.89U PD=4.715U
* device instance $6 r0 *1 6.725,3.78 pmos_5p0
M$6 17 4 16 15 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 9.8,3.78 pmos_5p0
M$9 2 14 17 15 pmos_5p0 L=0.5U W=3.66U AS=0.965325P AD=1.281P PS=4.715U PD=6.89U
* device instance $10 r0 *1 10.82,3.78 pmos_5p0
M$10 17 6 2 15 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $13 r0 *1 0.955,1.005 nmos_5p0
M$13 7 13 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $14 r0 *1 1.875,1.005 nmos_5p0
M$14 1 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 2.995,1.005 nmos_5p0
M$15 9 3 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 3.915,1.005 nmos_5p0
M$16 2 13 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.7524P PS=1.64U PD=2.46U
* device instance $17 r0 *1 5.655,1.005 nmos_5p0
M$17 10 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.7524P AD=0.2772P PS=2.46U PD=1.74U
* device instance $18 r0 *1 6.675,1.005 nmos_5p0
M$18 1 4 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $19 r0 *1 7.795,1.005 nmos_5p0
M$19 11 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 8.715,1.005 nmos_5p0
M$20 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3531P PS=1.64U PD=1.855U
* device instance $21 r0 *1 9.85,1.005 nmos_5p0
M$21 12 14 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3531P AD=0.2112P PS=1.855U PD=1.64U
* device instance $22 r0 *1 10.77,1.005 nmos_5p0
M$22 1 6 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 11.89,1.005 nmos_5p0
M$23 8 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $24 r0 *1 12.81,1.005 nmos_5p0
M$24 2 14 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi222_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 8 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 8 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 9 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 9 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 10 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 10 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_4 1 3 4 5 6 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 RN
* net 4 Q
* net 5 CLK
* net 6 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 16.975,3.78 pmos_5p0
M$1 4 13 17 17 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U PD=11.59U
* device instance $5 r0 *1 9.55,3.71 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.285P PS=2.88U PD=1.57U
* device instance $6 r0 *1 10.62,3.71 pmos_5p0
M$6 11 2 10 17 pmos_5p0 L=0.5U W=1U AS=0.285P AD=0.26P PS=1.57U PD=1.52U
* device instance $7 r0 *1 11.64,3.71 pmos_5p0
M$7 12 8 11 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2875P PS=1.52U PD=1.575U
* device instance $8 r0 *1 12.715,3.71 pmos_5p0
M$8 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.5457P AD=0.2875P PS=2.57U PD=1.575U
* device instance $9 r0 *1 13.955,3.78 pmos_5p0
M$9 13 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5457P AD=0.4758P PS=2.57U PD=2.35U
* device instance $10 r0 *1 14.975,3.78 pmos_5p0
M$10 17 11 13 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $11 r0 *1 3.73,3.41 pmos_5p0
M$11 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $12 r0 *1 4.75,3.41 pmos_5p0
M$12 9 8 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 5.77,3.41 pmos_5p0
M$13 18 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $14 r0 *1 6.79,3.41 pmos_5p0
M$14 17 10 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $15 r0 *1 7.81,3.41 pmos_5p0
M$15 18 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $16 r0 *1 0.97,3.555 pmos_5p0
M$16 17 5 2 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $17 r0 *1 1.99,3.555 pmos_5p0
M$17 8 2 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $18 r0 *1 16.925,1.005 nmos_5p0
M$18 4 13 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $22 r0 *1 3.9,1.315 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $23 r0 *1 5.02,1.315 nmos_5p0
M$23 9 2 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $24 r0 *1 6.14,1.315 nmos_5p0
M$24 15 8 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $25 r0 *1 6.98,1.315 nmos_5p0
M$25 14 10 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0826P PS=0.83U PD=0.87U
* device instance $26 r0 *1 7.86,1.315 nmos_5p0
M$26 1 3 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.0826P AD=0.2124P PS=0.87U PD=1.31U
* device instance $27 r0 *1 9.18,1.315 nmos_5p0
M$27 10 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2124P AD=0.190275P PS=1.31U PD=1.235U
* device instance $28 r0 *1 10.425,1.315 nmos_5p0
M$28 11 8 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.190275P AD=0.1534P PS=1.235U
+ PD=1.11U
* device instance $29 r0 *1 11.545,1.315 nmos_5p0
M$29 12 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $30 r0 *1 12.665,1.315 nmos_5p0
M$30 1 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 13.785,1.315 nmos_5p0
M$31 1 3 16 1 nmos_5p0 L=0.6U W=0.59U AS=0.3525P AD=0.1534P PS=2.02U PD=1.11U
* device instance $32 r0 *1 15.085,1.005 nmos_5p0
M$32 13 11 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3525P AD=0.5808P PS=2.02U PD=3.52U
* device instance $33 r0 *1 0.92,1.27 nmos_5p0
M$33 1 5 2 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $34 r0 *1 2.04,1.27 nmos_5p0
M$34 8 2 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_16 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7031P PS=21.69U PD=19.78U
* device instance $9 r0 *1 10.01,3.78 pmos_5p0
M$9 4 3 5 5 pmos_5p0 L=0.5U W=29.28U AS=9.2415P AD=9.3147P PS=39.38U PD=41.29U
* device instance $25 r0 *1 0.92,1.3 nmos_5p0
M$25 3 2 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.7295P AD=1.5184P PS=11.34U PD=10U
* device instance $33 r0 *1 10.06,1.265 nmos_5p0
M$33 4 3 1 1 nmos_5p0 L=0.6U W=12.8U AS=3.3895P AD=3.472P PS=21.3U PD=22.28U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 10 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 9 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 11 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
