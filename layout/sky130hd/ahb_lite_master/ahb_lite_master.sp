* cell ahb_lite_master
* pin hrdata[27]
* pin read_data[27]
* pin hrdata[1]
* pin hrdata[26]
* pin read_data[1]
* pin read_data[26]
* pin hrdata[19]
* pin read_data[19]
* pin hrdata[22]
* pin read_data[23]
* pin hrdata[23]
* pin hrdata[9]
* pin read_data[9]
* pin read_data[22]
* pin hrdata[10]
* pin hwdata[8]
* pin read_data[10]
* pin write_data[8]
* pin write_data[9]
* pin hwdata[9]
* pin read_data[11]
* pin hrdata[11]
* pin hrdata[17]
* pin hrdata[0]
* pin read_data[12]
* pin read_data[0]
* pin trans_write
* pin hwrite
* pin write_data[26]
* pin hrdata[14]
* pin write_data[1]
* pin hrdata[16]
* pin read_data[14]
* pin hwdata[26]
* pin read_data[16]
* pin hwdata[1]
* pin hrdata[18]
* pin hrdata[15]
* pin read_data[18]
* pin read_data[15]
* pin read_data[13]
* pin hready
* pin hbusreq
* pin hgrant
* pin start_trans
* pin trans_done
* pin hresp[1]
* pin hresp[0]
* pin trans_resp[1]
* pin hrdata[24]
* pin hclk
* pin read_data[8]
* pin hrdata[12]
* pin read_data[17]
* pin hrdata[13]
* pin trans_resp[0]
* pin hrdata[25]
* pin hrdata[21]
* pin hrdata[8]
* pin hrdata[6]
* pin hrdata[20]
* pin hreset
* pin hrdata[30]
* pin write_data[21]
* pin hrdata[7]
* pin read_data[25]
* pin hrdata[31]
* pin read_data[20]
* pin read_data[31]
* pin read_data[21]
* pin read_data[24]
* pin read_data[30]
* pin hrdata[3]
* pin hrdata[28]
* pin hrdata[29]
* pin read_data[2]
* pin hrdata[2]
* pin read_data[3]
* pin read_data[29]
* pin read_data[28]
* pin hburst[2]
* pin read_data[4]
* pin hwdata[21]
* pin hrdata[5]
* pin read_data[7]
* pin trans_burst[1]
* pin trans_burst[2]
* pin write_data[25]
* pin trans_burst[0]
* pin read_data[5]
* pin hwdata[25]
* pin read_data[6]
* pin hburst[1]
* pin htrans[0]
* pin hwdata[20]
* pin htrans[1]
* pin hrdata[4]
* pin hburst[0]
* pin hwdata[19]
* pin write_data[19]
* pin haddr[29]
* pin haddr[28]
* pin write_data[20]
* pin trans_addr[29]
* pin hwdata[22]
* pin haddr[30]
* pin write_data[22]
* pin hwdata[16]
* pin trans_addr[30]
* pin haddr[31]
* pin write_data[16]
* pin trans_addr[28]
* pin hwdata[18]
* pin trans_addr[10]
* pin write_data[18]
* pin trans_addr[31]
* pin write_data[17]
* pin trans_addr[14]
* pin hwdata[17]
* pin haddr[14]
* pin hwdata[27]
* pin haddr[15]
* pin write_data[24]
* pin trans_addr[26]
* pin hwdata[24]
* pin haddr[26]
* pin write_data[0]
* pin trans_addr[13]
* pin write_data[11]
* pin haddr[13]
* pin write_data[15]
* pin write_data[13]
* pin trans_addr[27]
* pin haddr[27]
* pin hwdata[15]
* pin trans_addr[23]
* pin hwdata[13]
* pin trans_size[1]
* pin trans_addr[24]
* pin haddr[10]
* pin hwdata[11]
* pin haddr[24]
* pin write_data[12]
* pin write_data[28]
* pin haddr[23]
* pin trans_addr[19]
* pin write_data[31]
* pin trans_size[2]
* pin trans_addr[17]
* pin haddr[19]
* pin hwdata[31]
* pin write_data[30]
* pin haddr[25]
* pin haddr[17]
* pin write_data[29]
* pin trans_addr[25]
* pin hwdata[30]
* pin haddr[18]
* pin hwdata[29]
* pin trans_size[0]
* pin trans_addr[18]
* pin write_data[3]
* pin hwdata[3]
* pin write_data[2]
* pin hwdata[28]
* pin haddr[22]
* pin hwdata[2]
* pin hwdata[0]
* pin hwdata[10]
* pin haddr[4]
* pin trans_addr[2]
* pin write_data[23]
* pin hwdata[12]
* pin write_data[27]
* pin haddr[9]
* pin trans_addr[11]
* pin hwdata[14]
* pin hwdata[23]
* pin hsize[2]
* pin trans_addr[16]
* pin haddr[21]
* pin write_data[6]
* pin hwdata[6]
* pin trans_addr[21]
* pin haddr[11]
* pin write_data[14]
* pin hwdata[4]
* pin write_data[7]
* pin trans_addr[8]
* pin trans_addr[22]
* pin write_data[4]
* pin trans_addr[20]
* pin write_data[5]
* pin trans_addr[0]
* pin trans_addr[4]
* pin trans_addr[6]
* pin trans_addr[9]
* pin trans_addr[7]
* pin trans_addr[15]
* pin trans_addr[1]
* pin trans_addr[12]
* pin trans_addr[5]
* pin write_data[10]
* pin hwdata[7]
* pin hwdata[5]
* pin haddr[3]
* pin trans_addr[3]
* pin haddr[0]
* pin haddr[1]
* pin hsize[0]
* pin hsize[1]
* pin haddr[2]
* pin haddr[5]
* pin haddr[12]
* pin haddr[7]
* pin haddr[8]
* pin haddr[6]
* pin haddr[16]
* pin haddr[20]
.SUBCKT ahb_lite_master 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 51 52 53 54 55 56 81 82 83 102 103 106 114 115 132 133 152 153 175
+ 177 182 188 214 215 223 234 248 249 250 275 280 289 290 305 306 316 317 331
+ 337 341 359 360 364 365 372 377 386 388 393 394 399 400 408 413 419 426 434
+ 435 440 441 446 450 455 461 465 469 481 486 491 493 497 505 515 520 522 537
+ 552 556 567 569 574 575 580 581 591 602 612 613 620 621 629 635 648 649 658
+ 659 669 670 676 677 698 699 712 713 727 733 740 750 760 761 769 779 780 802
+ 803 809 820 829 830 838 839 843 844 848 856 857 859 869 871 873 880 883 884
+ 891 893 899 900 901 903 905 906 907 908 910 911 912 913 915 916 917 918 919
+ 920 921 922 923 924 925 926 927 928 929 930 931 932 933 934 935 936
* net 1 hrdata[27]
* net 2 read_data[27]
* net 3 hrdata[1]
* net 4 hrdata[26]
* net 5 read_data[1]
* net 6 read_data[26]
* net 7 hrdata[19]
* net 8 read_data[19]
* net 9 hrdata[22]
* net 10 read_data[23]
* net 11 hrdata[23]
* net 12 hrdata[9]
* net 13 read_data[9]
* net 14 read_data[22]
* net 15 hrdata[10]
* net 16 hwdata[8]
* net 17 read_data[10]
* net 18 write_data[8]
* net 19 write_data[9]
* net 20 hwdata[9]
* net 21 read_data[11]
* net 22 hrdata[11]
* net 23 hrdata[17]
* net 24 hrdata[0]
* net 25 read_data[12]
* net 26 read_data[0]
* net 27 trans_write
* net 28 hwrite
* net 29 write_data[26]
* net 30 hrdata[14]
* net 31 write_data[1]
* net 32 hrdata[16]
* net 33 read_data[14]
* net 34 hwdata[26]
* net 35 read_data[16]
* net 36 hwdata[1]
* net 37 hrdata[18]
* net 38 hrdata[15]
* net 39 read_data[18]
* net 40 read_data[15]
* net 41 read_data[13]
* net 42 hready
* net 43 hbusreq
* net 44 hgrant
* net 45 start_trans
* net 46 trans_done
* net 47 hresp[1]
* net 48 hresp[0]
* net 49 trans_resp[1]
* net 50 hrdata[24]
* net 51 hclk
* net 52 read_data[8]
* net 53 hrdata[12]
* net 54 read_data[17]
* net 55 hrdata[13]
* net 56 trans_resp[0]
* net 81 hrdata[25]
* net 82 hrdata[21]
* net 83 hrdata[8]
* net 102 hrdata[6]
* net 103 hrdata[20]
* net 106 hreset
* net 114 hrdata[30]
* net 115 write_data[21]
* net 132 hrdata[7]
* net 133 read_data[25]
* net 152 hrdata[31]
* net 153 read_data[20]
* net 175 read_data[31]
* net 177 read_data[21]
* net 182 read_data[24]
* net 188 read_data[30]
* net 214 hrdata[3]
* net 215 hrdata[28]
* net 223 hrdata[29]
* net 234 read_data[2]
* net 248 hrdata[2]
* net 249 read_data[3]
* net 250 read_data[29]
* net 275 read_data[28]
* net 280 hburst[2]
* net 289 read_data[4]
* net 290 hwdata[21]
* net 305 hrdata[5]
* net 306 read_data[7]
* net 316 trans_burst[1]
* net 317 trans_burst[2]
* net 331 write_data[25]
* net 337 trans_burst[0]
* net 341 read_data[5]
* net 359 hwdata[25]
* net 360 read_data[6]
* net 364 hburst[1]
* net 365 htrans[0]
* net 372 hwdata[20]
* net 377 htrans[1]
* net 386 hrdata[4]
* net 388 hburst[0]
* net 393 hwdata[19]
* net 394 write_data[19]
* net 399 haddr[29]
* net 400 haddr[28]
* net 408 write_data[20]
* net 413 trans_addr[29]
* net 419 hwdata[22]
* net 426 haddr[30]
* net 434 write_data[22]
* net 435 hwdata[16]
* net 440 trans_addr[30]
* net 441 haddr[31]
* net 446 write_data[16]
* net 450 trans_addr[28]
* net 455 hwdata[18]
* net 461 trans_addr[10]
* net 465 write_data[18]
* net 469 trans_addr[31]
* net 481 write_data[17]
* net 486 trans_addr[14]
* net 491 hwdata[17]
* net 493 haddr[14]
* net 497 hwdata[27]
* net 505 haddr[15]
* net 515 write_data[24]
* net 520 trans_addr[26]
* net 522 hwdata[24]
* net 537 haddr[26]
* net 552 write_data[0]
* net 556 trans_addr[13]
* net 567 write_data[11]
* net 569 haddr[13]
* net 574 write_data[15]
* net 575 write_data[13]
* net 580 trans_addr[27]
* net 581 haddr[27]
* net 591 hwdata[15]
* net 602 trans_addr[23]
* net 612 hwdata[13]
* net 613 trans_size[1]
* net 620 trans_addr[24]
* net 621 haddr[10]
* net 629 hwdata[11]
* net 635 haddr[24]
* net 648 write_data[12]
* net 649 write_data[28]
* net 658 haddr[23]
* net 659 trans_addr[19]
* net 669 write_data[31]
* net 670 trans_size[2]
* net 676 trans_addr[17]
* net 677 haddr[19]
* net 698 hwdata[31]
* net 699 write_data[30]
* net 712 haddr[25]
* net 713 haddr[17]
* net 727 write_data[29]
* net 733 trans_addr[25]
* net 740 hwdata[30]
* net 750 haddr[18]
* net 760 hwdata[29]
* net 761 trans_size[0]
* net 769 trans_addr[18]
* net 779 write_data[3]
* net 780 hwdata[3]
* net 802 write_data[2]
* net 803 hwdata[28]
* net 809 haddr[22]
* net 820 hwdata[2]
* net 829 hwdata[0]
* net 830 hwdata[10]
* net 838 haddr[4]
* net 839 trans_addr[2]
* net 843 write_data[23]
* net 844 hwdata[12]
* net 848 write_data[27]
* net 856 haddr[9]
* net 857 trans_addr[11]
* net 859 hwdata[14]
* net 869 hwdata[23]
* net 871 hsize[2]
* net 873 trans_addr[16]
* net 880 haddr[21]
* net 883 write_data[6]
* net 884 hwdata[6]
* net 891 trans_addr[21]
* net 893 haddr[11]
* net 899 write_data[14]
* net 900 hwdata[4]
* net 901 write_data[7]
* net 903 trans_addr[8]
* net 905 trans_addr[22]
* net 906 write_data[4]
* net 907 trans_addr[20]
* net 908 write_data[5]
* net 910 trans_addr[0]
* net 911 trans_addr[4]
* net 912 trans_addr[6]
* net 913 trans_addr[9]
* net 915 trans_addr[7]
* net 916 trans_addr[15]
* net 917 trans_addr[1]
* net 918 trans_addr[12]
* net 919 trans_addr[5]
* net 920 write_data[10]
* net 921 hwdata[7]
* net 922 hwdata[5]
* net 923 haddr[3]
* net 924 trans_addr[3]
* net 925 haddr[0]
* net 926 haddr[1]
* net 927 hsize[0]
* net 928 hsize[1]
* net 929 haddr[2]
* net 930 haddr[5]
* net 931 haddr[12]
* net 932 haddr[7]
* net 933 haddr[8]
* net 934 haddr[6]
* net 935 haddr[16]
* net 936 haddr[20]
* cell instance $3 m0 *1 13.34,13.6
X$3 86 1 141 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $6 r0 *1 12.42,8.16
X$6 86 116 2 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $9 r0 *1 13.8,8.16
X$9 86 3 89 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $12 r0 *1 17.02,13.6
X$12 86 4 125 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $15 r0 *1 19.78,8.16
X$15 86 74 5 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $17 r0 *1 20.24,13.6
X$17 86 104 6 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $20 r0 *1 21.16,8.16
X$20 86 7 109 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $24 m0 *1 23.92,13.6
X$24 86 77 8 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $29 r0 *1 12.42,2.72
X$29 86 9 61 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $32 m0 *1 26.22,13.6
X$32 86 165 10 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $37 r0 *1 13.8,2.72
X$37 86 11 60 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $42 m0 *1 29.44,13.6
X$42 86 12 145 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $45 r0 *1 29.9,13.6
X$45 86 167 13 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $47 r0 *1 31.74,8.16
X$47 86 79 14 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $51 m0 *1 30.82,13.6
X$51 86 15 97 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $54 r0 *1 31.28,13.6
X$54 86 169 16 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $57 m0 *1 32.2,13.6
X$57 86 78 17 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $59 m0 *1 33.58,13.6
X$59 86 18 146 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $66 m0 *1 41.4,19.04
X$66 86 19 185 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $70 r0 *1 39.56,13.6
X$70 86 171 20 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $73 r0 *1 38.18,13.6
X$73 86 136 21 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $76 r0 *1 36.8,13.6
X$76 86 22 148 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $81 r0 *1 40.94,13.6
X$81 86 23 173 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $84 r0 *1 41.4,2.72
X$84 86 24 99 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $87 r0 *1 37.72,2.72
X$87 86 63 25 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $90 r0 *1 39.56,2.72
X$90 86 80 26 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $93 m0 *1 45.54,13.6
X$93 86 27 151 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $96 m0 *1 43.7,8.16
X$96 86 112 28 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $99 r0 *1 46.46,13.6
X$99 86 29 194 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $102 m0 *1 45.08,8.16
X$102 86 30 101 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $105 m0 *1 49.68,13.6
X$105 86 31 150 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $108 r0 *1 47.38,2.72
X$108 86 32 65 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $111 r0 *1 52.44,8.16
X$111 86 64 33 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $114 m0 *1 51.06,13.6
X$114 86 187 34 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $117 r0 *1 53.82,8.16
X$117 86 76 35 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $120 m0 *1 52.44,13.6
X$120 86 149 36 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $123 m0 *1 57.04,8.16
X$123 86 37 131 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $126 r0 *1 55.2,2.72
X$126 86 38 66 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $129 m0 *1 54.28,13.6
X$129 86 147 39 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $132 r0 *1 55.2,8.16
X$132 86 75 40 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $135 r0 *1 65.78,8.16
X$135 86 92 41 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $138 r0 *1 65.32,2.72
X$138 86 42 58 180 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $143 m0 *1 69.92,13.6
X$143 86 137 43 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $146 r0 *1 68.08,2.72
X$146 86 44 86 58 59 58 sky130_fd_sc_hd__clkbuf_2
* cell instance $149 m0 *1 65.78,13.6
X$149 86 45 144 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $153 r0 *1 77.74,8.16
X$153 86 117 46 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $157 r0 *1 72.22,2.72
X$157 86 47 90 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $160 r0 *1 69,8.16
X$160 86 48 105 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $163 r0 *1 73.6,2.72
X$163 86 57 49 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $166 m0 *1 17.94,19.04
X$166 86 50 183 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $170 r0 *1 1.38,2.72
X$170 58 51 69 86 86 58 sky130_fd_sc_hd__buf_16
* cell instance $174 r0 *1 28.52,13.6
X$174 86 193 52 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $177 m0 *1 34.96,13.6
X$177 86 53 129 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $180 r0 *1 43.24,13.6
X$180 86 189 54 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $183 r0 *1 53.82,2.72
X$183 86 55 68 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $186 r0 *1 70.84,2.72
X$186 86 73 56 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $191 m0 *1 77.28,8.16
X$191 58 72 90 57 84 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $194 r0 *1 74.98,2.72
X$194 58 71 57 69 72 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $215 r0 *1 16.1,2.72
X$215 58 88 89 74 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $217 r0 *1 20.7,2.72
X$217 58 91 109 77 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $218 r0 *1 24.84,2.72
X$218 58 93 61 79 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $220 r0 *1 29.44,2.72
X$220 58 96 97 78 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $221 r0 *1 33.58,2.72
X$221 58 98 129 63 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $226 r0 *1 43.24,2.72
X$226 58 100 101 64 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $227 r0 *1 48.76,2.72
X$227 58 113 65 76 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $230 r0 *1 57.04,2.72
X$230 58 95 66 75 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $231 r0 *1 61.18,2.72
X$231 58 94 68 92 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $236 r0 *1 84.64,2.72
X$236 58 71 70 69 110 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $237 r0 *1 93.84,2.72
X$237 58 70 87 86 86 58 sky130_fd_sc_hd__buf_6
* cell instance $252 m0 *1 1.38,8.16
X$252 58 71 108 69 107 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $253 m0 *1 10.58,8.16
X$253 58 71 74 69 88 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $254 m0 *1 19.78,8.16
X$254 58 71 77 69 91 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $257 m0 *1 30.36,8.16
X$257 58 71 78 69 96 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $258 m0 *1 39.56,8.16
X$258 58 130 99 80 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $260 m0 *1 46.92,8.16
X$260 58 71 76 69 113 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $263 m0 *1 58.42,8.16
X$263 58 71 92 69 94 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $264 m0 *1 67.62,8.16
X$264 58 71 73 69 111 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $271 m0 *1 89.24,8.16
X$271 58 71 120 69 85 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $272 m0 *1 98.44,8.16
X$272 58 106 71 86 86 58 sky130_fd_sc_hd__buf_16
* cell instance $274 r0 *1 3.22,8.16
X$274 58 71 116 69 161 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $277 r0 *1 15.64,8.16
X$277 58 124 125 104 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $278 r0 *1 22.54,8.16
X$278 58 71 79 69 93 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $280 r0 *1 33.58,8.16
X$280 58 71 63 69 98 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $283 r0 *1 43.24,8.16
X$283 58 71 64 69 100 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $284 r0 *1 56.58,8.16
X$284 58 71 75 69 95 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $288 r0 *1 70.84,8.16
X$288 58 111 105 73 84 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $292 r0 *1 79.58,8.16
X$292 86 119 87 86 127 58 58 sky130_fd_sc_hd__xor2_1
* cell instance $294 r0 *1 84.64,8.16
X$294 86 126 86 58 110 58 sky130_fd_sc_hd__inv_1
* cell instance $296 r0 *1 89.7,8.16
X$296 86 118 87 123 86 58 58 sky130_fd_sc_hd__xnor2_1
* cell instance $297 r0 *1 92.92,8.16
X$297 86 118 119 59 121 58 86 58 sky130_fd_sc_hd__nand3b_1
* cell instance $304 r0 *1 100.74,8.16
X$304 58 120 119 86 86 58 sky130_fd_sc_hd__buf_6
* cell instance $314 m0 *1 1.38,13.6
X$314 86 115 122 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $315 m0 *1 2.76,13.6
X$315 86 108 133 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $316 m0 *1 4.14,13.6
X$316 58 71 135 69 160 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $317 m0 *1 14.72,13.6
X$317 58 71 104 69 124 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $322 m0 *1 36.34,13.6
X$322 58 71 80 69 130 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $328 m0 *1 57.04,13.6
X$328 58 174 131 147 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $334 m0 *1 71.76,13.6
X$334 58 71 117 69 128 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $335 m0 *1 80.96,13.6
X$335 86 127 118 84 117 128 58 86 58 sky130_fd_sc_hd__o22a_1
* cell instance $338 m0 *1 85.1,13.6
X$338 86 84 87 143 86 58 85 58 sky130_fd_sc_hd__o21bai_1
* cell instance $341 m0 *1 90.16,13.6
X$341 86 119 123 142 86 140 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $343 m0 *1 92.46,13.6
X$343 58 71 139 69 140 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $347 r0 *1 1.38,13.6
X$347 86 152 154 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $348 r0 *1 2.76,13.6
X$348 86 103 155 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $349 r0 *1 4.14,13.6
X$349 86 81 134 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $350 r0 *1 5.52,13.6
X$350 58 107 134 108 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $351 r0 *1 9.66,13.6
X$351 86 135 153 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $352 r0 *1 11.04,13.6
X$352 58 161 141 116 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $356 r0 *1 15.64,13.6
X$356 86 102 162 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $357 r0 *1 18.4,13.6
X$357 86 132 163 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $360 r0 *1 22.08,13.6
X$360 58 164 60 165 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $362 r0 *1 26.68,13.6
X$362 86 83 168 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $364 r0 *1 32.66,13.6
X$364 58 170 148 136 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $370 r0 *1 47.84,13.6
X$370 58 71 147 69 174 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $380 r0 *1 74.52,13.6
X$380 86 137 86 58 172 58 sky130_fd_sc_hd__inv_1
* cell instance $382 r0 *1 76.82,13.6
X$382 58 180 126 87 119 118 86 86 58 sky130_fd_sc_hd__nand4b_4
* cell instance $384 r0 *1 86.02,13.6
X$384 86 158 166 143 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $385 r0 *1 87.4,13.6
X$385 86 118 59 138 119 158 86 58 58 sky130_fd_sc_hd__o211ai_1
* cell instance $388 r0 *1 91.54,13.6
X$388 86 138 121 87 58 86 142 58 sky130_fd_sc_hd__a21o_1
* cell instance $401 m0 *1 1.38,19.04
X$401 86 176 175 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $402 m0 *1 2.76,19.04
X$402 86 204 188 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $403 m0 *1 4.14,19.04
X$403 86 114 181 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $404 m0 *1 5.52,19.04
X$404 58 203 154 176 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $405 m0 *1 9.66,19.04
X$405 58 160 155 135 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $406 m0 *1 13.8,19.04
X$406 86 156 177 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $407 m0 *1 15.18,19.04
X$407 86 178 182 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $408 m0 *1 16.56,19.04
X$408 86 82 192 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $410 m0 *1 19.78,19.04
X$410 58 71 165 69 164 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $412 m0 *1 29.44,19.04
X$412 86 179 58 62 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $413 m0 *1 32.2,19.04
X$413 58 71 136 69 170 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $415 m0 *1 46.46,19.04
X$415 58 71 187 69 186 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $423 m0 *1 69.46,19.04
X$423 58 71 137 69 195 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $427 m0 *1 81.88,19.04
X$427 86 118 144 157 58 86 58 sky130_fd_sc_hd__nor2b_1
* cell instance $429 m0 *1 84.64,19.04
X$429 86 157 119 118 180 86 166 58 58 sky130_fd_sc_hd__a211o_1
* cell instance $431 m0 *1 88.78,19.04
X$431 86 139 58 118 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $433 m0 *1 93.38,19.04
X$433 86 159 59 139 86 184 58 58 sky130_fd_sc_hd__o21a_1
* cell instance $434 m0 *1 96.14,19.04
X$434 58 159 87 139 119 86 86 58 sky130_fd_sc_hd__nor3b_2
* cell instance $439 r0 *1 1.84,19.04
X$439 58 71 176 69 203 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $440 r0 *1 11.04,19.04
X$440 58 205 192 156 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $445 r0 *1 16.56,19.04
X$445 58 208 183 178 62 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $446 r0 *1 20.7,19.04
X$446 58 71 193 69 210 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $447 r0 *1 29.9,19.04
X$447 58 210 168 193 179 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $450 r0 *1 38.64,19.04
X$450 58 212 173 189 67 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $456 r0 *1 44.62,19.04
X$456 58 186 187 194 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $457 r0 *1 48.76,19.04
X$457 58 71 149 69 213 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $458 r0 *1 57.96,19.04
X$458 86 179 58 67 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $469 r0 *1 74.06,19.04
X$469 58 195 190 172 199 86 86 58 sky130_fd_sc_hd__mux2i_1
* cell instance $472 r0 *1 79.12,19.04
X$472 86 159 144 191 58 86 190 58 sky130_fd_sc_hd__a21oi_1
* cell instance $473 r0 *1 80.96,19.04
X$473 58 58 211 86 87 119 86 sky130_fd_sc_hd__nor2_2
* cell instance $474 r0 *1 83.26,19.04
X$474 86 180 119 209 58 86 58 sky130_fd_sc_hd__nand2b_1
* cell instance $476 r0 *1 86.48,19.04
X$476 86 139 180 138 58 86 58 sky130_fd_sc_hd__nand2b_1
* cell instance $477 r0 *1 88.78,19.04
X$477 58 87 119 207 139 86 86 58 sky130_fd_sc_hd__nor3b_4
* cell instance $478 r0 *1 95.68,19.04
X$478 86 59 159 217 58 86 58 sky130_fd_sc_hd__nor2b_1
* cell instance $483 r0 *1 99.36,19.04
X$483 58 71 201 69 202 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $489 m0 *1 1.84,24.48
X$489 58 71 204 69 228 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $490 m0 *1 11.04,24.48
X$490 58 71 156 69 205 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $492 m0 *1 22.08,24.48
X$492 86 179 58 218 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $496 m0 *1 29.44,24.48
X$496 58 220 145 167 179 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $499 m0 *1 35.88,24.48
X$499 58 71 189 69 212 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $502 m0 *1 49.22,24.48
X$502 58 213 149 150 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $503 m0 *1 53.36,24.48
X$503 58 58 179 86 112 126 86 sky130_fd_sc_hd__nor2_2
* cell instance $508 m0 *1 59.8,24.48
X$508 58 71 222 69 233 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $511 m0 *1 71.3,24.48
X$511 58 198 84 126 226 86 86 58 sky130_fd_sc_hd__nor3_2
* cell instance $514 m0 *1 79.58,24.48
X$514 86 221 231 200 58 199 86 58 sky130_fd_sc_hd__o21ai_2
* cell instance $518 m0 *1 84.64,24.48
X$518 86 87 118 209 58 86 200 58 sky130_fd_sc_hd__a21oi_1
* cell instance $521 m0 *1 88.78,24.48
X$521 86 87 139 219 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $522 m0 *1 90.16,24.48
X$522 86 59 219 138 211 58 206 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $523 m0 *1 93.38,24.48
X$523 86 184 58 197 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $524 m0 *1 96.14,24.48
X$524 86 199 217 206 201 202 58 86 58 sky130_fd_sc_hd__o22a_1
* cell instance $525 m0 *1 99.36,24.48
X$525 58 71 216 69 229 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $526 r0 *1 1.38,24.48
X$526 86 214 240 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $527 r0 *1 2.76,24.48
X$527 58 228 181 204 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $528 r0 *1 6.9,24.48
X$528 86 224 234 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $531 r0 *1 9.66,24.48
X$531 86 223 242 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $533 r0 *1 12.88,24.48
X$533 86 215 241 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $537 r0 *1 15.64,24.48
X$537 58 71 178 69 208 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $539 r0 *1 25.76,24.48
X$539 58 71 167 69 220 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $546 r0 *1 43.7,24.48
X$546 58 244 151 112 197 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $550 r0 *1 51.06,24.48
X$550 58 207 112 180 86 236 86 58 sky130_fd_sc_hd__nand3_4
* cell instance $553 r0 *1 60.26,24.48
X$553 86 222 232 225 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $554 r0 *1 61.64,24.48
X$554 86 222 221 246 225 86 58 233 58 sky130_fd_sc_hd__o31ai_1
* cell instance $555 r0 *1 64.4,24.48
X$555 86 180 207 246 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $557 r0 *1 67.62,24.48
X$557 86 180 198 207 247 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $563 r0 *1 73.14,24.48
X$563 86 198 226 221 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $566 r0 *1 75.9,24.48
X$566 58 409 207 206 197 198 227 86 86 58 sky130_fd_sc_hd__a41o_1
* cell instance $567 r0 *1 79.58,24.48
X$567 86 207 227 231 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $568 r0 *1 80.96,24.48
X$568 86 211 118 180 227 86 243 58 58 sky130_fd_sc_hd__nand4_1
* cell instance $569 r0 *1 83.26,24.48
X$569 58 58 211 230 157 86 86 sky130_fd_sc_hd__nand2_2
* cell instance $571 r0 *1 86.02,24.48
X$571 86 157 211 239 86 58 58 sky130_fd_sc_hd__and2_0
* cell instance $575 r0 *1 91.54,24.48
X$575 58 58 211 269 118 86 86 sky130_fd_sc_hd__nand2_2
* cell instance $582 r0 *1 99.82,24.48
X$582 86 199 159 206 216 229 58 86 58 sky130_fd_sc_hd__o22a_1
* cell instance $593 m0 *1 1.38,29.92
X$593 86 248 235 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $594 m0 *1 2.76,29.92
X$594 86 254 249 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $595 m0 *1 4.14,29.92
X$595 58 253 240 254 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $596 m0 *1 8.28,29.92
X$596 58 256 235 224 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $597 m0 *1 12.42,29.92
X$597 86 257 250 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $598 m0 *1 13.8,29.92
X$598 58 251 242 257 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $599 m0 *1 17.94,29.92
X$599 58 71 257 69 251 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $605 m0 *1 37.72,29.92
X$605 58 298 171 185 236 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $606 m0 *1 41.86,29.92
X$606 58 71 112 69 244 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $612 m0 *1 58.88,29.92
X$612 58 261 274 262 245 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $613 m0 *1 63.48,29.92
X$613 58 260 246 237 252 238 86 86 58 sky130_fd_sc_hd__a211oi_2
* cell instance $615 m0 *1 69,29.92
X$615 86 259 86 58 258 58 sky130_fd_sc_hd__inv_1
* cell instance $617 m0 *1 71.3,29.92
X$617 86 237 252 238 58 86 226 58 sky130_fd_sc_hd__a21oi_1
* cell instance $618 m0 *1 73.14,29.92
X$618 58 71 245 69 270 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $623 m0 *1 86.94,29.92
X$623 86 239 86 58 255 58 sky130_fd_sc_hd__buf_4
* cell instance $632 r0 *1 2.76,29.92
X$632 86 263 275 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $633 r0 *1 4.14,29.92
X$633 86 297 290 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $635 r0 *1 5.98,29.92
X$635 58 71 224 69 256 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $639 r0 *1 16.1,29.92
X$639 58 284 241 263 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $653 r0 *1 50.14,29.92
X$653 86 232 299 272 86 286 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $654 r0 *1 51.98,29.92
X$654 86 262 232 272 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $657 r0 *1 56.12,29.92
X$657 58 58 232 86 260 273 86 sky130_fd_sc_hd__nor2_2
* cell instance $659 r0 *1 60.26,29.92
X$659 86 245 222 261 86 264 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $661 r0 *1 63.02,29.92
X$661 86 259 265 274 266 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $663 r0 *1 65.78,29.92
X$663 58 266 264 238 258 304 86 86 58 sky130_fd_sc_hd__a22oi_2
* cell instance $666 r0 *1 70.84,29.92
X$666 58 288 243 237 252 238 86 86 58 sky130_fd_sc_hd__a211oi_2
* cell instance $669 r0 *1 76.82,29.92
X$669 86 245 86 58 271 58 sky130_fd_sc_hd__inv_1
* cell instance $670 r0 *1 78.2,29.92
X$670 86 271 255 267 86 270 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $674 r0 *1 85.1,29.92
X$674 58 71 283 69 268 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $675 r0 *1 94.3,29.92
X$675 86 269 86 58 191 58 sky130_fd_sc_hd__buf_4
* cell instance $679 r0 *1 98.44,29.92
X$679 58 71 296 69 281 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $690 m0 *1 1.84,35.36
X$690 58 71 254 69 253 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $695 m0 *1 19.78,35.36
X$695 58 71 263 69 284 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $698 m0 *1 31.28,35.36
X$698 58 71 171 69 298 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $702 m0 *1 45.54,35.36
X$702 58 71 262 69 286 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $706 m0 *1 58.88,35.36
X$706 58 301 265 276 287 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $707 m0 *1 63.48,35.36
X$707 58 303 259 340 292 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $708 m0 *1 68.08,35.36
X$708 86 230 247 273 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $712 m0 *1 75.44,35.36
X$712 58 287 302 271 277 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $713 m0 *1 80.04,35.36
X$713 86 300 283 245 285 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $715 m0 *1 82.34,35.36
X$715 86 283 86 58 277 58 sky130_fd_sc_hd__inv_1
* cell instance $718 m0 *1 84.64,35.36
X$718 86 277 255 278 86 268 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $719 m0 *1 86.48,35.36
X$719 86 279 230 293 278 86 58 58 sky130_fd_sc_hd__or3_1
* cell instance $721 m0 *1 89.24,35.36
X$721 86 279 293 255 267 58 86 58 sky130_fd_sc_hd__nand3b_1
* cell instance $724 m0 *1 96.6,35.36
X$724 86 296 282 295 227 86 58 58 sky130_fd_sc_hd__or3_1
* cell instance $725 m0 *1 98.9,35.36
X$725 58 281 279 296 197 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $728 m0 *1 107.18,35.36
X$728 86 296 280 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $731 r0 *1 2.76,35.36
X$731 86 307 289 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $733 r0 *1 5.98,35.36
X$733 58 71 297 69 318 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $738 r0 *1 17.02,35.36
X$738 86 319 306 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $739 r0 *1 18.4,35.36
X$739 58 321 163 319 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $744 r0 *1 32.2,35.36
X$744 58 71 169 69 322 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $751 r0 *1 47.84,35.36
X$751 86 308 340 86 323 58 58 sky130_fd_sc_hd__xor2_1
* cell instance $752 r0 *1 51.06,35.36
X$752 86 325 207 299 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $753 r0 *1 52.44,35.36
X$753 58 325 339 222 262 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $754 r0 *1 57.04,35.36
X$754 86 262 222 276 273 260 86 308 58 58 sky130_fd_sc_hd__o2111ai_1
* cell instance $756 r0 *1 60.72,35.36
X$756 86 301 265 303 86 304 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $757 r0 *1 62.56,35.36
X$757 58 291 328 310 330 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $758 r0 *1 67.16,35.36
X$758 86 327 291 311 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $761 r0 *1 69,35.36
X$761 86 329 311 252 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $764 r0 *1 71.76,35.36
X$764 58 330 198 313 285 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $766 r0 *1 78.2,35.36
X$766 86 302 300 292 86 58 58 sky130_fd_sc_hd__xnor2_1
* cell instance $769 r0 *1 82.8,35.36
X$769 86 313 255 314 86 368 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $772 r0 *1 87.4,35.36
X$772 86 279 315 239 314 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $774 r0 *1 89.7,35.36
X$774 86 315 279 255 324 58 86 58 sky130_fd_sc_hd__nand3b_1
* cell instance $775 r0 *1 92.46,35.36
X$775 86 349 315 293 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $776 r0 *1 93.84,35.36
X$776 58 294 315 282 197 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $780 r0 *1 99.36,35.36
X$780 58 71 282 69 294 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $789 m0 *1 1.38,40.8
X$789 86 332 341 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $790 m0 *1 2.76,40.8
X$790 86 305 351 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $791 m0 *1 4.14,40.8
X$791 58 350 351 332 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $792 m0 *1 8.28,40.8
X$792 58 318 297 122 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $794 m0 *1 12.88,40.8
X$794 86 331 352 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $797 m0 *1 18.4,40.8
X$797 58 71 319 69 321 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $802 m0 *1 33.12,40.8
X$802 58 322 169 146 236 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $807 m0 *1 46.92,40.8
X$807 86 255 323 353 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $811 m0 *1 51.52,40.8
X$811 86 309 276 86 326 58 58 sky130_fd_sc_hd__xor2_1
* cell instance $812 m0 *1 54.74,40.8
X$812 86 260 273 339 86 309 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $815 m0 *1 57.5,40.8
X$815 86 262 222 276 310 58 86 342 58 sky130_fd_sc_hd__and4_1
* cell instance $817 m0 *1 61.18,40.8
X$817 86 260 273 333 340 344 86 58 58 sky130_fd_sc_hd__o211ai_1
* cell instance $819 m0 *1 65.78,40.8
X$819 58 327 334 333 312 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $820 m0 *1 70.38,40.8
X$820 86 334 328 327 58 86 348 58 sky130_fd_sc_hd__a21oi_1
* cell instance $822 m0 *1 72.68,40.8
X$822 86 329 348 358 58 237 86 58 sky130_fd_sc_hd__o21ai_2
* cell instance $823 m0 *1 75.9,40.8
X$823 86 313 285 312 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $824 m0 *1 77.28,40.8
X$824 86 313 285 356 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $826 m0 *1 79.58,40.8
X$826 86 302 335 357 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $828 m0 *1 81.42,40.8
X$828 86 300 336 335 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $829 m0 *1 82.8,40.8
X$829 86 336 86 58 313 58 sky130_fd_sc_hd__inv_1
* cell instance $831 m0 *1 84.64,40.8
X$831 86 300 230 355 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $833 m0 *1 86.48,40.8
X$833 58 71 300 69 338 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $834 m0 *1 95.68,40.8
X$834 86 296 282 354 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $835 m0 *1 97.06,40.8
X$835 58 71 295 69 320 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $836 m0 *1 106.26,40.8
X$836 86 316 315 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $838 r0 *1 1.38,40.8
X$838 58 71 332 69 350 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $839 r0 *1 10.58,40.8
X$839 86 361 360 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $841 r0 *1 12.88,40.8
X$841 86 366 359 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $848 r0 *1 16.1,40.8
X$848 58 378 367 307 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $850 r0 *1 23.92,40.8
X$850 58 71 366 69 379 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $859 r0 *1 43.24,40.8
X$859 58 71 340 69 353 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $860 r0 *1 52.44,40.8
X$860 86 255 326 370 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $861 r0 *1 53.82,40.8
X$861 86 276 339 340 371 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $863 r0 *1 56.58,40.8
X$863 86 310 276 339 373 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $864 r0 *1 58.42,40.8
X$864 86 340 342 383 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $867 r0 *1 62.1,40.8
X$867 86 343 342 345 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $868 r0 *1 63.48,40.8
X$868 86 344 345 346 86 385 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $869 r0 *1 65.32,40.8
X$869 86 346 344 345 362 86 58 58 sky130_fd_sc_hd__or3_1
* cell instance $875 r0 *1 69,40.8
X$875 86 347 363 329 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $877 r0 *1 70.84,40.8
X$877 58 363 369 343 356 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $878 r0 *1 75.44,40.8
X$878 58 347 375 346 357 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $879 r0 *1 80.04,40.8
X$879 58 71 336 69 368 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $881 r0 *1 90.16,40.8
X$881 86 355 324 338 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $883 r0 *1 93.38,40.8
X$883 58 320 349 295 197 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $889 r0 *1 98.44,40.8
X$889 86 337 349 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $892 r0 *1 101.2,40.8
X$892 58 279 317 86 86 58 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $893 r0 *1 105.8,40.8
X$893 86 282 364 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $894 r0 *1 107.18,40.8
X$894 86 201 365 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $897 m0 *1 2.76,46.24
X$897 86 386 367 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $900 m0 *1 5.52,46.24
X$900 58 71 361 69 390 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $901 m0 *1 14.72,46.24
X$901 58 71 307 69 378 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $903 m0 *1 24.84,46.24
X$903 58 379 366 352 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $909 m0 *1 40.94,46.24
X$909 58 71 276 69 370 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $910 m0 *1 50.6,46.24
X$910 86 232 371 310 86 391 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $912 m0 *1 53.36,46.24
X$912 86 310 232 371 381 86 58 58 sky130_fd_sc_hd__or3_1
* cell instance $915 m0 *1 57.04,46.24
X$915 86 232 383 333 86 384 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $916 m0 *1 58.88,46.24
X$916 86 333 232 383 405 86 58 58 sky130_fd_sc_hd__or3_1
* cell instance $919 m0 *1 62.56,46.24
X$919 86 344 373 392 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $920 m0 *1 63.94,46.24
X$920 86 255 385 362 58 86 374 58 sky130_fd_sc_hd__a21oi_1
* cell instance $921 m0 *1 65.78,46.24
X$921 58 71 346 69 374 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $922 m0 *1 74.98,46.24
X$922 86 375 347 369 58 86 358 58 sky130_fd_sc_hd__a21oi_1
* cell instance $929 m0 *1 90.62,46.24
X$929 86 295 354 207 58 382 86 58 sky130_fd_sc_hd__o21ai_2
* cell instance $930 m0 *1 93.84,46.24
X$930 86 295 354 380 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $934 m0 *1 103.5,46.24
X$934 86 216 377 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $935 m0 *1 104.88,46.24
X$935 86 295 388 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $937 m0 *1 107.18,46.24
X$937 86 376 400 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $938 r0 *1 1.38,46.24
X$938 86 395 372 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $939 r0 *1 2.76,46.24
X$939 86 402 393 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $940 r0 *1 4.14,46.24
X$940 58 401 395 389 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $941 r0 *1 8.28,46.24
X$941 58 390 162 361 218 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $962 r0 *1 48.3,46.24
X$962 86 255 391 381 58 86 416 58 sky130_fd_sc_hd__a21oi_1
* cell instance $963 r0 *1 50.14,46.24
X$963 58 71 333 69 397 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $964 r0 *1 59.34,46.24
X$964 86 255 384 405 58 86 397 58 sky130_fd_sc_hd__a21oi_1
* cell instance $965 r0 *1 61.18,46.24
X$965 58 406 387 407 392 86 86 58 sky130_fd_sc_hd__mux2i_1
* cell instance $966 r0 *1 64.86,46.24
X$966 86 230 343 407 58 86 58 sky130_fd_sc_hd__nand2b_1
* cell instance $967 r0 *1 67.16,46.24
X$967 86 343 230 387 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $975 r0 *1 78.66,46.24
X$975 58 71 398 69 404 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $979 r0 *1 91.08,46.24
X$979 86 269 380 403 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $982 r0 *1 93.84,46.24
X$982 86 398 399 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $988 r0 *1 98.44,46.24
X$988 58 71 376 69 414 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $995 m0 *1 1.84,51.68
X$995 86 408 389 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $996 m0 *1 3.22,51.68
X$996 58 71 395 69 401 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $997 m0 *1 12.42,51.68
X$997 86 394 427 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $999 m0 *1 15.64,51.68
X$999 58 396 402 427 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1000 m0 *1 19.78,51.68
X$1000 58 71 402 69 396 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1008 m0 *1 43.7,51.68
X$1008 58 71 310 69 416 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1013 m0 *1 58.42,51.68
X$1013 58 71 343 69 406 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1016 m0 *1 71.76,51.68
X$1016 58 409 429 288 86 86 58 sky130_fd_sc_hd__nor2_4
* cell instance $1017 m0 *1 75.9,51.68
X$1017 86 409 288 418 58 86 58 sky130_fd_sc_hd__or2_0
* cell instance $1018 m0 *1 78.2,51.68
X$1018 58 418 410 86 86 58 sky130_fd_sc_hd__buf_6
* cell instance $1022 m0 *1 85.1,51.68
X$1022 86 382 58 417 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1023 m0 *1 87.86,51.68
X$1023 86 411 207 432 58 86 58 sky130_fd_sc_hd__and2b_1
* cell instance $1024 m0 *1 90.62,51.68
X$1024 86 417 423 410 86 424 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1025 m0 *1 92.46,51.68
X$1025 86 415 430 376 424 58 414 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1026 m0 *1 95.68,51.68
X$1026 58 71 412 69 428 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1027 m0 *1 104.88,51.68
X$1027 86 413 411 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1029 m0 *1 106.72,51.68
X$1029 86 412 426 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1031 r0 *1 1.38,51.68
X$1031 86 420 419 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1035 r0 *1 5.98,51.68
X$1035 86 436 435 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1037 r0 *1 9.2,51.68
X$1037 86 434 421 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1039 r0 *1 11.04,51.68
X$1039 58 437 420 421 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1042 r0 *1 15.64,51.68
X$1042 58 71 420 69 437 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1066 r0 *1 79.12,51.68
X$1066 86 418 58 415 86 58 sky130_fd_sc_hd__buf_2
* cell instance $1068 r0 *1 81.42,51.68
X$1068 86 398 431 444 460 86 404 58 58 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $1069 r0 *1 84.64,51.68
X$1069 86 432 433 445 58 86 444 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1072 r0 *1 88.78,51.68
X$1072 86 422 423 438 269 58 430 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1073 r0 *1 92,51.68
X$1073 86 417 443 410 86 425 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1075 r0 *1 94.76,51.68
X$1075 86 415 452 412 425 58 428 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1079 r0 *1 99.36,51.68
X$1079 58 71 442 69 451 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1088 m0 *1 1.38,57.12
X$1088 86 446 447 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1089 m0 *1 2.76,57.12
X$1089 86 456 455 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1091 m0 *1 5.06,57.12
X$1091 58 71 456 69 488 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1092 m0 *1 14.26,57.12
X$1092 58 457 436 447 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1095 m0 *1 19.78,57.12
X$1095 58 71 436 69 457 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1109 m0 *1 64.4,57.12
X$1109 58 71 464 69 463 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $1114 m0 *1 80.96,57.12
X$1114 86 453 454 415 86 431 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1119 m0 *1 85.56,57.12
X$1119 86 398 417 480 445 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $1121 m0 *1 87.86,57.12
X$1121 86 382 58 448 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1122 m0 *1 90.62,57.12
X$1122 86 376 448 422 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1123 m0 *1 92,57.12
X$1123 86 412 448 449 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1124 m0 *1 93.38,57.12
X$1124 86 449 443 439 269 58 452 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1125 m0 *1 96.6,57.12
X$1125 86 453 459 415 86 462 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1126 m0 *1 98.44,57.12
X$1126 86 442 417 472 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1127 m0 *1 99.82,57.12
X$1127 86 442 462 460 470 86 451 58 58 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $1130 m0 *1 105.8,57.12
X$1130 86 442 441 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1131 m0 *1 107.18,57.12
X$1131 86 440 439 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1132 r0 *1 1.38,57.12
X$1132 86 465 482 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1134 r0 *1 3.68,57.12
X$1134 58 71 489 69 487 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1147 r0 *1 40.02,57.12
X$1147 86 236 86 58 196 58 sky130_fd_sc_hd__buf_4
* cell instance $1157 r0 *1 61.18,57.12
X$1157 86 429 58 460 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1160 r0 *1 66.24,57.12
X$1160 86 464 417 476 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1161 r0 *1 67.62,57.12
X$1161 86 476 466 458 468 86 477 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1166 r0 *1 76.36,57.12
X$1166 58 71 473 69 479 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1170 r0 *1 88.78,57.12
X$1170 86 480 485 475 398 58 443 86 58 sky130_fd_sc_hd__nor4b_1
* cell instance $1171 r0 *1 92,57.12
X$1171 86 478 398 412 467 86 490 58 58 sky130_fd_sc_hd__nand4_1
* cell instance $1173 r0 *1 95.22,57.12
X$1173 58 376 467 473 474 86 86 58 sky130_fd_sc_hd__and3_1
* cell instance $1177 r0 *1 98.44,57.12
X$1177 86 472 459 471 468 86 470 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1178 r0 *1 101.2,57.12
X$1178 86 461 458 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1180 r0 *1 103.04,57.12
X$1180 86 450 438 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1191 m0 *1 1.38,62.56
X$1191 86 489 491 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1192 m0 *1 2.76,62.56
X$1192 86 481 508 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1193 m0 *1 4.14,62.56
X$1193 58 487 489 508 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1194 m0 *1 8.28,62.56
X$1194 58 488 456 482 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1197 m0 *1 17.02,62.56
X$1197 58 71 499 69 541 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1206 m0 *1 43.24,62.56
X$1206 58 71 510 69 543 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1210 m0 *1 57.04,62.56
X$1210 58 71 512 69 511 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1211 m0 *1 66.24,62.56
X$1211 86 453 466 495 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1212 m0 *1 67.62,62.56
X$1212 58 71 513 69 496 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $1213 m0 *1 77.28,62.56
X$1213 86 514 466 502 468 86 492 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1219 m0 *1 87.4,62.56
X$1219 86 382 58 453 86 58 sky130_fd_sc_hd__buf_2
* cell instance $1221 m0 *1 89.7,62.56
X$1221 86 478 467 480 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1222 m0 *1 91.08,62.56
X$1222 86 269 58 468 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1223 m0 *1 93.84,62.56
X$1223 86 494 485 475 484 58 423 86 58 sky130_fd_sc_hd__nor4_1
* cell instance $1225 m0 *1 96.6,62.56
X$1225 86 473 474 494 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1228 m0 *1 99.36,62.56
X$1228 58 71 507 69 509 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1231 r0 *1 4.14,62.56
X$1231 58 539 538 506 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1232 r0 *1 8.28,62.56
X$1232 86 515 498 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1233 r0 *1 9.66,62.56
X$1233 58 541 499 498 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1234 r0 *1 13.8,62.56
X$1234 86 523 497 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1239 r0 *1 18.4,62.56
X$1239 58 71 523 69 540 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1248 r0 *1 46.92,62.56
X$1248 86 500 607 544 86 543 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1249 r0 *1 48.76,62.56
X$1249 86 510 460 544 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1250 r0 *1 50.14,62.56
X$1250 86 429 58 501 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1254 r0 *1 56.12,62.56
X$1254 86 429 58 500 86 58 sky130_fd_sc_hd__buf_2
* cell instance $1255 r0 *1 57.96,62.56
X$1255 86 500 545 516 86 511 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1258 r0 *1 62.1,62.56
X$1258 86 501 546 512 86 516 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1261 r0 *1 65.32,62.56
X$1261 86 500 495 464 86 517 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1262 r0 *1 67.16,62.56
X$1262 86 500 477 517 86 463 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1268 r0 *1 72.68,62.56
X$1268 86 500 492 528 86 496 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1269 r0 *1 74.52,62.56
X$1269 86 501 551 513 86 528 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1270 r0 *1 76.36,62.56
X$1270 86 513 448 521 514 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $1272 r0 *1 80.04,62.56
X$1272 86 500 599 530 86 479 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1274 r0 *1 82.34,62.56
X$1274 86 501 531 473 86 530 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1276 r0 *1 84.64,62.56
X$1276 86 480 549 503 550 58 454 86 58 sky130_fd_sc_hd__nor4_1
* cell instance $1279 r0 *1 88.32,62.56
X$1279 86 269 58 548 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1280 r0 *1 91.08,62.56
X$1280 86 490 503 533 547 58 459 86 58 sky130_fd_sc_hd__nor4_1
* cell instance $1282 r0 *1 94.3,62.56
X$1282 86 518 485 475 484 58 536 86 58 sky130_fd_sc_hd__nor4_1
* cell instance $1287 r0 *1 98.44,62.56
X$1287 86 507 534 460 519 86 509 58 58 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $1288 r0 *1 101.66,62.56
X$1288 86 542 536 504 191 86 519 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1289 r0 *1 104.42,62.56
X$1289 86 486 502 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1290 r0 *1 105.8,62.56
X$1290 86 520 504 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1291 r0 *1 107.18,62.56
X$1291 86 469 471 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1301 m0 *1 2.3,68
X$1301 86 499 522 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1302 m0 *1 3.68,68
X$1302 58 71 538 69 539 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1305 m0 *1 17.48,68
X$1305 86 236 58 483 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1308 m0 *1 21.62,68
X$1308 58 540 523 557 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1313 m0 *1 29.44,68
X$1313 58 71 572 69 571 86 86 58 sky130_fd_sc_hd__dfrtp_4
* cell instance $1314 m0 *1 40.02,68
X$1314 58 71 586 69 524 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1315 m0 *1 49.22,68
X$1315 86 560 561 460 58 86 524 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1320 m0 *1 57.96,68
X$1320 86 562 897 191 58 86 545 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1322 m0 *1 61.64,68
X$1322 86 503 448 512 553 58 562 86 58 sky130_fd_sc_hd__nor4b_1
* cell instance $1324 m0 *1 65.78,68
X$1324 86 453 525 553 58 86 546 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1326 m0 *1 68.08,68
X$1326 86 521 526 553 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1328 m0 *1 69.92,68
X$1328 86 513 554 526 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1330 m0 *1 71.76,68
X$1330 86 529 527 521 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1332 m0 *1 73.6,68
X$1332 86 527 466 529 559 58 86 551 58 sky130_fd_sc_hd__a31oi_1
* cell instance $1334 m0 *1 76.82,68
X$1334 86 410 611 566 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1336 m0 *1 80.04,68
X$1336 58 550 529 513 512 86 86 58 sky130_fd_sc_hd__nand3_2
* cell instance $1339 m0 *1 84.64,68
X$1339 86 453 525 532 58 86 531 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1341 m0 *1 87.4,68
X$1341 86 579 548 565 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1343 m0 *1 89.24,68
X$1343 86 564 547 533 484 58 532 86 58 sky130_fd_sc_hd__nor4_1
* cell instance $1344 m0 *1 91.54,68
X$1344 86 535 563 555 518 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $1345 m0 *1 93.38,68
X$1345 86 507 555 563 535 58 86 474 58 sky130_fd_sc_hd__and4_1
* cell instance $1346 m0 *1 96.6,68
X$1346 86 453 536 415 86 534 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1347 m0 *1 98.44,68
X$1347 86 535 570 460 603 86 558 58 58 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $1349 m0 *1 102.12,68
X$1349 86 507 559 542 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1350 m0 *1 103.5,68
X$1350 86 513 493 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1351 m0 *1 104.88,68
X$1351 86 512 505 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1353 m0 *1 107.18,68
X$1353 86 507 537 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1354 r0 *1 1.38,68
X$1354 86 552 506 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1355 r0 *1 2.76,68
X$1355 86 567 582 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1356 r0 *1 4.14,68
X$1356 58 71 583 69 622 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1362 r0 *1 15.64,68
X$1362 58 71 584 69 605 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1366 r0 *1 29.9,68
X$1366 58 571 585 572 197 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1369 r0 *1 41.4,68
X$1369 86 586 86 58 561 58 sky130_fd_sc_hd__inv_1
* cell instance $1375 r0 *1 43.7,68
X$1375 58 594 588 561 587 615 86 86 58 sky130_fd_sc_hd__fa_1
* cell instance $1377 r0 *1 51.98,68
X$1377 58 71 573 69 589 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1380 r0 *1 62.56,68
X$1380 86 500 645 576 86 609 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1382 r0 *1 64.86,68
X$1382 86 501 577 578 86 576 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1385 r0 *1 68.08,68
X$1385 86 525 554 464 559 58 86 577 58 sky130_fd_sc_hd__a31oi_1
* cell instance $1390 r0 *1 70.84,68
X$1390 58 578 527 464 573 86 86 58 sky130_fd_sc_hd__and3_1
* cell instance $1391 r0 *1 73.14,68
X$1391 58 58 527 549 554 86 86 sky130_fd_sc_hd__nand2_2
* cell instance $1392 r0 *1 75.44,68
X$1392 58 71 529 69 590 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $1393 r0 *1 85.1,68
X$1393 58 610 565 549 503 382 529 86 86 58 sky130_fd_sc_hd__o41ai_1
* cell instance $1394 r0 *1 88.32,68
X$1394 86 473 448 564 608 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $1396 r0 *1 90.62,68
X$1396 86 484 503 533 547 58 568 86 58 sky130_fd_sc_hd__nor4_1
* cell instance $1398 r0 *1 93.38,68
X$1398 86 555 535 563 507 86 564 58 58 sky130_fd_sc_hd__nand4_1
* cell instance $1403 r0 *1 96.14,68
X$1403 86 453 568 415 86 570 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1406 r0 *1 98.9,68
X$1406 58 71 535 69 558 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $1407 m0 *1 1.38,73.44
X$1407 86 574 592 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1408 m0 *1 2.76,73.44
X$1408 86 575 614 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1410 m0 *1 4.6,73.44
X$1410 86 584 591 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1412 m0 *1 6.44,73.44
X$1412 58 71 604 69 623 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1413 m0 *1 15.64,73.44
X$1413 58 605 584 592 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1418 m0 *1 29.44,73.44
X$1418 58 71 632 69 626 86 86 58 sky130_fd_sc_hd__dfrtp_4
* cell instance $1421 m0 *1 42.78,73.44
X$1421 86 594 593 596 58 86 58 sky130_fd_sc_hd__nand2b_1
* cell instance $1422 m0 *1 45.08,73.44
X$1422 86 595 191 596 606 597 607 58 86 58 sky130_fd_sc_hd__a32oi_1
* cell instance $1423 m0 *1 48.3,73.44
X$1423 58 560 597 598 429 588 548 86 86 58 sky130_fd_sc_hd__a221oi_1
* cell instance $1430 m0 *1 59.8,73.44
X$1430 58 71 578 69 609 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1431 m0 *1 69,73.44
X$1431 86 464 554 618 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1435 m0 *1 75.44,73.44
X$1435 86 503 549 597 86 611 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1436 m0 *1 77.28,73.44
X$1436 86 529 566 415 610 58 590 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1440 m0 *1 86.48,73.44
X$1440 86 503 549 550 433 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $1442 m0 *1 90.16,73.44
X$1442 86 608 568 600 548 86 599 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1445 m0 *1 95.68,73.44
X$1445 86 535 559 601 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1447 m0 *1 97.52,73.44
X$1447 86 563 619 460 638 86 624 58 58 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $1448 m0 *1 100.74,73.44
X$1448 86 601 568 637 191 86 603 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1449 m0 *1 103.5,73.44
X$1449 86 556 579 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1450 m0 *1 104.88,73.44
X$1450 86 529 569 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1452 m0 *1 107.18,73.44
X$1452 86 580 600 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1455 r0 *1 2.76,73.44
X$1455 86 604 612 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1456 r0 *1 4.14,73.44
X$1456 58 622 583 582 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1457 r0 *1 8.28,73.44
X$1457 58 623 604 614 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1458 r0 *1 12.42,73.44
X$1458 86 613 585 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1467 r0 *1 22.54,73.44
X$1467 86 236 58 636 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1469 r0 *1 27.14,73.44
X$1469 58 71 628 69 625 86 86 58 sky130_fd_sc_hd__dfrtp_4
* cell instance $1471 r0 *1 38.18,73.44
X$1471 58 639 630 586 640 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $1474 r0 *1 43.24,73.44
X$1474 86 593 594 606 58 86 58 sky130_fd_sc_hd__nand2b_1
* cell instance $1475 r0 *1 45.54,73.44
X$1475 86 627 86 58 587 58 sky130_fd_sc_hd__inv_1
* cell instance $1477 r0 *1 47.38,73.44
X$1477 86 615 86 58 640 58 sky130_fd_sc_hd__inv_1
* cell instance $1479 r0 *1 50.6,73.44
X$1479 86 572 632 628 615 86 58 58 sky130_fd_sc_hd__or3b_1
* cell instance $1482 r0 *1 58.42,73.44
X$1482 86 573 86 58 643 58 sky130_fd_sc_hd__inv_1
* cell instance $1486 r0 *1 66.24,73.44
X$1486 86 617 616 191 58 86 645 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1487 r0 *1 68.08,73.44
X$1487 86 618 448 578 503 58 617 86 58 sky130_fd_sc_hd__nor4_1
* cell instance $1491 r0 *1 71.76,73.44
X$1491 86 464 578 573 646 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $1499 r0 *1 93.38,73.44
X$1499 86 484 485 475 535 58 634 86 58 sky130_fd_sc_hd__nor4b_1
* cell instance $1501 r0 *1 96.6,73.44
X$1501 86 473 581 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1504 r0 *1 98.9,73.44
X$1504 58 71 563 69 624 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $1515 m0 *1 2.76,78.88
X$1515 86 583 629 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1516 m0 *1 4.14,78.88
X$1516 58 71 700 69 660 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1524 m0 *1 30.36,78.88
X$1524 58 626 718 632 197 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1527 m0 *1 38.64,78.88
X$1527 86 627 639 630 58 86 684 58 sky130_fd_sc_hd__a21o_1
* cell instance $1528 m0 *1 41.4,78.88
X$1528 86 639 627 631 630 58 641 86 58 sky130_fd_sc_hd__a211oi_1
* cell instance $1529 m0 *1 44.16,78.88
X$1529 58 593 631 510 642 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $1530 m0 *1 48.76,78.88
X$1530 86 632 628 572 642 58 86 58 sky130_fd_sc_hd__nor3b_1
* cell instance $1536 m0 *1 57.96,78.88
X$1536 86 663 460 644 643 589 58 86 58 sky130_fd_sc_hd__o22ai_1
* cell instance $1537 m0 *1 60.26,78.88
X$1537 86 429 597 633 58 86 644 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1540 m0 *1 64.86,78.88
X$1540 86 464 578 664 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1541 m0 *1 66.24,78.88
X$1541 58 71 647 69 652 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $1544 m0 *1 78.66,78.88
X$1544 86 448 503 549 668 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $1545 m0 *1 80.5,78.88
X$1545 86 646 550 667 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1546 m0 *1 81.88,78.88
X$1546 86 550 646 547 58 86 58 sky130_fd_sc_hd__or2_1
* cell instance $1549 m0 *1 85.56,78.88
X$1549 86 653 549 650 550 58 710 86 58 sky130_fd_sc_hd__nor4_1
* cell instance $1551 m0 *1 91.54,78.88
X$1551 86 535 563 478 653 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $1552 m0 *1 93.38,78.88
X$1552 86 654 674 478 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1553 m0 *1 94.76,78.88
X$1553 86 464 621 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1555 m0 *1 96.6,78.88
X$1555 86 453 634 415 86 619 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1556 m0 *1 98.44,78.88
X$1556 86 563 559 661 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1558 m0 *1 100.28,78.88
X$1558 86 661 634 656 191 86 638 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1559 m0 *1 103.04,78.88
X$1559 86 620 656 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1560 m0 *1 104.42,78.88
X$1560 86 602 637 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1561 m0 *1 105.8,78.88
X$1561 86 535 658 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1562 m0 *1 107.18,78.88
X$1562 86 563 635 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1565 r0 *1 2.76,78.88
X$1565 86 649 678 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1566 r0 *1 4.14,78.88
X$1566 86 648 679 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1568 r0 *1 5.98,78.88
X$1568 58 71 681 69 715 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1572 r0 *1 16.56,78.88
X$1572 58 71 683 69 694 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1575 r0 *1 28.52,78.88
X$1575 58 625 805 628 197 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1578 r0 *1 35.42,78.88
X$1578 86 572 628 632 695 58 86 58 sky130_fd_sc_hd__and3b_1
* cell instance $1580 r0 *1 40.48,78.88
X$1580 86 631 593 684 58 86 736 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1589 r0 *1 57.04,78.88
X$1589 58 663 573 448 633 866 86 86 58 sky130_fd_sc_hd__o31a_1
* cell instance $1590 r0 *1 60.26,78.88
X$1590 86 651 671 672 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1591 r0 *1 61.64,78.88
X$1591 86 664 533 651 671 86 633 58 58 sky130_fd_sc_hd__a211o_1
* cell instance $1592 r0 *1 64.86,78.88
X$1592 86 650 58 503 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1594 r0 *1 68.54,78.88
X$1594 86 453 672 410 86 666 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1597 r0 *1 70.84,78.88
X$1597 86 647 666 460 696 86 652 58 58 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $1599 r0 *1 77.74,78.88
X$1599 58 71 665 69 687 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $1600 r0 *1 87.4,78.88
X$1600 86 693 433 673 468 86 686 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1602 r0 *1 91.08,78.88
X$1602 86 685 503 533 547 58 655 86 58 sky130_fd_sc_hd__nor4_1
* cell instance $1603 r0 *1 93.38,78.88
X$1603 86 674 654 484 58 86 58 sky130_fd_sc_hd__or2_1
* cell instance $1604 r0 *1 95.68,78.88
X$1604 86 453 655 415 86 662 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1608 r0 *1 98.44,78.88
X$1608 86 682 662 460 675 86 680 58 58 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $1609 r0 *1 101.66,78.88
X$1609 86 717 655 657 191 86 675 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1610 r0 *1 104.42,78.88
X$1610 86 659 657 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1621 m0 *1 1.38,84.32
X$1621 58 71 692 69 714 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1622 m0 *1 10.58,84.32
X$1622 58 660 700 679 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1623 m0 *1 14.72,84.32
X$1623 58 694 683 716 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1632 m0 *1 35.88,84.32
X$1632 58 701 702 719 695 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $1634 m0 *1 40.94,84.32
X$1634 86 606 631 720 58 86 58 sky130_fd_sc_hd__nand2b_1
* cell instance $1635 m0 *1 43.24,84.32
X$1635 86 593 631 703 701 697 86 58 58 sky130_fd_sc_hd__o211ai_1
* cell instance $1636 m0 *1 46,84.32
X$1636 86 606 704 688 58 86 707 58 sky130_fd_sc_hd__a21o_1
* cell instance $1637 m0 *1 48.76,84.32
X$1637 86 631 702 704 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1644 m0 *1 59.8,84.32
X$1644 86 707 724 723 58 86 671 58 sky130_fd_sc_hd__a21o_1
* cell instance $1645 m0 *1 62.56,84.32
X$1645 86 651 724 731 86 58 58 sky130_fd_sc_hd__and2_0
* cell instance $1647 m0 *1 66.7,84.32
X$1647 86 647 417 725 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1648 m0 *1 68.08,84.32
X$1648 86 725 672 726 468 86 696 58 58 sky130_fd_sc_hd__a22oi_1
* cell instance $1650 m0 *1 72.68,84.32
X$1650 58 58 708 533 647 86 86 sky130_fd_sc_hd__nand2_2
* cell instance $1653 m0 *1 77.28,84.32
X$1653 86 500 686 689 86 687 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1654 m0 *1 79.12,84.32
X$1654 58 690 525 554 559 667 691 86 86 58 sky130_fd_sc_hd__a41oi_1
* cell instance $1655 m0 *1 82.34,84.32
X$1655 86 501 690 665 86 689 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1657 m0 *1 84.64,84.32
X$1657 86 448 665 691 693 58 86 58 sky130_fd_sc_hd__nor3b_1
* cell instance $1660 m0 *1 89.7,84.32
X$1660 86 555 448 722 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1661 m0 *1 91.08,84.32
X$1661 86 691 665 711 685 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $1662 m0 *1 92.92,84.32
X$1662 58 682 711 665 691 86 654 86 58 sky130_fd_sc_hd__nand4_2
* cell instance $1664 m0 *1 97.98,84.32
X$1664 86 676 673 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1665 m0 *1 99.36,84.32
X$1665 58 71 682 69 680 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1666 r0 *1 1.38,84.32
X$1666 86 683 698 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1667 r0 *1 2.76,84.32
X$1667 58 714 692 678 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1668 r0 *1 6.9,84.32
X$1668 58 715 681 734 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1669 r0 *1 11.04,84.32
X$1669 86 669 716 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1672 r0 *1 13.8,84.32
X$1672 86 670 718 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1677 r0 *1 17.02,84.32
X$1677 86 699 754 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1682 r0 *1 27.14,84.32
X$1682 58 71 719 69 735 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1683 r0 *1 36.34,84.32
X$1683 86 736 701 755 86 58 58 sky130_fd_sc_hd__xnor2_1
* cell instance $1686 r0 *1 40.94,84.32
X$1686 86 702 701 720 58 86 756 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1689 r0 *1 43.24,84.32
X$1689 86 701 702 706 703 688 86 58 58 sky130_fd_sc_hd__o211ai_1
* cell instance $1690 r0 *1 46,84.32
X$1690 86 764 703 702 58 86 705 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1691 r0 *1 47.84,84.32
X$1691 86 697 641 705 58 759 86 58 sky130_fd_sc_hd__o21ai_2
* cell instance $1692 r0 *1 51.06,84.32
X$1692 86 697 641 738 705 758 86 58 58 sky130_fd_sc_hd__o211ai_1
* cell instance $1696 r0 *1 57.04,84.32
X$1696 58 650 739 706 729 730 759 86 86 58 sky130_fd_sc_hd__a41oi_2
* cell instance $1697 r0 *1 63.02,84.32
X$1697 86 729 730 723 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1700 r0 *1 65.78,84.32
X$1700 86 707 732 731 86 466 58 58 sky130_fd_sc_hd__a21oi_2
* cell instance $1705 r0 *1 70.84,84.32
X$1705 86 707 731 709 86 58 58 sky130_fd_sc_hd__and2_0
* cell instance $1707 r0 *1 74.06,84.32
X$1707 86 647 708 757 86 58 58 sky130_fd_sc_hd__and2_0
* cell instance $1708 r0 *1 76.36,84.32
X$1708 86 709 58 475 86 58 sky130_fd_sc_hd__buf_2
* cell instance $1710 r0 *1 78.66,84.32
X$1710 86 667 732 737 58 86 58 sky130_fd_sc_hd__nand2b_1
* cell instance $1713 r0 *1 83.72,84.32
X$1713 86 737 58 485 86 58 sky130_fd_sc_hd__buf_2
* cell instance $1716 r0 *1 90.16,84.32
X$1716 86 691 665 748 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1717 r0 *1 91.54,84.32
X$1717 86 722 710 721 548 58 749 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1718 r0 *1 94.76,84.32
X$1718 86 772 548 751 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1720 r0 *1 96.14,84.32
X$1720 86 417 710 410 86 771 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1725 r0 *1 101.66,84.32
X$1725 86 682 559 717 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1728 r0 *1 104.42,84.32
X$1728 86 555 712 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1729 r0 *1 105.8,84.32
X$1729 86 665 713 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1730 r0 *1 107.18,84.32
X$1730 86 682 677 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1741 m0 *1 2.76,89.76
X$1741 58 71 762 69 770 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1743 m0 *1 13.8,89.76
X$1743 58 71 773 69 753 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1749 m0 *1 29.9,89.76
X$1749 86 742 741 735 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1751 m0 *1 32.2,89.76
X$1751 86 719 767 742 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1753 m0 *1 34.5,89.76
X$1753 58 741 597 888 501 755 468 86 86 58 sky130_fd_sc_hd__a221oi_1
* cell instance $1755 m0 *1 38.64,89.76
X$1755 86 756 703 763 86 58 58 sky130_fd_sc_hd__xnor2_1
* cell instance $1756 m0 *1 41.86,89.76
X$1756 58 703 764 790 743 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $1757 m0 *1 46.46,89.76
X$1757 86 628 572 632 743 58 86 58 sky130_fd_sc_hd__nor3b_1
* cell instance $1759 m0 *1 51.06,89.76
X$1759 86 744 728 738 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1760 m0 *1 52.44,89.76
X$1760 86 744 706 764 58 86 724 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1761 m0 *1 54.28,89.76
X$1761 86 706 744 728 795 86 58 58 sky130_fd_sc_hd__or3_1
* cell instance $1763 m0 *1 57.04,89.76
X$1763 58 525 729 706 739 759 730 86 86 58 sky130_fd_sc_hd__a41o_2
* cell instance $1764 m0 *1 61.18,89.76
X$1764 86 730 728 729 86 765 58 58 sky130_fd_sc_hd__o21a_1
* cell instance $1765 m0 *1 63.94,89.76
X$1765 86 707 724 778 86 58 58 sky130_fd_sc_hd__and2_0
* cell instance $1766 m0 *1 66.24,89.76
X$1766 86 745 554 765 86 58 732 58 sky130_fd_sc_hd__o21ai_1
* cell instance $1769 m0 *1 70.84,89.76
X$1769 86 501 746 708 86 799 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1770 m0 *1 72.68,89.76
X$1770 86 559 647 525 58 86 746 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1772 m0 *1 74.98,89.76
X$1772 86 757 86 58 554 58 sky130_fd_sc_hd__buf_4
* cell instance $1774 m0 *1 78.2,89.76
X$1774 58 766 667 525 559 747 554 86 86 58 sky130_fd_sc_hd__a41oi_1
* cell instance $1775 m0 *1 81.42,89.76
X$1775 86 783 550 776 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1781 m0 *1 86.02,89.76
X$1781 86 382 58 559 86 58 sky130_fd_sc_hd__buf_2
* cell instance $1782 m0 *1 87.86,89.76
X$1782 86 382 475 485 752 86 58 58 sky130_fd_sc_hd__or3_1
* cell instance $1783 m0 *1 90.16,89.76
X$1783 86 475 485 748 775 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $1785 m0 *1 92.46,89.76
X$1785 86 711 752 748 751 86 58 789 58 sky130_fd_sc_hd__o31ai_1
* cell instance $1786 m0 *1 95.22,89.76
X$1786 86 767 749 555 771 58 768 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1788 m0 *1 98.9,89.76
X$1788 58 71 555 69 768 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1791 r0 *1 1.84,89.76
X$1791 58 770 762 785 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1792 r0 *1 5.98,89.76
X$1792 58 71 788 69 787 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1795 r0 *1 15.64,89.76
X$1795 86 773 740 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1796 r0 *1 17.02,89.76
X$1796 58 753 773 754 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1802 r0 *1 37.72,89.76
X$1802 58 836 597 890 501 763 468 86 86 58 sky130_fd_sc_hd__a221oi_1
* cell instance $1809 r0 *1 46.46,89.76
X$1809 86 628 632 819 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1811 r0 *1 48.3,89.76
X$1811 86 759 706 86 792 58 58 sky130_fd_sc_hd__xor2_1
* cell instance $1814 r0 *1 54.28,89.76
X$1814 86 729 728 758 795 777 86 58 58 sky130_fd_sc_hd__o211ai_1
* cell instance $1815 r0 *1 57.04,89.76
X$1815 86 729 730 744 781 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $1816 r0 *1 58.88,89.76
X$1816 86 651 781 739 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1817 r0 *1 60.26,89.76
X$1817 86 745 730 728 58 86 651 58 sky130_fd_sc_hd__a21oi_1
* cell instance $1819 r0 *1 63.02,89.76
X$1819 86 778 729 824 86 58 58 sky130_fd_sc_hd__xnor2_1
* cell instance $1820 r0 *1 66.24,89.76
X$1820 86 191 895 798 525 647 782 58 86 58 sky130_fd_sc_hd__a32oi_1
* cell instance $1824 r0 *1 70.84,89.76
X$1824 86 500 782 799 86 797 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1827 r0 *1 78.2,89.76
X$1827 86 801 191 776 747 668 800 58 86 58 sky130_fd_sc_hd__a32oi_1
* cell instance $1828 r0 *1 81.42,89.76
X$1828 86 501 766 783 86 796 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1831 r0 *1 88.78,89.76
X$1831 86 806 654 747 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1833 r0 *1 90.62,89.76
X$1833 86 559 775 410 86 774 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1834 r0 *1 92.46,89.76
X$1834 86 711 774 415 789 58 786 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1837 r0 *1 96.6,89.76
X$1837 86 733 721 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1841 r0 *1 100.74,89.76
X$1841 86 769 772 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1845 r0 *1 107.18,89.76
X$1845 86 711 750 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1854 m0 *1 1.38,95.2
X$1854 86 762 780 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1855 m0 *1 2.76,95.2
X$1855 86 681 760 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1857 m0 *1 4.6,95.2
X$1857 58 787 788 812 196 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1858 m0 *1 8.74,95.2
X$1858 58 71 804 69 813 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1860 m0 *1 18.86,95.2
X$1860 58 71 816 69 833 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1865 m0 *1 33.58,95.2
X$1865 58 71 790 69 837 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1868 m0 *1 46.92,95.2
X$1868 86 572 819 793 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1869 m0 *1 48.3,95.2
X$1869 58 706 744 818 793 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $1871 m0 *1 54.74,95.2
X$1871 86 841 86 58 729 58 sky130_fd_sc_hd__clkbuf_2
* cell instance $1874 m0 *1 57.96,95.2
X$1874 86 817 86 58 730 58 sky130_fd_sc_hd__clkbuf_2
* cell instance $1878 m0 *1 65.78,95.2
X$1878 58 71 708 69 797 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1880 m0 *1 75.44,95.2
X$1880 86 403 58 597 86 58 sky130_fd_sc_hd__clkbuf_4
* cell instance $1881 m0 *1 78.2,95.2
X$1881 86 500 800 796 86 815 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1886 m0 *1 85.1,95.2
X$1886 86 475 485 403 86 814 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1887 m0 *1 86.94,95.2
X$1887 86 475 485 654 794 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $1890 m0 *1 90.16,95.2
X$1890 86 783 747 791 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $1891 m0 *1 91.54,95.2
X$1891 86 826 783 811 674 86 58 58 sky130_fd_sc_hd__nand3_1
* cell instance $1892 m0 *1 93.38,95.2
X$1892 86 475 485 791 784 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $1893 m0 *1 95.22,95.2
X$1893 86 417 784 410 86 810 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1895 m0 *1 97.98,95.2
X$1895 58 71 711 69 786 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1898 r0 *1 1.38,95.2
X$1898 86 779 785 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1899 r0 *1 2.76,95.2
X$1899 86 802 821 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1900 r0 *1 4.14,95.2
X$1900 86 538 829 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1901 r0 *1 5.52,95.2
X$1901 86 727 734 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1902 r0 *1 6.9,95.2
X$1902 86 831 830 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1903 r0 *1 8.28,95.2
X$1903 58 813 804 821 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1905 r0 *1 13.34,95.2
X$1905 86 761 805 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1912 r0 *1 18.86,95.2
X$1912 58 833 816 860 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1913 r0 *1 23,95.2
X$1913 58 71 835 69 834 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1916 r0 *1 37.72,95.2
X$1916 86 822 836 837 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1918 r0 *1 40.94,95.2
X$1918 86 790 767 822 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1922 r0 *1 43.24,95.2
X$1922 86 790 838 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1923 r0 *1 44.62,95.2
X$1923 86 839 595 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1927 r0 *1 51.98,95.2
X$1927 86 572 632 628 842 58 86 58 sky130_fd_sc_hd__and3b_1
* cell instance $1928 r0 *1 55.2,95.2
X$1928 58 841 728 823 842 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $1929 r0 *1 59.8,95.2
X$1929 86 777 730 850 86 58 58 sky130_fd_sc_hd__xnor2_1
* cell instance $1931 r0 *1 66.7,95.2
X$1931 58 858 597 825 429 824 468 86 86 58 sky130_fd_sc_hd__a221oi_1
* cell instance $1935 r0 *1 70.84,95.2
X$1935 86 708 417 798 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1938 r0 *1 76.82,95.2
X$1938 58 71 783 69 815 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1941 r0 *1 87.4,95.2
X$1941 58 807 403 806 840 794 548 86 86 58 sky130_fd_sc_hd__a32o_1
* cell instance $1942 r0 *1 91.08,95.2
X$1942 86 767 807 826 827 58 832 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1944 r0 *1 94.76,95.2
X$1944 86 767 828 811 810 58 808 86 58 sky130_fd_sc_hd__a22o_1
* cell instance $1948 r0 *1 99.36,95.2
X$1948 58 71 811 69 808 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1957 m0 *1 1.38,100.64
X$1957 86 692 803 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1958 m0 *1 2.76,100.64
X$1958 86 852 859 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1959 m0 *1 4.14,100.64
X$1959 58 71 852 69 877 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1961 m0 *1 13.8,100.64
X$1961 58 71 854 69 853 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1962 m0 *1 23,100.64
X$1962 86 848 557 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1964 m0 *1 24.84,100.64
X$1964 58 861 886 885 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $1969 m0 *1 32.66,100.64
X$1969 86 845 767 863 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1970 m0 *1 34.04,100.64
X$1970 58 855 597 889 501 846 468 86 86 58 sky130_fd_sc_hd__a221oi_1
* cell instance $1972 m0 *1 39.1,100.64
X$1972 58 846 627 845 849 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $1975 m0 *1 46,100.64
X$1975 86 818 767 914 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $1977 m0 *1 48.3,100.64
X$1977 58 864 597 894 429 792 468 86 86 58 sky130_fd_sc_hd__a221oi_1
* cell instance $1982 m0 *1 57.04,100.64
X$1982 58 817 745 865 851 86 86 58 sky130_fd_sc_hd__ha_1
* cell instance $1983 m0 *1 61.64,100.64
X$1983 58 868 597 867 429 850 548 86 86 58 sky130_fd_sc_hd__a221oi_1
* cell instance $1985 m0 *1 65.78,100.64
X$1985 86 708 856 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $1986 m0 *1 67.16,100.64
X$1986 58 71 823 69 847 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $1989 m0 *1 77.74,100.64
X$1989 58 410 767 86 86 58 sky130_fd_sc_hd__buf_6
* cell instance $1993 m0 *1 84.64,100.64
X$1993 86 691 410 814 58 86 909 58 sky130_fd_sc_hd__a21boi_0
* cell instance $1994 m0 *1 87.4,100.64
X$1994 86 417 794 410 86 827 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $1995 m0 *1 89.24,100.64
X$1995 86 826 86 58 806 58 sky130_fd_sc_hd__inv_1
* cell instance $1998 m0 *1 93.38,100.64
X$1998 58 71 826 69 832 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $2001 m0 *1 107.18,100.64
X$2001 86 811 809 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2002 r0 *1 1.38,100.64
X$2002 86 899 870 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2003 r0 *1 2.76,100.64
X$2003 86 920 879 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2004 r0 *1 4.14,100.64
X$2004 86 843 812 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2006 r0 *1 5.98,100.64
X$2006 58 71 831 69 878 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $2009 r0 *1 15.64,100.64
X$2009 58 853 854 882 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $2010 r0 *1 19.78,100.64
X$2010 86 883 860 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2011 r0 *1 21.16,100.64
X$2011 86 816 884 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2012 r0 *1 22.54,100.64
X$2012 58 71 886 69 861 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $2013 r0 *1 31.74,100.64
X$2013 86 863 855 862 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $2014 r0 *1 33.12,100.64
X$2014 58 71 845 69 862 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $2019 r0 *1 44.16,100.64
X$2019 58 71 818 69 892 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $2020 r0 *1 53.36,100.64
X$2020 58 628 851 572 632 86 86 58 sky130_fd_sc_hd__and3_1
* cell instance $2021 r0 *1 55.66,100.64
X$2021 86 896 548 866 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $2022 r0 *1 57.04,100.64
X$2022 58 71 865 69 898 86 86 58 sky130_fd_sc_hd__dfrtp_1
* cell instance $2023 r0 *1 66.24,100.64
X$2023 86 857 616 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2025 r0 *1 68.54,100.64
X$2025 86 872 858 847 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $2029 r0 *1 70.84,100.64
X$2029 86 578 893 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2030 r0 *1 72.22,100.64
X$2030 86 823 767 872 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $2032 r0 *1 77.28,100.64
X$2032 86 891 801 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2033 r0 *1 78.66,100.64
X$2033 58 71 691 69 887 86 86 58 sky130_fd_sc_hd__dfrtp_2
* cell instance $2034 r0 *1 88.32,100.64
X$2034 86 881 548 874 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $2035 r0 *1 89.7,100.64
X$2035 86 691 752 874 86 904 58 58 sky130_fd_sc_hd__o21ai_0
* cell instance $2036 r0 *1 91.54,100.64
X$2036 86 783 880 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2037 r0 *1 92.92,100.64
X$2037 86 876 548 875 86 58 58 sky130_fd_sc_hd__nand2_1
* cell instance $2038 r0 *1 94.3,100.64
X$2038 86 811 752 791 875 86 58 828 58 sky130_fd_sc_hd__o31ai_1
* cell instance $2054 m0 *1 1.38,106.08
X$2054 86 804 820 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2055 m0 *1 2.76,106.08
X$2055 86 788 869 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2056 m0 *1 4.14,106.08
X$2056 58 877 852 870 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $2057 m0 *1 8.28,106.08
X$2057 58 878 831 879 483 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $2058 m0 *1 12.42,106.08
X$2058 86 700 844 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2062 m0 *1 15.64,106.08
X$2062 86 854 900 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2063 m0 *1 17.02,106.08
X$2063 86 906 882 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2064 m0 *1 18.4,106.08
X$2064 58 834 835 937 636 86 86 58 sky130_fd_sc_hd__mux2_1
* cell instance $2065 m0 *1 22.54,106.08
X$2065 86 908 937 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2066 m0 *1 23.92,106.08
X$2066 86 901 885 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2067 m0 *1 25.3,106.08
X$2067 86 886 921 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2068 m0 *1 26.68,106.08
X$2068 86 835 922 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2072 m0 *1 30.36,106.08
X$2072 86 719 923 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2073 m0 *1 31.74,106.08
X$2073 86 632 871 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2074 m0 *1 33.12,106.08
X$2074 86 910 889 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2076 m0 *1 34.96,106.08
X$2076 86 924 888 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2077 m0 *1 36.34,106.08
X$2077 86 845 925 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2079 m0 *1 38.18,106.08
X$2079 86 911 890 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2080 m0 *1 39.56,106.08
X$2080 86 572 628 632 849 58 86 58 sky130_fd_sc_hd__nor3_1
* cell instance $2081 m0 *1 41.4,106.08
X$2081 86 586 926 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2084 m0 *1 43.7,106.08
X$2084 86 628 927 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2085 m0 *1 45.08,106.08
X$2085 86 914 864 892 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $2087 m0 *1 47.38,106.08
X$2087 86 572 928 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2088 m0 *1 48.76,106.08
X$2088 86 917 598 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2089 m0 *1 50.14,106.08
X$2089 86 919 894 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2090 m0 *1 51.52,106.08
X$2090 86 510 929 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2092 m0 *1 53.82,106.08
X$2092 86 818 930 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2096 m0 *1 57.04,106.08
X$2096 86 918 896 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2097 m0 *1 58.42,106.08
X$2097 86 916 897 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2098 m0 *1 59.8,106.08
X$2098 86 573 931 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2099 m0 *1 61.18,106.08
X$2099 86 915 867 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2100 m0 *1 62.56,106.08
X$2100 86 868 902 898 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $2101 m0 *1 63.94,106.08
X$2101 86 865 767 902 58 86 58 sky130_fd_sc_hd__nor2_1
* cell instance $2102 m0 *1 65.32,106.08
X$2102 86 865 932 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2103 m0 *1 66.7,106.08
X$2103 86 913 895 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2105 m0 *1 69,106.08
X$2105 86 912 825 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2107 m0 *1 70.84,106.08
X$2107 86 903 726 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2108 m0 *1 72.22,106.08
X$2108 86 647 933 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2111 m0 *1 74.98,106.08
X$2111 86 823 934 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2116 m0 *1 84.64,106.08
X$2116 86 767 904 909 58 86 887 58 sky130_fd_sc_hd__a21o_1
* cell instance $2117 m0 *1 87.4,106.08
X$2117 86 873 881 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2118 m0 *1 88.78,106.08
X$2118 86 907 840 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2120 m0 *1 91.08,106.08
X$2120 86 691 935 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2123 m0 *1 93.84,106.08
X$2123 86 905 876 58 86 58 sky130_fd_sc_hd__clkbuf_1
* cell instance $2125 m0 *1 96.14,106.08
X$2125 86 826 936 58 86 58 sky130_fd_sc_hd__clkbuf_1
.ENDS ahb_lite_master

* cell sky130_fd_sc_hd__nor3b_4
* pin VGND
* pin A
* pin B
* pin Y
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_4 1 2 3 4 5 7 10 11
* net 1 VGND
* net 2 A
* net 3 B
* net 4 Y
* net 5 C_N
* net 7 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.11,1.985 pfet_01v8_hvt
M$1 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 4.79,1.985 pfet_01v8_hvt
M$5 4 6 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 7 5 6 10 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=135000000000P PS=2560000U PD=1270000U
* device instance $10 r0 *1 0.91,1.985 pfet_01v8_hvt
M$10 8 2 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $14 r0 *1 0.49,0.56 nfet_01v8
M$14 1 5 6 11 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $15 r0 *1 0.91,0.56 nfet_01v8
M$15 4 2 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $19 r0 *1 3.11,0.56 nfet_01v8
M$19 4 3 1 11 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $23 r0 *1 4.79,0.56 nfet_01v8
M$23 4 6 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor3b_4

* cell sky130_fd_sc_hd__nor3b_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_2 1 2 3 4 6 9 10 11
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 6 C_N
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 2 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=415000000000P PS=3830000U PD=3830000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 9 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 4.13,1.695 pfet_01v8_hvt
M$7 9 6 5 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $8 r0 *1 4.13,0.675 nfet_01v8
M$8 1 6 5 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=269750000000P
+ PS=2740000U PD=2780000U
* device instance $11 r0 *1 0.49,0.56 nfet_01v8
M$11 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $13 r0 *1 1.33,0.56 nfet_01v8
M$13 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3b_2

* cell sky130_fd_sc_hd__o21bai_1
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21bai_1 1 2 4 5 7 8 9 10
* net 1 VPB
* net 2 B1_N
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 VGND
* net 9 Y
* device instance $1 r0 *1 0.86,1.97 pfet_01v8_hvt
M$1 3 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=178250000000P AD=109200000000P
+ PS=1400000U PD=1360000U
* device instance $2 r0 *1 1.41,1.985 pfet_01v8_hvt
M$2 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=178250000000P
+ AD=152500000000P PS=1400000U PD=1305000U
* device instance $3 r0 *1 1.865,1.985 pfet_01v8_hvt
M$3 11 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=127500000000P PS=1305000U PD=1255000U
* device instance $4 r0 *1 2.27,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=127500000000P
+ AD=280000000000P PS=1255000U PD=2560000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 5 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.675 nfet_01v8
M$8 3 2 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__o21bai_1

* cell sky130_fd_sc_hd__a41o_1
* pin VGND
* pin X
* pin A2
* pin A3
* pin B1
* pin A1
* pin A4
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41o_1 1 2 4 5 6 7 8 12 13 15
* net 1 VGND
* net 2 X
* net 4 A2
* net 5 A3
* net 6 B1
* net 7 A1
* net 8 A4
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 14 6 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 1.83,1.985 pfet_01v8_hvt
M$2 12 7 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.25,1.985 pfet_01v8_hvt
M$3 14 4 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.73,1.985 pfet_01v8_hvt
M$4 12 5 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $5 r0 *1 3.21,1.985 pfet_01v8_hvt
M$5 14 8 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 12 3 2 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=160875000000P
+ PS=1820000U PD=1145000U
* device instance $8 r0 *1 1.115,0.56 nfet_01v8
M$8 3 6 1 15 nfet_01v8 L=150000U W=650000U AS=160875000000P AD=183625000000P
+ PS=1145000U PD=1215000U
* device instance $9 r0 *1 1.83,0.56 nfet_01v8
M$9 10 7 3 15 nfet_01v8 L=150000U W=650000U AS=183625000000P AD=87750000000P
+ PS=1215000U PD=920000U
* device instance $10 r0 *1 2.25,0.56 nfet_01v8
M$10 9 4 10 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $11 r0 *1 2.73,0.56 nfet_01v8
M$11 11 5 9 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 1 8 11 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a41o_1

* cell sky130_fd_sc_hd__nor3_2
* pin VGND
* pin A
* pin Y
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3_2 1 2 3 4 5 7 9 10
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 B
* net 5 C
* net 7 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 7 2 6 9 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 6 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 3 5 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 3 2 1 10 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $11 r0 *1 1.33,0.56 nfet_01v8
M$11 3 4 1 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3_2

* cell sky130_fd_sc_hd__nor2_4
* pin VGND
* pin B
* pin Y
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor2_4 1 2 3 4 6 7 8
* net 1 VGND
* net 2 B
* net 3 Y
* net 4 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 4 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $5 r0 *1 2.17,1.985 pfet_01v8_hvt
M$5 3 2 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=675000000000P PS=5080000U PD=6350000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 3 4 1 8 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $13 r0 *1 2.17,0.56 nfet_01v8
M$13 3 2 1 8 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor2_4

* cell sky130_fd_sc_hd__or2_0
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_0 1 2 3 4 6 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 9 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.985 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=98950000000P
+ PS=630000U PD=975000U
* device instance $3 r0 *1 1.52,2.095 pfet_01v8_hvt
M$3 4 5 7 1 pfet_01v8_hvt L=150000U W=640000U AS=98950000000P AD=217600000000P
+ PS=975000U PD=1960000U
* device instance $4 r0 *1 0.615,0.675 nfet_01v8
M$4 5 2 6 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.675 nfet_01v8
M$5 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=70350000000P
+ PS=690000U PD=755000U
* device instance $6 r0 *1 1.52,0.675 nfet_01v8
M$6 4 5 6 8 nfet_01v8 L=150000U W=420000U AS=70350000000P AD=109200000000P
+ PS=755000U PD=1360000U
.ENDS sky130_fd_sc_hd__or2_0

* cell sky130_fd_sc_hd__a22oi_2
* pin VGND
* pin B2
* pin B1
* pin Y
* pin A1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_2 1 3 4 5 7 8 10 11 12
* net 1 VGND
* net 3 B2
* net 4 B1
* net 5 Y
* net 7 A1
* net 8 A2
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 3.51,1.985 pfet_01v8_hvt
M$3 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 9 3 5 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 9 4 5 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 2.67,0.56 nfet_01v8
M$9 5 7 6 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 3.51,0.56 nfet_01v8
M$11 1 8 6 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 3 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 5 4 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a22oi_2

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 1.85,0.56 nfet_01v8
M$7 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.27,0.56 nfet_01v8
M$8 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 0.89,0.56 nfet_01v8
M$10 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__o2111ai_1
* pin VPB
* pin D1
* pin C1
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2111ai_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 D1
* net 3 C1
* net 4 B1
* net 5 A2
* net 6 A1
* net 8 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.67,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.1,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=195000000000P PS=1280000U PD=1390000U
* device instance $3 r0 *1 1.64,1.985 pfet_01v8_hvt
M$3 9 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=202500000000P PS=1390000U PD=1405000U
* device instance $4 r0 *1 2.195,1.985 pfet_01v8_hvt
M$4 12 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=202500000000P
+ AD=195000000000P PS=1405000U PD=1390000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 8 6 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=265000000000P PS=1390000U PD=2530000U
* device instance $6 r0 *1 0.74,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $7 r0 *1 1.1,0.56 nfet_01v8
M$7 13 3 14 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=126750000000P
+ PS=860000U PD=1040000U
* device instance $8 r0 *1 1.64,0.56 nfet_01v8
M$8 7 4 13 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=131625000000P
+ PS=1040000U PD=1055000U
* device instance $9 r0 *1 2.195,0.56 nfet_01v8
M$9 10 5 7 11 nfet_01v8 L=150000U W=650000U AS=131625000000P AD=126750000000P
+ PS=1055000U PD=1040000U
* device instance $10 r0 *1 2.735,0.56 nfet_01v8
M$10 7 6 10 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=172250000000P
+ PS=1040000U PD=1830000U
.ENDS sky130_fd_sc_hd__o2111ai_1

* cell sky130_fd_sc_hd__dlymetal6s2s_1
* pin VGND
* pin X
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dlymetal6s2s_1 1 3 8 9 10 11
* net 1 VGND
* net 3 X
* net 8 A
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.655,2.275 pfet_01v8_hvt
M$1 6 5 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 4.13,1.985 pfet_01v8_hvt
M$2 7 6 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 2.24,2.275 pfet_01v8_hvt
M$3 4 3 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $4 r0 *1 2.715,1.985 pfet_01v8_hvt
M$4 5 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $5 r0 *1 0.645,2.275 pfet_01v8_hvt
M$5 2 8 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $6 r0 *1 1.12,1.985 pfet_01v8_hvt
M$6 3 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 3.655,0.445 nfet_01v8
M$7 1 5 6 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $8 r0 *1 4.13,0.56 nfet_01v8
M$8 7 6 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $9 r0 *1 0.645,0.445 nfet_01v8
M$9 1 8 2 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $10 r0 *1 1.12,0.56 nfet_01v8
M$10 3 2 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 2.24,0.445 nfet_01v8
M$11 1 3 4 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $12 r0 *1 2.715,0.56 nfet_01v8
M$12 5 4 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
.ENDS sky130_fd_sc_hd__dlymetal6s2s_1

* cell sky130_fd_sc_hd__nand3b_1
* pin VPB
* pin A_N
* pin C
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A_N
* net 3 C
* net 4 B
* net 5 Y
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 8 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 8 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 5 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=280000000000P PS=1385000U PD=2560000U
* device instance $5 r0 *1 0.6,0.675 nfet_01v8
M$5 6 2 7 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $6 r0 *1 1.085,0.56 nfet_01v8
M$6 11 3 7 9 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $8 r0 *1 2.04,0.56 nfet_01v8
M$8 5 6 10 9 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=182000000000P
+ PS=1035000U PD=1860000U
.ENDS sky130_fd_sc_hd__nand3b_1

* cell sky130_fd_sc_hd__and2b_1
* pin VPB
* pin B
* pin A_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__and2b_1 1 3 5 6 7 8 9
* net 1 VPB
* net 3 B
* net 5 A_N
* net 6 X
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 8 5 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=71400000000P
+ PS=1360000U PD=760000U
* device instance $2 r0 *1 0.96,2.275 pfet_01v8_hvt
M$2 2 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=71400000000P AD=60900000000P
+ PS=760000U PD=710000U
* device instance $3 r0 *1 1.4,2.275 pfet_01v8_hvt
M$3 2 3 8 1 pfet_01v8_hvt L=150000U W=420000U AS=227900000000P AD=60900000000P
+ PS=1740000U PD=710000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=227900000000P
+ AD=260000000000P PS=1740000U PD=2520000U
* device instance $5 r0 *1 1.41,0.445 nfet_01v8
M$5 10 4 2 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=50400000000P
+ PS=1360000U PD=660000U
* device instance $6 r0 *1 1.8,0.445 nfet_01v8
M$6 7 3 10 9 nfet_01v8 L=150000U W=420000U AS=50400000000P AD=101300000000P
+ PS=660000U PD=990000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=101300000000P AD=169000000000P
+ PS=990000U PD=1820000U
* device instance $8 r0 *1 0.47,0.445 nfet_01v8
M$8 4 5 7 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and2b_1

* cell sky130_fd_sc_hd__o22a_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22a_1 1 2 3 4 5 6 7 10 11
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 6 X
* net 7 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=372500000000P PS=2560000U PD=1745000U
* device instance $2 r0 *1 1.385,1.985 pfet_01v8_hvt
M$2 13 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=372500000000P
+ AD=117500000000P PS=1745000U PD=1235000U
* device instance $3 r0 *1 1.77,1.985 pfet_01v8_hvt
M$3 8 3 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=117500000000P
+ AD=235000000000P PS=1235000U PD=1470000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=235000000000P
+ AD=105000000000P PS=1470000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 8 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.83,0.56 nfet_01v8
M$7 9 3 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 7 4 9 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=87750000000P
+ PS=1000000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 9 5 7 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 7 8 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22a_1

* cell sky130_fd_sc_hd__a211oi_2
* pin VGND
* pin Y
* pin C1
* pin B1
* pin A1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_2 1 2 4 5 6 7 10 11 12
* net 1 VGND
* net 2 Y
* net 4 C1
* net 5 B1
* net 6 A1
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.765,1.985 pfet_01v8_hvt
M$1 9 6 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 3.625,1.985 pfet_01v8_hvt
M$3 9 7 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $5 r0 *1 0.525,1.985 pfet_01v8_hvt
M$5 2 4 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $7 r0 *1 1.385,1.985 pfet_01v8_hvt
M$7 9 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $9 r0 *1 2.765,0.56 nfet_01v8
M$9 2 6 3 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $11 r0 *1 3.625,0.56 nfet_01v8
M$11 1 7 3 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
* device instance $13 r0 *1 0.525,0.56 nfet_01v8
M$13 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $15 r0 *1 1.385,0.56 nfet_01v8
M$15 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__a211oi_2

* cell sky130_fd_sc_hd__nand4b_4
* pin VGND
* pin D
* pin Y
* pin A_N
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_4 1 2 5 8 9 10 11 12 13
* net 1 VGND
* net 2 D
* net 5 Y
* net 8 A_N
* net 9 B
* net 10 C
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 5 3 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 3.09,1.985 pfet_01v8_hvt
M$5 5 9 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=800000000000P PS=5080000U PD=5600000U
* device instance $9 r0 *1 5.29,1.985 pfet_01v8_hvt
M$9 5 10 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=540000000000P PS=5600000U PD=5080000U
* device instance $13 r0 *1 6.97,1.985 pfet_01v8_hvt
M$13 5 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $17 r0 *1 0.47,1.985 pfet_01v8_hvt
M$17 11 8 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $18 r0 *1 5.29,0.56 nfet_01v8
M$18 6 10 7 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $22 r0 *1 6.97,0.56 nfet_01v8
M$22 1 2 7 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 8 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $27 r0 *1 1.41,0.56 nfet_01v8
M$27 5 3 4 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $31 r0 *1 3.09,0.56 nfet_01v8
M$31 6 9 4 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand4b_4

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__buf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_16 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=935000000000P
+ AD=810000000000P PS=8870000U PD=7620000U
* device instance $7 r0 *1 2.99,1.985 pfet_01v8_hvt
M$7 4 3 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $23 r0 *1 0.47,0.56 nfet_01v8
M$23 3 2 1 7 nfet_01v8 L=150000U W=3900000U AS=607750000000P AD=526500000000P
+ PS=6420000U PD=5520000U
* device instance $29 r0 *1 2.99,0.56 nfet_01v8
M$29 4 3 1 7 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__buf_16

* cell sky130_fd_sc_hd__a211oi_1
* pin VPB
* pin A2
* pin A1
* pin C1
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A2
* net 3 A1
* net 4 C1
* net 5 B1
* net 6 VGND
* net 7 Y
* net 9 VPWR
* device instance $1 r0 *1 0.62,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.05,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 1.48,1.985 pfet_01v8_hvt
M$3 11 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 1.94,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.62,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=266500000000P AD=91000000000P
+ PS=2120000U PD=930000U
* device instance $6 r0 *1 1.05,0.56 nfet_01v8
M$6 7 3 12 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $7 r0 *1 1.48,0.56 nfet_01v8
M$7 6 5 7 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $8 r0 *1 1.94,0.56 nfet_01v8
M$8 7 4 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211oi_1

* cell sky130_fd_sc_hd__fa_1
* pin VGND
* pin COUT
* pin SUM
* pin A
* pin CIN
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__fa_1 1 2 7 11 12 13 16 17 21
* net 1 VGND
* net 2 COUT
* net 7 SUM
* net 11 A
* net 12 CIN
* net 13 B
* net 16 VPWR
* net 17 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 16 3 2 17 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=147850000000P PS=2520000U PD=1345000U
* device instance $2 r0 *1 0.965,2.275 pfet_01v8_hvt
M$2 18 11 16 17 pfet_01v8_hvt L=150000U W=420000U AS=147850000000P
+ AD=63000000000P PS=1345000U PD=720000U
* device instance $3 r0 *1 1.415,2.275 pfet_01v8_hvt
M$3 3 13 18 17 pfet_01v8_hvt L=150000U W=420000U AS=63000000000P
+ AD=56700000000P PS=720000U PD=690000U
* device instance $4 r0 *1 1.835,2.275 pfet_01v8_hvt
M$4 14 12 3 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $5 r0 *1 2.255,2.275 pfet_01v8_hvt
M$5 16 11 14 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $6 r0 *1 2.675,2.275 pfet_01v8_hvt
M$6 14 13 16 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=109200000000P PS=690000U PD=1360000U
* device instance $7 r0 *1 3.615,2.275 pfet_01v8_hvt
M$7 15 13 16 17 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $8 r0 *1 4.035,2.275 pfet_01v8_hvt
M$8 16 12 15 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $9 r0 *1 4.455,2.275 pfet_01v8_hvt
M$9 15 11 16 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=61950000000P PS=690000U PD=715000U
* device instance $10 r0 *1 4.9,2.275 pfet_01v8_hvt
M$10 6 3 15 17 pfet_01v8_hvt L=150000U W=420000U AS=61950000000P
+ AD=69300000000P PS=715000U PD=750000U
* device instance $11 r0 *1 5.38,2.275 pfet_01v8_hvt
M$11 19 12 6 17 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=44100000000P PS=750000U PD=630000U
* device instance $12 r0 *1 5.74,2.275 pfet_01v8_hvt
M$12 20 13 19 17 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $13 r0 *1 6.22,2.275 pfet_01v8_hvt
M$13 20 11 16 17 pfet_01v8_hvt L=150000U W=420000U AS=147850000000P
+ AD=69300000000P PS=1345000U PD=750000U
* device instance $14 r0 *1 6.715,1.985 pfet_01v8_hvt
M$14 7 6 16 17 pfet_01v8_hvt L=150000U W=1000000U AS=147850000000P
+ AD=260000000000P PS=1345000U PD=2520000U
* device instance $15 r0 *1 0.965,0.445 nfet_01v8
M$15 8 11 1 21 nfet_01v8 L=150000U W=420000U AS=102350000000P AD=63000000000P
+ PS=995000U PD=720000U
* device instance $16 r0 *1 1.415,0.445 nfet_01v8
M$16 3 13 8 21 nfet_01v8 L=150000U W=420000U AS=63000000000P AD=56700000000P
+ PS=720000U PD=690000U
* device instance $17 r0 *1 1.835,0.445 nfet_01v8
M$17 4 12 3 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $18 r0 *1 2.255,0.445 nfet_01v8
M$18 1 11 4 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $19 r0 *1 2.675,0.445 nfet_01v8
M$19 4 13 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $20 r0 *1 0.47,0.56 nfet_01v8
M$20 1 3 2 21 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=102350000000P
+ PS=1820000U PD=995000U
* device instance $21 r0 *1 3.615,0.445 nfet_01v8
M$21 5 13 1 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $22 r0 *1 4.035,0.445 nfet_01v8
M$22 1 12 5 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $23 r0 *1 4.455,0.445 nfet_01v8
M$23 5 11 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=61950000000P
+ PS=690000U PD=715000U
* device instance $24 r0 *1 4.9,0.445 nfet_01v8
M$24 6 3 5 21 nfet_01v8 L=150000U W=420000U AS=61950000000P AD=69300000000P
+ PS=715000U PD=750000U
* device instance $25 r0 *1 5.38,0.445 nfet_01v8
M$25 10 12 6 21 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $26 r0 *1 5.74,0.445 nfet_01v8
M$26 9 13 10 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $27 r0 *1 6.22,0.445 nfet_01v8
M$27 1 11 9 21 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=102350000000P
+ PS=750000U PD=995000U
* device instance $28 r0 *1 6.715,0.56 nfet_01v8
M$28 7 6 1 21 nfet_01v8 L=150000U W=650000U AS=102350000000P AD=169000000000P
+ PS=995000U PD=1820000U
.ENDS sky130_fd_sc_hd__fa_1

* cell sky130_fd_sc_hd__or3b_1
* pin VPB
* pin A
* pin B
* pin C_N
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3b_1 1 2 3 5 6 7 8 10
* net 1 VPB
* net 2 A
* net 3 B
* net 5 C_N
* net 6 X
* net 7 VPWR
* net 8 VGND
* device instance $1 r0 *1 1.41,1.695 pfet_01v8_hvt
M$1 11 4 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.77,1.695 pfet_01v8_hvt
M$2 12 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=68250000000P
+ PS=630000U PD=745000U
* device instance $3 r0 *1 2.245,1.695 pfet_01v8_hvt
M$3 7 2 12 1 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=148250000000P
+ PS=745000U PD=1340000U
* device instance $4 r0 *1 2.735,1.985 pfet_01v8_hvt
M$4 6 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=275000000000P PS=1340000U PD=2550000U
* device instance $5 r0 *1 0.47,1.695 pfet_01v8_hvt
M$5 4 5 7 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.41,0.475 nfet_01v8
M$6 8 4 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $7 r0 *1 1.83,0.475 nfet_01v8
M$7 9 3 8 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 2.25,0.475 nfet_01v8
M$8 9 2 8 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=56700000000P
+ PS=985000U PD=690000U
* device instance $9 r0 *1 2.735,0.56 nfet_01v8
M$9 6 9 8 10 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=178750000000P
+ PS=985000U PD=1850000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or3b_1

* cell sky130_fd_sc_hd__o21ai_2
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_2 1 2 3 4 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 7 VGND
* net 8 Y
* net 9 VPWR
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 6 2 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=440000000000P
+ AD=300000000000P PS=3880000U PD=2600000U
* device instance $2 r0 *1 0.915,1.985 pfet_01v8_hvt
M$2 8 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=315000000000P PS=2560000U PD=2630000U
* device instance $5 r0 *1 2.315,1.985 pfet_01v8_hvt
M$5 8 4 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=405000000000P PS=2600000U PD=3810000U
* device instance $7 r0 *1 0.485,0.56 nfet_01v8
M$7 7 2 5 10 nfet_01v8 L=150000U W=1300000U AS=299000000000P AD=182000000000P
+ PS=2870000U PD=1860000U
* device instance $8 r0 *1 0.915,0.56 nfet_01v8
M$8 5 3 7 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=217750000000P
+ PS=1860000U PD=1970000U
* device instance $11 r0 *1 2.315,0.56 nfet_01v8
M$11 8 4 5 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__o21ai_2

* cell sky130_fd_sc_hd__xor2_1
* pin VPB
* pin B
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xor2_1 1 2 3 6 7 8 9
* net 1 VPB
* net 2 B
* net 3 A
* net 6 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=300000000000P PS=2520000U PD=2600000U
* device instance $2 r0 *1 0.51,1.985 pfet_01v8_hvt
M$2 10 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $3 r0 *1 0.93,1.985 pfet_01v8_hvt
M$3 6 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.35,1.985 pfet_01v8_hvt
M$4 5 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.77,1.985 pfet_01v8_hvt
M$5 6 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.51,0.56 nfet_01v8
M$6 4 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.93,0.56 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.35,0.56 nfet_01v8
M$8 11 3 8 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 1.77,0.56 nfet_01v8
M$9 7 2 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=250250000000P
+ PS=920000U PD=1420000U
* device instance $10 r0 *1 2.69,0.56 nfet_01v8
M$10 8 4 7 9 nfet_01v8 L=150000U W=650000U AS=250250000000P AD=208000000000P
+ PS=1420000U PD=1940000U
.ENDS sky130_fd_sc_hd__xor2_1

* cell sky130_fd_sc_hd__dfrtp_4
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_4 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPB
* net 18 VPWR
* device instance $1 r0 *1 8.63,1.985 pfet_01v8_hvt
M$1 9 8 18 17 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=710000000000P PS=6330000U PD=6420000U
* device instance $5 r0 *1 5.35,2.065 pfet_01v8_hvt
M$5 16 5 18 17 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $6 r0 *1 5.845,2.275 pfet_01v8_hvt
M$6 7 2 16 17 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $7 r0 *1 6.275,2.275 pfet_01v8_hvt
M$7 20 3 7 17 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $8 r0 *1 6.695,2.275 pfet_01v8_hvt
M$8 18 8 20 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $9 r0 *1 7.235,2.275 pfet_01v8_hvt
M$9 8 6 18 17 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $10 r0 *1 7.655,2.275 pfet_01v8_hvt
M$10 18 7 8 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $11 r0 *1 2.225,2.275 pfet_01v8_hvt
M$11 4 15 18 17 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $12 r0 *1 2.685,2.275 pfet_01v8_hvt
M$12 5 3 4 17 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $13 r0 *1 3.18,2.275 pfet_01v8_hvt
M$13 19 2 5 17 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $14 r0 *1 3.88,2.275 pfet_01v8_hvt
M$14 18 16 19 17 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $15 r0 *1 4.365,2.275 pfet_01v8_hvt
M$15 19 6 18 17 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $16 r0 *1 0.47,2.135 pfet_01v8_hvt
M$16 18 14 2 17 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $17 r0 *1 0.89,2.135 pfet_01v8_hvt
M$17 3 2 18 17 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $18 r0 *1 8.63,0.56 nfet_01v8
M$18 9 8 1 21 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $22 r0 *1 0.47,0.445 nfet_01v8
M$22 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $23 r0 *1 0.89,0.445 nfet_01v8
M$23 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $24 r0 *1 2.64,0.415 nfet_01v8
M$24 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $25 r0 *1 3.12,0.415 nfet_01v8
M$25 10 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $26 r0 *1 5.465,0.415 nfet_01v8
M$26 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $27 r0 *1 6.01,0.415 nfet_01v8
M$27 13 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $28 r0 *1 2.165,0.445 nfet_01v8
M$28 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $29 r0 *1 3.95,0.445 nfet_01v8
M$29 11 16 10 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $30 r0 *1 4.31,0.445 nfet_01v8
M$30 1 6 11 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $31 r0 *1 6.49,0.445 nfet_01v8
M$31 1 8 13 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $32 r0 *1 7.235,0.445 nfet_01v8
M$32 12 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $33 r0 *1 7.69,0.445 nfet_01v8
M$33 8 7 12 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $34 r0 *1 4.97,0.555 nfet_01v8
M$34 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_4

* cell sky130_fd_sc_hd__o41ai_1
* pin VGND
* pin Y
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o41ai_1 1 2 4 5 6 7 8 9 10 14
* net 1 VGND
* net 2 Y
* net 4 B1
* net 5 A4
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=312500000000P PS=1270000U PD=1625000U
* device instance $3 r0 *1 1.665,1.985 pfet_01v8_hvt
M$3 13 6 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=312500000000P
+ AD=135000000000P PS=1625000U PD=1270000U
* device instance $4 r0 *1 2.085,1.985 pfet_01v8_hvt
M$4 12 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=175000000000P PS=1270000U PD=1350000U
* device instance $5 r0 *1 2.585,1.985 pfet_01v8_hvt
M$5 9 8 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=175000000000P
+ AD=280000000000P PS=1350000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 3 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=203125000000P
+ PS=1820000U PD=1275000U
* device instance $7 r0 *1 1.245,0.56 nfet_01v8
M$7 1 5 3 14 nfet_01v8 L=150000U W=650000U AS=203125000000P AD=87750000000P
+ PS=1275000U PD=920000U
* device instance $8 r0 *1 1.665,0.56 nfet_01v8
M$8 3 6 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 2.085,0.56 nfet_01v8
M$9 1 7 3 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $10 r0 *1 2.585,0.56 nfet_01v8
M$10 3 8 1 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=182000000000P
+ PS=1000000U PD=1860000U
.ENDS sky130_fd_sc_hd__o41ai_1

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__and4_1
* pin VPB
* pin D
* pin C
* pin B
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and4_1 1 3 4 5 6 7 8 9 10
* net 1 VPB
* net 3 D
* net 4 C
* net 5 B
* net 6 A
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 2 6 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=73500000000P
+ PS=1360000U PD=770000U
* device instance $2 r0 *1 0.97,2.275 pfet_01v8_hvt
M$2 8 5 2 1 pfet_01v8_hvt L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $3 r0 *1 1.49,2.275 pfet_01v8_hvt
M$3 2 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=77700000000P AD=58800000000P
+ PS=790000U PD=700000U
* device instance $4 r0 *1 1.92,2.275 pfet_01v8_hvt
M$4 2 3 8 1 pfet_01v8_hvt L=150000U W=420000U AS=312450000000P AD=58800000000P
+ PS=1680000U PD=700000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=312450000000P
+ AD=260000000000P PS=1680000U PD=2520000U
* device instance $6 r0 *1 0.47,0.445 nfet_01v8
M$6 13 6 2 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $7 r0 *1 0.91,0.445 nfet_01v8
M$7 11 5 13 10 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=79800000000P
+ PS=710000U PD=800000U
* device instance $8 r0 *1 1.44,0.445 nfet_01v8
M$8 12 4 11 10 nfet_01v8 L=150000U W=420000U AS=79800000000P AD=69300000000P
+ PS=800000U PD=750000U
* device instance $9 r0 *1 1.92,0.445 nfet_01v8
M$9 7 3 12 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=196275000000P
+ PS=750000U PD=1330000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 9 2 7 10 nfet_01v8 L=150000U W=650000U AS=196275000000P AD=169000000000P
+ PS=1330000U PD=1820000U
.ENDS sky130_fd_sc_hd__and4_1

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__nor4b_1
* pin VPB
* pin C
* pin B
* pin A
* pin D_N
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_1 1 2 3 4 5 6 7 8 10
* net 1 VPB
* net 2 C
* net 3 B
* net 4 A
* net 5 D_N
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 2.535,1.89 pfet_01v8_hvt
M$1 9 5 8 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 13 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=520000000000P
+ AD=135000000000P PS=3040000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 12 2 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.63,1.985 pfet_01v8_hvt
M$4 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=135000000000P PS=1330000U PD=1270000U
* device instance $5 r0 *1 2.05,1.985 pfet_01v8_hvt
M$5 8 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $6 r0 *1 0.73,0.56 nfet_01v8
M$6 7 9 6 10 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $7 r0 *1 1.15,0.56 nfet_01v8
M$7 6 2 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.63,0.56 nfet_01v8
M$8 7 3 6 10 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $9 r0 *1 2.05,0.56 nfet_01v8
M$9 6 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $10 r0 *1 2.535,0.675 nfet_01v8
M$10 9 5 6 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor4b_1

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4

* cell sky130_fd_sc_hd__nand2_2
* pin VGND
* pin
* pin B
* pin Y
* pin A
* pin VPB
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nand2_2 1 2 4 5 6 7 8
* net 1 VGND
* net 4 B
* net 5 Y
* net 6 A
* net 7 VPB
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 5 6 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 1 4 3 2 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 5 6 3 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand2_2

* cell sky130_fd_sc_hd__o21ai_1
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 VGND
* net 8 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 8 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=174000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.37,2.135 pfet_01v8_hvt
M$3 5 3 8 1 pfet_01v8_hvt L=150000U W=700000U AS=174000000000P AD=182000000000P
+ PS=1390000U PD=1920000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $5 r0 *1 0.95,0.56 nfet_01v8
M$5 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 8 3 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21ai_1

* cell sky130_fd_sc_hd__o21a_1
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21a_1 1 2 3 4 5 7 8 10
* net 1 VPB
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=327500000000P PS=2560000U PD=1655000U
* device instance $2 r0 *1 1.295,1.985 pfet_01v8_hvt
M$2 9 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=327500000000P
+ AD=195000000000P PS=1655000U PD=1390000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=152500000000P PS=1390000U PD=1305000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 5 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=260000000000P PS=1305000U PD=2520000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 3 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 8 9 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21a_1

* cell sky130_fd_sc_hd__and2_0
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_0 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.54,2.275 pfet_01v8_hvt
M$1 4 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=60900000000P
+ PS=1370000U PD=710000U
* device instance $2 r0 *1 0.98,2.275 pfet_01v8_hvt
M$2 4 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=184100000000P AD=60900000000P
+ PS=1260000U PD=710000U
* device instance $3 r0 *1 1.75,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=184100000000P AD=169600000000P
+ PS=1260000U PD=1810000U
* device instance $4 r0 *1 0.54,0.445 nfet_01v8
M$4 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=1370000U PD=630000U
* device instance $5 r0 *1 0.9,0.445 nfet_01v8
M$5 7 3 9 8 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=96600000000P
+ PS=630000U PD=880000U
* device instance $6 r0 *1 1.51,0.445 nfet_01v8
M$6 5 4 7 8 nfet_01v8 L=150000U W=420000U AS=96600000000P AD=111300000000P
+ PS=880000U PD=1370000U
.ENDS sky130_fd_sc_hd__and2_0

* cell sky130_fd_sc_hd__a41o_2
* pin VGND
* pin X
* pin A2
* pin A1
* pin B1
* pin A4
* pin A3
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41o_2 1 2 4 5 6 7 8 12 13 15
* net 1 VGND
* net 2 X
* net 4 A2
* net 5 A1
* net 6 B1
* net 7 A4
* net 8 A3
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 14 6 3 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 12 7 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.67,1.985 pfet_01v8_hvt
M$3 14 8 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=215000000000P PS=1270000U PD=1430000U
* device instance $4 r0 *1 3.25,1.985 pfet_01v8_hvt
M$4 12 4 14 13 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=135000000000P PS=1430000U PD=1270000U
* device instance $5 r0 *1 3.67,1.985 pfet_01v8_hvt
M$5 14 5 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 2 3 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 1 6 3 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $9 r0 *1 2.25,0.56 nfet_01v8
M$9 9 7 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 2.67,0.56 nfet_01v8
M$10 11 8 9 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=139750000000P
+ PS=920000U PD=1080000U
* device instance $11 r0 *1 3.25,0.56 nfet_01v8
M$11 10 4 11 15 nfet_01v8 L=150000U W=650000U AS=139750000000P AD=87750000000P
+ PS=1080000U PD=920000U
* device instance $12 r0 *1 3.67,0.56 nfet_01v8
M$12 3 5 10 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 2 3 1 15 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__a41o_2

* cell sky130_fd_sc_hd__a41oi_2
* pin VGND
* pin Y
* pin B1
* pin A1
* pin A2
* pin A3
* pin A4
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_2 1 2 6 7 8 9 10 12 13 14
* net 1 VGND
* net 2 Y
* net 6 B1
* net 7 A1
* net 8 A2
* net 9 A3
* net 10 A4
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 1.08,1.985 pfet_01v8_hvt
M$1 2 6 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.92,1.985 pfet_01v8_hvt
M$3 12 7 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 2.76,1.985 pfet_01v8_hvt
M$5 12 8 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=280000000000P PS=2540000U PD=2560000U
* device instance $7 r0 *1 3.62,1.985 pfet_01v8_hvt
M$7 12 9 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=530000000000P
+ AD=520000000000P PS=3060000U PD=3040000U
* device instance $9 r0 *1 4.96,1.985 pfet_01v8_hvt
M$9 12 10 11 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 4.12,0.56 nfet_01v8
M$11 4 9 5 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $13 r0 *1 4.96,0.56 nfet_01v8
M$13 1 10 5 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $15 r0 *1 1.92,0.56 nfet_01v8
M$15 2 7 3 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $17 r0 *1 2.76,0.56 nfet_01v8
M$17 4 8 3 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $19 r0 *1 0.56,0.56 nfet_01v8
M$19 2 6 1 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
.ENDS sky130_fd_sc_hd__a41oi_2

* cell sky130_fd_sc_hd__xnor2_1
* pin VPB
* pin B
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_1 1 2 3 4 5 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 Y
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.51,1.985 pfet_01v8_hvt
M$1 8 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=135000000000P PS=2600000U PD=1270000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=365000000000P PS=1270000U PD=1730000U
* device instance $3 r0 *1 1.81,1.985 pfet_01v8_hvt
M$3 10 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=105000000000P PS=1730000U PD=1210000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 4 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 5 8 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=360000000000P PS=1330000U PD=2720000U
* device instance $6 r0 *1 2.29,0.56 nfet_01v8
M$6 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 4 8 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=195000000000P
+ PS=920000U PD=1900000U
* device instance $8 r0 *1 0.57,0.56 nfet_01v8
M$8 11 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $9 r0 *1 0.93,0.56 nfet_01v8
M$9 7 3 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=87750000000P
+ PS=860000U PD=920000U
* device instance $10 r0 *1 1.35,0.56 nfet_01v8
M$10 6 3 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor2_1

* cell sky130_fd_sc_hd__a32oi_1
* pin VPB
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a32oi_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A3
* net 5 A2
* net 6 A1
* net 8 Y
* net 9 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=215000000000P PS=1270000U PD=1430000U
* device instance $3 r0 *1 1.47,1.985 pfet_01v8_hvt
M$3 10 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=135000000000P PS=1430000U PD=1270000U
* device instance $4 r0 *1 1.89,1.985 pfet_01v8_hvt
M$4 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=140000000000P PS=1270000U PD=1280000U
* device instance $5 r0 *1 2.32,1.985 pfet_01v8_hvt
M$5 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=260000000000P PS=1280000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $7 r0 *1 0.85,0.56 nfet_01v8
M$7 8 3 14 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=152750000000P
+ PS=880000U PD=1120000U
* device instance $8 r0 *1 1.47,0.56 nfet_01v8
M$8 12 6 8 11 nfet_01v8 L=150000U W=650000U AS=152750000000P AD=71500000000P
+ PS=1120000U PD=870000U
* device instance $9 r0 *1 1.84,0.56 nfet_01v8
M$9 13 5 12 11 nfet_01v8 L=150000U W=650000U AS=71500000000P AD=107250000000P
+ PS=870000U PD=980000U
* device instance $10 r0 *1 2.32,0.56 nfet_01v8
M$10 9 4 13 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a32oi_1

* cell sky130_fd_sc_hd__a21oi_2
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_2 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=275000000000P PS=3830000U PD=2550000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 6 2 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=275000000000P PS=2560000U PD=2550000U
* device instance $5 r0 *1 2.19,1.985 pfet_01v8_hvt
M$5 7 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=495000000000P PS=2540000U PD=3990000U
* device instance $7 r0 *1 0.495,0.56 nfet_01v8
M$7 10 4 8 9 nfet_01v8 L=150000U W=650000U AS=185250000000P AD=89375000000P
+ PS=1870000U PD=925000U
* device instance $8 r0 *1 0.92,0.56 nfet_01v8
M$8 7 2 10 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $9 r0 *1 1.35,0.56 nfet_01v8
M$9 11 2 7 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=68250000000P
+ PS=930000U PD=860000U
* device instance $10 r0 *1 1.71,0.56 nfet_01v8
M$10 8 4 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=107250000000P
+ PS=860000U PD=980000U
* device instance $11 r0 *1 2.19,0.56 nfet_01v8
M$11 7 3 8 9 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=347750000000P
+ PS=1900000U PD=3020000U
.ENDS sky130_fd_sc_hd__a21oi_2

* cell sky130_fd_sc_hd__a221oi_1
* pin VGND
* pin Y
* pin B1
* pin A1
* pin C1
* pin B2
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_1 1 2 3 4 5 6 7 10 11 14
* net 1 VGND
* net 2 Y
* net 3 B1
* net 4 A1
* net 5 C1
* net 6 B2
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 13 4 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=152500000000P PS=2520000U PD=1305000U
* device instance $2 r0 *1 2.705,1.985 pfet_01v8_hvt
M$2 11 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=305000000000P PS=1305000U PD=2610000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 12 5 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 13 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 12 3 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 2.25,0.56 nfet_01v8
M$6 9 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=99125000000P
+ PS=1820000U PD=955000U
* device instance $7 r0 *1 2.705,0.56 nfet_01v8
M$7 1 7 9 14 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=198250000000P
+ PS=955000U PD=1910000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $9 r0 *1 0.945,0.56 nfet_01v8
M$9 8 6 1 14 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=69875000000P
+ PS=975000U PD=865000U
* device instance $10 r0 *1 1.31,0.56 nfet_01v8
M$10 2 3 8 14 nfet_01v8 L=150000U W=650000U AS=69875000000P AD=169000000000P
+ PS=865000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221oi_1

* cell sky130_fd_sc_hd__nor3b_1
* pin VPB
* pin B
* pin A
* pin C_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 C_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 2.055,1.86 pfet_01v8_hvt
M$1 8 4 7 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 11 8 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=320000000000P
+ AD=135000000000P PS=2640000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 10 2 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.57,1.985 pfet_01v8_hvt
M$4 7 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $5 r0 *1 0.73,0.56 nfet_01v8
M$5 6 8 5 9 nfet_01v8 L=150000U W=650000U AS=221000000000P AD=87750000000P
+ PS=1980000U PD=920000U
* device instance $6 r0 *1 1.15,0.56 nfet_01v8
M$6 5 2 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.57,0.56 nfet_01v8
M$7 6 3 5 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $8 r0 *1 2.055,0.675 nfet_01v8
M$8 8 4 6 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor3b_1

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__a32o_1
* pin VGND
* pin X
* pin A2
* pin A1
* pin B1
* pin A3
* pin B2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a32o_1 1 2 3 4 5 7 8 13 14 15
* net 1 VGND
* net 2 X
* net 3 A2
* net 4 A1
* net 5 B1
* net 7 A3
* net 8 B2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.54,1.985 pfet_01v8_hvt
M$1 13 6 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=330000000000P
+ AD=242500000000P PS=2660000U PD=1485000U
* device instance $2 r0 *1 1.175,1.985 pfet_01v8_hvt
M$2 12 7 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=242500000000P
+ AD=165000000000P PS=1485000U PD=1330000U
* device instance $3 r0 *1 1.655,1.985 pfet_01v8_hvt
M$3 13 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=225000000000P PS=1330000U PD=1450000U
* device instance $4 r0 *1 2.255,1.985 pfet_01v8_hvt
M$4 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=185000000000P PS=1450000U PD=1370000U
* device instance $5 r0 *1 2.775,1.985 pfet_01v8_hvt
M$5 6 5 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=185000000000P
+ AD=140000000000P PS=1370000U PD=1280000U
* device instance $6 r0 *1 3.205,1.985 pfet_01v8_hvt
M$6 12 8 6 14 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $7 r0 *1 0.54,0.56 nfet_01v8
M$7 1 6 2 15 nfet_01v8 L=150000U W=650000U AS=214500000000P AD=167375000000P
+ PS=1960000U PD=1165000U
* device instance $8 r0 *1 1.205,0.56 nfet_01v8
M$8 9 7 1 15 nfet_01v8 L=150000U W=650000U AS=167375000000P AD=97500000000P
+ PS=1165000U PD=950000U
* device instance $9 r0 *1 1.655,0.56 nfet_01v8
M$9 11 3 9 15 nfet_01v8 L=150000U W=650000U AS=97500000000P AD=146250000000P
+ PS=950000U PD=1100000U
* device instance $10 r0 *1 2.255,0.56 nfet_01v8
M$10 6 4 11 15 nfet_01v8 L=150000U W=650000U AS=146250000000P AD=143000000000P
+ PS=1100000U PD=1090000U
* device instance $11 r0 *1 2.845,0.56 nfet_01v8
M$11 10 5 6 15 nfet_01v8 L=150000U W=650000U AS=143000000000P AD=68250000000P
+ PS=1090000U PD=860000U
* device instance $12 r0 *1 3.205,0.56 nfet_01v8
M$12 1 8 10 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=172250000000P
+ PS=860000U PD=1830000U
.ENDS sky130_fd_sc_hd__a32o_1

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__a21boi_0
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_0 1 2 3 4 6 8 9 10
* net 1 VPB
* net 2 B1_N
* net 3 A1
* net 4 A2
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 1.425,2.165 pfet_01v8_hvt
M$1 5 7 9 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=89600000000P
+ PS=1810000U PD=920000U
* device instance $2 r0 *1 1.855,2.165 pfet_01v8_hvt
M$2 8 3 5 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=89600000000P
+ PS=920000U PD=920000U
* device instance $3 r0 *1 2.285,2.165 pfet_01v8_hvt
M$3 5 4 8 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=169600000000P
+ PS=920000U PD=1810000U
* device instance $4 r0 *1 0.475,2.275 pfet_01v8_hvt
M$4 8 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=111300000000P
+ PS=1370000U PD=1370000U
* device instance $5 r0 *1 0.475,0.445 nfet_01v8
M$5 6 2 7 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=130200000000P
+ PS=1370000U PD=1040000U
* device instance $6 r0 *1 1.245,0.445 nfet_01v8
M$6 9 7 6 10 nfet_01v8 L=150000U W=420000U AS=130200000000P AD=111300000000P
+ PS=1040000U PD=950000U
* device instance $7 r0 *1 1.925,0.445 nfet_01v8
M$7 11 3 9 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=950000U PD=630000U
* device instance $8 r0 *1 2.285,0.445 nfet_01v8
M$8 6 4 11 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=111300000000P
+ PS=630000U PD=1370000U
.ENDS sky130_fd_sc_hd__a21boi_0

* cell sky130_fd_sc_hd__nand4_2
* pin VGND
* pin D
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4_2 1 5 6 7 8 9 10 11 12
* net 1 VGND
* net 5 D
* net 6 C
* net 7 B
* net 8 A
* net 9 VPWR
* net 10 Y
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=350000000000P PS=2540000U PD=2700000U
* device instance $5 r0 *1 2.31,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=350000000000P
+ AD=470000000000P PS=2700000U PD=2940000U
* device instance $7 r0 *1 3.55,1.985 pfet_01v8_hvt
M$7 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=470000000000P
+ AD=555000000000P PS=2940000U PD=4110000U
* device instance $9 r0 *1 2.71,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.55,0.56 nfet_01v8
M$11 10 8 4 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=321750000000P
+ PS=1840000U PD=2940000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nand4_2

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__or2_1
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 5 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.695 pfet_01v8_hvt
M$1 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.695 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=145750000000P
+ PS=630000U PD=1335000U
* device instance $3 r0 *1 1.52,1.985 pfet_01v8_hvt
M$3 4 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=340000000000P PS=1335000U PD=2680000U
* device instance $4 r0 *1 0.615,0.445 nfet_01v8
M$4 6 2 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.445 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=100250000000P
+ PS=690000U PD=985000U
* device instance $6 r0 *1 1.52,0.56 nfet_01v8
M$6 4 6 5 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=169000000000P
+ PS=985000U PD=1820000U
.ENDS sky130_fd_sc_hd__or2_1

* cell sky130_fd_sc_hd__a41oi_1
* pin VGND
* pin Y
* pin A3
* pin A2
* pin B1
* pin A4
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_1 1 2 3 4 8 9 10 11 12 14
* net 1 VGND
* net 2 Y
* net 3 A3
* net 4 A2
* net 8 B1
* net 9 A4
* net 10 A1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 13 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=212500000000P PS=2520000U PD=1425000U
* device instance $2 r0 *1 1.045,1.985 pfet_01v8_hvt
M$2 11 9 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=205000000000P PS=1425000U PD=1410000U
* device instance $3 r0 *1 1.605,1.985 pfet_01v8_hvt
M$3 13 3 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=155000000000P PS=1410000U PD=1310000U
* device instance $4 r0 *1 2.065,1.985 pfet_01v8_hvt
M$4 11 4 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=212500000000P PS=1310000U PD=1425000U
* device instance $5 r0 *1 2.64,1.985 pfet_01v8_hvt
M$5 13 10 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=370000000000P PS=1425000U PD=2740000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 8 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=169000000000P
+ PS=1175000U PD=1820000U
* device instance $7 r0 *1 1.105,0.56 nfet_01v8
M$7 5 9 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=113750000000P
+ PS=1175000U PD=1000000U
* device instance $8 r0 *1 1.605,0.56 nfet_01v8
M$8 7 3 5 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $9 r0 *1 2.065,0.56 nfet_01v8
M$9 6 4 7 14 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=138125000000P
+ PS=960000U PD=1075000U
* device instance $10 r0 *1 2.64,0.56 nfet_01v8
M$10 2 10 6 14 nfet_01v8 L=150000U W=650000U AS=138125000000P AD=240500000000P
+ PS=1075000U PD=2040000U
.ENDS sky130_fd_sc_hd__a41oi_1

* cell sky130_fd_sc_hd__nand3_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_2 1 3 5 6 7 8 9 10
* net 1 VGND
* net 3 Y
* net 5 A
* net 6 B
* net 7 C
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 3 7 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=445000000000P PS=3790000U PD=3890000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 3 6 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $7 r0 *1 2.67,0.56 nfet_01v8
M$7 4 7 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=289250000000P
+ PS=2740000U PD=2840000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 5 2 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.31,0.56 nfet_01v8
M$11 4 6 2 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand3_2

* cell sky130_fd_sc_hd__o31a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31a_1 1 2 5 6 7 8 9 10 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.65,1.985 pfet_01v8_hvt
M$1 9 4 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=360000000000P
+ AD=195000000000P PS=2720000U PD=1390000U
* device instance $2 r0 *1 1.19,1.985 pfet_01v8_hvt
M$2 12 5 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=135000000000P PS=1390000U PD=1270000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 11 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.09,1.985 pfet_01v8_hvt
M$4 4 7 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=212500000000P PS=1330000U PD=1425000U
* device instance $5 r0 *1 2.665,1.985 pfet_01v8_hvt
M$5 9 8 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=345000000000P PS=1425000U PD=2690000U
* device instance $6 r0 *1 0.65,0.56 nfet_01v8
M$6 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=234000000000P AD=126750000000P
+ PS=2020000U PD=1040000U
* device instance $7 r0 *1 1.19,0.56 nfet_01v8
M$7 3 5 1 13 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.61,0.56 nfet_01v8
M$8 1 6 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 2.09,0.56 nfet_01v8
M$9 3 7 1 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.57,0.56 nfet_01v8
M$10 4 8 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=201500000000P
+ PS=980000U PD=1920000U
.ENDS sky130_fd_sc_hd__o31a_1

* cell sky130_fd_sc_hd__nor4_1
* pin VPB
* pin D
* pin B
* pin A
* pin C
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 D
* net 3 B
* net 4 A
* net 5 C
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=130000000000P PS=2520000U PD=1260000U
* device instance $2 r0 *1 0.88,1.985 pfet_01v8_hvt
M$2 10 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=130000000000P
+ AD=190000000000P PS=1260000U PD=1380000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 12 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 8 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=118625000000P
+ PS=1820000U PD=1015000U
* device instance $6 r0 *1 0.985,0.56 nfet_01v8
M$6 6 5 7 9 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=89375000000P
+ PS=1015000U PD=925000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 7 3 6 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=87750000000P
+ PS=925000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor4_1

* cell sky130_fd_sc_hd__a22oi_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=300000000000P PS=1270000U PD=2600000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 1.83,0.56 nfet_01v8
M$5 11 4 8 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 2.19,0.56 nfet_01v8
M$6 9 5 11 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=234000000000P
+ PS=860000U PD=2020000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 12 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 3 12 10 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22oi_1

* cell sky130_fd_sc_hd__a211o_1
* pin VPB
* pin B1
* pin C1
* pin A1
* pin A2
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a211o_1 1 2 3 4 5 7 8 9 11
* net 1 VPB
* net 2 B1
* net 3 C1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 X
* net 9 VGND
* device instance $1 r0 *1 1.425,1.985 pfet_01v8_hvt
M$1 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.855,1.985 pfet_01v8_hvt
M$2 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 2.285,1.985 pfet_01v8_hvt
M$3 12 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 2.745,1.985 pfet_01v8_hvt
M$4 6 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.475,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=265000000000P PS=2530000U PD=2530000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 9 6 8 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=260000000000P
+ PS=1830000U PD=1450000U
* device instance $7 r0 *1 1.425,0.56 nfet_01v8
M$7 13 5 9 11 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=91000000000P
+ PS=1450000U PD=930000U
* device instance $8 r0 *1 1.855,0.56 nfet_01v8
M$8 6 4 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $9 r0 *1 2.285,0.56 nfet_01v8
M$9 9 2 6 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $10 r0 *1 2.745,0.56 nfet_01v8
M$10 6 3 9 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211o_1

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__dfrtp_2
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_2 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=2000000U AS=436200000000P
+ AD=395000000000P PS=3930000U PD=3790000U
* device instance $3 r0 *1 5.35,2.065 pfet_01v8_hvt
M$3 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $4 r0 *1 5.845,2.275 pfet_01v8_hvt
M$4 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $5 r0 *1 6.275,2.275 pfet_01v8_hvt
M$5 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $6 r0 *1 6.695,2.275 pfet_01v8_hvt
M$6 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $7 r0 *1 7.235,2.275 pfet_01v8_hvt
M$7 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $8 r0 *1 7.655,2.275 pfet_01v8_hvt
M$8 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $9 r0 *1 2.225,2.275 pfet_01v8_hvt
M$9 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $10 r0 *1 2.685,2.275 pfet_01v8_hvt
M$10 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $11 r0 *1 3.18,2.275 pfet_01v8_hvt
M$11 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $12 r0 *1 3.88,2.275 pfet_01v8_hvt
M$12 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $13 r0 *1 4.365,2.275 pfet_01v8_hvt
M$13 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $14 r0 *1 0.47,2.135 pfet_01v8_hvt
M$14 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $15 r0 *1 0.89,2.135 pfet_01v8_hvt
M$15 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $16 r0 *1 8.73,0.56 nfet_01v8
M$16 9 8 1 21 nfet_01v8 L=150000U W=1300000U AS=296450000000P AD=256750000000P
+ PS=2940000U PD=2740000U
* device instance $18 r0 *1 0.47,0.445 nfet_01v8
M$18 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $19 r0 *1 0.89,0.445 nfet_01v8
M$19 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $20 r0 *1 2.64,0.415 nfet_01v8
M$20 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $21 r0 *1 3.12,0.415 nfet_01v8
M$21 11 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $22 r0 *1 5.465,0.415 nfet_01v8
M$22 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $23 r0 *1 6.01,0.415 nfet_01v8
M$23 12 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $24 r0 *1 2.165,0.445 nfet_01v8
M$24 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $25 r0 *1 3.95,0.445 nfet_01v8
M$25 13 16 11 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $26 r0 *1 4.31,0.445 nfet_01v8
M$26 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $27 r0 *1 6.49,0.445 nfet_01v8
M$27 1 8 12 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $28 r0 *1 7.235,0.445 nfet_01v8
M$28 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $29 r0 *1 7.69,0.445 nfet_01v8
M$29 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $30 r0 *1 4.97,0.555 nfet_01v8
M$30 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_2

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 0.47,0.445 nfet_01v8
M$16 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 0.89,0.445 nfet_01v8
M$17 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__ha_1
* pin VGND
* pin SUM
* pin COUT
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_1 1 2 5 8 9 10 11 13
* net 1 VGND
* net 2 SUM
* net 5 COUT
* net 8 A
* net 9 B
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=236050000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,2.275 pfet_01v8_hvt
M$2 3 7 10 11 pfet_01v8_hvt L=150000U W=420000U AS=236050000000P
+ AD=56700000000P PS=1765000U PD=690000U
* device instance $3 r0 *1 1.805,2.275 pfet_01v8_hvt
M$3 12 9 3 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=84000000000P
+ PS=690000U PD=820000U
* device instance $4 r0 *1 2.355,2.275 pfet_01v8_hvt
M$4 10 8 12 11 pfet_01v8_hvt L=150000U W=420000U AS=84000000000P
+ AD=149100000000P PS=820000U PD=1130000U
* device instance $5 r0 *1 3.215,2.275 pfet_01v8_hvt
M$5 7 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=149100000000P
+ AD=60900000000P PS=1130000U PD=710000U
* device instance $6 r0 *1 3.655,2.275 pfet_01v8_hvt
M$6 7 8 10 11 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=60900000000P PS=1325000U PD=710000U
* device instance $7 r0 *1 4.13,1.985 pfet_01v8_hvt
M$7 5 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $8 r0 *1 3.295,0.445 nfet_01v8
M$8 6 9 7 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 3.655,0.445 nfet_01v8
M$9 1 8 6 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $10 r0 *1 4.13,0.56 nfet_01v8
M$10 5 7 1 13 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 1.41,0.445 nfet_01v8
M$11 4 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $12 r0 *1 1.83,0.445 nfet_01v8
M$12 1 9 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $13 r0 *1 2.25,0.445 nfet_01v8
M$13 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__ha_1

* cell sky130_fd_sc_hd__o2bb2ai_1
* pin VPB
* pin A1_N
* pin A2_N
* pin B2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2bb2ai_1 1 2 3 4 5 6 8 10 11
* net 1 VPB
* net 2 A1_N
* net 3 A2_N
* net 4 B2
* net 5 B1
* net 6 VPWR
* net 8 Y
* net 10 VGND
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=275000000000P
+ AD=135000000000P PS=2550000U PD=1270000U
* device instance $2 r0 *1 0.905,1.985 pfet_01v8_hvt
M$2 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=420000000000P PS=1270000U PD=1840000U
* device instance $3 r0 *1 1.895,1.985 pfet_01v8_hvt
M$3 8 7 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=420000000000P
+ AD=135000000000P PS=1840000U PD=1270000U
* device instance $4 r0 *1 2.315,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 6 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=275000000000P PS=1270000U PD=2550000U
* device instance $6 r0 *1 1.895,0.56 nfet_01v8
M$6 9 7 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.315,0.56 nfet_01v8
M$7 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 2.735,0.56 nfet_01v8
M$8 9 5 10 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.485,0.56 nfet_01v8
M$9 13 2 10 11 nfet_01v8 L=150000U W=650000U AS=178750000000P AD=68250000000P
+ PS=1850000U PD=860000U
* device instance $10 r0 *1 0.845,0.56 nfet_01v8
M$10 7 3 13 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=240500000000P
+ PS=860000U PD=2040000U
.ENDS sky130_fd_sc_hd__o2bb2ai_1

* cell sky130_fd_sc_hd__clkbuf_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_2 1 2 3 4 6 7
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 6 X
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=162500000000P PS=2530000U PD=1325000U
* device instance $2 r0 *1 0.95,1.985 pfet_01v8_hvt
M$2 6 5 3 1 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=395000000000P PS=2595000U PD=3790000U
* device instance $4 r0 *1 0.475,0.445 nfet_01v8
M$4 4 2 5 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=68250000000P
+ PS=1370000U PD=745000U
* device instance $5 r0 *1 0.95,0.445 nfet_01v8
M$5 6 5 4 7 nfet_01v8 L=150000U W=840000U AS=124950000000P AD=165900000000P
+ PS=1435000U PD=2050000U
.ENDS sky130_fd_sc_hd__clkbuf_2

* cell sky130_fd_sc_hd__buf_2
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_2 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.125 pfet_01v8_hvt
M$1 2 3 6 1 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P AD=166400000000P
+ PS=1325000U PD=1800000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=284000000000P
+ AD=400000000000P PS=2595000U PD=3800000U
* device instance $4 r0 *1 0.47,0.445 nfet_01v8
M$4 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $5 r0 *1 0.945,0.56 nfet_01v8
M$5 5 2 4 7 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=260000000000P
+ PS=1895000U PD=2750000U
.ENDS sky130_fd_sc_hd__buf_2

* cell sky130_fd_sc_hd__nand3_4
* pin VGND
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_4 1 2 5 6 7 8 9 10
* net 1 VGND
* net 2 C
* net 5 B
* net 6 A
* net 7 VPWR
* net 8 Y
* net 9 VPB
* device instance $1 r0 *1 4.35,1.985 pfet_01v8_hvt
M$1 8 6 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=675000000000P PS=6330000U PD=6350000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 2.15,1.985 pfet_01v8_hvt
M$9 8 5 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 2 3 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $17 r0 *1 2.15,0.56 nfet_01v8
M$17 4 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $21 r0 *1 4.35,0.56 nfet_01v8
M$21 8 6 4 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=438750000000P
+ PS=4580000U PD=4600000U
.ENDS sky130_fd_sc_hd__nand3_4

* cell sky130_fd_sc_hd__a22o_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a22o_1 1 2 3 4 5 6 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 VGND
* net 9 X
* net 10 VPWR
* device instance $1 r0 *1 1.82,1.985 pfet_01v8_hvt
M$1 7 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=252900000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $2 r0 *1 2.29,1.985 pfet_01v8_hvt
M$2 10 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=155000000000P PS=1320000U PD=1310000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 8 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=252850000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 1.79,0.56 nfet_01v8
M$6 12 4 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=113750000000P
+ PS=1820000U PD=1000000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 5 12 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $8 r0 *1 2.75,0.56 nfet_01v8
M$8 9 8 6 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=169000000000P
+ PS=960000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 13 2 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $10 r0 *1 0.85,0.56 nfet_01v8
M$10 8 3 13 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22o_1

* cell sky130_fd_sc_hd__mux2_1
* pin VGND
* pin X
* pin A1
* pin A0
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_1 1 2 3 5 9 10 11 14
* net 1 VGND
* net 2 X
* net 3 A1
* net 5 A0
* net 9 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.015,2.08 pfet_01v8_hvt
M$1 12 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=158350000000P
+ AD=76650000000P PS=1395000U PD=785000U
* device instance $2 r0 *1 1.53,2.08 pfet_01v8_hvt
M$2 4 5 12 11 pfet_01v8_hvt L=150000U W=420000U AS=76650000000P
+ AD=193200000000P PS=785000U PD=1340000U
* device instance $3 r0 *1 2.6,2.08 pfet_01v8_hvt
M$3 13 3 4 11 pfet_01v8_hvt L=150000U W=420000U AS=193200000000P
+ AD=44100000000P PS=1340000U PD=630000U
* device instance $4 r0 *1 2.96,2.08 pfet_01v8_hvt
M$4 10 6 13 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $5 r0 *1 3.44,2.08 pfet_01v8_hvt
M$5 6 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=117600000000P PS=750000U PD=1400000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=158350000000P PS=2520000U PD=1395000U
* device instance $7 r0 *1 1.015,0.445 nfet_01v8
M$7 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=112850000000P AD=69300000000P
+ PS=1045000U PD=750000U
* device instance $8 r0 *1 1.495,0.445 nfet_01v8
M$8 4 3 7 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=99750000000P
+ PS=750000U PD=895000U
* device instance $9 r0 *1 2.12,0.445 nfet_01v8
M$9 8 5 4 14 nfet_01v8 L=150000U W=420000U AS=99750000000P AD=69300000000P
+ PS=895000U PD=750000U
* device instance $10 r0 *1 2.6,0.445 nfet_01v8
M$10 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=144900000000P
+ PS=750000U PD=1110000U
* device instance $11 r0 *1 3.44,0.445 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=420000U AS=144900000000P AD=109200000000P
+ PS=1110000U PD=1360000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112850000000P
+ PS=1820000U PD=1045000U
.ENDS sky130_fd_sc_hd__mux2_1

* cell sky130_fd_sc_hd__or3_1
* pin VPB
* pin A
* pin B
* pin C
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.48,1.695 pfet_01v8_hvt
M$1 11 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.84,1.695 pfet_01v8_hvt
M$2 10 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $3 r0 *1 1.32,1.695 pfet_01v8_hvt
M$3 6 2 10 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $4 r0 *1 1.81,1.985 pfet_01v8_hvt
M$4 5 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=280000000000P PS=1340000U PD=2560000U
* device instance $5 r0 *1 0.48,0.475 nfet_01v8
M$5 7 4 8 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.9,0.475 nfet_01v8
M$6 8 3 7 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $7 r0 *1 1.32,0.475 nfet_01v8
M$7 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $8 r0 *1 1.81,0.56 nfet_01v8
M$8 5 8 7 9 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=182000000000P
+ PS=990000U PD=1860000U
.ENDS sky130_fd_sc_hd__or3_1

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__nor2_2
* pin VGND
* pin
* pin Y
* pin VPB
* pin A
* pin B
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nor2_2 1 2 3 4 5 6 8
* net 1 VGND
* net 3 Y
* net 4 VPB
* net 5 A
* net 6 B
* net 8 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 8 5 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 1.33,1.985 pfet_01v8_hvt
M$3 3 6 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,0.56 nfet_01v8
M$5 3 5 1 2 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $7 r0 *1 1.33,0.56 nfet_01v8
M$7 3 6 1 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor2_2

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__clkbuf_4
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 6 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=165000000000P PS=2530000U PD=1330000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=4000000U AS=585000000000P
+ AD=720000000000P PS=5170000U PD=6440000U
* device instance $6 r0 *1 0.475,0.445 nfet_01v8
M$6 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=70350000000P
+ PS=1370000U PD=755000U
* device instance $7 r0 *1 0.96,0.445 nfet_01v8
M$7 5 2 4 7 nfet_01v8 L=150000U W=1680000U AS=246750000000P AD=298200000000P
+ PS=2855000U PD=3520000U
.ENDS sky130_fd_sc_hd__clkbuf_4

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__and3b_1
* pin VPB
* pin C
* pin B
* pin A_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__and3b_1 1 2 3 5 7 8 9 10
* net 1 VPB
* net 2 C
* net 3 B
* net 5 A_N
* net 7 X
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 2.275,1.695 pfet_01v8_hvt
M$1 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=142225000000P
+ PS=815000U PD=1335000U
* device instance $2 r0 *1 1.38,1.765 pfet_01v8_hvt
M$2 9 4 6 1 pfet_01v8_hvt L=150000U W=420000U AS=108500000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 1.8,1.765 pfet_01v8_hvt
M$3 9 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 2.75,1.985 pfet_01v8_hvt
M$4 7 6 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,2.275 pfet_01v8_hvt
M$5 4 5 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=108700000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.405,0.475 nfet_01v8
M$6 12 4 6 10 nfet_01v8 L=150000U W=420000U AS=107825000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 1.765,0.475 nfet_01v8
M$7 11 3 12 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 2.17,0.475 nfet_01v8
M$8 11 2 8 10 nfet_01v8 L=150000U W=420000U AS=122275000000P AD=53550000000P
+ PS=1080000U PD=675000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 6 8 10 nfet_01v8 L=150000U W=650000U AS=122275000000P AD=169000000000P
+ PS=1080000U PD=1820000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=107850000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and3b_1

* cell sky130_fd_sc_hd__nor3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 6 4 5 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $6 r0 *1 1.31,0.56 nfet_01v8
M$6 6 2 5 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor3_1
