* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT fixed_point_sqrt clk enable reset x[0] x[10] x[11]
+ x[12] x[13] x[14] x[15] x[1] x[2] x[3] x[4] x[5] x[6] x[7]
+ x[8] x[9] y[0] y[10] y[11] y[12] y[13] y[14] y[15] y[1] y[2]
+ y[3] y[4] y[5] y[6] y[7] y[8] y[9]
X_105_ enable VSS VSS VDD VDD _045_ sky130_fd_sc_hd__buf_2
X_106_ net6 net5 net7 net8 VSS VSS VDD VDD _046_ sky130_fd_sc_hd__nor4_4
X_107_ net15 _045_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__nor2_1
X_108_ _045_ _046_ _047_ net1 VSS VSS VDD VDD _000_ sky130_fd_sc_hd__a211oi_1
X_109_ x[3] VSS VSS VDD VDD _048_ sky130_fd_sc_hd__buf_2
X_110_ net2 _048_ net10 VSS VSS VDD VDD _049_ sky130_fd_sc_hd__nor3_1
X_111_ x[2] VSS VSS VDD VDD _050_ sky130_fd_sc_hd__clkbuf_2
X_112_ x[5] VSS VSS VDD VDD _051_ sky130_fd_sc_hd__buf_4
X_113_ net9 _050_ _051_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nor3_1
X_114_ x[6] VSS VSS VDD VDD _053_ sky130_fd_sc_hd__buf_4
X_115_ net11 _053_ net13 VSS VSS VDD VDD _054_ sky130_fd_sc_hd__nor3_1
X_116_ _049_ _052_ _054_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__nand3_2
X_117_ net12 VSS VSS VDD VDD _056_ sky130_fd_sc_hd__buf_2
X_118_ net3 net4 VSS VSS VDD VDD _057_ sky130_fd_sc_hd__nor2_1
X_119_ _056_ _046_ _057_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__nand3_1
X_120_ _055_ _058_ _045_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__o21a_1
X_121_ _046_ _057_ VSS VSS VDD VDD _060_ sky130_fd_sc_hd__nand2_1
X_122_ _053_ _056_ net13 net11 VSS VSS VDD VDD _061_ sky130_fd_sc_hd__nor4bb_1
X_123_ _049_ _052_ _061_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nand3_1
X_124_ net10 net5 net7 net8 VSS VSS VDD VDD _063_ sky130_fd_sc_hd__nand4_1
X_125_ _056_ net3 net4 net6 VSS VSS VDD VDD _064_ sky130_fd_sc_hd__nand4_1
X_126_ net2 VSS VSS VDD VDD _065_ sky130_fd_sc_hd__buf_4
X_127_ _065_ net9 _048_ _053_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nand4_1
X_128_ _050_ _051_ net11 net13 VSS VSS VDD VDD _067_ sky130_fd_sc_hd__nand4_1
X_129_ _063_ _064_ _066_ _067_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__or4_2
X_130_ _060_ _062_ _068_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__o21ai_2
X_131_ _045_ net17 VSS VSS VDD VDD _070_ sky130_fd_sc_hd__nor2b_1
X_132_ _059_ _069_ _070_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__a21oi_1
X_133_ net1 _071_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__nor2_1
X_134_ _063_ _064_ _066_ _067_ VSS VSS VDD VDD _072_ sky130_fd_sc_hd__nor4_1
X_135_ _045_ net16 VSS VSS VDD VDD _073_ sky130_fd_sc_hd__nor2b_1
X_136_ _059_ _072_ _073_ VSS VSS VDD VDD _074_ sky130_fd_sc_hd__a21oi_1
X_137_ net1 _074_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__nor2_1
X_138_ _050_ _051_ VSS VSS VDD VDD _075_ sky130_fd_sc_hd__nor2_1
X_139_ net13 _056_ VSS VSS VDD VDD _076_ sky130_fd_sc_hd__nor2_1
X_140_ _046_ _057_ _076_ VSS VSS VDD VDD _077_ sky130_fd_sc_hd__nand3_2
X_141_ net9 net11 _053_ _077_ VSS VSS VDD VDD _078_ sky130_fd_sc_hd__nor4_1
X_142_ _065_ _048_ _075_ _078_ _069_ VSS VSS VDD VDD _079_
+ sky130_fd_sc_hd__a41o_1
X_143_ _045_ net20 VSS VSS VDD VDD _080_ sky130_fd_sc_hd__nor2b_1
X_144_ _059_ _079_ _080_ VSS VSS VDD VDD _081_ sky130_fd_sc_hd__a21oi_1
X_145_ net1 _081_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__nor2_1
X_146_ net1 _059_ VSS VSS VDD VDD _082_ sky130_fd_sc_hd__nor2b_1
X_147_ net11 _053_ _077_ VSS VSS VDD VDD _083_ sky130_fd_sc_hd__nor3_1
X_148_ _048_ net10 VSS VSS VDD VDD _084_ sky130_fd_sc_hd__nand2b_1
X_149_ _065_ _048_ VSS VSS VDD VDD _085_ sky130_fd_sc_hd__nor2_1
X_150_ _065_ _084_ _085_ VSS VSS VDD VDD _086_ sky130_fd_sc_hd__a21oi_1
X_151_ _048_ net10 _051_ _050_ VSS VSS VDD VDD _087_ sky130_fd_sc_hd__nor4bb_1
X_152_ _065_ _048_ _051_ net10 VSS VSS VDD VDD _088_ sky130_fd_sc_hd__nor4_1
X_153_ _065_ _087_ _088_ VSS VSS VDD VDD _089_ sky130_fd_sc_hd__a21oi_1
X_154_ _050_ _051_ _086_ _089_ VSS VSS VDD VDD _090_ sky130_fd_sc_hd__o31ai_1
X_155_ net9 net11 VSS VSS VDD VDD _091_ sky130_fd_sc_hd__nor2_1
X_156_ _050_ _051_ VSS VSS VDD VDD _092_ sky130_fd_sc_hd__xnor2_1
X_157_ _053_ _049_ _091_ _092_ VSS VSS VDD VDD _093_ sky130_fd_sc_hd__nand4_1
X_158_ _077_ _093_ VSS VSS VDD VDD _094_ sky130_fd_sc_hd__nor2_1
X_159_ _056_ net6 VSS VSS VDD VDD _095_ sky130_fd_sc_hd__nor2_1
X_160_ net5 _057_ _095_ VSS VSS VDD VDD _096_ sky130_fd_sc_hd__nand3_1
X_161_ net4 net3 VSS VSS VDD VDD _097_ sky130_fd_sc_hd__nand2b_1
X_162_ net12 net6 net5 _097_ VSS VSS VDD VDD _098_ sky130_fd_sc_hd__or4_1
X_163_ net4 net6 net3 VSS VSS VDD VDD _099_ sky130_fd_sc_hd__and3b_1
X_164_ net3 net6 net4 VSS VSS VDD VDD _100_ sky130_fd_sc_hd__nor3b_1
X_165_ net5 _056_ VSS VSS VDD VDD _101_ sky130_fd_sc_hd__nor2b_1
X_166_ _099_ _100_ _101_ VSS VSS VDD VDD _102_ sky130_fd_sc_hd__o21ai_1
X_167_ net7 net8 VSS VSS VDD VDD _103_ sky130_fd_sc_hd__or2_2
X_168_ _096_ _098_ _102_ _055_ _103_ VSS VSS VDD VDD _009_
+ sky130_fd_sc_hd__a311oi_4
X_169_ _078_ _090_ _094_ _009_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__a211oi_2
X_170_ _082_ _083_ _010_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__nand3_1
X_171_ _045_ net1 VSS VSS VDD VDD _012_ sky130_fd_sc_hd__nor2_1
X_172_ _065_ _053_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__xor2_1
X_173_ _050_ _048_ _065_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__nand3b_1
X_174_ _065_ _048_ _050_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__or3b_1
X_175_ net9 net10 net11 _053_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__or4_1
X_176_ _014_ _015_ _051_ _016_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__a211oi_1
X_177_ _087_ _091_ _013_ _017_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__a31oi_1
X_178_ _077_ _018_ _068_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__o21ai_0
X_179_ net21 _012_ _082_ _019_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__a22oi_1
X_180_ _011_ _020_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__nand2_1
X_181_ _069_ _009_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__nor2_1
X_182_ _077_ _021_ _082_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__a21boi_0
X_183_ _060_ _062_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__or2_0
X_184_ _048_ net10 _075_ _087_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__a31o_1
X_185_ net10 _075_ _085_ _024_ _065_ VSS VSS VDD VDD _025_
+ sky130_fd_sc_hd__a32o_1
X_186_ _023_ _010_ _025_ _078_ _072_ VSS VSS VDD VDD _026_
+ sky130_fd_sc_hd__a221o_1
X_187_ net22 _012_ _022_ _026_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__a22o_1
X_188_ net4 net5 VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nor2_1
X_189_ net13 _056_ net3 VSS VSS VDD VDD _028_ sky130_fd_sc_hd__o21ai_0
X_190_ _027_ _028_ net6 VSS VSS VDD VDD _029_ sky130_fd_sc_hd__a21boi_1
X_191_ _069_ _094_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__nor2_1
X_192_ _103_ _083_ _009_ _029_ _030_ VSS VSS VDD VDD _031_
+ sky130_fd_sc_hd__o41ai_1
X_193_ net23 _012_ _082_ _031_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__a22o_1
X_194_ _103_ _055_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__nor2_1
X_195_ net3 net6 _099_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__o21bai_1
X_196_ _101_ _032_ _033_ _069_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__a31oi_1
X_197_ net13 _056_ net3 VSS VSS VDD VDD _035_ sky130_fd_sc_hd__or3_1
X_198_ _046_ _097_ _010_ _035_ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nand4_1
X_199_ _045_ net24 VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nor2_1
X_200_ _045_ _034_ _036_ _037_ net1 VSS VSS VDD VDD _007_
+ sky130_fd_sc_hd__a311oi_1
X_201_ _103_ _046_ _029_ _068_ _060_ VSS VSS VDD VDD _038_
+ sky130_fd_sc_hd__o311a_1
X_202_ _082_ _010_ _038_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__nand3_1
X_203_ net3 net4 _056_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nand3b_1
X_204_ _056_ _097_ _040_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__o21ai_0
X_205_ _046_ _041_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nand2_1
X_206_ _055_ _042_ _068_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__o21ai_0
X_207_ net25 _012_ _082_ _043_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__a22oi_1
X_208_ _039_ _044_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__nand2_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
X_210_ net16 VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
X_211_ net16 VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
X_212_ net16 VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
X_213_ net26 VSS VSS VDD VDD y[12] sky130_fd_sc_hd__buf_4
X_214_ net27 VSS VSS VDD VDD y[13] sky130_fd_sc_hd__buf_4
X_215_ net28 VSS VSS VDD VDD y[14] sky130_fd_sc_hd__buf_4
X_216_ net29 VSS VSS VDD VDD y[15] sky130_fd_sc_hd__buf_4
Xy\[10\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _000_ VSS VSS VDD
+ VDD net15 sky130_fd_sc_hd__dfxtp_1
Xy\[1\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _001_ VSS VSS VDD
+ VDD net17 sky130_fd_sc_hd__dfxtp_1
Xy\[3\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _002_ VSS VSS VDD
+ VDD net16 sky130_fd_sc_hd__dfxtp_1
Xy\[4\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _003_ VSS VSS VDD
+ VDD net20 sky130_fd_sc_hd__dfxtp_1
Xy\[5\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _004_ VSS VSS VDD
+ VDD net21 sky130_fd_sc_hd__dfxtp_1
Xy\[6\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _005_ VSS VSS VDD
+ VDD net22 sky130_fd_sc_hd__dfxtp_1
Xy\[7\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _006_ VSS VSS VDD
+ VDD net23 sky130_fd_sc_hd__dfxtp_1
Xy\[8\]$_SDFFE_PP0P_ clknet_1_0__leaf_clk _007_ VSS VSS VDD
+ VDD net24 sky130_fd_sc_hd__dfxtp_1
Xy\[9\]$_SDFFE_PP0P_ clknet_1_1__leaf_clk _008_ VSS VSS VDD
+ VDD net25 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 reset VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_2
Xinput2 x[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput3 x[10] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_2
Xinput4 x[11] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_2
Xinput5 x[12] VSS VSS VDD VDD net5 sky130_fd_sc_hd__buf_2
Xinput6 x[13] VSS VSS VDD VDD net6 sky130_fd_sc_hd__buf_2
Xinput7 x[14] VSS VSS VDD VDD net7 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput8 x[15] VSS VSS VDD VDD net8 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput9 x[1] VSS VSS VDD VDD net9 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput10 x[4] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_2
Xinput11 x[7] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_2
Xinput12 x[8] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput13 x[9] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_2
Xoutput14 net14 VSS VSS VDD VDD y[0] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net15 VSS VSS VDD VDD y[10] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net16 VSS VSS VDD VDD y[11] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net17 VSS VSS VDD VDD y[1] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net18 VSS VSS VDD VDD y[2] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net19 VSS VSS VDD VDD y[3] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net20 VSS VSS VDD VDD y[4] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net21 VSS VSS VDD VDD y[5] sky130_fd_sc_hd__clkbuf_1
Xoutput22 net22 VSS VSS VDD VDD y[6] sky130_fd_sc_hd__clkbuf_1
Xoutput23 net23 VSS VSS VDD VDD y[7] sky130_fd_sc_hd__clkbuf_1
Xoutput24 net24 VSS VSS VDD VDD y[8] sky130_fd_sc_hd__clkbuf_1
Xoutput25 net25 VSS VSS VDD VDD y[9] sky130_fd_sc_hd__clkbuf_1
X_213__26 VSS VSS VDD VDD _unconnected_0 net26 sky130_fd_sc_hd__conb_1
X_214__27 VSS VSS VDD VDD _unconnected_1 net27 sky130_fd_sc_hd__conb_1
X_215__28 VSS VSS VDD VDD _unconnected_2 net28 sky130_fd_sc_hd__conb_1
X_216__29 VSS VSS VDD VDD _unconnected_3 net29 sky130_fd_sc_hd__conb_1
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_4
+ sky130_fd_sc_hd__clkbuf_1
.ENDS fixed_point_sqrt
