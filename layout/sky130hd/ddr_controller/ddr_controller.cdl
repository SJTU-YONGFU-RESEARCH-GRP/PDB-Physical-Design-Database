* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT ddr_controller clk cmd_addr[0] cmd_addr[10] cmd_addr[11]
+ cmd_addr[12] cmd_addr[13] cmd_addr[14] cmd_addr[15] cmd_addr[16]
+ cmd_addr[17] cmd_addr[18] cmd_addr[19] cmd_addr[1] cmd_addr[20]
+ cmd_addr[21] cmd_addr[22] cmd_addr[23] cmd_addr[24] cmd_addr[25]
+ cmd_addr[26] cmd_addr[27] cmd_addr[2] cmd_addr[3] cmd_addr[4]
+ cmd_addr[5] cmd_addr[6] cmd_addr[7] cmd_addr[8] cmd_addr[9]
+ cmd_burst_len[0] cmd_burst_len[1] cmd_burst_len[2] cmd_burst_len[3]
+ cmd_ready cmd_valid cmd_write init_done phy_addr[0] phy_addr[10]
+ phy_addr[11] phy_addr[12] phy_addr[13] phy_addr[1] phy_addr[2]
+ phy_addr[3] phy_addr[4] phy_addr[5] phy_addr[6] phy_addr[7]
+ phy_addr[8] phy_addr[9] phy_bank[0] phy_bank[1] phy_bank[2]
+ phy_bank_group[0] phy_bank_group[1] phy_cas_n phy_cke phy_clk
+ phy_cs_n phy_dm[0] phy_dm[1] phy_dm[2] phy_dm[3] phy_dm[4]
+ phy_dm[5] phy_dm[6] phy_dm[7] phy_dq[0] phy_dq[10] phy_dq[11]
+ phy_dq[12] phy_dq[13] phy_dq[14] phy_dq[15] phy_dq[16] phy_dq[17]
+ phy_dq[18] phy_dq[19] phy_dq[1] phy_dq[20] phy_dq[21] phy_dq[22]
+ phy_dq[23] phy_dq[24] phy_dq[25] phy_dq[26] phy_dq[27] phy_dq[28]
+ phy_dq[29] phy_dq[2] phy_dq[30] phy_dq[31] phy_dq[32] phy_dq[33]
+ phy_dq[34] phy_dq[35] phy_dq[36] phy_dq[37] phy_dq[38] phy_dq[39]
+ phy_dq[3] phy_dq[40] phy_dq[41] phy_dq[42] phy_dq[43] phy_dq[44]
+ phy_dq[45] phy_dq[46] phy_dq[47] phy_dq[48] phy_dq[49] phy_dq[4]
+ phy_dq[50] phy_dq[51] phy_dq[52] phy_dq[53] phy_dq[54] phy_dq[55]
+ phy_dq[56] phy_dq[57] phy_dq[58] phy_dq[59] phy_dq[5] phy_dq[60]
+ phy_dq[61] phy_dq[62] phy_dq[63] phy_dq[6] phy_dq[7] phy_dq[8]
+ phy_dq[9] phy_dqs_n[0] phy_dqs_n[1] phy_dqs_n[2] phy_dqs_n[3]
+ phy_dqs_n[4] phy_dqs_n[5] phy_dqs_n[6] phy_dqs_n[7] phy_dqs_p[0]
+ phy_dqs_p[1] phy_dqs_p[2] phy_dqs_p[3] phy_dqs_p[4] phy_dqs_p[5]
+ phy_dqs_p[6] phy_dqs_p[7] phy_odt phy_ras_n phy_reset_n phy_we_n
+ rd_data[0] rd_data[10] rd_data[11] rd_data[12] rd_data[13]
+ rd_data[14] rd_data[15] rd_data[16] rd_data[17] rd_data[18]
+ rd_data[19] rd_data[1] rd_data[20] rd_data[21] rd_data[22]
+ rd_data[23] rd_data[24] rd_data[25] rd_data[26] rd_data[27]
+ rd_data[28] rd_data[29] rd_data[2] rd_data[30] rd_data[31]
+ rd_data[32] rd_data[33] rd_data[34] rd_data[35] rd_data[36]
+ rd_data[37] rd_data[38] rd_data[39] rd_data[3] rd_data[40]
+ rd_data[41] rd_data[42] rd_data[43] rd_data[44] rd_data[45]
+ rd_data[46] rd_data[47] rd_data[48] rd_data[49] rd_data[4]
+ rd_data[50] rd_data[51] rd_data[52] rd_data[53] rd_data[54]
+ rd_data[55] rd_data[56] rd_data[57] rd_data[58] rd_data[59]
+ rd_data[5] rd_data[60] rd_data[61] rd_data[62] rd_data[63]
+ rd_data[6] rd_data[7] rd_data[8] rd_data[9] rd_ready rd_valid
+ rst_n state[0] state[1] wr_data[0] wr_data[10] wr_data[11]
+ wr_data[12] wr_data[13] wr_data[14] wr_data[15] wr_data[16]
+ wr_data[17] wr_data[18] wr_data[19] wr_data[1] wr_data[20]
+ wr_data[21] wr_data[22] wr_data[23] wr_data[24] wr_data[25]
+ wr_data[26] wr_data[27] wr_data[28] wr_data[29] wr_data[2]
+ wr_data[30] wr_data[31] wr_data[32] wr_data[33] wr_data[34]
+ wr_data[35] wr_data[36] wr_data[37] wr_data[38] wr_data[39]
+ wr_data[3] wr_data[40] wr_data[41] wr_data[42] wr_data[43]
+ wr_data[44] wr_data[45] wr_data[46] wr_data[47] wr_data[48]
+ wr_data[49] wr_data[4] wr_data[50] wr_data[51] wr_data[52]
+ wr_data[53] wr_data[54] wr_data[55] wr_data[56] wr_data[57]
+ wr_data[58] wr_data[59] wr_data[5] wr_data[60] wr_data[61]
+ wr_data[62] wr_data[63] wr_data[6] wr_data[7] wr_data[8] wr_data[9]
+ wr_mask[0] wr_mask[1] wr_mask[2] wr_mask[3] wr_mask[4] wr_mask[5]
+ wr_mask[6] wr_mask[7] wr_ready wr_valid VSS VDD
Xinput85 wr_data[34] VSS VSS VDD VDD net84 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput84 wr_data[33] VSS VSS VDD VDD net83 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0660_ timer\[3\] timer\[2\] _0042_ VSS VSS VDD VDD _0086_
+ sky130_fd_sc_hd__or3b_2
Xinput83 wr_data[32] VSS VSS VDD VDD net82 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0662_ timer\[5\] timer\[4\] timer\[7\] timer\[6\] VSS VSS
+ VDD VDD _0088_ sky130_fd_sc_hd__or4_4
Xinput82 wr_data[31] VSS VSS VDD VDD net81 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0664_ timer\[9\] timer\[8\] VSS VSS VDD VDD _0090_ sky130_fd_sc_hd__or2_2
X_0665_ _0086_ _0088_ _0090_ VSS VSS VDD VDD _0091_ sky130_fd_sc_hd__nor3_4
X_0666_ timer\[10\] timer\[11\] timer\[13\] timer\[12\] VSS
+ VSS VDD VDD _0092_ sky130_fd_sc_hd__or4_1
X_0667_ timer\[15\] timer\[14\] _0092_ VSS VSS VDD VDD _0093_
+ sky130_fd_sc_hd__nor3_1
X_0668_ _0091_ _0093_ VSS VSS VDD VDD _0094_ sky130_fd_sc_hd__and2_1
Xinput81 wr_data[30] VSS VSS VDD VDD net80 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput80 wr_data[2] VSS VSS VDD VDD net79 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0671_ net243 net240 VSS VSS VDD VDD _0097_ sky130_fd_sc_hd__nand2_1
X_0672_ init_state\[4\] init_state\[2\] _0097_ VSS VSS VDD
+ VDD _0003_ sky130_fd_sc_hd__mux2_2
Xinput79 wr_data[29] VSS VSS VDD VDD net78 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0674_ net56 net242 net240 VSS VSS VDD VDD _0099_ sky130_fd_sc_hd__and3_1
X_0675_ _0027_ _0099_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__and2_1
X_0676_ net140 VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__inv_1
X_0677_ _0024_ _0023_ _0099_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__and3_1
X_0678_ init_state\[5\] init_state\[3\] _0097_ VSS VSS VDD
+ VDD _0004_ sky130_fd_sc_hd__mux2_2
X_0679_ _0024_ _0021_ _0099_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__and3_1
X_0680_ init_state\[0\] init_state\[4\] _0097_ VSS VSS VDD
+ VDD _0005_ sky130_fd_sc_hd__mux2_2
X_0681_ _0024_ _0022_ _0099_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__and3_1
X_0682_ _0025_ _0099_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__and2_1
X_0683_ init_state\[1\] init_state\[5\] _0097_ VSS VSS VDD
+ VDD _0006_ sky130_fd_sc_hd__mux2_2
X_0684_ net140 _0022_ _0099_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__and3_1
X_0685_ init_state\[0\] _0097_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__and2_1
X_0686_ net140 _0023_ _0099_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__and3_1
X_0687_ init_state\[6\] init_state\[1\] _0097_ VSS VSS VDD
+ VDD _0002_ sky130_fd_sc_hd__mux2_2
X_0688_ net140 _0021_ _0099_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__and3_1
X_0689_ init_state\[2\] init_state\[6\] _0097_ VSS VSS VDD
+ VDD _0007_ sky130_fd_sc_hd__mux2_2
Xinput78 wr_data[28] VSS VSS VDD VDD net77 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput77 wr_data[27] VSS VSS VDD VDD net76 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0692_ net243 init_state\[3\] net240 init_state\[7\] VSS
+ VSS VDD VDD _0008_ sky130_fd_sc_hd__a31o_2
Xinput76 wr_data[26] VSS VSS VDD VDD net75 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput75 wr_data[25] VSS VSS VDD VDD net74 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0695_ net141 net151 VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__nor2b_1
X_0696_ net245 net153 _0104_ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__and3_2
X_0697_ burst_counter\[0\] VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__inv_1
X_0698_ refresh_counter\[10\] refresh_counter\[9\] refresh_counter\[8\]
+ VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__nand3_1
X_0699_ refresh_counter\[7\] refresh_counter\[4\] refresh_counter\[3\]
+ refresh_counter\[2\] VSS VSS VDD VDD _0106_ sky130_fd_sc_hd__and4_1
X_0700_ refresh_counter\[6\] refresh_counter\[5\] _0033_ VSS
+ VSS VDD VDD _0107_ sky130_fd_sc_hd__nor3b_1
X_0701_ _0106_ _0107_ VSS VSS VDD VDD _0108_ sky130_fd_sc_hd__nand2_1
X_0702_ refresh_counter\[6\] refresh_counter\[5\] refresh_counter\[7\]
+ VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__o21a_1
X_0703_ refresh_counter\[1\] _0106_ _0109_ VSS VSS VDD VDD
+ _0110_ sky130_fd_sc_hd__a21oi_1
X_0704_ refresh_counter\[14\] refresh_counter\[13\] refresh_counter\[12\]
+ refresh_counter\[11\] VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__or4_1
X_0705_ refresh_counter\[15\] _0111_ VSS VSS VDD VDD _0112_
+ sky130_fd_sc_hd__nor2_1
X_0706_ _0105_ _0110_ _0112_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__o21a_1
Xinput74 wr_data[24] VSS VSS VDD VDD net73 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0708_ _0105_ _0108_ _0113_ net241 VSS VSS VDD VDD _0115_
+ sky130_fd_sc_hd__o211a_1
Xinput73 wr_data[23] VSS VSS VDD VDD net72 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0710_ net52 _0091_ _0093_ VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__nand3_1
Xinput72 wr_data[22] VSS VSS VDD VDD net71 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0712_ net250 VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__inv_1
X_0713_ _0119_ active_row\[5\]\[11\] VSS VSS VDD VDD _0120_
+ sky130_fd_sc_hd__nand2_1
Xinput71 wr_data[21] VSS VSS VDD VDD net70 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0715_ net249 net251 VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__nand2_1
Xinput70 wr_data[20] VSS VSS VDD VDD net69 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0717_ net249 net251 VSS VSS VDD VDD _0124_ sky130_fd_sc_hd__nor2b_1
Xinput69 wr_data[1] VSS VSS VDD VDD net68 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0719_ net250 active_row\[3\]\[11\] net246 VSS VSS VDD VDD
+ _0126_ sky130_fd_sc_hd__nand3_1
X_0720_ _0120_ _0122_ _0126_ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__o21ai_0
Xinput68 wr_data[19] VSS VSS VDD VDD net67 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput67 wr_data[18] VSS VSS VDD VDD net66 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0723_ net251 net249 VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__nor2b_1
Xinput66 wr_data[17] VSS VSS VDD VDD net65 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0725_ active_row\[4\]\[11\] _0130_ net246 active_row\[1\]\[11\]
+ VSS VSS VDD VDD _0132_ sky130_fd_sc_hd__a22oi_1
X_0726_ net250 _0132_ VSS VSS VDD VDD _0133_ sky130_fd_sc_hd__nor2_1
Xinput65 wr_data[16] VSS VSS VDD VDD net64 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0728_ net251 VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__clkinv_1
X_0729_ _0119_ active_row\[2\]\[11\] _0135_ VSS VSS VDD VDD
+ _0136_ sky130_fd_sc_hd__o21ai_0
X_0730_ net249 net250 VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__nand2_1
Xinput64 wr_data[15] VSS VSS VDD VDD net63 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0732_ active_row\[6\]\[11\] active_row\[7\]\[11\] net251
+ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__mux2i_1
X_0733_ net249 _0136_ _0137_ _0139_ VSS VSS VDD VDD _0140_
+ sky130_fd_sc_hd__o22ai_1
X_0734_ _0127_ _0133_ _0140_ VSS VSS VDD VDD _0141_ sky130_fd_sc_hd__nor3_1
X_0735_ net249 net251 net250 VSS VSS VDD VDD _0142_ sky130_fd_sc_hd__or3_4
Xinput63 wr_data[14] VSS VSS VDD VDD net62 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0737_ active_row\[0\]\[11\] _0142_ VSS VSS VDD VDD _0144_
+ sky130_fd_sc_hd__nor2_1
Xinput62 wr_data[13] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0739_ net251 net250 VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__nor2_1
X_0740_ net250 active_row\[6\]\[12\] _0130_ _0146_ active_row\[4\]\[12\]
+ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__a32o_1
X_0741_ active_row\[2\]\[12\] net250 VSS VSS VDD VDD _0148_
+ sky130_fd_sc_hd__nand2b_1
X_0742_ net249 net251 VSS VSS VDD VDD _0149_ sky130_fd_sc_hd__nor2_1
X_0743_ net249 net250 VSS VSS VDD VDD _0150_ sky130_fd_sc_hd__nor2_1
X_0744_ _0148_ _0149_ _0150_ active_row\[1\]\[12\] VSS VSS
+ VDD VDD _0151_ sky130_fd_sc_hd__a22o_1
Xinput61 wr_data[12] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0746_ active_row\[5\]\[12\] active_row\[7\]\[12\] net250
+ VSS VSS VDD VDD _0153_ sky130_fd_sc_hd__mux2i_1
Xinput60 wr_data[11] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0748_ net250 active_row\[3\]\[12\] net249 VSS VSS VDD VDD
+ _0155_ sky130_fd_sc_hd__a21oi_1
X_0749_ net249 _0153_ _0155_ _0135_ VSS VSS VDD VDD _0156_
+ sky130_fd_sc_hd__a211oi_1
X_0750_ _0147_ _0151_ _0156_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__nor3_1
X_0751_ net38 _0157_ VSS VSS VDD VDD _0158_ sky130_fd_sc_hd__nand2_1
X_0752_ net37 _0141_ _0144_ _0158_ VSS VSS VDD VDD _0159_
+ sky130_fd_sc_hd__o31ai_1
X_0753_ net32 VSS VSS VDD VDD _0160_ sky130_fd_sc_hd__inv_1
X_0754_ active_row\[0\]\[6\] _0142_ _0160_ VSS VSS VDD VDD
+ _0161_ sky130_fd_sc_hd__o21ai_0
Xinput59 wr_data[10] VSS VSS VDD VDD net58 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput58 wr_data[0] VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0757_ active_row\[4\]\[6\] _0130_ net246 active_row\[1\]\[6\]
+ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__a22oi_1
X_0758_ _0122_ net250 active_row\[5\]\[6\] VSS VSS VDD VDD
+ _0165_ sky130_fd_sc_hd__nor3b_1
X_0759_ net250 active_row\[3\]\[6\] net246 _0165_ VSS VSS
+ VDD VDD _0166_ sky130_fd_sc_hd__a31oi_1
X_0760_ active_row\[6\]\[6\] active_row\[7\]\[6\] net251 VSS
+ VSS VDD VDD _0167_ sky130_fd_sc_hd__mux2i_1
Xinput57 net252 VSS VSS VDD VDD net56 sky130_fd_sc_hd__buf_4
X_0762_ _0119_ active_row\[2\]\[6\] _0135_ VSS VSS VDD VDD
+ _0169_ sky130_fd_sc_hd__o21ai_0
X_0763_ _0137_ _0167_ _0169_ net249 VSS VSS VDD VDD _0170_
+ sky130_fd_sc_hd__o22a_1
X_0764_ net250 _0164_ _0166_ _0170_ VSS VSS VDD VDD _0171_
+ sky130_fd_sc_hd__o211ai_1
X_0765_ _0160_ _0161_ _0171_ VSS VSS VDD VDD _0172_ sky130_fd_sc_hd__mux2i_1
X_0766_ active_row\[0\]\[12\] _0142_ VSS VSS VDD VDD _0173_
+ sky130_fd_sc_hd__nor2_1
X_0767_ net38 _0157_ _0173_ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__nor3_1
X_0768_ net33 VSS VSS VDD VDD _0175_ sky130_fd_sc_hd__inv_1
X_0769_ active_row\[0\]\[7\] _0142_ _0175_ VSS VSS VDD VDD
+ _0176_ sky130_fd_sc_hd__o21ai_0
X_0770_ _0122_ net250 active_row\[5\]\[7\] VSS VSS VDD VDD
+ _0177_ sky130_fd_sc_hd__nor3b_1
X_0771_ net250 active_row\[3\]\[7\] net246 _0177_ VSS VSS
+ VDD VDD _0178_ sky130_fd_sc_hd__a31oi_1
X_0772_ active_row\[4\]\[7\] _0130_ net246 active_row\[1\]\[7\]
+ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__a22o_1
X_0773_ _0119_ _0179_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__nand2_1
X_0774_ active_row\[6\]\[7\] active_row\[7\]\[7\] net251 VSS
+ VSS VDD VDD _0181_ sky130_fd_sc_hd__mux2_2
X_0775_ net249 net250 _0181_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__nand3_1
X_0776_ _0119_ active_row\[2\]\[7\] _0149_ VSS VSS VDD VDD
+ _0183_ sky130_fd_sc_hd__o21ai_0
X_0777_ _0178_ _0180_ _0182_ _0183_ VSS VSS VDD VDD _0184_
+ sky130_fd_sc_hd__nand4_1
X_0778_ _0175_ _0176_ _0184_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__mux2i_1
X_0779_ _0159_ _0172_ _0174_ _0185_ VSS VSS VDD VDD _0186_
+ sky130_fd_sc_hd__nor4_2
X_0780_ active_row\[2\]\[2\] active_row\[3\]\[2\] active_row\[6\]\[2\]
+ active_row\[7\]\[2\] net251 net249 VSS VSS VDD VDD _0187_
+ sky130_fd_sc_hd__mux4_2
X_0781_ active_row\[1\]\[2\] VSS VSS VDD VDD _0188_ sky130_fd_sc_hd__inv_1
X_0782_ active_row\[4\]\[2\] active_row\[5\]\[2\] net251 VSS
+ VSS VDD VDD _0189_ sky130_fd_sc_hd__mux2i_1
X_0783_ _0188_ net246 _0189_ net249 net250 VSS VSS VDD VDD
+ _0190_ sky130_fd_sc_hd__a221oi_1
X_0784_ net250 _0187_ _0190_ VSS VSS VDD VDD _0191_ sky130_fd_sc_hd__a21oi_1
X_0785_ active_row\[0\]\[2\] _0142_ VSS VSS VDD VDD _0192_
+ sky130_fd_sc_hd__nor2_1
X_0786_ _0191_ _0192_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__nor2_1
X_0787_ net27 _0193_ VSS VSS VDD VDD _0194_ sky130_fd_sc_hd__xor2_1
X_0788_ active_row\[4\]\[10\] active_row\[5\]\[10\] active_row\[6\]\[10\]
+ active_row\[7\]\[10\] net251 net250 VSS VSS VDD VDD _0195_
+ sky130_fd_sc_hd__mux4_2
Xinput56 rd_ready VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0790_ active_row\[1\]\[10\] active_row\[3\]\[10\] net250
+ VSS VSS VDD VDD _0197_ sky130_fd_sc_hd__mux2i_1
X_0791_ net251 active_row\[2\]\[10\] net250 VSS VSS VDD VDD
+ _0198_ sky130_fd_sc_hd__nor3b_1
X_0792_ net251 _0197_ _0198_ net249 VSS VSS VDD VDD _0199_
+ sky130_fd_sc_hd__a211oi_1
X_0793_ net249 _0195_ _0199_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__a21o_1
X_0794_ active_row\[0\]\[10\] _0142_ _0200_ VSS VSS VDD VDD
+ _0201_ sky130_fd_sc_hd__o21ai_2
X_0795_ net36 _0201_ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__xnor2_1
X_0796_ net30 VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__inv_1
X_0797_ active_row\[0\]\[5\] _0142_ _0203_ VSS VSS VDD VDD
+ _0204_ sky130_fd_sc_hd__o21ai_0
X_0798_ active_row\[4\]\[5\] _0130_ net246 active_row\[1\]\[5\]
+ VSS VSS VDD VDD _0205_ sky130_fd_sc_hd__a22oi_1
X_0799_ net250 _0205_ VSS VSS VDD VDD _0206_ sky130_fd_sc_hd__nor2_1
X_0800_ net250 active_row\[3\]\[5\] net246 VSS VSS VDD VDD
+ _0207_ sky130_fd_sc_hd__and3_1
X_0801_ _0122_ net250 active_row\[5\]\[5\] VSS VSS VDD VDD
+ _0208_ sky130_fd_sc_hd__nor3b_1
X_0802_ active_row\[6\]\[5\] active_row\[7\]\[5\] net251 VSS
+ VSS VDD VDD _0209_ sky130_fd_sc_hd__mux2i_1
X_0803_ _0119_ active_row\[2\]\[5\] _0135_ VSS VSS VDD VDD
+ _0210_ sky130_fd_sc_hd__o21ai_0
X_0804_ _0137_ _0209_ _0210_ net249 VSS VSS VDD VDD _0211_
+ sky130_fd_sc_hd__o22ai_1
X_0805_ _0206_ _0207_ _0208_ _0211_ VSS VSS VDD VDD _0212_
+ sky130_fd_sc_hd__nor4_1
X_0806_ _0204_ _0203_ _0212_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__mux2i_1
X_0807_ net250 active_row\[3\]\[3\] net246 _0146_ active_row\[4\]\[3\]
+ VSS VSS VDD VDD _0214_ sky130_fd_sc_hd__a32oi_1
X_0808_ _0119_ active_row\[2\]\[3\] _0149_ VSS VSS VDD VDD
+ _0215_ sky130_fd_sc_hd__o21ai_0
X_0809_ active_row\[1\]\[3\] _0150_ VSS VSS VDD VDD _0216_
+ sky130_fd_sc_hd__nand2_1
X_0810_ active_row\[5\]\[3\] active_row\[7\]\[3\] net250 VSS
+ VSS VDD VDD _0217_ sky130_fd_sc_hd__mux2i_1
X_0811_ net251 _0217_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__nand2_1
X_0812_ net250 active_row\[6\]\[3\] VSS VSS VDD VDD _0219_
+ sky130_fd_sc_hd__nand2_1
X_0813_ _0135_ _0219_ VSS VSS VDD VDD _0220_ sky130_fd_sc_hd__nand2_1
X_0814_ net249 _0218_ _0220_ VSS VSS VDD VDD _0221_ sky130_fd_sc_hd__nand3_1
X_0815_ active_row\[0\]\[3\] _0142_ VSS VSS VDD VDD _0222_
+ sky130_fd_sc_hd__nor2_1
X_0816_ _0214_ _0215_ _0216_ _0221_ _0222_ VSS VSS VDD VDD
+ _0223_ sky130_fd_sc_hd__a41oi_1
X_0817_ net28 _0223_ VSS VSS VDD VDD _0224_ sky130_fd_sc_hd__xor2_1
X_0818_ _0194_ _0202_ _0213_ _0224_ VSS VSS VDD VDD _0225_
+ sky130_fd_sc_hd__nor4_2
X_0819_ active_row\[4\]\[8\] _0130_ net246 active_row\[1\]\[8\]
+ VSS VSS VDD VDD _0226_ sky130_fd_sc_hd__a22oi_1
X_0820_ net250 _0226_ VSS VSS VDD VDD _0227_ sky130_fd_sc_hd__nor2_1
X_0821_ _0122_ net250 active_row\[5\]\[8\] VSS VSS VDD VDD
+ _0228_ sky130_fd_sc_hd__nor3b_1
X_0822_ net250 active_row\[3\]\[8\] net246 _0227_ _0228_ VSS
+ VSS VDD VDD _0229_ sky130_fd_sc_hd__a311oi_1
X_0823_ active_row\[6\]\[8\] active_row\[7\]\[8\] net251 VSS
+ VSS VDD VDD _0230_ sky130_fd_sc_hd__mux2_2
X_0824_ net249 net250 _0230_ VSS VSS VDD VDD _0231_ sky130_fd_sc_hd__nand3_1
X_0825_ _0119_ active_row\[2\]\[8\] _0149_ VSS VSS VDD VDD
+ _0232_ sky130_fd_sc_hd__o21ai_0
X_0826_ active_row\[0\]\[8\] _0142_ VSS VSS VDD VDD _0233_
+ sky130_fd_sc_hd__nor2_1
X_0827_ _0229_ _0231_ _0232_ _0233_ net34 VSS VSS VDD VDD
+ _0234_ sky130_fd_sc_hd__a311oi_1
X_0828_ net26 VSS VSS VDD VDD _0235_ sky130_fd_sc_hd__inv_1
X_0829_ active_row\[0\]\[1\] _0142_ _0235_ VSS VSS VDD VDD
+ _0236_ sky130_fd_sc_hd__o21ai_0
X_0830_ active_row\[4\]\[1\] _0130_ net246 active_row\[1\]\[1\]
+ VSS VSS VDD VDD _0237_ sky130_fd_sc_hd__a22oi_1
X_0831_ active_row\[6\]\[1\] active_row\[7\]\[1\] net251 VSS
+ VSS VDD VDD _0238_ sky130_fd_sc_hd__mux2i_1
X_0832_ _0119_ active_row\[2\]\[1\] _0135_ VSS VSS VDD VDD
+ _0239_ sky130_fd_sc_hd__o21ai_0
X_0833_ _0137_ _0238_ _0239_ net249 VSS VSS VDD VDD _0240_
+ sky130_fd_sc_hd__o22a_1
X_0834_ _0122_ net250 active_row\[5\]\[1\] VSS VSS VDD VDD
+ _0241_ sky130_fd_sc_hd__nor3b_1
X_0835_ net250 active_row\[3\]\[1\] net246 _0241_ VSS VSS
+ VDD VDD _0242_ sky130_fd_sc_hd__a31oi_1
X_0836_ net250 _0237_ _0240_ _0242_ VSS VSS VDD VDD _0243_
+ sky130_fd_sc_hd__o211ai_1
X_0837_ _0235_ _0236_ _0243_ VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__mux2i_1
X_0838_ bank_active\[4\] bank_active\[6\] net250 VSS VSS VDD
+ VDD _0245_ sky130_fd_sc_hd__mux2i_1
X_0839_ _0135_ _0245_ VSS VSS VDD VDD _0246_ sky130_fd_sc_hd__nand2_1
X_0840_ _0135_ _0119_ bank_active\[7\] VSS VSS VDD VDD _0247_
+ sky130_fd_sc_hd__or3_1
X_0841_ bank_active\[1\] bank_active\[3\] net250 VSS VSS VDD
+ VDD _0248_ sky130_fd_sc_hd__mux2i_1
X_0842_ net251 bank_active\[2\] VSS VSS VDD VDD _0249_ sky130_fd_sc_hd__nor2_1
X_0843_ net251 _0248_ _0249_ net250 net249 VSS VSS VDD VDD
+ _0250_ sky130_fd_sc_hd__a221oi_1
X_0844_ net249 _0246_ _0247_ _0250_ VSS VSS VDD VDD _0251_
+ sky130_fd_sc_hd__a31oi_1
X_0845_ bank_active\[5\] _0122_ VSS VSS VDD VDD _0252_ sky130_fd_sc_hd__nor2_1
X_0846_ net249 bank_active\[0\] net251 VSS VSS VDD VDD _0253_
+ sky130_fd_sc_hd__nor3_1
X_0847_ _0252_ _0253_ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__nor2_1
X_0848_ net250 _0254_ VSS VSS VDD VDD _0255_ sky130_fd_sc_hd__nor2_1
X_0849_ net37 VSS VSS VDD VDD _0256_ sky130_fd_sc_hd__inv_1
X_0850_ active_row\[0\]\[1\] _0235_ active_row\[0\]\[11\]
+ _0256_ VSS VSS VDD VDD _0257_ sky130_fd_sc_hd__o22ai_1
X_0851_ net38 VSS VSS VDD VDD _0258_ sky130_fd_sc_hd__inv_1
X_0852_ active_row\[0\]\[8\] net34 VSS VSS VDD VDD _0259_
+ sky130_fd_sc_hd__nand2b_1
X_0853_ active_row\[0\]\[7\] _0175_ active_row\[0\]\[12\]
+ _0258_ _0259_ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__o221ai_1
X_0854_ active_row\[0\]\[5\] _0203_ active_row\[0\]\[6\] _0160_
+ VSS VSS VDD VDD _0261_ sky130_fd_sc_hd__o22ai_1
X_0855_ net249 net251 net250 VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__nor3_1
X_0856_ _0257_ _0260_ _0261_ _0262_ VSS VSS VDD VDD _0263_
+ sky130_fd_sc_hd__o31a_1
X_0857_ net37 _0141_ _0251_ _0255_ _0263_ VSS VSS VDD VDD
+ _0264_ sky130_fd_sc_hd__a2111oi_0
X_0858_ net34 _0229_ _0231_ _0232_ VSS VSS VDD VDD _0265_
+ sky130_fd_sc_hd__nand4_1
X_0859_ _0234_ _0244_ _0264_ _0265_ VSS VSS VDD VDD _0266_
+ sky130_fd_sc_hd__and4bb_1
X_0860_ active_row\[4\]\[13\] active_row\[5\]\[13\] active_row\[6\]\[13\]
+ active_row\[7\]\[13\] net251 net250 VSS VSS VDD VDD _0267_
+ sky130_fd_sc_hd__mux4_2
X_0861_ active_row\[1\]\[13\] active_row\[3\]\[13\] net250
+ VSS VSS VDD VDD _0268_ sky130_fd_sc_hd__mux2i_1
X_0862_ net251 active_row\[2\]\[13\] net250 VSS VSS VDD VDD
+ _0269_ sky130_fd_sc_hd__nor3b_1
X_0863_ net251 _0268_ _0269_ net249 VSS VSS VDD VDD _0270_
+ sky130_fd_sc_hd__a211oi_1
X_0864_ net249 _0267_ _0270_ VSS VSS VDD VDD _0271_ sky130_fd_sc_hd__a21o_1
X_0865_ active_row\[0\]\[13\] _0142_ _0271_ VSS VSS VDD VDD
+ _0272_ sky130_fd_sc_hd__o21ai_0
X_0866_ net39 _0272_ VSS VSS VDD VDD _0273_ sky130_fd_sc_hd__xnor2_1
X_0867_ active_row\[6\]\[4\] active_row\[7\]\[4\] net251 VSS
+ VSS VDD VDD _0274_ sky130_fd_sc_hd__mux2i_1
X_0868_ _0137_ _0274_ VSS VSS VDD VDD _0275_ sky130_fd_sc_hd__nor2_1
X_0869_ _0119_ active_row\[1\]\[4\] net246 _0275_ VSS VSS
+ VDD VDD _0276_ sky130_fd_sc_hd__a31oi_1
X_0870_ _0119_ active_row\[5\]\[4\] _0122_ VSS VSS VDD VDD
+ _0277_ sky130_fd_sc_hd__a21oi_1
X_0871_ net250 active_row\[3\]\[4\] VSS VSS VDD VDD _0278_
+ sky130_fd_sc_hd__nand2_1
X_0872_ net246 _0278_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__nand2_1
X_0873_ active_row\[4\]\[4\] VSS VSS VDD VDD _0280_ sky130_fd_sc_hd__inv_1
X_0874_ active_row\[2\]\[4\] net250 VSS VSS VDD VDD _0281_
+ sky130_fd_sc_hd__nor2b_1
X_0875_ net250 _0280_ _0281_ net249 _0135_ VSS VSS VDD VDD
+ _0282_ sky130_fd_sc_hd__o221ai_1
X_0876_ _0277_ _0279_ _0282_ VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__nand3b_1
X_0877_ _0276_ _0283_ _0142_ active_row\[0\]\[4\] VSS VSS
+ VDD VDD _0284_ sky130_fd_sc_hd__o2bb2ai_2
X_0878_ net29 _0284_ VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__xnor2_1
X_0879_ active_row\[1\]\[9\] active_row\[3\]\[9\] net250 VSS
+ VSS VDD VDD _0286_ sky130_fd_sc_hd__mux2i_1
X_0880_ net250 active_row\[5\]\[9\] net249 VSS VSS VDD VDD
+ _0287_ sky130_fd_sc_hd__nand3b_1
X_0881_ net249 _0286_ _0287_ VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__o21ai_0
X_0882_ net251 _0288_ VSS VSS VDD VDD _0289_ sky130_fd_sc_hd__nand2_1
X_0883_ _0119_ active_row\[2\]\[9\] _0149_ VSS VSS VDD VDD
+ _0290_ sky130_fd_sc_hd__o21ai_0
X_0884_ active_row\[4\]\[9\] _0146_ VSS VSS VDD VDD _0291_
+ sky130_fd_sc_hd__nand2_1
X_0885_ active_row\[6\]\[9\] active_row\[7\]\[9\] net251 VSS
+ VSS VDD VDD _0292_ sky130_fd_sc_hd__mux2_2
X_0886_ net249 net250 _0292_ VSS VSS VDD VDD _0293_ sky130_fd_sc_hd__nand3_1
X_0887_ active_row\[0\]\[9\] _0142_ VSS VSS VDD VDD _0294_
+ sky130_fd_sc_hd__nor2_1
X_0888_ _0289_ _0290_ _0291_ _0293_ _0294_ VSS VSS VDD VDD
+ _0295_ sky130_fd_sc_hd__a41oi_1
X_0889_ net35 _0295_ VSS VSS VDD VDD _0296_ sky130_fd_sc_hd__xor2_1
X_0890_ net250 active_row\[3\]\[0\] net246 _0146_ active_row\[4\]\[0\]
+ VSS VSS VDD VDD _0297_ sky130_fd_sc_hd__a32oi_1
X_0891_ _0119_ active_row\[2\]\[0\] _0149_ VSS VSS VDD VDD
+ _0298_ sky130_fd_sc_hd__o21ai_0
X_0892_ active_row\[1\]\[0\] _0150_ VSS VSS VDD VDD _0299_
+ sky130_fd_sc_hd__nand2_1
X_0893_ active_row\[5\]\[0\] active_row\[7\]\[0\] net250 VSS
+ VSS VDD VDD _0300_ sky130_fd_sc_hd__mux2i_1
X_0894_ net251 _0300_ VSS VSS VDD VDD _0301_ sky130_fd_sc_hd__nand2_1
X_0895_ net250 active_row\[6\]\[0\] VSS VSS VDD VDD _0302_
+ sky130_fd_sc_hd__nand2_1
X_0896_ _0135_ _0302_ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__nand2_1
X_0897_ net249 _0301_ _0303_ VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__nand3_1
X_0898_ active_row\[0\]\[0\] _0142_ VSS VSS VDD VDD _0305_
+ sky130_fd_sc_hd__nor2_1
X_0899_ _0297_ _0298_ _0299_ _0304_ _0305_ VSS VSS VDD VDD
+ _0306_ sky130_fd_sc_hd__a41oi_1
X_0900_ net25 _0306_ VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__xor2_1
X_0901_ _0273_ _0285_ _0296_ _0307_ VSS VSS VDD VDD _0308_
+ sky130_fd_sc_hd__nor4_1
X_0902_ _0186_ _0225_ _0266_ _0308_ VSS VSS VDD VDD _0309_
+ sky130_fd_sc_hd__nand4_1
X_0903_ _0117_ _0309_ VSS VSS VDD VDD _0310_ sky130_fd_sc_hd__nor2_1
X_0904_ net242 VSS VSS VDD VDD _0311_ sky130_fd_sc_hd__inv_1
X_0905_ net53 VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__inv_1
X_0906_ burst_counter\[3\] burst_counter\[2\] VSS VSS VDD
+ VDD _0313_ sky130_fd_sc_hd__nor2_1
X_0907_ _0030_ _0313_ VSS VSS VDD VDD _0314_ sky130_fd_sc_hd__and2_1
Xinput55 phy_clk VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0909_ net153 _0104_ net245 VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__nand3b_1
X_0910_ _0311_ net245 _0312_ _0314_ _0316_ VSS VSS VDD VDD
+ _0317_ sky130_fd_sc_hd__o32ai_1
X_0911_ net53 _0115_ _0310_ _0317_ net240 VSS VSS VDD VDD
+ _0318_ sky130_fd_sc_hd__a32oi_1
X_0912_ net243 _0318_ VSS VSS VDD VDD _0609_ sky130_fd_sc_hd__nor2_1
X_0913_ net240 VSS VSS VDD VDD _0319_ sky130_fd_sc_hd__inv_2
Xinput54 cmd_write VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0915_ _0312_ _0319_ net242 VSS VSS VDD VDD _0321_ sky130_fd_sc_hd__o21ai_0
X_0916_ net243 net241 VSS VSS VDD VDD _0322_ sky130_fd_sc_hd__nor2_1
X_0917_ _0049_ _0051_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__nor2_1
X_0918_ _0322_ _0323_ VSS VSS VDD VDD _0324_ sky130_fd_sc_hd__nand2_1
X_0919_ init_state\[5\] init_state\[1\] VSS VSS VDD VDD _0325_
+ sky130_fd_sc_hd__or2_2
Xinput53 cmd_valid VSS VSS VDD VDD net52 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0921_ init_state\[6\] _0325_ VSS VSS VDD VDD _0327_ sky130_fd_sc_hd__nor2_1
X_0922_ _0319_ _0327_ net243 VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__o21ai_0
X_0923_ _0030_ _0313_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__nand2_1
X_0924_ _0319_ _0329_ net245 VSS VSS VDD VDD _0330_ sky130_fd_sc_hd__o21ai_0
X_0925_ _0324_ _0328_ _0330_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__and3_1
X_0926_ refresh_counter\[1\] _0107_ _0106_ VSS VSS VDD VDD
+ _0332_ sky130_fd_sc_hd__o21ai_0
X_0927_ refresh_counter\[15\] _0111_ _0109_ VSS VSS VDD VDD
+ _0333_ sky130_fd_sc_hd__nor3_1
X_0928_ _0112_ _0105_ _0332_ _0333_ VSS VSS VDD VDD _0334_
+ sky130_fd_sc_hd__a22oi_1
X_0929_ _0186_ _0225_ _0266_ _0308_ VSS VSS VDD VDD _0335_
+ sky130_fd_sc_hd__and4_1
Xinput52 cmd_burst_len[3] VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput51 cmd_burst_len[2] VSS VSS VDD VDD net50 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0932_ net52 net240 _0335_ VSS VSS VDD VDD _0338_ sky130_fd_sc_hd__nand3_1
Xinput50 cmd_burst_len[1] VSS VSS VDD VDD net49 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput49 cmd_burst_len[0] VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0935_ _0312_ _0334_ _0338_ net241 VSS VSS VDD VDD _0341_
+ sky130_fd_sc_hd__o31ai_1
X_0936_ _0321_ _0331_ _0341_ VSS VSS VDD VDD _0610_ sky130_fd_sc_hd__nand3_1
X_0937_ _0117_ _0309_ _0115_ VSS VSS VDD VDD _0342_ sky130_fd_sc_hd__o21a_2
X_0938_ net242 net241 VSS VSS VDD VDD _0343_ sky130_fd_sc_hd__nor2_1
X_0939_ net242 _0319_ _0343_ VSS VSS VDD VDD _0344_ sky130_fd_sc_hd__a21oi_1
X_0940_ net243 _0344_ _0328_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__o21ai_0
X_0941_ net245 _0342_ _0345_ VSS VSS VDD VDD _0611_ sky130_fd_sc_hd__or3_1
X_0942_ _0117_ _0335_ _0115_ VSS VSS VDD VDD _0346_ sky130_fd_sc_hd__o21ai_0
X_0943_ _0311_ _0331_ _0346_ VSS VSS VDD VDD _0612_ sky130_fd_sc_hd__nand3_1
X_0944_ init_state\[7\] _0091_ _0093_ VSS VSS VDD VDD _0347_
+ sky130_fd_sc_hd__and3_1
X_0945_ net243 _0347_ VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__nand2_1
X_0946_ net243 net241 VSS VSS VDD VDD _0349_ sky130_fd_sc_hd__nand2b_1
X_0947_ _0348_ _0349_ _0115_ VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__a21oi_1
Xinput48 cmd_addr[9] VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkdlybuf4s50_1
X_0949_ refresh_counter\[0\] _0113_ VSS VSS VDD VDD _0352_
+ sky130_fd_sc_hd__xnor2_1
X_0950_ net235 _0352_ VSS VSS VDD VDD _0613_ sky130_fd_sc_hd__nor2_1
X_0951_ refresh_counter\[1\] _0113_ VSS VSS VDD VDD _0353_
+ sky130_fd_sc_hd__nor2_1
X_0952_ _0034_ _0113_ net235 _0353_ VSS VSS VDD VDD _0620_
+ sky130_fd_sc_hd__a211oi_1
X_0953_ _0035_ _0113_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__nand2_1
X_0954_ refresh_counter\[2\] _0354_ VSS VSS VDD VDD _0355_
+ sky130_fd_sc_hd__xor2_1
X_0955_ net235 _0355_ VSS VSS VDD VDD _0621_ sky130_fd_sc_hd__nor2_1
X_0956_ refresh_counter\[2\] refresh_counter\[1\] refresh_counter\[0\]
+ _0113_ VSS VSS VDD VDD _0356_ sky130_fd_sc_hd__nand4_1
X_0957_ refresh_counter\[3\] _0356_ VSS VSS VDD VDD _0357_
+ sky130_fd_sc_hd__xor2_1
X_0958_ net235 _0357_ VSS VSS VDD VDD _0622_ sky130_fd_sc_hd__nor2_1
X_0959_ refresh_counter\[4\] VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__inv_1
X_0960_ refresh_counter\[3\] refresh_counter\[2\] _0035_ _0113_
+ VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__nand4_1
X_0961_ _0358_ _0359_ VSS VSS VDD VDD _0360_ sky130_fd_sc_hd__xnor2_1
X_0962_ net235 _0360_ VSS VSS VDD VDD _0623_ sky130_fd_sc_hd__nor2_1
X_0963_ refresh_counter\[4\] refresh_counter\[3\] VSS VSS
+ VDD VDD _0361_ sky130_fd_sc_hd__nand2_1
X_0964_ _0361_ _0356_ VSS VSS VDD VDD _0362_ sky130_fd_sc_hd__or2_2
X_0965_ refresh_counter\[5\] _0362_ VSS VSS VDD VDD _0363_
+ sky130_fd_sc_hd__xor2_1
X_0966_ net235 _0363_ VSS VSS VDD VDD _0624_ sky130_fd_sc_hd__nor2_1
X_0967_ _0358_ _0359_ VSS VSS VDD VDD _0364_ sky130_fd_sc_hd__nor2_1
X_0968_ refresh_counter\[5\] _0364_ VSS VSS VDD VDD _0365_
+ sky130_fd_sc_hd__nand2_1
X_0969_ refresh_counter\[6\] _0365_ VSS VSS VDD VDD _0366_
+ sky130_fd_sc_hd__xor2_1
X_0970_ net235 _0366_ VSS VSS VDD VDD _0625_ sky130_fd_sc_hd__nor2_1
X_0971_ refresh_counter\[6\] refresh_counter\[5\] VSS VSS
+ VDD VDD _0367_ sky130_fd_sc_hd__nand2_1
X_0972_ _0362_ _0367_ refresh_counter\[7\] VSS VSS VDD VDD
+ _0368_ sky130_fd_sc_hd__o21ai_0
X_0973_ refresh_counter\[7\] _0362_ _0367_ VSS VSS VDD VDD
+ _0369_ sky130_fd_sc_hd__or3_1
X_0974_ _0368_ _0369_ net235 VSS VSS VDD VDD _0626_ sky130_fd_sc_hd__a21oi_1
X_0975_ refresh_counter\[6\] refresh_counter\[7\] refresh_counter\[5\]
+ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__and3_1
X_0976_ _0364_ _0370_ VSS VSS VDD VDD _0371_ sky130_fd_sc_hd__nand2_1
X_0977_ refresh_counter\[8\] _0371_ VSS VSS VDD VDD _0372_
+ sky130_fd_sc_hd__xor2_1
X_0978_ net235 _0372_ VSS VSS VDD VDD _0627_ sky130_fd_sc_hd__nor2_1
X_0979_ refresh_counter\[8\] _0370_ VSS VSS VDD VDD _0373_
+ sky130_fd_sc_hd__nand2_1
X_0980_ _0362_ _0373_ refresh_counter\[9\] VSS VSS VDD VDD
+ _0374_ sky130_fd_sc_hd__o21ai_0
X_0981_ refresh_counter\[9\] _0362_ _0373_ VSS VSS VDD VDD
+ _0375_ sky130_fd_sc_hd__or3_1
X_0982_ _0374_ _0375_ net235 VSS VSS VDD VDD _0628_ sky130_fd_sc_hd__a21oi_1
X_0983_ refresh_counter\[9\] refresh_counter\[8\] _0364_ _0370_
+ refresh_counter\[10\] VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__a41oi_1
X_0984_ net235 _0376_ VSS VSS VDD VDD _0614_ sky130_fd_sc_hd__nor2_1
X_0985_ net235 refresh_counter\[11\] VSS VSS VDD VDD _0615_
+ sky130_fd_sc_hd__nor2b_1
X_0986_ net235 refresh_counter\[12\] VSS VSS VDD VDD _0616_
+ sky130_fd_sc_hd__nor2b_1
X_0987_ net235 refresh_counter\[13\] VSS VSS VDD VDD _0617_
+ sky130_fd_sc_hd__nor2b_1
X_0988_ net235 refresh_counter\[14\] VSS VSS VDD VDD _0618_
+ sky130_fd_sc_hd__nor2b_1
X_0989_ net235 refresh_counter\[15\] VSS VSS VDD VDD _0619_
+ sky130_fd_sc_hd__nor2b_1
X_0990_ net243 net242 net241 net245 VSS VSS VDD VDD _0377_
+ sky130_fd_sc_hd__nor4_1
X_0991_ net121 VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__inv_1
X_0992_ net153 net218 net55 VSS VSS VDD VDD _0379_ sky130_fd_sc_hd__nand3_1
X_0993_ net153 _0378_ _0379_ VSS VSS VDD VDD _0380_ sky130_fd_sc_hd__o21ai_0
X_0994_ _0104_ _0380_ VSS VSS VDD VDD _0381_ sky130_fd_sc_hd__nand2_1
X_0995_ timer\[15\] timer\[14\] VSS VSS VDD VDD _0382_ sky130_fd_sc_hd__nor2_1
X_0996_ _0088_ _0090_ _0092_ _0382_ VSS VSS VDD VDD _0383_
+ sky130_fd_sc_hd__nor4b_4
X_0997_ net153 _0104_ _0383_ VSS VSS VDD VDD _0384_ sky130_fd_sc_hd__nand3_2
X_0998_ _0381_ _0384_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__nor2b_4
X_0999_ timer\[3\] timer\[2\] VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__nor2_1
X_1000_ _0044_ _0386_ VSS VSS VDD VDD _0387_ sky130_fd_sc_hd__nand2_1
X_1001_ timer\[0\] _0384_ _0387_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__nor3b_1
X_1002_ _0329_ _0385_ _0388_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__a21oi_1
X_1003_ _0319_ _0314_ VSS VSS VDD VDD _0390_ sky130_fd_sc_hd__nor2_1
X_1004_ _0319_ _0384_ _0381_ _0390_ VSS VSS VDD VDD _0391_
+ sky130_fd_sc_hd__a31oi_1
X_1005_ net240 _0389_ _0391_ _0039_ VSS VSS VDD VDD _0392_
+ sky130_fd_sc_hd__o22ai_1
X_1006_ init_state\[2\] init_state\[6\] _0325_ VSS VSS VDD
+ VDD _0393_ sky130_fd_sc_hd__nor3_1
X_1007_ init_state\[4\] init_state\[3\] init_state\[0\] VSS
+ VSS VDD VDD _0394_ sky130_fd_sc_hd__nor3_1
X_1008_ _0393_ _0394_ VSS VSS VDD VDD _0395_ sky130_fd_sc_hd__nand2_1
X_1009_ _0038_ _0395_ VSS VSS VDD VDD _0396_ sky130_fd_sc_hd__nand2_1
X_1010_ _0039_ _0395_ _0396_ VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__o21ai_0
X_1011_ _0311_ _0040_ _0324_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__o21ai_0
X_1012_ net245 _0392_ _0397_ net243 _0398_ VSS VSS VDD VDD
+ _0399_ sky130_fd_sc_hd__a221oi_2
X_1013_ _0377_ _0399_ VSS VSS VDD VDD _0400_ sky130_fd_sc_hd__nor2_1
X_1014_ _0115_ _0117_ VSS VSS VDD VDD _0401_ sky130_fd_sc_hd__nand2_1
X_1015_ _0399_ _0401_ _0039_ VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__a21oi_1
X_1016_ _0115_ _0310_ _0400_ _0402_ VSS VSS VDD VDD _0629_
+ sky130_fd_sc_hd__a211o_1
X_1017_ timer\[1\] VSS VSS VDD VDD _0041_ sky130_fd_sc_hd__inv_1
X_1018_ _0312_ _0338_ _0115_ VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__o21ai_1
X_1019_ net52 _0324_ VSS VSS VDD VDD _0404_ sky130_fd_sc_hd__nand2_1
X_1020_ net240 _0404_ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__nand2_1
Xinput47 cmd_addr[8] VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkdlybuf4s50_1
X_1022_ _0043_ _0319_ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__nand2_1
X_1023_ timer\[1\] _0405_ _0406_ VSS VSS VDD VDD _0407_ sky130_fd_sc_hd__o21ai_0
Xinput46 cmd_addr[7] VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkdlybuf4s50_1
X_1025_ _0384_ _0387_ VSS VSS VDD VDD _0409_ sky130_fd_sc_hd__nor2_1
X_1026_ _0043_ _0385_ _0409_ _0319_ VSS VSS VDD VDD _0410_
+ sky130_fd_sc_hd__o31ai_1
X_1027_ _0041_ net240 _0329_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__nand3_1
X_1028_ timer\[1\] _0319_ _0377_ VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__o21ai_0
X_1029_ timer\[1\] _0394_ VSS VSS VDD VDD _0413_ sky130_fd_sc_hd__nand2_1
X_1030_ net240 _0393_ _0413_ VSS VSS VDD VDD _0414_ sky130_fd_sc_hd__nand3_1
X_1031_ net243 _0414_ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__nand2_1
X_1032_ _0321_ _0412_ _0415_ VSS VSS VDD VDD _0416_ sky130_fd_sc_hd__nand3_1
X_1033_ net245 _0410_ _0411_ _0406_ _0416_ VSS VSS VDD VDD
+ _0417_ sky130_fd_sc_hd__a32oi_1
X_1034_ _0403_ _0407_ _0417_ VSS VSS VDD VDD _0636_ sky130_fd_sc_hd__o21ai_0
X_1035_ init_state\[0\] _0319_ net243 VSS VSS VDD VDD _0418_
+ sky130_fd_sc_hd__o21ai_0
X_1036_ timer\[2\] _0042_ VSS VSS VDD VDD _0419_ sky130_fd_sc_hd__xnor2_1
X_1037_ net240 _0321_ _0418_ _0419_ VSS VSS VDD VDD _0420_
+ sky130_fd_sc_hd__a31oi_1
X_1038_ net53 _0338_ _0334_ VSS VSS VDD VDD _0421_ sky130_fd_sc_hd__o21bai_1
X_1039_ net241 VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__inv_1
X_1040_ net240 _0384_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__nor2_1
X_1041_ _0384_ _0387_ _0423_ _0381_ VSS VSS VDD VDD _0424_
+ sky130_fd_sc_hd__o22ai_1
X_1042_ _0424_ VSS VSS VDD VDD _0425_ sky130_fd_sc_hd__inv_1
X_1043_ net245 _0425_ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__nand2_1
X_1044_ net240 _0426_ _0418_ _0321_ VSS VSS VDD VDD _0427_
+ sky130_fd_sc_hd__o211ai_1
X_1045_ net240 _0324_ VSS VSS VDD VDD _0428_ sky130_fd_sc_hd__nor2_1
X_1046_ _0427_ _0428_ _0419_ VSS VSS VDD VDD _0429_ sky130_fd_sc_hd__o21bai_1
X_1047_ _0420_ _0421_ _0422_ _0429_ VSS VSS VDD VDD _0637_
+ sky130_fd_sc_hd__a2bb2oi_1
X_1048_ timer\[2\] timer\[0\] timer\[1\] timer\[3\] VSS VSS
+ VDD VDD _0430_ sky130_fd_sc_hd__o31ai_1
X_1049_ timer\[0\] VSS VSS VDD VDD _0036_ sky130_fd_sc_hd__inv_1
X_1050_ _0036_ _0041_ _0386_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__nand3_1
X_1051_ _0319_ _0430_ _0431_ VSS VSS VDD VDD _0432_ sky130_fd_sc_hd__nand3_1
X_1052_ _0405_ _0432_ VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__nand2_1
X_1053_ _0321_ VSS VSS VDD VDD _0434_ sky130_fd_sc_hd__inv_1
X_1054_ _0324_ _0426_ net240 VSS VSS VDD VDD _0435_ sky130_fd_sc_hd__a21oi_1
X_1055_ _0430_ _0431_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__nand2_1
X_1056_ _0434_ _0435_ _0436_ VSS VSS VDD VDD _0437_ sky130_fd_sc_hd__o21ai_0
X_1057_ init_state\[4\] init_state\[3\] VSS VSS VDD VDD _0438_
+ sky130_fd_sc_hd__nor2_1
X_1058_ net240 _0393_ _0438_ VSS VSS VDD VDD _0439_ sky130_fd_sc_hd__nand3_1
X_1059_ net245 _0314_ VSS VSS VDD VDD _0440_ sky130_fd_sc_hd__nand2_1
X_1060_ _0321_ _0440_ _0319_ VSS VSS VDD VDD _0441_ sky130_fd_sc_hd__a21oi_1
X_1061_ net243 _0439_ _0432_ _0441_ VSS VSS VDD VDD _0442_
+ sky130_fd_sc_hd__a31oi_1
X_1062_ _0403_ _0433_ _0437_ _0442_ VSS VSS VDD VDD _0638_
+ sky130_fd_sc_hd__o211ai_1
X_1063_ net240 _0424_ _0390_ VSS VSS VDD VDD _0443_ sky130_fd_sc_hd__o21bai_1
X_1064_ net243 net242 net241 VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__nor3_1
X_1065_ _0422_ net52 net240 VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__o21a_1
X_1066_ net243 _0393_ _0394_ _0377_ VSS VSS VDD VDD _0446_
+ sky130_fd_sc_hd__a31oi_1
X_1067_ _0444_ _0445_ _0446_ VSS VSS VDD VDD _0447_ sky130_fd_sc_hd__o21ai_0
X_1068_ net245 _0443_ _0447_ VSS VSS VDD VDD _0448_ sky130_fd_sc_hd__a21oi_1
X_1069_ timer\[4\] _0086_ _0383_ VSS VSS VDD VDD _0449_ sky130_fd_sc_hd__nor3_1
X_1070_ timer\[4\] _0086_ _0449_ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__a21oi_1
X_1071_ net241 _0334_ VSS VSS VDD VDD _0451_ sky130_fd_sc_hd__and2_1
X_1072_ _0448_ _0450_ _0451_ VSS VSS VDD VDD _0639_ sky130_fd_sc_hd__o21bai_1
X_1073_ timer\[4\] _0431_ timer\[5\] VSS VSS VDD VDD _0452_
+ sky130_fd_sc_hd__o21ai_0
X_1074_ timer\[5\] timer\[4\] _0431_ VSS VSS VDD VDD _0453_
+ sky130_fd_sc_hd__or3_1
X_1075_ _0319_ _0452_ _0453_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__nand3_1
X_1076_ net240 _0418_ VSS VSS VDD VDD _0455_ sky130_fd_sc_hd__nand2_1
X_1077_ net242 _0115_ _0377_ VSS VSS VDD VDD _0456_ sky130_fd_sc_hd__nor3_1
X_1078_ _0330_ _0424_ _0418_ _0456_ VSS VSS VDD VDD _0457_
+ sky130_fd_sc_hd__o211ai_1
X_1079_ _0454_ _0455_ _0457_ VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__and3_1
X_1080_ net245 _0384_ _0381_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__nand3_1
X_1081_ _0311_ _0401_ _0446_ _0458_ VSS VSS VDD VDD _0459_
+ sky130_fd_sc_hd__nand4_1
X_1082_ net240 _0393_ _0394_ VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__o21ai_0
X_1083_ _0319_ _0459_ _0460_ net243 VSS VSS VDD VDD _0461_
+ sky130_fd_sc_hd__a22oi_1
X_1084_ timer\[5\] timer\[4\] _0086_ VSS VSS VDD VDD _0462_
+ sky130_fd_sc_hd__nor3_1
X_1085_ timer\[6\] _0462_ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__xnor2_1
X_1086_ _0461_ _0463_ VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__nor2_1
X_1087_ timer\[5\] timer\[4\] timer\[6\] _0431_ VSS VSS VDD
+ VDD _0464_ sky130_fd_sc_hd__nor4_1
X_1088_ timer\[7\] _0464_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__xnor2_1
X_1089_ init_state\[2\] init_state\[6\] _0325_ VSS VSS VDD
+ VDD _0466_ sky130_fd_sc_hd__or3_1
X_1090_ init_state\[0\] _0466_ _0319_ VSS VSS VDD VDD _0467_
+ sky130_fd_sc_hd__o21ai_0
X_1091_ _0438_ _0467_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__nand2_1
X_1092_ _0311_ _0401_ _0426_ _0446_ VSS VSS VDD VDD _0469_
+ sky130_fd_sc_hd__nand4_1
X_1093_ net243 _0468_ _0469_ _0319_ VSS VSS VDD VDD _0470_
+ sky130_fd_sc_hd__a22oi_1
X_1094_ _0319_ _0465_ _0470_ VSS VSS VDD VDD _0642_ sky130_fd_sc_hd__a21oi_1
X_1095_ net243 _0469_ _0319_ VSS VSS VDD VDD _0471_ sky130_fd_sc_hd__o21ai_2
X_1096_ _0086_ _0088_ VSS VSS VDD VDD _0472_ sky130_fd_sc_hd__nor2_1
X_1097_ timer\[8\] _0472_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__xnor2_1
X_1098_ _0471_ _0473_ VSS VSS VDD VDD _0643_ sky130_fd_sc_hd__nor2_1
X_1099_ timer\[8\] _0088_ _0431_ timer\[9\] VSS VSS VDD VDD
+ _0474_ sky130_fd_sc_hd__o31ai_1
X_1100_ _0088_ _0090_ _0431_ VSS VSS VDD VDD _0475_ sky130_fd_sc_hd__or3_1
X_1101_ _0474_ _0475_ _0471_ VSS VSS VDD VDD _0644_ sky130_fd_sc_hd__a21oi_1
X_1102_ timer\[10\] _0091_ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__xnor2_1
X_1103_ _0471_ _0476_ VSS VSS VDD VDD _0630_ sky130_fd_sc_hd__nor2_1
X_1104_ timer\[10\] _0475_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__nor2_1
X_1105_ timer\[11\] _0477_ VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__xnor2_1
X_1106_ _0471_ _0478_ VSS VSS VDD VDD _0631_ sky130_fd_sc_hd__nor2_1
X_1107_ timer\[10\] timer\[11\] VSS VSS VDD VDD _0479_ sky130_fd_sc_hd__nor2_1
X_1108_ _0091_ _0479_ VSS VSS VDD VDD _0480_ sky130_fd_sc_hd__nand2_1
X_1109_ timer\[12\] _0480_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__xor2_1
X_1110_ _0471_ _0481_ VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__nor2_1
X_1111_ timer\[10\] timer\[11\] timer\[12\] _0475_ VSS VSS
+ VDD VDD _0482_ sky130_fd_sc_hd__nor4_1
X_1112_ timer\[13\] _0482_ VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__xnor2_1
X_1113_ _0471_ _0483_ VSS VSS VDD VDD _0633_ sky130_fd_sc_hd__nor2_1
X_1114_ net243 _0469_ VSS VSS VDD VDD _0484_ sky130_fd_sc_hd__nor2_1
X_1115_ timer\[14\] _0092_ VSS VSS VDD VDD _0485_ sky130_fd_sc_hd__nor2_1
X_1116_ _0086_ _0088_ _0090_ _0092_ timer\[14\] VSS VSS VDD
+ VDD _0486_ sky130_fd_sc_hd__o41a_1
X_1117_ timer\[15\] _0091_ _0485_ _0486_ VSS VSS VDD VDD _0487_
+ sky130_fd_sc_hd__a31oi_1
X_1118_ _0484_ _0487_ VSS VSS VDD VDD _0634_ sky130_fd_sc_hd__nor2_1
X_1119_ timer\[14\] _0092_ _0475_ VSS VSS VDD VDD _0488_ sky130_fd_sc_hd__nor3_1
X_1120_ timer\[15\] _0488_ VSS VSS VDD VDD _0489_ sky130_fd_sc_hd__xnor2_1
X_1121_ _0471_ _0489_ VSS VSS VDD VDD _0635_ sky130_fd_sc_hd__nor2_1
X_1122_ _0044_ _0386_ _0383_ net240 VSS VSS VDD VDD _0490_
+ sky130_fd_sc_hd__a31oi_1
X_1123_ net55 net240 _0329_ _0490_ VSS VSS VDD VDD _0491_
+ sky130_fd_sc_hd__a31oi_1
X_1124_ _0017_ _0491_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__and2_1
X_1125_ net138 VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__inv_1
X_1126_ refresh_counter\[0\] VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__inv_1
X_1127_ net219 VSS VSS VDD VDD _0045_ sky130_fd_sc_hd__inv_1
X_1128_ net139 VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__inv_1
X_1129_ burst_counter\[1\] VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__inv_1
X_1130_ net220 VSS VSS VDD VDD _0046_ sky130_fd_sc_hd__inv_1
Xinput45 cmd_addr[6] VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkdlybuf4s50_1
X_1132_ net242 net21 VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__nand2_1
X_1133_ _0319_ _0327_ VSS VSS VDD VDD _0494_ sky130_fd_sc_hd__nor2_1
X_1134_ _0042_ _0386_ VSS VSS VDD VDD _0495_ sky130_fd_sc_hd__and2_1
X_1135_ _0495_ _0383_ _0323_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__a21oi_1
X_1136_ net243 _0496_ VSS VSS VDD VDD _0497_ sky130_fd_sc_hd__nor2_1
X_1137_ _0495_ _0383_ VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__nand2_1
X_1138_ net245 _0329_ VSS VSS VDD VDD _0499_ sky130_fd_sc_hd__nand2_1
X_1139_ _0117_ _0334_ net241 VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__o21ai_1
X_1140_ _0498_ _0499_ _0324_ _0500_ VSS VSS VDD VDD _0501_
+ sky130_fd_sc_hd__o211a_1
X_1141_ _0494_ _0497_ _0501_ VSS VSS VDD VDD _0502_ sky130_fd_sc_hd__o21a_2
Xinput44 cmd_addr[5] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkdlybuf4s50_1
X_1143_ _0501_ _0497_ VSS VSS VDD VDD _0504_ sky130_fd_sc_hd__and2_1
Xinput43 cmd_addr[4] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkdlybuf4s50_1
X_1145_ _0325_ _0502_ _0504_ VSS VSS VDD VDD _0506_ sky130_fd_sc_hd__a21oi_1
X_1146_ net245 _0506_ VSS VSS VDD VDD _0507_ sky130_fd_sc_hd__nor2_1
X_1147_ net25 net21 _0335_ VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__mux2_2
X_1148_ net241 _0508_ VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__nand2_1
X_1149_ net243 _0325_ _0502_ VSS VSS VDD VDD _0510_ sky130_fd_sc_hd__nand3_1
X_1150_ net124 _0502_ _0510_ VSS VSS VDD VDD _0511_ sky130_fd_sc_hd__o21ai_0
X_1151_ _0493_ _0507_ _0509_ _0511_ VSS VSS VDD VDD _0052_
+ sky130_fd_sc_hd__a31oi_1
X_1152_ _0494_ _0497_ _0501_ VSS VSS VDD VDD _0512_ sky130_fd_sc_hd__o21ai_1
X_1153_ net125 _0512_ _0504_ net245 VSS VSS VDD VDD _0513_
+ sky130_fd_sc_hd__a22oi_1
X_1154_ net241 _0504_ VSS VSS VDD VDD _0514_ sky130_fd_sc_hd__nand2_1
X_1155_ _0335_ _0514_ VSS VSS VDD VDD _0515_ sky130_fd_sc_hd__nor2_1
X_1156_ net36 _0515_ VSS VSS VDD VDD _0516_ sky130_fd_sc_hd__nand2_1
X_1157_ _0513_ _0516_ VSS VSS VDD VDD _0053_ sky130_fd_sc_hd__nand2_1
X_1158_ init_state\[1\] _0502_ _0504_ VSS VSS VDD VDD _0517_
+ sky130_fd_sc_hd__a21oi_2
X_1159_ net243 init_state\[5\] net245 _0517_ VSS VSS VDD VDD
+ _0518_ sky130_fd_sc_hd__a211o_1
X_1160_ _0422_ _0256_ _0335_ VSS VSS VDD VDD _0519_ sky130_fd_sc_hd__nor3_1
X_1161_ init_state\[5\] init_state\[1\] _0502_ net243 VSS
+ VSS VDD VDD _0520_ sky130_fd_sc_hd__nand4b_1
X_1162_ net126 _0502_ _0518_ _0519_ _0520_ VSS VSS VDD VDD
+ _0054_ sky130_fd_sc_hd__o221a_1
X_1163_ net127 _0512_ _0504_ net245 VSS VSS VDD VDD _0521_
+ sky130_fd_sc_hd__a22oi_1
X_1164_ net38 _0515_ VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__nand2_1
X_1165_ _0521_ _0522_ VSS VSS VDD VDD _0055_ sky130_fd_sc_hd__nand2_1
X_1166_ net128 _0512_ _0504_ net245 VSS VSS VDD VDD _0523_
+ sky130_fd_sc_hd__a22oi_1
X_1167_ net39 _0515_ VSS VSS VDD VDD _0524_ sky130_fd_sc_hd__nand2_1
X_1168_ _0523_ _0524_ VSS VSS VDD VDD _0056_ sky130_fd_sc_hd__nand2_1
X_1169_ net242 net31 VSS VSS VDD VDD _0525_ sky130_fd_sc_hd__nand2_1
X_1170_ net26 net31 _0335_ VSS VSS VDD VDD _0526_ sky130_fd_sc_hd__mux2_2
X_1171_ net241 _0526_ VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__nand2_1
X_1172_ net129 _0502_ _0510_ VSS VSS VDD VDD _0528_ sky130_fd_sc_hd__o21ai_0
X_1173_ _0507_ _0525_ _0527_ _0528_ VSS VSS VDD VDD _0057_
+ sky130_fd_sc_hd__a31oi_1
X_1174_ net27 net40 _0335_ VSS VSS VDD VDD _0529_ sky130_fd_sc_hd__mux2_2
X_1175_ net242 net40 net245 net243 VSS VSS VDD VDD _0530_
+ sky130_fd_sc_hd__a211o_1
X_1176_ net241 _0529_ _0530_ VSS VSS VDD VDD _0531_ sky130_fd_sc_hd__a21oi_1
X_1177_ net130 _0512_ VSS VSS VDD VDD _0532_ sky130_fd_sc_hd__nand2_1
X_1178_ _0517_ _0531_ _0532_ VSS VSS VDD VDD _0058_ sky130_fd_sc_hd__o21ai_0
X_1179_ _0501_ _0497_ VSS VSS VDD VDD _0533_ sky130_fd_sc_hd__nand2_1
X_1180_ net242 net41 net245 VSS VSS VDD VDD _0534_ sky130_fd_sc_hd__a21oi_1
X_1181_ net28 net41 _0335_ VSS VSS VDD VDD _0535_ sky130_fd_sc_hd__mux2i_1
X_1182_ net131 _0512_ VSS VSS VDD VDD _0536_ sky130_fd_sc_hd__nand2_1
X_1183_ _0533_ _0534_ _0535_ _0514_ _0536_ VSS VSS VDD VDD
+ _0059_ sky130_fd_sc_hd__o221ai_1
X_1184_ net29 net42 _0335_ VSS VSS VDD VDD _0537_ sky130_fd_sc_hd__mux2_2
X_1185_ net242 net42 _0537_ net241 net245 VSS VSS VDD VDD
+ _0538_ sky130_fd_sc_hd__a221oi_1
X_1186_ net243 init_state\[5\] _0502_ VSS VSS VDD VDD _0539_
+ sky130_fd_sc_hd__and3_1
X_1187_ net132 _0512_ _0539_ VSS VSS VDD VDD _0540_ sky130_fd_sc_hd__a21oi_1
X_1188_ _0533_ _0538_ _0540_ VSS VSS VDD VDD _0060_ sky130_fd_sc_hd__o21ai_0
X_1189_ net242 net43 VSS VSS VDD VDD _0541_ sky130_fd_sc_hd__nand2_1
X_1190_ net30 net43 _0335_ VSS VSS VDD VDD _0542_ sky130_fd_sc_hd__mux2_2
X_1191_ net241 _0542_ VSS VSS VDD VDD _0543_ sky130_fd_sc_hd__nand2_1
X_1192_ net133 _0502_ _0510_ VSS VSS VDD VDD _0544_ sky130_fd_sc_hd__o21ai_0
X_1193_ _0507_ _0541_ _0543_ _0544_ VSS VSS VDD VDD _0061_
+ sky130_fd_sc_hd__a31oi_1
X_1194_ net32 net44 _0335_ VSS VSS VDD VDD _0545_ sky130_fd_sc_hd__mux2_2
X_1195_ net242 net44 _0545_ net241 net245 VSS VSS VDD VDD
+ _0546_ sky130_fd_sc_hd__a221oi_1
X_1196_ net134 _0512_ _0539_ VSS VSS VDD VDD _0547_ sky130_fd_sc_hd__a21oi_1
X_1197_ _0533_ _0546_ _0547_ VSS VSS VDD VDD _0062_ sky130_fd_sc_hd__o21ai_0
X_1198_ net33 net45 _0335_ VSS VSS VDD VDD _0548_ sky130_fd_sc_hd__mux2i_1
X_1199_ net242 net45 net245 VSS VSS VDD VDD _0549_ sky130_fd_sc_hd__a21oi_1
X_1200_ _0533_ _0549_ VSS VSS VDD VDD _0550_ sky130_fd_sc_hd__nor2_1
X_1201_ net135 _0512_ _0550_ VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__a21oi_1
X_1202_ _0514_ _0548_ _0551_ VSS VSS VDD VDD _0063_ sky130_fd_sc_hd__o21ai_0
X_1203_ net136 _0502_ _0520_ VSS VSS VDD VDD _0552_ sky130_fd_sc_hd__o21ai_0
X_1204_ net34 net46 _0335_ VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__mux2_2
X_1205_ net242 net46 _0553_ net241 _0518_ VSS VSS VDD VDD
+ _0554_ sky130_fd_sc_hd__a221oi_2
X_1206_ _0552_ _0554_ VSS VSS VDD VDD _0064_ sky130_fd_sc_hd__nor2_1
X_1207_ net35 net47 _0335_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__mux2_2
X_1208_ net242 net47 _0555_ net241 net245 VSS VSS VDD VDD
+ _0556_ sky130_fd_sc_hd__a221oi_1
X_1209_ net137 _0512_ _0539_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__a21oi_1
X_1210_ _0533_ _0556_ _0557_ VSS VSS VDD VDD _0065_ sky130_fd_sc_hd__o21ai_0
X_1211_ net245 net240 _0314_ _0322_ VSS VSS VDD VDD _0558_
+ sky130_fd_sc_hd__and4_1
Xinput42 cmd_addr[3] VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkdlybuf4s50_1
X_1213_ net240 _0499_ _0323_ VSS VSS VDD VDD _0560_ sky130_fd_sc_hd__a21oi_1
X_1214_ net243 net241 _0026_ _0560_ VSS VSS VDD VDD _0561_
+ sky130_fd_sc_hd__nor4_1
X_1215_ net140 net139 VSS VSS VDD VDD _0562_ sky130_fd_sc_hd__nor2_1
X_1216_ net138 _0020_ VSS VSS VDD VDD _0563_ sky130_fd_sc_hd__nor2_1
X_1217_ _0561_ _0562_ _0563_ bank_active\[0\] VSS VSS VDD
+ VDD _0564_ sky130_fd_sc_hd__a31oi_1
X_1218_ _0558_ _0564_ VSS VSS VDD VDD _0066_ sky130_fd_sc_hd__nor2_1
X_1219_ _0560_ _0322_ _0026_ VSS VSS VDD VDD _0565_ sky130_fd_sc_hd__and3b_1
X_1220_ _0022_ _0565_ bank_active\[1\] VSS VSS VDD VDD _0566_
+ sky130_fd_sc_hd__a21oi_1
X_1221_ _0558_ _0566_ VSS VSS VDD VDD _0067_ sky130_fd_sc_hd__nor2_1
X_1222_ net138 _0562_ VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__nor2_1
X_1223_ _0020_ _0565_ _0567_ bank_active\[2\] VSS VSS VDD
+ VDD _0568_ sky130_fd_sc_hd__a31oi_1
X_1224_ _0558_ _0568_ VSS VSS VDD VDD _0068_ sky130_fd_sc_hd__nor2_1
X_1225_ _0023_ _0565_ bank_active\[3\] VSS VSS VDD VDD _0569_
+ sky130_fd_sc_hd__a21oi_1
X_1226_ _0558_ _0569_ VSS VSS VDD VDD _0069_ sky130_fd_sc_hd__nor2_1
X_1227_ net138 _0020_ _0562_ VSS VSS VDD VDD _0570_ sky130_fd_sc_hd__nor3_1
X_1228_ _0565_ _0570_ bank_active\[4\] VSS VSS VDD VDD _0571_
+ sky130_fd_sc_hd__a21oi_1
X_1229_ _0558_ _0571_ VSS VSS VDD VDD _0070_ sky130_fd_sc_hd__nor2_1
X_1230_ _0022_ _0561_ bank_active\[5\] VSS VSS VDD VDD _0572_
+ sky130_fd_sc_hd__a21oi_1
X_1231_ _0558_ _0572_ VSS VSS VDD VDD _0071_ sky130_fd_sc_hd__nor2_1
X_1232_ _0020_ _0561_ _0567_ bank_active\[6\] VSS VSS VDD
+ VDD _0573_ sky130_fd_sc_hd__a31oi_1
X_1233_ _0558_ _0573_ VSS VSS VDD VDD _0072_ sky130_fd_sc_hd__nor2_1
X_1234_ _0023_ _0561_ bank_active\[7\] VSS VSS VDD VDD _0574_
+ sky130_fd_sc_hd__a21oi_1
X_1235_ _0558_ _0574_ VSS VSS VDD VDD _0073_ sky130_fd_sc_hd__nor2_1
X_1236_ net243 _0327_ _0322_ VSS VSS VDD VDD _0575_ sky130_fd_sc_hd__a21oi_1
X_1237_ _0445_ _0575_ VSS VSS VDD VDD _0576_ sky130_fd_sc_hd__nand2_1
X_1238_ _0451_ _0576_ VSS VSS VDD VDD _0577_ sky130_fd_sc_hd__nor2_1
X_1239_ init_state\[1\] net251 net241 VSS VSS VDD VDD _0578_
+ sky130_fd_sc_hd__mux2i_1
X_1240_ net138 _0577_ VSS VSS VDD VDD _0579_ sky130_fd_sc_hd__nor2_1
X_1241_ _0577_ _0578_ _0579_ VSS VSS VDD VDD _0074_ sky130_fd_sc_hd__a21oi_1
X_1242_ net241 net250 VSS VSS VDD VDD _0580_ sky130_fd_sc_hd__nand2_1
X_1243_ net241 _0325_ _0580_ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__o21ai_0
X_1244_ _0577_ _0581_ VSS VSS VDD VDD _0582_ sky130_fd_sc_hd__nand2_1
X_1245_ _0019_ _0577_ _0582_ VSS VSS VDD VDD _0075_ sky130_fd_sc_hd__o21ai_0
X_1246_ net249 _0115_ VSS VSS VDD VDD _0583_ sky130_fd_sc_hd__nand2_1
X_1247_ _0024_ _0577_ _0583_ _0576_ VSS VSS VDD VDD _0076_
+ sky130_fd_sc_hd__o22ai_1
X_1248_ net245 burst_counter\[0\] VSS VSS VDD VDD _0584_ sky130_fd_sc_hd__nand2_1
X_1249_ net245 net48 _0584_ VSS VSS VDD VDD _0585_ sky130_fd_sc_hd__o21ai_0
X_1250_ net242 _0319_ net245 VSS VSS VDD VDD _0586_ sky130_fd_sc_hd__a21oi_1
X_1251_ net243 _0451_ VSS VSS VDD VDD _0587_ sky130_fd_sc_hd__nor2_1
X_1252_ _0390_ _0586_ _0587_ VSS VSS VDD VDD _0588_ sky130_fd_sc_hd__o21ai_1
X_1253_ _0342_ _0588_ VSS VSS VDD VDD _0589_ sky130_fd_sc_hd__or2_4
X_1254_ _0342_ _0588_ burst_counter\[0\] VSS VSS VDD VDD _0590_
+ sky130_fd_sc_hd__o21ai_0
X_1255_ _0585_ _0589_ _0590_ VSS VSS VDD VDD _0077_ sky130_fd_sc_hd__o21ai_0
X_1256_ net245 _0031_ VSS VSS VDD VDD _0591_ sky130_fd_sc_hd__nand2_1
X_1257_ net245 net49 _0591_ VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__o21ai_0
X_1258_ _0342_ _0588_ burst_counter\[1\] VSS VSS VDD VDD _0593_
+ sky130_fd_sc_hd__o21ai_0
X_1259_ _0589_ _0592_ _0593_ VSS VSS VDD VDD _0078_ sky130_fd_sc_hd__o21ai_0
X_1260_ net245 _0030_ VSS VSS VDD VDD _0594_ sky130_fd_sc_hd__nand2_1
X_1261_ burst_counter\[2\] _0342_ _0588_ _0594_ VSS VSS VDD
+ VDD _0595_ sky130_fd_sc_hd__nor4_1
X_1262_ net245 net50 VSS VSS VDD VDD _0596_ sky130_fd_sc_hd__nand2b_1
X_1263_ net245 burst_counter\[2\] VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__nand2_1
X_1264_ _0342_ _0588_ _0596_ _0597_ _0030_ VSS VSS VDD VDD
+ _0598_ sky130_fd_sc_hd__o32ai_1
X_1265_ burst_counter\[2\] _0589_ _0595_ _0598_ VSS VSS VDD
+ VDD _0079_ sky130_fd_sc_hd__a211o_1
X_1266_ burst_counter\[2\] burst_counter\[1\] burst_counter\[0\]
+ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__nor3_1
X_1267_ burst_counter\[3\] _0599_ net245 VSS VSS VDD VDD _0600_
+ sky130_fd_sc_hd__nand3b_1
X_1268_ _0342_ _0588_ _0600_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__nor3_1
X_1269_ net245 net51 VSS VSS VDD VDD _0602_ sky130_fd_sc_hd__nand2b_1
X_1270_ net245 burst_counter\[3\] VSS VSS VDD VDD _0603_ sky130_fd_sc_hd__nand2_1
X_1271_ _0342_ _0588_ _0602_ _0603_ _0599_ VSS VSS VDD VDD
+ _0604_ sky130_fd_sc_hd__o32ai_1
X_1272_ burst_counter\[3\] _0589_ _0601_ _0604_ VSS VSS VDD
+ VDD _0080_ sky130_fd_sc_hd__a211o_1
X_1273_ _0347_ _0497_ _0501_ VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__o21ai_0
X_1274_ _0048_ VSS VSS VDD VDD _0606_ sky130_fd_sc_hd__inv_1
X_1275_ net241 _0335_ _0605_ _0606_ net242 VSS VSS VDD VDD
+ _0607_ sky130_fd_sc_hd__a2111oi_0
X_1276_ _0045_ _0605_ _0607_ VSS VSS VDD VDD _0081_ sky130_fd_sc_hd__a21oi_1
X_1277_ net220 _0605_ VSS VSS VDD VDD _0608_ sky130_fd_sc_hd__nand2_1
X_1278_ _0606_ _0605_ _0608_ VSS VSS VDD VDD _0082_ sky130_fd_sc_hd__o21ai_0
X_1279_ net123 _0348_ VSS VSS VDD VDD _0083_ sky130_fd_sc_hd__nand2b_1
X_1280_ net241 net240 _0113_ VSS VSS VDD VDD net122 sky130_fd_sc_hd__and3_1
X_1281_ cmd_reg_valid VSS VSS VDD VDD net142 sky130_fd_sc_hd__inv_1
X_1282_ init_state\[7\] init_state\[3\] _0466_ net247 VSS
+ VSS VDD VDD net152 sky130_fd_sc_hd__o31a_1
X_1283_ _0018_ _0019_ VSS VSS VDD VDD _0645_ _0020_ sky130_fd_sc_hd__ha_1
X_1284_ _0018_ net139 VSS VSS VDD VDD _0021_ _0646_ sky130_fd_sc_hd__ha_1
X_1285_ net138 _0019_ VSS VSS VDD VDD _0022_ _0647_ sky130_fd_sc_hd__ha_1
X_1286_ net138 net139 VSS VSS VDD VDD _0023_ _0648_ sky130_fd_sc_hd__ha_1
X_1287_ _0024_ _0645_ VSS VSS VDD VDD _0025_ _0026_ sky130_fd_sc_hd__ha_1
X_1288_ net140 _0645_ VSS VSS VDD VDD _0027_ _0649_ sky130_fd_sc_hd__ha_1
X_1289_ _0028_ _0029_ VSS VSS VDD VDD _0030_ _0031_ sky130_fd_sc_hd__ha_1
X_1290_ _0032_ refresh_counter\[1\] VSS VSS VDD VDD _0033_
+ _0034_ sky130_fd_sc_hd__ha_1
X_1291_ refresh_counter\[0\] refresh_counter\[1\] VSS VSS
+ VDD VDD _0035_ _0650_ sky130_fd_sc_hd__ha_1
X_1292_ _0036_ _0319_ VSS VSS VDD VDD _0038_ _0039_ sky130_fd_sc_hd__ha_1
X_1293_ timer\[0\] _0319_ VSS VSS VDD VDD _0040_ _0651_ sky130_fd_sc_hd__ha_1
X_1294_ _0036_ _0041_ VSS VSS VDD VDD _0042_ _0043_ sky130_fd_sc_hd__ha_1
X_1295_ timer\[0\] _0041_ VSS VSS VDD VDD _0044_ _0652_ sky130_fd_sc_hd__ha_1
X_1296_ _0045_ _0046_ VSS VSS VDD VDD _0047_ _0048_ sky130_fd_sc_hd__ha_1
X_1297_ _0045_ net220 VSS VSS VDD VDD _0049_ _0653_ sky130_fd_sc_hd__ha_1
X_1298_ net219 _0046_ VSS VSS VDD VDD _0050_ _0654_ sky130_fd_sc_hd__ha_1
X_1299_ net219 net220 VSS VSS VDD VDD _0051_ _0655_ sky130_fd_sc_hd__ha_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_1304__11 VSS VSS VDD VDD phy_cke _unconnected_0 sky130_fd_sc_hd__conb_1
Xinput41 cmd_addr[2] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput40 cmd_addr[27] VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput39 cmd_addr[26] VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkdlybuf4s50_1
X_1305_ wr_mask[0] VSS VSS VDD VDD net143 sky130_fd_sc_hd__buf_4
X_1306_ wr_mask[1] VSS VSS VDD VDD net144 sky130_fd_sc_hd__buf_4
X_1307_ wr_mask[2] VSS VSS VDD VDD net145 sky130_fd_sc_hd__buf_4
X_1308_ wr_mask[3] VSS VSS VDD VDD net146 sky130_fd_sc_hd__buf_4
X_1309_ wr_mask[4] VSS VSS VDD VDD net147 sky130_fd_sc_hd__buf_4
X_1310_ wr_mask[5] VSS VSS VDD VDD net148 sky130_fd_sc_hd__buf_4
X_1311_ wr_mask[6] VSS VSS VDD VDD net149 sky130_fd_sc_hd__buf_4
X_1312_ wr_mask[7] VSS VSS VDD VDD net150 sky130_fd_sc_hd__buf_4
X_1313_ net57 VSS VSS VDD VDD phy_dq[0] sky130_fd_sc_hd__buf_4
X_1314_ net68 VSS VSS VDD VDD phy_dq[1] sky130_fd_sc_hd__buf_4
X_1315_ net79 VSS VSS VDD VDD phy_dq[2] sky130_fd_sc_hd__buf_4
X_1316_ net90 VSS VSS VDD VDD phy_dq[3] sky130_fd_sc_hd__buf_4
X_1317_ net101 VSS VSS VDD VDD phy_dq[4] sky130_fd_sc_hd__buf_4
X_1318_ net112 VSS VSS VDD VDD phy_dq[5] sky130_fd_sc_hd__buf_4
X_1319_ net117 VSS VSS VDD VDD phy_dq[6] sky130_fd_sc_hd__buf_4
X_1320_ net118 VSS VSS VDD VDD phy_dq[7] sky130_fd_sc_hd__buf_4
X_1321_ net119 VSS VSS VDD VDD phy_dq[8] sky130_fd_sc_hd__buf_4
X_1322_ net120 VSS VSS VDD VDD phy_dq[9] sky130_fd_sc_hd__buf_4
X_1323_ net58 VSS VSS VDD VDD phy_dq[10] sky130_fd_sc_hd__buf_4
X_1324_ net59 VSS VSS VDD VDD phy_dq[11] sky130_fd_sc_hd__buf_4
X_1325_ net60 VSS VSS VDD VDD phy_dq[12] sky130_fd_sc_hd__buf_4
X_1326_ net61 VSS VSS VDD VDD phy_dq[13] sky130_fd_sc_hd__buf_4
X_1327_ net62 VSS VSS VDD VDD phy_dq[14] sky130_fd_sc_hd__buf_4
X_1328_ net63 VSS VSS VDD VDD phy_dq[15] sky130_fd_sc_hd__buf_4
X_1329_ net64 VSS VSS VDD VDD phy_dq[16] sky130_fd_sc_hd__buf_4
X_1330_ net65 VSS VSS VDD VDD phy_dq[17] sky130_fd_sc_hd__buf_4
X_1331_ net66 VSS VSS VDD VDD phy_dq[18] sky130_fd_sc_hd__buf_4
X_1332_ net67 VSS VSS VDD VDD phy_dq[19] sky130_fd_sc_hd__buf_4
X_1333_ net69 VSS VSS VDD VDD phy_dq[20] sky130_fd_sc_hd__buf_4
X_1334_ net70 VSS VSS VDD VDD phy_dq[21] sky130_fd_sc_hd__buf_4
X_1335_ net71 VSS VSS VDD VDD phy_dq[22] sky130_fd_sc_hd__buf_4
X_1336_ net72 VSS VSS VDD VDD phy_dq[23] sky130_fd_sc_hd__buf_4
X_1337_ net73 VSS VSS VDD VDD phy_dq[24] sky130_fd_sc_hd__buf_4
X_1338_ net74 VSS VSS VDD VDD phy_dq[25] sky130_fd_sc_hd__buf_4
X_1339_ net75 VSS VSS VDD VDD phy_dq[26] sky130_fd_sc_hd__buf_4
X_1340_ net76 VSS VSS VDD VDD phy_dq[27] sky130_fd_sc_hd__buf_4
X_1341_ net77 VSS VSS VDD VDD phy_dq[28] sky130_fd_sc_hd__buf_4
X_1342_ net78 VSS VSS VDD VDD phy_dq[29] sky130_fd_sc_hd__buf_4
X_1343_ net80 VSS VSS VDD VDD phy_dq[30] sky130_fd_sc_hd__buf_4
X_1344_ net81 VSS VSS VDD VDD phy_dq[31] sky130_fd_sc_hd__buf_4
X_1345_ net82 VSS VSS VDD VDD phy_dq[32] sky130_fd_sc_hd__buf_4
X_1346_ net83 VSS VSS VDD VDD phy_dq[33] sky130_fd_sc_hd__buf_4
X_1347_ net84 VSS VSS VDD VDD phy_dq[34] sky130_fd_sc_hd__buf_4
X_1348_ net85 VSS VSS VDD VDD phy_dq[35] sky130_fd_sc_hd__buf_4
X_1349_ net86 VSS VSS VDD VDD phy_dq[36] sky130_fd_sc_hd__buf_4
X_1350_ net87 VSS VSS VDD VDD phy_dq[37] sky130_fd_sc_hd__buf_4
X_1351_ net88 VSS VSS VDD VDD phy_dq[38] sky130_fd_sc_hd__buf_4
X_1352_ net89 VSS VSS VDD VDD phy_dq[39] sky130_fd_sc_hd__buf_4
X_1353_ net91 VSS VSS VDD VDD phy_dq[40] sky130_fd_sc_hd__buf_4
X_1354_ net92 VSS VSS VDD VDD phy_dq[41] sky130_fd_sc_hd__buf_4
X_1355_ net93 VSS VSS VDD VDD phy_dq[42] sky130_fd_sc_hd__buf_4
X_1356_ net94 VSS VSS VDD VDD phy_dq[43] sky130_fd_sc_hd__buf_4
X_1357_ net95 VSS VSS VDD VDD phy_dq[44] sky130_fd_sc_hd__buf_4
X_1358_ net96 VSS VSS VDD VDD phy_dq[45] sky130_fd_sc_hd__buf_4
X_1359_ net97 VSS VSS VDD VDD phy_dq[46] sky130_fd_sc_hd__buf_4
X_1360_ net98 VSS VSS VDD VDD phy_dq[47] sky130_fd_sc_hd__buf_4
X_1361_ net99 VSS VSS VDD VDD phy_dq[48] sky130_fd_sc_hd__buf_4
X_1362_ net100 VSS VSS VDD VDD phy_dq[49] sky130_fd_sc_hd__buf_4
X_1363_ net102 VSS VSS VDD VDD phy_dq[50] sky130_fd_sc_hd__buf_4
X_1364_ net103 VSS VSS VDD VDD phy_dq[51] sky130_fd_sc_hd__buf_4
X_1365_ net104 VSS VSS VDD VDD phy_dq[52] sky130_fd_sc_hd__buf_4
X_1366_ net105 VSS VSS VDD VDD phy_dq[53] sky130_fd_sc_hd__buf_4
X_1367_ net106 VSS VSS VDD VDD phy_dq[54] sky130_fd_sc_hd__buf_4
X_1368_ net107 VSS VSS VDD VDD phy_dq[55] sky130_fd_sc_hd__buf_4
X_1369_ net108 VSS VSS VDD VDD phy_dq[56] sky130_fd_sc_hd__buf_4
X_1370_ net109 VSS VSS VDD VDD phy_dq[57] sky130_fd_sc_hd__buf_4
X_1371_ net110 VSS VSS VDD VDD phy_dq[58] sky130_fd_sc_hd__buf_4
X_1372_ net111 VSS VSS VDD VDD phy_dq[59] sky130_fd_sc_hd__buf_4
X_1373_ net113 VSS VSS VDD VDD phy_dq[60] sky130_fd_sc_hd__buf_4
X_1374_ net114 VSS VSS VDD VDD phy_dq[61] sky130_fd_sc_hd__buf_4
X_1375_ net115 VSS VSS VDD VDD phy_dq[62] sky130_fd_sc_hd__buf_4
X_1376_ net116 VSS VSS VDD VDD phy_dq[63] sky130_fd_sc_hd__buf_4
Xinput38 cmd_addr[25] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput37 cmd_addr[24] VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput36 cmd_addr[23] VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput35 cmd_addr[22] VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput34 cmd_addr[21] VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput33 cmd_addr[20] VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput32 cmd_addr[1] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput31 cmd_addr[19] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput30 cmd_addr[18] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput29 cmd_addr[17] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput28 cmd_addr[16] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput27 cmd_addr[15] VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput26 cmd_addr[14] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput25 cmd_addr[13] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput24 cmd_addr[12] VSS VSS VDD VDD net23 sky130_fd_sc_hd__buf_2
Xinput23 cmd_addr[11] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput22 cmd_addr[0] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkdlybuf4s50_1
Xactive_row\[0\]\[0\]$_DFFE_PP_ clknet_4_9_0_clk net124 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[10\]$_DFFE_PP_ clknet_4_8_0_clk net125 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[11\]$_DFFE_PP_ clknet_4_6_0_clk net126 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[12\]$_DFFE_PP_ clknet_4_12_0_clk net127
+ _0016_ VSS VSS VDD VDD active_row\[0\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[13\]$_DFFE_PP_ clknet_4_8_0_clk net128 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[1\]$_DFFE_PP_ clknet_4_12_0_clk net129 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[2\]$_DFFE_PP_ clknet_4_9_0_clk net130 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[3\]$_DFFE_PP_ clknet_4_9_0_clk net131 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[4\]$_DFFE_PP_ clknet_4_9_0_clk net132 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[5\]$_DFFE_PP_ clknet_4_9_0_clk net133 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[6\]$_DFFE_PP_ clknet_4_3_0_clk net134 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[7\]$_DFFE_PP_ clknet_4_6_0_clk net135 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[8\]$_DFFE_PP_ clknet_4_6_0_clk net136 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[9\]$_DFFE_PP_ clknet_4_8_0_clk net137 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[0\]$_DFFE_PP_ clknet_4_9_0_clk net124 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[10\]$_DFFE_PP_ clknet_4_10_0_clk net125
+ _0015_ VSS VSS VDD VDD active_row\[1\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[11\]$_DFFE_PP_ clknet_4_13_0_clk net126
+ _0015_ VSS VSS VDD VDD active_row\[1\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[12\]$_DFFE_PP_ clknet_4_9_0_clk net127 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[13\]$_DFFE_PP_ clknet_4_10_0_clk net128
+ _0015_ VSS VSS VDD VDD active_row\[1\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[1\]$_DFFE_PP_ clknet_4_15_0_clk net129 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[2\]$_DFFE_PP_ clknet_4_11_0_clk net130 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[3\]$_DFFE_PP_ clknet_4_9_0_clk net131 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[4\]$_DFFE_PP_ clknet_4_11_0_clk net132 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[5\]$_DFFE_PP_ clknet_4_14_0_clk net133 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[6\]$_DFFE_PP_ clknet_4_14_0_clk net134 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[7\]$_DFFE_PP_ clknet_4_14_0_clk net135 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[8\]$_DFFE_PP_ clknet_4_13_0_clk net136 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[9\]$_DFFE_PP_ clknet_4_8_0_clk net137 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[0\]$_DFFE_PP_ clknet_4_9_0_clk net124 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[10\]$_DFFE_PP_ clknet_4_10_0_clk net125
+ _0014_ VSS VSS VDD VDD active_row\[2\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[11\]$_DFFE_PP_ clknet_4_15_0_clk net126
+ _0014_ VSS VSS VDD VDD active_row\[2\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[12\]$_DFFE_PP_ clknet_4_9_0_clk net127 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[13\]$_DFFE_PP_ clknet_4_10_0_clk net128
+ _0014_ VSS VSS VDD VDD active_row\[2\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[1\]$_DFFE_PP_ clknet_4_15_0_clk net129 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[2\]$_DFFE_PP_ clknet_4_11_0_clk net130 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[3\]$_DFFE_PP_ clknet_4_9_0_clk net131 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[4\]$_DFFE_PP_ clknet_4_11_0_clk net132 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[5\]$_DFFE_PP_ clknet_4_14_0_clk net133 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[6\]$_DFFE_PP_ clknet_4_14_0_clk net134 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[7\]$_DFFE_PP_ clknet_4_12_0_clk net135 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[8\]$_DFFE_PP_ clknet_4_13_0_clk net136 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[9\]$_DFFE_PP_ clknet_4_8_0_clk net137 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[0\]$_DFFE_PP_ clknet_4_9_0_clk net124 net238
+ VSS VSS VDD VDD active_row\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[10\]$_DFFE_PP_ clknet_4_10_0_clk net125
+ net238 VSS VSS VDD VDD active_row\[3\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[11\]$_DFFE_PP_ clknet_4_13_0_clk net126
+ net238 VSS VSS VDD VDD active_row\[3\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[12\]$_DFFE_PP_ clknet_4_12_0_clk net127
+ net238 VSS VSS VDD VDD active_row\[3\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[13\]$_DFFE_PP_ clknet_4_10_0_clk net128
+ net238 VSS VSS VDD VDD active_row\[3\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[1\]$_DFFE_PP_ clknet_4_15_0_clk net129 net238
+ VSS VSS VDD VDD active_row\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[2\]$_DFFE_PP_ clknet_4_10_0_clk net130 net238
+ VSS VSS VDD VDD active_row\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[3\]$_DFFE_PP_ clknet_4_11_0_clk net131 net238
+ VSS VSS VDD VDD active_row\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[4\]$_DFFE_PP_ clknet_4_11_0_clk net132 net238
+ VSS VSS VDD VDD active_row\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[5\]$_DFFE_PP_ clknet_4_15_0_clk net133 net238
+ VSS VSS VDD VDD active_row\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[6\]$_DFFE_PP_ clknet_4_11_0_clk net134 net238
+ VSS VSS VDD VDD active_row\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[7\]$_DFFE_PP_ clknet_4_11_0_clk net135 net238
+ VSS VSS VDD VDD active_row\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[8\]$_DFFE_PP_ clknet_4_12_0_clk net136 net238
+ VSS VSS VDD VDD active_row\[3\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[9\]$_DFFE_PP_ clknet_4_8_0_clk net137 net238
+ VSS VSS VDD VDD active_row\[3\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[0\]$_DFFE_PP_ clknet_4_9_0_clk net124 net239
+ VSS VSS VDD VDD active_row\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[10\]$_DFFE_PP_ clknet_4_10_0_clk net125
+ net239 VSS VSS VDD VDD active_row\[4\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[11\]$_DFFE_PP_ clknet_4_15_0_clk net126
+ net239 VSS VSS VDD VDD active_row\[4\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[12\]$_DFFE_PP_ clknet_4_12_0_clk net127
+ net239 VSS VSS VDD VDD active_row\[4\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[13\]$_DFFE_PP_ clknet_4_10_0_clk net128
+ net239 VSS VSS VDD VDD active_row\[4\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[1\]$_DFFE_PP_ clknet_4_15_0_clk net129 net239
+ VSS VSS VDD VDD active_row\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[2\]$_DFFE_PP_ clknet_4_10_0_clk net130 net239
+ VSS VSS VDD VDD active_row\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[3\]$_DFFE_PP_ clknet_4_11_0_clk net131 net239
+ VSS VSS VDD VDD active_row\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[4\]$_DFFE_PP_ clknet_4_11_0_clk net132 net239
+ VSS VSS VDD VDD active_row\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[5\]$_DFFE_PP_ clknet_4_15_0_clk net133 net239
+ VSS VSS VDD VDD active_row\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[6\]$_DFFE_PP_ clknet_4_14_0_clk net134 net239
+ VSS VSS VDD VDD active_row\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[7\]$_DFFE_PP_ clknet_4_14_0_clk net135 net239
+ VSS VSS VDD VDD active_row\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[8\]$_DFFE_PP_ clknet_4_13_0_clk net136 net239
+ VSS VSS VDD VDD active_row\[4\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[9\]$_DFFE_PP_ clknet_4_8_0_clk net137 net239
+ VSS VSS VDD VDD active_row\[4\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[0\]$_DFFE_PP_ clknet_4_8_0_clk net124 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[10\]$_DFFE_PP_ clknet_4_10_0_clk net125
+ _0011_ VSS VSS VDD VDD active_row\[5\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[11\]$_DFFE_PP_ clknet_4_13_0_clk net126
+ _0011_ VSS VSS VDD VDD active_row\[5\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[12\]$_DFFE_PP_ clknet_4_12_0_clk net127
+ _0011_ VSS VSS VDD VDD active_row\[5\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[13\]$_DFFE_PP_ clknet_4_10_0_clk net128
+ _0011_ VSS VSS VDD VDD active_row\[5\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[1\]$_DFFE_PP_ clknet_4_15_0_clk net129 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[2\]$_DFFE_PP_ clknet_4_10_0_clk net130 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[3\]$_DFFE_PP_ clknet_4_10_0_clk net131 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[4\]$_DFFE_PP_ clknet_4_11_0_clk net132 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[5\]$_DFFE_PP_ clknet_4_15_0_clk net133 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[6\]$_DFFE_PP_ clknet_4_14_0_clk net134 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[7\]$_DFFE_PP_ clknet_4_11_0_clk net135 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[8\]$_DFFE_PP_ clknet_4_12_0_clk net136 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[9\]$_DFFE_PP_ clknet_4_8_0_clk net137 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[0\]$_DFFE_PP_ clknet_4_8_0_clk net124 net236
+ VSS VSS VDD VDD active_row\[6\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[10\]$_DFFE_PP_ clknet_4_10_0_clk net125
+ net236 VSS VSS VDD VDD active_row\[6\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[11\]$_DFFE_PP_ clknet_4_15_0_clk net126
+ net236 VSS VSS VDD VDD active_row\[6\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[12\]$_DFFE_PP_ clknet_4_12_0_clk net127
+ net236 VSS VSS VDD VDD active_row\[6\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[13\]$_DFFE_PP_ clknet_4_8_0_clk net128 net236
+ VSS VSS VDD VDD active_row\[6\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[1\]$_DFFE_PP_ clknet_4_15_0_clk net129 net236
+ VSS VSS VDD VDD active_row\[6\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[2\]$_DFFE_PP_ clknet_4_10_0_clk net130 net236
+ VSS VSS VDD VDD active_row\[6\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[3\]$_DFFE_PP_ clknet_4_8_0_clk net131 net236
+ VSS VSS VDD VDD active_row\[6\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[4\]$_DFFE_PP_ clknet_4_11_0_clk net132 net236
+ VSS VSS VDD VDD active_row\[6\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[5\]$_DFFE_PP_ clknet_4_15_0_clk net133 net236
+ VSS VSS VDD VDD active_row\[6\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[6\]$_DFFE_PP_ clknet_4_14_0_clk net134 net236
+ VSS VSS VDD VDD active_row\[6\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[7\]$_DFFE_PP_ clknet_4_14_0_clk net135 net236
+ VSS VSS VDD VDD active_row\[6\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[8\]$_DFFE_PP_ clknet_4_13_0_clk net136 net236
+ VSS VSS VDD VDD active_row\[6\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[9\]$_DFFE_PP_ clknet_4_8_0_clk net137 net236
+ VSS VSS VDD VDD active_row\[6\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[0\]$_DFFE_PP_ clknet_4_8_0_clk net124 net237
+ VSS VSS VDD VDD active_row\[7\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[10\]$_DFFE_PP_ clknet_4_10_0_clk net125
+ net237 VSS VSS VDD VDD active_row\[7\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[11\]$_DFFE_PP_ clknet_4_15_0_clk net126
+ net237 VSS VSS VDD VDD active_row\[7\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[12\]$_DFFE_PP_ clknet_4_12_0_clk net127
+ net237 VSS VSS VDD VDD active_row\[7\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[13\]$_DFFE_PP_ clknet_4_8_0_clk net128 net237
+ VSS VSS VDD VDD active_row\[7\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[1\]$_DFFE_PP_ clknet_4_15_0_clk net129 net237
+ VSS VSS VDD VDD active_row\[7\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[2\]$_DFFE_PP_ clknet_4_11_0_clk net130 net237
+ VSS VSS VDD VDD active_row\[7\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[3\]$_DFFE_PP_ clknet_4_10_0_clk net131 net237
+ VSS VSS VDD VDD active_row\[7\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[4\]$_DFFE_PP_ clknet_4_11_0_clk net132 net237
+ VSS VSS VDD VDD active_row\[7\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[5\]$_DFFE_PP_ clknet_4_15_0_clk net133 net237
+ VSS VSS VDD VDD active_row\[7\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[6\]$_DFFE_PP_ clknet_4_14_0_clk net134 net237
+ VSS VSS VDD VDD active_row\[7\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[7\]$_DFFE_PP_ clknet_4_11_0_clk net135 net237
+ VSS VSS VDD VDD active_row\[7\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[8\]$_DFFE_PP_ clknet_4_13_0_clk net136 net237
+ VSS VSS VDD VDD active_row\[7\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[9\]$_DFFE_PP_ clknet_4_8_0_clk net137 net237
+ VSS VSS VDD VDD active_row\[7\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xaddr_reg\[0\]$_DFFE_PN0P_ clknet_4_9_0_clk _0052_ net56 VSS
+ VSS VDD VDD net124 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[10\]$_DFFE_PN0P_ clknet_4_2_0_clk _0053_ net247
+ VSS VSS VDD VDD net125 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[11\]$_DFFE_PN0P_ clknet_4_6_0_clk _0054_ net56
+ VSS VSS VDD VDD net126 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[12\]$_DFFE_PN0P_ clknet_4_2_0_clk _0055_ net247
+ VSS VSS VDD VDD net127 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[13\]$_DFFE_PN0P_ clknet_4_2_0_clk _0056_ net247
+ VSS VSS VDD VDD net128 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[1\]$_DFFE_PN0P_ clknet_4_6_0_clk _0057_ net56 VSS
+ VSS VDD VDD net129 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[2\]$_DFFE_PN0P_ clknet_4_3_0_clk _0058_ net247
+ VSS VSS VDD VDD net130 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[3\]$_DFFE_PN0P_ clknet_4_2_0_clk _0059_ net247
+ VSS VSS VDD VDD net131 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[4\]$_DFFE_PN0P_ clknet_4_3_0_clk _0060_ net247
+ VSS VSS VDD VDD net132 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[5\]$_DFFE_PN0P_ clknet_4_3_0_clk _0061_ net56 VSS
+ VSS VDD VDD net133 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[6\]$_DFFE_PN0P_ clknet_4_3_0_clk _0062_ net56 VSS
+ VSS VDD VDD net134 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[7\]$_DFFE_PN0P_ clknet_4_3_0_clk _0063_ net247
+ VSS VSS VDD VDD net135 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[8\]$_DFFE_PN0P_ clknet_4_6_0_clk _0064_ net56 VSS
+ VSS VDD VDD net136 sky130_fd_sc_hd__dfrtp_1
Xaddr_reg\[9\]$_DFFE_PN0P_ clknet_4_2_0_clk _0065_ net247
+ VSS VSS VDD VDD net137 sky130_fd_sc_hd__dfrtp_1
Xbank_active\[0\]$_DFFE_PN0P_ clknet_4_13_0_clk _0066_ net56
+ VSS VSS VDD VDD bank_active\[0\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[1\]$_DFFE_PN0P_ clknet_4_13_0_clk _0067_ net56
+ VSS VSS VDD VDD bank_active\[1\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[2\]$_DFFE_PN0P_ clknet_4_7_0_clk _0068_ net56
+ VSS VSS VDD VDD bank_active\[2\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[3\]$_DFFE_PN0P_ clknet_4_13_0_clk _0069_ net56
+ VSS VSS VDD VDD bank_active\[3\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[4\]$_DFFE_PN0P_ clknet_4_7_0_clk _0070_ net56
+ VSS VSS VDD VDD bank_active\[4\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[5\]$_DFFE_PN0P_ clknet_4_13_0_clk _0071_ net56
+ VSS VSS VDD VDD bank_active\[5\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[6\]$_DFFE_PN0P_ clknet_4_7_0_clk _0072_ net56
+ VSS VSS VDD VDD bank_active\[6\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[7\]$_DFFE_PN0P_ clknet_4_13_0_clk _0073_ net56
+ VSS VSS VDD VDD bank_active\[7\] sky130_fd_sc_hd__dfrtp_1
Xbank_reg\[0\]$_DFFE_PN0P_ clknet_4_6_0_clk _0074_ net56 VSS
+ VSS VDD VDD net138 sky130_fd_sc_hd__dfrtp_1
Xbank_reg\[1\]$_DFFE_PN0P_ clknet_4_7_0_clk _0075_ net56 VSS
+ VSS VDD VDD net139 sky130_fd_sc_hd__dfrtp_1
Xbank_reg\[2\]$_DFFE_PN0P_ clknet_4_6_0_clk _0076_ net56 VSS
+ VSS VDD VDD net140 sky130_fd_sc_hd__dfrtp_1
Xburst_counter\[0\]$_DFFE_PN0P_ clknet_4_2_0_clk _0077_ net247
+ VSS VSS VDD VDD burst_counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xburst_counter\[1\]$_DFFE_PN0P_ clknet_4_2_0_clk _0078_ net247
+ VSS VSS VDD VDD burst_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xburst_counter\[2\]$_DFFE_PN0P_ clknet_4_0_0_clk _0079_ net247
+ VSS VSS VDD VDD burst_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xburst_counter\[3\]$_DFFE_PN0P_ clknet_4_0_0_clk _0080_ net247
+ VSS VSS VDD VDD burst_counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xcmd_reg\[0\]$_DFF_PN1_ clknet_4_4_0_clk _0610_ net247 VSS
+ VSS VDD VDD net153 sky130_fd_sc_hd__dfstp_2
Xcmd_reg\[1\]$_DFF_PN1_ clknet_4_1_0_clk _0611_ net247 VSS
+ VSS VDD VDD net141 sky130_fd_sc_hd__dfstp_2
Xcmd_reg\[2\]$_DFF_PN1_ clknet_4_4_0_clk _0612_ net247 VSS
+ VSS VDD VDD net151 sky130_fd_sc_hd__dfstp_2
Xcmd_reg_valid$_DFF_PN0_ clknet_4_2_0_clk net20 net247 VSS
+ VSS VDD VDD cmd_reg_valid sky130_fd_sc_hd__dfrtp_1
Xcurr_state\[0\]$_DFFE_PN0P_ clknet_4_1_0_clk _0081_ net247
+ VSS VSS VDD VDD net219 sky130_fd_sc_hd__dfrtp_1
Xcurr_state\[1\]$_DFFE_PN0P_ clknet_4_1_0_clk _0082_ net247
+ VSS VSS VDD VDD net220 sky130_fd_sc_hd__dfrtp_1
Xinit_done_reg$_DFFE_PN0P_ clknet_4_1_0_clk _0083_ net247
+ VSS VSS VDD VDD net123 sky130_fd_sc_hd__dfrtp_1
Xinit_state\[0\]$_DFF_PN1_ clknet_4_3_0_clk _0001_ net247
+ VSS VSS VDD VDD init_state\[0\] sky130_fd_sc_hd__dfstp_2
Xinit_state\[1\]$_DFF_PN0_ clknet_4_3_0_clk _0002_ net247
+ VSS VSS VDD VDD init_state\[1\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[2\]$_DFF_PN0_ clknet_4_1_0_clk _0003_ net247
+ VSS VSS VDD VDD init_state\[2\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[3\]$_DFF_PN0_ clknet_4_3_0_clk _0004_ net247
+ VSS VSS VDD VDD init_state\[3\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[4\]$_DFF_PN0_ clknet_4_1_0_clk _0005_ net247
+ VSS VSS VDD VDD init_state\[4\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[5\]$_DFF_PN0_ clknet_4_3_0_clk _0006_ net247
+ VSS VSS VDD VDD init_state\[5\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[6\]$_DFF_PN0_ clknet_4_1_0_clk _0007_ net247
+ VSS VSS VDD VDD init_state\[6\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[7\]$_DFF_PN0_ clknet_4_1_0_clk _0008_ net247
+ VSS VSS VDD VDD init_state\[7\] sky130_fd_sc_hd__dfrtp_1
Xrd_data_reg\[0\]$_DFFE_PP_ net248 net57 net244 VSS VSS VDD
+ VDD net154 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[10\]$_DFFE_PP_ net248 net58 net244 VSS VSS VDD
+ VDD net155 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[11\]$_DFFE_PP_ net248 net59 net244 VSS VSS VDD
+ VDD net156 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[12\]$_DFFE_PP_ net248 net60 net244 VSS VSS VDD
+ VDD net157 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[13\]$_DFFE_PP_ net248 net61 net244 VSS VSS VDD
+ VDD net158 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[14\]$_DFFE_PP_ net248 net62 net244 VSS VSS VDD
+ VDD net159 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[15\]$_DFFE_PP_ net248 net63 net244 VSS VSS VDD
+ VDD net160 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[16\]$_DFFE_PP_ net248 net64 net244 VSS VSS VDD
+ VDD net161 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[17\]$_DFFE_PP_ net248 net65 net244 VSS VSS VDD
+ VDD net162 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[18\]$_DFFE_PP_ net248 net66 net244 VSS VSS VDD
+ VDD net163 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[19\]$_DFFE_PP_ net248 net67 net244 VSS VSS VDD
+ VDD net164 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[1\]$_DFFE_PP_ net248 net68 net244 VSS VSS VDD
+ VDD net165 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[20\]$_DFFE_PP_ net248 net69 net244 VSS VSS VDD
+ VDD net166 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[21\]$_DFFE_PP_ net248 net70 net244 VSS VSS VDD
+ VDD net167 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[22\]$_DFFE_PP_ net248 net71 net244 VSS VSS VDD
+ VDD net168 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[23\]$_DFFE_PP_ net248 net72 net244 VSS VSS VDD
+ VDD net169 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[24\]$_DFFE_PP_ net248 net73 net244 VSS VSS VDD
+ VDD net170 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[25\]$_DFFE_PP_ net248 net74 net244 VSS VSS VDD
+ VDD net171 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[26\]$_DFFE_PP_ net248 net75 net244 VSS VSS VDD
+ VDD net172 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[27\]$_DFFE_PP_ net248 net76 net244 VSS VSS VDD
+ VDD net173 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[28\]$_DFFE_PP_ net248 net77 net244 VSS VSS VDD
+ VDD net174 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[29\]$_DFFE_PP_ net248 net78 net244 VSS VSS VDD
+ VDD net175 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[2\]$_DFFE_PP_ net248 net79 net244 VSS VSS VDD
+ VDD net176 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[30\]$_DFFE_PP_ net248 net80 net244 VSS VSS VDD
+ VDD net177 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[31\]$_DFFE_PP_ net248 net81 net244 VSS VSS VDD
+ VDD net178 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[32\]$_DFFE_PP_ net248 net82 net244 VSS VSS VDD
+ VDD net179 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[33\]$_DFFE_PP_ net248 net83 net244 VSS VSS VDD
+ VDD net180 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[34\]$_DFFE_PP_ net248 net84 net244 VSS VSS VDD
+ VDD net181 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[35\]$_DFFE_PP_ net248 net85 net244 VSS VSS VDD
+ VDD net182 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[36\]$_DFFE_PP_ net248 net86 net244 VSS VSS VDD
+ VDD net183 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[37\]$_DFFE_PP_ net248 net87 net244 VSS VSS VDD
+ VDD net184 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[38\]$_DFFE_PP_ net248 net88 net244 VSS VSS VDD
+ VDD net185 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[39\]$_DFFE_PP_ net248 net89 net244 VSS VSS VDD
+ VDD net186 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[3\]$_DFFE_PP_ net248 net90 net244 VSS VSS VDD
+ VDD net187 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[40\]$_DFFE_PP_ net248 net91 net244 VSS VSS VDD
+ VDD net188 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[41\]$_DFFE_PP_ net248 net92 net244 VSS VSS VDD
+ VDD net189 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[42\]$_DFFE_PP_ net248 net93 net244 VSS VSS VDD
+ VDD net190 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[43\]$_DFFE_PP_ net248 net94 net244 VSS VSS VDD
+ VDD net191 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[44\]$_DFFE_PP_ net248 net95 net244 VSS VSS VDD
+ VDD net192 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[45\]$_DFFE_PP_ net248 net96 net244 VSS VSS VDD
+ VDD net193 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[46\]$_DFFE_PP_ net248 net97 net244 VSS VSS VDD
+ VDD net194 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[47\]$_DFFE_PP_ net248 net98 net244 VSS VSS VDD
+ VDD net195 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[48\]$_DFFE_PP_ net248 net99 net244 VSS VSS VDD
+ VDD net196 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[49\]$_DFFE_PP_ net248 net100 net244 VSS VSS
+ VDD VDD net197 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[4\]$_DFFE_PP_ net248 net101 net244 VSS VSS VDD
+ VDD net198 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[50\]$_DFFE_PP_ net248 net102 net244 VSS VSS
+ VDD VDD net199 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[51\]$_DFFE_PP_ net248 net103 net244 VSS VSS
+ VDD VDD net200 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[52\]$_DFFE_PP_ net248 net104 net244 VSS VSS
+ VDD VDD net201 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[53\]$_DFFE_PP_ net248 net105 net244 VSS VSS
+ VDD VDD net202 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[54\]$_DFFE_PP_ net248 net106 net244 VSS VSS
+ VDD VDD net203 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[55\]$_DFFE_PP_ net248 net107 net244 VSS VSS
+ VDD VDD net204 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[56\]$_DFFE_PP_ net248 net108 net244 VSS VSS
+ VDD VDD net205 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[57\]$_DFFE_PP_ net248 net109 net244 VSS VSS
+ VDD VDD net206 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[58\]$_DFFE_PP_ net248 net110 net244 VSS VSS
+ VDD VDD net207 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[59\]$_DFFE_PP_ net248 net111 net244 VSS VSS
+ VDD VDD net208 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[5\]$_DFFE_PP_ net248 net112 net244 VSS VSS VDD
+ VDD net209 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[60\]$_DFFE_PP_ net248 net113 net244 VSS VSS
+ VDD VDD net210 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[61\]$_DFFE_PP_ net248 net114 net244 VSS VSS
+ VDD VDD net211 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[62\]$_DFFE_PP_ net248 net115 net244 VSS VSS
+ VDD VDD net212 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[63\]$_DFFE_PP_ net248 net116 net244 VSS VSS
+ VDD VDD net213 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[6\]$_DFFE_PP_ net248 net117 net244 VSS VSS VDD
+ VDD net214 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[7\]$_DFFE_PP_ net248 net118 net244 VSS VSS VDD
+ VDD net215 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[8\]$_DFFE_PP_ net248 net119 net244 VSS VSS VDD
+ VDD net216 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[9\]$_DFFE_PP_ net248 net120 net244 VSS VSS VDD
+ VDD net217 sky130_fd_sc_hd__edfxtp_1
Xrd_valid_reg$_DFF_PN0_ clknet_4_5_0_clk _0000_ net56 VSS
+ VSS VDD VDD net218 sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[0\]$_DFF_PN0_ clknet_4_0_0_clk _0613_ net247
+ VSS VSS VDD VDD refresh_counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[10\]$_DFF_PN0_ clknet_4_0_0_clk _0614_ net247
+ VSS VSS VDD VDD refresh_counter\[10\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[11\]$_DFF_PN0_ clknet_4_0_0_clk _0615_ net247
+ VSS VSS VDD VDD refresh_counter\[11\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[12\]$_DFF_PN0_ clknet_4_1_0_clk _0616_ net247
+ VSS VSS VDD VDD refresh_counter\[12\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[13\]$_DFF_PN0_ clknet_4_1_0_clk _0617_ net247
+ VSS VSS VDD VDD refresh_counter\[13\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[14\]$_DFF_PN0_ clknet_4_1_0_clk _0618_ net247
+ VSS VSS VDD VDD refresh_counter\[14\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[15\]$_DFF_PN0_ clknet_4_0_0_clk _0619_ net247
+ VSS VSS VDD VDD refresh_counter\[15\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[1\]$_DFF_PN0_ clknet_4_0_0_clk _0620_ net247
+ VSS VSS VDD VDD refresh_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[2\]$_DFF_PN0_ clknet_4_0_0_clk _0621_ net247
+ VSS VSS VDD VDD refresh_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[3\]$_DFF_PN0_ clknet_4_0_0_clk _0622_ net247
+ VSS VSS VDD VDD refresh_counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[4\]$_DFF_PN0_ clknet_4_0_0_clk _0623_ net247
+ VSS VSS VDD VDD refresh_counter\[4\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[5\]$_DFF_PN0_ clknet_4_0_0_clk _0624_ net247
+ VSS VSS VDD VDD refresh_counter\[5\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[6\]$_DFF_PN0_ clknet_4_0_0_clk _0625_ net247
+ VSS VSS VDD VDD refresh_counter\[6\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[7\]$_DFF_PN0_ clknet_4_2_0_clk _0626_ net247
+ VSS VSS VDD VDD refresh_counter\[7\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[8\]$_DFF_PN0_ clknet_4_0_0_clk _0627_ net247
+ VSS VSS VDD VDD refresh_counter\[8\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[9\]$_DFF_PN0_ clknet_4_2_0_clk _0628_ net247
+ VSS VSS VDD VDD refresh_counter\[9\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[0\]$_DFF_PN0_ clknet_4_4_0_clk _0629_ net247 VSS VSS
+ VDD VDD timer\[0\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[10\]$_DFF_PN0_ clknet_4_7_0_clk _0630_ net56 VSS VSS
+ VDD VDD timer\[10\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[11\]$_DFF_PN0_ clknet_4_7_0_clk _0631_ net56 VSS VSS
+ VDD VDD timer\[11\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[12\]$_DFF_PN0_ clknet_4_5_0_clk _0632_ net56 VSS VSS
+ VDD VDD timer\[12\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[13\]$_DFF_PN0_ clknet_4_5_0_clk _0633_ net56 VSS VSS
+ VDD VDD timer\[13\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[14\]$_DFF_PN0_ clknet_4_7_0_clk _0634_ net56 VSS VSS
+ VDD VDD timer\[14\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[15\]$_DFF_PN0_ clknet_4_7_0_clk _0635_ net56 VSS VSS
+ VDD VDD timer\[15\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[1\]$_DFF_PN0_ clknet_4_4_0_clk _0636_ net56 VSS VSS
+ VDD VDD timer\[1\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[2\]$_DFF_PN0_ clknet_4_7_0_clk _0637_ net56 VSS VSS
+ VDD VDD timer\[2\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[3\]$_DFF_PN0_ clknet_4_4_0_clk _0638_ net56 VSS VSS
+ VDD VDD timer\[3\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[4\]$_DFF_PN0_ clknet_4_4_0_clk _0639_ net56 VSS VSS
+ VDD VDD timer\[4\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[5\]$_DFF_PN0_ clknet_4_7_0_clk _0640_ net56 VSS VSS
+ VDD VDD timer\[5\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[6\]$_DFF_PN0_ clknet_4_5_0_clk _0641_ net56 VSS VSS
+ VDD VDD timer\[6\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[7\]$_DFF_PN0_ clknet_4_7_0_clk _0642_ net56 VSS VSS
+ VDD VDD timer\[7\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[8\]$_DFF_PN0_ clknet_4_5_0_clk _0643_ net56 VSS VSS
+ VDD VDD timer\[8\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[9\]$_DFF_PN0_ clknet_4_5_0_clk _0644_ net56 VSS VSS
+ VDD VDD timer\[9\] sky130_fd_sc_hd__dfrtp_1
Xwr_ready_reg$_DFF_PN0_ clknet_4_5_0_clk _0609_ net56 VSS
+ VSS VDD VDD net221 sky130_fd_sc_hd__dfrtp_1
X_1302__1 VSS VSS VDD VDD _unconnected_1 phy_bank_group[0]
+ sky130_fd_sc_hd__conb_1
X_1303__2 VSS VSS VDD VDD _unconnected_2 phy_bank_group[1]
+ sky130_fd_sc_hd__conb_1
X_1377__3 VSS VSS VDD VDD _unconnected_3 phy_dqs_n[0] sky130_fd_sc_hd__conb_1
X_1378__4 VSS VSS VDD VDD _unconnected_4 phy_dqs_n[1] sky130_fd_sc_hd__conb_1
X_1379__5 VSS VSS VDD VDD _unconnected_5 phy_dqs_n[2] sky130_fd_sc_hd__conb_1
X_1380__6 VSS VSS VDD VDD _unconnected_6 phy_dqs_n[3] sky130_fd_sc_hd__conb_1
X_1381__7 VSS VSS VDD VDD _unconnected_7 phy_dqs_n[4] sky130_fd_sc_hd__conb_1
X_1382__8 VSS VSS VDD VDD _unconnected_8 phy_dqs_n[5] sky130_fd_sc_hd__conb_1
X_1383__9 VSS VSS VDD VDD _unconnected_9 phy_dqs_n[6] sky130_fd_sc_hd__conb_1
X_1384__10 VSS VSS VDD VDD _unconnected_10 phy_dqs_n[7] sky130_fd_sc_hd__conb_1
X_1385__12 VSS VSS VDD VDD phy_dqs_p[0] _unconnected_11 sky130_fd_sc_hd__conb_1
X_1386__13 VSS VSS VDD VDD phy_dqs_p[1] _unconnected_12 sky130_fd_sc_hd__conb_1
X_1387__14 VSS VSS VDD VDD phy_dqs_p[2] _unconnected_13 sky130_fd_sc_hd__conb_1
X_1388__15 VSS VSS VDD VDD phy_dqs_p[3] _unconnected_14 sky130_fd_sc_hd__conb_1
X_1389__16 VSS VSS VDD VDD phy_dqs_p[4] _unconnected_15 sky130_fd_sc_hd__conb_1
X_1390__17 VSS VSS VDD VDD phy_dqs_p[5] _unconnected_16 sky130_fd_sc_hd__conb_1
X_1391__18 VSS VSS VDD VDD phy_dqs_p[6] _unconnected_17 sky130_fd_sc_hd__conb_1
X_1392__19 VSS VSS VDD VDD phy_dqs_p[7] _unconnected_18 sky130_fd_sc_hd__conb_1
X_1393__20 VSS VSS VDD VDD phy_odt _unconnected_19 sky130_fd_sc_hd__conb_1
Xcmd_reg_valid$_DFF_PN0__21 VSS VSS VDD VDD net20 _unconnected_20
+ sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput86 wr_data[35] VSS VSS VDD VDD net85 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput87 wr_data[36] VSS VSS VDD VDD net86 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput88 wr_data[37] VSS VSS VDD VDD net87 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput89 wr_data[38] VSS VSS VDD VDD net88 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput90 wr_data[39] VSS VSS VDD VDD net89 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput91 wr_data[3] VSS VSS VDD VDD net90 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput92 wr_data[40] VSS VSS VDD VDD net91 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput93 wr_data[41] VSS VSS VDD VDD net92 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput94 wr_data[42] VSS VSS VDD VDD net93 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput95 wr_data[43] VSS VSS VDD VDD net94 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput96 wr_data[44] VSS VSS VDD VDD net95 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput97 wr_data[45] VSS VSS VDD VDD net96 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput98 wr_data[46] VSS VSS VDD VDD net97 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput99 wr_data[47] VSS VSS VDD VDD net98 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput100 wr_data[48] VSS VSS VDD VDD net99 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput101 wr_data[49] VSS VSS VDD VDD net100 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput102 wr_data[4] VSS VSS VDD VDD net101 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput103 wr_data[50] VSS VSS VDD VDD net102 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput104 wr_data[51] VSS VSS VDD VDD net103 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput105 wr_data[52] VSS VSS VDD VDD net104 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput106 wr_data[53] VSS VSS VDD VDD net105 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput107 wr_data[54] VSS VSS VDD VDD net106 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput108 wr_data[55] VSS VSS VDD VDD net107 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput109 wr_data[56] VSS VSS VDD VDD net108 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput110 wr_data[57] VSS VSS VDD VDD net109 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput111 wr_data[58] VSS VSS VDD VDD net110 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput112 wr_data[59] VSS VSS VDD VDD net111 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput113 wr_data[5] VSS VSS VDD VDD net112 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput114 wr_data[60] VSS VSS VDD VDD net113 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput115 wr_data[61] VSS VSS VDD VDD net114 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput116 wr_data[62] VSS VSS VDD VDD net115 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput117 wr_data[63] VSS VSS VDD VDD net116 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput118 wr_data[6] VSS VSS VDD VDD net117 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput119 wr_data[7] VSS VSS VDD VDD net118 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput120 wr_data[8] VSS VSS VDD VDD net119 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput121 wr_data[9] VSS VSS VDD VDD net120 sky130_fd_sc_hd__clkdlybuf4s50_1
Xinput122 wr_valid VSS VSS VDD VDD net121 sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput123 net122 VSS VSS VDD VDD cmd_ready sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput124 net123 VSS VSS VDD VDD init_done sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput125 net124 VSS VSS VDD VDD phy_addr[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput126 net125 VSS VSS VDD VDD phy_addr[10] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput127 net126 VSS VSS VDD VDD phy_addr[11] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput128 net127 VSS VSS VDD VDD phy_addr[12] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput129 net128 VSS VSS VDD VDD phy_addr[13] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput130 net129 VSS VSS VDD VDD phy_addr[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput131 net130 VSS VSS VDD VDD phy_addr[2] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput132 net131 VSS VSS VDD VDD phy_addr[3] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput133 net132 VSS VSS VDD VDD phy_addr[4] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput134 net133 VSS VSS VDD VDD phy_addr[5] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput135 net134 VSS VSS VDD VDD phy_addr[6] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput136 net135 VSS VSS VDD VDD phy_addr[7] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput137 net136 VSS VSS VDD VDD phy_addr[8] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput138 net137 VSS VSS VDD VDD phy_addr[9] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput139 net138 VSS VSS VDD VDD phy_bank[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput140 net139 VSS VSS VDD VDD phy_bank[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput141 net140 VSS VSS VDD VDD phy_bank[2] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput142 net141 VSS VSS VDD VDD phy_cas_n sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput143 net142 VSS VSS VDD VDD phy_cs_n sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput144 net143 VSS VSS VDD VDD phy_dm[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput145 net144 VSS VSS VDD VDD phy_dm[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput146 net145 VSS VSS VDD VDD phy_dm[2] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput147 net146 VSS VSS VDD VDD phy_dm[3] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput148 net147 VSS VSS VDD VDD phy_dm[4] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput149 net148 VSS VSS VDD VDD phy_dm[5] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput150 net149 VSS VSS VDD VDD phy_dm[6] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput151 net150 VSS VSS VDD VDD phy_dm[7] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput152 net151 VSS VSS VDD VDD phy_ras_n sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput153 net152 VSS VSS VDD VDD phy_reset_n sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput154 net153 VSS VSS VDD VDD phy_we_n sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput155 net154 VSS VSS VDD VDD rd_data[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput156 net155 VSS VSS VDD VDD rd_data[10] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput157 net156 VSS VSS VDD VDD rd_data[11] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput158 net157 VSS VSS VDD VDD rd_data[12] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput159 net158 VSS VSS VDD VDD rd_data[13] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput160 net159 VSS VSS VDD VDD rd_data[14] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput161 net160 VSS VSS VDD VDD rd_data[15] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput162 net161 VSS VSS VDD VDD rd_data[16] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput163 net162 VSS VSS VDD VDD rd_data[17] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput164 net163 VSS VSS VDD VDD rd_data[18] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput165 net164 VSS VSS VDD VDD rd_data[19] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput166 net165 VSS VSS VDD VDD rd_data[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput167 net166 VSS VSS VDD VDD rd_data[20] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput168 net167 VSS VSS VDD VDD rd_data[21] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput169 net168 VSS VSS VDD VDD rd_data[22] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput170 net169 VSS VSS VDD VDD rd_data[23] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput171 net170 VSS VSS VDD VDD rd_data[24] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput172 net171 VSS VSS VDD VDD rd_data[25] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput173 net172 VSS VSS VDD VDD rd_data[26] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput174 net173 VSS VSS VDD VDD rd_data[27] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput175 net174 VSS VSS VDD VDD rd_data[28] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput176 net175 VSS VSS VDD VDD rd_data[29] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput177 net176 VSS VSS VDD VDD rd_data[2] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput178 net177 VSS VSS VDD VDD rd_data[30] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput179 net178 VSS VSS VDD VDD rd_data[31] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput180 net179 VSS VSS VDD VDD rd_data[32] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput181 net180 VSS VSS VDD VDD rd_data[33] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput182 net181 VSS VSS VDD VDD rd_data[34] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput183 net182 VSS VSS VDD VDD rd_data[35] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput184 net183 VSS VSS VDD VDD rd_data[36] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput185 net184 VSS VSS VDD VDD rd_data[37] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput186 net185 VSS VSS VDD VDD rd_data[38] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput187 net186 VSS VSS VDD VDD rd_data[39] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput188 net187 VSS VSS VDD VDD rd_data[3] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput189 net188 VSS VSS VDD VDD rd_data[40] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput190 net189 VSS VSS VDD VDD rd_data[41] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput191 net190 VSS VSS VDD VDD rd_data[42] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput192 net191 VSS VSS VDD VDD rd_data[43] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput193 net192 VSS VSS VDD VDD rd_data[44] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput194 net193 VSS VSS VDD VDD rd_data[45] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput195 net194 VSS VSS VDD VDD rd_data[46] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput196 net195 VSS VSS VDD VDD rd_data[47] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput197 net196 VSS VSS VDD VDD rd_data[48] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput198 net197 VSS VSS VDD VDD rd_data[49] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput199 net198 VSS VSS VDD VDD rd_data[4] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput200 net199 VSS VSS VDD VDD rd_data[50] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput201 net200 VSS VSS VDD VDD rd_data[51] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput202 net201 VSS VSS VDD VDD rd_data[52] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput203 net202 VSS VSS VDD VDD rd_data[53] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput204 net203 VSS VSS VDD VDD rd_data[54] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput205 net204 VSS VSS VDD VDD rd_data[55] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput206 net205 VSS VSS VDD VDD rd_data[56] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput207 net206 VSS VSS VDD VDD rd_data[57] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput208 net207 VSS VSS VDD VDD rd_data[58] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput209 net208 VSS VSS VDD VDD rd_data[59] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput210 net209 VSS VSS VDD VDD rd_data[5] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput211 net210 VSS VSS VDD VDD rd_data[60] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput212 net211 VSS VSS VDD VDD rd_data[61] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput213 net212 VSS VSS VDD VDD rd_data[62] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput214 net213 VSS VSS VDD VDD rd_data[63] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput215 net214 VSS VSS VDD VDD rd_data[6] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput216 net215 VSS VSS VDD VDD rd_data[7] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput217 net216 VSS VSS VDD VDD rd_data[8] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput218 net217 VSS VSS VDD VDD rd_data[9] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput219 net218 VSS VSS VDD VDD rd_valid sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput220 net219 VSS VSS VDD VDD state[0] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput221 net220 VSS VSS VDD VDD state[1] sky130_fd_sc_hd__clkdlybuf4s50_1
Xoutput222 net221 VSS VSS VDD VDD wr_ready sky130_fd_sc_hd__clkdlybuf4s50_1
Xplace247 _0124_ VSS VSS VDD VDD net246 sky130_fd_sc_hd__buf_4
Xplace250 net24 VSS VSS VDD VDD net249 sky130_fd_sc_hd__buf_4
Xplace237 _0010_ VSS VSS VDD VDD net236 sky130_fd_sc_hd__buf_4
Xplace243 _0049_ VSS VSS VDD VDD net242 sky130_fd_sc_hd__buf_4
Xplace245 _0017_ VSS VSS VDD VDD net244 sky130_fd_sc_hd__buf_4
Xplace246 _0051_ VSS VSS VDD VDD net245 sky130_fd_sc_hd__buf_4
Xplace248 net56 VSS VSS VDD VDD net247 sky130_fd_sc_hd__buf_4
Xplace249 net54 VSS VSS VDD VDD net248 sky130_fd_sc_hd__buf_4
Xplace251 net23 VSS VSS VDD VDD net250 sky130_fd_sc_hd__buf_4
Xplace252 net22 VSS VSS VDD VDD net251 sky130_fd_sc_hd__buf_4
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xplace236 _0350_ VSS VSS VDD VDD net235 sky130_fd_sc_hd__buf_4
Xplace238 _0009_ VSS VSS VDD VDD net237 sky130_fd_sc_hd__buf_4
Xplace239 _0013_ VSS VSS VDD VDD net238 sky130_fd_sc_hd__buf_4
Xplace240 _0012_ VSS VSS VDD VDD net239 sky130_fd_sc_hd__buf_4
Xplace241 _0094_ VSS VSS VDD VDD net240 sky130_fd_sc_hd__buf_4
Xplace242 _0050_ VSS VSS VDD VDD net241 sky130_fd_sc_hd__buf_4
Xplace244 _0047_ VSS VSS VDD VDD net243 sky130_fd_sc_hd__buf_4
Xclkbuf_4_0_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_0_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_1_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_1_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_2_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_2_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_3_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_3_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_4_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_4_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_5_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_5_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_6_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_6_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_7_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_7_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_8_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_8_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_9_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_9_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_10_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_10_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_11_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_11_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_12_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_12_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_13_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_13_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_14_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_14_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_15_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_15_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_4_0_0_clk VSS VSS VDD VDD _unconnected_21
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload1 clknet_4_1_0_clk VSS VSS VDD VDD _unconnected_22
+ sky130_fd_sc_hd__inv_6
Xclkload2 clknet_4_2_0_clk VSS VSS VDD VDD _unconnected_23
+ sky130_fd_sc_hd__inv_6
Xclkload3 clknet_4_3_0_clk VSS VSS VDD VDD _unconnected_24
+ sky130_fd_sc_hd__inv_6
Xclkload4 clknet_4_4_0_clk VSS VSS VDD VDD _unconnected_25
+ sky130_fd_sc_hd__clkinv_8
Xclkload5 clknet_4_5_0_clk VSS VSS VDD VDD _unconnected_26
+ sky130_fd_sc_hd__clkinv_8
Xclkload6 clknet_4_6_0_clk VSS VSS VDD VDD _unconnected_27
+ sky130_fd_sc_hd__inv_8
Xclkload7 clknet_4_7_0_clk VSS VSS VDD VDD _unconnected_28
+ sky130_fd_sc_hd__inv_6
Xclkload8 clknet_4_8_0_clk VSS VSS VDD VDD _unconnected_29
+ sky130_fd_sc_hd__clkinv_1
Xclkload9 clknet_4_9_0_clk VSS VSS VDD VDD _unconnected_30
+ sky130_fd_sc_hd__bufinv_16
Xclkload10 clknet_4_11_0_clk VSS VSS VDD VDD _unconnected_31
+ sky130_fd_sc_hd__clkinv_1
Xclkload11 clknet_4_12_0_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__inv_6
Xclkload12 clknet_4_13_0_clk VSS VSS VDD VDD _unconnected_33
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload13 clknet_4_14_0_clk VSS VSS VDD VDD _unconnected_34
+ sky130_fd_sc_hd__inv_6
Xclkload14 clknet_4_15_0_clk VSS VSS VDD VDD _unconnected_35
+ sky130_fd_sc_hd__clkinv_1
Xhold253 rst_n VSS VSS VDD VDD net252 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS ddr_controller
