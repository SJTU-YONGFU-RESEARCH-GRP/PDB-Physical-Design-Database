* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_scrambler clk data_in data_out enable
+ lfsr_state[0] lfsr_state[1] lfsr_state[2] lfsr_state[3] lfsr_state[4]
+ lfsr_state[5] lfsr_state[6] lfsr_state[7] rst_n
X_10_ enable VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_2
X_11_ next_input net5 _08_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__mux2_1
X_12_ net5 net6 _08_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__mux2_1
X_13_ net6 net7 _08_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__mux2_1
X_14_ net7 net8 _08_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__mux2_1
X_15_ net8 net9 _08_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__mux2_1
X_16_ net9 net10 _08_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__mux2_1
X_17_ net10 net11 _08_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__mux2_1
X_18_ net9 net8 net10 VSS VSS VDD VDD _09_ sky130_fd_sc_hd__xor3_1
X_19_ net11 _09_ _08_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__mux2_1
X_20_ next_input net1 VSS VSS VDD VDD net3 sky130_fd_sc_hd__xor2_1
X_21_ next_input VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xlfsr_reg\[0\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _00_ net2
+ VSS VSS VDD VDD next_input sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[1\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _01_ net2
+ VSS VSS VDD VDD net5 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[2\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _02_ net2
+ VSS VSS VDD VDD net6 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[3\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _03_ net2
+ VSS VSS VDD VDD net7 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[4\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _04_ net2
+ VSS VSS VDD VDD net8 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[5\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _05_ net2
+ VSS VSS VDD VDD net9 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[6\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _06_ net2
+ VSS VSS VDD VDD net10 sky130_fd_sc_hd__dfstp_1
Xlfsr_reg\[7\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _07_ net2
+ VSS VSS VDD VDD net11 sky130_fd_sc_hd__dfstp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_1
Xinput2 net12 VSS VSS VDD VDD net2 sky130_fd_sc_hd__buf_2
Xoutput3 net3 VSS VSS VDD VDD data_out sky130_fd_sc_hd__clkbuf_1
Xoutput4 net4 VSS VSS VDD VDD lfsr_state[0] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net5 VSS VSS VDD VDD lfsr_state[1] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net6 VSS VSS VDD VDD lfsr_state[2] sky130_fd_sc_hd__clkbuf_1
Xoutput7 net7 VSS VSS VDD VDD lfsr_state[3] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net8 VSS VSS VDD VDD lfsr_state[4] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net9 VSS VSS VDD VDD lfsr_state[5] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net10 VSS VSS VDD VDD lfsr_state[6] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net11 VSS VSS VDD VDD lfsr_state[7] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xhold1 rst_n VSS VSS VDD VDD net12 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_scrambler
