* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT scan_register clk data_in[0] data_in[1] data_in[2]
+ data_in[3] data_in[4] data_in[5] data_in[6] data_in[7] data_out[0]
+ data_out[1] data_out[2] data_out[3] data_out[4] data_out[5]
+ data_out[6] data_out[7] rst_n scan_en scan_in scan_out
X_52_ rst_n _16_ VDD VSS BUF_X1
X_53_ _16_ _17_ VDD VSS BUF_X2
X_54_ scan_en _18_ VDD VSS BUF_X4
X_55_ _18_ _19_ VDD VSS BUF_X8
X_56_ scan_reg\[0\] net9 _19_ _20_ VDD VSS MUX2_X1
X_57_ _17_ _20_ _00_ VDD VSS AND2_X1
X_58_ scan_reg\[1\] scan_reg\[0\] _19_ _21_ VDD VSS MUX2_X1
X_59_ _17_ _21_ _01_ VDD VSS AND2_X1
X_60_ scan_reg\[2\] scan_reg\[1\] _19_ _22_ VDD VSS MUX2_X1
X_61_ _17_ _22_ _02_ VDD VSS AND2_X1
X_62_ scan_reg\[3\] scan_reg\[2\] _19_ _23_ VDD VSS MUX2_X1
X_63_ _17_ _23_ _03_ VDD VSS AND2_X1
X_64_ scan_reg\[4\] scan_reg\[3\] _19_ _24_ VDD VSS MUX2_X1
X_65_ _17_ _24_ _04_ VDD VSS AND2_X1
X_66_ scan_reg\[5\] scan_reg\[4\] _19_ _25_ VDD VSS MUX2_X1
X_67_ _17_ _25_ _05_ VDD VSS AND2_X1
X_68_ scan_reg\[6\] scan_reg\[5\] _19_ _26_ VDD VSS MUX2_X1
X_69_ _17_ _26_ _06_ VDD VSS AND2_X1
X_70_ net18 scan_reg\[6\] _19_ _27_ VDD VSS MUX2_X1
X_71_ _17_ _27_ _07_ VDD VSS AND2_X1
X_72_ net1 net9 _19_ _28_ VDD VSS MUX2_X1
X_73_ _17_ _28_ _08_ VDD VSS AND2_X1
X_74_ net2 scan_reg\[0\] _19_ _29_ VDD VSS MUX2_X1
X_75_ _17_ _29_ _09_ VDD VSS AND2_X1
X_76_ net3 scan_reg\[1\] _18_ _30_ VDD VSS MUX2_X1
X_77_ _16_ _30_ _10_ VDD VSS AND2_X1
X_78_ net4 scan_reg\[2\] _18_ _31_ VDD VSS MUX2_X1
X_79_ _16_ _31_ _11_ VDD VSS AND2_X1
X_80_ net5 scan_reg\[3\] _18_ _32_ VDD VSS MUX2_X1
X_81_ _16_ _32_ _12_ VDD VSS AND2_X1
X_82_ net6 scan_reg\[4\] _18_ _33_ VDD VSS MUX2_X1
X_83_ _16_ _33_ _13_ VDD VSS AND2_X1
X_84_ net7 scan_reg\[5\] _18_ _34_ VDD VSS MUX2_X1
X_85_ _16_ _34_ _14_ VDD VSS AND2_X1
X_86_ net8 scan_reg\[6\] _18_ _35_ VDD VSS MUX2_X1
X_87_ _16_ _35_ _15_ VDD VSS AND2_X1
Xdata_out\[0\]$_SDFF_PN0_ _00_ clknet_1_0__leaf_clk net10
+ _51_ VDD VSS DFF_X1
Xdata_out\[1\]$_SDFF_PN0_ _01_ clknet_1_0__leaf_clk net11
+ _50_ VDD VSS DFF_X1
Xdata_out\[2\]$_SDFF_PN0_ _02_ clknet_1_0__leaf_clk net12
+ _49_ VDD VSS DFF_X1
Xdata_out\[3\]$_SDFF_PN0_ _03_ clknet_1_0__leaf_clk net13
+ _48_ VDD VSS DFF_X1
Xdata_out\[4\]$_SDFF_PN0_ _04_ clknet_1_1__leaf_clk net14
+ _47_ VDD VSS DFF_X1
Xdata_out\[5\]$_SDFF_PN0_ _05_ clknet_1_1__leaf_clk net15
+ _46_ VDD VSS DFF_X1
Xdata_out\[6\]$_SDFF_PN0_ _06_ clknet_1_1__leaf_clk net16
+ _45_ VDD VSS DFF_X1
Xdata_out\[7\]$_SDFF_PN0_ _07_ clknet_1_1__leaf_clk net17
+ _44_ VDD VSS DFF_X1
Xscan_reg\[0\]$_SDFF_PN0_ _08_ clknet_1_0__leaf_clk scan_reg\[0\]
+ _43_ VDD VSS DFF_X1
Xscan_reg\[1\]$_SDFF_PN0_ _09_ clknet_1_0__leaf_clk scan_reg\[1\]
+ _42_ VDD VSS DFF_X1
Xscan_reg\[2\]$_SDFF_PN0_ _10_ clknet_1_0__leaf_clk scan_reg\[2\]
+ _41_ VDD VSS DFF_X1
Xscan_reg\[3\]$_SDFF_PN0_ _11_ clknet_1_1__leaf_clk scan_reg\[3\]
+ _40_ VDD VSS DFF_X1
Xscan_reg\[4\]$_SDFF_PN0_ _12_ clknet_1_1__leaf_clk scan_reg\[4\]
+ _39_ VDD VSS DFF_X1
Xscan_reg\[5\]$_SDFF_PN0_ _13_ clknet_1_1__leaf_clk scan_reg\[5\]
+ _38_ VDD VSS DFF_X1
Xscan_reg\[6\]$_SDFF_PN0_ _14_ clknet_1_1__leaf_clk scan_reg\[6\]
+ _37_ VDD VSS DFF_X1
Xscan_reg\[7\]$_SDFF_PN0_ _15_ clknet_1_1__leaf_clk net18
+ _36_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_71 VDD VSS TAPCELL_X1
Xinput1 data_in[0] net1 VDD VSS BUF_X1
Xinput2 data_in[1] net2 VDD VSS BUF_X1
Xinput3 data_in[2] net3 VDD VSS BUF_X1
Xinput4 data_in[3] net4 VDD VSS BUF_X1
Xinput5 data_in[4] net5 VDD VSS BUF_X1
Xinput6 data_in[5] net6 VDD VSS BUF_X1
Xinput7 data_in[6] net7 VDD VSS BUF_X1
Xinput8 data_in[7] net8 VDD VSS BUF_X1
Xinput9 scan_in net9 VDD VSS BUF_X1
Xoutput10 net10 data_out[0] VDD VSS BUF_X1
Xoutput11 net11 data_out[1] VDD VSS BUF_X1
Xoutput12 net12 data_out[2] VDD VSS BUF_X1
Xoutput13 net13 data_out[3] VDD VSS BUF_X1
Xoutput14 net14 data_out[4] VDD VSS BUF_X1
Xoutput15 net15 data_out[5] VDD VSS BUF_X1
Xoutput16 net16 data_out[6] VDD VSS BUF_X1
Xoutput17 net17 data_out[7] VDD VSS BUF_X1
Xoutput18 net18 scan_out VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_1_0__leaf_clk _unconnected_0 VDD VSS INV_X1
.ENDS scan_register
