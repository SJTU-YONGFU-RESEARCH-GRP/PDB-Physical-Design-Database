* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT aes_cipher_top clk done key[0] key[100] key[101] key[102]
+ key[103] key[104] key[105] key[106] key[107] key[108] key[109]
+ key[10] key[110] key[111] key[112] key[113] key[114] key[115]
+ key[116] key[117] key[118] key[119] key[11] key[120] key[121]
+ key[122] key[123] key[124] key[125] key[126] key[127] key[12]
+ key[13] key[14] key[15] key[16] key[17] key[18] key[19] key[1]
+ key[20] key[21] key[22] key[23] key[24] key[25] key[26] key[27]
+ key[28] key[29] key[2] key[30] key[31] key[32] key[33] key[34]
+ key[35] key[36] key[37] key[38] key[39] key[3] key[40] key[41]
+ key[42] key[43] key[44] key[45] key[46] key[47] key[48] key[49]
+ key[4] key[50] key[51] key[52] key[53] key[54] key[55] key[56]
+ key[57] key[58] key[59] key[5] key[60] key[61] key[62] key[63]
+ key[64] key[65] key[66] key[67] key[68] key[69] key[6] key[70]
+ key[71] key[72] key[73] key[74] key[75] key[76] key[77] key[78]
+ key[79] key[7] key[80] key[81] key[82] key[83] key[84] key[85]
+ key[86] key[87] key[88] key[89] key[8] key[90] key[91] key[92]
+ key[93] key[94] key[95] key[96] key[97] key[98] key[99] key[9]
+ ld rst text_in[0] text_in[100] text_in[101] text_in[102] text_in[103]
+ text_in[104] text_in[105] text_in[106] text_in[107] text_in[108]
+ text_in[109] text_in[10] text_in[110] text_in[111] text_in[112]
+ text_in[113] text_in[114] text_in[115] text_in[116] text_in[117]
+ text_in[118] text_in[119] text_in[11] text_in[120] text_in[121]
+ text_in[122] text_in[123] text_in[124] text_in[125] text_in[126]
+ text_in[127] text_in[12] text_in[13] text_in[14] text_in[15]
+ text_in[16] text_in[17] text_in[18] text_in[19] text_in[1]
+ text_in[20] text_in[21] text_in[22] text_in[23] text_in[24]
+ text_in[25] text_in[26] text_in[27] text_in[28] text_in[29]
+ text_in[2] text_in[30] text_in[31] text_in[32] text_in[33]
+ text_in[34] text_in[35] text_in[36] text_in[37] text_in[38]
+ text_in[39] text_in[3] text_in[40] text_in[41] text_in[42]
+ text_in[43] text_in[44] text_in[45] text_in[46] text_in[47]
+ text_in[48] text_in[49] text_in[4] text_in[50] text_in[51]
+ text_in[52] text_in[53] text_in[54] text_in[55] text_in[56]
+ text_in[57] text_in[58] text_in[59] text_in[5] text_in[60]
+ text_in[61] text_in[62] text_in[63] text_in[64] text_in[65]
+ text_in[66] text_in[67] text_in[68] text_in[69] text_in[6]
+ text_in[70] text_in[71] text_in[72] text_in[73] text_in[74]
+ text_in[75] text_in[76] text_in[77] text_in[78] text_in[79]
+ text_in[7] text_in[80] text_in[81] text_in[82] text_in[83]
+ text_in[84] text_in[85] text_in[86] text_in[87] text_in[88]
+ text_in[89] text_in[8] text_in[90] text_in[91] text_in[92]
+ text_in[93] text_in[94] text_in[95] text_in[96] text_in[97]
+ text_in[98] text_in[99] text_in[9] text_out[0] text_out[100]
+ text_out[101] text_out[102] text_out[103] text_out[104] text_out[105]
+ text_out[106] text_out[107] text_out[108] text_out[109] text_out[10]
+ text_out[110] text_out[111] text_out[112] text_out[113] text_out[114]
+ text_out[115] text_out[116] text_out[117] text_out[118] text_out[119]
+ text_out[11] text_out[120] text_out[121] text_out[122] text_out[123]
+ text_out[124] text_out[125] text_out[126] text_out[127] text_out[12]
+ text_out[13] text_out[14] text_out[15] text_out[16] text_out[17]
+ text_out[18] text_out[19] text_out[1] text_out[20] text_out[21]
+ text_out[22] text_out[23] text_out[24] text_out[25] text_out[26]
+ text_out[27] text_out[28] text_out[29] text_out[2] text_out[30]
+ text_out[31] text_out[32] text_out[33] text_out[34] text_out[35]
+ text_out[36] text_out[37] text_out[38] text_out[39] text_out[3]
+ text_out[40] text_out[41] text_out[42] text_out[43] text_out[44]
+ text_out[45] text_out[46] text_out[47] text_out[48] text_out[49]
+ text_out[4] text_out[50] text_out[51] text_out[52] text_out[53]
+ text_out[54] text_out[55] text_out[56] text_out[57] text_out[58]
+ text_out[59] text_out[5] text_out[60] text_out[61] text_out[62]
+ text_out[63] text_out[64] text_out[65] text_out[66] text_out[67]
+ text_out[68] text_out[69] text_out[6] text_out[70] text_out[71]
+ text_out[72] text_out[73] text_out[74] text_out[75] text_out[76]
+ text_out[77] text_out[78] text_out[79] text_out[7] text_out[80]
+ text_out[81] text_out[82] text_out[83] text_out[84] text_out[85]
+ text_out[86] text_out[87] text_out[88] text_out[89] text_out[8]
+ text_out[90] text_out[91] text_out[92] text_out[93] text_out[94]
+ text_out[95] text_out[96] text_out[97] text_out[98] text_out[99]
+ text_out[9]
X_15332_ net215 _06216_ VDD VSS BUF_X32
X_15333_ _06216_ _06217_ VDD VSS INV_X8
X_15334_ _06217_ _06218_ VDD VSS BUF_X4
X_15335_ _06218_ net69 _06219_ VDD VSS NOR2_X2
X_15336_ _06217_ _06220_ VDD VSS BUF_X4
X_15337_ u0.w\[0\]\[19\] _06221_ VDD VSS CLKBUF_X3
X_15338_ u0.w\[1\]\[19\] _06222_ VDD VSS BUF_X4
X_15339_ _06221_ _06222_ _06223_ VDD VSS XNOR2_X2
X_15340_ net50 _06223_ _06224_ VDD VSS AND2_X1
X_15341_ _06216_ _06225_ VDD VSS BUF_X16
X_15342_ _06225_ _06226_ VDD VSS BUF_X16
X_15343_ net16 _06223_ _06227_ VDD VSS NOR2_X1
X_15344_ u0.w\[2\]\[19\] _06228_ VDD VSS CLKBUF_X3
X_15345_ u0.tmp_w\[19\] _06229_ VDD VSS BUF_X4
X_15346_ _06229_ u0.subword\[19\] _06230_ VDD VSS XNOR2_X1
X_15347_ _06228_ _06230_ _06231_ VDD VSS XNOR2_X1
X_15348_ _06224_ _06227_ _06231_ _06232_ VDD VSS MUX2_X2
X_15349_ _06219_ _06232_ _06233_ VDD VSS OR2_X2
X_15350_ _06233_ _06234_ VDD VSS INV_X1
X_15351_ _06234_ _06235_ VDD VSS BUF_X4
X_15352_ _06235_ _06236_ VDD VSS BUF_X4
X_15353_ _06236_ _06237_ VDD VSS BUF_X4
X_15354_ _06237_ _06238_ VDD VSS CLKBUF_X3
X_15355_ _06238_ _00390_ VDD VSS CLKBUF_X3
X_15356_ _06218_ _06239_ VDD VSS BUF_X8
X_15357_ _06239_ net65 _06240_ VDD VSS NOR2_X2
X_15358_ u0.w\[0\]\[16\] _06241_ VDD VSS BUF_X4
X_15359_ u0.w\[1\]\[16\] _06242_ VDD VSS BUF_X4
X_15360_ _06241_ _06242_ _06243_ VDD VSS XNOR2_X2
X_15361_ _06218_ _06243_ _06244_ VDD VSS AND2_X1
X_15362_ _06225_ _06245_ VDD VSS BUF_X4
X_15363_ _06245_ _06243_ _06246_ VDD VSS NOR2_X1
X_15364_ u0.w\[2\]\[16\] _06247_ VDD VSS CLKBUF_X3
Xclone524 _00961_ net1152 VDD VSS BUF_X8
X_15366_ u0.tmp_w\[16\] u0.subword\[16\] _06249_ VDD VSS XNOR2_X2
X_15367_ _06249_ _06247_ _06250_ VDD VSS XNOR2_X2
X_15368_ _06244_ _06246_ _06250_ _06251_ VDD VSS MUX2_X2
X_15369_ _06251_ _06240_ _06252_ VDD VSS NOR2_X4
X_15370_ net856 _06253_ VDD VSS INV_X4
X_15371_ _06253_ _14664_ VDD VSS BUF_X16
X_15372_ _06239_ net66 _06254_ VDD VSS NOR2_X4
X_15373_ u0.w\[0\]\[17\] _06255_ VDD VSS BUF_X2
X_15374_ u0.w\[1\]\[17\] _06256_ VDD VSS BUF_X4
X_15375_ _06255_ _06256_ _06257_ VDD VSS XNOR2_X2
X_15376_ _06220_ _06257_ _06258_ VDD VSS AND2_X1
X_15377_ _06245_ _06257_ _06259_ VDD VSS NOR2_X1
X_15378_ u0.w\[2\]\[17\] _06260_ VDD VSS CLKBUF_X3
Xrebuffer248 _06252_ net856 VDD VSS BUF_X4
X_15380_ u0.tmp_w\[17\] u0.subword\[17\] _06262_ VDD VSS XNOR2_X2
X_15381_ _06262_ _06260_ _06263_ VDD VSS XNOR2_X2
X_15382_ _06258_ _06259_ _06263_ _06264_ VDD VSS MUX2_X2
X_15383_ _06264_ _06254_ _06265_ VDD VSS NOR2_X4
X_15384_ net524 _14669_ VDD VSS INV_X4
X_15385_ _06239_ _06266_ VDD VSS BUF_X8
X_15386_ _06266_ _06267_ VDD VSS BUF_X8
X_15387_ u0.tmp_w\[21\] _06268_ VDD VSS CLKBUF_X3
X_15388_ u0.w\[0\]\[21\] _06269_ VDD VSS CLKBUF_X3
X_15389_ u0.w\[1\]\[21\] _06270_ VDD VSS BUF_X4
X_15390_ _06269_ _06270_ _06271_ VDD VSS XOR2_X2
X_15391_ u0.w\[2\]\[21\] _06272_ VDD VSS BUF_X4
X_15392_ _06272_ u0.subword\[21\] _06273_ VDD VSS XNOR2_X1
X_15393_ _06271_ _06273_ _06274_ VDD VSS XNOR2_X1
X_15394_ _06268_ _06274_ _06275_ VDD VSS XNOR2_X1
X_15395_ _06267_ _06275_ _06276_ VDD VSS NAND2_X1
X_15396_ _06276_ net72 _06267_ _06277_ VDD VSS OAI21_X4
X_15397_ _06277_ _06278_ VDD VSS INV_X4
X_15398_ _06278_ _00392_ VDD VSS BUF_X4
X_15399_ _06245_ _06279_ VDD VSS BUF_X4
X_15400_ _06279_ net71 _06280_ VDD VSS AND2_X1
X_15401_ u0.w\[0\]\[20\] _06281_ VDD VSS CLKBUF_X3
X_15402_ u0.w\[1\]\[20\] _06282_ VDD VSS BUF_X4
X_15403_ _06281_ _06282_ _06283_ VDD VSS XNOR2_X2
X_15404_ u0.w\[2\]\[20\] _06284_ VDD VSS BUF_X4
X_15405_ u0.tmp_w\[20\] _06285_ VDD VSS CLKBUF_X3
X_15406_ _06285_ u0.subword\[20\] _06286_ VDD VSS XNOR2_X1
X_15407_ _06284_ _06286_ _06287_ VDD VSS XNOR2_X1
X_15408_ _06283_ _06287_ _06288_ VDD VSS XNOR2_X2
X_15409_ _06280_ _06288_ _06239_ _06289_ VDD VSS AOI21_X4
X_15410_ _06289_ _06290_ VDD VSS INV_X2
X_15411_ _06290_ _06291_ VDD VSS BUF_X4
X_15412_ _06291_ _06292_ VDD VSS CLKBUF_X3
X_15413_ _06292_ _06293_ VDD VSS CLKBUF_X3
X_15414_ _06293_ _00391_ VDD VSS CLKBUF_X3
X_15415_ _06245_ net67 _06294_ VDD VSS NAND2_X1
X_15416_ u0.tmp_w\[18\] _06295_ VDD VSS CLKBUF_X3
X_15417_ u0.w\[0\]\[18\] _06296_ VDD VSS BUF_X8
X_15418_ u0.w\[1\]\[18\] _06297_ VDD VSS BUF_X4
X_15419_ _06296_ _06297_ _06298_ VDD VSS XOR2_X2
X_15420_ u0.w\[2\]\[18\] _06299_ VDD VSS BUF_X4
X_15421_ _00408_ _06300_ VDD VSS BUF_X1
X_15422_ _06299_ _06300_ _06301_ VDD VSS NOR2_X1
X_15423_ _06217_ _06295_ _06298_ _06301_ _06302_ VDD VSS NAND4_X1
X_15424_ _06300_ _06303_ VDD VSS INV_X1
X_15425_ _06216_ _06295_ _06304_ VDD VSS NOR2_X1
X_15426_ _06299_ _06303_ _06298_ _06304_ _06305_ VDD VSS NAND4_X1
X_15427_ _06299_ _06306_ VDD VSS INV_X2
X_15428_ _06306_ _06300_ _06298_ _06304_ _06307_ VDD VSS NAND4_X1
X_15429_ _06295_ _06308_ VDD VSS INV_X1
X_15430_ _06296_ _06297_ _06309_ VDD VSS XNOR2_X2
X_15431_ _06299_ _06300_ _06310_ VDD VSS NAND2_X1
X_15432_ _06216_ _06308_ _06309_ _06310_ _06311_ VDD VSS OR4_X2
X_15433_ _06302_ _06305_ _06307_ _06311_ _06312_ VDD VSS AND4_X4
X_15434_ _06301_ _06304_ _06313_ VDD VSS AND2_X1
X_15435_ _06225_ _06308_ _06306_ _06300_ _06314_ VDD VSS NOR4_X1
X_15436_ _06309_ _06313_ _06314_ _06315_ VDD VSS OAI21_X1
X_15437_ _06225_ _06308_ _06299_ _06303_ _06316_ VDD VSS NOR4_X1
X_15438_ _06225_ _06295_ _06310_ _06317_ VDD VSS NOR3_X1
X_15439_ _06309_ _06316_ _06317_ _06318_ VDD VSS OAI21_X1
X_15440_ _06294_ _06312_ _06315_ _06318_ _06319_ VDD VSS AND4_X4
X_15441_ _06319_ _06320_ VDD VSS BUF_X8
X_15442_ _06320_ _06321_ VDD VSS INV_X8
X_15443_ _06321_ _06322_ VDD VSS BUF_X16
X_15444_ _06322_ _06323_ VDD VSS BUF_X8
X_15445_ _06323_ _14683_ VDD VSS BUF_X8
X_15446_ _06239_ net9 _06324_ VDD VSS NOR2_X4
X_15447_ u0.w\[0\]\[0\] _06325_ VDD VSS BUF_X4
X_15448_ u0.w\[1\]\[0\] _06326_ VDD VSS BUF_X4
X_15449_ _06326_ _06325_ _06327_ VDD VSS XNOR2_X2
X_15450_ _06220_ _06327_ _06328_ VDD VSS AND2_X1
X_15451_ _06226_ _06327_ _06329_ VDD VSS NOR2_X1
X_15452_ u0.w\[2\]\[0\] _06330_ VDD VSS BUF_X4
Xclone148 net630 net629 VDD VSS BUF_X4
X_15454_ u0.subword\[0\] u0.tmp_w\[0\] _06332_ VDD VSS XNOR2_X2
X_15455_ _06332_ _06330_ _06333_ VDD VSS XNOR2_X2
X_15456_ _06328_ _06329_ _06333_ _06334_ VDD VSS MUX2_X2
X_15457_ _06334_ _06324_ _06335_ VDD VSS NOR2_X4
X_15458_ net531 _06336_ VDD VSS INV_X8
X_15459_ _06336_ _06337_ VDD VSS BUF_X16
X_15460_ _06337_ _14732_ VDD VSS BUF_X32
X_15461_ _06239_ net70 _06338_ VDD VSS NOR2_X4
X_15462_ _06226_ _06339_ VDD VSS BUF_X16
X_15463_ u0.w\[0\]\[1\] _06340_ VDD VSS BUF_X4
X_15464_ u0.w\[1\]\[1\] _06341_ VDD VSS BUF_X4
X_15465_ _06340_ _06341_ _06342_ VDD VSS XOR2_X2
X_15466_ _06339_ _06342_ _06343_ VDD VSS NOR2_X1
X_15467_ _06340_ _06341_ _06344_ VDD VSS XNOR2_X2
X_15468_ _06339_ _06344_ _06345_ VDD VSS NOR2_X1
X_15469_ u0.w\[2\]\[1\] _06346_ VDD VSS BUF_X4
X_15470_ u0.tmp_w\[1\] _06347_ VDD VSS BUF_X4
X_15471_ _06347_ u0.subword\[1\] _06348_ VDD VSS XNOR2_X1
X_15472_ _06348_ _06346_ _06349_ VDD VSS XNOR2_X1
X_15473_ _06343_ _06345_ _06349_ _06350_ VDD VSS MUX2_X2
X_15474_ _06338_ _06350_ _06351_ VDD VSS NOR2_X4
X_15475_ _06351_ _06352_ VDD VSS INV_X4
X_15476_ _06352_ _14737_ VDD VSS BUF_X8
X_15477_ _06245_ net80 _06353_ VDD VSS NAND2_X1
X_15478_ u0.tmp_w\[2\] _06354_ VDD VSS BUF_X4
X_15479_ u0.w\[0\]\[2\] _06355_ VDD VSS BUF_X4
X_15480_ u0.w\[1\]\[2\] _06356_ VDD VSS BUF_X4
X_15481_ _06355_ _06356_ _06357_ VDD VSS XOR2_X2
X_15482_ u0.w\[2\]\[2\] _06358_ VDD VSS BUF_X4
X_15483_ _00409_ _06359_ VDD VSS BUF_X2
X_15484_ _06358_ _06359_ _06360_ VDD VSS NOR2_X1
X_15485_ _06220_ _06354_ _06357_ _06360_ _06361_ VDD VSS NAND4_X1
X_15486_ _06359_ _06362_ VDD VSS INV_X1
X_15487_ _06216_ _06354_ _06363_ VDD VSS NOR2_X1
X_15488_ _06358_ _06362_ _06357_ _06363_ _06364_ VDD VSS NAND4_X1
X_15489_ _06358_ _06365_ VDD VSS INV_X1
X_15490_ _06365_ _06359_ _06357_ _06363_ _06366_ VDD VSS NAND4_X1
X_15491_ _06354_ _06367_ VDD VSS INV_X1
X_15492_ _06355_ _06356_ _06368_ VDD VSS XNOR2_X2
X_15493_ u0.w\[2\]\[2\] _06359_ _06369_ VDD VSS NAND2_X1
X_15494_ net6 _06367_ _06368_ _06369_ _06370_ VDD VSS OR4_X1
X_15495_ _06361_ _06364_ _06366_ _06370_ _06371_ VDD VSS AND4_X1
X_15496_ _06360_ _06363_ _06372_ VDD VSS AND2_X1
X_15497_ _06226_ _06367_ _06365_ _06359_ _06373_ VDD VSS NOR4_X1
X_15498_ _06368_ _06372_ _06373_ _06374_ VDD VSS OAI21_X1
X_15499_ net16 _06367_ _06358_ _06362_ _06375_ VDD VSS NOR4_X1
X_15500_ net16 _06354_ _06369_ _06376_ VDD VSS NOR3_X1
X_15501_ _06368_ _06375_ _06376_ _06377_ VDD VSS OAI21_X1
X_15502_ _06353_ _06371_ _06374_ _06377_ _06378_ VDD VSS AND4_X2
X_15503_ _06378_ _06379_ VDD VSS BUF_X4
X_15504_ _06379_ _06380_ VDD VSS INV_X4
X_15505_ _06380_ _06381_ VDD VSS BUF_X8
X_15506_ _06381_ _06382_ VDD VSS BUF_X8
X_15507_ _06382_ _06383_ VDD VSS BUF_X4
X_15508_ _06383_ _14751_ VDD VSS BUF_X4
X_15509_ _06218_ net116 _06384_ VDD VSS OR2_X1
X_15510_ _06384_ _06385_ VDD VSS BUF_X4
X_15511_ u0.w\[0\]\[3\] _06386_ VDD VSS BUF_X4
X_15512_ u0.w\[1\]\[3\] _06387_ VDD VSS BUF_X4
X_15513_ _06386_ _06387_ _06388_ VDD VSS XNOR2_X2
X_15514_ net50 _06388_ _06389_ VDD VSS NAND2_X1
X_15515_ _06386_ _06387_ _06390_ VDD VSS XOR2_X2
X_15516_ net50 _06390_ _06391_ VDD VSS NAND2_X1
X_15517_ u0.w\[2\]\[3\] _06392_ VDD VSS BUF_X4
X_15518_ u0.tmp_w\[3\] _06393_ VDD VSS CLKBUF_X3
X_15519_ _06393_ u0.subword\[3\] _06394_ VDD VSS XNOR2_X1
X_15520_ _06392_ _06394_ _06395_ VDD VSS XNOR2_X1
X_15521_ _06389_ _06391_ _06395_ _06396_ VDD VSS MUX2_X1
X_15522_ _06396_ _06397_ VDD VSS BUF_X4
X_15523_ _06385_ _06397_ _06398_ VDD VSS NAND2_X2
X_15524_ _06398_ _06399_ VDD VSS INV_X4
X_15525_ _06399_ _06400_ VDD VSS CLKBUF_X3
X_15526_ _06400_ _00400_ VDD VSS BUF_X4
X_15527_ _06279_ _06401_ VDD VSS BUF_X4
X_15528_ _06401_ net133 _06402_ VDD VSS AND2_X1
X_15529_ u0.w\[0\]\[4\] _06403_ VDD VSS CLKBUF_X3
X_15530_ u0.w\[1\]\[4\] _06404_ VDD VSS CLKBUF_X3
X_15531_ _06403_ _06404_ _06405_ VDD VSS XNOR2_X2
X_15532_ u0.w\[2\]\[4\] _06406_ VDD VSS CLKBUF_X3
X_15533_ u0.tmp_w\[4\] _06407_ VDD VSS CLKBUF_X3
X_15534_ _06407_ u0.subword\[4\] _06408_ VDD VSS XNOR2_X1
X_15535_ _06406_ _06408_ _06409_ VDD VSS XNOR2_X1
X_15536_ _06405_ _06409_ _06410_ VDD VSS XNOR2_X2
X_15537_ _06402_ _06410_ _06267_ _06411_ VDD VSS AOI21_X4
X_15538_ _06411_ _06412_ VDD VSS INV_X4
X_15539_ _06412_ _06413_ VDD VSS BUF_X4
X_15540_ _06413_ _06414_ VDD VSS BUF_X4
X_15541_ _06414_ _00401_ VDD VSS CLKBUF_X3
X_15542_ net163 _06415_ VDD VSS INV_X1
X_15543_ u0.tmp_w\[5\] _06416_ VDD VSS CLKBUF_X3
X_15544_ u0.w\[0\]\[5\] _06417_ VDD VSS CLKBUF_X3
X_15545_ u0.w\[1\]\[5\] _06418_ VDD VSS CLKBUF_X3
X_15546_ _06417_ _06418_ _06419_ VDD VSS XOR2_X2
X_15547_ u0.w\[2\]\[5\] _06420_ VDD VSS BUF_X4
X_15548_ _06420_ u0.subword\[5\] _06421_ VDD VSS XNOR2_X1
X_15549_ _06419_ _06421_ _06422_ VDD VSS XNOR2_X2
X_15550_ _06416_ _06422_ _06423_ VDD VSS XNOR2_X1
X_15551_ _06415_ _06423_ _06266_ _06424_ VDD VSS MUX2_X1
X_15552_ _06424_ _06425_ VDD VSS BUF_X4
X_15553_ _06425_ _06426_ VDD VSS INV_X2
X_15554_ _06426_ _06427_ VDD VSS CLKBUF_X3
X_15555_ _06427_ _00402_ VDD VSS CLKBUF_X3
X_15556_ _06267_ _06428_ VDD VSS BUF_X4
X_15557_ _06428_ net180 _06429_ VDD VSS NOR2_X1
X_15558_ u0.tmp_w\[6\] _06430_ VDD VSS BUF_X2
X_15559_ u0.w\[0\]\[6\] _06431_ VDD VSS CLKBUF_X3
X_15560_ u0.w\[1\]\[6\] _06432_ VDD VSS CLKBUF_X3
X_15561_ _06431_ _06432_ _06433_ VDD VSS XOR2_X2
X_15562_ u0.w\[2\]\[6\] _06434_ VDD VSS BUF_X4
X_15563_ _06434_ u0.subword\[6\] _06435_ VDD VSS XNOR2_X1
X_15564_ _06433_ _06435_ _06436_ VDD VSS XNOR2_X2
X_15565_ _06430_ _06436_ _06437_ VDD VSS XNOR2_X2
X_15566_ _06429_ _06437_ _06428_ _06438_ VDD VSS AOI21_X4
X_15567_ _06438_ _00403_ VDD VSS BUF_X4
X_15568_ u0.w\[0\]\[7\] _06439_ VDD VSS CLKBUF_X3
X_15569_ u0.w\[1\]\[7\] _06440_ VDD VSS BUF_X4
X_15570_ _06439_ _06440_ _06441_ VDD VSS XOR2_X2
X_15571_ u0.w\[2\]\[7\] _06442_ VDD VSS CLKBUF_X3
X_15572_ _06442_ u0.subword\[7\] _06443_ VDD VSS XOR2_X1
X_15573_ _06441_ _06443_ _06444_ VDD VSS XNOR2_X1
X_15574_ u0.tmp_w\[7\] _06444_ _06445_ VDD VSS XNOR2_X1
X_15575_ net192 _06445_ _06267_ _06446_ VDD VSS MUX2_X1
X_15576_ _06446_ _06447_ VDD VSS CLKBUF_X3
X_15577_ _06447_ _06448_ VDD VSS CLKBUF_X3
X_15578_ _06448_ _00404_ VDD VSS CLKBUF_X3
X_15579_ _06239_ net203 _06449_ VDD VSS NOR2_X4
X_15580_ u0.w\[0\]\[8\] _06450_ VDD VSS BUF_X4
X_15581_ u0.w\[1\]\[8\] _06451_ VDD VSS BUF_X4
X_15582_ _06450_ _06451_ _06452_ VDD VSS XOR2_X2
X_15583_ _06339_ _06452_ _06453_ VDD VSS NOR2_X1
X_15584_ _06450_ _06451_ _06454_ VDD VSS XNOR2_X2
X_15585_ _06339_ _06454_ _06455_ VDD VSS NOR2_X1
X_15586_ u0.w\[2\]\[8\] _06456_ VDD VSS BUF_X4
X_15587_ u0.tmp_w\[8\] _06457_ VDD VSS BUF_X8
X_15588_ u0.subword\[8\] _06457_ _06458_ VDD VSS XNOR2_X2
X_15589_ _06458_ _06456_ _06459_ VDD VSS XNOR2_X2
X_15590_ _06453_ _06455_ _06459_ _06460_ VDD VSS MUX2_X2
X_15591_ _06460_ _06449_ _06461_ VDD VSS NOR2_X4
X_15592_ _06461_ _06462_ VDD VSS INV_X2
X_15593_ _06462_ _06463_ VDD VSS BUF_X4
X_15594_ _06463_ _14698_ VDD VSS BUF_X8
X_15595_ _06239_ net214 _06464_ VDD VSS NOR2_X1
X_15596_ u0.w\[0\]\[9\] _06465_ VDD VSS CLKBUF_X3
X_15597_ u0.w\[1\]\[9\] _06466_ VDD VSS CLKBUF_X3
X_15598_ _06465_ _06466_ _06467_ VDD VSS XNOR2_X2
X_15599_ _06218_ _06467_ _06468_ VDD VSS AND2_X1
X_15600_ _06339_ _06467_ _06469_ VDD VSS NOR2_X1
X_15601_ u0.w\[2\]\[9\] _06470_ VDD VSS CLKBUF_X3
X_15602_ u0.tmp_w\[9\] _06471_ VDD VSS BUF_X4
X_15603_ _06471_ u0.subword\[9\] _06472_ VDD VSS XNOR2_X2
X_15604_ _06472_ _06470_ _06473_ VDD VSS XNOR2_X2
X_15605_ _06468_ _06469_ _06473_ _06474_ VDD VSS MUX2_X2
X_15606_ _06474_ _06464_ _06475_ VDD VSS NOR2_X4
X_15607_ _06475_ _06476_ VDD VSS INV_X1
X_15608_ _06476_ _06477_ VDD VSS BUF_X4
X_15609_ _06477_ _14703_ VDD VSS BUF_X4
X_15610_ _06245_ net26 _06478_ VDD VSS NAND2_X1
X_15611_ u0.tmp_w\[10\] _06479_ VDD VSS CLKBUF_X3
X_15612_ u0.w\[0\]\[10\] _06480_ VDD VSS BUF_X8
X_15613_ _06480_ _00410_ _06481_ VDD VSS XOR2_X2
X_15614_ u0.w\[2\]\[10\] _06482_ VDD VSS BUF_X4
X_15615_ u0.w\[1\]\[10\] _06483_ VDD VSS CLKBUF_X3
X_15616_ _06482_ _06483_ _06484_ VDD VSS NOR2_X1
X_15617_ _06220_ _06479_ _06481_ _06484_ _06485_ VDD VSS NAND4_X1
X_15618_ _06483_ _06486_ VDD VSS INV_X1
X_15619_ _06216_ _06479_ _06487_ VDD VSS NOR2_X1
X_15620_ _06482_ _06486_ _06481_ _06487_ _06488_ VDD VSS NAND4_X1
X_15621_ _06482_ _06489_ VDD VSS INV_X1
X_15622_ _06489_ _06483_ _06481_ _06487_ _06490_ VDD VSS NAND4_X1
X_15623_ _06479_ _06491_ VDD VSS INV_X2
X_15624_ _06480_ _00410_ _06492_ VDD VSS XNOR2_X2
X_15625_ u0.w\[2\]\[10\] u0.w\[1\]\[10\] _06493_ VDD VSS NAND2_X1
X_15626_ _06216_ _06491_ _06492_ _06493_ _06494_ VDD VSS OR4_X1
X_15627_ _06485_ _06488_ _06490_ _06494_ _06495_ VDD VSS AND4_X1
X_15628_ _06484_ _06487_ _06496_ VDD VSS AND2_X1
X_15629_ _06226_ _06491_ _06489_ _06483_ _06497_ VDD VSS NOR4_X1
X_15630_ _06492_ _06496_ _06497_ _06498_ VDD VSS OAI21_X1
X_15631_ _06226_ _06491_ _06482_ _06486_ _06499_ VDD VSS NOR4_X1
X_15632_ net16 _06479_ _06493_ _06500_ VDD VSS NOR3_X1
X_15633_ _06492_ _06499_ _06500_ _06501_ VDD VSS OAI21_X1
X_15634_ _06478_ _06495_ _06498_ _06501_ _06502_ VDD VSS AND4_X4
X_15635_ _06502_ _06503_ VDD VSS BUF_X8
X_15636_ _06503_ _06504_ VDD VSS INV_X4
X_15637_ _06504_ _06505_ VDD VSS BUF_X8
X_15638_ _06505_ _06506_ VDD VSS BUF_X4
X_15639_ _06506_ _06507_ VDD VSS BUF_X4
X_15640_ _06507_ _14717_ VDD VSS BUF_X4
X_15641_ _06218_ net46 _06508_ VDD VSS OR2_X1
X_15642_ _06508_ _06509_ VDD VSS BUF_X8
X_15643_ u0.w\[0\]\[11\] _06510_ VDD VSS CLKBUF_X3
X_15644_ u0.w\[1\]\[11\] _06511_ VDD VSS BUF_X4
X_15645_ _06510_ _06511_ _06512_ VDD VSS XNOR2_X2
X_15646_ _06217_ _06512_ _06513_ VDD VSS NAND2_X1
X_15647_ _06510_ _06511_ _06514_ VDD VSS XOR2_X2
X_15648_ _06217_ _06514_ _06515_ VDD VSS NAND2_X1
X_15649_ u0.w\[2\]\[11\] _06516_ VDD VSS BUF_X4
X_15650_ u0.tmp_w\[11\] _06517_ VDD VSS BUF_X4
X_15651_ _06517_ u0.subword\[11\] _06518_ VDD VSS XNOR2_X1
X_15652_ _06516_ _06518_ _06519_ VDD VSS XNOR2_X1
X_15653_ _06513_ _06515_ _06519_ _06520_ VDD VSS MUX2_X2
X_15654_ _06520_ _06521_ VDD VSS BUF_X8
X_15655_ _06509_ _06521_ _06522_ VDD VSS NAND2_X4
X_15656_ _06522_ _06523_ VDD VSS INV_X4
X_15657_ _06523_ _06524_ VDD VSS BUF_X4
X_15658_ _06524_ _06525_ VDD VSS CLKBUF_X3
X_15659_ _06525_ _00385_ VDD VSS CLKBUF_X3
X_15660_ _06239_ net61 _06526_ VDD VSS NOR2_X1
X_15661_ u0.w\[0\]\[12\] _06527_ VDD VSS CLKBUF_X3
X_15662_ u0.w\[1\]\[12\] _06528_ VDD VSS CLKBUF_X3
X_15663_ _06527_ _06528_ _06529_ VDD VSS XNOR2_X2
X_15664_ _06218_ _06529_ _06530_ VDD VSS AND2_X1
X_15665_ _06245_ _06529_ _06531_ VDD VSS NOR2_X1
X_15666_ u0.w\[2\]\[12\] _06532_ VDD VSS BUF_X4
X_15667_ u0.tmp_w\[12\] _06533_ VDD VSS CLKBUF_X3
X_15668_ _06533_ u0.subword\[12\] _06534_ VDD VSS XNOR2_X1
X_15669_ _06532_ _06534_ _06535_ VDD VSS XNOR2_X1
X_15670_ _06530_ _06531_ _06535_ _06536_ VDD VSS MUX2_X2
X_15671_ _06526_ _06536_ _06537_ VDD VSS OR2_X1
X_15672_ _06537_ _06538_ VDD VSS INV_X2
X_15673_ _06538_ _06539_ VDD VSS CLKBUF_X3
X_15674_ _06539_ _06540_ VDD VSS BUF_X4
X_15675_ _06540_ _00386_ VDD VSS BUF_X4
X_15676_ net62 _06541_ VDD VSS INV_X1
X_15677_ u0.w\[0\]\[13\] _06542_ VDD VSS CLKBUF_X3
X_15678_ u0.w\[1\]\[13\] _06543_ VDD VSS CLKBUF_X3
X_15679_ _06542_ _06543_ _06544_ VDD VSS XNOR2_X2
X_15680_ u0.w\[2\]\[13\] _06545_ VDD VSS BUF_X4
X_15681_ u0.tmp_w\[13\] _06546_ VDD VSS BUF_X4
X_15682_ _06546_ u0.subword\[13\] _06547_ VDD VSS XOR2_X1
X_15683_ _06545_ _06547_ _06548_ VDD VSS XNOR2_X1
X_15684_ _06544_ _06548_ _06549_ VDD VSS XNOR2_X2
X_15685_ _06541_ _06549_ _06266_ _06550_ VDD VSS MUX2_X2
X_15686_ _06550_ _06551_ VDD VSS INV_X4
X_15687_ _06551_ _06552_ VDD VSS CLKBUF_X3
X_15688_ _06552_ _00387_ VDD VSS CLKBUF_X3
X_15689_ _06428_ net63 _06553_ VDD VSS NOR2_X1
X_15690_ u0.tmp_w\[14\] _06554_ VDD VSS CLKBUF_X3
X_15691_ u0.w\[0\]\[14\] _06555_ VDD VSS BUF_X4
X_15692_ u0.w\[1\]\[14\] _06556_ VDD VSS CLKBUF_X3
X_15693_ _06555_ _06556_ _06557_ VDD VSS XOR2_X2
X_15694_ u0.w\[2\]\[14\] _06558_ VDD VSS BUF_X4
X_15695_ _06558_ u0.subword\[14\] _06559_ VDD VSS XNOR2_X1
X_15696_ _06557_ _06559_ _06560_ VDD VSS XNOR2_X1
X_15697_ _06554_ _06560_ _06561_ VDD VSS XNOR2_X1
X_15698_ _06553_ _06561_ _06428_ _06562_ VDD VSS AOI21_X2
X_15699_ _06562_ _00388_ VDD VSS BUF_X4
X_15700_ u0.tmp_w\[15\] _06563_ VDD VSS BUF_X2
X_15701_ u0.w\[0\]\[15\] _06564_ VDD VSS BUF_X2
X_15702_ u0.w\[1\]\[15\] _06565_ VDD VSS CLKBUF_X3
X_15703_ _06564_ _06565_ _06566_ VDD VSS XOR2_X2
X_15704_ u0.w\[2\]\[15\] _06567_ VDD VSS BUF_X4
X_15705_ _06567_ u0.subword\[15\] _06568_ VDD VSS XNOR2_X1
X_15706_ _06566_ _06568_ _06569_ VDD VSS XNOR2_X2
X_15707_ _06563_ _06569_ _06570_ VDD VSS XNOR2_X1
X_15708_ _06266_ _06570_ _06571_ VDD VSS NAND2_X1
X_15709_ _06571_ net64 _06267_ _06572_ VDD VSS OAI21_X4
X_15710_ _06572_ _06573_ VDD VSS INV_X4
X_15711_ _06573_ _00389_ VDD VSS BUF_X4
X_15712_ u0.tmp_w\[22\] _06574_ VDD VSS CLKBUF_X3
X_15713_ u0.w\[0\]\[22\] _06575_ VDD VSS CLKBUF_X3
X_15714_ u0.w\[1\]\[22\] _06576_ VDD VSS BUF_X4
X_15715_ _06575_ _06576_ _06577_ VDD VSS XOR2_X2
X_15716_ u0.w\[2\]\[22\] _06578_ VDD VSS BUF_X4
X_15717_ _06578_ u0.subword\[22\] _06579_ VDD VSS XNOR2_X1
X_15718_ _06577_ _06579_ _06580_ VDD VSS XNOR2_X1
X_15719_ _06574_ _06580_ _06581_ VDD VSS XNOR2_X1
X_15720_ _06428_ _06581_ _06582_ VDD VSS NAND2_X1
X_15721_ _06582_ net73 _06428_ _06583_ VDD VSS OAI21_X2
X_15722_ _06583_ _06584_ VDD VSS INV_X1
X_15723_ _06584_ _06585_ VDD VSS CLKBUF_X3
X_15724_ _06585_ _00393_ VDD VSS CLKBUF_X3
X_15725_ u0.tmp_w\[23\] _06586_ VDD VSS CLKBUF_X3
X_15726_ u0.w\[0\]\[23\] _06587_ VDD VSS CLKBUF_X3
X_15727_ u0.w\[1\]\[23\] _06588_ VDD VSS BUF_X4
X_15728_ _06587_ _06588_ _06589_ VDD VSS XOR2_X2
X_15729_ u0.w\[2\]\[23\] _06590_ VDD VSS BUF_X4
X_15730_ _06590_ u0.subword\[23\] _06591_ VDD VSS XNOR2_X1
X_15731_ _06589_ _06591_ _06592_ VDD VSS XNOR2_X2
X_15732_ _06586_ _06592_ _06593_ VDD VSS XNOR2_X1
X_15733_ _06267_ _06593_ _06594_ VDD VSS NAND2_X1
X_15734_ _06594_ net74 _06267_ _06595_ VDD VSS OAI21_X2
X_15735_ _06595_ _06596_ VDD VSS INV_X2
X_15736_ _06596_ _00394_ VDD VSS BUF_X4
X_15737_ _06279_ net75 _06597_ VDD VSS AND2_X2
X_15738_ u0.w\[0\]\[24\] _06598_ VDD VSS CLKBUF_X3
X_15739_ _06598_ u0.subword\[24\] _06599_ VDD VSS XNOR2_X2
X_15740_ _06220_ _06599_ _06600_ VDD VSS AND2_X1
X_15741_ _06245_ _06599_ _06601_ VDD VSS NOR2_X1
X_15742_ u0.tmp_w\[24\] _06602_ VDD VSS BUF_X4
X_15743_ _06602_ u0.r0.out\[24\] _06603_ VDD VSS XNOR2_X2
Xrebuffer292 _15236_ net908 VDD VSS BUF_X1
Xrebuffer290 u0.w\[1\]\[24\] net883 VDD VSS BUF_X1
X_15746_ u0.w\[2\]\[24\] u0.w\[1\]\[24\] _06606_ VDD VSS XNOR2_X2
X_15747_ _06603_ _06606_ _06607_ VDD VSS XNOR2_X2
X_15748_ _06600_ _06601_ _06607_ _06608_ VDD VSS MUX2_X2
X_15749_ _06608_ _06597_ _06609_ VDD VSS OR2_X4
Xclone276 _06597_ net742 net741 VDD VSS OR2_X2
X_15751_ _06609_ _06611_ VDD VSS INV_X16
X_15753_ _06611_ _14766_ VDD VSS BUF_X32
X_15754_ _06279_ net76 _06613_ VDD VSS NAND2_X2
X_15755_ u0.w\[0\]\[25\] _06614_ VDD VSS BUF_X4
X_15756_ _06614_ u0.subword\[25\] _06615_ VDD VSS XNOR2_X2
X_15757_ _06218_ _06615_ _06616_ VDD VSS NAND2_X1
X_15758_ _06614_ u0.subword\[25\] _06617_ VDD VSS XOR2_X2
X_15759_ _06218_ _06617_ _06618_ VDD VSS NAND2_X1
X_15760_ u0.tmp_w\[25\] _06619_ VDD VSS BUF_X4
X_15761_ _06619_ u0.r0.out\[25\] _06620_ VDD VSS XNOR2_X2
Xrebuffer273 u0.w\[2\]\[25\] net738 VDD VSS BUF_X1
Xrebuffer570 u0.w\[1\]\[25\] net1184 VDD VSS BUF_X1
X_15764_ u0.w\[2\]\[25\] u0.w\[1\]\[25\] _06623_ VDD VSS XNOR2_X2
X_15765_ _06623_ _06620_ _06624_ VDD VSS XNOR2_X2
X_15766_ _06616_ _06618_ _06624_ _06625_ VDD VSS MUX2_X2
X_15767_ _06625_ _06613_ _06626_ VDD VSS NAND2_X4
X_15768_ _06626_ _06627_ VDD VSS INV_X2
X_15769_ _06627_ _06628_ VDD VSS BUF_X8
X_15770_ _06628_ _14771_ VDD VSS BUF_X16
X_15771_ net18 net77 _06629_ VDD VSS NAND2_X2
X_15772_ u0.w\[0\]\[26\] _06630_ VDD VSS BUF_X4
X_15773_ _06630_ u0.subword\[26\] _06631_ VDD VSS XNOR2_X2
X_15774_ net50 _06631_ _06632_ VDD VSS NAND2_X1
X_15775_ _06630_ u0.subword\[26\] _06633_ VDD VSS XOR2_X2
X_15776_ net50 _06633_ _06634_ VDD VSS NAND2_X1
X_15777_ u0.tmp_w\[26\] _06635_ VDD VSS CLKBUF_X3
X_15778_ _06635_ u0.r0.out\[26\] _06636_ VDD VSS XNOR2_X1
X_15779_ u0.w\[2\]\[26\] _06637_ VDD VSS CLKBUF_X3
X_15780_ u0.w\[1\]\[26\] _06638_ VDD VSS BUF_X4
X_15781_ _06638_ _06637_ _06639_ VDD VSS XNOR2_X2
X_15782_ _06636_ _06639_ _06640_ VDD VSS XNOR2_X2
X_15783_ _06632_ _06634_ _06640_ _06641_ VDD VSS MUX2_X2
X_15784_ _06629_ _06641_ _06642_ VDD VSS NAND2_X1
X_15785_ _06642_ _06643_ VDD VSS INV_X2
X_15786_ _06643_ _06644_ VDD VSS BUF_X4
X_15787_ _06644_ _06645_ VDD VSS CLKBUF_X3
X_15788_ _06645_ _14785_ VDD VSS BUF_X4
X_15789_ key[27] _06646_ VDD VSS BUF_X2
X_15790_ net18 _06646_ _06647_ VDD VSS AND2_X4
X_15791_ _06647_ _06648_ VDD VSS BUF_X8
X_15792_ u0.w\[0\]\[27\] _06649_ VDD VSS BUF_X4
X_15793_ _06649_ u0.subword\[27\] _06650_ VDD VSS XOR2_X2
X_15794_ net6 _06650_ _06651_ VDD VSS NOR2_X1
X_15795_ _06649_ u0.subword\[27\] _06652_ VDD VSS XNOR2_X2
X_15796_ net6 _06652_ _06653_ VDD VSS NOR2_X1
X_15797_ u0.tmp_w\[27\] _06654_ VDD VSS CLKBUF_X3
X_15798_ _06654_ u0.r0.out\[27\] _06655_ VDD VSS XNOR2_X1
X_15799_ u0.w\[2\]\[27\] _06656_ VDD VSS BUF_X2
X_15800_ u0.w\[1\]\[27\] _06657_ VDD VSS CLKBUF_X3
X_15801_ _06657_ _06656_ _06658_ VDD VSS XNOR2_X2
X_15802_ _06655_ _06658_ _06659_ VDD VSS XNOR2_X2
X_15803_ _06651_ _06653_ _06659_ _06660_ VDD VSS MUX2_X1
X_15804_ _06660_ _06661_ VDD VSS BUF_X4
X_15805_ _06648_ _06661_ _06662_ VDD VSS NOR2_X4
X_15806_ _06662_ _06663_ VDD VSS INV_X4
X_15807_ _06663_ _06664_ VDD VSS BUF_X4
X_15808_ _06664_ _00395_ VDD VSS BUF_X4
X_15809_ _06401_ net78 _06665_ VDD VSS AND2_X1
X_15810_ u0.w\[0\]\[28\] _06666_ VDD VSS CLKBUF_X3
X_15811_ _06666_ u0.subword\[28\] _06667_ VDD VSS XNOR2_X2
X_15812_ _06239_ _06667_ _06668_ VDD VSS AND2_X1
X_15813_ _06279_ _06667_ _06669_ VDD VSS NOR2_X1
X_15814_ u0.tmp_w\[28\] _06670_ VDD VSS CLKBUF_X3
X_15815_ _06670_ u0.r0.out\[28\] _06671_ VDD VSS XNOR2_X1
X_15816_ u0.w\[2\]\[28\] _06672_ VDD VSS CLKBUF_X3
X_15817_ u0.w\[1\]\[28\] _06673_ VDD VSS BUF_X2
X_15818_ _06672_ _06673_ _06674_ VDD VSS XNOR2_X2
X_15819_ _06671_ _06674_ _06675_ VDD VSS XNOR2_X1
X_15820_ _06668_ _06669_ _06675_ _06676_ VDD VSS MUX2_X2
X_15821_ _06665_ _06676_ _06677_ VDD VSS NOR2_X4
X_15822_ _06677_ _06678_ VDD VSS INV_X2
X_15823_ _06678_ _06679_ VDD VSS BUF_X4
X_15824_ _06679_ _06680_ VDD VSS BUF_X4
X_15825_ _06680_ _06681_ VDD VSS BUF_X4
X_15826_ _06681_ _00396_ VDD VSS CLKBUF_X3
X_15827_ _06279_ net79 _06682_ VDD VSS AND2_X1
X_15828_ u0.w\[0\]\[29\] _06683_ VDD VSS CLKBUF_X3
X_15829_ _06683_ u0.subword\[29\] _06684_ VDD VSS XOR2_X2
X_15830_ u0.tmp_w\[29\] _06685_ VDD VSS CLKBUF_X3
X_15831_ _06685_ u0.r0.out\[29\] _06686_ VDD VSS XNOR2_X1
X_15832_ u0.w\[2\]\[29\] _06687_ VDD VSS CLKBUF_X3
X_15833_ u0.w\[1\]\[29\] _06688_ VDD VSS CLKBUF_X3
X_15834_ _06687_ _06688_ _06689_ VDD VSS XNOR2_X2
X_15835_ _06686_ _06689_ _06690_ VDD VSS XNOR2_X1
X_15836_ _06684_ _06690_ _06691_ VDD VSS XNOR2_X2
X_15837_ _06682_ _06691_ _06266_ _06692_ VDD VSS AOI21_X4
X_15838_ _06692_ _06693_ VDD VSS INV_X1
X_15839_ _06693_ _06694_ VDD VSS BUF_X4
X_15840_ _06694_ _06695_ VDD VSS CLKBUF_X3
X_15841_ _06695_ _00397_ VDD VSS CLKBUF_X3
X_15842_ u0.w\[2\]\[30\] _06696_ VDD VSS CLKBUF_X3
X_15843_ u0.w\[1\]\[30\] _06697_ VDD VSS CLKBUF_X3
X_15844_ _06696_ _06697_ _06698_ VDD VSS XOR2_X2
X_15845_ u0.tmp_w\[30\] _06699_ VDD VSS BUF_X2
X_15846_ _06699_ u0.r0.out\[30\] _06700_ VDD VSS XNOR2_X1
X_15847_ u0.w\[0\]\[30\] _06701_ VDD VSS CLKBUF_X3
X_15848_ _06701_ u0.subword\[30\] _06702_ VDD VSS XNOR2_X2
X_15849_ _06700_ _06702_ _06703_ VDD VSS XNOR2_X1
X_15850_ _06698_ _06703_ _06704_ VDD VSS XNOR2_X1
X_15851_ net81 _06704_ _06428_ _06705_ VDD VSS MUX2_X1
X_15852_ _06705_ _00398_ VDD VSS CLKBUF_X3
X_15853_ u0.w\[0\]\[31\] _06706_ VDD VSS CLKBUF_X3
X_15854_ _06706_ u0.subword\[31\] _06707_ VDD VSS XNOR2_X2
X_15855_ u0.tmp_w\[31\] _06708_ VDD VSS CLKBUF_X3
X_15856_ _06708_ u0.r0.out\[31\] _06709_ VDD VSS XNOR2_X1
X_15857_ u0.w\[2\]\[31\] _06710_ VDD VSS CLKBUF_X3
X_15858_ u0.w\[1\]\[31\] _06711_ VDD VSS BUF_X2
X_15859_ _06710_ _06711_ _06712_ VDD VSS XNOR2_X2
X_15860_ _06709_ _06712_ _06713_ VDD VSS XNOR2_X1
X_15861_ _06707_ _06713_ _06714_ VDD VSS XNOR2_X1
X_15862_ _06428_ _06714_ _06715_ VDD VSS NAND2_X1
X_15863_ _06715_ net82 _06428_ _06716_ VDD VSS OAI21_X4
X_15864_ _06716_ _06717_ VDD VSS INV_X1
X_15865_ _06717_ _00399_ VDD VSS CLKBUF_X3
X_15866_ _00411_ _06327_ _06718_ VDD VSS XNOR2_X2
X_15867_ _06330_ _06718_ _06719_ VDD VSS XNOR2_X1
X_15868_ _06428_ _06720_ VDD VSS BUF_X4
X_15869_ _06720_ _06721_ VDD VSS BUF_X4
X_15870_ net89 _06719_ _06721_ _00353_ VDD VSS MUX2_X1
X_15871_ _00412_ _06344_ _06722_ VDD VSS XNOR2_X2
X_15872_ _06346_ _06722_ _06723_ VDD VSS XNOR2_X1
X_15873_ net94 _06723_ _06721_ _00364_ VDD VSS MUX2_X1
X_15874_ _06359_ _06368_ _06724_ VDD VSS XNOR2_X2
X_15875_ _06358_ _06724_ _06725_ VDD VSS XNOR2_X1
X_15876_ _06720_ _06726_ VDD VSS BUF_X4
X_15877_ net105 _06725_ _06726_ _00375_ VDD VSS MUX2_X1
X_15878_ _00413_ _06388_ _06727_ VDD VSS XNOR2_X1
X_15879_ _06392_ _06727_ _06728_ VDD VSS XNOR2_X1
X_15880_ net110 _06728_ _06726_ _00378_ VDD VSS MUX2_X1
X_15881_ _00414_ _06405_ _06729_ VDD VSS XNOR2_X1
X_15882_ _06406_ _06729_ _06730_ VDD VSS XNOR2_X1
X_15883_ net111 _06730_ _06726_ _00379_ VDD VSS MUX2_X1
X_15884_ _00415_ _06419_ _06731_ VDD VSS XOR2_X2
X_15885_ _06420_ _06731_ _06732_ VDD VSS XNOR2_X1
X_15886_ net112 _06732_ _06726_ _00380_ VDD VSS MUX2_X1
X_15887_ _00416_ _06433_ _06733_ VDD VSS XOR2_X2
X_15888_ _06434_ _06733_ _06734_ VDD VSS XNOR2_X1
X_15889_ net113 _06734_ _06726_ _00381_ VDD VSS MUX2_X1
X_15890_ _00417_ _06441_ _06735_ VDD VSS XOR2_X2
X_15891_ _06442_ _06735_ _06736_ VDD VSS XNOR2_X1
X_15892_ net114 _06736_ _06726_ _00382_ VDD VSS MUX2_X1
X_15893_ _00418_ _06454_ _06737_ VDD VSS XNOR2_X2
X_15894_ _06456_ _06737_ _06738_ VDD VSS XNOR2_X1
X_15895_ net117 _06738_ _06726_ _00383_ VDD VSS MUX2_X1
X_15896_ _00419_ _06467_ _06739_ VDD VSS XNOR2_X1
X_15897_ _06470_ _06739_ _06740_ VDD VSS XNOR2_X1
X_15898_ net118 _06740_ _06726_ _00384_ VDD VSS MUX2_X1
X_15899_ _06483_ _06492_ _06741_ VDD VSS XNOR2_X1
X_15900_ _06482_ _06741_ _06742_ VDD VSS XNOR2_X1
X_15901_ net119 _06742_ _06726_ _00354_ VDD VSS MUX2_X1
X_15902_ _00420_ _06512_ _06743_ VDD VSS XNOR2_X1
X_15903_ _06516_ _06743_ _06744_ VDD VSS XNOR2_X1
X_15904_ net120 _06744_ _06726_ _00355_ VDD VSS MUX2_X1
X_15905_ _00421_ _06529_ _06745_ VDD VSS XNOR2_X1
X_15906_ _06532_ _06745_ _06746_ VDD VSS XNOR2_X1
X_15907_ _06720_ _06747_ VDD VSS BUF_X4
X_15908_ net121 _06746_ _06747_ _00356_ VDD VSS MUX2_X1
X_15909_ _00422_ _06544_ _06748_ VDD VSS XNOR2_X1
X_15910_ _06545_ _06748_ _06749_ VDD VSS XNOR2_X1
X_15911_ net122 _06749_ _06747_ _00357_ VDD VSS MUX2_X1
X_15912_ _00423_ _06557_ _06750_ VDD VSS XOR2_X2
X_15913_ _06558_ _06750_ _06751_ VDD VSS XNOR2_X1
X_15914_ net124 _06751_ _06747_ _00358_ VDD VSS MUX2_X1
X_15915_ _00424_ _06566_ _06752_ VDD VSS XOR2_X2
X_15916_ _06567_ _06752_ _06753_ VDD VSS XNOR2_X1
X_15917_ net129 _06753_ _06747_ _00359_ VDD VSS MUX2_X1
X_15918_ _00425_ _06243_ _06754_ VDD VSS XNOR2_X1
X_15919_ _06247_ _06754_ _06755_ VDD VSS XNOR2_X1
X_15920_ net130 _06755_ _06747_ _00360_ VDD VSS MUX2_X1
X_15921_ _00426_ _06257_ _06756_ VDD VSS XNOR2_X1
X_15922_ _06260_ _06756_ _06757_ VDD VSS XNOR2_X1
X_15923_ net132 _06757_ _06747_ _00361_ VDD VSS MUX2_X1
X_15924_ _06303_ _06309_ _06758_ VDD VSS XNOR2_X1
X_15925_ _06306_ _06758_ _06759_ VDD VSS XNOR2_X1
X_15926_ net140 _06759_ _06747_ _00362_ VDD VSS MUX2_X1
X_15927_ _00427_ _06223_ _06760_ VDD VSS XNOR2_X1
X_15928_ _06228_ _06760_ _06761_ VDD VSS XNOR2_X1
X_15929_ net145 _06761_ _06747_ _00363_ VDD VSS MUX2_X1
X_15930_ _00428_ _06283_ _06762_ VDD VSS XNOR2_X2
X_15931_ _06284_ _06762_ _06763_ VDD VSS XNOR2_X1
X_15932_ net146 _06763_ _06747_ _00365_ VDD VSS MUX2_X1
X_15933_ _00429_ _06271_ _06764_ VDD VSS XOR2_X2
X_15934_ _06272_ _06764_ _06765_ VDD VSS XNOR2_X1
X_15935_ net149 _06765_ _06747_ _00366_ VDD VSS MUX2_X1
X_15936_ _00430_ _06577_ _06766_ VDD VSS XOR2_X2
X_15937_ _06578_ _06766_ _06767_ VDD VSS XNOR2_X1
X_15938_ _06720_ _06768_ VDD VSS BUF_X4
X_15939_ net150 _06767_ _06768_ _00367_ VDD VSS MUX2_X1
X_15940_ _00431_ _06589_ _06769_ VDD VSS XOR2_X2
X_15941_ _06590_ _06769_ _06770_ VDD VSS XNOR2_X1
X_15942_ net151 _06770_ _06768_ _00368_ VDD VSS MUX2_X1
X_15943_ _06401_ _06771_ VDD VSS BUF_X4
X_15944_ _06771_ _06772_ VDD VSS BUF_X4
X_15945_ _06772_ net152 _06773_ VDD VSS NAND2_X1
X_15946_ _00432_ _06599_ _06774_ VDD VSS XNOR2_X2
X_15947_ net731 _06774_ _06775_ VDD VSS XNOR2_X1
X_15948_ _06773_ _06775_ _06772_ _00369_ VDD VSS OAI21_X1
X_15949_ _06771_ _06776_ VDD VSS BUF_X4
X_15950_ _06776_ net154 _06777_ VDD VSS NAND2_X1
X_15951_ _00433_ _06615_ _06778_ VDD VSS XNOR2_X2
X_15952_ net1068 _06778_ _06779_ VDD VSS XNOR2_X1
X_15953_ _06777_ _06779_ _06772_ _00370_ VDD VSS OAI21_X1
X_15954_ _06776_ net161 _06780_ VDD VSS NAND2_X1
X_15955_ _00434_ _06631_ _06781_ VDD VSS XNOR2_X2
X_15956_ _06639_ _06781_ _06782_ VDD VSS XNOR2_X1
X_15957_ _06780_ _06782_ _06772_ _00371_ VDD VSS OAI21_X1
X_15958_ _06776_ net162 _06783_ VDD VSS NAND2_X1
X_15959_ _00435_ _06652_ _06784_ VDD VSS XNOR2_X2
X_15960_ _06658_ _06784_ _06785_ VDD VSS XNOR2_X1
X_15961_ _06783_ _06785_ _06772_ _00372_ VDD VSS OAI21_X1
X_15962_ _06776_ net164 _06786_ VDD VSS NAND2_X1
X_15963_ _00436_ _06667_ _06787_ VDD VSS XNOR2_X2
X_15964_ _06674_ _06787_ _06788_ VDD VSS XNOR2_X1
X_15965_ _06786_ _06788_ _06772_ _00373_ VDD VSS OAI21_X1
X_15966_ _06776_ net165 _06789_ VDD VSS NAND2_X1
X_15967_ _00437_ _06684_ _06790_ VDD VSS XOR2_X2
X_15968_ _06689_ _06790_ _06791_ VDD VSS XNOR2_X1
X_15969_ _06789_ _06791_ _06772_ _00374_ VDD VSS OAI21_X1
X_15970_ _00438_ _06702_ _06792_ VDD VSS XNOR2_X2
X_15971_ _06698_ _06792_ _06793_ VDD VSS XNOR2_X1
X_15972_ net166 _06793_ _06768_ _00376_ VDD VSS MUX2_X1
X_15973_ _00439_ _06707_ _06794_ VDD VSS XNOR2_X2
X_15974_ _06711_ _06794_ _06795_ VDD VSS XNOR2_X1
X_15975_ _06710_ _06795_ _06796_ VDD VSS XOR2_X1
X_15976_ net167 _06796_ _06768_ _00377_ VDD VSS MUX2_X1
X_15977_ _06720_ _06797_ VDD VSS BUF_X4
X_15978_ _06797_ net172 _06798_ VDD VSS NOR2_X1
X_15979_ _06720_ _06799_ VDD VSS BUF_X4
X_15980_ _06799_ _06800_ VDD VSS BUF_X4
X_15981_ _06798_ _06718_ _06800_ _00321_ VDD VSS AOI21_X1
X_15982_ _06797_ net173 _06801_ VDD VSS NOR2_X1
X_15983_ _06801_ _06722_ _06800_ _00332_ VDD VSS AOI21_X1
X_15984_ _06797_ net174 _06802_ VDD VSS NOR2_X1
X_15985_ _06802_ _06724_ _06800_ _00343_ VDD VSS AOI21_X1
X_15986_ _06797_ net175 _06803_ VDD VSS NOR2_X1
X_15987_ _06803_ _06727_ _06800_ _00346_ VDD VSS AOI21_X1
X_15988_ _06797_ net178 _06804_ VDD VSS NOR2_X1
X_15989_ _06804_ _06729_ _06800_ _00347_ VDD VSS AOI21_X1
X_15990_ _06720_ _06805_ VDD VSS BUF_X4
X_15991_ _06805_ net179 _06806_ VDD VSS NOR2_X1
X_15992_ _06806_ _06731_ _06800_ _00348_ VDD VSS AOI21_X1
X_15993_ _06805_ net182 _06807_ VDD VSS NOR2_X1
X_15994_ _06807_ _06733_ _06800_ _00349_ VDD VSS AOI21_X1
X_15995_ _06805_ net183 _06808_ VDD VSS NOR2_X1
X_15996_ _06808_ _06735_ _06800_ _00350_ VDD VSS AOI21_X1
X_15997_ _06805_ net184 _06809_ VDD VSS NOR2_X1
X_15998_ _06809_ _06737_ _06800_ _00351_ VDD VSS AOI21_X1
X_15999_ _06805_ net185 _06810_ VDD VSS NOR2_X1
X_16000_ _06810_ _06739_ _06800_ _00352_ VDD VSS AOI21_X1
X_16001_ _06805_ net186 _06811_ VDD VSS NOR2_X1
X_16002_ _06799_ _06812_ VDD VSS BUF_X4
X_16003_ _06811_ _06741_ _06812_ _00322_ VDD VSS AOI21_X1
X_16004_ _06805_ net187 _06813_ VDD VSS NOR2_X1
X_16005_ _06813_ _06743_ _06812_ _00323_ VDD VSS AOI21_X1
X_16006_ _06805_ net188 _06814_ VDD VSS NOR2_X1
X_16007_ _06814_ _06745_ _06812_ _00324_ VDD VSS AOI21_X1
X_16008_ _06805_ net189 _06815_ VDD VSS NOR2_X1
X_16009_ _06815_ _06748_ _06812_ _00325_ VDD VSS AOI21_X1
X_16010_ _06805_ net190 _06816_ VDD VSS NOR2_X1
X_16011_ _06816_ _06750_ _06812_ _00326_ VDD VSS AOI21_X1
X_16012_ _06720_ _06817_ VDD VSS BUF_X4
X_16013_ _06817_ net191 _06818_ VDD VSS NOR2_X1
X_16014_ _06818_ _06752_ _06812_ _00327_ VDD VSS AOI21_X1
X_16015_ _06817_ net193 _06819_ VDD VSS NOR2_X1
X_16016_ _06819_ _06754_ _06812_ _00328_ VDD VSS AOI21_X1
X_16017_ _06817_ net194 _06820_ VDD VSS NOR2_X1
X_16018_ _06820_ _06756_ _06812_ _00329_ VDD VSS AOI21_X1
X_16019_ net195 _06758_ _06768_ _00330_ VDD VSS MUX2_X1
X_16020_ _06817_ net196 _06821_ VDD VSS NOR2_X1
X_16021_ _06821_ _06760_ _06812_ _00331_ VDD VSS AOI21_X1
X_16022_ _06817_ net197 _06822_ VDD VSS NOR2_X1
X_16023_ _06822_ _06762_ _06812_ _00333_ VDD VSS AOI21_X1
X_16024_ _06817_ net198 _06823_ VDD VSS NOR2_X1
X_16025_ _06799_ _06824_ VDD VSS CLKBUF_X3
X_16026_ _06823_ _06764_ _06824_ _00334_ VDD VSS AOI21_X1
X_16027_ _06817_ net199 _06825_ VDD VSS NOR2_X1
X_16028_ _06825_ _06766_ _06824_ _00335_ VDD VSS AOI21_X1
X_16029_ _06817_ net200 _06826_ VDD VSS NOR2_X1
X_16030_ _06826_ _06769_ _06824_ _00336_ VDD VSS AOI21_X1
X_16031_ u0.w\[1\]\[24\] _06774_ _06827_ VDD VSS XNOR2_X1
X_16032_ net201 _06827_ _06768_ _00337_ VDD VSS MUX2_X1
X_16033_ u0.w\[1\]\[25\] _06778_ _06828_ VDD VSS XNOR2_X1
X_16034_ net202 _06828_ _06768_ _00338_ VDD VSS MUX2_X1
X_16035_ _06638_ _06781_ _06829_ VDD VSS XNOR2_X1
X_16036_ net204 _06829_ _06768_ _00339_ VDD VSS MUX2_X1
X_16037_ _06657_ _06784_ _06830_ VDD VSS XNOR2_X1
X_16038_ net205 _06830_ _06768_ _00340_ VDD VSS MUX2_X1
X_16039_ _06673_ _06787_ _06831_ VDD VSS XNOR2_X1
X_16040_ net206 _06831_ _06768_ _00341_ VDD VSS MUX2_X1
X_16041_ _06688_ _06790_ _06832_ VDD VSS XNOR2_X1
X_16042_ _06720_ _06833_ VDD VSS BUF_X4
X_16043_ net207 _06832_ _06833_ _00342_ VDD VSS MUX2_X1
X_16044_ _06697_ _06792_ _06834_ VDD VSS XNOR2_X1
X_16045_ net208 _06834_ _06833_ _00344_ VDD VSS MUX2_X1
X_16046_ net209 _06795_ _06833_ _00345_ VDD VSS MUX2_X1
X_16047_ _06325_ net597 _06835_ VDD VSS XOR2_X1
X_16048_ net210 _06835_ _06833_ _00289_ VDD VSS MUX2_X1
X_16049_ _06340_ u0.subword\[1\] _06836_ VDD VSS XOR2_X1
X_16050_ net211 _06836_ _06833_ _00300_ VDD VSS MUX2_X1
X_16051_ _06355_ u0.subword\[2\] _06837_ VDD VSS XOR2_X1
X_16052_ net212 _06837_ _06833_ _00311_ VDD VSS MUX2_X1
X_16053_ _06386_ u0.subword\[3\] _06838_ VDD VSS XOR2_X1
X_16054_ net213 _06838_ _06833_ _00314_ VDD VSS MUX2_X1
X_16055_ _06403_ u0.subword\[4\] _06839_ VDD VSS XOR2_X1
X_16056_ net10 _06839_ _06833_ _00315_ VDD VSS MUX2_X1
X_16057_ _06417_ u0.subword\[5\] _06840_ VDD VSS XOR2_X1
X_16058_ net11 _06840_ _06833_ _00316_ VDD VSS MUX2_X1
X_16059_ _06431_ u0.subword\[6\] _06841_ VDD VSS XOR2_X1
X_16060_ net17 _06841_ _06833_ _00317_ VDD VSS MUX2_X1
X_16061_ _06439_ u0.subword\[7\] _06842_ VDD VSS XOR2_X1
X_16062_ _06720_ _06843_ VDD VSS BUF_X4
X_16063_ net19 _06842_ _06843_ _00318_ VDD VSS MUX2_X1
X_16064_ _06450_ net668 _06844_ VDD VSS XOR2_X1
X_16065_ net20 _06844_ _06843_ _00319_ VDD VSS MUX2_X1
X_16066_ _06465_ u0.subword\[9\] _06845_ VDD VSS XOR2_X1
X_16067_ net21 _06845_ _06843_ _00320_ VDD VSS MUX2_X1
X_16068_ _06480_ u0.subword\[10\] _06846_ VDD VSS XOR2_X1
X_16069_ net22 _06846_ _06843_ _00290_ VDD VSS MUX2_X1
X_16070_ _06510_ u0.subword\[11\] _06847_ VDD VSS XOR2_X1
X_16071_ net23 _06847_ _06843_ _00291_ VDD VSS MUX2_X1
X_16072_ _06527_ u0.subword\[12\] _06848_ VDD VSS XOR2_X1
X_16073_ net24 _06848_ _06843_ _00292_ VDD VSS MUX2_X1
X_16074_ _06542_ u0.subword\[13\] _06849_ VDD VSS XOR2_X1
X_16075_ net25 _06849_ _06843_ _00293_ VDD VSS MUX2_X1
X_16076_ _06555_ u0.subword\[14\] _06850_ VDD VSS XOR2_X1
X_16077_ net30 _06850_ _06843_ _00294_ VDD VSS MUX2_X1
X_16078_ _06564_ u0.subword\[15\] _06851_ VDD VSS XOR2_X1
X_16079_ net31 _06851_ _06843_ _00295_ VDD VSS MUX2_X1
X_16080_ _06241_ u0.subword\[16\] _06852_ VDD VSS XOR2_X1
X_16081_ net33 _06852_ _06843_ _00296_ VDD VSS MUX2_X1
X_16082_ _06255_ u0.subword\[17\] _06853_ VDD VSS XOR2_X1
X_16083_ net34 _06853_ _06799_ _00297_ VDD VSS MUX2_X1
X_16084_ _06296_ u0.subword\[18\] _06854_ VDD VSS XOR2_X1
X_16085_ net35 _06854_ _06799_ _00298_ VDD VSS MUX2_X1
X_16086_ _06221_ u0.subword\[19\] _06855_ VDD VSS XOR2_X1
X_16087_ net38 _06855_ _06799_ _00299_ VDD VSS MUX2_X1
X_16088_ _06281_ u0.subword\[20\] _06856_ VDD VSS XOR2_X1
X_16089_ net40 _06856_ _06799_ _00301_ VDD VSS MUX2_X1
X_16090_ _06269_ u0.subword\[21\] _06857_ VDD VSS XOR2_X1
X_16091_ net41 _06857_ _06799_ _00302_ VDD VSS MUX2_X1
X_16092_ _06575_ u0.subword\[22\] _06858_ VDD VSS XOR2_X1
X_16093_ net44 _06858_ _06799_ _00303_ VDD VSS MUX2_X1
X_16094_ _06587_ u0.subword\[23\] _06859_ VDD VSS XOR2_X1
X_16095_ net45 _06859_ _06799_ _00304_ VDD VSS MUX2_X1
X_16096_ _06817_ net47 _06860_ VDD VSS NOR2_X1
X_16097_ _06860_ _06774_ _06824_ _00305_ VDD VSS AOI21_X1
X_16098_ _06817_ net48 _06861_ VDD VSS NOR2_X1
X_16099_ _06861_ _06778_ _06824_ _00306_ VDD VSS AOI21_X1
X_16100_ _06721_ net52 _06862_ VDD VSS NOR2_X1
X_16101_ _06862_ _06781_ _06824_ _00307_ VDD VSS AOI21_X1
X_16102_ _06721_ net53 _06863_ VDD VSS NOR2_X1
X_16103_ _06863_ _06784_ _06824_ _00308_ VDD VSS AOI21_X1
X_16104_ _06721_ net54 _06864_ VDD VSS NOR2_X1
X_16105_ _06864_ _06787_ _06824_ _00309_ VDD VSS AOI21_X1
X_16106_ _06721_ net55 _06865_ VDD VSS NOR2_X1
X_16107_ _06865_ _06790_ _06824_ _00310_ VDD VSS AOI21_X1
X_16108_ _06721_ net59 _06866_ VDD VSS NOR2_X1
X_16109_ _06866_ _06792_ _06824_ _00312_ VDD VSS AOI21_X1
X_16110_ _06721_ net60 _06867_ VDD VSS NOR2_X1
X_16111_ _06867_ _06794_ _06797_ _00313_ VDD VSS AOI21_X1
X_16112_ _06265_ _06868_ VDD VSS BUF_X8
X_16113_ _06868_ _14658_ VDD VSS BUF_X16
X_16114_ _06320_ _06869_ VDD VSS BUF_X16
X_16115_ _06869_ _06870_ VDD VSS BUF_X8
Xrebuffer651 _14676_ net1116 VDD VSS BUF_X1
X_16117_ _06870_ _14678_ VDD VSS BUF_X8
X_16118_ _06252_ _14659_ VDD VSS BUF_X8
X_16119_ _06277_ _06596_ _06872_ VDD VSS NOR2_X1
X_16120_ _06583_ _06873_ VDD VSS CLKBUF_X3
X_16121_ _06873_ _06874_ VDD VSS CLKBUF_X3
Xclone42 net545 _06254_ net42 VDD VSS NOR2_X1
X_16123_ _14661_ _06876_ VDD VSS INV_X2
X_16124_ net43 _06323_ _06877_ VDD VSS NAND2_X1
X_16125_ _14660_ _06878_ VDD VSS BUF_X1
X_16126_ _06878_ _06879_ VDD VSS CLKBUF_X3
X_16127_ _06869_ _06880_ VDD VSS BUF_X8
X_16128_ _06880_ _06881_ VDD VSS BUF_X4
X_16129_ _06879_ _06881_ _06882_ VDD VSS NAND2_X1
X_16130_ _06236_ _06883_ VDD VSS BUF_X4
X_16131_ _06883_ _06291_ _06884_ VDD VSS NOR2_X1
X_16132_ _06877_ _06882_ _06884_ _06885_ VDD VSS NAND3_X1
X_16133_ _06233_ _06886_ VDD VSS BUF_X4
X_16134_ _06886_ _06291_ _06887_ VDD VSS NOR2_X4
Xclone670 net1136 net1135 VDD VSS BUF_X8
X_16136_ _14674_ _06880_ _06889_ VDD VSS NAND2_X1
X_16137_ _14670_ _06890_ VDD VSS CLKBUF_X3
X_16138_ _06890_ _06322_ _06891_ VDD VSS NAND2_X1
X_16139_ _06887_ _06889_ _06891_ _06892_ VDD VSS NAND3_X1
X_16140_ _06874_ _06885_ _06892_ _06893_ VDD VSS NAND3_X1
X_16141_ _06240_ _06251_ _06254_ net545 _06894_ VDD VSS OAI22_X4
X_16142_ _06883_ _06894_ _06881_ _14664_ _06895_ VDD VSS OAI211_X2
X_16143_ _06233_ _06896_ VDD VSS BUF_X4
X_16144_ _06896_ _06897_ VDD VSS CLKBUF_X3
X_16145_ _06897_ _06898_ VDD VSS CLKBUF_X3
X_16146_ net587 net57 _06899_ VDD VSS NOR2_X1
X_16147_ _14664_ _06881_ _06900_ VDD VSS NOR2_X1
X_16148_ _06898_ _06899_ _06900_ _06901_ VDD VSS OAI21_X1
X_16149_ _00391_ _06895_ _06901_ _06902_ VDD VSS AND3_X1
X_16150_ _06289_ _06903_ VDD VSS BUF_X4
X_16151_ _06903_ _06904_ VDD VSS CLKBUF_X3
X_16152_ _06904_ _06905_ VDD VSS CLKBUF_X3
Xclone58 net1119 net58 VDD VSS INV_X1
X_16154_ _14665_ _06907_ VDD VSS INV_X2
X_16155_ net58 _14683_ _06908_ VDD VSS NOR2_X1
Xclone84 _04863_ net84 VDD VSS BUF_X4
X_16157_ _14667_ _06910_ VDD VSS CLKBUF_X3
X_16158_ _06910_ _06881_ _06911_ VDD VSS NOR2_X1
X_16159_ _00390_ _06908_ _06911_ _06912_ VDD VSS OAI21_X1
X_16160_ _14664_ _06870_ _06913_ VDD VSS NAND2_X2
X_16161_ _06912_ _06913_ _00390_ _06914_ VDD VSS OAI21_X1
X_16162_ net1119 _06915_ VDD VSS BUF_X4
X_16163_ _06320_ _06916_ VDD VSS BUF_X4
X_16164_ _06916_ _06917_ VDD VSS BUF_X4
X_16165_ _06915_ _06917_ _06918_ VDD VSS NAND2_X2
X_16166_ _06235_ _06919_ VDD VSS CLKBUF_X3
X_16167_ net781 _06320_ _06920_ VDD VSS NOR2_X4
X_16168_ _06919_ _06920_ _06921_ VDD VSS NOR2_X1
X_16169_ _06905_ _06918_ _06921_ _06922_ VDD VSS AOI21_X1
Xclone68 _14925_ net68 VDD VSS BUF_X2
X_16171_ _14662_ _06924_ VDD VSS INV_X4
X_16172_ _06924_ _06916_ _06925_ VDD VSS NAND2_X2
X_16173_ _00390_ _06877_ _06925_ _06926_ VDD VSS NAND3_X1
X_16174_ _06905_ _06914_ _06922_ _06926_ _06927_ VDD VSS AOI22_X1
X_16175_ _06872_ _06893_ _06902_ _06927_ _06874_ _06928_ VDD
+ VSS OAI221_X2
X_16176_ _06595_ _06929_ VDD VSS BUF_X4
X_16177_ _06277_ _06929_ _06930_ VDD VSS NOR2_X2
X_16178_ _06321_ _06931_ VDD VSS BUF_X8
X_16179_ _06931_ _06932_ VDD VSS BUF_X4
X_16180_ _06915_ _06932_ _06933_ VDD VSS NAND2_X1
X_16181_ _14672_ _06934_ VDD VSS BUF_X2
X_16182_ _06934_ _06935_ VDD VSS INV_X2
X_16183_ _06935_ _14678_ _06936_ VDD VSS NAND2_X1
X_16184_ _06887_ _06933_ _06936_ _06937_ VDD VSS NAND3_X1
X_16185_ _06233_ _06290_ _06938_ VDD VSS NAND2_X2
Xclone57 _06265_ net57 VDD VSS BUF_X4
X_16187_ net1117 _14683_ _06940_ VDD VSS NAND2_X1
X_16188_ _06887_ _06940_ _06941_ VDD VSS NOR2_X1
X_16189_ _06883_ _06903_ _06942_ VDD VSS NOR2_X1
X_16190_ _06890_ _06916_ _06943_ VDD VSS NAND2_X1
X_16191_ _06942_ _06943_ _06944_ VDD VSS AND2_X1
X_16192_ _06938_ _06941_ _06933_ _06944_ _06945_ VDD VSS AOI22_X1
X_16193_ _06874_ _06937_ _06945_ _06946_ VDD VSS NAND3_X1
X_16194_ _06930_ _06946_ _06947_ VDD VSS NAND2_X1
X_16195_ _06919_ _06948_ VDD VSS CLKBUF_X3
X_16196_ _06948_ _06949_ VDD VSS CLKBUF_X3
X_16197_ _14661_ net524 _06321_ _06950_ VDD VSS MUX2_X1
X_16198_ _06949_ _06950_ _06951_ VDD VSS NOR2_X1
X_16199_ _06886_ _06952_ VDD VSS CLKBUF_X3
X_16200_ _06952_ _06953_ VDD VSS CLKBUF_X3
X_16201_ net778 _06931_ _06954_ VDD VSS NAND2_X2
X_16202_ _06890_ _06955_ VDD VSS INV_X1
X_16203_ _06955_ _06870_ _06956_ VDD VSS NAND2_X1
X_16204_ _06953_ _06954_ _06956_ _06957_ VDD VSS AOI21_X1
X_16205_ _00391_ _06951_ _06957_ _06958_ VDD VSS NOR3_X1
X_16206_ _14674_ _06959_ VDD VSS INV_X1
X_16207_ _14676_ _06959_ _06870_ _06960_ VDD VSS MUX2_X1
X_16208_ _06236_ _06932_ _06961_ VDD VSS NAND2_X2
X_16209_ _00390_ _06960_ _06961_ _06910_ _06962_ VDD VSS OAI22_X1
X_16210_ _06958_ _06962_ _00391_ _06963_ VDD VSS AOI21_X1
X_16211_ _06874_ _06963_ _06964_ VDD VSS NOR2_X1
X_16212_ net857 _06965_ VDD VSS CLKBUF_X3
X_16213_ _06915_ _06965_ _06880_ _06966_ VDD VSS MUX2_X1
X_16214_ _14674_ _06253_ _06880_ _06967_ VDD VSS MUX2_X1
X_16215_ _06966_ _06967_ _06883_ _06968_ VDD VSS MUX2_X1
X_16216_ _14667_ _06969_ VDD VSS INV_X1
X_16217_ _06969_ _06235_ _06970_ VDD VSS NOR2_X2
X_16218_ _06878_ _06971_ VDD VSS INV_X2
X_16219_ _06971_ _06965_ _06880_ _06972_ VDD VSS MUX2_X1
X_16220_ _06292_ _06881_ _06970_ _06972_ _06237_ _06973_ VDD
+ VSS AOI221_X2
X_16221_ _06968_ _06973_ _06585_ _06974_ VDD VSS MUX2_X1
X_16222_ _00391_ _06974_ _06975_ VDD VSS NOR2_X1
X_16223_ _06910_ _06934_ _06323_ _06976_ VDD VSS MUX2_X1
X_16224_ _06949_ _06976_ _06977_ VDD VSS NOR2_X1
X_16225_ _14661_ _06978_ VDD VSS BUF_X2
X_16226_ net51 _06896_ _06917_ _06979_ VDD VSS NOR3_X4
X_16227_ _06874_ _06973_ _06977_ _06979_ _06980_ VDD VSS NOR4_X2
X_16228_ _06873_ _06897_ _14686_ _06981_ VDD VSS OAI21_X1
X_16229_ _06978_ _06881_ _06982_ VDD VSS NAND2_X2
X_16230_ _06981_ _06968_ _06904_ _06898_ _06982_ _06983_ VDD
+ VSS AOI221_X2
X_16231_ _06929_ _06975_ _06980_ _06983_ _06984_ VDD VSS NOR4_X2
X_16232_ _06277_ _06985_ VDD VSS CLKBUF_X3
X_16233_ _06903_ _06986_ VDD VSS BUF_X4
X_16234_ _06878_ _14664_ _06870_ _06987_ VDD VSS MUX2_X1
X_16235_ _06986_ _06987_ _06952_ _06988_ VDD VSS OAI21_X2
X_16236_ net1130 _06917_ _06989_ VDD VSS NAND2_X2
X_16237_ _06238_ _06940_ _06989_ _06990_ VDD VSS AOI21_X1
X_16238_ net58 _06868_ _06322_ _06991_ VDD VSS MUX2_X1
X_16239_ net921 _14659_ _06870_ _06992_ VDD VSS MUX2_X1
X_16240_ _06991_ _06992_ _06238_ _06993_ VDD VSS MUX2_X1
X_16241_ _00393_ _06988_ _06990_ _06993_ _06905_ _06994_ VDD
+ VSS OAI221_X1
X_16242_ _06292_ _06995_ VDD VSS CLKBUF_X3
X_16243_ _06995_ _06996_ VDD VSS CLKBUF_X3
X_16244_ _06868_ _06931_ _06997_ VDD VSS NOR2_X1
X_16245_ _06978_ _06998_ VDD VSS BUF_X4
X_16246_ _06998_ _06953_ _06999_ VDD VSS NAND2_X1
X_16247_ _14678_ net782 _06238_ _07000_ VDD VSS OAI21_X1
X_16248_ _06996_ _06997_ _06999_ _07000_ _06998_ _07001_ VDD
+ VSS OAI221_X1
X_16249_ _06235_ _06931_ _07002_ VDD VSS NOR2_X4
X_16250_ _06234_ _06869_ _07003_ VDD VSS XNOR2_X2
X_16251_ _14674_ _07004_ VDD VSS BUF_X4
X_16252_ _06979_ _07002_ _06890_ _07003_ _07004_ _07005_ VDD
+ VSS AOI221_X2
X_16253_ _07001_ _07005_ _00391_ _07006_ VDD VSS OAI21_X1
X_16254_ _06994_ _07006_ _00393_ _07007_ VDD VSS OAI21_X1
X_16255_ _06985_ _00394_ _07007_ _07008_ VDD VSS OAI21_X1
X_16256_ _06928_ _06947_ _06964_ _06984_ _07008_ _00000_ VDD
+ VSS OAI221_X2
X_16257_ _14674_ _06253_ _06931_ _07009_ VDD VSS MUX2_X1
X_16258_ _06878_ net1119 _06880_ _07010_ VDD VSS MUX2_X1
X_16259_ _07009_ _07010_ _06883_ _07011_ VDD VSS MUX2_X1
X_16260_ _06969_ net1130 _06916_ _07012_ VDD VSS MUX2_X1
X_16261_ _06965_ net42 _06880_ _07013_ VDD VSS MUX2_X1
X_16262_ _07012_ _07013_ _06896_ _07014_ VDD VSS MUX2_X1
X_16263_ _07011_ _07014_ _06277_ _07015_ VDD VSS MUX2_X1
X_16264_ _06943_ _06870_ _06971_ _07016_ VDD VSS OAI21_X1
X_16265_ _14688_ _06278_ _07017_ VDD VSS OR2_X1
X_16266_ _06237_ _07018_ VDD VSS CLKBUF_X3
X_16267_ _07016_ _07017_ _07018_ _07019_ VDD VSS MUX2_X1
X_16268_ _07015_ _07019_ _06904_ _07020_ VDD VSS MUX2_X1
X_16269_ _06894_ _06869_ _14669_ _07021_ VDD VSS OAI21_X2
X_16270_ _06883_ _06881_ _07022_ VDD VSS NAND2_X2
X_16271_ _06904_ _07021_ _06948_ _07022_ _06915_ _07023_ VDD
+ VSS OAI221_X1
X_16272_ _06978_ _06965_ _06870_ _07024_ VDD VSS MUX2_X1
X_16273_ _06910_ _14664_ _06917_ _07025_ VDD VSS MUX2_X1
X_16274_ _07024_ _07025_ _06952_ _07026_ VDD VSS MUX2_X1
X_16275_ _07023_ _07026_ _06904_ _07027_ VDD VSS OAI21_X1
X_16276_ _06886_ _06322_ _14667_ _07028_ VDD VSS OAI21_X1
X_16277_ net1120 _06265_ _06290_ _07029_ VDD VSS MUX2_X1
X_16278_ _07028_ _07029_ _06932_ _07030_ VDD VSS AOI21_X1
X_16279_ _14679_ _06903_ _07031_ VDD VSS NOR2_X1
X_16280_ net1130 _06931_ _07032_ VDD VSS NAND2_X2
X_16281_ _06235_ _06870_ _06910_ _07033_ VDD VSS AOI21_X1
X_16282_ _07032_ _07033_ _07034_ VDD VSS NAND2_X1
X_16283_ net51 _14662_ _06322_ _07035_ VDD VSS MUX2_X1
X_16284_ _07030_ _07031_ _07034_ _06887_ _07035_ _07036_ VDD
+ VSS AOI221_X2
X_16285_ _07027_ _07036_ _06985_ _07037_ VDD VSS MUX2_X1
X_16286_ _07020_ _07037_ _00394_ _07038_ VDD VSS MUX2_X1
X_16287_ _06924_ _14683_ _07039_ VDD VSS NAND2_X1
X_16288_ _07039_ _06232_ _06219_ net1118 _14683_ _07040_ VDD
+ VSS OAI221_X1
X_16289_ _06998_ _06932_ _07041_ VDD VSS NAND2_X2
X_16290_ _06949_ _07041_ _06882_ _07042_ VDD VSS NAND3_X1
X_16291_ _06996_ _07040_ _07042_ _07043_ VDD VSS AND3_X1
X_16292_ _06979_ _06987_ _06898_ _07044_ VDD VSS AOI21_X1
X_16293_ _00391_ _07044_ _07045_ VDD VSS NOR2_X1
X_16294_ _00392_ _07043_ _07045_ _07046_ VDD VSS NOR3_X1
X_16295_ _06913_ _06232_ _06219_ net1118 _14678_ _07047_ VDD
+ VSS OAI221_X1
X_16296_ _06876_ _06880_ _07048_ VDD VSS NAND2_X2
X_16297_ _07004_ _06323_ _07049_ VDD VSS NAND2_X1
X_16298_ _06949_ _07048_ _07049_ _07050_ VDD VSS NAND3_X1
X_16299_ _00391_ _07047_ _07050_ _07051_ VDD VSS NAND3_X1
X_16300_ _06949_ net1178 _07052_ VDD VSS AND2_X1
X_16301_ _07004_ _14683_ _07053_ VDD VSS NOR2_X1
X_16302_ _06949_ _06920_ _07053_ _07054_ VDD VSS NOR3_X1
X_16303_ _06904_ _07052_ _07054_ _07055_ VDD VSS OAI21_X1
X_16304_ _00392_ _07051_ _07055_ _07056_ VDD VSS AND3_X1
X_16305_ _06929_ _07046_ _07056_ _07057_ VDD VSS OAI21_X1
X_16306_ _06905_ _06930_ _07058_ VDD VSS NAND2_X1
X_16307_ _06910_ _06898_ _14683_ _07059_ VDD VSS NAND3_X1
X_16308_ _07058_ _07059_ _07042_ _07060_ VDD VSS AOI21_X1
X_16309_ _06998_ _06969_ _06881_ _07061_ VDD VSS MUX2_X1
X_16310_ _06886_ _06289_ _07062_ VDD VSS NOR2_X4
X_16311_ _06942_ _06967_ _07061_ _07062_ _07063_ VDD VSS AOI22_X1
X_16312_ _06985_ _00394_ _07063_ _07064_ VDD VSS NAND3_X1
X_16313_ _14664_ _06322_ _07065_ VDD VSS NAND2_X1
X_16314_ _06898_ _07065_ _06982_ _07066_ VDD VSS NAND3_X1
X_16315_ _06965_ net1130 _07067_ VDD VSS NAND2_X1
X_16316_ _00390_ _06913_ _07067_ _07068_ VDD VSS NAND3_X1
X_16317_ _07064_ _07066_ _07068_ _07069_ VDD VSS AOI21_X1
X_16318_ _06896_ _06932_ _07070_ VDD VSS NAND2_X1
X_16319_ _06879_ _07070_ _07071_ VDD VSS NOR2_X1
X_16320_ _07018_ _06925_ _07032_ _07072_ VDD VSS AND3_X1
X_16321_ _06930_ _07071_ _07072_ _07073_ VDD VSS OAI21_X1
X_16322_ _06905_ _07064_ _07073_ _07074_ VDD VSS AOI21_X1
X_16323_ _06874_ _07060_ _07069_ _07074_ _07075_ VDD VSS NOR4_X1
X_16324_ _06874_ _07038_ _07057_ _07075_ _00001_ VDD VSS AOI22_X2
X_16325_ _06907_ net1130 _06321_ _07076_ VDD VSS MUX2_X1
X_16326_ _14681_ _07076_ _06236_ _07077_ VDD VSS MUX2_X1
X_16327_ _14684_ _06237_ _07002_ _06915_ _07078_ VDD VSS AOI22_X1
X_16328_ _07077_ _07078_ _06986_ _07079_ VDD VSS MUX2_X1
X_16329_ _06890_ _06235_ _06931_ _07080_ VDD VSS NOR3_X1
X_16330_ _07080_ _06920_ _06236_ _06971_ _07003_ _07081_ VDD
+ VSS AOI221_X2
X_16331_ net51 _06910_ _06917_ _07082_ VDD VSS MUX2_X1
X_16332_ _06948_ _07082_ _07083_ VDD VSS NAND2_X1
X_16333_ _07004_ _06919_ _06917_ _07084_ VDD VSS NOR3_X1
X_16334_ _06995_ _07084_ _07085_ VDD VSS NOR2_X1
X_16335_ _06293_ _07081_ _07083_ _07085_ _07086_ VDD VSS AOI22_X1
X_16336_ _07079_ _07086_ _06278_ _07087_ VDD VSS MUX2_X1
X_16337_ _14662_ _14667_ _06321_ _07088_ VDD VSS MUX2_X1
X_16338_ _07076_ _07088_ _06886_ _07089_ VDD VSS MUX2_X1
X_16339_ _14667_ _06907_ _06321_ _07090_ VDD VSS MUX2_X1
X_16340_ _06950_ _07090_ _06236_ _07091_ VDD VSS MUX2_X1
X_16341_ _07089_ _07091_ _06986_ _07092_ VDD VSS MUX2_X1
X_16342_ net1105 net1130 _06869_ _07093_ VDD VSS MUX2_X1
X_16343_ _14676_ net778 _06321_ _07094_ VDD VSS MUX2_X1
X_16344_ _07093_ _07094_ _06236_ _07095_ VDD VSS MUX2_X1
X_16345_ _06924_ _06878_ _06916_ _07096_ VDD VSS MUX2_X1
X_16346_ _06915_ _07002_ _07096_ _06883_ _07097_ VDD VSS AOI22_X1
X_16347_ _07095_ _07097_ _06986_ _07098_ VDD VSS MUX2_X1
X_16348_ _07092_ _07098_ _06278_ _07099_ VDD VSS MUX2_X1
X_16349_ _07087_ _07099_ _06929_ _07100_ VDD VSS MUX2_X1
X_16350_ _06938_ _06925_ _07065_ _07101_ VDD VSS AOI21_X1
X_16351_ _06934_ _06323_ _07102_ VDD VSS NAND2_X1
X_16352_ _07062_ _06989_ _07102_ _07103_ VDD VSS NAND3_X1
X_16353_ _00392_ _07103_ _07104_ VDD VSS NAND2_X1
X_16354_ _06876_ _06869_ _07105_ VDD VSS XNOR2_X2
X_16355_ _06934_ _06965_ _06322_ _07106_ VDD VSS MUX2_X1
X_16356_ _07105_ _07106_ _06896_ _07107_ VDD VSS MUX2_X1
X_16357_ _06293_ _07107_ _07108_ VDD VSS NOR2_X1
X_16358_ _06938_ _06870_ _14662_ _07109_ VDD VSS AOI21_X1
X_16359_ _07102_ _07109_ _07110_ VDD VSS AND2_X1
X_16360_ _06903_ _06954_ _06236_ _07111_ VDD VSS AOI21_X1
X_16361_ _06290_ _06916_ _07112_ VDD VSS NOR2_X4
X_16362_ _06934_ net42 _06235_ _07113_ VDD VSS MUX2_X1
X_16363_ _07111_ _07112_ _07113_ _06870_ _06910_ _07114_ VDD
+ VSS AOI221_X2
X_16364_ _07101_ _07104_ _07108_ _07110_ _07114_ _00392_ _07115_
+ VDD VSS OAI33_X1
X_16365_ _06938_ _07032_ _06889_ _07116_ VDD VSS AOI21_X1
X_16366_ _14688_ _07021_ _06235_ _07117_ VDD VSS MUX2_X1
X_16367_ _06891_ _07048_ _07118_ VDD VSS NAND2_X1
X_16368_ _07116_ _07117_ _06903_ _07062_ _07118_ _07119_ VDD
+ VSS AOI221_X1
X_16369_ _14686_ _06233_ _07120_ VDD VSS AND2_X1
X_16370_ net51 _06907_ _06931_ _07121_ VDD VSS MUX2_X1
X_16371_ _06291_ _07120_ _07121_ _06919_ _07122_ VDD VSS AOI211_X2
X_16372_ _14681_ _06965_ _06322_ _07123_ VDD VSS AOI21_X2
X_16373_ _06950_ _07123_ _06883_ _07124_ VDD VSS MUX2_X1
X_16374_ _07122_ _07124_ _06293_ _07125_ VDD VSS AOI21_X1
X_16375_ _07119_ _07125_ _06278_ _07126_ VDD VSS MUX2_X1
X_16376_ _07115_ _07126_ _00394_ _07127_ VDD VSS MUX2_X1
X_16377_ _07100_ _07127_ _00393_ _00002_ VDD VSS MUX2_X1
X_16378_ net57 _06932_ _06965_ _07128_ VDD VSS MUX2_X1
X_16379_ _06952_ _07128_ _07129_ VDD VSS NAND2_X1
X_16380_ net57 _06917_ _07130_ VDD VSS NAND2_X1
X_16381_ _07018_ _07041_ _07130_ _07131_ VDD VSS NAND3_X1
X_16382_ _06293_ _07129_ _07131_ _07132_ VDD VSS AOI21_X1
X_16383_ _06953_ _07123_ _07133_ VDD VSS NAND2_X1
X_16384_ _07133_ _07022_ _06998_ _07134_ VDD VSS OAI21_X1
X_16385_ _00392_ _07132_ _07134_ _06996_ _07135_ VDD VSS AOI211_X2
X_16386_ net57 _06289_ _07136_ VDD VSS NAND2_X1
X_16387_ _06965_ _06291_ _06870_ _07137_ VDD VSS NAND3_X1
X_16388_ _06919_ _07136_ _07137_ _07138_ VDD VSS AOI21_X1
X_16389_ _06910_ _06289_ _07139_ VDD VSS NAND2_X1
X_16390_ _07139_ _07048_ _06903_ _07140_ VDD VSS OAI21_X1
X_16391_ _07004_ _07062_ _07141_ VDD VSS NAND2_X1
X_16392_ _07138_ _07140_ _06883_ _07141_ _06323_ _07142_ VDD
+ VSS AOI221_X2
X_16393_ _06924_ _06238_ _07112_ _07143_ VDD VSS NAND3_X1
X_16394_ _06890_ _06995_ _07112_ _06998_ _07144_ VDD VSS AOI22_X1
X_16395_ _07143_ _07144_ _06949_ _07145_ VDD VSS OAI21_X1
X_16396_ _14659_ _06870_ _07146_ VDD VSS NAND2_X2
X_16397_ _06985_ _07142_ _07145_ _07146_ _07147_ VDD VSS AOI211_X2
X_16398_ _06929_ _07135_ _07147_ _07148_ VDD VSS NOR3_X1
X_16399_ _06903_ _06917_ _07149_ VDD VSS NOR2_X2
X_16400_ net43 _06952_ _06278_ _07150_ VDD VSS NAND3_X1
X_16401_ net1116 _07151_ VDD VSS INV_X1
X_16402_ _07150_ _06897_ _07151_ _07152_ VDD VSS OAI21_X1
X_16403_ _06985_ _06293_ _07153_ VDD VSS NOR2_X1
X_16404_ _06238_ _06954_ _07003_ _06935_ _07154_ VDD VSS OAI22_X2
X_16405_ _06596_ _07149_ _07152_ _07153_ _07154_ _07155_ VDD
+ VSS AOI221_X2
X_16406_ _00390_ _07032_ _06956_ _07156_ VDD VSS AOI21_X1
X_16407_ _00391_ _07022_ _06998_ _07157_ VDD VSS OAI21_X1
X_16408_ _06985_ _07156_ _07157_ _07158_ VDD VSS OAI21_X1
X_16409_ _06898_ _07024_ _07159_ VDD VSS NAND2_X1
X_16410_ _00390_ _06925_ _06954_ _07160_ VDD VSS NAND3_X1
X_16411_ _06905_ _07159_ _07160_ _07161_ VDD VSS AND3_X1
X_16412_ _07155_ _07158_ _07161_ _07162_ VDD VSS OAI21_X1
X_16413_ _06874_ _07162_ _07163_ VDD VSS NAND2_X1
X_16414_ _06935_ net781 _06931_ _07164_ VDD VSS MUX2_X1
X_16415_ _07065_ _06925_ _07165_ VDD VSS NAND2_X1
X_16416_ _07016_ _07165_ _06291_ _07166_ VDD VSS MUX2_X1
X_16417_ _06278_ _06887_ _07164_ _07166_ _06897_ _07167_ VDD
+ VSS AOI221_X2
X_16418_ _07146_ _07021_ _07018_ _06961_ _07004_ _07168_ VDD
+ VSS OAI221_X1
X_16419_ _06934_ _06253_ _06869_ _07169_ VDD VSS MUX2_X1
X_16420_ _06897_ _07169_ _07170_ VDD VSS NOR2_X1
X_16421_ _06948_ _06877_ _06925_ _07171_ VDD VSS AOI21_X1
X_16422_ _07170_ _07171_ _07172_ VDD VSS NOR2_X1
X_16423_ _07168_ _07172_ _06293_ _07173_ VDD VSS MUX2_X1
X_16424_ _00394_ _07167_ _07173_ _00392_ _07174_ VDD VSS AOI211_X2
X_16425_ _06925_ _07062_ _07032_ _07175_ VDD VSS NAND3_X1
X_16426_ _06277_ _06596_ _07176_ VDD VSS NAND2_X1
X_16427_ _06896_ _06932_ _07177_ VDD VSS NOR2_X1
X_16428_ _06292_ _07177_ _06915_ _07178_ VDD VSS AOI21_X1
X_16429_ _06877_ _14683_ _06935_ _07179_ VDD VSS OAI21_X1
X_16430_ _07176_ _07129_ _07178_ _07179_ _06942_ _07180_ VDD
+ VSS AOI221_X2
X_16431_ _06982_ _06232_ _06219_ _06879_ _14678_ _07181_ VDD
+ VSS OAI221_X1
X_16432_ _06915_ _06890_ _14683_ _07182_ VDD VSS MUX2_X1
X_16433_ _00390_ _07182_ _07183_ VDD VSS NAND2_X1
X_16434_ _06905_ _07181_ _07183_ _07184_ VDD VSS NAND3_X1
X_16435_ _06278_ _06596_ _07185_ VDD VSS NAND2_X1
X_16436_ _06899_ _06900_ _07186_ VDD VSS NOR2_X1
X_16437_ _07185_ _07062_ _07186_ _06944_ _07041_ _07187_ VDD
+ VSS AOI221_X1
X_16438_ _07175_ _07180_ _07184_ _07187_ _07188_ VDD VSS AOI22_X1
X_16439_ _00393_ _07188_ _07189_ VDD VSS NAND2_X1
X_16440_ _07148_ _07163_ _07174_ _07189_ _00003_ VDD VSS OAI22_X1
X_16441_ _06253_ _06880_ _14669_ _07190_ VDD VSS MUX2_X1
X_16442_ _07164_ _07190_ _06896_ _07191_ VDD VSS MUX2_X1
X_16443_ _06895_ _06960_ _06948_ _07192_ VDD VSS OAI21_X1
X_16444_ _07191_ _07192_ _06904_ _07193_ VDD VSS MUX2_X1
X_16445_ _06934_ _06868_ _06931_ _07194_ VDD VSS MUX2_X2
X_16446_ _06982_ _07194_ _06292_ _07195_ VDD VSS MUX2_X1
X_16447_ _06949_ _07195_ _07196_ VDD VSS NAND2_X1
X_16448_ net58 _06292_ _06323_ _07197_ VDD VSS NAND3_X1
X_16449_ _07197_ _06995_ _06879_ _07198_ VDD VSS OAI21_X1
X_16450_ _06985_ _07198_ _06953_ _07199_ VDD VSS AOI21_X1
X_16451_ _06985_ _07193_ _07196_ _07199_ _07200_ VDD VSS AOI22_X1
X_16452_ _06289_ _06322_ _07201_ VDD VSS NOR2_X1
X_16453_ _06884_ _07035_ _07201_ _06970_ _07202_ VDD VSS AOI22_X1
X_16454_ net58 _07112_ _07201_ _06998_ _07203_ VDD VSS AOI22_X1
X_16455_ _06291_ _06322_ _07204_ VDD VSS NOR2_X4
X_16456_ _07149_ _07204_ _06948_ _07205_ VDD VSS AOI21_X1
X_16457_ _07202_ _07203_ _06897_ _06935_ _07205_ _07206_ VDD
+ VSS OAI221_X1
X_16458_ _06959_ net42 _06869_ _07207_ VDD VSS MUX2_X1
X_16459_ _07090_ _07207_ _06236_ _07208_ VDD VSS MUX2_X1
X_16460_ _06907_ net42 _06916_ _07209_ VDD VSS MUX2_X1
X_16461_ _07088_ _07209_ _06919_ _07210_ VDD VSS MUX2_X1
X_16462_ _07208_ _07210_ _06292_ _07211_ VDD VSS MUX2_X1
X_16463_ _07206_ _07211_ _06985_ _07212_ VDD VSS MUX2_X1
X_16464_ _07200_ _07212_ _00394_ _07213_ VDD VSS MUX2_X1
X_16465_ _07004_ net782 _06881_ _07214_ VDD VSS MUX2_X1
X_16466_ _06924_ _07204_ _07214_ _06995_ _07215_ VDD VSS AOI22_X1
X_16467_ _06949_ _07215_ _07216_ VDD VSS NOR2_X1
X_16468_ _06596_ _07112_ net587 _07217_ VDD VSS AOI21_X1
X_16469_ _07112_ net1178 _06995_ _07218_ VDD VSS AOI21_X1
X_16470_ _07217_ _07218_ _06898_ _07219_ VDD VSS OAI21_X1
X_16471_ _07149_ _06887_ _14664_ _07220_ VDD VSS AOI21_X1
X_16472_ _00394_ _07220_ net782 _07221_ VDD VSS OAI21_X1
X_16473_ _06896_ net57 _07112_ _07201_ _07004_ _07222_ VDD
+ VSS AOI221_X2
X_16474_ net587 _06989_ _07204_ net782 _07223_ VDD VSS AOI22_X1
X_16475_ _07222_ _07223_ _06953_ _07224_ VDD VSS AOI21_X1
X_16476_ _07216_ _07219_ _07221_ _07224_ _07225_ VDD VSS OAI22_X1
X_16477_ _06910_ _06323_ _07226_ VDD VSS NAND2_X1
X_16478_ _06948_ _07048_ _07226_ _07227_ VDD VSS AOI21_X1
X_16479_ net1116 _06971_ _06237_ _07228_ VDD VSS MUX2_X1
X_16480_ _06293_ _14678_ _07229_ VDD VSS NAND2_X1
X_16481_ _06929_ _06988_ _07227_ _07228_ _07229_ _07230_ VDD
+ VSS OAI221_X1
X_16482_ _06934_ _06323_ _07231_ VDD VSS NOR2_X1
X_16483_ _06995_ _14678_ _07151_ _07231_ _06897_ _07232_ VDD
+ VSS OAI221_X1
X_16484_ _06886_ _06917_ _07233_ VDD VSS NAND2_X1
X_16485_ _14690_ _07234_ VDD VSS INV_X1
X_16486_ _06954_ _07233_ _07004_ _06953_ _07234_ _07235_ VDD
+ VSS OAI221_X1
X_16487_ _07232_ _07235_ _06996_ _07236_ VDD VSS OAI21_X1
X_16488_ _07230_ _07236_ _06929_ _07237_ VDD VSS OAI21_X1
X_16489_ _07225_ _07237_ _00392_ _07238_ VDD VSS MUX2_X1
X_16490_ _07213_ _07238_ _00393_ _00004_ VDD VSS MUX2_X1
X_16491_ net587 net782 _06293_ _07239_ VDD VSS NAND3_X1
X_16492_ _06903_ _06881_ _07240_ VDD VSS NAND2_X1
X_16493_ _07239_ _07240_ net782 _07241_ VDD VSS OAI21_X1
X_16494_ _07136_ _07016_ _06904_ _07242_ VDD VSS OAI21_X1
X_16495_ _07241_ _07242_ _00390_ _07243_ VDD VSS MUX2_X1
X_16496_ net587 _07233_ _07136_ _07244_ VDD VSS AOI21_X1
X_16497_ _00393_ _07244_ _07245_ VDD VSS OR2_X1
X_16498_ _06996_ _06940_ _06989_ _07246_ VDD VSS AOI21_X1
X_16499_ _06996_ _06933_ _06936_ _07247_ VDD VSS AND3_X1
X_16500_ _06898_ _07246_ _07247_ _07248_ VDD VSS OAI21_X1
X_16501_ _06969_ _07149_ _07204_ _07249_ VDD VSS NOR3_X1
X_16502_ _07249_ _07149_ _14664_ _14662_ _07204_ _07250_ VDD
+ VSS AOI221_X2
X_16503_ _07248_ _07250_ _06898_ _07251_ VDD VSS OAI21_X1
X_16504_ _06930_ _07243_ _07245_ _07251_ _06874_ _07252_ VDD
+ VSS OAI221_X1
X_16505_ _14664_ _06584_ _07253_ VDD VSS NAND2_X1
X_16506_ _07253_ _06584_ _06879_ _07254_ VDD VSS OAI21_X1
X_16507_ _06953_ _06585_ _06918_ _07254_ _14678_ _07255_ VDD
+ VSS OAI221_X1
X_16508_ _06873_ _06900_ _07256_ VDD VSS NAND2_X1
X_16509_ _06238_ _07253_ _07256_ _07257_ VDD VSS NAND3_X1
X_16510_ _06996_ _06585_ _06899_ _07255_ _07257_ _07258_ VDD
+ VSS AOI221_X1
X_16511_ _07033_ _07177_ _06924_ _07259_ VDD VSS AOI21_X1
X_16512_ _06978_ net58 _06870_ _07260_ VDD VSS MUX2_X1
X_16513_ _07194_ _07260_ _06238_ _07261_ VDD VSS MUX2_X1
X_16514_ _07259_ _07261_ _00393_ _07262_ VDD VSS MUX2_X1
X_16515_ _07258_ _07262_ _00391_ _07263_ VDD VSS AOI21_X1
X_16516_ _06278_ _06595_ _07264_ VDD VSS NAND2_X1
X_16517_ _06978_ _06924_ _06916_ _07265_ VDD VSS MUX2_X1
X_16518_ _06876_ _06890_ _06880_ _07266_ VDD VSS MUX2_X1
X_16519_ _07265_ _07266_ _06919_ _07267_ VDD VSS MUX2_X1
X_16520_ _06919_ _06932_ _06879_ _07268_ VDD VSS AOI21_X1
X_16521_ _07268_ _06948_ _06955_ _07269_ VDD VSS AOI21_X1
X_16522_ _07267_ _07269_ _06986_ _07270_ VDD VSS MUX2_X1
X_16523_ _06924_ _06879_ _06932_ _07271_ VDD VSS MUX2_X1
X_16524_ _06995_ _07022_ _06890_ _07271_ _07018_ _07272_ VDD
+ VSS OAI221_X2
X_16525_ _06920_ _07028_ _07273_ VDD VSS NOR2_X1
X_16526_ _07272_ _07273_ _06988_ _07274_ VDD VSS OAI21_X1
X_16527_ _07270_ _07274_ _06585_ _07275_ VDD VSS MUX2_X1
X_16528_ _06585_ _06911_ _06948_ _14683_ _06915_ _07276_ VDD
+ VSS OAI221_X1
X_16529_ _07151_ net782 _06932_ _07277_ VDD VSS MUX2_X1
X_16530_ _06873_ _07022_ net43 _07277_ _07018_ _07278_ VDD
+ VSS OAI221_X1
X_16531_ _06996_ _07276_ _07278_ _07279_ VDD VSS AND3_X1
X_16532_ net43 _06959_ _06870_ _07280_ VDD VSS MUX2_X1
X_16533_ _06584_ _07002_ net921 _07280_ _06237_ _07281_ VDD
+ VSS AOI221_X2
X_16534_ _06998_ _07070_ _07169_ _06953_ _07282_ VDD VSS OAI22_X1
X_16535_ _07281_ _07282_ _00393_ _07283_ VDD VSS AOI21_X1
X_16536_ _07279_ _07283_ _06905_ _07284_ VDD VSS AOI21_X1
X_16537_ _07275_ _07284_ _00394_ _07285_ VDD VSS MUX2_X1
X_16538_ _07252_ _07263_ _07264_ _07285_ _00392_ _00005_ VDD
+ VSS OAI221_X1
X_16539_ _07090_ _07194_ _06292_ _07286_ VDD VSS MUX2_X1
X_16540_ _06873_ _06938_ _06943_ _07286_ _06898_ _07287_ VDD
+ VSS OAI221_X1
X_16541_ _07018_ _07169_ _07288_ VDD VSS AND2_X1
X_16542_ _06904_ _07070_ net43 _07289_ VDD VSS OAI21_X1
X_16543_ _06585_ _07288_ _07289_ _07290_ VDD VSS OAI21_X1
X_16544_ _14679_ _07291_ VDD VSS INV_X1
X_16545_ _06986_ _06918_ _06921_ _06948_ _07291_ _07292_ VDD
+ VSS AOI221_X2
X_16546_ _07287_ _07290_ _07292_ _07293_ VDD VSS OAI21_X1
X_16547_ _14662_ _06934_ _06320_ _07294_ VDD VSS MUX2_X1
X_16548_ _14676_ _06971_ _06869_ _07295_ VDD VSS MUX2_X1
X_16549_ _07294_ _07295_ _06236_ _07296_ VDD VSS MUX2_X1
X_16550_ _06907_ _06253_ _06869_ _07297_ VDD VSS MUX2_X1
X_16551_ _06876_ _06253_ _06321_ _07298_ VDD VSS MUX2_X1
X_16552_ _07297_ _07298_ _06886_ _07299_ VDD VSS MUX2_X1
X_16553_ _07296_ _07299_ _06873_ _07300_ VDD VSS MUX2_X1
X_16554_ _07169_ _07298_ _06886_ _07301_ VDD VSS MUX2_X1
X_16555_ _14665_ _06265_ _06916_ _07302_ VDD VSS MUX2_X1
X_16556_ _06890_ _07233_ _07302_ _06896_ _07303_ VDD VSS OAI22_X1
X_16557_ _07301_ _07303_ _06873_ _07304_ VDD VSS MUX2_X1
X_16558_ _07300_ _07304_ _06293_ _07305_ VDD VSS MUX2_X1
X_16559_ _07293_ _07305_ _00394_ _07306_ VDD VSS MUX2_X1
X_16560_ _14662_ _07070_ _07307_ VDD VSS NOR2_X1
X_16561_ _07146_ _06894_ _06953_ _07308_ VDD VSS OAI21_X1
X_16562_ _06873_ _07307_ _07308_ _07309_ VDD VSS NOR3_X1
X_16563_ _06237_ net587 _06870_ _07310_ VDD VSS AOI21_X1
X_16564_ _06585_ _07310_ _07265_ _06238_ _07311_ VDD VSS AOI211_X2
X_16565_ _06905_ _07309_ _07311_ _07312_ VDD VSS NOR3_X1
X_16566_ _14680_ _06952_ _07313_ VDD VSS NOR2_X1
X_16567_ _07313_ _07194_ _06953_ _07314_ VDD VSS AOI21_X1
X_16568_ _06949_ _07128_ _07315_ VDD VSS AND2_X1
X_16569_ _06585_ _06918_ _06238_ net1130 _14678_ _07316_ VDD
+ VSS OAI221_X1
X_16570_ _06905_ _00393_ _07314_ _07315_ _07316_ _07317_ VDD
+ VSS OAI221_X1
X_16571_ _06929_ _07317_ _07318_ VDD VSS NAND2_X1
X_16572_ _06919_ _14659_ _07319_ VDD VSS NAND2_X1
X_16573_ _06583_ _06997_ _06919_ _07319_ net782 _07320_ VDD
+ VSS AOI221_X2
X_16574_ _06876_ net1116 _06917_ _07321_ VDD VSS MUX2_X1
X_16575_ _06991_ _07321_ _06952_ _07322_ VDD VSS MUX2_X1
X_16576_ _07320_ _07322_ _06873_ _07323_ VDD VSS AOI21_X1
X_16577_ net1116 _06870_ _07324_ VDD VSS NAND2_X1
X_16578_ _06897_ _07102_ _07324_ _07325_ VDD VSS AOI21_X1
X_16579_ _06873_ _07084_ _07326_ VDD VSS OR2_X1
X_16580_ _14684_ _07327_ VDD VSS INV_X1
X_16581_ _07327_ _07260_ _06952_ _07328_ VDD VSS MUX2_X1
X_16582_ _07325_ _07326_ _07328_ _06585_ _07329_ VDD VSS OAI22_X1
X_16583_ _07323_ _07329_ _06996_ _07330_ VDD VSS MUX2_X1
X_16584_ _07312_ _07318_ _07330_ _06929_ _07331_ VDD VSS OAI22_X2
X_16585_ _07306_ _07331_ _00392_ _00006_ VDD VSS MUX2_X1
X_16586_ _07151_ _07018_ _07332_ VDD VSS NOR2_X1
X_16587_ _06870_ net783 _06952_ _07333_ VDD VSS OAI21_X1
X_16588_ _06904_ _07332_ _07333_ _14678_ _06959_ _07334_ VDD
+ VSS OAI221_X1
X_16589_ _06897_ _07190_ _07335_ VDD VSS NOR2_X1
X_16590_ _06996_ _06970_ _07335_ _07336_ VDD VSS OAI21_X1
X_16591_ _07176_ _07334_ _07336_ _07337_ VDD VSS AOI21_X1
X_16592_ _06235_ _06291_ _07294_ _07338_ VDD VSS NOR3_X1
X_16593_ _06278_ _06596_ _07338_ _07339_ VDD VSS OR3_X1
X_16594_ _07003_ _07340_ VDD VSS INV_X1
X_16595_ _06237_ _06913_ _06961_ _14662_ net51 _07340_ _07341_
+ VDD VSS OAI222_X2
X_16596_ _07339_ _07123_ _06887_ _06995_ _07341_ _07342_ VDD
+ VSS AOI221_X1
X_16597_ _06938_ _06933_ _06913_ _07343_ VDD VSS AOI21_X1
X_16598_ _06882_ _07049_ _07344_ VDD VSS NAND2_X1
X_16599_ _07343_ _07344_ _07062_ _07345_ VDD VSS AOI21_X1
X_16600_ _06952_ _07194_ _07346_ VDD VSS NOR2_X1
X_16601_ _06986_ _07307_ _07346_ _07347_ VDD VSS OAI21_X1
X_16602_ _06872_ _07345_ _07347_ _07348_ VDD VSS AND3_X1
X_16603_ _07004_ _06868_ _06291_ _07349_ VDD VSS MUX2_X1
X_16604_ _06879_ _07204_ _07349_ _06323_ _07350_ VDD VSS AOI22_X1
X_16605_ _07018_ _07350_ _07351_ VDD VSS NOR2_X1
X_16606_ _06237_ _06986_ _07352_ VDD VSS NAND2_X1
X_16607_ _07352_ _06943_ _07041_ _07353_ VDD VSS AOI21_X1
X_16608_ _06879_ _07002_ _07164_ _06883_ _07354_ VDD VSS AOI22_X1
X_16609_ _06986_ _07354_ _07355_ VDD VSS NOR2_X1
X_16610_ _07185_ _07351_ _07353_ _07355_ _07356_ VDD VSS NOR4_X1
X_16611_ _07337_ _07342_ _07348_ _07356_ _07357_ VDD VSS OR4_X1
X_16612_ _06897_ _06986_ _07302_ _07240_ _07151_ _07358_ VDD
+ VSS OAI221_X1
X_16613_ _06292_ _06989_ _07359_ VDD VSS NAND2_X1
X_16614_ _07018_ _06911_ _07359_ _06995_ _06879_ _07360_ VDD
+ VSS OAI221_X1
X_16615_ _07185_ _07358_ _07360_ _07361_ VDD VSS AOI21_X1
X_16616_ _06882_ _06884_ _07032_ _07362_ VDD VSS NAND3_X1
X_16617_ _06965_ _06920_ _06235_ _07363_ VDD VSS MUX2_X1
X_16618_ _07130_ _07067_ _06291_ _07364_ VDD VSS OAI21_X1
X_16619_ _07264_ _07363_ _06292_ _07364_ _06237_ _07365_ VDD
+ VSS AOI221_X1
X_16620_ _14686_ net778 _06916_ _07366_ VDD VSS AOI21_X1
X_16621_ _07105_ _07366_ _06886_ _07367_ VDD VSS MUX2_X1
X_16622_ net1105 _06935_ _06321_ _07368_ VDD VSS MUX2_X1
X_16623_ _07234_ _07368_ _06886_ _07369_ VDD VSS MUX2_X1
X_16624_ _07367_ _07369_ _06903_ _07370_ VDD VSS MUX2_X1
X_16625_ _06887_ _07002_ _07371_ VDD VSS NOR2_X1
X_16626_ _06998_ _06896_ _07062_ _06915_ _07372_ VDD VSS AOI22_X1
X_16627_ _07240_ _07371_ _06971_ _07372_ _06870_ _07373_ VDD
+ VSS OAI221_X1
X_16628_ _07370_ _07373_ _06929_ _07374_ VDD VSS MUX2_X1
X_16629_ _07361_ _07362_ _07365_ _07374_ _06985_ _07375_ VDD
+ VSS AOI221_X2
X_16630_ _07357_ _07375_ _06874_ _00007_ VDD VSS MUX2_X1
X_16631_ _06475_ _07376_ VDD VSS BUF_X8
X_16632_ _07376_ _07377_ VDD VSS BUF_X16
X_16633_ _07377_ _14692_ VDD VSS BUF_X16
X_16634_ _06503_ _07378_ VDD VSS BUF_X4
X_16635_ _07378_ _07379_ VDD VSS BUF_X8
X_16636_ _07379_ _07380_ VDD VSS BUF_X4
X_16637_ _07380_ _14712_ VDD VSS BUF_X8
X_16638_ _06461_ _07381_ VDD VSS BUF_X8
X_16639_ _07381_ _14693_ VDD VSS BUF_X16
X_16640_ _06550_ _07382_ VDD VSS BUF_X4
X_16641_ _14708_ _07383_ VDD VSS BUF_X4
X_16642_ _06509_ _07384_ VDD VSS BUF_X4
X_16643_ _06521_ _07385_ VDD VSS BUF_X4
X_16644_ _07383_ _07384_ _07385_ _07386_ VDD VSS NAND3_X1
X_16645_ _14699_ _07387_ VDD VSS CLKBUF_X3
X_16646_ _06266_ net46 _07388_ VDD VSS NOR2_X4
X_16647_ _07388_ _07389_ VDD VSS BUF_X4
X_16648_ net18 _06514_ _07390_ VDD VSS NOR2_X1
X_16649_ net18 _06512_ _07391_ VDD VSS NOR2_X1
X_16650_ _07390_ _07391_ _06519_ _07392_ VDD VSS MUX2_X1
X_16651_ _07392_ _07393_ VDD VSS BUF_X4
X_16652_ _07393_ _07394_ VDD VSS BUF_X4
X_16653_ _07387_ _07389_ _07394_ _07395_ VDD VSS OAI21_X2
X_16654_ _06506_ _07386_ _07395_ _07396_ VDD VSS NAND3_X1
X_16655_ _06449_ net504 _07388_ _07393_ _07397_ VDD VSS NOR4_X4
X_16656_ _06267_ net203 _07398_ VDD VSS OR2_X1
X_16657_ _06266_ _06454_ _07399_ VDD VSS NAND2_X1
X_16658_ _06266_ _06452_ _07400_ VDD VSS NAND2_X1
X_16659_ _07399_ _07400_ _06459_ _07401_ VDD VSS MUX2_X2
X_16660_ _07398_ _07401_ _06509_ _06521_ _07402_ VDD VSS AOI22_X4
X_16661_ _07379_ _07397_ _07402_ _07403_ VDD VSS OAI21_X1
X_16662_ _07382_ _07396_ _07403_ _07404_ VDD VSS AND3_X1
X_16663_ _06504_ _06522_ _07405_ VDD VSS NOR2_X4
X_16664_ _14706_ _07406_ VDD VSS BUF_X2
X_16665_ _07406_ _07407_ VDD VSS BUF_X4
Xclone90 _05530_ _05527_ net90 VDD VSS NOR2_X2
X_16667_ _14710_ _07388_ _07393_ _07409_ VDD VSS OAI21_X1
X_16668_ _06522_ _07410_ VDD VSS BUF_X4
X_16669_ _07409_ _07410_ _07387_ _07411_ VDD VSS OAI21_X1
X_16670_ _06505_ _07412_ VDD VSS BUF_X4
X_16671_ _06550_ _07405_ _07407_ _07411_ _07412_ _07413_ VDD
+ VSS AOI221_X1
X_16672_ _06540_ _07404_ _07413_ _07414_ VDD VSS NOR3_X1
X_16673_ _06537_ _07415_ VDD VSS CLKBUF_X3
X_16674_ _07415_ _07416_ VDD VSS BUF_X4
X_16675_ _07416_ _07417_ VDD VSS BUF_X4
X_16676_ _06504_ _06523_ _07418_ VDD VSS NOR2_X1
X_16677_ _07418_ _07419_ VDD VSS BUF_X4
Xclone18 _06226_ net18 VDD VSS BUF_X8
X_16679_ _14704_ _07421_ VDD VSS INV_X1
X_16680_ _14710_ _07384_ _07385_ _07422_ VDD VSS NAND3_X1
X_16681_ _07387_ _07423_ VDD VSS BUF_X4
X_16682_ _07422_ _06524_ _07423_ _07424_ VDD VSS OAI21_X1
X_16683_ _06550_ _07419_ _07421_ _07424_ _07412_ _07425_ VDD
+ VSS AOI221_X1
X_16684_ _14695_ _07426_ VDD VSS BUF_X4
X_16685_ _07426_ _07427_ VDD VSS BUF_X8
X_16686_ _06524_ _07428_ VDD VSS BUF_X4
X_16687_ _06551_ _07419_ _07427_ _14720_ _07428_ _07429_ VDD
+ VSS AOI221_X2
X_16688_ _07417_ _07425_ _07429_ _07430_ VDD VSS NOR3_X1
X_16689_ _07414_ _07430_ _07431_ VDD VSS OR2_X1
X_16690_ _14704_ _06509_ _06521_ _07432_ VDD VSS NAND3_X4
X_16691_ _07426_ _07433_ VDD VSS INV_X8
X_16692_ _07433_ _07388_ _07393_ _07434_ VDD VSS OAI21_X4
X_16693_ _06506_ _07432_ _07434_ _07435_ VDD VSS NAND3_X1
Xclone28 net1011 _06338_ net28 VDD VSS NOR2_X4
X_16695_ _14694_ _07389_ _07394_ _07437_ VDD VSS OAI21_X2
X_16696_ _07379_ _07386_ _07437_ _07438_ VDD VSS NAND3_X1
X_16697_ _07435_ _07438_ _07439_ VDD VSS NAND2_X1
X_16698_ _07426_ _06503_ _06522_ _07440_ VDD VSS NOR3_X4
X_16699_ _06503_ _06523_ _07441_ VDD VSS XNOR2_X2
X_16700_ _07440_ _07441_ _14708_ _14704_ _07418_ _07442_ VDD
+ VSS AOI221_X1
X_16701_ _07439_ _07442_ _07382_ _07443_ VDD VSS MUX2_X1
X_16702_ _07412_ _07444_ VDD VSS CLKBUF_X3
X_16703_ _06524_ _06551_ _07445_ VDD VSS NOR2_X2
X_16704_ _07427_ _07444_ _07445_ _07446_ VDD VSS NAND3_X1
X_16705_ _07410_ _07447_ VDD VSS CLKBUF_X3
X_16706_ _07427_ _07388_ _07393_ _07448_ VDD VSS NOR3_X4
X_16707_ _07377_ _07447_ _07382_ _07448_ _07449_ VDD VSS AOI22_X2
X_16708_ net540 _06523_ _07450_ VDD VSS XNOR2_X2
X_16709_ _07441_ _07450_ _06463_ _07451_ VDD VSS MUX2_X1
X_16710_ _07382_ _07452_ VDD VSS CLKBUF_X3
X_16711_ _07446_ _07449_ _06507_ _07451_ _07452_ _07453_ VDD
+ VSS OAI221_X1
X_16712_ _07443_ _07453_ _06540_ _07454_ VDD VSS MUX2_X1
X_16713_ _06572_ _07455_ VDD VSS BUF_X4
X_16714_ _07431_ _07454_ _07455_ _07456_ VDD VSS MUX2_X1
X_16715_ _06551_ _07457_ VDD VSS BUF_X4
X_16716_ _07416_ _07457_ _07458_ VDD VSS NAND2_X1
X_16717_ _06524_ _07459_ VDD VSS CLKBUF_X3
X_16718_ _07459_ _07460_ VDD VSS BUF_X4
X_16719_ _07427_ _07376_ _06505_ _07461_ VDD VSS MUX2_X1
X_16720_ _07460_ _07461_ _07462_ VDD VSS NOR2_X1
X_16721_ _14704_ _07379_ _07463_ VDD VSS NAND2_X1
X_16722_ _06462_ _06505_ _07464_ VDD VSS NAND2_X1
X_16723_ _06525_ _07463_ _07464_ _07465_ VDD VSS AND3_X1
X_16724_ _14694_ _07466_ VDD VSS INV_X2
X_16725_ _07378_ _07467_ VDD VSS CLKBUF_X3
X_16726_ _07466_ _07467_ _07468_ VDD VSS NOR2_X1
X_16727_ _07459_ _07412_ _07381_ _07469_ VDD VSS OAI21_X1
X_16728_ _07416_ _07468_ _07469_ _07470_ VDD VSS OAI21_X1
Xclone39 _06335_ net39 VDD VSS BUF_X4
X_16730_ _14701_ _07472_ VDD VSS INV_X4
X_16731_ _06503_ _07410_ _07473_ VDD VSS NAND2_X4
X_16732_ _07472_ _07473_ _07474_ VDD VSS NOR2_X1
X_16733_ _07458_ _07462_ _07465_ _07470_ _07474_ _07457_ _07475_
+ VDD VSS OAI33_X1
X_16734_ _06505_ _07476_ VDD VSS BUF_X8
X_16735_ _07476_ _07477_ VDD VSS BUF_X4
X_16736_ _14701_ _07389_ _07394_ _07478_ VDD VSS NOR3_X1
X_16737_ _14710_ _07384_ _07385_ _07479_ VDD VSS AOI21_X2
X_16738_ _07477_ _07478_ _07479_ _07480_ VDD VSS OAI21_X1
X_16739_ _07452_ _07419_ _07383_ _07481_ VDD VSS AOI21_X1
X_16740_ _07417_ _07480_ _07481_ _07482_ VDD VSS AOI21_X1
X_16741_ _07410_ _07483_ VDD VSS CLKBUF_X3
X_16742_ _07483_ _07484_ VDD VSS CLKBUF_X3
X_16743_ _07406_ _07485_ VDD VSS INV_X2
X_16744_ _07448_ _07484_ _07485_ _07486_ VDD VSS AOI21_X1
X_16745_ _07378_ _07487_ VDD VSS BUF_X4
X_16746_ _07487_ _07488_ VDD VSS CLKBUF_X3
X_16747_ _07452_ _07473_ net1143 _07486_ _07488_ _07489_ VDD
+ VSS OAI221_X1
X_16748_ _07475_ _07482_ _07489_ _07490_ VDD VSS AOI21_X1
X_16749_ _07382_ _07491_ VDD VSS BUF_X4
X_16750_ _14710_ _07492_ VDD VSS INV_X1
X_16751_ _07492_ net5 _07378_ _07493_ VDD VSS MUX2_X1
X_16752_ _00385_ _07493_ _07494_ VDD VSS NOR2_X1
X_16753_ _07387_ _07495_ VDD VSS INV_X1
X_16754_ _07495_ _06507_ _07496_ VDD VSS NOR2_X1
X_16755_ _07483_ _07497_ VDD VSS CLKBUF_X3
X_16756_ _07497_ _07487_ _07377_ _07498_ VDD VSS OAI21_X1
X_16757_ _14696_ _07499_ VDD VSS CLKBUF_X3
X_16758_ _07499_ _07500_ VDD VSS CLKBUF_X3
X_16759_ _07500_ _07487_ _07501_ VDD VSS NOR2_X1
X_16760_ _07496_ _07498_ _07501_ _07469_ _07502_ VDD VSS OAI22_X1
X_16761_ _07491_ _07470_ _07494_ _07502_ _07417_ _07503_ VDD
+ VSS OAI221_X2
X_16762_ _06503_ _07410_ _07504_ VDD VSS NOR2_X2
X_16763_ _06449_ net499 _07388_ _07393_ _07505_ VDD VSS OAI22_X4
X_16764_ _07387_ _06509_ _06521_ _07506_ VDD VSS NAND3_X4
X_16765_ _07505_ _07506_ _07507_ VDD VSS NAND2_X1
X_16766_ _06538_ _07504_ _07472_ _07507_ _07467_ _07508_ VDD
+ VSS AOI221_X1
X_16767_ _07433_ _06509_ _06521_ _07509_ VDD VSS NAND3_X4
X_16768_ _07467_ _07505_ _07509_ _07510_ VDD VSS AOI21_X1
X_16769_ _07395_ _07497_ _07500_ _07511_ VDD VSS OAI21_X1
X_16770_ _07510_ _07511_ _07488_ _07512_ VDD VSS AOI21_X1
X_16771_ _07508_ _07512_ _06540_ _07513_ VDD VSS AOI21_X1
X_16772_ _07503_ _07513_ _07491_ _07514_ VDD VSS OAI21_X1
X_16773_ _07490_ _07514_ _07455_ _07515_ VDD VSS MUX2_X1
X_16774_ _07456_ _07515_ _00388_ _00008_ VDD VSS MUX2_X1
X_16775_ _06562_ _07516_ VDD VSS INV_X1
X_16776_ _07516_ _00389_ _07517_ VDD VSS NOR2_X1
X_16777_ _07417_ _07518_ VDD VSS CLKBUF_X3
X_16778_ _14701_ _06509_ _06521_ _07519_ VDD VSS NAND3_X2
X_16779_ _07412_ _07505_ _07519_ _07520_ VDD VSS NAND3_X1
X_16780_ net14 _07460_ _07521_ VDD VSS NAND2_X1
X_16781_ _07383_ _07522_ VDD VSS INV_X1
X_16782_ _07497_ _07523_ VDD VSS CLKBUF_X3
X_16783_ _07522_ _07523_ _07524_ VDD VSS NAND2_X1
X_16784_ _14712_ _07521_ _07524_ _07525_ VDD VSS NAND3_X1
X_16785_ _07518_ _00387_ _07520_ _07525_ _07526_ VDD VSS NAND4_X1
X_16786_ _06507_ _07402_ _07448_ _07527_ VDD VSS NOR3_X2
X_16787_ _07479_ _00385_ _07383_ _07528_ VDD VSS AOI21_X1
X_16788_ _07527_ _07528_ _14717_ _07529_ VDD VSS AOI21_X1
X_16789_ _14694_ _07384_ _07385_ _07530_ VDD VSS NAND3_X2
X_16790_ _07530_ _07460_ _14710_ _07531_ VDD VSS OAI21_X2
X_16791_ _07426_ _06509_ _06521_ _07532_ VDD VSS NAND3_X2
X_16792_ _07532_ _07460_ _07500_ _07533_ VDD VSS OAI21_X1
X_16793_ _07477_ _07534_ VDD VSS BUF_X4
X_16794_ _07531_ _07533_ _07534_ _07535_ VDD VSS MUX2_X1
X_16795_ _07529_ _07535_ _07491_ _07536_ VDD VSS MUX2_X1
X_16796_ _07526_ _07536_ _07518_ _07537_ VDD VSS OAI21_X1
X_16797_ _07457_ _07538_ VDD VSS BUF_X4
X_16798_ _06540_ _07538_ _07539_ VDD VSS NOR2_X1
X_16799_ _07466_ _07384_ _07385_ _07540_ VDD VSS AOI21_X4
X_16800_ _14717_ _07540_ _07448_ _07541_ VDD VSS OAI21_X1
X_16801_ _14698_ _07487_ _07484_ _07542_ VDD VSS NAND3_X2
X_16802_ _07539_ _07541_ _07542_ _07543_ VDD VSS AND3_X1
X_16803_ _07517_ _07537_ _07543_ _07544_ VDD VSS OAI21_X1
X_16804_ _06538_ _06551_ _07545_ VDD VSS NAND2_X2
X_16805_ _07545_ _07405_ _07500_ _07546_ VDD VSS AOI21_X1
X_16806_ net32 _14703_ _00385_ _07547_ VDD VSS MUX2_X1
X_16807_ _07546_ _07547_ _14712_ _07548_ VDD VSS OAI21_X1
X_16808_ _07416_ _07457_ _07549_ VDD VSS NOR2_X2
X_16809_ _14717_ _07402_ _07550_ VDD VSS NOR2_X1
X_16810_ _07550_ _07523_ net1143 _07551_ VDD VSS OAI21_X1
X_16811_ _14708_ _07389_ _07394_ _07552_ VDD VSS OAI21_X1
X_16812_ _07444_ _07532_ _07552_ _07553_ VDD VSS NAND3_X1
X_16813_ _07549_ _07551_ _07553_ _07554_ VDD VSS NAND3_X1
X_16814_ _00388_ _00389_ _07548_ _07554_ _07555_ VDD VSS NAND4_X1
X_16815_ _07378_ _07428_ _07556_ VDD VSS NAND2_X2
X_16816_ _07448_ _07523_ net1143 _07557_ VDD VSS AOI21_X1
X_16817_ _00387_ _07556_ net32 _07557_ _14712_ _07558_ VDD
+ VSS OAI221_X1
X_16818_ _06505_ _06524_ _07559_ VDD VSS XNOR2_X2
X_16819_ net710 _07473_ _07559_ _14693_ _07560_ VDD VSS OAI22_X1
X_16820_ net13 _07483_ _07561_ VDD VSS NOR2_X1
X_16821_ _07560_ _07561_ net709 _07562_ VDD VSS AOI21_X1
X_16822_ _07558_ _07562_ _00387_ _07563_ VDD VSS OAI21_X1
X_16823_ _07518_ _07563_ _07564_ VDD VSS AND2_X1
X_16824_ _14694_ _07412_ _07565_ VDD VSS NAND2_X2
X_16825_ _07523_ _07463_ _07565_ _07566_ VDD VSS NAND3_X1
X_16826_ _14722_ _07497_ _07457_ _07567_ VDD VSS NOR3_X1
X_16827_ _06540_ _07567_ _07568_ VDD VSS NOR2_X1
X_16828_ _07412_ _07505_ _07530_ _07569_ VDD VSS NAND3_X1
X_16829_ _07378_ _07506_ _07552_ _07570_ VDD VSS NAND3_X1
X_16830_ _07569_ _07570_ _07571_ VDD VSS AND2_X1
X_16831_ _07520_ _07450_ _07444_ _07572_ VDD VSS OAI21_X1
X_16832_ _07571_ _07572_ _07382_ _07573_ VDD VSS MUX2_X1
X_16833_ _06573_ _07566_ _07568_ _07573_ _00386_ _07574_ VDD
+ VSS AOI221_X2
X_16834_ _14693_ _14703_ _07497_ _07575_ VDD VSS NAND3_X1
X_16835_ _07423_ _07389_ _07394_ _07576_ VDD VSS NOR3_X2
X_16836_ _07576_ _07497_ net13 _07577_ VDD VSS AOI21_X1
X_16837_ _07575_ _07577_ _07534_ _07578_ VDD VSS OAI21_X1
X_16838_ _07472_ _07389_ _07394_ _07579_ VDD VSS OAI21_X2
X_16839_ _06506_ _07509_ _07579_ _07580_ VDD VSS AOI21_X2
X_16840_ _07580_ _07511_ _07534_ _07581_ VDD VSS AOI21_X1
X_16841_ _07578_ _07581_ _07452_ _07582_ VDD VSS MUX2_X1
X_16842_ _14713_ _06525_ _07583_ VDD VSS AND2_X1
X_16843_ _07472_ net13 _07412_ _07584_ VDD VSS MUX2_X1
X_16844_ _07583_ _07584_ _07484_ _07585_ VDD VSS AOI21_X1
X_16845_ _06507_ _07509_ _07579_ _07586_ VDD VSS NAND3_X1
X_16846_ _07403_ _07586_ _07587_ VDD VSS NAND2_X1
X_16847_ _07585_ _07587_ _06552_ _07588_ VDD VSS MUX2_X1
X_16848_ _07582_ _07588_ _00386_ _07589_ VDD VSS MUX2_X1
X_16849_ _07574_ _07589_ _00389_ _07590_ VDD VSS AOI21_X2
X_16850_ _07544_ _07555_ _07564_ _00388_ _07590_ _00009_ VDD
+ VSS OAI221_X2
X_16851_ _06540_ _07452_ _07591_ VDD VSS NOR2_X2
X_16852_ _07509_ _07552_ _07592_ VDD VSS NAND2_X4
X_16853_ _07591_ _07592_ _14712_ _07556_ _07472_ _07593_ VDD
+ VSS OAI221_X1
X_16854_ _07516_ _00389_ _07593_ _07594_ VDD VSS AND3_X1
X_16855_ _14718_ _00385_ _07419_ _07423_ _07595_ VDD VSS AOI22_X2
X_16856_ _07416_ _07382_ _07596_ VDD VSS NAND2_X2
X_16857_ _14703_ _07444_ _07597_ VDD VSS NAND2_X1
X_16858_ _07597_ _07534_ _07423_ _07598_ VDD VSS OAI21_X1
X_16859_ _14715_ _07598_ _00385_ _07599_ VDD VSS MUX2_X1
X_16860_ _07476_ _06524_ _07600_ VDD VSS NAND2_X2
X_16861_ _14698_ _07600_ _07601_ VDD VSS NOR2_X1
X_16862_ _07601_ _07419_ _14704_ net32 _07441_ _07602_ VDD
+ VSS AOI221_X1
X_16863_ _07599_ _07602_ _00387_ _07603_ VDD VSS MUX2_X1
X_16864_ _07594_ _07595_ _07596_ _07518_ _07603_ _07604_ VDD
+ VSS OAI221_X2
X_16865_ _07433_ _07384_ _07385_ _07605_ VDD VSS AOI21_X4
X_16866_ _06506_ _07605_ _07397_ _07606_ VDD VSS OAI21_X4
X_16867_ _07492_ net5 _07483_ _07607_ VDD VSS MUX2_X1
X_16868_ _07606_ _07607_ _14717_ _07608_ VDD VSS OAI21_X1
X_16869_ _07491_ _07608_ _07609_ VDD VSS NOR2_X1
X_16870_ _07534_ _07579_ _07521_ _07610_ VDD VSS AND3_X1
X_16871_ _07506_ _07460_ _07500_ _07611_ VDD VSS OAI21_X1
X_16872_ _14717_ _07611_ _07612_ VDD VSS NOR2_X1
X_16873_ _00387_ _07610_ _07612_ _07613_ VDD VSS NOR3_X1
X_16874_ _07518_ _07609_ _07613_ _07614_ VDD VSS NOR3_X1
X_16875_ _14717_ _07395_ _07530_ _07615_ VDD VSS AOI21_X1
X_16876_ _07500_ _07600_ _07616_ VDD VSS NOR2_X1
X_16877_ _14701_ _07495_ _07476_ _07617_ VDD VSS MUX2_X1
X_16878_ _07416_ _07617_ _07484_ _07618_ VDD VSS OAI21_X1
X_16879_ _07458_ _07615_ _07616_ _07618_ _07462_ _00387_ _07619_
+ VDD VSS OAI33_X1
X_16880_ _07614_ _07619_ _07620_ VDD VSS NOR2_X1
X_16881_ _07516_ _07455_ _07621_ VDD VSS NAND2_X1
X_16882_ _07485_ _07459_ _07622_ VDD VSS NOR2_X1
X_16883_ net4 net5 _07415_ _07623_ VDD VSS MUX2_X1
X_16884_ _07487_ _07622_ _07623_ _07460_ _07624_ VDD VSS AOI211_X2
X_16885_ _07500_ _07497_ _06539_ _07625_ VDD VSS AND3_X1
X_16886_ _07472_ _07484_ _06539_ _07626_ VDD VSS AOI21_X1
X_16887_ _14717_ _07625_ _07626_ _07627_ VDD VSS NOR3_X1
X_16888_ _07491_ _07624_ _07627_ _07628_ VDD VSS OAI21_X1
X_16889_ _07402_ _07459_ _07485_ _07629_ VDD VSS AOI21_X1
X_16890_ _07499_ _06509_ _06521_ _07630_ VDD VSS AOI21_X4
X_16891_ _07630_ _06525_ net13 _07631_ VDD VSS AOI21_X1
X_16892_ _07629_ _07631_ _07467_ _07632_ VDD VSS MUX2_X1
X_16893_ _07532_ _07460_ _07407_ _07633_ VDD VSS OAI21_X1
X_16894_ _07510_ _07633_ _07380_ _07634_ VDD VSS AOI21_X1
X_16895_ _07632_ _07634_ _07417_ _07635_ VDD VSS MUX2_X1
X_16896_ _07628_ _07635_ _07491_ _07636_ VDD VSS OAI21_X1
X_16897_ _06462_ _06505_ _07376_ _07637_ VDD VSS MUX2_X1
X_16898_ _14722_ _07637_ _07459_ _07638_ VDD VSS MUX2_X1
X_16899_ _07433_ _07379_ _07639_ VDD VSS NAND2_X1
X_16900_ _07483_ _07412_ _07423_ _07640_ VDD VSS AOI21_X1
X_16901_ _14720_ _07497_ _07639_ _07640_ _07641_ VDD VSS AOI22_X1
X_16902_ _07638_ _07641_ _07457_ _07642_ VDD VSS MUX2_X1
X_16903_ _07432_ _07428_ _07376_ _07643_ VDD VSS OAI21_X1
X_16904_ _07643_ _07592_ _07379_ _07644_ VDD VSS MUX2_X1
X_16905_ _14715_ _06461_ _07476_ _07645_ VDD VSS AOI21_X2
X_16906_ _07461_ _07645_ _07459_ _07646_ VDD VSS MUX2_X1
X_16907_ _07644_ _07646_ _07457_ _07647_ VDD VSS MUX2_X1
X_16908_ _07642_ _07647_ _00386_ _07648_ VDD VSS MUX2_X1
X_16909_ _07636_ _07648_ _00389_ _07649_ VDD VSS MUX2_X1
X_16910_ _07604_ _07620_ _07621_ _07516_ _07649_ _00010_ VDD
+ VSS OAI221_X2
X_16911_ net5 _07476_ net4 _07650_ VDD VSS MUX2_X1
X_16912_ _06551_ _07405_ _07423_ _07650_ _07447_ _07651_ VDD
+ VSS AOI221_X2
X_16913_ _07467_ _07432_ _07437_ _07652_ VDD VSS AOI21_X1
X_16914_ _07444_ _07576_ _07605_ _07653_ VDD VSS NOR3_X1
X_16915_ _07452_ _07652_ _07653_ _07654_ VDD VSS NOR3_X1
X_16916_ _07417_ _07651_ _07654_ _07655_ VDD VSS OAI21_X1
X_16917_ _07499_ _07384_ _07385_ _07656_ VDD VSS NAND3_X1
X_16918_ _07407_ _07389_ _07394_ _07657_ VDD VSS OAI21_X1
X_16919_ _06506_ _07656_ _07657_ _07658_ VDD VSS AOI21_X1
X_16920_ _07434_ _07410_ _06476_ _07659_ VDD VSS OAI21_X2
X_16921_ _07658_ _07659_ _06507_ _07660_ VDD VSS AOI21_X1
X_16922_ _06477_ _07428_ _07661_ VDD VSS NAND2_X1
X_16923_ _07606_ _07661_ net3 _07421_ _07473_ _07662_ VDD
+ VSS OAI221_X1
X_16924_ _07660_ _07662_ _06552_ _07663_ VDD VSS MUX2_X1
X_16925_ _07655_ _07663_ _07518_ _07664_ VDD VSS OAI21_X1
X_16926_ _07434_ _07410_ _07406_ _07665_ VDD VSS OAI21_X4
X_16927_ _07379_ _06551_ _07665_ _07445_ _06463_ _07666_ VDD
+ VSS AOI221_X2
X_16928_ _07630_ _07397_ _06551_ _07667_ VDD VSS AOI21_X1
X_16929_ _07380_ _07667_ _07668_ VDD VSS AND2_X1
X_16930_ _07417_ _07666_ _07668_ _07669_ VDD VSS NOR3_X1
X_16931_ _07477_ _07397_ _07540_ _07670_ VDD VSS OAI21_X1
X_16932_ _07406_ _07384_ _07385_ _07671_ VDD VSS NAND3_X1
X_16933_ _07671_ _07459_ _14704_ _07672_ VDD VSS OAI21_X1
X_16934_ _07670_ _07672_ _06507_ _07673_ VDD VSS OAI21_X1
X_16935_ _07412_ _07428_ _07376_ _07674_ VDD VSS OAI21_X1
X_16936_ _07522_ _07504_ _07674_ net3 _07377_ _07419_ _07675_
+ VDD VSS AOI222_X2
X_16937_ _07673_ _07675_ _06552_ _07676_ VDD VSS MUX2_X1
X_16938_ _07669_ _07676_ _07518_ _07677_ VDD VSS AOI21_X1
X_16939_ _07664_ _07677_ _07455_ _07678_ VDD VSS MUX2_X1
X_16940_ _06551_ _07405_ net710 _07645_ _07447_ _07679_ VDD
+ VSS AOI221_X1
X_16941_ _07421_ _07522_ _07428_ _07680_ VDD VSS MUX2_X1
X_16942_ _07509_ _06525_ _06463_ _07681_ VDD VSS OAI21_X1
X_16943_ _07680_ _07681_ _07487_ _07682_ VDD VSS MUX2_X1
X_16944_ _07679_ _07682_ _07538_ _07683_ VDD VSS AOI21_X1
X_16945_ _06461_ _06475_ _06524_ _07684_ VDD VSS NOR3_X1
X_16946_ _06461_ net708 _06523_ _07685_ VDD VSS MUX2_X1
X_16947_ _07684_ _07685_ _07378_ _07504_ net12 _07686_ VDD
+ VSS AOI221_X1
X_16948_ _07477_ _07434_ _07656_ _07687_ VDD VSS NAND3_X1
X_16949_ _07519_ _06525_ _06477_ _07688_ VDD VSS OAI21_X1
X_16950_ _07687_ _07688_ _07444_ _07689_ VDD VSS OAI21_X1
X_16951_ _07686_ _07689_ _06552_ _07690_ VDD VSS MUX2_X1
X_16952_ _07683_ _07690_ _07417_ _07691_ VDD VSS MUX2_X1
X_16953_ _06503_ _06523_ _07692_ VDD VSS NOR2_X2
X_16954_ _07407_ _07559_ _07692_ net709 _07693_ VDD VSS AOI22_X2
X_16955_ _07402_ _06507_ _14693_ _07694_ VDD VSS AOI21_X1
X_16956_ _07542_ _07694_ net12 _14698_ _07600_ _07695_ VDD
+ VSS OAI221_X2
X_16957_ _07397_ _07380_ _14698_ _07696_ VDD VSS AOI21_X1
X_16958_ _07452_ _07696_ _07500_ _07697_ VDD VSS OAI21_X1
X_16959_ _07491_ _07693_ _07695_ _07697_ _07698_ VDD VSS OAI22_X2
X_16960_ _00386_ _07698_ _07699_ VDD VSS NOR2_X1
X_16961_ _14704_ _07384_ _07385_ _07700_ VDD VSS AOI21_X1
X_16962_ _07444_ _07448_ _07700_ _07701_ VDD VSS NOR3_X2
X_16963_ _07701_ _07607_ _07534_ _07702_ VDD VSS AOI21_X1
X_16964_ _07380_ _07422_ _07434_ _07703_ VDD VSS AOI21_X1
X_16965_ _07702_ _07703_ _06552_ _07704_ VDD VSS MUX2_X1
X_16966_ _07455_ _07704_ _07518_ _07705_ VDD VSS OAI21_X2
X_16967_ _07455_ _07691_ _07699_ _07705_ _07706_ VDD VSS OAI22_X1
X_16968_ _07678_ _07706_ _07516_ _00011_ VDD VSS MUX2_X1
X_16969_ _07483_ _07379_ _06463_ _07707_ VDD VSS AOI21_X1
X_16970_ _06538_ _07565_ _07707_ _07708_ VDD VSS AOI21_X2
X_16971_ net12 _07444_ _07709_ VDD VSS NOR2_X1
X_16972_ _07472_ _07487_ _07710_ VDD VSS NOR2_X1
X_16973_ _07523_ _07709_ _07710_ _07711_ VDD VSS OAI21_X1
X_16974_ _07534_ _07416_ _07712_ VDD VSS NOR2_X1
X_16975_ _06573_ _07708_ _07711_ _07712_ _07531_ _07713_ VDD
+ VSS AOI221_X2
X_16976_ _06539_ _07477_ net3 _14724_ _07460_ _07714_ VDD
+ VSS AOI221_X2
X_16977_ _07714_ _07473_ _07383_ _07715_ VDD VSS OAI21_X1
X_16978_ _00386_ _07479_ _07488_ _07523_ _07485_ _07716_ VDD
+ VSS OAI221_X1
X_16979_ _06573_ _07715_ _07716_ _07717_ VDD VSS NAND3_X1
X_16980_ _00387_ _07717_ _07718_ VDD VSS NAND2_X1
X_16981_ _07416_ _07405_ _07383_ _14703_ _06507_ _07719_ VDD
+ VSS AOI221_X1
X_16982_ net709 _07523_ _07720_ VDD VSS NOR2_X1
X_16983_ net14 _07488_ _07721_ VDD VSS NAND2_X1
X_16984_ _00386_ _07720_ _07721_ _07722_ VDD VSS AOI21_X1
X_16985_ _14698_ _07488_ _07723_ VDD VSS NOR2_X1
X_16986_ net14 _07419_ _07723_ _07724_ VDD VSS OAI21_X1
X_16987_ _07719_ _07722_ _07724_ _07725_ VDD VSS AOI21_X1
X_16988_ _14698_ _14703_ _07380_ _07384_ _07385_ _07726_ VDD
+ VSS AOI221_X1
X_16989_ _07455_ _07725_ _07726_ _07727_ VDD VSS NOR3_X1
X_16990_ _07476_ _07410_ _07728_ VDD VSS NAND2_X1
X_16991_ _07417_ _07728_ net709 _07630_ _14717_ _07729_ VDD
+ VSS OAI221_X1
X_16992_ _07519_ _00385_ _07383_ _07730_ VDD VSS OAI21_X1
X_16993_ _07450_ _07730_ _07534_ _07731_ VDD VSS MUX2_X1
X_16994_ _07729_ _07731_ _07518_ _07732_ VDD VSS OAI21_X1
X_16995_ _07491_ _00389_ _07732_ _07733_ VDD VSS OAI21_X1
X_16996_ _00388_ _07713_ _07718_ _07727_ _07733_ _07734_ VDD
+ VSS OAI221_X1
X_16997_ _07444_ _07506_ _07579_ _07735_ VDD VSS AND3_X1
X_16998_ _07630_ _00385_ _14703_ _07736_ VDD VSS AOI21_X1
X_16999_ _07735_ _07736_ _07488_ _07737_ VDD VSS AOI21_X1
X_17000_ _07538_ _14712_ _07407_ _07738_ VDD VSS OAI21_X1
X_17001_ _00386_ _00387_ _07737_ _07738_ _07580_ _07739_ VDD
+ VSS OAI221_X1
X_17002_ _07611_ _07665_ _07488_ _07740_ VDD VSS MUX2_X1
X_17003_ net1143 net14 _07460_ _07741_ VDD VSS MUX2_X1
X_17004_ _07596_ _07741_ _14712_ _07742_ VDD VSS AOI21_X1
X_17005_ _07591_ _07740_ _07742_ _07396_ _07743_ VDD VSS AOI22_X1
X_17006_ _07739_ _07743_ _07744_ VDD VSS AND2_X1
X_17007_ _07407_ _07405_ _07745_ VDD VSS NAND2_X1
X_17008_ _07534_ _07538_ _07395_ _07746_ VDD VSS NAND3_X1
X_17009_ _07746_ _07397_ _07538_ _07747_ VDD VSS OAI21_X1
X_17010_ _07488_ _00385_ _07538_ _07748_ VDD VSS AOI21_X1
X_17011_ _14712_ _07445_ net14 _07749_ VDD VSS AOI21_X1
X_17012_ _07747_ _07748_ net14 _07749_ net709 _07750_ VDD
+ VSS OAI221_X1
X_17013_ _07518_ _07745_ _07750_ _07751_ VDD VSS AOI21_X1
X_17014_ _07437_ _07591_ _07752_ VDD VSS NAND2_X1
X_17015_ net710 _07556_ _07753_ VDD VSS NOR2_X1
X_17016_ _14710_ _07728_ _07754_ VDD VSS NOR2_X1
X_17017_ _07397_ _07523_ _07383_ _07755_ VDD VSS AOI21_X1
X_17018_ _07539_ _07755_ _14717_ _07521_ net709 _07756_ VDD
+ VSS OAI221_X2
X_17019_ _07455_ _07752_ _07753_ _07754_ _07756_ _07757_ VDD
+ VSS OAI221_X2
X_17020_ _07455_ _07744_ _07751_ _07757_ _07758_ VDD VSS OAI22_X1
X_17021_ _07734_ _07758_ _00388_ _00012_ VDD VSS OAI21_X1
X_17022_ _07409_ _07532_ _07759_ VDD VSS NAND2_X1
X_17023_ _07415_ _07692_ _06477_ _07759_ _07378_ _07760_ VDD
+ VSS AOI221_X1
X_17024_ _07499_ _07522_ _07428_ _07761_ VDD VSS MUX2_X1
X_17025_ _07440_ _07761_ _07380_ _07762_ VDD VSS AOI21_X1
X_17026_ _07760_ _07762_ _07417_ _07763_ VDD VSS AOI21_X1
X_17027_ _07497_ _06539_ _07764_ VDD VSS NOR2_X1
X_17028_ _06463_ _07459_ _07415_ _07765_ VDD VSS NOR3_X1
X_17029_ net15 _07764_ _07765_ _07766_ VDD VSS OAI21_X1
X_17030_ _14703_ _07487_ _07497_ _07416_ _07767_ VDD VSS NAND4_X1
X_17031_ _06477_ _06538_ _07768_ VDD VSS NOR2_X1
X_17032_ _14698_ _07419_ _07768_ _07769_ VDD VSS OAI21_X1
X_17033_ _07483_ _07415_ _07770_ VDD VSS NOR2_X1
X_17034_ _07463_ _07565_ _07770_ _07771_ VDD VSS NAND3_X1
X_17035_ _07766_ _07767_ _07769_ _07771_ _07772_ VDD VSS NAND4_X1
X_17036_ _07763_ _07772_ _07538_ _07773_ VDD VSS MUX2_X1
X_17037_ _07423_ _07467_ _07447_ _07774_ VDD VSS NAND3_X1
X_17038_ _07457_ _07774_ _07670_ _07775_ VDD VSS NAND3_X1
X_17039_ _07432_ _07565_ _07460_ _07776_ VDD VSS OAI21_X1
X_17040_ _07775_ _07776_ _06552_ _07777_ VDD VSS OAI21_X1
X_17041_ _07421_ _07388_ _07393_ _07778_ VDD VSS NOR3_X1
X_17042_ _07476_ _07778_ _07630_ _07779_ VDD VSS NOR3_X1
X_17043_ _07467_ _07434_ _07532_ _07780_ VDD VSS AOI21_X1
X_17044_ _07382_ _07779_ _07780_ _07781_ VDD VSS OAI21_X1
X_17045_ _07447_ _07477_ _07472_ _07782_ VDD VSS OAI21_X1
X_17046_ _07782_ _07556_ _07500_ _07783_ VDD VSS OAI21_X1
X_17047_ _07781_ _07783_ _07452_ _07784_ VDD VSS OAI21_X1
X_17048_ _07777_ _07784_ _06540_ _07785_ VDD VSS MUX2_X1
X_17049_ _07773_ _07785_ _07455_ _07786_ VDD VSS MUX2_X1
X_17050_ _07464_ _07394_ _07389_ net1143 _07477_ _07787_ VDD
+ VSS OAI221_X1
X_17051_ _07708_ _07787_ _07788_ VDD VSS NAND2_X1
X_17052_ _07779_ _07692_ _07466_ _07789_ VDD VSS AOI21_X1
X_17053_ _07457_ _07789_ _06539_ _07790_ VDD VSS AOI21_X1
X_17054_ _07381_ _07477_ _07447_ _07791_ VDD VSS NAND3_X1
X_17055_ _06463_ _06477_ _07459_ _07792_ VDD VSS OAI21_X1
X_17056_ _06539_ _07791_ _07792_ _07793_ VDD VSS AOI21_X1
X_17057_ _07509_ _07428_ net5 _07794_ VDD VSS OAI21_X1
X_17058_ _07506_ _07428_ _07407_ _07795_ VDD VSS OAI21_X1
X_17059_ _07794_ _07795_ _07379_ _07796_ VDD VSS MUX2_X1
X_17060_ _07793_ _07796_ _06540_ _07797_ VDD VSS AOI21_X1
X_17061_ _06573_ _07788_ _07790_ _07797_ _07538_ _07798_ VDD
+ VSS AOI221_X2
X_17062_ _07499_ _06477_ _07483_ _07799_ VDD VSS MUX2_X1
X_17063_ _07480_ _07799_ _06507_ _07800_ VDD VSS OAI21_X1
X_17064_ _07397_ _07665_ _06506_ _07801_ VDD VSS MUX2_X1
X_17065_ _07800_ _07801_ _07452_ _07802_ VDD VSS MUX2_X1
X_17066_ _14701_ _07484_ _07506_ _07467_ _07803_ VDD VSS AOI22_X1
X_17067_ _06552_ _07803_ _07804_ VDD VSS NOR2_X1
X_17068_ _07467_ _07519_ _07657_ _07805_ VDD VSS AND3_X1
X_17069_ _07423_ _07381_ _06525_ _07806_ VDD VSS MUX2_X1
X_17070_ _07805_ _07806_ _07534_ _07807_ VDD VSS AOI21_X1
X_17071_ _07804_ _07807_ _07538_ _07808_ VDD VSS AOI21_X1
X_17072_ _07802_ _07808_ _00386_ _07809_ VDD VSS MUX2_X1
X_17073_ _07798_ _07809_ _00389_ _07810_ VDD VSS AOI21_X2
X_17074_ _07786_ _07810_ _00388_ _00013_ VDD VSS MUX2_X1
X_17075_ _06539_ _07600_ _07377_ _07672_ _07444_ _07811_ VDD
+ VSS OAI221_X1
X_17076_ _07452_ _07618_ _07811_ _07812_ VDD VSS AND3_X1
X_17077_ _07485_ _06477_ _06505_ _07813_ VDD VSS MUX2_X1
X_17078_ _14714_ _07813_ _07447_ _07814_ VDD VSS MUX2_X1
X_17079_ _07656_ _06525_ _14698_ _07815_ VDD VSS OAI21_X1
X_17080_ _07440_ _07815_ _07380_ _07816_ VDD VSS AOI21_X1
X_17081_ _07814_ _07816_ _06539_ _07817_ VDD VSS MUX2_X1
X_17082_ _07812_ _07817_ _00387_ _07818_ VDD VSS AOI21_X1
X_17083_ _07495_ _07476_ _07428_ _07819_ VDD VSS NAND3_X1
X_17084_ _07819_ _07559_ _07381_ net12 _07473_ _07820_ VDD
+ VSS OAI221_X1
X_17085_ _07411_ _07659_ _07476_ _07821_ VDD VSS MUX2_X1
X_17086_ _07820_ _07821_ _07457_ _07822_ VDD VSS MUX2_X1
X_17087_ _07433_ _07387_ _07378_ _07823_ VDD VSS MUX2_X1
X_17088_ _14718_ _07823_ _07447_ _07824_ VDD VSS MUX2_X1
X_17089_ _07487_ _07561_ _07700_ _07825_ VDD VSS OAI21_X1
X_17090_ _07382_ _07819_ _07826_ VDD VSS AND2_X1
X_17091_ _06552_ _07824_ _07825_ _07826_ _07827_ VDD VSS AOI22_X1
X_17092_ _07822_ _07827_ _06540_ _07828_ VDD VSS MUX2_X1
X_17093_ _07818_ _07828_ _06573_ _07829_ VDD VSS MUX2_X1
X_17094_ net710 _07419_ _07441_ _14698_ _07830_ VDD VSS AOI22_X1
X_17095_ _07407_ _07504_ _07831_ VDD VSS NAND2_X1
X_17096_ _07549_ _07830_ _07831_ _07832_ VDD VSS NAND3_X1
X_17097_ _07671_ _07459_ _07383_ _07833_ VDD VSS OAI21_X1
X_17098_ _07545_ _07833_ _07477_ _07405_ _14710_ _07834_ VDD
+ VSS AOI221_X2
X_17099_ _14703_ _07397_ _07835_ VDD VSS OR2_X1
X_17100_ _07835_ _07556_ net14 _07836_ VDD VSS OAI21_X1
X_17101_ _07834_ _07836_ _07591_ _07837_ VDD VSS AOI21_X1
X_17102_ _07499_ _07407_ _07378_ _07838_ VDD VSS MUX2_X1
X_17103_ _07596_ _07838_ _07484_ _07839_ VDD VSS AOI21_X2
X_17104_ _07523_ _07488_ net32 _07840_ VDD VSS AOI21_X1
X_17105_ _07840_ _14712_ _14710_ _07841_ VDD VSS OAI21_X1
X_17106_ _06572_ _07839_ _07841_ _07842_ VDD VSS AOI21_X1
X_17107_ _07832_ _07837_ _07842_ _07843_ VDD VSS NAND3_X1
X_17108_ _06506_ _06525_ _06463_ _07844_ VDD VSS AOI21_X1
X_17109_ _06506_ _07665_ _07845_ VDD VSS AND2_X1
X_17110_ net3 _07661_ _07728_ _07499_ _07846_ VDD VSS OAI22_X1
X_17111_ _06463_ _06506_ _07847_ VDD VSS NOR2_X1
X_17112_ _07596_ _07844_ _07845_ _07846_ _07847_ _07545_ _07848_
+ VDD VSS OAI33_X1
X_17113_ _07464_ _07394_ _07389_ _07495_ _07477_ _07849_ VDD
+ VSS OAI221_X1
X_17114_ _07849_ _07484_ _14713_ _07850_ VDD VSS OAI21_X1
X_17115_ _14703_ _07844_ _07851_ VDD VSS NOR2_X1
X_17116_ _07458_ _07851_ _07852_ VDD VSS NOR2_X1
X_17117_ _07601_ _07419_ _07423_ _07853_ VDD VSS AOI21_X1
X_17118_ _07848_ _07850_ _07549_ _07852_ _07853_ _07854_ VDD
+ VSS AOI221_X2
X_17119_ _07843_ _07854_ _00389_ _07855_ VDD VSS OAI21_X1
X_17120_ _07829_ _07855_ _00388_ _00014_ VDD VSS MUX2_X1
X_17121_ _07415_ _07473_ _07492_ net32 _07410_ _07856_ VDD
+ VSS OAI221_X1
X_17122_ _07519_ _06524_ _07387_ _07857_ VDD VSS OAI21_X1
X_17123_ _07450_ _07857_ _06505_ _07858_ VDD VSS MUX2_X1
X_17124_ _07856_ _07858_ _07415_ _07859_ VDD VSS OAI21_X1
X_17125_ _06522_ _06538_ _07860_ VDD VSS NAND2_X1
X_17126_ _06523_ _07415_ _07861_ VDD VSS NAND2_X1
X_17127_ _07860_ _07861_ _06475_ _07862_ VDD VSS OAI21_X1
X_17128_ _06505_ _06524_ _06538_ _07863_ VDD VSS NOR3_X1
X_17129_ _06573_ _07862_ net4 _07863_ _07466_ _07864_ VDD
+ VSS AOI221_X2
X_17130_ _07476_ _07483_ _07415_ _07865_ VDD VSS NAND3_X1
X_17131_ _06477_ _07556_ _07865_ _07866_ VDD VSS AOI21_X1
X_17132_ _07447_ _07415_ _07464_ _07867_ VDD VSS NOR3_X1
X_17133_ _07866_ _07867_ _07868_ VDD VSS NOR2_X1
X_17134_ _07382_ _06573_ _07859_ _07864_ _07868_ _07869_ VDD
+ VSS AOI221_X2
X_17135_ _14720_ _07870_ VDD VSS INV_X1
X_17136_ _06539_ _00385_ _07870_ _07871_ VDD VSS OAI21_X1
X_17137_ _07440_ _07527_ _07871_ _07872_ VDD VSS NOR3_X1
X_17138_ _07416_ _07394_ _07389_ _07485_ _07487_ _07873_ VDD
+ VSS OAI221_X2
X_17139_ _06573_ _07709_ _07873_ _07861_ _14724_ _07874_ VDD
+ VSS OAI221_X2
X_17140_ _07466_ _07473_ _07861_ _07875_ VDD VSS AOI21_X1
X_17141_ _07379_ _07483_ _07427_ _07770_ _07423_ _07876_ VDD
+ VSS AOI221_X2
X_17142_ _06572_ _07712_ _07876_ _07877_ VDD VSS OAI21_X1
X_17143_ _07872_ _07874_ _07875_ _07877_ _07878_ VDD VSS OAI22_X2
X_17144_ _00388_ _07869_ _07878_ _07491_ _07879_ VDD VSS AOI211_X2
X_17145_ _07380_ _07432_ _07437_ _07880_ VDD VSS NAND3_X1
X_17146_ _06552_ _07553_ _07880_ _07881_ VDD VSS AND3_X1
X_17147_ _07383_ _07380_ _07882_ VDD VSS NOR2_X1
X_17148_ _07409_ _07523_ net14 _07883_ VDD VSS OAI21_X1
X_17149_ _07882_ _07883_ _07488_ _07884_ VDD VSS AOI21_X1
X_17150_ _07881_ _07884_ _07491_ _07885_ VDD VSS AOI21_X1
X_17151_ _07447_ net13 net3 _07886_ VDD VSS AOI21_X1
X_17152_ _07472_ _07484_ _07597_ _07886_ _07887_ VDD VSS AOI22_X1
X_17153_ _06463_ _06477_ _07410_ _07888_ VDD VSS MUX2_X1
X_17154_ _07671_ _06525_ _14694_ _07889_ VDD VSS OAI21_X1
X_17155_ _07888_ _07889_ _07467_ _07890_ VDD VSS MUX2_X1
X_17156_ _07887_ _07890_ _07538_ _07891_ VDD VSS MUX2_X1
X_17157_ _07885_ _07891_ _00386_ _07892_ VDD VSS MUX2_X1
X_17158_ _07407_ _07556_ _07736_ _14712_ _07893_ VDD VSS OAI22_X1
X_17159_ _07545_ _07550_ _07530_ _07894_ VDD VSS AOI21_X1
X_17160_ _07591_ _07893_ _07894_ _07396_ _07895_ VDD VSS AOI22_X1
X_17161_ _07484_ _07645_ _07896_ VDD VSS OR2_X1
X_17162_ _07542_ _07600_ _07500_ net12 _07559_ _07897_ VDD
+ VSS OAI221_X2
X_17163_ _06573_ _07896_ _07839_ _07897_ _07549_ _07898_ VDD
+ VSS AOI221_X2
X_17164_ _00389_ _07892_ _07895_ _07898_ _07899_ VDD VSS AOI22_X2
X_17165_ _07879_ _07899_ _00388_ _00015_ VDD VSS AOI21_X2
X_17166_ _06351_ _14726_ VDD VSS BUF_X8
X_17167_ _06379_ _07900_ VDD VSS BUF_X8
X_17168_ _07900_ _07901_ VDD VSS BUF_X4
X_17169_ _07901_ _14746_ VDD VSS BUF_X4
X_17170_ _06335_ _07902_ VDD VSS BUF_X8
X_17171_ _07902_ _14727_ VDD VSS BUF_X16
X_17172_ _06411_ _07903_ VDD VSS BUF_X4
X_17173_ _07903_ _07904_ VDD VSS BUF_X4
X_17174_ _14729_ _07905_ VDD VSS BUF_X4
X_17175_ _07905_ _07906_ VDD VSS INV_X8
X_17176_ _06398_ _07907_ VDD VSS BUF_X4
X_17177_ _06381_ _07907_ _07908_ VDD VSS NAND2_X2
X_17178_ _07906_ _06447_ _07908_ _07909_ VDD VSS NOR3_X1
X_17179_ _06399_ _07910_ VDD VSS BUF_X4
X_17180_ _07910_ _07911_ VDD VSS CLKBUF_X3
X_17181_ _14754_ _07911_ _06447_ _07912_ VDD VSS AND3_X1
Xrebuffer508 _15297_ net1131 VDD VSS BUF_X4
X_17183_ _06218_ net116 _07914_ VDD VSS NOR2_X4
X_17184_ _07914_ _07915_ VDD VSS BUF_X4
X_17185_ _07915_ _07916_ VDD VSS BUF_X4
X_17186_ net16 _06390_ _07917_ VDD VSS NOR2_X1
X_17187_ _06245_ _06388_ _07918_ VDD VSS NOR2_X1
X_17188_ _07917_ _07918_ _06395_ _07919_ VDD VSS MUX2_X2
X_17189_ _07919_ _07920_ VDD VSS BUF_X4
X_17190_ _07920_ _07921_ VDD VSS BUF_X4
X_17191_ net1082 _07916_ _07921_ _06447_ _06351_ _07922_ VDD
+ VSS OAI221_X1
X_17192_ net70 _07923_ VDD VSS INV_X1
X_17193_ _06401_ _07923_ _07924_ VDD VSS NAND2_X1
X_17194_ _06266_ _06344_ _07925_ VDD VSS NAND2_X1
X_17195_ _06266_ _06342_ _07926_ VDD VSS NAND2_X1
X_17196_ _07925_ _07926_ net1063 _07927_ VDD VSS MUX2_X1
X_17197_ _07924_ _07927_ _06385_ _06397_ _07928_ VDD VSS AOI22_X4
X_17198_ net1082 _06446_ _07928_ _07929_ VDD VSS OR3_X1
X_17199_ _06383_ _07922_ _07929_ _07930_ VDD VSS AOI21_X1
X_17200_ _07904_ _07909_ _07912_ _07930_ _07931_ VDD VSS NOR4_X1
Xsplit101 net480 net101 VDD VSS BUF_X8
X_17202_ net918 _07915_ _07920_ _07933_ VDD VSS OAI21_X4
X_17203_ _06385_ _07934_ VDD VSS BUF_X4
X_17204_ _06397_ _07935_ VDD VSS BUF_X4
X_17205_ _14742_ _07934_ _07935_ _07936_ VDD VSS NAND3_X2
X_17206_ _06381_ _07933_ _07936_ _07937_ VDD VSS NAND3_X4
X_17207_ _14732_ _00400_ _07938_ VDD VSS XNOR2_X1
X_17208_ _06447_ _07937_ _07938_ _14751_ _07939_ VDD VSS OAI211_X2
X_17209_ net1082 _07940_ VDD VSS BUF_X16
X_17210_ _07940_ _06383_ _00400_ _07941_ VDD VSS NAND3_X1
X_17211_ _06381_ _06399_ _07942_ VDD VSS XNOR2_X2
X_17212_ _14742_ _07943_ VDD VSS CLKBUF_X3
X_17213_ _07900_ _07907_ _07944_ VDD VSS NAND2_X4
Xclone27 net28 net27 VDD VSS BUF_X4
X_17215_ _07941_ _07942_ _07943_ _07944_ net88 _07946_ VDD
+ VSS OAI221_X2
X_17216_ _07939_ _07946_ _06448_ _07947_ VDD VSS OAI21_X1
X_17217_ _07904_ _07948_ VDD VSS CLKBUF_X3
X_17218_ _07931_ _07947_ _07948_ _07949_ VDD VSS AOI21_X1
X_17219_ _07900_ _07950_ VDD VSS CLKBUF_X3
Xclone93 net869 net93 VDD VSS BUF_X4
X_17221_ net913 _07916_ _07921_ _07952_ VDD VSS NOR3_X1
X_17222_ _07950_ _07928_ _07952_ _07953_ VDD VSS NOR3_X1
X_17223_ _06397_ _06334_ _06324_ _06267_ net116 _07954_ VDD
+ VSS OAI221_X1
X_17224_ _07954_ _07955_ VDD VSS CLKBUF_X3
X_17225_ _07933_ _07955_ _07956_ VDD VSS AND2_X1
X_17226_ _06379_ _07957_ VDD VSS CLKBUF_X3
X_17227_ _07957_ _07958_ VDD VSS BUF_X4
X_17228_ _07953_ _07956_ _07958_ _07959_ VDD VSS AOI21_X1
Xclone446 _01604_ net1070 VDD VSS BUF_X8
X_17230_ _14728_ _07961_ VDD VSS CLKBUF_X3
X_17231_ _07961_ _06382_ _07962_ VDD VSS NAND2_X1
X_17232_ _06379_ _07963_ VDD VSS CLKBUF_X3
X_17233_ _07907_ _07963_ _06337_ _07964_ VDD VSS AOI21_X1
X_17234_ _06412_ _07962_ _07964_ _07965_ VDD VSS AOI21_X2
X_17235_ _07907_ _07966_ VDD VSS CLKBUF_X3
X_17236_ _07966_ _07967_ VDD VSS CLKBUF_X3
X_17237_ _14744_ _07968_ VDD VSS CLKBUF_X3
X_17238_ _07968_ _06352_ _07900_ _07969_ VDD VSS MUX2_X1
X_17239_ _07967_ _07969_ _07970_ VDD VSS NAND2_X1
X_17240_ _06414_ _07959_ _07965_ _07970_ _07971_ VDD VSS AOI22_X1
X_17241_ _14728_ _07972_ VDD VSS INV_X1
X_17242_ _06381_ _07973_ VDD VSS BUF_X4
X_17243_ _07973_ _07974_ VDD VSS BUF_X4
X_17244_ _07907_ _07975_ VDD VSS BUF_X4
X_17245_ _07975_ _06412_ _07976_ VDD VSS NOR2_X1
X_17246_ _07972_ _07974_ _07976_ _07977_ VDD VSS NAND3_X1
X_17247_ _07906_ _07915_ _07920_ _07978_ VDD VSS NOR3_X4
X_17248_ _07957_ _06400_ _07979_ VDD VSS NOR2_X1
Xclone43 net1104 net43 VDD VSS INV_X2
X_17250_ _14740_ _07981_ VDD VSS CLKBUF_X3
X_17251_ _07978_ _07979_ _07981_ _07982_ VDD VSS AOI21_X1
X_17252_ _14735_ _07983_ VDD VSS BUF_X8
X_17253_ net1135 _07916_ _07921_ _07984_ VDD VSS OAI21_X4
X_17254_ _07911_ _06412_ net39 _07985_ VDD VSS OAI21_X1
X_17255_ _07984_ _07985_ _07986_ VDD VSS AND2_X1
X_17256_ _07977_ _07982_ _07904_ _14751_ _07986_ _07987_ VDD
+ VSS OAI221_X1
X_17257_ _07971_ _07987_ _06447_ _07988_ VDD VSS MUX2_X1
X_17258_ _07949_ _07988_ _00403_ _07989_ VDD VSS MUX2_X1
X_17259_ _06351_ _06379_ _06335_ _07990_ VDD VSS MUX2_X1
X_17260_ _07975_ _07990_ _07991_ VDD VSS XNOR2_X1
X_17261_ net9 _07992_ VDD VSS INV_X1
X_17262_ net525 _06385_ _06397_ _07992_ _06401_ _07993_ VDD
+ VSS AOI221_X1
X_17263_ _07993_ _07994_ VDD VSS CLKBUF_X3
X_17264_ _07978_ _07994_ _07995_ VDD VSS OR2_X1
X_17265_ net916 _06385_ _06397_ _07996_ VDD VSS AOI21_X4
X_17266_ _14730_ _07997_ VDD VSS INV_X1
X_17267_ _07997_ _07915_ _07920_ _07998_ VDD VSS NOR3_X2
X_17268_ _07996_ _07998_ _07999_ VDD VSS OR2_X1
X_17269_ _07995_ _07999_ _07963_ _08000_ VDD VSS MUX2_X1
X_17270_ _07991_ _08000_ _06438_ _08001_ VDD VSS MUX2_X1
X_17271_ _06381_ _06399_ _08002_ VDD VSS NAND2_X4
X_17272_ _14733_ _08003_ VDD VSS INV_X2
X_17273_ _08003_ _07914_ _07919_ _08004_ VDD VSS NOR3_X4
X_17274_ net1013 _07967_ _06337_ _08005_ VDD VSS AOI21_X1
X_17275_ _06438_ _08002_ net1135 _08005_ _06383_ _08006_ VDD
+ VSS OAI221_X1
X_17276_ _06380_ _08007_ VDD VSS BUF_X4
X_17277_ _08007_ _08008_ VDD VSS BUF_X4
X_17278_ net1030 _07934_ _07935_ _08009_ VDD VSS NAND3_X2
X_17279_ _07906_ _07916_ _07921_ _08010_ VDD VSS OAI21_X4
X_17280_ _08008_ _08009_ net1150 _08011_ VDD VSS NAND3_X1
X_17281_ _14728_ _07915_ _07920_ _08012_ VDD VSS OAI21_X2
X_17282_ _07950_ _07936_ _08012_ _08013_ VDD VSS NAND3_X1
X_17283_ _08011_ _08013_ _08014_ VDD VSS AND2_X1
X_17284_ _08006_ _08014_ _06438_ _08015_ VDD VSS OAI21_X1
X_17285_ _08001_ _08015_ _07904_ _08016_ VDD VSS MUX2_X1
X_17286_ _07981_ _07963_ _06400_ _08017_ VDD VSS NAND3_X1
X_17287_ _14744_ _07934_ _07935_ _08018_ VDD VSS AOI21_X2
X_17288_ _08004_ _08018_ _08019_ VDD VSS OR2_X1
X_17289_ _08017_ _08019_ _07950_ _08020_ VDD VSS OAI21_X1
X_17290_ _06324_ net525 _07914_ _07919_ _08021_ VDD VSS NOR4_X4
X_17291_ _08007_ _07928_ _08021_ _08022_ VDD VSS OAI21_X1
X_17292_ _07905_ _07915_ _07920_ _08023_ VDD VSS OAI21_X4
X_17293_ _07957_ _08009_ _08023_ _08024_ VDD VSS NAND3_X1
X_17294_ _08022_ _08024_ _08025_ VDD VSS NAND2_X1
X_17295_ _08020_ _08025_ _06438_ _08026_ VDD VSS MUX2_X1
X_17296_ _07996_ _07910_ _07968_ _08027_ VDD VSS AOI21_X1
X_17297_ net1031 _07944_ _08027_ _07957_ _08028_ VDD VSS OAI22_X1
X_17298_ _07983_ _07915_ _07920_ _08029_ VDD VSS NOR3_X4
X_17299_ _06382_ _08018_ _08029_ _08030_ VDD VSS OAI21_X1
X_17300_ _07943_ _07963_ _07966_ _08031_ VDD VSS NAND3_X1
X_17301_ _08030_ _08031_ _08032_ VDD VSS AND2_X1
X_17302_ _08028_ _08032_ _06438_ _08033_ VDD VSS MUX2_X1
X_17303_ _06413_ _08034_ VDD VSS BUF_X4
X_17304_ _08026_ _08033_ _08034_ _08035_ VDD VSS MUX2_X1
X_17305_ _08016_ _08035_ _00404_ _08036_ VDD VSS MUX2_X1
X_17306_ _07989_ _08036_ _00402_ _00016_ VDD VSS MUX2_X1
X_17307_ _14756_ _07975_ _06426_ _08037_ VDD VSS OR3_X1
X_17308_ net88 _07950_ _08038_ VDD VSS NAND2_X1
X_17309_ _07967_ _07962_ _08038_ _08039_ VDD VSS NAND3_X1
X_17310_ _06413_ _08037_ _08039_ _08040_ VDD VSS AOI21_X2
X_17311_ net917 _07934_ _07935_ _08041_ VDD VSS NAND3_X1
X_17312_ _07943_ _07916_ _07921_ _08042_ VDD VSS OAI21_X1
X_17313_ _06382_ _08041_ _08042_ _08043_ VDD VSS AOI21_X1
X_17314_ _07994_ _07910_ _07972_ _08044_ VDD VSS AOI21_X2
X_17315_ _08043_ _08044_ _08008_ _08045_ VDD VSS AOI21_X1
X_17316_ _06338_ net1010 _07914_ _07919_ _08046_ VDD VSS NOR4_X4
X_17317_ _08007_ _07928_ _08046_ _08047_ VDD VSS NOR3_X2
X_17318_ _07994_ _08029_ _08048_ VDD VSS OR2_X1
X_17319_ _08047_ _08048_ _08008_ _08049_ VDD VSS AOI21_X1
X_17320_ _06425_ _08050_ VDD VSS BUF_X4
X_17321_ _08045_ _08049_ _08050_ _08051_ VDD VSS MUX2_X1
X_17322_ _06447_ _08040_ _08051_ _08034_ _08052_ VDD VSS AOI211_X2
X_17323_ net916 _07915_ _07920_ _08053_ VDD VSS NOR3_X2
X_17324_ _06350_ _06385_ _06397_ _07923_ _06401_ _08054_ VDD
+ VSS AOI221_X1
X_17325_ _08054_ _08055_ VDD VSS CLKBUF_X3
X_17326_ _07901_ _08053_ _08055_ _08056_ VDD VSS OAI21_X1
X_17327_ _06425_ _08057_ VDD VSS BUF_X4
X_17328_ _08057_ _07928_ net39 _08058_ VDD VSS AOI21_X1
X_17329_ net1082 _07934_ _07935_ _08059_ VDD VSS NAND3_X4
X_17330_ _07963_ _08059_ _07984_ _08060_ VDD VSS NAND3_X4
X_17331_ _08060_ _07999_ _07958_ _08061_ VDD VSS OAI21_X1
X_17332_ _06413_ _08056_ _08058_ _08061_ _08050_ _08062_ VDD
+ VSS AOI221_X2
X_17333_ _07957_ _08059_ _07984_ _08063_ VDD VSS AOI21_X1
X_17334_ net39 _07911_ _08064_ VDD VSS XNOR2_X1
X_17335_ _07950_ _08065_ VDD VSS CLKBUF_X3
X_17336_ _08050_ _08063_ _08064_ _08065_ _08066_ VDD VSS AOI211_X2
X_17337_ _14735_ _08067_ VDD VSS INV_X2
X_17338_ _08067_ net29 _08008_ _08068_ VDD VSS MUX2_X1
X_17339_ _07975_ _08069_ VDD VSS CLKBUF_X3
X_17340_ _14747_ _08068_ _08069_ _08070_ VDD VSS MUX2_X1
X_17341_ _08050_ _08071_ VDD VSS CLKBUF_X3
X_17342_ _08066_ _08070_ _08071_ _08072_ VDD VSS AOI21_X1
X_17343_ _08062_ _08072_ _00401_ _08073_ VDD VSS AOI21_X1
X_17344_ _08052_ _08073_ _00404_ _08074_ VDD VSS AOI21_X1
X_17345_ _07900_ _07910_ _08075_ VDD VSS NAND2_X4
X_17346_ _08046_ _08069_ _07972_ _08076_ VDD VSS AOI21_X1
X_17347_ _06427_ _08075_ _07997_ _08076_ _14746_ _08077_ VDD
+ VSS OAI221_X1
X_17348_ _08057_ _08078_ VDD VSS CLKBUF_X3
X_17349_ _07905_ _07915_ _07920_ _08079_ VDD VSS NOR3_X4
X_17350_ _14742_ _07934_ _07935_ _08080_ VDD VSS AOI21_X2
X_17351_ _07974_ _08079_ _08080_ _08081_ VDD VSS OAI21_X1
X_17352_ _08067_ _07915_ _07920_ _08082_ VDD VSS NOR3_X4
X_17353_ _08065_ _07994_ _08082_ _08083_ VDD VSS OAI21_X1
X_17354_ _08078_ _08081_ _08083_ _08084_ VDD VSS NAND3_X1
X_17355_ _08034_ _08077_ _08084_ _08085_ VDD VSS NAND3_X1
X_17356_ _08079_ _08069_ net1135 _08086_ VDD VSS AOI21_X1
X_17357_ _06427_ _08075_ _07961_ _08086_ _08065_ _08087_ VDD
+ VSS OAI221_X1
X_17358_ _06337_ net28 _07966_ _08088_ VDD VSS NOR3_X1
X_17359_ _06379_ _06399_ _08089_ VDD VSS XNOR2_X1
X_17360_ _06380_ _06399_ _08090_ VDD VSS NOR2_X4
X_17361_ _08088_ _08089_ _06337_ _07940_ _08090_ _08091_ VDD
+ VSS AOI221_X2
X_17362_ _06426_ _08092_ VDD VSS CLKBUF_X3
X_17363_ _08092_ _08093_ VDD VSS CLKBUF_X3
X_17364_ _08087_ _08091_ _08093_ _08094_ VDD VSS OAI21_X1
X_17365_ _08085_ _08094_ _00401_ _08095_ VDD VSS OAI21_X1
X_17366_ _08012_ _07966_ net1082 _08096_ VDD VSS OAI21_X1
X_17367_ _14732_ _08090_ _08096_ _07973_ _08097_ VDD VSS AOI22_X1
X_17368_ _07957_ _08046_ _08080_ _08098_ VDD VSS OAI21_X1
X_17369_ _08098_ _08048_ _07901_ _08099_ VDD VSS OAI21_X1
X_17370_ _08097_ _08099_ _08092_ _08100_ VDD VSS MUX2_X1
X_17371_ net913 _06385_ _06397_ _08101_ VDD VSS AOI21_X4
X_17372_ _07978_ _07900_ _08101_ _08102_ VDD VSS OR3_X2
X_17373_ _07961_ _07934_ _07935_ _08103_ VDD VSS NAND3_X1
X_17374_ _08103_ _07910_ _07968_ _08104_ VDD VSS OAI21_X1
X_17375_ _08102_ _08104_ _08008_ _08105_ VDD VSS OAI21_X1
X_17376_ _07957_ _07994_ _07978_ _08106_ VDD VSS OAI21_X1
X_17377_ _07936_ _06400_ _07968_ _08107_ VDD VSS OAI21_X1
X_17378_ _08106_ _08107_ _07901_ _08108_ VDD VSS OAI21_X1
X_17379_ _08105_ _08108_ _08092_ _08109_ VDD VSS MUX2_X1
X_17380_ _08100_ _08109_ _06414_ _08110_ VDD VSS MUX2_X1
X_17381_ _06447_ _08111_ VDD VSS INV_X2
X_17382_ _08095_ _08110_ _08111_ _08112_ VDD VSS MUX2_X1
X_17383_ _08074_ _08112_ _00403_ _00017_ VDD VSS MUX2_X1
X_17384_ _06381_ _07907_ _08113_ VDD VSS NOR2_X4
X_17385_ _07978_ _08080_ _08114_ VDD VSS OR2_X1
X_17386_ _08057_ _08113_ net1135 _08114_ _07974_ _08115_ VDD
+ VSS AOI221_X2
X_17387_ net916 _07950_ _07975_ _08116_ VDD VSS NAND3_X1
X_17388_ _14752_ _06400_ _08117_ VDD VSS NAND2_X1
X_17389_ _08093_ _08116_ _08117_ _08118_ VDD VSS AOI21_X1
X_17390_ _07948_ _08115_ _08118_ _08119_ VDD VSS OAI21_X1
X_17391_ _08003_ _06352_ _06382_ _08120_ VDD VSS MUX2_X1
X_17392_ _14749_ _08120_ _00400_ _08121_ VDD VSS MUX2_X1
X_17393_ _06337_ _08007_ _07910_ _08122_ VDD VSS NAND3_X1
X_17394_ _08122_ _07944_ net88 _07961_ _07942_ _08123_ VDD
+ VSS OAI221_X1
X_17395_ _08121_ _08123_ _08093_ _08124_ VDD VSS MUX2_X1
X_17396_ _08119_ _08124_ _07948_ _08125_ VDD VSS OAI21_X1
X_17397_ _07973_ _08126_ VDD VSS CLKBUF_X3
X_17398_ _08126_ _07933_ _08103_ _08127_ VDD VSS AOI21_X1
X_17399_ net914 _08002_ _08128_ VDD VSS NOR2_X1
X_17400_ _08034_ _08071_ _08127_ _08128_ _08129_ VDD VSS NOR4_X1
X_17401_ _07983_ _07934_ _07935_ _08130_ VDD VSS AOI21_X4
X_17402_ _08065_ _08046_ _08130_ _08131_ VDD VSS NOR3_X1
X_17403_ _08126_ net1014 _08101_ _08132_ VDD VSS NOR3_X1
X_17404_ _08093_ _08131_ _08132_ _08133_ VDD VSS NOR3_X1
X_17405_ _07968_ _07916_ _07921_ _08134_ VDD VSS NOR3_X1
X_17406_ _08126_ _08055_ _08134_ _08135_ VDD VSS NOR3_X1
X_17407_ _07955_ _08010_ _08136_ VDD VSS AND2_X1
X_17408_ _08135_ _08136_ _14751_ _08137_ VDD VSS AOI21_X1
X_17409_ _08133_ _08137_ _00402_ _08138_ VDD VSS AOI21_X1
X_17410_ _08129_ _08138_ _00401_ _08139_ VDD VSS AOI21_X1
X_17411_ _07904_ _08078_ _08140_ VDD VSS NAND2_X1
X_17412_ _08067_ net917 _07974_ _08141_ VDD VSS MUX2_X1
X_17413_ _08140_ _08141_ _00400_ _08142_ VDD VSS AOI21_X1
X_17414_ net27 _07958_ _08143_ VDD VSS NOR2_X1
X_17415_ net1082 _06382_ _08144_ VDD VSS NOR2_X1
X_17416_ _08069_ _08143_ _08144_ _08145_ VDD VSS OAI21_X1
X_17417_ _06448_ _08142_ _08145_ _08146_ VDD VSS AOI21_X1
X_17418_ _00404_ _08125_ _08139_ _08146_ _08147_ VDD VSS AOI22_X1
X_17419_ _14740_ _06385_ _06397_ _08148_ VDD VSS AOI21_X4
X_17420_ _07978_ _08148_ _08149_ VDD VSS NOR2_X1
X_17421_ _07995_ _08149_ _07963_ _08150_ VDD VSS MUX2_X1
X_17422_ _08148_ _07910_ _06352_ _08151_ VDD VSS AOI21_X1
X_17423_ _07983_ _08151_ _06382_ _08152_ VDD VSS MUX2_X1
X_17424_ _08150_ _08152_ _08057_ _08153_ VDD VSS MUX2_X1
X_17425_ _06381_ _08046_ _08101_ _08154_ VDD VSS NOR3_X1
X_17426_ _14740_ _06335_ _07907_ _08155_ VDD VSS MUX2_X1
X_17427_ _06425_ _08154_ _08155_ _06382_ _08156_ VDD VSS AOI211_X2
X_17428_ _08008_ _08029_ _08101_ _08157_ VDD VSS NOR3_X1
X_17429_ _08148_ _07911_ _14732_ _08158_ VDD VSS AOI21_X1
X_17430_ _08157_ _08158_ _07974_ _08159_ VDD VSS AOI21_X1
X_17431_ _08156_ _08159_ _08078_ _08160_ VDD VSS AOI21_X1
X_17432_ _08153_ _08160_ _06414_ _08161_ VDD VSS MUX2_X1
X_17433_ _14754_ _07966_ _08162_ VDD VSS NAND2_X1
X_17434_ _08007_ _08053_ _08163_ VDD VSS NAND2_X1
X_17435_ _07903_ _08162_ _08163_ _08164_ VDD VSS NAND3_X1
X_17436_ _06411_ _07910_ _14749_ _08165_ VDD VSS AOI21_X1
X_17437_ _08022_ _08165_ _08166_ VDD VSS NAND2_X1
X_17438_ net1082 _07934_ _07935_ _08167_ VDD VSS AOI21_X4
X_17439_ _08167_ _06412_ _14754_ _08168_ VDD VSS OAI21_X1
X_17440_ _07978_ _06411_ _14749_ _08169_ VDD VSS OAI21_X1
X_17441_ _08168_ _08169_ _08170_ VDD VSS NAND2_X1
X_17442_ _08057_ _08164_ _08166_ _08170_ _07958_ _08171_ VDD
+ VSS AOI221_X2
X_17443_ _06336_ _08007_ net28 _08172_ VDD VSS MUX2_X1
X_17444_ _14756_ _08172_ _07911_ _08173_ VDD VSS MUX2_X1
X_17445_ _06338_ net1012 _07916_ _07921_ _08174_ VDD VSS OAI22_X2
X_17446_ _07973_ _08174_ _08009_ _08175_ VDD VSS AND3_X1
X_17447_ _08175_ _08114_ _07958_ _08176_ VDD VSS AOI21_X1
X_17448_ _08173_ _08176_ _06413_ _08177_ VDD VSS MUX2_X1
X_17449_ _08171_ _08177_ _08071_ _08178_ VDD VSS AOI21_X1
X_17450_ _08161_ _08178_ _00404_ _08179_ VDD VSS MUX2_X1
X_17451_ _08147_ _08179_ _00403_ _00018_ VDD VSS MUX2_X1
X_17452_ _07943_ _07916_ _07921_ _08180_ VDD VSS NOR3_X1
X_17453_ net1030 _07934_ _07935_ _08181_ VDD VSS AOI21_X4
X_17454_ _14746_ _08180_ _08181_ _08182_ VDD VSS NOR3_X1
X_17455_ _14751_ _07994_ _08079_ _08183_ VDD VSS NOR3_X1
X_17456_ _08071_ _08182_ _08183_ _08184_ VDD VSS NOR3_X1
X_17457_ _14749_ _07911_ _08185_ VDD VSS OR2_X1
X_17458_ _06337_ _07957_ _08186_ VDD VSS NOR2_X1
X_17459_ _07940_ _08075_ _08185_ _08186_ _08187_ VDD VSS OAI22_X1
X_17460_ _08034_ _00402_ _08187_ _08188_ VDD VSS OAI21_X1
X_17461_ _07994_ _08046_ _08189_ VDD VSS NOR2_X1
X_17462_ _07941_ _08189_ _08126_ _08174_ _14727_ _08190_ VDD
+ VSS OAI221_X1
X_17463_ _08167_ _07998_ _08065_ _08191_ VDD VSS NOR3_X2
X_17464_ _07974_ _08082_ _08055_ _08192_ VDD VSS NOR3_X1
X_17465_ _08191_ _08192_ _08193_ VDD VSS NOR2_X1
X_17466_ _08190_ _08193_ _08093_ _08194_ VDD VSS MUX2_X1
X_17467_ _00404_ _08184_ _08188_ _00401_ _08194_ _08195_ VDD
+ VSS OAI221_X2
X_17468_ net39 _07963_ _07966_ _08196_ VDD VSS NAND3_X1
X_17469_ _07903_ _08057_ _08122_ _08196_ _08197_ VDD VSS NAND4_X1
X_17470_ _07955_ _07973_ _06337_ _08198_ VDD VSS OAI21_X1
X_17471_ _08021_ _07901_ _14732_ _08199_ VDD VSS AOI21_X1
X_17472_ _08197_ _08198_ net912 _07940_ _08199_ _08200_ VDD
+ VSS AOI221_X1
X_17473_ _07900_ _08079_ _08181_ _08201_ VDD VSS OAI21_X1
X_17474_ _08201_ _07908_ net28 _08202_ VDD VSS OAI21_X1
X_17475_ _07968_ _08203_ VDD VSS INV_X1
X_17476_ _08203_ _07967_ _08057_ _08010_ _08204_ VDD VSS OAI22_X1
X_17477_ _07903_ _08057_ _08202_ _08204_ _07974_ _08205_ VDD
+ VSS AOI221_X1
X_17478_ _07902_ _06383_ _07967_ _08206_ VDD VSS NAND3_X1
X_17479_ _07981_ _08207_ VDD VSS INV_X1
X_17480_ _08206_ _08089_ _08207_ _08208_ VDD VSS OAI21_X1
X_17481_ _08034_ _08078_ _08208_ _08209_ VDD VSS NOR3_X1
X_17482_ _08200_ _08205_ _08209_ _08210_ VDD VSS OR3_X1
X_17483_ _08195_ _08210_ _00404_ _08211_ VDD VSS OAI21_X2
X_17484_ _06351_ _06399_ _08212_ VDD VSS NAND2_X1
X_17485_ _06411_ _06425_ _08213_ VDD VSS NOR2_X2
X_17486_ _06379_ _08212_ _08213_ _06335_ _08214_ VDD VSS AOI211_X2
X_17487_ _06411_ _06426_ _08215_ VDD VSS NOR2_X1
X_17488_ _07998_ _07907_ _07981_ _08216_ VDD VSS AOI21_X1
X_17489_ _08215_ _08216_ _07973_ _08217_ VDD VSS OAI21_X1
X_17490_ _08021_ _08181_ _08218_ VDD VSS NOR2_X2
X_17491_ _08213_ _08218_ _08007_ _08212_ _06335_ _08219_ VDD
+ VSS OAI221_X2
X_17492_ _08214_ _08219_ _08217_ _08167_ _07974_ _08220_ VDD
+ VSS AOI221_X2
X_17493_ net28 _08007_ _06335_ _08221_ VDD VSS MUX2_X1
X_17494_ _06426_ _08113_ net917 _08221_ _07967_ _08222_ VDD
+ VSS AOI221_X1
X_17495_ _08126_ _08009_ _08012_ _08223_ VDD VSS NAND3_X1
X_17496_ _08053_ _08069_ _07940_ _08224_ VDD VSS AOI21_X1
X_17497_ _08223_ _08224_ _14751_ _08225_ VDD VSS OAI21_X1
X_17498_ _08222_ _08225_ _08093_ _08226_ VDD VSS AOI21_X1
X_17499_ _08220_ _08226_ _07948_ _08227_ VDD VSS AOI21_X1
X_17500_ _07955_ _06399_ _14728_ _08228_ VDD VSS OAI21_X1
X_17501_ _14740_ _06385_ _06397_ _08229_ VDD VSS NAND3_X4
X_17502_ _08229_ _14738_ _06399_ _08230_ VDD VSS OAI21_X2
X_17503_ _08228_ _08230_ _07963_ _08231_ VDD VSS MUX2_X1
X_17504_ net39 _07963_ _07928_ _08232_ VDD VSS OAI21_X1
X_17505_ _08232_ _07944_ _14737_ _07943_ _08002_ _08233_ VDD
+ VSS OAI221_X1
X_17506_ _08231_ _08233_ _08092_ _08234_ VDD VSS MUX2_X1
X_17507_ _08101_ _08021_ _08092_ _08235_ VDD VSS AOI21_X1
X_17508_ _06336_ _07907_ _08236_ VDD VSS NAND2_X1
X_17509_ _08229_ _08023_ _08237_ VDD VSS NAND2_X2
X_17510_ _08236_ _08237_ _06426_ _08238_ VDD VSS MUX2_X1
X_17511_ _08235_ _08238_ _06383_ _08239_ VDD VSS MUX2_X1
X_17512_ _08234_ _08239_ _06414_ _08240_ VDD VSS MUX2_X1
X_17513_ _08227_ _08240_ _08111_ _08241_ VDD VSS MUX2_X1
X_17514_ _08211_ _08241_ _00403_ _00019_ VDD VSS MUX2_X2
X_17515_ _08046_ _07907_ _07983_ _08242_ VDD VSS AOI21_X1
X_17516_ _07937_ _08242_ _06382_ _08243_ VDD VSS OAI21_X1
X_17517_ _08004_ _08101_ _08244_ VDD VSS NOR2_X1
X_17518_ _08244_ _08237_ _07900_ _08245_ VDD VSS MUX2_X1
X_17519_ _08243_ _08245_ _08092_ _08246_ VDD VSS MUX2_X1
X_17520_ _08207_ _06382_ _08247_ VDD VSS NAND2_X1
X_17521_ _06425_ _08060_ _08247_ _08248_ VDD VSS AOI21_X2
X_17522_ _07963_ net1013 _08130_ _08249_ VDD VSS NOR3_X1
X_17523_ _08101_ _06400_ _06352_ _08250_ VDD VSS AOI21_X1
X_17524_ _08249_ _08250_ _07901_ _08251_ VDD VSS AOI21_X1
X_17525_ _08248_ _08251_ _08050_ _08252_ VDD VSS AOI21_X1
X_17526_ _08246_ _08252_ _06413_ _08253_ VDD VSS MUX2_X1
X_17527_ _06352_ _06381_ _08254_ VDD VSS NAND2_X2
X_17528_ _07966_ _06412_ _07968_ _08255_ VDD VSS OAI21_X1
X_17529_ _08057_ _08254_ _08255_ _08256_ VDD VSS OAI21_X1
X_17530_ _07981_ _06336_ _08007_ _08257_ VDD VSS MUX2_X1
X_17531_ _07966_ _06411_ _08258_ VDD VSS NOR2_X1
X_17532_ _08203_ _07943_ _06379_ _08259_ VDD VSS MUX2_X1
X_17533_ net27 _07955_ _08259_ _07911_ _08260_ VDD VSS OAI22_X2
X_17534_ _08256_ _08257_ _08258_ _07903_ _08260_ _08261_ VDD
+ VSS AOI221_X2
X_17535_ _00400_ _07903_ _08055_ _07968_ _08262_ VDD VSS AOI22_X1
X_17536_ _14746_ _08262_ _08263_ VDD VSS NOR2_X1
X_17537_ _07904_ _14751_ _07943_ _08264_ VDD VSS OAI21_X1
X_17538_ _08263_ _08264_ _08055_ _08265_ VDD VSS AOI21_X1
X_17539_ _08261_ _08265_ _14732_ _08266_ VDD VSS OAI21_X1
X_17540_ _06383_ _07996_ _08046_ _08267_ VDD VSS OAI21_X1
X_17541_ _07904_ _08017_ _08267_ _08268_ VDD VSS AOI21_X1
X_17542_ _06412_ _08113_ net1082 _07961_ _07975_ _08269_ VDD
+ VSS AOI221_X2
X_17543_ _08071_ _08268_ _08269_ _08270_ VDD VSS NOR3_X1
X_17544_ _06448_ _08270_ _08271_ VDD VSS NOR2_X1
X_17545_ _06438_ _08253_ _06448_ _08266_ _08271_ _08272_ VDD
+ VSS AOI221_X2
X_17546_ _07958_ _08082_ _08080_ _08273_ VDD VSS NOR3_X1
X_17547_ _06414_ _08047_ _08273_ _08274_ VDD VSS OAI21_X1
X_17548_ net49 _07908_ _08101_ _08126_ _08275_ VDD VSS OAI22_X1
X_17549_ _08274_ _08275_ _08034_ _08276_ VDD VSS OAI21_X1
X_17550_ _06413_ _07955_ _14737_ _08277_ VDD VSS AOI21_X1
X_17551_ _08277_ _08075_ _14737_ net49 _07908_ _08278_ VDD
+ VSS OAI221_X1
X_17552_ _08126_ _07936_ _08279_ VDD VSS NOR2_X1
X_17553_ _06414_ _08143_ _08279_ _08280_ VDD VSS OAI21_X1
X_17554_ _07994_ _14751_ net27 _08281_ VDD VSS OAI21_X1
X_17555_ _08278_ _08280_ _08281_ _08282_ VDD VSS NAND3_X1
X_17556_ _08276_ _08282_ _06448_ _08283_ VDD VSS MUX2_X1
X_17557_ _08067_ _07957_ _08284_ VDD VSS NOR2_X1
X_17558_ _07967_ _08144_ _08284_ _08285_ VDD VSS OAI21_X1
X_17559_ _07974_ _07903_ _08286_ VDD VSS NOR2_X1
X_17560_ _06447_ _07965_ _08285_ _08286_ _08104_ _08287_ VDD
+ VSS AOI221_X1
X_17561_ _14758_ _00400_ _08288_ VDD VSS NAND2_X1
X_17562_ _08288_ _08065_ _14732_ _07943_ _07944_ _08289_ VDD
+ VSS OAI221_X1
X_17563_ _08018_ _08229_ _14746_ _08290_ VDD VSS AOI21_X1
X_17564_ _08289_ _08290_ _06414_ _08291_ VDD VSS MUX2_X1
X_17565_ _08287_ _08291_ _00404_ _08292_ VDD VSS AOI21_X1
X_17566_ _08283_ _08292_ _00402_ _08293_ VDD VSS MUX2_X1
X_17567_ _08272_ _08293_ _00403_ _00020_ VDD VSS AOI21_X2
X_17568_ _07902_ _07928_ _08044_ _08008_ _08113_ net88 _08294_
+ VDD VSS AOI222_X2
X_17569_ _07968_ _07916_ _07921_ _08295_ VDD VSS OAI21_X1
X_17570_ _08126_ _08059_ _08295_ _08296_ VDD VSS AOI21_X1
X_17571_ _08050_ _07908_ net27 _08297_ VDD VSS OAI21_X1
X_17572_ _08034_ _08078_ _08294_ _08296_ _08297_ _08298_ VDD
+ VSS OAI221_X1
X_17573_ _08180_ _08069_ net915 _08299_ VDD VSS AOI21_X1
X_17574_ _08050_ _08002_ _07940_ _08299_ _14751_ _08300_ VDD
+ VSS OAI221_X1
X_17575_ _14737_ _07944_ _08055_ _14727_ _08301_ VDD VSS AOI22_X1
X_17576_ _08300_ _08301_ _08071_ _08302_ VDD VSS OAI21_X1
X_17577_ _08298_ _08302_ _00401_ _08303_ VDD VSS OAI21_X1
X_17578_ _08065_ _08228_ _08304_ VDD VSS NOR2_X1
X_17579_ _06427_ _08116_ _08305_ VDD VSS NAND2_X1
X_17580_ _08009_ _07962_ _00400_ _08306_ VDD VSS OAI21_X1
X_17581_ _08304_ _08305_ _08306_ _06427_ _08307_ VDD VSS OAI22_X1
X_17582_ _07997_ _07900_ _08308_ VDD VSS NAND2_X1
X_17583_ _06425_ _07983_ _08090_ _08308_ _07910_ _08309_ VDD
+ VSS AOI221_X2
X_17584_ _07950_ _08059_ _08010_ _08310_ VDD VSS AOI21_X2
X_17585_ net914 _07916_ _07921_ _08311_ VDD VSS OAI21_X1
X_17586_ _08311_ _07975_ _14738_ _08312_ VDD VSS OAI21_X1
X_17587_ _08310_ _08312_ _07958_ _08313_ VDD VSS AOI21_X2
X_17588_ _08309_ _08313_ _08078_ _08314_ VDD VSS AOI21_X1
X_17589_ _08307_ _08314_ _06414_ _08315_ VDD VSS MUX2_X1
X_17590_ _08303_ _08315_ _08111_ _08316_ VDD VSS MUX2_X1
X_17591_ _07950_ _07952_ _08055_ _08317_ VDD VSS OAI21_X1
X_17592_ _08092_ _08030_ _08317_ _08318_ VDD VSS NAND3_X1
X_17593_ _07973_ _08023_ _08229_ _08319_ VDD VSS NAND3_X1
X_17594_ _07901_ _08021_ _08320_ VDD VSS NAND2_X1
X_17595_ _08050_ _08319_ _08320_ _08321_ VDD VSS NAND3_X1
X_17596_ _06413_ _08318_ _08321_ _08322_ VDD VSS AOI21_X1
X_17597_ _06379_ _07996_ _06399_ _06336_ _08323_ VDD VSS AOI211_X2
X_17598_ _08082_ _07975_ _07981_ _08324_ VDD VSS AOI21_X1
X_17599_ _08323_ _08324_ _07901_ _08325_ VDD VSS AOI21_X1
X_17600_ _07984_ _08004_ _08008_ _08326_ VDD VSS OAI21_X1
X_17601_ _08325_ _08326_ _08050_ _08327_ VDD VSS MUX2_X1
X_17602_ _08111_ _08322_ _08327_ _08034_ _08328_ VDD VSS AOI211_X2
X_17603_ _06400_ _07973_ _06337_ _08329_ VDD VSS AOI21_X1
X_17604_ _08329_ _06383_ net1135 _08330_ VDD VSS OAI21_X1
X_17605_ _07972_ _07979_ _08312_ _07958_ _08331_ VDD VSS AOI22_X2
X_17606_ _06427_ _07965_ _08330_ _08331_ _06414_ _08332_ VDD
+ VSS AOI221_X2
X_17607_ _08065_ _07928_ _08079_ _08333_ VDD VSS NOR3_X1
X_17608_ _08126_ net1014 _08148_ _08334_ VDD VSS NOR3_X1
X_17609_ _07904_ _08333_ _08334_ _08335_ VDD VSS NOR3_X1
X_17610_ _08206_ _08055_ net49 _08336_ VDD VSS OAI21_X1
X_17611_ _08335_ _08336_ _07948_ _08337_ VDD VSS AOI21_X1
X_17612_ _08332_ _08337_ _00402_ _08338_ VDD VSS AOI21_X1
X_17613_ _08328_ _08338_ _08111_ _08339_ VDD VSS AOI21_X1
X_17614_ _08316_ _08339_ _00403_ _00021_ VDD VSS MUX2_X2
X_17615_ _06438_ _06447_ _08340_ VDD VSS NOR2_X1
X_17616_ _08215_ _08230_ _14751_ _08002_ net27 _08341_ VDD
+ VSS OAI221_X2
X_17617_ _08340_ _08341_ _08342_ VDD VSS NAND2_X1
X_17618_ _07906_ _07973_ _07911_ _08343_ VDD VSS NAND3_X1
X_17619_ _07900_ _07994_ _07998_ _08344_ VDD VSS OAI21_X1
X_17620_ _06412_ _08344_ _08345_ VDD VSS AND2_X1
X_17621_ _08254_ _08007_ _07981_ _08346_ VDD VSS OAI21_X1
X_17622_ _14748_ _08346_ _07966_ _08347_ VDD VSS MUX2_X1
X_17623_ _08050_ _08343_ _08345_ _08347_ _07903_ _08348_ VDD
+ VSS AOI221_X2
X_17624_ _08229_ _06400_ _07943_ _08349_ VDD VSS OAI21_X1
X_17625_ _06425_ _08113_ _07968_ _08349_ _08008_ _08350_ VDD
+ VSS AOI221_X1
X_17626_ _07940_ _08090_ _08351_ VDD VSS NAND2_X1
X_17627_ _08351_ _07942_ _14732_ _07981_ _08002_ _08352_ VDD
+ VSS OAI221_X1
X_17628_ _08350_ _08352_ _08071_ _08353_ VDD VSS AOI21_X1
X_17629_ _06438_ _06448_ _08354_ VDD VSS NAND2_X1
X_17630_ _08142_ _08342_ _08348_ _08353_ _08354_ _07948_ _08355_
+ VDD VSS OAI33_X1
X_17631_ net1082 _08003_ _06379_ _08356_ VDD VSS MUX2_X1
X_17632_ _08117_ _08356_ _07911_ _08357_ VDD VSS OAI21_X1
X_17633_ net27 _07975_ _08358_ VDD VSS NOR2_X1
X_17634_ _07958_ _08358_ _08181_ _08359_ VDD VSS OAI21_X1
X_17635_ _08092_ _08053_ _06383_ _08360_ VDD VSS AOI21_X1
X_17636_ _07904_ _08092_ _08357_ _08359_ _08360_ _08361_ VDD
+ VSS AOI221_X2
X_17637_ _07901_ _08167_ _08046_ _08362_ VDD VSS NOR3_X1
X_17638_ _08362_ _08019_ _08065_ _08363_ VDD VSS AOI21_X1
X_17639_ _08163_ _07942_ net49 _07940_ _07944_ _08364_ VDD
+ VSS OAI221_X1
X_17640_ _08363_ _08364_ _08078_ _08365_ VDD VSS MUX2_X1
X_17641_ _08361_ _08365_ _07948_ _08366_ VDD VSS AOI21_X2
X_17642_ _00403_ _08111_ _08367_ VDD VSS NOR2_X1
X_17643_ _07902_ _14737_ _06400_ _08368_ VDD VSS AOI21_X1
X_17644_ _06427_ _08186_ _08368_ _07908_ net912 _08369_ VDD
+ VSS OAI221_X1
X_17645_ net917 _06336_ _06381_ _08370_ VDD VSS MUX2_X1
X_17646_ _14747_ _08370_ _07967_ _08371_ VDD VSS MUX2_X1
X_17647_ _08369_ _08371_ _06427_ _08372_ VDD VSS OAI21_X2
X_17648_ _08092_ _07955_ _07901_ _08373_ VDD VSS AOI21_X1
X_17649_ _08319_ _08373_ _08374_ VDD VSS NAND2_X1
X_17650_ _07957_ _07955_ _08375_ VDD VSS AND2_X1
X_17651_ _08116_ _08375_ _14737_ _08002_ _14732_ _08376_ VDD
+ VSS OAI221_X1
X_17652_ _08374_ _08376_ _08078_ _08377_ VDD VSS OAI21_X1
X_17653_ _08372_ _08377_ _07904_ _08378_ VDD VSS MUX2_X1
X_17654_ _08057_ _08075_ _14737_ _08046_ net49 _08379_ VDD
+ VSS AOI221_X2
X_17655_ _14746_ _08101_ _08134_ _08380_ VDD VSS NOR3_X1
X_17656_ _08148_ _00400_ _07961_ _08381_ VDD VSS AOI21_X1
X_17657_ _08380_ _08381_ _14746_ _08382_ VDD VSS AOI21_X1
X_17658_ _08379_ _08382_ _08071_ _08383_ VDD VSS AOI21_X2
X_17659_ _07948_ _06448_ _08384_ VDD VSS NAND2_X1
X_17660_ _08378_ _00404_ _08383_ _08384_ _08385_ VDD VSS OAI22_X2
X_17661_ _08355_ _08366_ _08367_ _08385_ _00403_ _00022_ VDD
+ VSS AOI221_X2
X_17662_ _06383_ _07967_ _07903_ _08386_ VDD VSS NAND3_X1
X_17663_ _14737_ _08075_ _08386_ _08387_ VDD VSS AOI21_X1
X_17664_ _06400_ _06412_ _08388_ VDD VSS NAND2_X1
X_17665_ _07961_ _06413_ _07944_ _08388_ _07950_ _07902_ _08389_
+ VDD VSS OAI33_X1
X_17666_ _14737_ _07911_ _07903_ _08390_ VDD VSS NAND3_X1
X_17667_ _07967_ _06413_ _08391_ VDD VSS NAND2_X1
X_17668_ _14732_ _08390_ _08391_ _08392_ VDD VSS AOI21_X1
X_17669_ _08078_ _08387_ _08389_ _08392_ _08393_ VDD VSS NOR4_X1
X_17670_ _07961_ _08090_ _07976_ _08394_ VDD VSS OAI21_X1
X_17671_ _07950_ _07975_ net1082 _08258_ net917 _08395_ VDD
+ VSS AOI221_X1
X_17672_ _08394_ _08395_ _08286_ _08396_ VDD VSS OAI21_X1
X_17673_ _08393_ _08396_ _08071_ _08397_ VDD VSS AOI21_X1
X_17674_ _08078_ _08343_ _08106_ _08162_ _08398_ VDD VSS NAND4_X1
X_17675_ _07958_ _07996_ _08082_ _08399_ VDD VSS NOR3_X1
X_17676_ _08093_ _08047_ _08399_ _08400_ VDD VSS OAI21_X1
X_17677_ _08034_ _08398_ _08400_ _08401_ VDD VSS NAND3_X1
X_17678_ _06427_ _07944_ _08203_ _07961_ _08069_ _08402_ VDD
+ VSS OAI221_X1
X_17679_ _07940_ _08207_ _08008_ _08403_ VDD VSS MUX2_X1
X_17680_ _08288_ _08403_ _00400_ _08404_ VDD VSS OAI21_X1
X_17681_ _08402_ _08093_ _08404_ _08405_ VDD VSS OAI21_X1
X_17682_ _08401_ _00401_ _08405_ _08406_ VDD VSS OAI21_X1
X_17683_ _08397_ _08406_ _06448_ _08407_ VDD VSS MUX2_X1
X_17684_ _07943_ _08065_ _08408_ VDD VSS NOR2_X1
X_17685_ _08295_ _08069_ net27 _08409_ VDD VSS OAI21_X1
X_17686_ _08408_ _08409_ _14746_ _08410_ VDD VSS AOI21_X1
X_17687_ _00402_ _08410_ _08411_ VDD VSS NOR2_X1
X_17688_ _14746_ _08009_ _08012_ _08412_ VDD VSS NAND3_X1
X_17689_ _08071_ _08081_ _08412_ _08413_ VDD VSS AOI21_X1
X_17690_ _00401_ _08411_ _08413_ _08414_ VDD VSS NOR3_X1
X_17691_ _08069_ net27 net49 _08415_ VDD VSS AOI21_X1
X_17692_ _08130_ _08254_ _08415_ _08416_ VDD VSS AOI21_X1
X_17693_ _07948_ _00402_ _08416_ _08417_ VDD VSS NOR3_X1
X_17694_ _00401_ _00402_ _08418_ VDD VSS NAND2_X1
X_17695_ _08254_ _08126_ _07961_ _08419_ VDD VSS OAI21_X1
X_17696_ _08257_ _08419_ _08069_ _08420_ VDD VSS MUX2_X1
X_17697_ _06448_ _08418_ _08420_ _08421_ VDD VSS OAI21_X1
X_17698_ _06427_ _08075_ _07981_ _08250_ _14746_ _08422_ VDD
+ VSS OAI221_X1
X_17699_ _14749_ _07910_ _08423_ VDD VSS AND2_X1
X_17700_ _08311_ _07966_ _06337_ _08424_ VDD VSS OAI21_X1
X_17701_ _08423_ _08424_ _07973_ _08090_ _07981_ _08425_ VDD
+ VSS AOI221_X1
X_17702_ _08422_ _08425_ _00402_ _08426_ VDD VSS OAI21_X1
X_17703_ _00401_ _08426_ _08427_ VDD VSS NOR2_X1
X_17704_ _14727_ _07944_ _08428_ VDD VSS NOR2_X1
X_17705_ _07940_ _07942_ _08429_ VDD VSS NOR2_X1
X_17706_ _08429_ _08428_ _08128_ _08093_ _08430_ VDD VSS NOR4_X1
X_17707_ _07937_ _08044_ _07974_ _08431_ VDD VSS OAI21_X1
X_17708_ _08093_ _08431_ _08432_ VDD VSS AND2_X2
X_17709_ _07948_ _08430_ _08432_ _08433_ VDD VSS NOR3_X1
X_17710_ _08414_ _08417_ _08421_ _08433_ _08427_ _00404_ _08434_
+ VDD VSS OAI33_X1
X_17711_ _08407_ _08434_ _00403_ _00023_ VDD VSS MUX2_X2
X_17712_ _06626_ _08435_ VDD VSS BUF_X8
X_17713_ _08435_ _14760_ VDD VSS BUF_X16
X_17714_ _06642_ _08436_ VDD VSS BUF_X4
X_17715_ _08436_ _08437_ VDD VSS BUF_X4
X_17716_ _08437_ _08438_ VDD VSS BUF_X8
X_17717_ _08438_ _14780_ VDD VSS BUF_X8
X_17718_ _06609_ _14761_ VDD VSS BUF_X8
X_17719_ net18 net77 _08439_ VDD VSS AND2_X2
X_17720_ net6 _06633_ _08440_ VDD VSS NOR2_X1
X_17721_ net6 _06631_ _08441_ VDD VSS NOR2_X1
X_17722_ _08440_ _08441_ _06640_ _08442_ VDD VSS MUX2_X2
X_17723_ _08439_ _08442_ _06647_ _06661_ _08443_ VDD VSS NOR4_X4
Xclone51 _14661_ net51 VDD VSS BUF_X2
X_17725_ net844 _08445_ VDD VSS INV_X1
X_17726_ _14778_ _08446_ VDD VSS BUF_X2
X_17727_ _06648_ _08447_ VDD VSS BUF_X4
X_17728_ _06661_ _08448_ VDD VSS BUF_X4
X_17729_ _08448_ _08449_ VDD VSS BUF_X4
X_17730_ _08446_ _08447_ _08449_ _08450_ VDD VSS OAI21_X1
Xclone230 net849 net839 VDD VSS INV_X8
X_17732_ _14767_ _08452_ VDD VSS BUF_X4
X_17733_ _08450_ _06663_ _08452_ _08453_ VDD VSS OAI21_X1
X_17734_ _06692_ _08443_ _08445_ _08453_ _08437_ _08454_ VDD
+ VSS AOI221_X1
X_17735_ _14763_ _08455_ VDD VSS BUF_X4
X_17736_ _08455_ _08443_ _08456_ VDD VSS AND2_X1
X_17737_ _08456_ _00395_ _14783_ _08457_ VDD VSS AOI21_X1
X_17738_ _06692_ _08458_ VDD VSS BUF_X4
X_17739_ _08458_ _08459_ VDD VSS CLKBUF_X3
X_17740_ _08454_ _08457_ _08459_ _08460_ VDD VSS AOI21_X1
X_17741_ _06245_ _06646_ _08461_ VDD VSS NAND2_X4
X_17742_ _06217_ _06652_ _08462_ VDD VSS NAND2_X1
X_17743_ _06217_ _06650_ _08463_ VDD VSS NAND2_X1
X_17744_ _08462_ _08463_ _06659_ _08464_ VDD VSS MUX2_X2
X_17745_ _08464_ _08465_ VDD VSS BUF_X8
X_17746_ _08442_ _08465_ _08461_ net77 _06279_ _08466_ VDD
+ VSS AOI221_X2
X_17747_ _08466_ _08467_ VDD VSS BUF_X4
X_17748_ _14774_ _08468_ VDD VSS BUF_X4
X_17749_ _14767_ _08469_ VDD VSS INV_X4
X_17750_ _08469_ _06648_ _08448_ _08470_ VDD VSS OAI21_X4
X_17751_ _08446_ _08461_ _08465_ _08471_ VDD VSS NAND3_X2
X_17752_ _08470_ _08471_ _08472_ VDD VSS NAND2_X2
X_17753_ _06692_ net1154 _08468_ _08472_ _08437_ _08473_ VDD
+ VSS AOI221_X2
X_17754_ _06643_ _08474_ VDD VSS BUF_X4
X_17755_ _14767_ _08447_ _08449_ _08475_ VDD VSS NOR3_X1
Xclone95 net748 net95 VDD VSS BUF_X8
X_17757_ net847 _08461_ _08465_ _08477_ VDD VSS AOI21_X4
X_17758_ _08477_ _08475_ _08474_ _08478_ VDD VSS OR3_X4
X_17759_ _06662_ _08479_ VDD VSS BUF_X4
X_17760_ _08479_ _08480_ VDD VSS BUF_X4
X_17761_ net743 _08480_ _08481_ VDD VSS XNOR2_X1
X_17762_ _08436_ _08482_ VDD VSS BUF_X4
X_17763_ _08482_ _08483_ VDD VSS BUF_X4
X_17764_ _08478_ _08481_ _08483_ _08484_ VDD VSS OAI21_X2
X_17765_ _08473_ _08484_ _08459_ _08485_ VDD VSS AOI21_X1
X_17766_ _06677_ _08486_ VDD VSS BUF_X4
X_17767_ _08486_ _08487_ VDD VSS CLKBUF_X3
X_17768_ _08460_ _08485_ _08487_ _08488_ VDD VSS MUX2_X1
X_17769_ net844 _08461_ _08465_ _08489_ VDD VSS AOI21_X4
X_17770_ _08455_ _08490_ VDD VSS BUF_X8
X_17771_ _08489_ _06641_ _06629_ _08490_ _06662_ _08491_ VDD
+ VSS AOI221_X2
X_17772_ _14762_ _08492_ VDD VSS BUF_X2
X_17773_ _08492_ _06648_ _08448_ _08493_ VDD VSS NOR3_X2
X_17774_ _08437_ _08477_ _08493_ _08494_ VDD VSS NOR3_X1
X_17775_ _08458_ _08491_ _08494_ _08495_ VDD VSS NOR3_X1
X_17776_ _08439_ _08442_ _06647_ _06661_ _08496_ VDD VSS OAI22_X4
X_17777_ _08490_ _08496_ _08497_ VDD VSS NOR2_X2
X_17778_ _06661_ _06641_ _06629_ _06279_ _06646_ _08498_ VDD
+ VSS AOI221_X2
X_17779_ _08498_ _08467_ _08499_ VDD VSS OR2_X4
X_17780_ _08497_ _08499_ net510 _08443_ net846 _08500_ VDD
+ VSS AOI221_X2
X_17781_ _06692_ _08501_ VDD VSS BUF_X4
X_17782_ _06679_ _08495_ _08500_ _08501_ _08502_ VDD VSS AOI211_X2
X_17783_ _08455_ _08503_ VDD VSS INV_X8
X_17784_ _08482_ _08480_ _06692_ _08504_ VDD VSS NAND3_X1
X_17785_ _08448_ net734 _06613_ _06401_ _06646_ _08505_ VDD
+ VSS AOI221_X2
X_17786_ _08455_ _08461_ _08465_ _08506_ VDD VSS AOI21_X4
X_17787_ _08505_ _08506_ _08458_ _08507_ VDD VSS AOI21_X1
X_17788_ _08438_ _08508_ VDD VSS BUF_X4
X_17789_ _08503_ _08504_ _08507_ _08508_ _08509_ VDD VSS OAI22_X1
X_17790_ _08467_ _08498_ _08510_ VDD VSS NOR2_X1
X_17791_ _08435_ _08479_ _08511_ VDD VSS XNOR2_X2
X_17792_ _08510_ _08511_ _14766_ _08512_ VDD VSS MUX2_X1
X_17793_ _06695_ _08513_ VDD VSS CLKBUF_X3
X_17794_ _08509_ _08512_ _08513_ _08514_ VDD VSS AOI21_X1
X_17795_ _08502_ _08514_ _00396_ _08515_ VDD VSS AOI21_X1
X_17796_ _06716_ _08516_ VDD VSS CLKBUF_X3
X_17797_ _08488_ _08515_ _08516_ _08517_ VDD VSS MUX2_X1
X_17798_ _08459_ _08518_ VDD VSS CLKBUF_X3
X_17799_ _08436_ _08519_ VDD VSS CLKBUF_X3
X_17800_ _14769_ _08520_ VDD VSS BUF_X4
X_17801_ _08461_ _08521_ VDD VSS BUF_X4
X_17802_ _08465_ _08522_ VDD VSS BUF_X4
X_17803_ _08520_ _08521_ _08522_ _08523_ VDD VSS AOI21_X1
X_17804_ _08446_ _08447_ _08449_ _08524_ VDD VSS NOR3_X2
X_17805_ _08519_ _08523_ _08524_ _08525_ VDD VSS OAI21_X1
X_17806_ _08474_ _06662_ _08526_ VDD VSS NAND2_X2
X_17807_ _14776_ _08527_ VDD VSS INV_X2
X_17808_ _08525_ _08526_ _08527_ _08528_ VDD VSS OAI21_X1
X_17809_ _00396_ _08528_ _08529_ VDD VSS NAND2_X1
X_17810_ _08486_ _08530_ VDD VSS BUF_X4
X_17811_ _08530_ _08531_ VDD VSS CLKBUF_X3
X_17812_ _06663_ _08532_ VDD VSS BUF_X4
X_17813_ _06611_ _08532_ _08533_ VDD VSS NAND2_X1
X_17814_ _08505_ _08534_ VDD VSS INV_X1
X_17815_ _14785_ _08533_ _08534_ _08535_ VDD VSS AOI21_X1
X_17816_ _08532_ _08536_ VDD VSS CLKBUF_X3
X_17817_ _08490_ _08536_ _08537_ VDD VSS NOR2_X1
X_17818_ _14780_ _08489_ _08537_ _08538_ VDD VSS NOR3_X1
X_17819_ _08531_ _08535_ _08538_ _08539_ VDD VSS OAI21_X1
X_17820_ _08518_ _08529_ _08539_ _08540_ VDD VSS AOI21_X1
X_17821_ _08492_ _08541_ VDD VSS CLKBUF_X3
X_17822_ _08541_ _06611_ _08474_ _08542_ VDD VSS MUX2_X1
X_17823_ _08479_ _08543_ VDD VSS BUF_X4
X_17824_ _08486_ _08542_ _08543_ _08544_ VDD VSS OAI21_X2
X_17825_ _06664_ _08519_ _08468_ _08545_ VDD VSS AOI21_X1
X_17826_ _06680_ _08497_ _08545_ _08546_ VDD VSS OAI21_X1
X_17827_ _08443_ _08547_ VDD VSS BUF_X4
X_17828_ _08513_ _08544_ _08546_ _08547_ _08520_ _08548_ VDD
+ VSS AOI221_X2
X_17829_ _08458_ _08549_ VDD VSS CLKBUF_X3
X_17830_ _14764_ _08550_ VDD VSS BUF_X4
X_17831_ _08550_ _08521_ _08522_ _08551_ VDD VSS AOI21_X2
X_17832_ _08551_ _06641_ _06629_ _06628_ _08480_ _08552_ VDD
+ VSS AOI221_X1
X_17833_ _06609_ _08479_ _08553_ VDD VSS NOR2_X1
X_17834_ _08469_ _06664_ _08554_ VDD VSS NOR2_X1
X_17835_ _08508_ _08553_ _08554_ _08555_ VDD VSS NOR3_X1
X_17836_ _08549_ _08552_ _08555_ _08556_ VDD VSS OAI21_X1
X_17837_ _06597_ net548 _06647_ _06661_ _08557_ VDD VSS NOR4_X4
X_17838_ _08519_ _08557_ _08506_ _08558_ VDD VSS OAI21_X1
X_17839_ _08474_ _08559_ VDD VSS CLKBUF_X3
X_17840_ _08559_ _08560_ VDD VSS CLKBUF_X3
X_17841_ _08560_ _08551_ _08554_ _08561_ VDD VSS OAI21_X1
X_17842_ _08513_ _08558_ _08561_ _08562_ VDD VSS NAND3_X1
X_17843_ _06681_ _08556_ _08562_ _08563_ VDD VSS AND3_X1
X_17844_ _06677_ _06693_ _08564_ VDD VSS NAND2_X1
X_17845_ _08469_ _08521_ _08522_ _08565_ VDD VSS AOI21_X2
X_17846_ _14785_ _08557_ _08565_ _08566_ VDD VSS OAI21_X1
X_17847_ _08496_ _08567_ VDD VSS BUF_X4
X_17848_ _08520_ _08567_ _08568_ VDD VSS OR2_X1
X_17849_ _08564_ _08566_ _08568_ _08569_ VDD VSS AOI21_X1
X_17850_ _08474_ _08570_ VDD VSS CLKBUF_X3
X_17851_ _08570_ _08571_ VDD VSS CLKBUF_X3
X_17852_ _14760_ _08571_ _08572_ VDD VSS NAND2_X1
X_17853_ _08446_ _08573_ VDD VSS INV_X1
X_17854_ _08532_ _08482_ _08573_ _08574_ VDD VSS AOI21_X2
X_17855_ _08572_ _08574_ _08575_ VDD VSS NAND2_X1
X_17856_ _08518_ _08575_ _08576_ VDD VSS NAND2_X1
X_17857_ _06716_ _08544_ _08576_ _08577_ VDD VSS OAI21_X1
X_17858_ _08516_ _08540_ _08548_ _08563_ _08569_ _08577_ _08578_
+ VDD VSS OAI33_X1
X_17859_ _08517_ _08578_ _00398_ _00024_ VDD VSS MUX2_X1
X_17860_ _08557_ _06663_ _08492_ _08579_ VDD VSS AOI21_X1
X_17861_ _08527_ _08461_ _08465_ _08580_ VDD VSS NAND3_X2
X_17862_ _08470_ _08580_ _08581_ VDD VSS NAND2_X2
X_17863_ _08579_ _08581_ _06644_ _08582_ VDD VSS MUX2_X1
X_17864_ _14769_ _08583_ VDD VSS INV_X1
X_17865_ _08583_ _08521_ _08522_ _08584_ VDD VSS AOI21_X1
X_17866_ _06644_ _08557_ _08584_ _08585_ VDD VSS NOR3_X1
X_17867_ _08585_ _08511_ _08559_ _08586_ VDD VSS AOI21_X1
X_17868_ _08582_ _08586_ _08458_ _08587_ VDD VSS MUX2_X1
X_17869_ _08541_ net844 _06644_ _08588_ VDD VSS MUX2_X1
X_17870_ _00395_ _08501_ _08589_ VDD VSS NAND2_X1
X_17871_ _00395_ _08588_ _08589_ _14790_ _08590_ VDD VSS OAI22_X2
X_17872_ _08587_ _08590_ _08487_ _08591_ VDD VSS MUX2_X1
X_17873_ _08490_ _08474_ _08592_ VDD VSS NAND2_X1
X_17874_ _08550_ _08437_ _08593_ VDD VSS NAND2_X1
X_17875_ _06677_ _08592_ _08593_ _08594_ VDD VSS NAND3_X1
X_17876_ _08479_ _06678_ _14786_ _08595_ VDD VSS AOI21_X1
X_17877_ _08520_ _06644_ _08596_ VDD VSS NAND2_X1
X_17878_ _08452_ _08435_ _06678_ _08597_ VDD VSS MUX2_X1
X_17879_ _08596_ _08597_ _08559_ _08598_ VDD VSS OAI21_X1
X_17880_ _06694_ _08594_ _08595_ _08598_ _08543_ _08599_ VDD
+ VSS AOI221_X2
X_17881_ _06613_ net734 _08461_ _08465_ _08600_ VDD VSS NAND4_X4
X_17882_ _08505_ _08536_ _08469_ _08601_ VDD VSS AOI21_X1
X_17883_ _08530_ _08600_ _14766_ _08601_ _08508_ _08602_ VDD
+ VSS OAI221_X1
X_17884_ _08490_ _08447_ _08449_ _08603_ VDD VSS OAI21_X2
X_17885_ _14769_ _08461_ _08465_ _08604_ VDD VSS NAND3_X2
X_17886_ _08603_ _08604_ _08605_ VDD VSS NAND2_X1
X_17887_ _08481_ _08605_ _08483_ _08606_ VDD VSS MUX2_X1
X_17888_ _08602_ _08606_ _08531_ _08607_ VDD VSS OAI21_X1
X_17889_ _08599_ _08607_ _00397_ _08608_ VDD VSS AOI21_X1
X_17890_ _08591_ _08608_ _00399_ _08609_ VDD VSS MUX2_X1
X_17891_ _14764_ _08610_ VDD VSS INV_X2
X_17892_ _08474_ _06663_ _08611_ VDD VSS NAND2_X2
X_17893_ _08493_ _08532_ _08435_ _08612_ VDD VSS AOI21_X1
X_17894_ _08610_ _08611_ _08612_ _08570_ _08613_ VDD VSS OAI22_X1
X_17895_ net1069 _08521_ _08522_ _08614_ VDD VSS NAND3_X4
X_17896_ _08482_ _08603_ _08614_ _08615_ VDD VSS NAND3_X1
X_17897_ _08523_ _08557_ _08616_ VDD VSS OR2_X1
X_17898_ _08615_ _08616_ _08519_ _08617_ VDD VSS OAI21_X1
X_17899_ _08613_ _08617_ _08501_ _08618_ VDD VSS MUX2_X1
X_17900_ _08503_ _06648_ _08448_ _08619_ VDD VSS OAI21_X2
X_17901_ _08619_ _08604_ _08620_ VDD VSS AND2_X1
X_17902_ _08541_ _08611_ _08620_ _08559_ _08621_ VDD VSS OAI22_X1
X_17903_ net744 _06626_ _06662_ _08622_ VDD VSS NOR3_X1
X_17904_ _08456_ _08622_ _08499_ net744 _08623_ VDD VSS AOI211_X2
X_17905_ _08621_ _08623_ _08501_ _08624_ VDD VSS MUX2_X1
X_17906_ _08618_ _08624_ _08487_ _08625_ VDD VSS MUX2_X1
X_17907_ _08610_ _06648_ _08449_ _08626_ VDD VSS NOR3_X2
X_17908_ _06644_ _08506_ _08626_ _08627_ VDD VSS NOR3_X1
X_17909_ _08492_ _08447_ _08449_ _08628_ VDD VSS OAI21_X1
X_17910_ _08628_ _08532_ _08446_ _08629_ VDD VSS OAI21_X1
X_17911_ _08627_ _08629_ _08559_ _08630_ VDD VSS AOI21_X1
X_17912_ _08506_ _08557_ _08436_ _08631_ VDD VSS NOR3_X1
X_17913_ _08527_ _08447_ _08449_ _08632_ VDD VSS OAI21_X1
X_17914_ _08474_ _08632_ _08471_ _08633_ VDD VSS AOI21_X1
X_17915_ _08631_ _08633_ _08634_ VDD VSS OR2_X1
X_17916_ _08630_ _08634_ _06695_ _08635_ VDD VSS MUX2_X1
X_17917_ _08614_ _08480_ _08435_ _08636_ VDD VSS OAI21_X1
X_17918_ _08585_ _08636_ _06645_ _08637_ VDD VSS AOI21_X1
X_17919_ _08492_ _08638_ VDD VSS INV_X1
X_17920_ _08619_ _06663_ _08638_ _08639_ VDD VSS OAI21_X1
X_17921_ _06611_ _08547_ _08639_ _08519_ _08640_ VDD VSS AOI22_X1
X_17922_ _08637_ _08640_ _08501_ _08641_ VDD VSS MUX2_X1
X_17923_ _08635_ _08641_ _08487_ _08642_ VDD VSS MUX2_X1
X_17924_ _08625_ _08642_ _08516_ _08643_ VDD VSS MUX2_X1
X_17925_ _08609_ _08643_ _00398_ _00025_ VDD VSS MUX2_X1
X_17926_ _06597_ net549 _06648_ _08448_ _08644_ VDD VSS OAI22_X4
X_17927_ _08490_ _08461_ _08465_ _08645_ VDD VSS NAND3_X4
X_17928_ _08474_ _08644_ _08645_ _08646_ VDD VSS AOI21_X2
X_17929_ _08482_ _08600_ _08450_ _08647_ VDD VSS AOI21_X1
X_17930_ _08458_ _08646_ _08647_ _08648_ VDD VSS NOR3_X2
X_17931_ _08550_ _06648_ _08448_ _08649_ VDD VSS NOR3_X2
X_17932_ _08565_ _08649_ _08650_ VDD VSS OR2_X1
X_17933_ _06401_ net76 _08651_ VDD VSS AND2_X1
X_17934_ _06279_ _06617_ _08652_ VDD VSS NOR2_X1
X_17935_ _06279_ _06615_ _08653_ VDD VSS NOR2_X1
X_17936_ _08652_ _08653_ _06624_ _08654_ VDD VSS MUX2_X1
X_17937_ _08651_ _08654_ _06648_ _08448_ _08655_ VDD VSS OAI22_X4
X_17938_ _08655_ _08532_ _08520_ _08656_ VDD VSS OAI21_X1
X_17939_ _08650_ _08656_ _08519_ _08657_ VDD VSS MUX2_X1
X_17940_ _08530_ _08648_ _08657_ _08459_ _08658_ VDD VSS AOI211_X2
X_17941_ _08520_ _08439_ _08442_ _08659_ VDD VSS NOR3_X2
X_17942_ _08659_ _08452_ _08519_ _08660_ VDD VSS AOI21_X4
X_17943_ _08486_ _08660_ _08543_ _08661_ VDD VSS OAI21_X4
X_17944_ _08543_ _06645_ _14771_ _08662_ VDD VSS OAI21_X1
X_17945_ _08662_ _08560_ _08490_ _08663_ VDD VSS AOI21_X1
X_17946_ _08452_ _08521_ _08522_ _08664_ VDD VSS NAND3_X4
X_17947_ _08483_ _08664_ _08628_ _08665_ VDD VSS AOI21_X1
X_17948_ _08550_ _08496_ _08666_ VDD VSS NOR2_X1
X_17949_ _00397_ _08661_ _08663_ _08665_ _08666_ _08564_ _08667_
+ VDD VSS OAI33_X1
X_17950_ _00399_ _08658_ _08667_ _08668_ VDD VSS NOR3_X1
X_17951_ _08603_ _08580_ _08669_ VDD VSS NAND2_X1
X_17952_ _08501_ net1154 _08520_ _08669_ _08483_ _08670_ VDD
+ VSS AOI221_X2
X_17953_ _14781_ _00395_ _08547_ net56 _08671_ VDD VSS AOI22_X2
X_17954_ _00397_ _08671_ _08672_ VDD VSS NOR2_X1
X_17955_ _08531_ _08670_ _08672_ _08673_ VDD VSS OAI21_X1
X_17956_ net744 _08567_ _08674_ VDD VSS NOR2_X1
X_17957_ _08674_ _08547_ net846 _08541_ _08499_ _08675_ VDD
+ VSS AOI221_X2
X_17958_ _08469_ _06628_ _08437_ _08676_ VDD VSS MUX2_X1
X_17959_ _14788_ _08676_ _08536_ _08677_ VDD VSS MUX2_X1
X_17960_ _08675_ _08677_ _08549_ _08678_ VDD VSS MUX2_X1
X_17961_ _08673_ _08678_ _08531_ _08679_ VDD VSS OAI21_X2
X_17962_ _08668_ _08679_ _00399_ _08680_ VDD VSS AOI21_X1
X_17963_ _08520_ _06663_ _08681_ VDD VSS NAND2_X1
X_17964_ _08550_ _08521_ _08522_ _08682_ VDD VSS NAND3_X1
X_17965_ _08560_ _08681_ _08682_ _08683_ VDD VSS NAND3_X1
X_17966_ _08468_ _08521_ _08522_ _08684_ VDD VSS NAND3_X1
X_17967_ _08438_ _08684_ _08685_ VDD VSS AND2_X1
X_17968_ _08644_ _08685_ _08686_ VDD VSS NAND2_X1
X_17969_ _06681_ _08549_ _08683_ _08686_ _08687_ VDD VSS NAND4_X1
X_17970_ _06628_ _08479_ _08688_ VDD VSS NOR2_X2
X_17971_ _08483_ _08688_ _08649_ _08689_ VDD VSS NOR3_X1
X_17972_ _14774_ _08690_ VDD VSS INV_X4
X_17973_ _08557_ _00395_ _08690_ _08691_ VDD VSS AOI21_X1
X_17974_ _08689_ _08691_ _14780_ _08692_ VDD VSS AOI21_X1
X_17975_ _06679_ _06694_ _08693_ VDD VSS NAND2_X2
X_17976_ _06645_ _08619_ _08684_ _08694_ VDD VSS NAND3_X1
X_17977_ _06695_ _08558_ _08694_ _08695_ VDD VSS AND3_X1
X_17978_ _08659_ _08685_ _08655_ _08696_ VDD VSS AOI21_X1
X_17979_ _08695_ _08696_ _08549_ _08697_ VDD VSS AOI21_X1
X_17980_ _08687_ _08692_ _08693_ _08697_ _00396_ _08698_ VDD
+ VSS OAI221_X1
X_17981_ _06645_ _08603_ _08580_ _08699_ VDD VSS NAND3_X1
X_17982_ _08570_ _08505_ _08489_ _08700_ VDD VSS OR3_X1
X_17983_ _08501_ _08699_ _08700_ _08701_ VDD VSS NAND3_X1
X_17984_ _08467_ _08498_ _06627_ _08702_ VDD VSS MUX2_X1
X_17985_ _08655_ _08474_ _06626_ _08703_ VDD VSS OAI21_X1
X_17986_ _08600_ _08436_ net1186 _08704_ VDD VSS OAI21_X1
X_17987_ _08702_ _08703_ _06609_ _08704_ _08503_ _08705_ VDD
+ VSS AOI221_X2
X_17988_ _08701_ _08705_ _08459_ _08706_ VDD VSS OAI21_X1
X_17989_ _08503_ _06643_ _08707_ VDD VSS NAND2_X1
X_17990_ _06662_ _08436_ _14767_ _08708_ VDD VSS AOI21_X1
X_17991_ _06692_ _08708_ _08707_ _08480_ _14783_ _08709_ VDD
+ VSS AOI221_X2
X_17992_ _06611_ _08436_ _08435_ _08710_ VDD VSS MUX2_X1
X_17993_ _14790_ _08710_ _06664_ _08711_ VDD VSS MUX2_X1
X_17994_ _08709_ _08711_ _08549_ _08712_ VDD VSS AOI21_X1
X_17995_ _08706_ _08712_ _08487_ _08713_ VDD VSS MUX2_X1
X_17996_ _08698_ _08713_ _00399_ _08714_ VDD VSS MUX2_X1
X_17997_ _08680_ _08714_ _00398_ _00026_ VDD VSS MUX2_X1
X_17998_ _08557_ _08482_ net741 _08715_ VDD VSS AOI21_X1
X_17999_ _06694_ _08547_ _14761_ _08715_ _08550_ _08716_ VDD
+ VSS AOI221_X2
X_18000_ _08458_ net1110 net741 _08510_ _08468_ _08717_ VDD
+ VSS AOI221_X2
X_18001_ _08503_ _08521_ _08522_ _08718_ VDD VSS NAND3_X1
X_18002_ net746 _06695_ _08719_ VDD VSS NAND2_X1
X_18003_ _08644_ _08718_ _08719_ _08720_ VDD VSS NAND3_X1
X_18004_ _08531_ _08716_ _08717_ _08720_ _14785_ _08721_ VDD
+ VSS OAI221_X1
X_18005_ _14771_ _08498_ _08722_ VDD VSS NAND2_X1
X_18006_ net844 _06648_ _08448_ _08723_ VDD VSS NOR3_X4
X_18007_ _06645_ _08506_ _08723_ _08724_ VDD VSS OAI21_X1
X_18008_ _06695_ _08722_ _08724_ _08725_ VDD VSS AOI21_X1
X_18009_ _08503_ _08543_ _06694_ _08726_ VDD VSS NAND3_X1
X_18010_ _08560_ _08450_ _08726_ _08727_ VDD VSS AOI21_X1
X_18011_ _08487_ _08725_ _08727_ _08728_ VDD VSS OR3_X1
X_18012_ _00399_ _08721_ _08728_ _08729_ VDD VSS AOI21_X1
X_18013_ _08482_ _06678_ _08730_ VDD VSS NAND2_X1
X_18014_ _08570_ _08480_ _06677_ _08731_ VDD VSS NAND3_X1
X_18015_ net746 _08730_ _08731_ _08732_ VDD VSS AOI21_X1
X_18016_ _08490_ _08483_ _06680_ _08733_ VDD VSS OAI21_X1
X_18017_ _14760_ _08571_ _08486_ _08734_ VDD VSS NAND3_X1
X_18018_ _00395_ _08730_ _08733_ _08734_ _08735_ VDD VSS NAND4_X1
X_18019_ _08543_ _08736_ VDD VSS CLKBUF_X3
X_18020_ _14760_ _08571_ _06680_ _08737_ VDD VSS NAND3_X1
X_18021_ net746 _14771_ _08530_ _08738_ VDD VSS NAND3_X1
X_18022_ _08736_ _08737_ _08738_ _08739_ VDD VSS NAND3_X1
X_18023_ _08732_ _08735_ _08739_ _08740_ VDD VSS AOI21_X1
X_18024_ _08645_ _08442_ _08439_ _08550_ _08543_ _08741_ VDD
+ VSS OAI221_X1
X_18025_ _08583_ _08447_ _08449_ _08742_ VDD VSS OAI21_X2
X_18026_ _08560_ _08600_ _08742_ _08743_ VDD VSS NAND3_X1
X_18027_ _08487_ _08741_ _08743_ _08744_ VDD VSS NAND3_X1
X_18028_ _08571_ _08477_ _08723_ _08745_ VDD VSS NOR3_X1
X_18029_ _08506_ _08736_ _14761_ _08746_ VDD VSS AOI21_X1
X_18030_ _08745_ _08746_ _14785_ _08747_ VDD VSS AOI21_X1
X_18031_ _08744_ _08747_ _08531_ _08748_ VDD VSS OAI21_X1
X_18032_ _08740_ _08748_ _00397_ _08749_ VDD VSS MUX2_X1
X_18033_ _08729_ _08749_ _00399_ _08750_ VDD VSS AOI21_X1
X_18034_ _06664_ _06694_ _08751_ VDD VSS NAND2_X1
X_18035_ _08571_ _08536_ _08550_ _08751_ net746 _08752_ VDD
+ VSS OAI221_X2
X_18036_ net743 _08543_ _08458_ _08753_ VDD VSS NAND3_X1
X_18037_ _08468_ _08447_ _08449_ _08754_ VDD VSS OAI21_X2
X_18038_ _08645_ _08754_ _08755_ VDD VSS NAND2_X2
X_18039_ _08753_ _08755_ _08501_ _08756_ VDD VSS OAI21_X1
X_18040_ _08752_ _08756_ _14785_ _08757_ VDD VSS OAI21_X1
X_18041_ _08436_ _08600_ _08758_ VDD VSS AND2_X1
X_18042_ net511 _08567_ _08758_ _06611_ net1186 _08526_ _08759_
+ VDD VSS OAI222_X2
X_18043_ _08690_ _08521_ _08522_ _08760_ VDD VSS AOI21_X2
X_18044_ _08437_ _08723_ _08760_ _08761_ VDD VSS NOR3_X4
X_18045_ _08644_ _08532_ _08638_ _08762_ VDD VSS OAI21_X1
X_18046_ _08761_ _08762_ _08438_ _08763_ VDD VSS AOI21_X1
X_18047_ _08759_ _08763_ _08501_ _08764_ VDD VSS MUX2_X1
X_18048_ _08757_ _08764_ _08487_ _08765_ VDD VSS MUX2_X1
X_18049_ _08435_ _08436_ _06609_ _08766_ VDD VSS MUX2_X1
X_18050_ _06694_ _08467_ net56 _08766_ _08480_ _08767_ VDD
+ VSS AOI221_X2
X_18051_ _08570_ _08645_ _08470_ _08768_ VDD VSS AND3_X1
X_18052_ _06645_ _08489_ _08493_ _08769_ VDD VSS NOR3_X1
X_18053_ _08459_ _08768_ _08769_ _08770_ VDD VSS NOR3_X1
X_18054_ _08770_ _08767_ _06681_ _08771_ VDD VSS NOR3_X1
X_18055_ _08570_ _08718_ _08655_ _08772_ VDD VSS AOI21_X2
X_18056_ _08550_ _08447_ _08449_ _08773_ VDD VSS OAI21_X1
X_18057_ _08519_ _08684_ _08773_ _08774_ VDD VSS AOI21_X1
X_18058_ _06695_ _08772_ _08774_ _08775_ VDD VSS OR3_X1
X_18059_ _08646_ _08553_ net1186 net845 _08547_ _08776_ VDD
+ VSS AOI221_X1
X_18060_ _08775_ _08776_ _08518_ _08777_ VDD VSS OAI21_X1
X_18061_ _08771_ _08777_ _00396_ _08778_ VDD VSS AOI21_X1
X_18062_ _08765_ _08778_ _00399_ _08779_ VDD VSS MUX2_X1
X_18063_ _08750_ _08779_ _00398_ _00027_ VDD VSS MUX2_X1
X_18064_ net741 _08482_ _08780_ VDD VSS NAND2_X1
X_18065_ _08479_ _08570_ _08690_ _08781_ VDD VSS AOI21_X1
X_18066_ _08486_ _08780_ _08781_ _08782_ VDD VSS AOI21_X1
X_18067_ _14776_ _08570_ _08783_ VDD VSS NAND2_X1
X_18068_ _06679_ _08574_ _08783_ _08784_ VDD VSS AOI21_X2
X_18069_ net743 _14771_ _08536_ _08785_ VDD VSS NAND3_X1
X_18070_ _08782_ _08784_ _08785_ _08786_ VDD VSS AOI21_X1
X_18071_ _08459_ _08722_ _08784_ _08787_ VDD VSS OAI21_X1
X_18072_ _06681_ _08567_ _08784_ _08534_ _08788_ VDD VSS OAI22_X2
X_18073_ _08786_ _08787_ _14761_ _08788_ _08789_ VDD VSS AOI211_X2
X_18074_ _14780_ _08475_ _08688_ _08790_ VDD VSS OAI21_X1
X_18075_ _08487_ net1154 _08468_ _08791_ VDD VSS AOI21_X1
X_18076_ _08541_ _08736_ _08792_ VDD VSS NAND2_X1
X_18077_ _08792_ _08592_ _08736_ _08793_ VDD VSS OAI21_X1
X_18078_ _08790_ _08791_ _08793_ _08531_ _08794_ VDD VSS AOI22_X1
X_18079_ _08516_ _08794_ _08518_ _08795_ VDD VSS OAI21_X1
X_18080_ _08459_ _08508_ _08690_ _08796_ VDD VSS AOI21_X1
X_18081_ _08796_ _08605_ _14780_ _08797_ VDD VSS OAI21_X1
X_18082_ _08508_ _08470_ _08604_ _08798_ VDD VSS NAND3_X1
X_18083_ _08655_ _08682_ _08799_ VDD VSS NAND2_X1
X_18084_ _08798_ _08799_ _14780_ _08800_ VDD VSS OAI21_X1
X_18085_ _08797_ _08800_ _08513_ _06665_ _06676_ _08801_ VDD
+ VSS OAI221_X1
X_18086_ _08560_ _08655_ _08604_ _08802_ VDD VSS NAND3_X1
X_18087_ _08513_ _08478_ _08802_ _08803_ VDD VSS AOI21_X1
X_18088_ _14780_ _08565_ _08649_ _08804_ VDD VSS OAI21_X1
X_18089_ _08804_ _08755_ _14780_ _08805_ VDD VSS OAI21_X1
X_18090_ _08803_ _08805_ _00397_ _08806_ VDD VSS AOI21_X1
X_18091_ _08801_ _08806_ _00396_ _08807_ VDD VSS OAI21_X1
X_18092_ _08789_ _08795_ _08807_ _08516_ _08808_ VDD VSS OAI22_X1
X_18093_ _08571_ _08655_ _08614_ _08809_ VDD VSS NAND3_X1
X_18094_ _08530_ _08780_ _08809_ _08810_ VDD VSS NAND3_X1
X_18095_ _08754_ _08524_ _08560_ _08811_ VDD VSS OAI21_X1
X_18096_ _08810_ _08811_ _08487_ _08812_ VDD VSS OAI21_X1
X_18097_ _08707_ _14785_ _08583_ _08813_ VDD VSS OAI21_X1
X_18098_ _08544_ _08813_ _08736_ _08814_ VDD VSS AOI21_X1
X_18099_ _14785_ _06680_ _08629_ _08815_ VDD VSS NAND3_X1
X_18100_ _06716_ _08815_ _08816_ VDD VSS NAND2_X1
X_18101_ _06716_ _08812_ _08814_ _08816_ _08817_ VDD VSS OAI22_X1
X_18102_ _06611_ _08532_ _08818_ VDD VSS NOR2_X1
X_18103_ _14771_ _08571_ _08819_ VDD VSS NAND2_X1
X_18104_ _06679_ _08611_ _08527_ _08435_ _06645_ _08820_ VDD
+ VSS OAI221_X2
X_18105_ _06628_ _08437_ _08821_ VDD VSS NOR2_X1
X_18106_ _08547_ _08482_ net741 _08822_ VDD VSS AOI21_X1
X_18107_ _08486_ _08533_ _08821_ _08822_ _14771_ _08823_ VDD
+ VSS OAI221_X2
X_18108_ _08818_ _08819_ _08820_ _08823_ _08824_ VDD VSS AOI22_X2
X_18109_ _08437_ _08479_ _08825_ VDD VSS NAND2_X1
X_18110_ _14761_ _08825_ _08649_ _08519_ _08826_ VDD VSS OAI22_X1
X_18111_ _06644_ _08614_ _08742_ _08827_ VDD VSS AOI21_X2
X_18112_ _08827_ _08511_ _06645_ _08828_ VDD VSS AOI21_X1
X_18113_ _08826_ _08828_ _06680_ _08829_ VDD VSS MUX2_X1
X_18114_ _08824_ _08829_ _06716_ _08830_ VDD VSS MUX2_X1
X_18115_ _08817_ _08830_ _08518_ _08831_ VDD VSS MUX2_X1
X_18116_ _08808_ _08831_ _00398_ _00028_ VDD VSS MUX2_X1
X_18117_ _08477_ _08626_ _08832_ VDD VSS NOR2_X1
X_18118_ _08530_ _08567_ _08490_ _08832_ _08508_ _08833_ VDD
+ VSS OAI221_X1
X_18119_ _08603_ _08471_ _08834_ VDD VSS AND2_X1
X_18120_ _06680_ _08825_ _14760_ _08834_ _08508_ _08835_ VDD
+ VSS OAI221_X2
X_18121_ _06716_ _08833_ _08835_ _08836_ VDD VSS AOI21_X1
X_18122_ _06645_ _08489_ _08626_ _08837_ VDD VSS OAI21_X1
X_18123_ _08483_ _08645_ _08619_ _08838_ VDD VSS NAND3_X1
X_18124_ _08530_ _08837_ _08838_ _08839_ VDD VSS AOI21_X1
X_18125_ _06678_ net1111 _08541_ net844 _06664_ _08840_ VDD
+ VSS AOI221_X2
X_18126_ _06717_ _08839_ _08840_ _08841_ VDD VSS NOR3_X1
X_18127_ _00397_ _08836_ _08841_ _08842_ VDD VSS OR3_X1
X_18128_ _08536_ _06679_ _08843_ VDD VSS NAND2_X1
X_18129_ _08547_ _08486_ _08435_ _08844_ VDD VSS AOI21_X1
X_18130_ _14760_ _08731_ _08843_ _08588_ _08844_ _14761_ _08845_
+ VDD VSS OAI222_X2
X_18131_ _08536_ _08818_ _06680_ _08846_ VDD VSS MUX2_X1
X_18132_ _08845_ _08846_ _14760_ _08847_ VDD VSS AOI21_X1
X_18133_ _06679_ _08547_ net56 _08762_ _08519_ _08848_ VDD
+ VSS AOI221_X1
X_18134_ _08736_ _08596_ _08467_ _08610_ _08849_ VDD VSS AOI22_X1
X_18135_ _08848_ _08849_ _06681_ _08850_ VDD VSS AOI21_X1
X_18136_ _08847_ _08850_ _06716_ _08851_ VDD VSS MUX2_X1
X_18137_ _08842_ _08851_ _08518_ _08852_ VDD VSS OAI21_X1
X_18138_ _08559_ _08681_ _08684_ _08853_ VDD VSS AND3_X1
X_18139_ _08559_ _08644_ _08664_ _08854_ VDD VSS AOI21_X1
X_18140_ _06695_ _08853_ _08854_ _08855_ VDD VSS OAI21_X1
X_18141_ _14767_ _08447_ _08448_ _08856_ VDD VSS OAI21_X1
X_18142_ _06693_ _08856_ _06643_ _08479_ _08520_ _08857_ VDD
+ VSS AOI221_X2
X_18143_ _08530_ _08857_ _08858_ VDD VSS NOR2_X1
X_18144_ _08559_ _08505_ _08551_ _08859_ VDD VSS OAI21_X1
X_18145_ _08458_ _08525_ _08859_ _08860_ VDD VSS AOI21_X1
X_18146_ _08438_ _08645_ _08754_ _08861_ VDD VSS NAND3_X1
X_18147_ _08861_ _08644_ _08483_ _08862_ VDD VSS OAI21_X1
X_18148_ _08860_ _08862_ _08459_ _08863_ VDD VSS AOI21_X1
X_18149_ _06716_ _08855_ _08858_ _08863_ _08531_ _08864_ VDD
+ VSS AOI221_X2
X_18150_ _14761_ net1186 _08532_ _06692_ _08865_ VDD VSS NOR4_X2
X_18151_ _08583_ _08526_ _08567_ _08541_ _08866_ VDD VSS OAI22_X1
X_18152_ _08570_ _08532_ _06694_ _08867_ VDD VSS OAI21_X1
X_18153_ _08504_ _08751_ _08867_ _08868_ VDD VSS NAND3_X1
X_18154_ _08865_ _08866_ _08458_ _08868_ _14761_ _08869_ VDD
+ VSS AOI221_X2
X_18155_ _08638_ _08498_ _08870_ VDD VSS NAND2_X1
X_18156_ _08549_ _08870_ _08837_ _08871_ VDD VSS NAND3_X1
X_18157_ _08508_ _08600_ _08619_ _08872_ VDD VSS NAND3_X1
X_18158_ _08856_ _00395_ _08468_ _08873_ VDD VSS OAI21_X1
X_18159_ _08872_ _08873_ _14780_ _08874_ VDD VSS OAI21_X1
X_18160_ _08871_ _08874_ _08518_ _08875_ VDD VSS OAI21_X1
X_18161_ _08869_ _08875_ _00396_ _08876_ VDD VSS MUX2_X1
X_18162_ _08864_ _08876_ _08516_ _08877_ VDD VSS AOI21_X1
X_18163_ _08852_ _08877_ _00398_ _00029_ VDD VSS MUX2_X1
X_18164_ _14782_ _08878_ VDD VSS INV_X1
X_18165_ _08690_ _06627_ _08436_ _08879_ VDD VSS MUX2_X1
X_18166_ _08878_ _08879_ _08480_ _08880_ VDD VSS MUX2_X1
X_18167_ _08486_ _08497_ _08881_ VDD VSS NOR2_X1
X_18168_ _08610_ _08480_ _08882_ VDD VSS NOR2_X1
X_18169_ _08571_ _08818_ _08882_ _08883_ VDD VSS OAI21_X1
X_18170_ _08530_ _08880_ _08881_ _08883_ _08884_ VDD VSS AOI22_X1
X_18171_ _06680_ _08567_ _14760_ _08885_ VDD VSS OAI21_X1
X_18172_ _08661_ _08761_ _08885_ _08886_ VDD VSS OAI21_X2
X_18173_ _08884_ _08886_ _08549_ _08887_ VDD VSS MUX2_X1
X_18174_ net56 _08567_ _08888_ VDD VSS NOR2_X1
X_18175_ _08723_ _08536_ _14771_ _08889_ VDD VSS AOI21_X1
X_18176_ _08508_ _08530_ _08889_ _08890_ VDD VSS NOR3_X1
X_18177_ _08549_ _08888_ _08890_ _08891_ VDD VSS OAI21_X1
X_18178_ _08503_ _08452_ _06644_ _08892_ VDD VSS MUX2_X1
X_18179_ _14781_ _08892_ _08736_ _08893_ VDD VSS MUX2_X1
X_18180_ _08503_ _08547_ _08499_ _06611_ _08894_ VDD VSS AOI22_X1
X_18181_ _08772_ _08472_ _08571_ _08895_ VDD VSS AOI21_X2
X_18182_ _08894_ _08895_ _06695_ _08896_ VDD VSS MUX2_X1
X_18183_ _08891_ _08893_ _08693_ _08896_ _06681_ _08897_ VDD
+ VSS OAI221_X1
X_18184_ _08887_ _08897_ _00399_ _08898_ VDD VSS MUX2_X1
X_18185_ net56 net743 _08482_ _08899_ VDD VSS MUX2_X1
X_18186_ _14786_ _08899_ _08736_ _08900_ VDD VSS MUX2_X1
X_18187_ net746 _14780_ _08825_ _08550_ _08901_ VDD VSS OAI22_X1
X_18188_ _00397_ _08785_ _08902_ VDD VSS NAND2_X1
X_18189_ _00396_ _00397_ _08900_ _08901_ _08902_ _08903_ VDD
+ VSS OAI221_X1
X_18190_ _08438_ _06664_ net743 _08904_ VDD VSS AOI21_X1
X_18191_ _08469_ _08526_ _08567_ net746 _08904_ _14771_ _08905_
+ VDD VSS OAI222_X2
X_18192_ _08513_ _08904_ _08906_ VDD VSS OR2_X1
X_18193_ _14785_ _08755_ _08907_ VDD VSS NOR2_X1
X_18194_ _08531_ _08518_ _08905_ _08906_ _08907_ _08908_ VDD
+ VSS OAI221_X1
X_18195_ _08516_ _08903_ _08908_ _08909_ VDD VSS NAND3_X1
X_18196_ _08580_ _08754_ _08910_ VDD VSS NAND2_X1
X_18197_ _08693_ _08910_ _08438_ net1154 _08446_ _08911_ VDD
+ VSS AOI221_X1
X_18198_ _06679_ _06694_ _08912_ VDD VSS NOR2_X1
X_18199_ _08610_ _08690_ _06644_ _08913_ VDD VSS MUX2_X1
X_18200_ _08912_ _08913_ _08536_ _08914_ VDD VSS OAI21_X1
X_18201_ _08638_ _08438_ _08915_ VDD VSS NOR2_X1
X_18202_ _08915_ _08508_ _08573_ _08916_ VDD VSS AOI21_X1
X_18203_ _08914_ _08916_ _00395_ _08917_ VDD VSS AOI21_X1
X_18204_ _08564_ _08611_ net1186 _08688_ _14761_ _08918_ VDD
+ VSS AOI221_X1
X_18205_ _08468_ _08438_ _06664_ _08919_ VDD VSS NAND3_X1
X_18206_ _06680_ _08501_ _08894_ _08919_ _08920_ VDD VSS AND4_X1
X_18207_ _08911_ _08917_ _08918_ _08920_ _08921_ VDD VSS OR4_X1
X_18208_ _08909_ _08921_ _08516_ _08922_ VDD VSS OAI21_X1
X_18209_ _08898_ _08922_ _00398_ _00030_ VDD VSS MUX2_X1
X_18210_ net517 _06663_ _06678_ _08923_ VDD VSS NAND3_X1
X_18211_ _06644_ _08645_ _08923_ _08924_ VDD VSS AOI21_X1
X_18212_ _08526_ _06678_ _08479_ _08925_ VDD VSS OAI21_X1
X_18213_ _08924_ _06677_ _08570_ _08541_ _08925_ _08926_ VDD
+ VSS AOI221_X1
X_18214_ _08541_ _08731_ _08927_ VDD VSS OR2_X1
X_18215_ _08533_ _08730_ _08928_ VDD VSS OR2_X1
X_18216_ _08559_ _06664_ _06679_ _08929_ VDD VSS NOR3_X1
X_18217_ _14760_ net1154 _08929_ _08930_ VDD VSS OAI21_X1
X_18218_ _08435_ _08480_ _06679_ _08931_ VDD VSS NOR3_X1
X_18219_ _06664_ _08486_ _08932_ VDD VSS NOR2_X1
X_18220_ _14761_ _08931_ _08932_ _08933_ VDD VSS OAI21_X1
X_18221_ _08927_ _08928_ _08930_ _08933_ _08934_ VDD VSS NAND4_X1
X_18222_ _08926_ _08934_ _08513_ _08935_ VDD VSS MUX2_X1
X_18223_ _08559_ _08742_ _08664_ _08936_ VDD VSS AOI21_X2
X_18224_ _08936_ _08511_ _08571_ _08937_ VDD VSS AOI21_X1
X_18225_ _06694_ _08543_ _14783_ _08938_ VDD VSS AOI21_X1
X_18226_ _08938_ _08567_ _08490_ _08939_ VDD VSS OAI21_X1
X_18227_ _06681_ _08937_ _08549_ _08939_ _08631_ _08940_ VDD
+ VSS OAI221_X1
X_18228_ _06695_ _08471_ _08483_ _08736_ _08541_ _08941_ VDD
+ VSS OAI221_X1
X_18229_ _08503_ _08468_ _08437_ _08942_ VDD VSS MUX2_X1
X_18230_ _14792_ _08942_ _08543_ _08943_ VDD VSS MUX2_X1
X_18231_ _08941_ _08943_ _08513_ _08944_ VDD VSS OAI21_X2
X_18232_ _08940_ _08944_ _00396_ _08945_ VDD VSS OAI21_X1
X_18233_ _08935_ _08945_ _00399_ _08946_ VDD VSS MUX2_X1
X_18234_ net512 _08560_ _08947_ VDD VSS NOR2_X1
X_18235_ _08483_ _08524_ _08688_ _08948_ VDD VSS NOR3_X1
X_18236_ _08513_ _08947_ _08948_ _08949_ VDD VSS OR3_X1
X_18237_ _14785_ _08489_ _08493_ _08950_ VDD VSS OAI21_X1
X_18238_ _00397_ _08615_ _08950_ _08951_ VDD VSS NAND3_X1
X_18239_ _00396_ _08949_ _08951_ _08952_ VDD VSS AOI21_X1
X_18240_ _14760_ _08560_ _08953_ VDD VSS NOR2_X1
X_18241_ _08536_ _14771_ _14766_ _08954_ VDD VSS OAI21_X1
X_18242_ _08520_ _00395_ _08953_ _08954_ _08955_ VDD VSS OAI22_X1
X_18243_ _06681_ _08518_ _08955_ _08956_ VDD VSS NAND3_X1
X_18244_ _08782_ _08915_ _08662_ _08957_ VDD VSS OAI21_X1
X_18245_ _08956_ _08957_ _08518_ _08958_ VDD VSS OAI21_X1
X_18246_ _08736_ _08572_ _08780_ _08959_ VDD VSS AOI21_X1
X_18247_ _08516_ _08914_ _08959_ _08960_ VDD VSS OAI21_X1
X_18248_ _08666_ _08443_ net744 _08503_ _08499_ _08961_ VDD
+ VSS AOI221_X2
X_18249_ _08549_ _08961_ _08962_ VDD VSS NAND2_X1
X_18250_ _08478_ _08579_ _08438_ _08963_ VDD VSS OAI21_X1
X_18251_ _08459_ _08963_ _08964_ VDD VSS OR2_X1
X_18252_ _06681_ _08962_ _08964_ _08965_ VDD VSS AND3_X1
X_18253_ _08468_ _08611_ _08799_ _08560_ _08966_ VDD VSS OAI22_X1
X_18254_ _08531_ _08513_ _08966_ _08967_ VDD VSS AND3_X1
X_18255_ _08516_ _08952_ _08958_ _08965_ _08960_ _08967_ _08968_
+ VDD VSS OAI33_X1
X_18256_ _08946_ _08968_ _00398_ _00031_ VDD VSS MUX2_X1
X_18257_ _06614_ _08969_ VDD VSS INV_X1
X_18258_ ld_r _08970_ VDD VSS BUF_X8
X_18259_ _08970_ _08971_ VDD VSS BUF_X32
X_18260_ _08971_ _08972_ VDD VSS BUF_X32
X_18261_ _08972_ _08973_ VDD VSS BUF_X32
X_18262_ _08973_ _08974_ VDD VSS BUF_X32
X_18263_ _08974_ _08975_ VDD VSS BUF_X8
X_18264_ _08969_ _08975_ _08976_ VDD VSS NOR2_X1
X_18265_ _06614_ _08975_ _08977_ VDD VSS NOR2_X1
X_18266_ sa00_sr\[7\] _08978_ VDD VSS BUF_X8
X_18267_ sa10_sr\[7\] _08979_ VDD VSS BUF_X8
X_18268_ _08979_ _08978_ _08980_ VDD VSS XOR2_X2
Xclone29 _06351_ net29 VDD VSS BUF_X4
Xclone8 _06465_ net699 net8 VDD VSS XOR2_X2
X_18271_ sa10_sr\[1\] sa20_sr\[1\] _08983_ VDD VSS XNOR2_X2
X_18272_ _08980_ _08983_ _08984_ VDD VSS XNOR2_X2
Xclone36 net614 net36 VDD VSS BUF_X8
X_18274_ sa10_sr\[0\] _08986_ VDD VSS BUF_X4
X_18275_ sa30_sr\[1\] _08987_ VDD VSS BUF_X4
X_18276_ _08986_ _08987_ _08988_ VDD VSS XOR2_X2
X_18277_ sa00_sr\[0\] _08988_ _08989_ VDD VSS XNOR2_X1
X_18278_ _08984_ _08989_ _08990_ VDD VSS XNOR2_X2
X_18279_ _08976_ _08977_ _08990_ _08991_ VDD VSS MUX2_X2
X_18280_ _08970_ _08992_ VDD VSS BUF_X16
X_18281_ _08992_ _08993_ VDD VSS BUF_X8
X_18282_ _08993_ _08994_ VDD VSS BUF_X8
X_18283_ _08994_ _08995_ VDD VSS BUF_X8
X_18284_ _08995_ _08996_ VDD VSS BUF_X8
X_18285_ _06614_ _00440_ _08997_ VDD VSS NOR2_X2
X_18286_ _08996_ _08997_ _08998_ VDD VSS NAND2_X1
X_18287_ _06614_ _00440_ _08999_ VDD VSS AND2_X1
X_18288_ _08996_ _08999_ _09000_ VDD VSS NAND2_X1
X_18289_ _09000_ _08998_ _09001_ VDD VSS NAND2_X4
X_18290_ _09001_ _08991_ _09002_ VDD VSS NOR2_X4
X_18291_ net663 _09003_ VDD VSS INV_X16
Xclone375 _01707_ net840 VDD VSS BUF_X8
X_18293_ _09003_ _14800_ VDD VSS BUF_X32
Xclone37 _09236_ net37 VDD VSS BUF_X4
X_18295_ sa20_sr\[0\] _09006_ VDD VSS BUF_X4
X_18296_ _08986_ _09006_ _09007_ VDD VSS XNOR2_X2
X_18297_ net702 _09007_ _09008_ VDD VSS XNOR2_X1
X_18298_ _08970_ _09009_ VDD VSS INV_X16
X_18299_ _09009_ _09010_ VDD VSS BUF_X32
X_18300_ _09010_ _09011_ VDD VSS BUF_X32
X_18301_ _09011_ _09012_ VDD VSS BUF_X32
X_18302_ _06598_ _09012_ _08980_ _09013_ VDD VSS NAND3_X1
X_18303_ _08978_ _08979_ _09014_ VDD VSS XNOR2_X2
X_18304_ _08992_ _09015_ VDD VSS BUF_X8
X_18305_ _06598_ _09015_ _09016_ VDD VSS NOR2_X1
X_18306_ _09014_ _09016_ _09017_ VDD VSS NAND2_X1
X_18307_ _09008_ _09013_ _09017_ _09018_ VDD VSS AOI21_X1
X_18308_ _08986_ _09006_ _09019_ VDD VSS XOR2_X2
X_18309_ net633 _09019_ _09020_ VDD VSS XNOR2_X1
X_18310_ _08980_ _09016_ _09021_ VDD VSS NAND2_X1
X_18311_ _09009_ _09022_ VDD VSS BUF_X8
X_18312_ _09022_ _09023_ VDD VSS BUF_X16
X_18313_ _06598_ _09023_ _09014_ _09024_ VDD VSS NAND3_X1
X_18314_ _09020_ _09021_ _09024_ _09025_ VDD VSS AOI21_X1
X_18315_ _06598_ _09026_ VDD VSS INV_X1
X_18316_ _08971_ _09027_ VDD VSS BUF_X16
X_18317_ _09027_ _09028_ VDD VSS BUF_X8
X_18318_ _09026_ _09028_ _00441_ _09029_ VDD VSS NAND3_X1
X_18319_ _09027_ _09030_ VDD VSS BUF_X16
X_18320_ _06598_ _09030_ _09031_ VDD VSS NAND2_X1
X_18321_ _09029_ _09031_ _00441_ _09032_ VDD VSS OAI21_X1
X_18322_ _09018_ _09025_ _09032_ _09033_ VDD VSS OR3_X4
X_18323_ _09033_ _09034_ VDD VSS INV_X8
Xrebuffer404 _05531_ net869 VDD VSS BUF_X8
X_18325_ _09034_ _14803_ VDD VSS BUF_X8
Xclone16 _06225_ net16 VDD VSS BUF_X8
X_18327_ sa30_sr\[2\] _09037_ VDD VSS BUF_X4
X_18328_ net536 _09037_ _09038_ VDD VSS XOR2_X2
X_18329_ net572 _09038_ _09039_ VDD VSS XOR2_X2
X_18330_ sa10_sr\[2\] _09040_ VDD VSS CLKBUF_X3
X_18331_ sa20_sr\[2\] _09041_ VDD VSS CLKBUF_X3
X_18332_ _09040_ _09041_ _09042_ VDD VSS XOR2_X2
X_18333_ _06630_ _09022_ _09042_ _09043_ VDD VSS NAND3_X1
X_18334_ _09040_ _09041_ _09044_ VDD VSS XNOR2_X2
X_18335_ _06630_ _08971_ _09045_ VDD VSS NOR2_X1
X_18336_ _09044_ _09045_ _09046_ VDD VSS NAND2_X1
X_18337_ _09039_ _09043_ _09046_ _09047_ VDD VSS AOI21_X2
X_18338_ net573 _09038_ _09048_ VDD VSS XNOR2_X1
X_18339_ _09042_ _09045_ _09049_ VDD VSS NAND2_X1
X_18340_ _06630_ net829 _09044_ _09050_ VDD VSS NAND3_X1
X_18341_ _09048_ _09049_ _09050_ _09051_ VDD VSS AOI21_X2
X_18342_ _06630_ _09052_ VDD VSS INV_X1
X_18343_ _09052_ _08972_ _00442_ _09053_ VDD VSS NAND3_X1
X_18344_ _06630_ _08972_ _09054_ VDD VSS NAND2_X1
X_18345_ _09053_ _09054_ _00442_ _09055_ VDD VSS OAI21_X2
X_18346_ _09047_ _09051_ _09055_ _09056_ VDD VSS NOR3_X4
X_18347_ _09056_ _09057_ VDD VSS INV_X2
X_18348_ _09057_ _09058_ VDD VSS BUF_X4
X_18349_ _09058_ _09059_ VDD VSS CLKBUF_X3
X_18350_ _09059_ _09060_ VDD VSS BUF_X4
X_18351_ _09060_ _14819_ VDD VSS BUF_X4
X_18352_ _09033_ _09061_ VDD VSS BUF_X16
X_18353_ _09061_ _14794_ VDD VSS BUF_X8
X_18354_ _09056_ _09062_ VDD VSS BUF_X4
X_18355_ _09062_ _09063_ VDD VSS BUF_X4
X_18356_ _09063_ _09064_ VDD VSS CLKBUF_X3
X_18357_ _09064_ _14812_ VDD VSS BUF_X4
X_18358_ sa00_sr\[5\] _09065_ VDD VSS BUF_X2
X_18359_ sa10_sr\[6\] _09066_ VDD VSS BUF_X2
X_18360_ sa20_sr\[6\] _09067_ VDD VSS BUF_X2
X_18361_ _09066_ _09067_ _09068_ VDD VSS XNOR2_X2
X_18362_ _09065_ _09068_ _09069_ VDD VSS XNOR2_X2
X_18363_ sa10_sr\[5\] _09070_ VDD VSS CLKBUF_X3
X_18364_ sa30_sr\[6\] _09071_ VDD VSS BUF_X4
X_18365_ _09070_ _09071_ _09072_ VDD VSS XNOR2_X1
X_18366_ _09069_ _09072_ _09073_ VDD VSS XNOR2_X1
X_18367_ _09010_ _09074_ VDD VSS BUF_X8
X_18368_ _09074_ _09075_ VDD VSS BUF_X8
X_18369_ _09075_ _09076_ VDD VSS BUF_X8
X_18370_ text_in_r\[126\] _09073_ _09076_ _09077_ VDD VSS
+ MUX2_X2
X_18371_ _06701_ _09077_ _09078_ VDD VSS XOR2_X2
X_18372_ _09078_ _09079_ VDD VSS BUF_X4
X_18373_ _09079_ _09080_ VDD VSS BUF_X4
X_18374_ _09058_ _09081_ VDD VSS BUF_X4
X_18375_ _09081_ _09082_ VDD VSS CLKBUF_X3
X_18376_ _09082_ _09083_ VDD VSS CLKBUF_X3
X_18377_ _14794_ _09083_ _09084_ VDD VSS NAND2_X1
X_18378_ _06649_ _08974_ _09085_ VDD VSS NOR2_X1
X_18379_ _06649_ _09086_ VDD VSS INV_X1
X_18380_ _09086_ _08974_ _09087_ VDD VSS NOR2_X1
X_18381_ sa00_sr\[2\] _09088_ VDD VSS BUF_X4
X_18382_ sa20_sr\[3\] _09089_ VDD VSS BUF_X2
X_18383_ _09088_ _09089_ _09090_ VDD VSS XNOR2_X1
X_18384_ _08978_ _09090_ _09091_ VDD VSS XNOR2_X2
X_18385_ sa10_sr\[3\] _09092_ VDD VSS BUF_X2
X_18386_ _08979_ _09092_ _09093_ VDD VSS XOR2_X2
X_18387_ sa30_sr\[3\] _09094_ VDD VSS BUF_X4
X_18388_ _09040_ _09094_ _09095_ VDD VSS XNOR2_X1
X_18389_ _09093_ _09095_ _09096_ VDD VSS XNOR2_X1
X_18390_ _09091_ _09096_ _09097_ VDD VSS XNOR2_X2
X_18391_ _09085_ _09087_ _09097_ _09098_ VDD VSS MUX2_X2
X_18392_ _09010_ _09099_ VDD VSS BUF_X32
X_18393_ _09099_ _09100_ VDD VSS BUF_X32
X_18394_ _09086_ net871 text_in_r\[123\] _09101_ VDD VSS OR3_X2
X_18395_ _09015_ _09102_ VDD VSS BUF_X16
X_18396_ _09102_ _09103_ VDD VSS BUF_X16
X_18397_ _09086_ _09103_ text_in_r\[123\] _09104_ VDD VSS
+ NAND3_X2
X_18398_ _09101_ _09104_ _09105_ VDD VSS NAND2_X4
X_18399_ _09098_ _09105_ _09106_ VDD VSS NOR2_X4
X_18400_ _09003_ _09106_ _09107_ VDD VSS NOR2_X1
X_18401_ _09098_ _09108_ VDD VSS BUF_X8
X_18402_ _09056_ _09108_ _09105_ _09109_ VDD VSS OAI21_X4
X_18403_ _14801_ _09110_ VDD VSS BUF_X4
X_18404_ _09080_ _09084_ _09107_ _09109_ _09110_ _09111_ VDD
+ VSS OAI221_X1
X_18405_ _09059_ _09112_ VDD VSS CLKBUF_X3
X_18406_ _09112_ _09113_ VDD VSS CLKBUF_X3
X_18407_ _14804_ _09114_ VDD VSS CLKBUF_X3
X_18408_ _09114_ _09115_ VDD VSS INV_X1
X_18409_ _09023_ _09116_ VDD VSS BUF_X8
X_18410_ _09086_ _09116_ _09117_ VDD VSS NAND2_X1
X_18411_ _09012_ _09118_ VDD VSS BUF_X32
X_18412_ _06649_ _09118_ _09119_ VDD VSS NAND2_X1
X_18413_ _09117_ _09119_ _09097_ _09120_ VDD VSS MUX2_X1
X_18414_ _09120_ _09121_ VDD VSS BUF_X4
X_18415_ _09121_ _09122_ VDD VSS BUF_X8
X_18416_ _09122_ _09123_ VDD VSS BUF_X4
X_18417_ _09101_ _09104_ _09124_ VDD VSS AND2_X1
X_18418_ _09124_ _09125_ VDD VSS BUF_X4
X_18419_ _09125_ _09126_ VDD VSS BUF_X4
X_18420_ _09126_ _09127_ VDD VSS BUF_X4
X_18421_ _09115_ _09123_ _09127_ _09128_ VDD VSS AOI21_X2
X_18422_ _14797_ _09129_ VDD VSS BUF_X4
X_18423_ _09105_ _09130_ VDD VSS BUF_X8
X_18424_ _09129_ _09108_ _09130_ _09131_ VDD VSS NOR3_X4
X_18425_ _09113_ _09128_ _09131_ _09132_ VDD VSS NOR3_X1
X_18426_ _09106_ _09133_ VDD VSS BUF_X4
X_18427_ _09133_ _09134_ VDD VSS BUF_X4
X_18428_ _09103_ _09135_ VDD VSS BUF_X8
X_18429_ _09135_ _09136_ VDD VSS BUF_X8
X_18430_ _09136_ _08997_ _08999_ _09137_ VDD VSS OAI21_X4
X_18431_ _09116_ _09138_ VDD VSS BUF_X4
X_18432_ _06614_ _09138_ _09139_ VDD VSS NAND2_X1
X_18433_ _08969_ _09138_ _09140_ VDD VSS NAND2_X1
X_18434_ _09139_ _09140_ _08990_ _09141_ VDD VSS MUX2_X2
X_18435_ _09061_ _09137_ _09141_ _09142_ VDD VSS AOI21_X4
X_18436_ _09134_ _09142_ _09143_ VDD VSS NAND2_X1
Xclone106 net107 net106 VDD VSS INV_X2
X_18438_ _09108_ _09145_ VDD VSS BUF_X4
X_18439_ _09130_ _09146_ VDD VSS BUF_X4
X_18440_ _14796_ _09145_ _09146_ _09147_ VDD VSS OAI21_X2
X_18441_ _09113_ _09147_ _09148_ VDD VSS AND2_X1
X_18442_ _09132_ _09143_ _09148_ _09149_ VDD VSS AOI21_X1
X_18443_ _09111_ _09149_ _09080_ _09150_ VDD VSS OAI21_X1
X_18444_ sa20_sr\[7\] _09151_ VDD VSS BUF_X8
X_18445_ sa30_sr\[7\] _09152_ VDD VSS BUF_X8
X_18446_ net624 _09152_ _09153_ VDD VSS XOR2_X2
X_18447_ sa00_sr\[6\] _09154_ VDD VSS BUF_X2
X_18448_ _09066_ _09154_ _09155_ VDD VSS XOR2_X1
X_18449_ net583 _09155_ _09156_ VDD VSS XNOR2_X1
X_18450_ _08979_ _09156_ _09157_ VDD VSS XNOR2_X1
X_18451_ _09076_ _09158_ VDD VSS BUF_X4
X_18452_ text_in_r\[127\] _09157_ _09158_ _09159_ VDD VSS
+ MUX2_X2
X_18453_ _06706_ _09159_ _09160_ VDD VSS XNOR2_X2
X_18454_ sa10_sr\[4\] _09161_ VDD VSS CLKBUF_X3
X_18455_ sa00_sr\[4\] _09162_ VDD VSS BUF_X4
X_18456_ _09161_ _09162_ _09163_ VDD VSS XNOR2_X2
X_18457_ _09070_ _09163_ _09164_ VDD VSS XNOR2_X1
X_18458_ sa20_sr\[5\] _09165_ VDD VSS BUF_X4
X_18459_ sa30_sr\[5\] _09166_ VDD VSS BUF_X4
X_18460_ _09165_ _09166_ _09167_ VDD VSS XOR2_X2
X_18461_ _06683_ _09138_ _09167_ _09168_ VDD VSS NAND3_X1
X_18462_ _09165_ _09166_ _09169_ VDD VSS XNOR2_X2
X_18463_ _06683_ _09103_ _09170_ VDD VSS NOR2_X1
X_18464_ _09169_ _09170_ _09171_ VDD VSS NAND2_X1
X_18465_ _09164_ _09168_ _09171_ _09172_ VDD VSS AOI21_X2
X_18466_ _09070_ _09163_ _09173_ VDD VSS XOR2_X1
X_18467_ _09167_ _09170_ _09174_ VDD VSS NAND2_X1
X_18468_ _09116_ _09175_ VDD VSS BUF_X4
X_18469_ _06683_ _09175_ _09169_ _09176_ VDD VSS NAND3_X1
X_18470_ _09173_ _09174_ _09176_ _09177_ VDD VSS AOI21_X2
X_18471_ _06683_ _09118_ text_in_r\[125\] _09178_ VDD VSS
+ OR3_X1
X_18472_ _09030_ _09179_ VDD VSS BUF_X16
X_18473_ _09179_ _09180_ VDD VSS BUF_X8
X_18474_ _06683_ _09180_ text_in_r\[125\] _09181_ VDD VSS
+ NAND3_X1
X_18475_ _09178_ _09181_ _09182_ VDD VSS NAND2_X1
X_18476_ _09172_ _09177_ _09182_ _09183_ VDD VSS NOR3_X4
X_18477_ _09183_ _09184_ VDD VSS BUF_X4
X_18478_ _09184_ _09185_ VDD VSS CLKBUF_X3
X_18479_ sa00_sr\[3\] _09186_ VDD VSS BUF_X2
X_18480_ sa20_sr\[4\] _09187_ VDD VSS CLKBUF_X3
X_18481_ _09186_ _09187_ _09188_ VDD VSS XNOR2_X1
X_18482_ _08978_ _09188_ _09189_ VDD VSS XNOR2_X2
X_18483_ sa30_sr\[4\] _09190_ VDD VSS BUF_X4
X_18484_ _09161_ _09190_ _09191_ VDD VSS XOR2_X1
X_18485_ _09093_ _09191_ _09192_ VDD VSS XNOR2_X1
X_18486_ _09189_ _09192_ _09193_ VDD VSS XNOR2_X1
X_18487_ _09022_ _09194_ VDD VSS BUF_X8
X_18488_ _09194_ _09195_ VDD VSS BUF_X8
X_18489_ text_in_r\[124\] _09193_ _09195_ _09196_ VDD VSS
+ MUX2_X2
X_18490_ _06666_ _09196_ _09197_ VDD VSS XNOR2_X2
X_18491_ _09197_ _09198_ VDD VSS CLKBUF_X3
X_18492_ _09198_ _09199_ VDD VSS CLKBUF_X3
X_18493_ _09150_ _09160_ _09185_ _09199_ _09200_ VDD VSS NAND4_X1
X_18494_ _06701_ _09077_ _09201_ VDD VSS XNOR2_X2
X_18495_ _09201_ _09202_ VDD VSS BUF_X4
Xclone137 _03673_ net137 VDD VSS BUF_X2
X_18497_ _14798_ _09122_ _09126_ _09204_ VDD VSS NAND3_X2
X_18498_ _09121_ _09125_ _09205_ VDD VSS NAND2_X2
X_18499_ _09205_ _09206_ VDD VSS BUF_X4
X_18500_ _09206_ _09207_ VDD VSS BUF_X4
X_18501_ _09207_ _09208_ VDD VSS BUF_X4
X_18502_ _09002_ _09209_ VDD VSS BUF_X16
X_18503_ _09209_ _09210_ VDD VSS BUF_X4
X_18504_ _09208_ _14803_ _09210_ _09211_ VDD VSS OAI21_X1
X_18505_ _09083_ _09204_ _09211_ _09212_ VDD VSS AOI21_X1
X_18506_ _06666_ _09196_ _09213_ VDD VSS XOR2_X2
X_18507_ _09213_ _09214_ VDD VSS BUF_X4
X_18508_ _09214_ _09215_ VDD VSS BUF_X4
X_18509_ _09062_ _09122_ _09126_ _09216_ VDD VSS AOI21_X4
Xsplit148 _14874_ net148 VDD VSS BUF_X1
X_18511_ _14806_ _09218_ VDD VSS BUF_X8
X_18512_ _09215_ _09216_ _09218_ _09219_ VDD VSS AOI21_X1
X_18513_ _09219_ _09220_ VDD VSS INV_X1
X_18514_ _14798_ _09221_ VDD VSS INV_X1
X_18515_ _09214_ _09109_ _09221_ _09222_ VDD VSS OAI21_X2
X_18516_ _09034_ _09057_ _09223_ VDD VSS NOR2_X4
X_18517_ _09207_ _09223_ _09003_ _09112_ _09114_ _09224_ VDD
+ VSS AOI221_X2
X_18518_ _09202_ _09212_ _09220_ _09222_ _09224_ _09225_ VDD
+ VSS OAI221_X2
X_18519_ _09062_ _09226_ VDD VSS BUF_X4
X_18520_ _09226_ _09227_ VDD VSS BUF_X4
X_18521_ _09110_ _09123_ _09127_ _09228_ VDD VSS AOI21_X2
X_18522_ net866 _09145_ _09146_ _09229_ VDD VSS NOR3_X1
X_18523_ _09227_ _09228_ _09229_ _09230_ VDD VSS OAI21_X1
X_18524_ _09062_ _09108_ _09130_ _09231_ VDD VSS NOR3_X4
X_18525_ net971 _09231_ _09232_ VDD VSS NAND2_X1
X_18526_ _09230_ _09232_ _09233_ VDD VSS AND2_X1
X_18527_ _09197_ _09234_ VDD VSS BUF_X4
X_18528_ _09081_ _09137_ _09141_ _09235_ VDD VSS AOI21_X2
X_18529_ _09129_ _09236_ VDD VSS INV_X8
X_18530_ _09236_ _09237_ VDD VSS BUF_X8
X_18531_ _09123_ _09127_ _09237_ _09226_ _09238_ VDD VSS OAI211_X4
X_18532_ _09234_ _09238_ _09235_ _09239_ VDD VSS OAI21_X2
X_18533_ _09134_ _09240_ VDD VSS CLKBUF_X3
X_18534_ _09034_ _09226_ _09241_ VDD VSS NAND2_X2
X_18535_ _09115_ _09083_ _09242_ VDD VSS NAND2_X1
X_18536_ _09240_ _09241_ _09242_ _09243_ VDD VSS AOI21_X1
X_18537_ _09079_ _09199_ _09233_ _09239_ _09243_ _09244_ VDD
+ VSS OAI221_X1
X_18538_ _09185_ _09225_ _09244_ _09245_ VDD VSS AND3_X1
X_18539_ _06706_ _09159_ _09246_ VDD VSS XOR2_X2
X_18540_ _09106_ _09247_ VDD VSS BUF_X4
X_18541_ _09061_ _09226_ net664 net867 _09248_ VDD VSS OAI211_X4
X_18542_ _14801_ _09249_ VDD VSS INV_X4
X_18543_ net834 _09058_ _09250_ VDD VSS NAND2_X4
X_18544_ _09247_ _09248_ _09250_ _09251_ VDD VSS NAND3_X1
X_18545_ _09234_ _09251_ _09252_ VDD VSS AND2_X1
X_18546_ _09034_ _09108_ _09130_ _09253_ VDD VSS OAI21_X4
X_18547_ _09226_ _09204_ _09253_ _09254_ VDD VSS AOI21_X1
X_18548_ _09057_ _09121_ _09125_ _09255_ VDD VSS AOI21_X2
X_18549_ _09255_ _09256_ VDD VSS BUF_X4
X_18550_ _14796_ _09257_ VDD VSS INV_X2
X_18551_ _09254_ _09256_ _09257_ _09258_ VDD VSS AOI21_X1
X_18552_ _09247_ _09259_ VDD VSS BUF_X4
X_18553_ _09238_ _09259_ _14817_ _09260_ VDD VSS OAI21_X1
X_18554_ _09214_ _09261_ VDD VSS BUF_X4
X_18555_ _09078_ _09252_ _09258_ _09260_ _09261_ _09262_ VDD
+ VSS AOI221_X1
X_18556_ _09172_ _09177_ _09182_ _09263_ VDD VSS OR3_X1
X_18557_ _09263_ _09264_ VDD VSS BUF_X4
X_18558_ _09264_ _09265_ VDD VSS BUF_X4
X_18559_ _09265_ _09266_ VDD VSS CLKBUF_X3
X_18560_ _09266_ _09267_ VDD VSS CLKBUF_X3
X_18561_ _14806_ _09122_ _09126_ _09268_ VDD VSS NAND3_X2
X_18562_ _09129_ _09108_ _09130_ _09269_ VDD VSS OAI21_X4
X_18563_ _09198_ _09268_ _09269_ _09270_ VDD VSS AOI21_X1
X_18564_ _09106_ _09213_ _09271_ VDD VSS NOR2_X2
X_18565_ _09034_ net867 net494 _09272_ VDD VSS OAI21_X4
X_18566_ _09270_ _09271_ _09272_ _09273_ VDD VSS AOI21_X1
X_18567_ _09227_ _09274_ VDD VSS BUF_X4
X_18568_ _09274_ _09079_ _09275_ VDD VSS NAND2_X1
X_18569_ _14819_ _09079_ _09276_ VDD VSS NAND2_X1
X_18570_ _09034_ _09121_ _09125_ _09277_ VDD VSS AOI21_X4
X_18571_ _09234_ _09277_ _09278_ VDD VSS NAND2_X1
X_18572_ _09207_ _09279_ VDD VSS CLKBUF_X3
X_18573_ _09278_ _09279_ _09110_ _09280_ VDD VSS OAI21_X1
X_18574_ _09267_ _09273_ _09275_ _09276_ _09280_ _09281_ VDD
+ VSS OAI221_X1
X_18575_ _09246_ _09262_ _09281_ _09282_ VDD VSS OAI21_X1
X_18576_ _09081_ _09123_ _09127_ _09283_ VDD VSS NAND3_X2
X_18577_ net37 _09109_ _09283_ _09114_ _09284_ VDD VSS OAI22_X1
X_18578_ _09081_ _09145_ _09146_ _09285_ VDD VSS OAI21_X4
X_18579_ _09226_ _09123_ _09127_ _09286_ VDD VSS NAND3_X2
X_18580_ _09285_ _09286_ _09287_ VDD VSS NAND2_X2
X_18581_ _09284_ _09287_ _09257_ _09288_ VDD VSS AOI21_X1
X_18582_ _09079_ _09285_ _14803_ _09286_ _14798_ _09289_ VDD
+ VSS OAI221_X2
Xrebuffer90 _15165_ net566 VDD VSS BUF_X4
X_18584_ _09209_ _14795_ VDD VSS BUF_X32
X_18585_ _09231_ _09256_ _14803_ _09291_ VDD VSS AOI21_X1
X_18586_ _14795_ _09291_ _09292_ VDD VSS NOR2_X1
X_18587_ _09080_ _09288_ _09289_ _09292_ _09293_ VDD VSS OAI22_X2
X_18588_ _09184_ _09215_ _09294_ VDD VSS NOR2_X2
X_18589_ _09034_ _09122_ _09126_ _09295_ VDD VSS NAND3_X4
Xsplit83 _14810_ net83 VDD VSS BUF_X1
X_18591_ _14810_ _09297_ VDD VSS INV_X4
X_18592_ _09297_ _09122_ _09126_ _09298_ VDD VSS AOI21_X4
X_18593_ _09298_ _09259_ _09210_ _09299_ VDD VSS AOI21_X2
X_18594_ _09295_ _09109_ net37 _09299_ _09064_ _09300_ VDD
+ VSS OAI221_X1
X_18595_ _09061_ _09058_ _09301_ VDD VSS NOR2_X4
X_18596_ _09301_ _14794_ _09209_ _09302_ VDD VSS AOI21_X1
X_18597_ _09259_ _09302_ _09303_ VDD VSS XNOR2_X1
X_18598_ _09300_ _09303_ _09202_ _09304_ VDD VSS MUX2_X1
X_18599_ _09264_ _09197_ _09305_ VDD VSS NOR2_X2
X_18600_ _09237_ _09108_ _09146_ _09306_ VDD VSS NOR3_X4
X_18601_ _09209_ _09081_ _09307_ VDD VSS NAND2_X1
X_18602_ _09129_ _09056_ _09308_ VDD VSS NOR2_X2
X_18603_ _09209_ _09247_ _09309_ VDD VSS NAND2_X1
X_18604_ _09078_ _09306_ _09307_ _09308_ _09309_ _09310_ VDD
+ VSS AOI221_X2
X_18605_ net861 _09208_ _09311_ VDD VSS NOR2_X1
X_18606_ _14810_ _09145_ _09146_ _09312_ VDD VSS OAI21_X2
X_18607_ _09312_ _09208_ _09210_ _09313_ VDD VSS OAI21_X1
X_18608_ _09084_ _09311_ _09313_ _09083_ _09314_ VDD VSS OAI22_X1
X_18609_ _09310_ _09314_ _09079_ _09315_ VDD VSS AOI21_X1
X_18610_ _09184_ _09234_ _09316_ VDD VSS NOR2_X2
X_18611_ _09293_ _09294_ _09305_ _09304_ _09315_ _09316_ _09317_
+ VDD VSS AOI222_X2
X_18612_ _09200_ _09245_ _09282_ _09317_ _09246_ _00032_ VDD
+ VSS OAI221_X1
X_18613_ _09034_ _09098_ _09105_ _09318_ VDD VSS NOR3_X4
X_18614_ _09249_ _09121_ _09125_ _09319_ VDD VSS AOI21_X4
X_18615_ _09064_ _09318_ _09319_ _09320_ VDD VSS OAI21_X1
X_18616_ _09003_ _09133_ _09321_ VDD VSS XNOR2_X2
X_18617_ _09202_ _09320_ _09321_ _09274_ _09322_ VDD VSS OAI211_X2
X_18618_ _09134_ _09272_ _09323_ VDD VSS NOR2_X1
X_18619_ _09221_ _09123_ _09127_ _09324_ VDD VSS NAND3_X1
X_18620_ _09082_ _09324_ _09325_ VDD VSS NAND2_X1
X_18621_ net833 _09098_ _09105_ _09326_ VDD VSS NOR3_X4
X_18622_ _09058_ _09326_ _09327_ VDD VSS OR2_X1
X_18623_ _09236_ _09121_ _09125_ _09328_ VDD VSS AOI21_X4
X_18624_ _09078_ _09323_ _09325_ _09327_ _09328_ _09329_ VDD
+ VSS OAI221_X1
X_18625_ _09185_ _09322_ _09329_ _09330_ VDD VSS AOI21_X1
X_18626_ _09112_ _09147_ _09324_ _09331_ VDD VSS AOI21_X1
X_18627_ _09061_ _09108_ _09130_ _09332_ VDD VSS NOR3_X4
X_18628_ _09227_ _09332_ _09328_ _09333_ VDD VSS NOR3_X1
X_18629_ _09201_ _09331_ _09333_ _09334_ VDD VSS NOR3_X1
X_18630_ _09061_ _09062_ _09335_ VDD VSS NOR2_X4
X_18631_ _09223_ _09335_ _09336_ VDD VSS NOR2_X1
X_18632_ net663 _09133_ _09337_ VDD VSS NOR2_X2
X_18633_ net971 _09081_ _09338_ VDD VSS NAND2_X1
X_18634_ _09338_ _09059_ _09034_ _09339_ VDD VSS OAI21_X1
X_18635_ _09078_ _09336_ _09337_ _09339_ _09134_ _09340_ VDD
+ VSS AOI221_X1
X_18636_ _09266_ _09334_ _09340_ _09341_ VDD VSS NOR3_X1
X_18637_ _09246_ _09199_ _09330_ _09341_ _09342_ VDD VSS NOR4_X1
X_18638_ _09201_ _09265_ _09343_ VDD VSS NOR2_X1
X_18639_ net834 _09081_ _09344_ VDD VSS NOR2_X4
X_18640_ _09062_ _09137_ _09141_ _09345_ VDD VSS AOI21_X4
X_18641_ _09279_ _09344_ _09345_ _09346_ VDD VSS OAI21_X1
X_18642_ _09098_ _09130_ _09034_ _09056_ _09347_ VDD VSS AOI211_X2
X_18643_ _09338_ _09347_ _09348_ VDD VSS NAND2_X1
X_18644_ _09343_ _09346_ _09348_ _09349_ VDD VSS NAND3_X1
X_18645_ _09160_ _09199_ _09349_ _09350_ VDD VSS NAND3_X1
X_18646_ _09078_ _09264_ _09351_ VDD VSS NAND2_X1
X_18647_ _09206_ _09272_ _09352_ VDD VSS NOR2_X2
X_18648_ _09129_ _09353_ VDD VSS BUF_X8
X_18649_ _09353_ _09123_ _09127_ _09354_ VDD VSS AOI21_X2
X_18650_ _09274_ _09352_ _09354_ _09355_ VDD VSS OAI21_X1
X_18651_ _14794_ _09231_ _09356_ VDD VSS NAND2_X1
X_18652_ _09351_ _09355_ _09356_ _09357_ VDD VSS AOI21_X1
X_18653_ _09115_ _09226_ _09358_ VDD VSS NOR2_X1
X_18654_ _09060_ _09272_ _09359_ VDD VSS NOR2_X1
X_18655_ _09279_ _09358_ _09359_ _09360_ VDD VSS NOR3_X1
X_18656_ _14820_ _09240_ _09184_ _09361_ VDD VSS NOR3_X1
X_18657_ _09079_ _09360_ _09361_ _09362_ VDD VSS NOR3_X1
X_18658_ _09297_ _09063_ _09363_ VDD VSS NOR2_X2
X_18659_ _09235_ _09363_ _09364_ VDD VSS NOR2_X1
X_18660_ _09207_ _09214_ _09365_ VDD VSS NAND2_X1
X_18661_ _09057_ _09098_ _09105_ _09366_ VDD VSS NOR3_X4
X_18662_ _09366_ _09215_ _09110_ _09367_ VDD VSS OAI21_X1
X_18663_ _09184_ _09364_ _09365_ _09367_ _09142_ _09368_ VDD
+ VSS OAI221_X1
X_18664_ _09106_ _09142_ _09369_ VDD VSS NOR2_X1
X_18665_ _09237_ _09145_ _09146_ _09370_ VDD VSS OAI21_X2
X_18666_ _09110_ _09123_ _09127_ _09371_ VDD VSS NAND3_X1
X_18667_ _09370_ _09371_ _09372_ VDD VSS NAND2_X1
X_18668_ _09369_ _09372_ _09227_ _09373_ VDD VSS MUX2_X1
X_18669_ _09368_ _09373_ _09198_ _09374_ VDD VSS AOI21_X2
X_18670_ _09078_ _09246_ _09375_ VDD VSS NAND2_X2
X_18671_ _09257_ _09108_ _09130_ _09376_ VDD VSS NOR3_X4
X_18672_ _09082_ _09328_ _09376_ _09377_ VDD VSS NOR3_X1
X_18673_ _09112_ _09332_ _09319_ _09378_ VDD VSS OAI21_X1
X_18674_ _09316_ _09378_ _09379_ VDD VSS NAND2_X1
X_18675_ _09237_ _09283_ _09253_ _09003_ _09380_ VDD VSS OAI22_X1
X_18676_ _09380_ _09287_ _14794_ _09381_ VDD VSS AOI21_X1
X_18677_ _09264_ _09197_ _09382_ VDD VSS NAND2_X2
X_18678_ _09377_ _09379_ _09381_ _09382_ _09383_ VDD VSS OAI22_X1
X_18679_ _09350_ _09357_ _09362_ _09374_ _09375_ _09383_ _09384_
+ VDD VSS OAI33_X1
X_18680_ _09202_ _09246_ _09385_ VDD VSS NAND2_X1
X_18681_ net860 _14812_ _09277_ _09386_ VDD VSS OAI21_X1
X_18682_ _09183_ _09197_ _09387_ VDD VSS NAND2_X4
X_18683_ _09387_ _09318_ net36 _09227_ _09207_ _09388_ VDD
+ VSS AOI221_X2
X_18684_ _09061_ _09108_ _09130_ _09389_ VDD VSS OAI21_X4
X_18685_ _09083_ _09295_ _09389_ _09390_ VDD VSS NAND3_X1
X_18686_ _09269_ _09371_ _09391_ VDD VSS AND2_X1
X_18687_ _09390_ _09391_ _09113_ _09392_ VDD VSS OAI21_X1
X_18688_ _09386_ _09388_ _09392_ _09305_ _09393_ VDD VSS AOI22_X1
X_18689_ _09249_ _09231_ _09287_ net860 _09394_ VDD VSS AOI22_X1
X_18690_ _09353_ _09083_ _09395_ VDD VSS NAND2_X1
X_18691_ net83 _09064_ _09396_ VDD VSS NAND2_X1
X_18692_ _09240_ _09395_ _09396_ _09397_ VDD VSS AOI21_X1
X_18693_ _09198_ _09251_ _09398_ VDD VSS NAND2_X1
X_18694_ _09267_ _09199_ _09394_ _09397_ _09398_ _09399_ VDD
+ VSS OAI221_X1
X_18695_ _09385_ _09393_ _09399_ _09400_ VDD VSS AOI21_X1
X_18696_ _09342_ _09384_ _09400_ _00033_ VDD VSS OR3_X2
X_18697_ _09160_ _09267_ _09401_ VDD VSS NOR2_X1
X_18698_ _09112_ _09228_ _09402_ VDD VSS NOR2_X1
X_18699_ _09061_ _09121_ _09125_ _09403_ VDD VSS AOI21_X4
X_18700_ _09114_ _09259_ _09403_ net861 _09404_ VDD VSS AOI22_X1
X_18701_ _09222_ _09402_ _09143_ _09404_ _09113_ _09405_ VDD
+ VSS AOI221_X1
X_18702_ _09354_ _09376_ _09406_ VDD VSS NOR2_X1
X_18703_ _09215_ _09216_ _09110_ _09406_ _09274_ _09407_ VDD
+ VSS AOI221_X2
X_18704_ _09080_ _09405_ _09407_ _09408_ VDD VSS NOR3_X1
X_18705_ _09261_ _09409_ VDD VSS CLKBUF_X3
X_18706_ _09080_ _09409_ _09410_ VDD VSS NAND2_X1
X_18707_ _14795_ _09279_ _09241_ _09411_ VDD VSS NAND3_X1
X_18708_ net861 _09063_ _09412_ VDD VSS NAND2_X2
X_18709_ _09064_ _09208_ net861 _09413_ VDD VSS MUX2_X1
X_18710_ _09411_ _09403_ _09412_ net37 _09413_ _09414_ VDD
+ VSS OAI221_X2
X_18711_ _09240_ _09308_ _09415_ VDD VSS NOR2_X1
X_18712_ _14817_ _09240_ _09248_ _09415_ _09416_ VDD VSS AOI22_X1
X_18713_ _09080_ _09199_ _09417_ VDD VSS NAND2_X1
X_18714_ _09410_ _09414_ _09416_ _09417_ _09418_ VDD VSS OAI22_X1
X_18715_ _09401_ _09408_ _09418_ _09419_ VDD VSS OAI21_X1
X_18716_ _09201_ _14794_ net36 _09420_ VDD VSS AOI21_X1
X_18717_ _14815_ _09421_ VDD VSS INV_X1
X_18718_ _09240_ _09412_ _09420_ _09202_ _09421_ _09422_ VDD
+ VSS AOI221_X2
X_18719_ _14820_ _09079_ _09423_ VDD VSS NAND2_X1
X_18720_ net860 _14794_ _09113_ _09202_ _09424_ VDD VSS NAND4_X1
X_18721_ _09279_ _09423_ _09424_ _09425_ VDD VSS AOI21_X1
X_18722_ _09199_ _09422_ _09425_ _09426_ VDD VSS OAI21_X1
X_18723_ _09210_ _09134_ _09335_ _09427_ VDD VSS NOR3_X2
X_18724_ _09202_ _09279_ _14824_ _09428_ VDD VSS OAI21_X1
X_18725_ _09274_ _09354_ _09376_ _09429_ VDD VSS NOR3_X1
X_18726_ _09128_ _09240_ _14795_ _09430_ VDD VSS AOI21_X1
X_18727_ _09429_ _09430_ _14812_ _09431_ VDD VSS AOI21_X1
X_18728_ _09409_ _09427_ _09428_ _09431_ _09202_ _09432_ VDD
+ VSS OAI221_X1
X_18729_ _09246_ _09267_ _09426_ _09432_ _09433_ VDD VSS NAND4_X1
X_18730_ _14819_ _09228_ _09326_ _09434_ VDD VSS OAI21_X1
X_18731_ _14812_ _09253_ _09268_ _09435_ VDD VSS NAND3_X1
X_18732_ _09409_ _09434_ _09435_ _09436_ VDD VSS NAND3_X1
X_18733_ _09274_ _09268_ _09437_ VDD VSS NAND2_X1
X_18734_ _09199_ _09337_ _09437_ _14812_ _09110_ _09438_ VDD
+ VSS OAI221_X1
X_18735_ _09080_ _09267_ _09436_ _09438_ _09439_ VDD VSS NAND4_X1
X_18736_ _14812_ _09295_ _09269_ _09440_ VDD VSS NAND3_X1
X_18737_ _14819_ _09268_ _09370_ _09441_ VDD VSS NAND3_X1
X_18738_ _09409_ _09440_ _09441_ _09442_ VDD VSS AOI21_X1
X_18739_ _14810_ _09121_ _09125_ _09443_ VDD VSS NAND3_X2
X_18740_ _14819_ _09443_ _09240_ net860 _09444_ VDD VSS OAI211_X2
X_18741_ _09218_ _09145_ _09130_ _09445_ VDD VSS OAI21_X4
X_18742_ _14812_ _09295_ _09445_ _09446_ VDD VSS NAND3_X1
X_18743_ _09199_ _09444_ _09446_ _09447_ VDD VSS AOI21_X1
X_18744_ _09343_ _09442_ _09447_ _09448_ VDD VSS OAI21_X1
X_18745_ _09183_ _09214_ _09449_ VDD VSS NAND2_X4
X_18746_ _09064_ _09306_ _09403_ _09450_ VDD VSS OAI21_X2
X_18747_ _09221_ _09145_ _09146_ _09451_ VDD VSS OAI21_X1
X_18748_ _09060_ _09451_ _09208_ _09210_ _09452_ VDD VSS OAI211_X2
X_18749_ _09449_ _09450_ _09452_ _09453_ VDD VSS AOI21_X2
X_18750_ _09264_ _09214_ _09454_ VDD VSS NAND2_X2
X_18751_ _09344_ _09363_ _09207_ _09455_ VDD VSS NOR3_X4
X_18752_ _09454_ _09427_ _09455_ _09456_ VDD VSS NOR3_X2
X_18753_ _09134_ _09250_ _09248_ _09457_ VDD VSS AOI21_X4
X_18754_ _09295_ _09389_ _09345_ _09458_ VDD VSS AND3_X1
X_18755_ _14810_ _09109_ _09459_ VDD VSS NOR2_X1
X_18756_ _09239_ _09457_ _09184_ _09458_ _09459_ _09387_ _09460_
+ VDD VSS OAI33_X1
X_18757_ _09453_ _09460_ _09456_ _09079_ _09461_ VDD VSS OR4_X2
X_18758_ _09160_ _09461_ _09448_ _09439_ _09462_ VDD VSS NAND4_X2
X_18759_ _09462_ _09433_ _09419_ _00034_ VDD VSS NAND3_X1
X_18760_ _09114_ _09122_ _09126_ _09463_ VDD VSS NAND3_X1
X_18761_ _09059_ _09147_ _09463_ _09464_ VDD VSS AOI21_X1
X_18762_ _09061_ _09122_ _09126_ _09465_ VDD VSS NAND3_X2
X_18763_ _09063_ _09269_ _09465_ _09466_ VDD VSS AOI21_X1
X_18764_ _09062_ _09319_ _09133_ net106 _09467_ VDD VSS AOI211_X2
X_18765_ _09059_ _09131_ _09298_ _09468_ VDD VSS NOR3_X1
X_18766_ _09449_ _09464_ _09466_ _09468_ _09467_ _09387_ _09469_
+ VDD VSS OAI33_X1
X_18767_ _09353_ _09256_ _09465_ _09345_ _09347_ net107 _09470_
+ VDD VSS AOI222_X2
X_18768_ _09226_ _09328_ _09133_ net106 _09471_ VDD VSS AOI211_X2
X_18769_ _09061_ _09226_ _09123_ _09127_ _09472_ VDD VSS NAND4_X1
X_18770_ _09265_ _09214_ _09472_ _09473_ VDD VSS NAND3_X1
X_18771_ _09201_ _09382_ _09470_ _09471_ _09473_ _09474_ VDD
+ VSS OAI221_X1
X_18772_ _09246_ _09474_ _09469_ _09475_ VDD VSS OAI21_X1
X_18773_ _09059_ _09268_ _09312_ _09476_ VDD VSS AND3_X1
X_18774_ _09353_ _09122_ _09126_ _09477_ VDD VSS NAND3_X4
X_18775_ _09477_ _09134_ net861 _09478_ VDD VSS OAI21_X1
X_18776_ _09476_ _09478_ _09227_ _09479_ VDD VSS AOI21_X1
X_18777_ _09003_ _09277_ _09480_ VDD VSS NAND2_X2
X_18778_ _09403_ _09247_ _09115_ _09481_ VDD VSS AOI21_X1
X_18779_ _09480_ _09481_ _09063_ net841 _09286_ _09482_ VDD
+ VSS OAI221_X1
X_18780_ _09454_ _09479_ _09482_ _09449_ _09483_ VDD VSS OAI22_X1
X_18781_ _09122_ _09126_ _09264_ _09484_ VDD VSS NAND3_X4
X_18782_ _09034_ _09285_ _09484_ _09485_ VDD VSS AOI21_X1
X_18783_ _09485_ _09301_ _09259_ _09486_ VDD VSS AOI21_X1
X_18784_ _09114_ _09256_ _09231_ net37 _09487_ VDD VSS AOI22_X2
X_18785_ _14795_ _09486_ _09487_ _09265_ _09241_ _09484_ _09488_
+ VDD VSS OAI222_X2
X_18786_ _09202_ _09261_ _09489_ VDD VSS NOR2_X1
X_18787_ _09475_ _09483_ _09079_ _09488_ _09489_ _09490_ VDD
+ VSS AOI221_X1
X_18788_ _09078_ _09160_ _09491_ VDD VSS NAND2_X2
X_18789_ _09221_ _09249_ _09492_ VDD VSS NAND2_X2
X_18790_ _09247_ _09492_ _09493_ VDD VSS NOR2_X2
X_18791_ _09227_ _09352_ _09493_ _09494_ VDD VSS OAI21_X1
X_18792_ _09463_ _09247_ _09218_ _09495_ VDD VSS OAI21_X1
X_18793_ _09183_ _09495_ _09082_ _09496_ VDD VSS AOI21_X1
X_18794_ _09059_ _09247_ net7 _09497_ VDD VSS AOI21_X1
X_18795_ _14796_ _09109_ _09283_ net36 _09497_ _14794_ _09498_
+ VDD VSS OAI222_X2
X_18796_ _09215_ _09494_ _09496_ _09498_ _09184_ _09499_ VDD
+ VSS AOI221_X2
X_18797_ _09477_ _09445_ _09500_ VDD VSS NAND2_X4
X_18798_ _09274_ _09265_ _09500_ _09484_ _14803_ _09501_ VDD
+ VSS OAI221_X1
X_18799_ _09083_ _09265_ _09253_ _09279_ net83 _09502_ VDD
+ VSS OAI221_X1
X_18800_ _09409_ _09501_ _09502_ _09503_ VDD VSS AND3_X1
X_18801_ _09202_ _09160_ _09504_ VDD VSS NAND2_X2
X_18802_ _09216_ _09366_ _09505_ VDD VSS NOR2_X1
X_18803_ _09387_ _09301_ _09259_ _09505_ _09218_ _09506_ VDD
+ VSS AOI221_X2
X_18804_ _09113_ _09131_ _09493_ _09507_ VDD VSS NOR3_X1
X_18805_ _09059_ _09332_ _09298_ _09508_ VDD VSS OAI21_X1
X_18806_ _09294_ _09508_ _09509_ VDD VSS NAND2_X1
X_18807_ _09235_ _09358_ _09484_ _09510_ VDD VSS OR3_X1
X_18808_ _09059_ _09145_ _09146_ _09264_ _09511_ VDD VSS NOR4_X1
X_18809_ _09063_ _09184_ _09512_ VDD VSS NOR2_X1
X_18810_ _09511_ _09512_ _09207_ _09513_ VDD VSS AOI21_X1
X_18811_ _09510_ _09513_ net841 _09514_ VDD VSS OAI21_X1
X_18812_ _09507_ _09509_ _09514_ _09222_ _09515_ VDD VSS OAI22_X1
X_18813_ _09491_ _09499_ _09503_ _09504_ _09506_ _09515_ _09516_
+ VDD VSS OAI33_X1
X_18814_ _09490_ _09516_ _00035_ VDD VSS OR2_X1
X_18815_ _09297_ _09231_ _09465_ _09274_ _09517_ VDD VSS AOI22_X1
X_18816_ _09382_ _09517_ _09518_ VDD VSS NOR2_X1
X_18817_ _09229_ _09323_ _09519_ VDD VSS NOR2_X1
X_18818_ _14812_ _09449_ _09519_ _09520_ VDD VSS NOR3_X1
X_18819_ _09110_ _09207_ _09521_ VDD VSS NOR2_X1
X_18820_ _09060_ _09521_ _09323_ _09522_ VDD VSS NOR3_X1
X_18821_ _09064_ _09306_ _09277_ _09523_ VDD VSS NOR3_X2
X_18822_ _09060_ _09228_ _09376_ _09524_ VDD VSS NOR3_X1
X_18823_ _09227_ _09321_ _09525_ VDD VSS NOR2_X1
X_18824_ _09523_ _09522_ _09387_ _09524_ _09525_ _09454_ _09526_
+ VDD VSS OAI33_X1
X_18825_ _09526_ _09518_ _09520_ _09491_ _09527_ VDD VSS OR4_X2
X_18826_ _09082_ _09445_ _09528_ VDD VSS NAND2_X1
X_18827_ net106 _09318_ _09529_ VDD VSS NAND2_X1
X_18828_ _14795_ _09256_ _09530_ VDD VSS NAND2_X1
X_18829_ _09305_ _09528_ _09529_ _09530_ _09531_ VDD VSS NAND4_X1
X_18830_ _09060_ _09403_ _09376_ _09532_ VDD VSS OAI21_X1
X_18831_ _09532_ _09389_ _14795_ net865 _09286_ _09533_ VDD
+ VSS OAI221_X2
X_18832_ _14808_ _09208_ _09534_ VDD VSS NOR2_X1
X_18833_ _09534_ _09395_ _09279_ _09535_ VDD VSS AOI21_X1
X_18834_ _09531_ _09533_ _09382_ _09387_ _09535_ _09536_ VDD
+ VSS OAI221_X2
X_18835_ _14806_ _09537_ VDD VSS INV_X2
X_18836_ _09277_ _09311_ _09538_ VDD VSS NOR2_X1
X_18837_ _09143_ _09285_ _09537_ _09538_ _14819_ _09539_ VDD
+ VSS OAI221_X1
X_18838_ _09536_ _09539_ _09316_ _09540_ VDD VSS AOI21_X1
X_18839_ _14819_ _09391_ _09541_ VDD VSS AND2_X1
X_18840_ _09185_ _14819_ _09218_ _09542_ VDD VSS OAI21_X1
X_18841_ _09082_ _09134_ _09249_ _09277_ net861 _09543_ VDD
+ VSS AOI221_X1
X_18842_ _09326_ _09206_ net7 _09544_ VDD VSS AOI21_X1
X_18843_ _09543_ _09544_ _14819_ _09545_ VDD VSS AOI21_X1
X_18844_ _09409_ _09541_ _09542_ _09545_ _09185_ _09546_ VDD
+ VSS OAI221_X1
X_18845_ _09112_ _09326_ _09547_ VDD VSS NOR2_X1
X_18846_ _09387_ _09547_ _09480_ _09500_ _09083_ _09548_ VDD
+ VSS AOI221_X2
X_18847_ net971 _09112_ _09549_ VDD VSS NOR2_X1
X_18848_ _09208_ _09345_ _09549_ _09550_ VDD VSS OAI21_X1
X_18849_ _09266_ _09198_ _09251_ _09550_ _09551_ VDD VSS AND4_X1
X_18850_ _09548_ _09551_ _09552_ VDD VSS NOR2_X1
X_18851_ _09080_ _09546_ _09552_ _09553_ VDD VSS AOI21_X1
X_18852_ _09324_ _09528_ _09554_ VDD VSS NAND2_X1
X_18853_ _09227_ _09337_ _09376_ _09555_ VDD VSS OR3_X1
X_18854_ _09261_ _09301_ _09556_ VDD VSS NOR2_X1
X_18855_ _09266_ _09261_ _09554_ _09555_ _09556_ _09557_ VDD
+ VSS AOI221_X1
X_18856_ _14795_ _09287_ _09558_ VDD VSS NOR2_X1
X_18857_ _09294_ _09241_ _09208_ net860 _09389_ _09559_ VDD
+ VSS OAI221_X2
X_18858_ _09316_ _09113_ net860 _09257_ _09285_ _09560_ VDD
+ VSS OAI221_X2
X_18859_ _09080_ _09558_ _09559_ _09560_ _09352_ _09561_ VDD
+ VSS OAI221_X2
X_18860_ _09246_ _09557_ _09561_ _09562_ VDD VSS OAI21_X1
X_18861_ _09527_ _09540_ _09504_ _09553_ _09562_ _00036_ VDD
+ VSS OAI221_X1
X_18862_ _09204_ _09269_ _09563_ VDD VSS NAND2_X1
X_18863_ _09234_ _09366_ net36 _09563_ _09060_ _09564_ VDD
+ VSS AOI221_X2
X_18864_ _09443_ _09247_ net971 _09565_ VDD VSS OAI21_X1
X_18865_ _09215_ _09565_ _09082_ _09256_ net37 _09566_ VDD
+ VSS AOI221_X1
X_18866_ _09185_ _09564_ _09566_ _09567_ VDD VSS NOR3_X1
X_18867_ _09114_ _09216_ _09366_ _14794_ _09568_ VDD VSS AOI22_X1
X_18868_ _14795_ _09198_ _09569_ VDD VSS NAND2_X1
X_18869_ _09185_ _09198_ _09568_ _09569_ _09231_ _09570_ VDD
+ VSS OAI221_X1
X_18870_ _09256_ _09198_ _09571_ VDD VSS NOR2_X1
X_18871_ net614 _09214_ _09572_ VDD VSS NAND2_X1
X_18872_ _14795_ _09271_ _09571_ _09572_ _09146_ _09145_ _09573_
+ VDD VSS OAI33_X1
X_18873_ _09570_ _09573_ _14803_ _09574_ VDD VSS AOI21_X1
X_18874_ _09210_ _09207_ _09223_ _09335_ _09575_ VDD VSS NOR4_X1
X_18875_ _14798_ _09110_ _09576_ VDD VSS NOR2_X1
X_18876_ _09576_ _09146_ _09145_ _09577_ VDD VSS OAI21_X1
X_18877_ _09060_ _09577_ _09578_ VDD VSS NOR2_X1
X_18878_ _09261_ _09575_ _09578_ _09579_ VDD VSS OR3_X1
X_18879_ _09249_ _09064_ _09580_ VDD VSS NOR2_X1
X_18880_ _09261_ _09285_ net83 _09580_ _09279_ _09581_ VDD
+ VSS OAI221_X1
X_18881_ _09267_ _09579_ _09581_ _09582_ VDD VSS AOI21_X1
X_18882_ _09128_ _09142_ _09366_ _09583_ VDD VSS AOI21_X1
X_18883_ _09266_ _09261_ _09583_ _09584_ VDD VSS OAI21_X1
X_18884_ _09083_ _09306_ _09354_ _09585_ VDD VSS NOR3_X1
X_18885_ _09128_ _09326_ _09586_ VDD VSS NOR2_X1
X_18886_ _09585_ _09586_ _09113_ _09587_ VDD VSS AOI21_X1
X_18887_ _09584_ _09587_ _09409_ _09588_ VDD VSS AOI21_X1
X_18888_ _09385_ _09567_ _09574_ _09588_ _09582_ _09504_ _09589_
+ VDD VSS OAI33_X1
X_18889_ _14819_ _09500_ _09590_ VDD VSS NOR2_X1
X_18890_ _09266_ _09253_ _09274_ _09591_ VDD VSS OAI21_X1
X_18891_ _09312_ _09279_ _14800_ _09592_ VDD VSS OAI21_X1
X_18892_ _09230_ _09592_ _14812_ _09593_ VDD VSS OAI21_X1
X_18893_ _09199_ _09590_ _09591_ _09593_ _09267_ _09594_ VDD
+ VSS OAI221_X1
X_18894_ _09206_ _09223_ _09003_ _09082_ _09537_ _09595_ VDD
+ VSS AOI221_X2
X_18895_ _09267_ _09222_ _09319_ _09595_ _09596_ VDD VSS NOR4_X1
X_18896_ _14812_ _09371_ _09597_ VDD VSS NAND2_X1
X_18897_ _09454_ _09480_ _09597_ _09598_ VDD VSS AOI21_X1
X_18898_ _09596_ _09598_ _09599_ VDD VSS NOR2_X1
X_18899_ _09375_ _09594_ _09599_ _09600_ VDD VSS AOI21_X1
X_18900_ net614 _09206_ _09601_ VDD VSS NOR2_X1
X_18901_ _14803_ _09265_ _09601_ _09602_ VDD VSS NOR3_X1
X_18902_ _09261_ _09602_ _09603_ VDD VSS NOR2_X1
X_18903_ _09112_ _09259_ _09034_ _09484_ _09110_ _09604_ VDD
+ VSS OAI221_X1
X_18904_ _09003_ _09034_ _09206_ _09265_ _09605_ VDD VSS NAND4_X1
X_18905_ _09034_ _09183_ _09606_ VDD VSS NAND2_X1
X_18906_ _09605_ _09606_ _09207_ _09484_ _14803_ _09607_ VDD
+ VSS OAI221_X1
X_18907_ _09604_ _09607_ _09083_ _09608_ VDD VSS OAI21_X1
X_18908_ _09062_ _09133_ _09537_ _09609_ VDD VSS AOI21_X1
X_18909_ _09269_ _09206_ net7 _09610_ VDD VSS OAI21_X1
X_18910_ _09264_ _09480_ _09609_ _09610_ _09063_ _09611_ VDD
+ VSS AOI221_X2
X_18911_ _09272_ _09366_ _09586_ _09060_ _09612_ VDD VSS AOI22_X1
X_18912_ _09611_ _09612_ _09266_ _09613_ VDD VSS AOI21_X1
X_18913_ _09491_ _09603_ _09608_ _09613_ _09409_ _09614_ VDD
+ VSS AOI221_X2
X_18914_ _09589_ _09600_ _09614_ _00037_ VDD VSS NOR3_X1
X_18915_ _09504_ _09615_ VDD VSS INV_X1
X_18916_ _09409_ _09457_ _09616_ VDD VSS NOR2_X1
X_18917_ _09198_ _09495_ _09082_ _09256_ _09210_ _09617_ VDD
+ VSS AOI221_X2
X_18918_ _09185_ _09616_ _09617_ _09618_ VDD VSS NOR3_X1
X_18919_ _09508_ _09109_ net841 _09619_ VDD VSS OAI21_X1
X_18920_ _09215_ _09208_ _14814_ _09620_ VDD VSS AOI21_X1
X_18921_ _09218_ _09112_ _09621_ VDD VSS NAND2_X1
X_18922_ _09259_ _09412_ _09621_ _09622_ VDD VSS NAND3_X1
X_18923_ _09265_ _09261_ _09619_ _09620_ _09622_ _09623_ VDD
+ VSS AOI221_X2
X_18924_ _09615_ _09618_ _09623_ _09624_ VDD VSS OAI21_X1
X_18925_ _09335_ _09277_ net614 _09625_ VDD VSS AOI21_X1
X_18926_ _09332_ _09223_ net614 _09626_ VDD VSS AOI21_X1
X_18927_ _09625_ _09626_ net83 _09627_ VDD VSS OAI21_X1
X_18928_ _09063_ _09234_ _09326_ _09628_ VDD VSS OAI21_X1
X_18929_ _09628_ _09215_ _14803_ _09629_ VDD VSS OAI21_X1
X_18930_ _09301_ _09271_ _09627_ _09215_ _14800_ _09629_ _09630_
+ VDD VSS AOI222_X2
X_18931_ _09267_ _09491_ _09630_ _09631_ VDD VSS OR3_X1
X_18932_ _09353_ _09197_ _09632_ VDD VSS NAND2_X1
X_18933_ _09081_ _09632_ _09133_ _09271_ _09537_ _09633_ VDD
+ VSS AOI221_X2
X_18934_ _09227_ _09278_ _09572_ _09634_ VDD VSS AOI21_X1
X_18935_ _09201_ _09246_ _09183_ _09635_ VDD VSS NOR3_X1
X_18936_ _09635_ _09234_ _09295_ _09636_ VDD VSS OAI21_X1
X_18937_ _09633_ _09634_ _09636_ _09637_ VDD VSS NOR3_X1
X_18938_ _09184_ _09375_ _09638_ VDD VSS NOR2_X1
X_18939_ _09057_ _09205_ _14798_ _09639_ VDD VSS AOI21_X1
X_18940_ _14806_ _09205_ _09253_ _09002_ _09640_ VDD VSS OAI22_X1
X_18941_ _09213_ _09443_ _09639_ _09640_ _09058_ _09641_ VDD
+ VSS AOI221_X1
X_18942_ _09059_ _09477_ _09577_ _09642_ VDD VSS NAND3_X1
X_18943_ _09295_ _09134_ _09218_ _09643_ VDD VSS OAI21_X1
X_18944_ _09642_ _09643_ _09082_ _09644_ VDD VSS OAI21_X1
X_18945_ _09641_ _09644_ _09215_ _09645_ VDD VSS AOI21_X1
X_18946_ net663 _09062_ _09646_ VDD VSS NAND2_X1
X_18947_ _14813_ _14822_ _09647_ VDD VSS NOR2_X1
X_18948_ _09213_ _09369_ _09646_ _09647_ _09133_ _09648_ VDD
+ VSS AOI221_X1
X_18949_ _09266_ _09375_ _09648_ _09649_ VDD VSS NOR3_X1
X_18950_ _09445_ _09206_ net971 _09650_ VDD VSS OAI21_X1
X_18951_ net866 _09216_ _09650_ _09063_ _09651_ VDD VSS AOI22_X1
X_18952_ _09198_ _09651_ _09652_ VDD VSS OR2_X1
X_18953_ _09637_ _09638_ _09645_ _09649_ _09652_ _09653_ VDD
+ VSS AOI221_X2
X_18954_ _09210_ _14803_ _09064_ _09654_ VDD VSS NOR3_X1
X_18955_ _09259_ _09060_ net841 _09655_ VDD VSS OAI21_X1
X_18956_ _09449_ _09654_ _09655_ _09656_ VDD VSS NOR3_X1
X_18957_ _14815_ _09240_ _09449_ _09657_ VDD VSS NOR3_X1
X_18958_ _09385_ _09656_ _09657_ _09658_ VDD VSS NOR3_X1
X_18959_ _09240_ _09241_ _14800_ _09659_ VDD VSS AOI21_X1
X_18960_ _09659_ _09231_ _09115_ _09660_ VDD VSS AOI21_X1
X_18961_ _09210_ _09389_ _09661_ VDD VSS NOR2_X1
X_18962_ _09064_ _09208_ _09492_ _09662_ VDD VSS OAI21_X1
X_18963_ _09477_ _09253_ _09663_ VDD VSS NAND2_X1
X_18964_ _09266_ _09661_ _09662_ _09663_ _09274_ _09664_ VDD
+ VSS OAI221_X1
X_18965_ _09113_ _09478_ _09661_ _09325_ _09665_ VDD VSS OAI22_X1
X_18966_ _09664_ _09665_ _09267_ _09666_ VDD VSS OAI21_X1
X_18967_ _09658_ _09660_ _09454_ _09409_ _09666_ _09667_ VDD
+ VSS OAI221_X1
X_18968_ _09653_ _09631_ _09624_ _09667_ _00038_ VDD VSS AND4_X2
X_18969_ _09459_ _09318_ _09081_ _09668_ VDD VSS AOI21_X1
X_18970_ _09197_ _09366_ _09236_ _09308_ _09205_ _09669_ VDD
+ VSS AOI221_X2
X_18971_ _09058_ _09206_ _09218_ _09670_ VDD VSS OAI21_X1
X_18972_ _09277_ _09327_ _09670_ _09107_ _09671_ VDD VSS OAI22_X1
X_18973_ _09351_ _09668_ _09669_ _09671_ _09234_ _09672_ VDD
+ VSS AOI221_X1
X_18974_ net7 _09034_ _09109_ _09197_ _09673_ VDD VSS NOR4_X1
X_18975_ _09283_ _09214_ _09134_ _09674_ VDD VSS OAI21_X1
X_18976_ _09673_ _09674_ _09142_ _09675_ VDD VSS AOI21_X1
X_18977_ _09183_ _09197_ _09058_ _09366_ net841 _09676_ VDD
+ VSS AOI221_X1
X_18978_ _09078_ _09675_ _09676_ _09677_ VDD VSS AOI21_X1
X_18979_ net7 _09231_ _09403_ _09678_ VDD VSS OAI21_X1
X_18980_ _09214_ _09529_ _09678_ _09679_ VDD VSS AOI21_X1
X_18981_ _09332_ _09256_ _14794_ _09680_ VDD VSS AOI21_X1
X_18982_ _09216_ _09301_ _09247_ _09681_ VDD VSS AOI21_X1
X_18983_ _09234_ _09680_ _09681_ net36 _09682_ VDD VSS OAI22_X1
X_18984_ _09184_ _09679_ _09682_ _09683_ VDD VSS OAI21_X1
X_18985_ _09234_ _09285_ _09218_ _09544_ _09112_ _09684_ VDD
+ VSS OAI221_X1
X_18986_ _09197_ _09318_ _09058_ _09255_ net972 _09685_ VDD
+ VSS AOI221_X2
X_18987_ _09685_ _09285_ _09272_ _09210_ _09465_ _09686_ VDD
+ VSS OAI221_X1
X_18988_ _09684_ _09686_ _09687_ VDD VSS AND2_X1
X_18989_ _09672_ _09677_ _09683_ _09687_ _09343_ _09688_ VDD
+ VSS AOI221_X1
X_18990_ _09226_ _09206_ _09114_ _09332_ net106 _09689_ VDD
+ VSS AOI221_X2
X_18991_ _09265_ _09377_ _09689_ _09690_ VDD VSS OR3_X1
X_18992_ _09266_ _09325_ _09337_ _09113_ net971 _09691_ VDD
+ VSS OAI221_X1
X_18993_ _09489_ _09690_ _09691_ _09692_ VDD VSS NAND3_X1
X_18994_ _09259_ _09449_ _09344_ _09345_ _09693_ VDD VSS NOR4_X1
X_18995_ _09241_ _09601_ _09305_ _09694_ VDD VSS AND3_X1
X_18996_ _09058_ _09328_ _09133_ net107 _09695_ VDD VSS AOI211_X2
X_18997_ _09063_ _09295_ _09269_ _09696_ VDD VSS AOI21_X1
X_18998_ _09454_ _09695_ _09696_ _09697_ VDD VSS NOR3_X1
X_18999_ _14798_ _09081_ _09123_ _09127_ _09698_ VDD VSS NAND4_X1
X_19000_ _09698_ _09247_ _14808_ _09699_ VDD VSS OAI21_X1
X_19001_ _09237_ _14806_ _09062_ _09700_ VDD VSS MUX2_X1
X_19002_ _14822_ _09700_ _09133_ _09701_ VDD VSS MUX2_X1
X_19003_ _09387_ _09699_ _09701_ _09382_ _09702_ VDD VSS OAI22_X2
X_19004_ _09693_ _09694_ _09697_ _09702_ _09703_ VDD VSS OR4_X2
X_19005_ _09218_ _09216_ _09492_ _09256_ _09704_ VDD VSS AOI22_X1
X_19006_ _09185_ _09309_ _09356_ _09704_ _09705_ VDD VSS NAND4_X1
X_19007_ _09521_ _09369_ _09646_ _09706_ VDD VSS AOI21_X1
X_19008_ _09705_ _09706_ _09185_ _09707_ VDD VSS OAI21_X1
X_19009_ _09692_ _09703_ _09080_ _09410_ _09707_ _09708_ VDD
+ VSS OAI221_X1
X_19010_ _09688_ _09708_ _09246_ _00039_ VDD VSS MUX2_X1
X_19011_ net1185 _09709_ VDD VSS INV_X1
X_19012_ _09709_ _09102_ _09710_ VDD VSS NOR2_X1
X_19013_ net1185 _09102_ _09711_ VDD VSS NOR2_X1
X_19014_ sa01_sr\[7\] _09712_ VDD VSS BUF_X4
Xrebuffer86 sa11_sr\[7\] net562 VDD VSS BUF_X1
X_19016_ _09712_ sa11_sr\[7\] _09714_ VDD VSS XOR2_X2
Xclone7 net107 net7 VDD VSS BUF_X4
Xclone4 net498 _06449_ net4 VDD VSS NOR2_X2
X_19019_ sa21_sr\[1\] sa11_sr\[1\] _09717_ VDD VSS XNOR2_X2
X_19020_ _09717_ _09714_ _09718_ VDD VSS XNOR2_X1
Xclone128 _04233_ net128 VDD VSS BUF_X4
X_19022_ sa11_sr\[0\] _09720_ VDD VSS BUF_X4
Xclone156 net513 _13171_ net156 VDD VSS NOR2_X4
X_19024_ _09720_ net655 _09722_ VDD VSS XOR2_X2
X_19025_ sa01_sr\[0\] _09722_ _09723_ VDD VSS XNOR2_X1
X_19026_ _09723_ _09718_ _09724_ VDD VSS XNOR2_X1
X_19027_ _09710_ _09711_ _09724_ _09725_ VDD VSS MUX2_X2
X_19028_ _08971_ _09726_ VDD VSS BUF_X16
X_19029_ _09726_ _09727_ VDD VSS BUF_X16
X_19030_ _09727_ _09728_ VDD VSS BUF_X16
X_19031_ net1185 _09728_ _00443_ _09729_ VDD VSS NAND3_X1
X_19032_ _09727_ _09730_ VDD VSS BUF_X8
X_19033_ _09709_ _09730_ _09731_ VDD VSS NAND2_X1
X_19034_ _09729_ _00443_ _09731_ _09732_ VDD VSS OAI21_X4
X_19035_ _09732_ _09725_ _09733_ VDD VSS NOR2_X4
X_19036_ _09733_ _09734_ VDD VSS INV_X8
X_19037_ _09734_ _09735_ VDD VSS BUF_X16
X_19038_ _09735_ _09736_ VDD VSS BUF_X32
Xrebuffer418 _14842_ net1048 VDD VSS BUF_X1
Xclone12 _07426_ net12 VDD VSS BUF_X4
Xsplit168 _14970_ net168 VDD VSS CLKBUF_X2
X_19042_ sa21_sr\[0\] _09720_ _09739_ VDD VSS XNOR2_X2
X_19043_ net506 net763 _09740_ VDD VSS XNOR2_X1
X_19044_ net735 _09022_ net606 _09741_ VDD VSS NAND3_X1
X_19045_ _09712_ net609 _09742_ VDD VSS XNOR2_X2
X_19046_ net735 _08992_ _09743_ VDD VSS NOR2_X1
X_19047_ _09742_ _09743_ _09744_ VDD VSS NAND2_X1
X_19048_ _09740_ _09741_ _09744_ _09745_ VDD VSS AOI21_X1
X_19049_ net506 net762 _09746_ VDD VSS XOR2_X1
X_19050_ net606 _09743_ _09747_ VDD VSS NAND2_X1
X_19051_ net735 _09010_ _09742_ _09748_ VDD VSS NAND3_X1
X_19052_ _09746_ _09747_ _09748_ _09749_ VDD VSS AOI21_X1
X_19053_ net735 _09750_ VDD VSS INV_X1
X_19054_ _09750_ _09726_ _00444_ _09751_ VDD VSS NAND3_X1
X_19055_ net735 _09726_ _09752_ VDD VSS NAND2_X1
X_19056_ _09751_ _09752_ _00444_ _09753_ VDD VSS OAI21_X1
X_19057_ _09745_ _09749_ _09753_ _09754_ VDD VSS OR3_X1
X_19058_ _09754_ _09755_ VDD VSS BUF_X4
X_19059_ _09755_ _09756_ VDD VSS INV_X16
Xrebuffer131 sa30_sub\[1\] net607 VDD VSS BUF_X1
X_19061_ _09756_ _14835_ VDD VSS BUF_X8
Xclone155 net156 net155 VDD VSS INV_X2
X_19063_ sa30_sub\[2\] _09759_ VDD VSS BUF_X4
X_19064_ sa11_sr\[1\] _09759_ _09760_ VDD VSS XOR2_X2
X_19065_ net770 _09760_ _09761_ VDD VSS XOR2_X1
X_19066_ sa11_sr\[2\] _09762_ VDD VSS BUF_X4
X_19067_ sa21_sr\[2\] _09763_ VDD VSS BUF_X4
X_19068_ _09762_ _09763_ _09764_ VDD VSS XOR2_X2
X_19069_ _06638_ _09010_ _09764_ _09765_ VDD VSS NAND3_X1
X_19070_ _09762_ _09763_ _09766_ VDD VSS XNOR2_X2
X_19071_ _06638_ net831 _09767_ VDD VSS NOR2_X1
X_19072_ _09766_ _09767_ _09768_ VDD VSS NAND2_X1
X_19073_ _09761_ _09765_ _09768_ _09769_ VDD VSS AOI21_X2
X_19074_ net770 _09760_ _09770_ VDD VSS XNOR2_X1
X_19075_ _09764_ _09767_ _09771_ VDD VSS NAND2_X1
X_19076_ _06638_ _09010_ _09766_ _09772_ VDD VSS NAND3_X1
X_19077_ _09770_ _09771_ _09772_ _09773_ VDD VSS AOI21_X2
X_19078_ _06638_ _09774_ VDD VSS INV_X1
X_19079_ _09774_ net1083 _00445_ _09775_ VDD VSS NAND3_X1
X_19080_ _06638_ net1083 _09776_ VDD VSS NAND2_X1
X_19081_ _09775_ _09776_ _00445_ _09777_ VDD VSS OAI21_X2
X_19082_ _09769_ _09773_ _09777_ _09778_ VDD VSS NOR3_X4
X_19083_ _09778_ _09779_ VDD VSS INV_X4
X_19084_ _09779_ _09780_ VDD VSS BUF_X4
X_19085_ _09780_ _09781_ VDD VSS BUF_X4
X_19086_ _09781_ _09782_ VDD VSS CLKBUF_X3
X_19087_ _09782_ _14851_ VDD VSS BUF_X4
X_19088_ _09755_ _14826_ VDD VSS BUF_X4
X_19089_ _09778_ _09783_ VDD VSS BUF_X4
X_19090_ _09783_ _09784_ VDD VSS BUF_X4
X_19091_ _09784_ _14844_ VDD VSS BUF_X4
X_19092_ sa11_sr\[5\] _09785_ VDD VSS CLKBUF_X3
X_19093_ sa11_sr\[6\] _09786_ VDD VSS CLKBUF_X3
X_19094_ sa21_sr\[6\] _09787_ VDD VSS BUF_X4
X_19095_ _09786_ _09787_ _09788_ VDD VSS XNOR2_X2
X_19096_ sa01_sr\[5\] _09789_ VDD VSS CLKBUF_X3
X_19097_ sa30_sub\[6\] _09790_ VDD VSS CLKBUF_X3
X_19098_ _09789_ _09790_ _09791_ VDD VSS XNOR2_X1
X_19099_ _09788_ _09791_ _09792_ VDD VSS XNOR2_X1
X_19100_ _09785_ _09792_ _09793_ VDD VSS XNOR2_X1
X_19101_ text_in_r\[94\] _09793_ _09074_ _09794_ VDD VSS MUX2_X2
X_19102_ _06697_ _09794_ _09795_ VDD VSS XOR2_X2
X_19103_ sa21_sr\[7\] _09796_ VDD VSS BUF_X8
X_19104_ _09796_ sa11_sr\[7\] _09797_ VDD VSS XNOR2_X2
X_19105_ sa01_sr\[6\] _09798_ VDD VSS BUF_X2
X_19106_ sa30_sub\[7\] _09799_ VDD VSS BUF_X8
X_19107_ _09798_ _09799_ _09800_ VDD VSS XNOR2_X1
X_19108_ net769 _09800_ _09801_ VDD VSS XNOR2_X1
X_19109_ _09786_ _09801_ _09802_ VDD VSS XNOR2_X1
X_19110_ _09138_ _09803_ VDD VSS BUF_X4
X_19111_ text_in_r\[95\] _09802_ _09803_ _09804_ VDD VSS MUX2_X1
X_19112_ _06711_ _09804_ _09805_ VDD VSS XNOR2_X2
X_19113_ _09795_ _09805_ _09806_ VDD VSS NOR2_X2
X_19114_ _06688_ _09807_ VDD VSS INV_X1
X_19115_ sa11_sr\[4\] _09808_ VDD VSS CLKBUF_X3
X_19116_ sa30_sub\[5\] _09809_ VDD VSS CLKBUF_X3
X_19117_ _09808_ _09809_ _09810_ VDD VSS XNOR2_X1
X_19118_ _09807_ _09180_ _09810_ _09811_ VDD VSS NOR3_X1
X_19119_ _06688_ _09180_ _09810_ _09812_ VDD VSS NOR3_X1
X_19120_ sa01_sr\[4\] _09813_ VDD VSS BUF_X2
X_19121_ sa21_sr\[5\] _09814_ VDD VSS BUF_X4
X_19122_ _09785_ _09814_ _09815_ VDD VSS XNOR2_X1
X_19123_ _09813_ _09815_ _09816_ VDD VSS XNOR2_X2
X_19124_ _09811_ _09812_ _09816_ _09817_ VDD VSS MUX2_X1
X_19125_ _09728_ _09818_ VDD VSS BUF_X16
X_19126_ _09808_ _09809_ _09819_ VDD VSS XOR2_X2
X_19127_ _06688_ _09818_ _09819_ _09820_ VDD VSS NOR3_X1
X_19128_ _09807_ _09818_ _09819_ _09821_ VDD VSS NOR3_X1
X_19129_ _09820_ _09821_ _09816_ _09822_ VDD VSS MUX2_X1
X_19130_ _08974_ _09823_ VDD VSS BUF_X32
X_19131_ _09823_ _09824_ VDD VSS BUF_X8
X_19132_ _06688_ _09824_ text_in_r\[93\] _09825_ VDD VSS NAND3_X1
X_19133_ _09807_ _09824_ _09826_ VDD VSS NAND2_X1
X_19134_ _09825_ _09826_ text_in_r\[93\] _09827_ VDD VSS OAI21_X2
X_19135_ _09817_ _09822_ _09827_ _09828_ VDD VSS NOR3_X4
X_19136_ _09828_ _09829_ VDD VSS CLKBUF_X3
X_19137_ _09829_ _09830_ VDD VSS CLKBUF_X3
X_19138_ _09779_ _09831_ VDD VSS CLKBUF_X3
X_19139_ _06657_ net1086 _09832_ VDD VSS NOR2_X1
X_19140_ _06657_ _09833_ VDD VSS INV_X1
X_19141_ _09833_ net1086 _09834_ VDD VSS NOR2_X1
X_19142_ sa01_sr\[2\] _09835_ VDD VSS BUF_X4
X_19143_ sa21_sr\[3\] _09836_ VDD VSS BUF_X4
X_19144_ _09835_ _09836_ _09837_ VDD VSS XNOR2_X1
X_19145_ _09712_ _09837_ _09838_ VDD VSS XNOR2_X2
X_19146_ sa11_sr\[3\] _09839_ VDD VSS CLKBUF_X3
X_19147_ net565 _09839_ _09840_ VDD VSS XOR2_X2
X_19148_ sa30_sub\[3\] _09841_ VDD VSS CLKBUF_X3
X_19149_ _09762_ _09841_ _09842_ VDD VSS XNOR2_X1
X_19150_ _09840_ _09842_ _09843_ VDD VSS XNOR2_X1
X_19151_ _09838_ _09843_ _09844_ VDD VSS XNOR2_X1
X_19152_ _09832_ _09834_ _09844_ _09845_ VDD VSS MUX2_X1
X_19153_ _09845_ _09846_ VDD VSS BUF_X4
X_19154_ _09833_ _09074_ text_in_r\[91\] _09847_ VDD VSS OR3_X2
X_19155_ _09833_ _08994_ text_in_r\[91\] _09848_ VDD VSS NAND3_X2
X_19156_ _09847_ _09848_ _09849_ VDD VSS NAND2_X4
X_19157_ _09846_ _09849_ _09850_ VDD VSS NOR2_X2
X_19158_ _09850_ _09851_ VDD VSS BUF_X4
X_19159_ _09851_ _09852_ VDD VSS BUF_X8
X_19160_ _14830_ _09853_ VDD VSS BUF_X4
X_19161_ _09853_ _09854_ VDD VSS INV_X4
X_19162_ _09833_ net871 _09855_ VDD VSS NAND2_X1
X_19163_ _09099_ _09856_ VDD VSS BUF_X32
X_19164_ _06657_ net1004 _09857_ VDD VSS NAND2_X1
X_19165_ _09855_ _09857_ _09844_ _09858_ VDD VSS MUX2_X2
X_19166_ _09858_ _09859_ VDD VSS BUF_X8
X_19167_ _09847_ _09848_ _09860_ VDD VSS AND2_X2
X_19168_ _09860_ _09861_ VDD VSS BUF_X8
X_19169_ _09756_ _09859_ _09861_ _09862_ VDD VSS AOI21_X4
X_19170_ _09735_ _09863_ VDD VSS BUF_X4
X_19171_ _09831_ _09852_ _09854_ _09862_ _09863_ _09864_ VDD
+ VSS AOI221_X2
X_19172_ _06673_ _09865_ VDD VSS INV_X1
X_19173_ _09865_ _09818_ _09866_ VDD VSS NOR2_X1
X_19174_ _06673_ _09818_ _09867_ VDD VSS NOR2_X1
X_19175_ sa01_sr\[3\] _09868_ VDD VSS BUF_X2
X_19176_ sa21_sr\[4\] _09869_ VDD VSS BUF_X4
X_19177_ _09868_ _09869_ _09870_ VDD VSS XNOR2_X1
X_19178_ _09712_ _09870_ _09871_ VDD VSS XNOR2_X1
X_19179_ sa30_sub\[4\] _09872_ VDD VSS CLKBUF_X3
X_19180_ _09808_ _09872_ _09873_ VDD VSS XOR2_X1
X_19181_ _09840_ _09873_ _09874_ VDD VSS XNOR2_X1
X_19182_ _09871_ _09874_ _09875_ VDD VSS XNOR2_X1
X_19183_ _09866_ _09867_ _09875_ _09876_ VDD VSS MUX2_X2
X_19184_ _09865_ _08996_ text_in_r\[92\] _09877_ VDD VSS NAND3_X1
X_19185_ _06673_ _09135_ _09878_ VDD VSS NAND2_X1
X_19186_ _09877_ _09878_ text_in_r\[92\] _09879_ VDD VSS OAI21_X4
X_19187_ _09876_ _09879_ _09880_ VDD VSS NOR2_X4
X_19188_ _09880_ _09881_ VDD VSS BUF_X4
X_19189_ _09779_ _09846_ _09849_ _09882_ VDD VSS OAI21_X2
Xsplit142 _15268_ net142 VDD VSS BUF_X1
X_19191_ _14838_ _09884_ VDD VSS INV_X4
X_19192_ _09881_ _09882_ _09884_ _09885_ VDD VSS OAI21_X1
X_19193_ _09859_ _09861_ _09886_ VDD VSS NAND2_X4
X_19194_ _09756_ _09846_ _09849_ _09887_ VDD VSS NOR3_X4
X_19195_ _09780_ _09886_ _09854_ _09887_ _09735_ _09888_ VDD
+ VSS AOI221_X2
X_19196_ _09876_ _09879_ _09889_ VDD VSS OR2_X2
X_19197_ _09889_ _09890_ VDD VSS BUF_X4
X_19198_ _09890_ _09891_ VDD VSS BUF_X4
X_19199_ _09779_ _09859_ _09861_ _09892_ VDD VSS NAND3_X2
X_19200_ _09892_ _09893_ VDD VSS CLKBUF_X3
X_19201_ _14836_ _09894_ VDD VSS BUF_X4
X_19202_ _09891_ _09893_ _09894_ _09895_ VDD VSS OAI21_X1
X_19203_ _09830_ _09864_ _09885_ _09888_ _09895_ _09896_ VDD
+ VSS OAI221_X1
X_19204_ _09886_ _09897_ VDD VSS BUF_X4
X_19205_ _09778_ _09846_ _09849_ _09898_ VDD VSS NOR3_X4
Xclone15 _07377_ net15 VDD VSS BUF_X8
X_19207_ net477 _09900_ VDD VSS BUF_X4
X_19208_ _09880_ _09897_ _14849_ _09898_ _09900_ _09901_ VDD
+ VSS AOI221_X1
X_19209_ _09830_ _09901_ _09902_ VDD VSS OR2_X1
X_19210_ _09890_ _09903_ VDD VSS BUF_X4
X_19211_ _09903_ _09904_ VDD VSS BUF_X4
X_19212_ _09756_ _09779_ _09905_ VDD VSS NOR2_X4
Xclone126 _02278_ net126 VDD VSS BUF_X2
X_19214_ _14833_ _09907_ VDD VSS INV_X4
X_19215_ _09886_ _09905_ _09734_ _09907_ _09779_ _09908_ VDD
+ VSS AOI221_X2
X_19216_ _14828_ _09909_ VDD VSS BUF_X4
X_19217_ _09846_ _09910_ VDD VSS BUF_X4
X_19218_ _09849_ _09911_ VDD VSS BUF_X8
X_19219_ _09783_ _09910_ _09911_ _09912_ VDD VSS OAI21_X2
X_19220_ _09909_ _09912_ _09913_ VDD VSS NOR2_X1
X_19221_ _09859_ _09914_ VDD VSS BUF_X4
X_19222_ _09861_ _09915_ VDD VSS BUF_X4
X_19223_ _09853_ _09914_ _09915_ _09916_ VDD VSS NAND3_X2
X_19224_ _09756_ _09910_ _09911_ _09917_ VDD VSS OAI21_X4
X_19225_ _09784_ _09916_ _09917_ _09918_ VDD VSS AOI21_X1
X_19226_ _09904_ _09908_ _09913_ _09918_ _09919_ VDD VSS NOR4_X2
X_19227_ _09896_ _09919_ _09902_ _09920_ VDD VSS OAI21_X1
X_19228_ _09806_ _09920_ _09921_ VDD VSS AND2_X2
X_19229_ _09881_ _09922_ VDD VSS BUF_X4
X_19230_ _09795_ _09923_ VDD VSS BUF_X4
X_19231_ _09852_ _09924_ VDD VSS CLKBUF_X3
X_19232_ net103 _09924_ _09925_ VDD VSS NOR2_X1
X_19233_ _09755_ _09780_ _09926_ VDD VSS NAND2_X1
X_19234_ _09912_ _09927_ VDD VSS CLKBUF_X3
X_19235_ net922 _09928_ VDD VSS BUF_X4
X_19236_ _09923_ _09925_ _09926_ _09927_ _09928_ _09929_ VDD
+ VSS OAI221_X1
X_19237_ _06697_ _09794_ _09930_ VDD VSS XNOR2_X2
X_19238_ _09930_ _09931_ VDD VSS BUF_X4
X_19239_ _09851_ _09932_ VDD VSS CLKBUF_X3
X_19240_ _09756_ net613 net910 _09933_ VDD VSS OAI21_X4
X_19241_ _09932_ _09933_ _09934_ VDD VSS AND2_X1
X_19242_ _09831_ _09935_ VDD VSS CLKBUF_X3
X_19243_ _09935_ _09924_ _09909_ _09936_ VDD VSS OAI21_X1
X_19244_ net479 _09859_ _09861_ _09937_ VDD VSS NAND3_X4
X_19245_ _09852_ _09938_ VDD VSS BUF_X4
X_19246_ _09937_ _09938_ _09894_ _09939_ VDD VSS OAI21_X1
X_19247_ _09781_ _09940_ VDD VSS BUF_X4
X_19248_ _09931_ _09934_ _09936_ _09939_ _09940_ _09941_ VDD
+ VSS OAI221_X1
X_19249_ _09922_ _09929_ _09941_ _09942_ VDD VSS AND3_X1
X_19250_ _09863_ _09943_ VDD VSS CLKBUF_X3
X_19251_ _09755_ _09910_ _09911_ _09944_ VDD VSS OAI21_X4
X_19252_ _09893_ _09944_ _09930_ _09945_ VDD VSS MUX2_X1
X_19253_ _09943_ _09945_ _09946_ VDD VSS NOR2_X1
X_19254_ _09756_ _09914_ _09915_ _09947_ VDD VSS NAND3_X4
X_19255_ _09783_ _09948_ VDD VSS BUF_X4
X_19256_ _09948_ _09949_ VDD VSS BUF_X4
X_19257_ _09947_ _09931_ _09949_ _09950_ VDD VSS AOI21_X1
X_19258_ _09897_ _09951_ VDD VSS BUF_X4
Xclone97 net618 net97 VDD VSS BUF_X4
X_19260_ net101 net1048 _09780_ _09953_ VDD VSS MUX2_X1
X_19261_ _09795_ _09953_ _09951_ _09954_ VDD VSS NAND3_X1
X_19262_ _09755_ _09780_ _09955_ VDD VSS NOR2_X4
X_19263_ _09863_ _09887_ _09955_ _09951_ _09956_ VDD VSS AOI22_X1
X_19264_ _09954_ _09956_ _09795_ _09957_ VDD VSS OAI21_X1
X_19265_ _09957_ _09922_ _09950_ _09946_ _09958_ VDD VSS NOR4_X2
X_19266_ _09805_ _09959_ VDD VSS CLKBUF_X3
X_19267_ _09959_ _09830_ _09960_ VDD VSS NAND2_X1
X_19268_ _09958_ _09942_ _09960_ _09961_ VDD VSS NOR3_X1
X_19269_ _09930_ _09805_ _09962_ VDD VSS NOR2_X1
X_19270_ _09880_ _09963_ VDD VSS BUF_X4
X_19271_ _09780_ net480 _09964_ VDD VSS NAND2_X1
X_19272_ _09778_ _09732_ _09725_ _09965_ VDD VSS OAI21_X2
X_19273_ _09852_ _09964_ _09965_ _09966_ VDD VSS NAND3_X1
X_19274_ _09963_ _09966_ _09967_ VDD VSS NAND2_X1
X_19275_ _09894_ _09968_ VDD VSS INV_X1
X_19276_ _09955_ _09831_ _09968_ _09969_ VDD VSS AOI21_X1
X_19277_ _09828_ _09932_ _09969_ _09970_ VDD VSS OAI21_X1
X_19278_ _09962_ _09967_ _09970_ _09971_ VDD VSS OAI21_X2
X_19279_ _09755_ _09882_ _09972_ VDD VSS NOR2_X1
X_19280_ _09779_ _09858_ _09860_ _09973_ VDD VSS AOI21_X4
X_19281_ _09972_ _09933_ _09973_ _09928_ _09898_ _09974_ VDD
+ VSS AOI221_X2
X_19282_ _09829_ _09903_ _09975_ VDD VSS NOR2_X1
X_19283_ _09909_ _09976_ VDD VSS INV_X2
X_19284_ _09778_ _09859_ _09861_ _09977_ VDD VSS NAND3_X4
X_19285_ _09928_ _09912_ _09892_ _09976_ _09977_ _09853_ _09978_
+ VDD VSS OAI222_X2
X_19286_ net101 _09910_ _09911_ _09979_ VDD VSS OAI21_X4
X_19287_ net598 _09914_ _09915_ _09980_ VDD VSS NAND3_X2
X_19288_ _09783_ _09979_ _09980_ _09981_ VDD VSS NAND3_X1
X_19289_ _09981_ _09893_ _09928_ _09982_ VDD VSS OAI21_X1
X_19290_ _09817_ _09822_ _09827_ _09983_ VDD VSS OR3_X2
X_19291_ _09983_ _09984_ VDD VSS BUF_X4
X_19292_ _09978_ _09982_ _09984_ _09985_ VDD VSS MUX2_X1
X_19293_ _09971_ _09974_ _09975_ _09985_ _09904_ _09986_ VDD
+ VSS AOI221_X2
X_19294_ _09882_ _09977_ _09987_ VDD VSS NAND2_X1
X_19295_ _09909_ _09987_ _09988_ VDD VSS NAND2_X1
X_19296_ net478 _09989_ VDD VSS INV_X4
X_19297_ _09795_ _09973_ _09989_ _09898_ _14836_ _09990_ VDD
+ VSS AOI221_X2
X_19298_ _09779_ _09846_ _09849_ _09991_ VDD VSS NOR3_X4
X_19299_ _09756_ _09778_ _09992_ VDD VSS NAND2_X2
X_19300_ _09892_ _09992_ _09850_ _09993_ VDD VSS OAI21_X1
X_19301_ _09854_ _09991_ _09993_ _09734_ _09779_ _09862_ _09994_
+ VDD VSS AOI222_X2
X_19302_ _09890_ _09988_ _09990_ _09994_ _09795_ _09995_ VDD
+ VSS AOI221_X2
X_19303_ _09984_ _09996_ VDD VSS BUF_X4
X_19304_ _09805_ _09996_ _09997_ VDD VSS NAND2_X1
X_19305_ net1049 _09735_ _09851_ _09998_ VDD VSS MUX2_X1
X_19306_ net102 _09897_ _09999_ VDD VSS NOR2_X2
X_19307_ _09781_ _09998_ _09999_ _09926_ _10000_ VDD VSS OAI22_X1
X_19308_ _09937_ _09831_ net618 _10001_ VDD VSS AOI21_X1
X_19309_ _09900_ _09783_ _10002_ VDD VSS NOR2_X1
X_19310_ net618 _10003_ VDD VSS BUF_X16
X_19311_ _10003_ _09852_ _10004_ VDD VSS NAND2_X1
X_19312_ _10001_ _10002_ _10004_ _10005_ VDD VSS AOI21_X1
X_19313_ _10000_ _10005_ _09930_ _10006_ VDD VSS MUX2_X1
X_19314_ _09995_ _09997_ _10006_ _09904_ _10007_ VDD VSS AOI211_X2
X_19315_ _09961_ _10007_ _09986_ _09921_ _00040_ VDD VSS OR4_X4
X_19316_ _09984_ _09963_ _10008_ VDD VSS NOR2_X2
Xclone142 net615 net614 VDD VSS BUF_X8
X_19318_ _10008_ _09947_ net98 _10009_ VDD VSS OAI21_X1
X_19319_ _14842_ _10010_ VDD VSS INV_X2
X_19320_ _10010_ _09932_ _10011_ VDD VSS NOR2_X1
X_19321_ net103 _09927_ _10011_ _09949_ _10012_ VDD VSS OAI22_X1
X_19322_ _09989_ _09910_ _09911_ _10013_ VDD VSS OAI21_X4
X_19323_ _09976_ _09914_ _09915_ _10014_ VDD VSS NAND3_X2
X_19324_ _09935_ _10013_ _10014_ _10015_ VDD VSS AOI21_X1
X_19325_ net922 _09910_ _09911_ _10016_ VDD VSS OAI21_X4
X_19326_ _09949_ _09947_ _10016_ _10017_ VDD VSS AOI21_X1
X_19327_ _10015_ _10017_ _10018_ VDD VSS NOR2_X1
X_19328_ _09996_ _09891_ _10019_ VDD VSS NAND2_X1
X_19329_ _09962_ _10009_ _10012_ _10018_ _10019_ _10020_ VDD
+ VSS OAI221_X1
X_19330_ _09907_ _09951_ _10021_ VDD VSS NOR2_X1
X_19331_ _10013_ _09784_ _10022_ VDD VSS NAND2_X4
X_19332_ _09897_ _10023_ VDD VSS CLKBUF_X3
X_19333_ _10023_ _09933_ _10024_ VDD VSS AND2_X1
X_19334_ _09784_ _10025_ VDD VSS BUF_X4
X_19335_ _09830_ _10021_ _10022_ _10024_ _10025_ _10026_ VDD
+ VSS OAI221_X1
X_19336_ _09755_ _09859_ _09861_ _10027_ VDD VSS AOI21_X4
X_19337_ net98 _10027_ _09898_ net100 _10028_ VDD VSS AOI22_X1
X_19338_ _09783_ _09914_ _09915_ _10029_ VDD VSS AOI21_X4
X_19339_ _10029_ _09991_ _10030_ VDD VSS NOR2_X2
X_19340_ _10028_ _10030_ _14835_ _10031_ VDD VSS OAI21_X1
X_19341_ _09828_ _10032_ VDD VSS BUF_X4
X_19342_ _10032_ _10033_ VDD VSS CLKBUF_X3
X_19343_ _10026_ _10031_ _10033_ _10034_ VDD VSS OAI21_X1
X_19344_ _09881_ _10035_ VDD VSS BUF_X4
X_19345_ _10020_ _10034_ _10035_ _10036_ VDD VSS AOI21_X1
X_19346_ _09805_ _10037_ VDD VSS INV_X2
X_19347_ _09854_ _09914_ _09915_ _10038_ VDD VSS NAND3_X2
X_19348_ net102 _10027_ _10039_ VDD VSS NAND2_X1
X_19349_ _10025_ _10038_ _10039_ _10040_ VDD VSS AOI21_X1
X_19350_ _09900_ _09914_ _09915_ _10041_ VDD VSS AOI21_X2
X_19351_ _09935_ _10041_ _10042_ VDD VSS NOR2_X1
X_19352_ net526 _09859_ _09861_ _10043_ VDD VSS NAND3_X4
X_19353_ _10042_ net656 _10044_ VDD VSS AND2_X1
X_19354_ _09996_ _10040_ _10044_ _10045_ VDD VSS OAI21_X1
X_19355_ _09923_ _09891_ _10046_ VDD VSS NAND2_X1
X_19356_ _09979_ _09947_ _09782_ _10047_ VDD VSS NAND3_X2
X_19357_ _09916_ _09938_ _09909_ _10048_ VDD VSS OAI21_X1
X_19358_ _09935_ _10049_ VDD VSS CLKBUF_X3
X_19359_ _10047_ _10048_ _10049_ _10050_ VDD VSS OAI21_X1
X_19360_ _10046_ _10050_ _09830_ _10051_ VDD VSS AOI21_X2
X_19361_ _10037_ _10051_ _10045_ _10052_ VDD VSS AOI21_X2
X_19362_ _09907_ _09859_ _09861_ _10053_ VDD VSS AOI21_X4
X_19363_ _10053_ _09887_ _09780_ _10054_ VDD VSS NOR3_X2
X_19364_ _09735_ _09851_ _10055_ VDD VSS XNOR2_X1
X_19365_ _09828_ _10054_ _10055_ _09781_ _10056_ VDD VSS AOI211_X2
X_19366_ _09756_ _09780_ _10057_ VDD VSS XNOR2_X2
X_19367_ net97 _09932_ _10057_ _10058_ VDD VSS NOR3_X1
X_19368_ _09976_ _09756_ _09783_ _10059_ VDD VSS MUX2_X1
X_19369_ _09828_ _09951_ _10059_ _10060_ VDD VSS OAI21_X1
X_19370_ _09903_ _10058_ _10060_ _10061_ VDD VSS OAI21_X1
X_19371_ _09935_ _09933_ _10062_ VDD VSS NOR2_X1
X_19372_ _09932_ _09784_ _09968_ _10063_ VDD VSS OAI21_X1
X_19373_ _09881_ _10062_ _10063_ _10064_ VDD VSS OAI21_X1
X_19374_ _14852_ _10032_ _09938_ _10065_ VDD VSS NOR3_X1
X_19375_ _09931_ _10056_ _10061_ _10064_ _10065_ _10066_ VDD
+ VSS OAI221_X2
X_19376_ _09930_ _09903_ _10067_ VDD VSS NOR2_X1
X_19377_ _09907_ net620 _09780_ _10068_ VDD VSS MUX2_X1
X_19378_ _10032_ _09938_ _10068_ _10069_ VDD VSS OAI21_X1
X_19379_ _09909_ _09779_ _10070_ VDD VSS NAND2_X1
X_19380_ _09897_ _09955_ _10071_ VDD VSS NOR2_X1
X_19381_ _10070_ _10071_ _10072_ VDD VSS AND2_X1
X_19382_ _14835_ _09893_ _10073_ VDD VSS NOR2_X1
X_19383_ net617 _10074_ VDD VSS BUF_X4
X_19384_ _10013_ _09947_ _10074_ _10075_ VDD VSS OAI21_X2
X_19385_ _10073_ _09949_ _10075_ _10076_ VDD VSS AOI21_X2
X_19386_ _10067_ _10069_ _10072_ _10076_ _09830_ _10077_ VDD
+ VSS OAI221_X1
X_19387_ _10066_ _10077_ _10078_ VDD VSS AND2_X2
X_19388_ _09890_ _09908_ _10079_ VDD VSS NOR2_X1
X_19389_ _09964_ _09831_ _10010_ _10080_ VDD VSS OAI21_X1
X_19390_ _09951_ _10080_ _10081_ VDD VSS NAND2_X1
X_19391_ _09928_ _09893_ _10030_ _10074_ _10082_ VDD VSS OAI22_X1
X_19392_ _10032_ _10081_ _10079_ _10082_ _09891_ _10083_ VDD
+ VSS AOI221_X2
X_19393_ _09940_ _09891_ _10023_ _10084_ VDD VSS NAND3_X1
X_19394_ _09963_ _09924_ _10085_ VDD VSS NAND2_X1
X_19395_ _10084_ _10085_ net104 _10086_ VDD VSS OAI21_X1
X_19396_ _10049_ _09904_ _09882_ _14835_ _10087_ VDD VSS OAI22_X1
X_19397_ _14826_ _10086_ _10087_ net104 _10088_ VDD VSS AOI22_X1
X_19398_ _14826_ _09948_ _10089_ VDD VSS NOR2_X2
X_19399_ _09963_ _09951_ _10090_ VDD VSS NOR2_X1
X_19400_ _09951_ _09963_ net96 _10091_ VDD VSS OAI21_X2
X_19401_ _09889_ _09851_ _10092_ VDD VSS NAND2_X2
X_19402_ _10091_ _10092_ _09928_ _10093_ VDD VSS OAI21_X1
X_19403_ _09984_ _10089_ _10090_ _10093_ _10025_ _10094_ VDD
+ VSS AOI221_X2
X_19404_ _10083_ _10094_ _10088_ _10095_ VDD VSS AOI21_X2
X_19405_ _10036_ _10078_ _10052_ _09806_ _10095_ _00041_ VDD
+ VSS AOI221_X2
X_19406_ _10023_ _10096_ VDD VSS CLKBUF_X3
X_19407_ _09863_ _09951_ _10097_ VDD VSS NAND2_X1
X_19408_ _14856_ _10096_ _10097_ _10089_ _10098_ VDD VSS OAI22_X1
X_19409_ net617 _14835_ _09949_ _10099_ VDD VSS NOR3_X1
X_19410_ _09938_ _10100_ VDD VSS BUF_X4
X_19411_ _14847_ _10099_ _10100_ _10101_ VDD VSS MUX2_X1
X_19412_ _09996_ _10102_ VDD VSS CLKBUF_X3
X_19413_ _10102_ _10035_ _10103_ VDD VSS NAND2_X1
X_19414_ _09806_ _10019_ _10098_ _10101_ _10103_ _10104_ VDD
+ VSS OAI221_X1
X_19415_ _09979_ _10014_ _10105_ VDD VSS NAND2_X1
X_19416_ _09891_ _10029_ _09928_ _10105_ _10025_ _10106_ VDD
+ VSS AOI221_X1
X_19417_ _09894_ _09898_ _10107_ VDD VSS NAND2_X1
X_19418_ _09907_ _09854_ _10108_ VDD VSS NAND2_X4
X_19419_ _10107_ _10108_ _09927_ _09933_ _10030_ _10109_ VDD
+ VSS OAI221_X1
X_19420_ _09904_ _10110_ VDD VSS CLKBUF_X3
X_19421_ _10106_ _10109_ _10110_ _10111_ VDD VSS AOI21_X1
X_19422_ _10104_ _10111_ _10033_ _10112_ VDD VSS AOI21_X1
X_19423_ net104 _14851_ _09944_ _09947_ _10113_ VDD VSS NAND4_X1
X_19424_ _09984_ _09903_ _09973_ _10010_ _10114_ VDD VSS AOI211_X2
X_19425_ _10037_ _10113_ _10114_ _10115_ VDD VSS AOI21_X1
X_19426_ _14844_ _09917_ net656 _10116_ VDD VSS AOI21_X1
X_19427_ _09932_ _10117_ VDD VSS BUF_X4
X_19428_ _09996_ _10117_ _09943_ _09977_ _09907_ _10118_ VDD
+ VSS OAI221_X1
X_19429_ _10110_ _10116_ _10118_ _10119_ VDD VSS OAI21_X1
X_19430_ _09854_ _09951_ _10120_ VDD VSS NAND2_X1
X_19431_ _09948_ _09932_ _09863_ _10121_ VDD VSS AOI21_X1
X_19432_ _09917_ _09937_ _10122_ VDD VSS NAND2_X1
X_19433_ _09984_ _10120_ _10121_ _10122_ _09949_ _10123_ VDD
+ VSS AOI221_X2
X_19434_ _09907_ _14851_ _09905_ _09943_ _10124_ VDD VSS AOI22_X1
X_19435_ _10102_ _10100_ _10124_ _10125_ VDD VSS OAI21_X1
X_19436_ _10115_ _10119_ _10123_ _09967_ _10125_ _10126_ VDD
+ VSS OAI221_X1
X_19437_ _09903_ _09914_ _09915_ _14826_ _10074_ _10127_ VDD
+ VSS AOI221_X2
X_19438_ _10033_ _09965_ _10127_ _10128_ VDD VSS AOI21_X1
X_19439_ _14852_ _09904_ _10096_ _10129_ VDD VSS OR3_X1
X_19440_ _09979_ _10014_ _10130_ VDD VSS AND2_X1
X_19441_ _09894_ _09914_ _09915_ _10131_ VDD VSS AOI21_X2
X_19442_ _10131_ _10117_ _09943_ _10132_ VDD VSS AOI21_X1
X_19443_ _10130_ _10132_ _14844_ _10133_ VDD VSS MUX2_X1
X_19444_ _10128_ _10129_ _10133_ _10035_ _10134_ VDD VSS OAI211_X2
X_19445_ _09984_ _09890_ _10135_ VDD VSS NOR2_X1
X_19446_ _09851_ _09905_ _09734_ _09989_ _09780_ _10136_ VDD
+ VSS AOI221_X2
X_19447_ _10136_ _10117_ _14849_ _10137_ VDD VSS AOI21_X1
X_19448_ _10074_ _10023_ _09992_ _10138_ VDD VSS NAND3_X1
X_19449_ _09948_ _09897_ _09863_ _10139_ VDD VSS MUX2_X1
X_19450_ _10138_ _09965_ _10027_ net96 _10139_ _10140_ VDD
+ VSS OAI221_X2
X_19451_ _09805_ _10137_ _10135_ _10140_ _10008_ _10141_ VDD
+ VSS AOI221_X2
X_19452_ _09931_ _10126_ _10141_ _10134_ _10142_ VDD VSS AOI22_X1
X_19453_ _09983_ _09948_ _09928_ _10143_ VDD VSS OAI21_X2
X_19454_ _10025_ _09980_ _10144_ VDD VSS AND2_X1
X_19455_ _10143_ _10144_ _10097_ _10145_ VDD VSS AOI21_X1
X_19456_ _10022_ _09887_ _09996_ _10146_ VDD VSS NOR3_X2
X_19457_ _09940_ _10023_ net711 _10147_ VDD VSS OAI21_X1
X_19458_ _10032_ _09979_ _10148_ VDD VSS NAND2_X1
X_19459_ _09922_ _10147_ _10148_ _10149_ VDD VSS OAI21_X1
X_19460_ _10145_ _10146_ _10149_ _10150_ VDD VSS NOR3_X1
X_19461_ _09923_ _09959_ _10151_ VDD VSS NAND2_X1
X_19462_ _09829_ _09890_ _10152_ VDD VSS NAND2_X1
X_19463_ _14838_ _09859_ _09861_ _10153_ VDD VSS AOI21_X4
X_19464_ _10049_ _09887_ net911 _10154_ VDD VSS NOR3_X2
X_19465_ _10010_ _09932_ _10155_ VDD VSS NAND2_X1
X_19466_ _09940_ _10097_ _10155_ _10156_ VDD VSS AND3_X1
X_19467_ _10152_ _10154_ _10156_ _10157_ VDD VSS NOR3_X1
X_19468_ _14844_ _09917_ _09980_ _10158_ VDD VSS NAND3_X1
X_19469_ _10049_ _10016_ net656 _10159_ VDD VSS NAND3_X1
X_19470_ _10019_ _10158_ _10159_ _10160_ VDD VSS AOI21_X1
X_19471_ _10150_ _10151_ _10157_ _10160_ _10161_ VDD VSS OR4_X1
X_19472_ _10112_ _10142_ _10161_ _00042_ VDD VSS AOI21_X1
X_19473_ net480 _09910_ _09911_ _10162_ VDD VSS NOR3_X4
X_19474_ _09784_ net911 _10162_ _10163_ VDD VSS OAI21_X1
X_19475_ _09935_ _09944_ _10043_ _10164_ VDD VSS NAND3_X2
X_19476_ _09881_ _10164_ _10163_ _10165_ VDD VSS AOI21_X2
X_19477_ _09948_ _09897_ net102 _10166_ VDD VSS OAI21_X1
X_19478_ _09913_ _09898_ net102 _10166_ _09756_ _10167_ VDD
+ VSS AOI221_X2
X_19479_ _10165_ _10167_ _09922_ _10168_ VDD VSS AOI21_X2
X_19480_ _09884_ _09782_ _10169_ VDD VSS NAND2_X1
X_19481_ _10108_ _09781_ _10170_ VDD VSS NOR2_X4
X_19482_ _10170_ _09924_ _10171_ VDD VSS NOR2_X4
X_19483_ _10171_ _10169_ _10172_ VDD VSS AND2_X4
X_19484_ _10172_ _10064_ _10173_ VDD VSS OR2_X4
X_19485_ _14842_ _14851_ _10174_ VDD VSS NAND2_X1
X_19486_ _09955_ _10092_ _10175_ VDD VSS NOR2_X1
X_19487_ _09830_ _10174_ _10175_ _10176_ VDD VSS AOI21_X1
X_19488_ _10037_ _10033_ _10168_ _10176_ _10173_ _10177_ VDD
+ VSS AOI221_X2
X_19489_ _09922_ _09927_ _09968_ _09893_ net100 _10178_ VDD
+ VSS OAI221_X1
X_19490_ _14844_ _09944_ _09992_ _10096_ _10179_ VDD VSS OAI22_X1
X_19491_ _10178_ _10179_ net104 _10180_ VDD VSS AOI21_X1
X_19492_ _09959_ _09996_ _10181_ VDD VSS NOR2_X1
X_19493_ _09891_ _10182_ VDD VSS CLKBUF_X3
X_19494_ _10182_ _09893_ _09968_ _09944_ net1050 _10183_ VDD
+ VSS OAI221_X1
X_19495_ _14851_ _09917_ _09937_ _10184_ VDD VSS AOI21_X1
X_19496_ _10181_ _10183_ _10184_ _10185_ VDD VSS OAI21_X1
X_19497_ _14851_ _10110_ _14835_ _10186_ VDD VSS OAI21_X1
X_19498_ _10011_ _10100_ _14838_ _10187_ VDD VSS AOI21_X1
X_19499_ _10186_ _10187_ _10110_ _10188_ VDD VSS AOI21_X1
X_19500_ net104 _10110_ _09973_ _10189_ VDD VSS NAND3_X1
X_19501_ _09959_ _10033_ _10190_ VDD VSS NOR2_X1
X_19502_ net103 _14835_ _09903_ _10191_ VDD VSS NOR3_X1
X_19503_ _09935_ _09963_ _10192_ VDD VSS NOR2_X1
X_19504_ _09938_ _09903_ _10074_ _10193_ VDD VSS AOI21_X1
X_19505_ _10191_ _10192_ _10162_ _10193_ _10025_ _10194_ VDD
+ VSS AOI221_X2
X_19506_ _10189_ _10190_ _10194_ _10195_ VDD VSS NAND3_X1
X_19507_ _09923_ _10180_ _10185_ _10188_ _10195_ _10196_ VDD
+ VSS OAI221_X1
X_19508_ _10181_ _10197_ VDD VSS INV_X1
X_19509_ _09755_ _09846_ _09849_ _10198_ VDD VSS NOR3_X4
X_19510_ _09940_ _10013_ _10199_ VDD VSS NAND2_X2
X_19511_ _09976_ _09968_ _09938_ _10200_ VDD VSS MUX2_X1
X_19512_ _10182_ _10199_ _10198_ _10200_ _14851_ _10201_ VDD
+ VSS OAI221_X2
X_19513_ _09937_ _10117_ _14842_ _10202_ VDD VSS OAI21_X1
X_19514_ _09907_ net97 _09932_ _10203_ VDD VSS MUX2_X1
X_19515_ _10202_ _10203_ _10049_ _10204_ VDD VSS MUX2_X1
X_19516_ _10201_ _10204_ _10110_ _10205_ VDD VSS OAI21_X2
X_19517_ _09955_ _09903_ _10074_ _10206_ VDD VSS AOI21_X1
X_19518_ _10023_ _10206_ _10207_ VDD VSS NOR2_X1
X_19519_ _09783_ _09876_ _09879_ _10208_ VDD VSS NOR3_X2
X_19520_ _10074_ _10208_ _10209_ VDD VSS NAND2_X1
X_19521_ _09863_ _09948_ _09890_ _10210_ VDD VSS MUX2_X1
X_19522_ _10209_ _10210_ _09900_ _10211_ VDD VSS OAI21_X1
X_19523_ _09924_ _09963_ _09989_ _10212_ VDD VSS AOI21_X2
X_19524_ _14835_ _10085_ _10212_ _09940_ _10213_ VDD VSS OAI22_X2
X_19525_ _10207_ _10211_ _10096_ net104 _10213_ _10214_ VDD
+ VSS AOI221_X2
X_19526_ _10190_ _09992_ _10035_ _10215_ VDD VSS OAI21_X1
X_19527_ _09931_ _10205_ _10197_ _10214_ _10215_ _10216_ VDD
+ VSS OAI221_X2
X_19528_ _10023_ _09992_ _10217_ VDD VSS NOR2_X2
X_19529_ _09960_ _10217_ _10218_ VDD VSS NOR2_X1
X_19530_ _10218_ _09987_ _09884_ _10219_ VDD VSS OAI21_X1
X_19531_ _09900_ _09756_ _09831_ _10220_ VDD VSS MUX2_X1
X_19532_ _10010_ _09782_ _10221_ VDD VSS NAND2_X1
X_19533_ _10032_ _09938_ _10220_ _10221_ _10171_ _10222_ VDD
+ VSS AOI221_X2
X_19534_ _09959_ _10110_ _10222_ _10223_ VDD VSS OAI21_X1
X_19535_ _10074_ _09991_ _10224_ VDD VSS NAND2_X1
X_19536_ _09894_ _09910_ _09911_ _10225_ VDD VSS NOR3_X1
X_19537_ _10049_ _10041_ _10225_ _10226_ VDD VSS OAI21_X1
X_19538_ _09830_ _10224_ _10226_ _10227_ VDD VSS AOI21_X1
X_19539_ _09853_ _10096_ _10228_ VDD VSS NAND2_X1
X_19540_ net96 _10032_ _10117_ _10229_ VDD VSS NAND3_X1
X_19541_ _14851_ _10228_ _10229_ _10230_ VDD VSS AOI21_X1
X_19542_ _10227_ _10230_ _10231_ VDD VSS OR2_X1
X_19543_ _10223_ _10219_ _10231_ _10110_ _10232_ VDD VSS AOI22_X1
X_19544_ _10196_ _10177_ _10232_ _10216_ _00043_ VDD VSS OAI22_X2
X_19545_ _09979_ _09935_ _10233_ VDD VSS NAND2_X2
X_19546_ _09904_ _10233_ _10021_ _10049_ net712 _10234_ VDD
+ VSS OAI221_X2
X_19547_ _09924_ _14826_ net103 _10235_ VDD VSS AOI21_X1
X_19548_ _09784_ _10043_ _10236_ VDD VSS NAND2_X1
X_19549_ _10162_ net911 _10237_ VDD VSS NOR2_X4
X_19550_ _09881_ _10235_ _10236_ _10237_ _10025_ _10238_ VDD
+ VSS OAI221_X1
X_19551_ _09806_ _10234_ _10033_ _10238_ _10239_ VDD VSS NAND4_X2
X_19552_ _09806_ _10102_ _10240_ VDD VSS NAND2_X1
X_19553_ net102 _09862_ _10241_ VDD VSS NAND2_X1
X_19554_ _09911_ _09910_ net848 _10242_ VDD VSS NOR3_X4
X_19555_ _09831_ _10242_ _10243_ VDD VSS NOR2_X2
X_19556_ _10043_ _09852_ net620 _10244_ VDD VSS OAI21_X4
X_19557_ _09963_ _10243_ _10241_ _10244_ _09781_ _10245_ VDD
+ VSS AOI221_X2
X_19558_ net98 _09949_ _10246_ VDD VSS NOR2_X1
X_19559_ _09909_ _09782_ _10247_ VDD VSS NOR2_X1
X_19560_ _10096_ _10246_ _10247_ _10248_ VDD VSS OAI21_X1
X_19561_ _10245_ _10248_ _10079_ _10249_ VDD VSS AOI21_X1
X_19562_ _10239_ _10240_ _10249_ _10250_ VDD VSS OAI21_X2
X_19563_ _09828_ _09914_ _09915_ _10251_ VDD VSS AOI21_X1
X_19564_ net1050 _09887_ _09955_ _10251_ _10252_ VDD VSS AOI22_X2
X_19565_ net911 _09938_ _09829_ _10253_ VDD VSS AOI21_X2
X_19566_ _09898_ _09973_ _10032_ _10254_ VDD VSS AOI21_X1
X_19567_ _10252_ _10253_ _10025_ _10254_ _09943_ _10255_ VDD
+ VSS OAI221_X2
X_19568_ _09829_ _09862_ _09736_ _10256_ VDD VSS AOI21_X1
X_19569_ _10027_ _09924_ _09909_ _10257_ VDD VSS AOI21_X1
X_19570_ _10256_ _10257_ _09949_ _09853_ _09977_ _10258_ VDD
+ VSS OAI221_X2
X_19571_ _14840_ _10259_ VDD VSS INV_X1
X_19572_ _10259_ _09964_ _09897_ _10260_ VDD VSS MUX2_X1
X_19573_ _09891_ _10260_ _10032_ _10261_ VDD VSS AOI21_X1
X_19574_ _10255_ _10182_ _10258_ _10261_ _10262_ VDD VSS AOI22_X2
X_19575_ _09931_ _09959_ _10263_ VDD VSS NAND2_X1
X_19576_ _09965_ _10070_ _09889_ _10264_ VDD VSS MUX2_X1
X_19577_ _09863_ _09756_ _10208_ _10265_ VDD VSS OAI21_X1
X_19578_ _09828_ _10264_ _09897_ _10265_ _10071_ _10266_ VDD
+ VSS AOI221_X2
X_19579_ _09828_ _09880_ _10267_ VDD VSS NAND2_X1
X_19580_ _09909_ _09851_ _10268_ VDD VSS NAND2_X1
X_19581_ _09783_ _09886_ _09734_ _10269_ VDD VSS AOI21_X4
X_19582_ _10267_ _10268_ _10269_ _09948_ _09756_ _10270_ VDD
+ VSS AOI221_X2
X_19583_ _09831_ _09944_ _09880_ _10271_ VDD VSS MUX2_X1
X_19584_ _09943_ _10032_ _10271_ _10272_ VDD VSS NOR3_X1
X_19585_ _09935_ _09924_ _09884_ _10273_ VDD VSS OAI21_X1
X_19586_ _10152_ _10273_ _10038_ _10274_ VDD VSS AOI21_X1
X_19587_ _10274_ _10270_ _10272_ _10266_ _10275_ VDD VSS NOR4_X2
X_19588_ _09923_ _10037_ _10276_ VDD VSS NAND2_X2
X_19589_ _10262_ _10263_ _10275_ _10276_ _10277_ VDD VSS OAI22_X2
X_19590_ _09944_ _09937_ _10278_ VDD VSS AND2_X1
X_19591_ _09984_ _10039_ _10243_ _10278_ _09782_ _10279_ VDD
+ VSS AOI221_X2
X_19592_ _09829_ _09991_ _14826_ _10155_ _09782_ _10280_ VDD
+ VSS AOI221_X1
X_19593_ _10035_ _10279_ _10280_ _10281_ VDD VSS OAI21_X1
X_19594_ _09781_ _10014_ _10016_ _10282_ VDD VSS AOI21_X1
X_19595_ net97 _09852_ _10283_ VDD VSS XNOR2_X1
X_19596_ _09829_ _10282_ _10283_ _09782_ _10284_ VDD VSS AOI211_X2
X_19597_ _10284_ _10040_ _10033_ _10285_ VDD VSS AOI21_X1
X_19598_ _10281_ _10285_ _10035_ _10286_ VDD VSS OAI21_X1
X_19599_ _10151_ _10287_ VDD VSS INV_X1
X_19600_ _10277_ _10250_ _10286_ _10287_ _00044_ VDD VSS AOI211_X2
X_19601_ _09931_ _09922_ _10288_ VDD VSS NAND2_X1
X_19602_ _09943_ _10117_ _10289_ VDD VSS NAND2_X1
X_19603_ _10289_ _10057_ _10108_ _09927_ _10290_ VDD VSS OAI22_X1
X_19604_ _09928_ _09898_ _10221_ _10096_ _10291_ VDD VSS AOI22_X1
X_19605_ _09931_ _10182_ _10292_ VDD VSS NAND2_X1
X_19606_ _09959_ _10288_ _10290_ _10291_ _10292_ _10293_ VDD
+ VSS OAI221_X1
X_19607_ net617 _09944_ _10294_ VDD VSS NOR2_X2
X_19608_ _09999_ _10022_ _10147_ _10294_ _10295_ VDD VSS OAI22_X1
X_19609_ _10217_ _10289_ _14826_ _10296_ VDD VSS AOI21_X1
X_19610_ _10295_ _10296_ _10035_ _10297_ VDD VSS MUX2_X1
X_19611_ _10293_ _10297_ _09923_ _10298_ VDD VSS AOI21_X1
X_19612_ _10010_ _09736_ _09932_ _10299_ VDD VSS MUX2_X1
X_19613_ _09931_ _10208_ _10299_ _10300_ VDD VSS AOI21_X1
X_19614_ _10016_ _09893_ _09884_ _10301_ VDD VSS OAI21_X1
X_19615_ _09881_ _09888_ _10301_ _10302_ VDD VSS OR3_X2
X_19616_ _14844_ _09922_ _09916_ _10016_ _10303_ VDD VSS NAND4_X1
X_19617_ _10300_ _10302_ _10303_ _10304_ VDD VSS AND3_X4
X_19618_ _09890_ _09973_ _10305_ VDD VSS NAND2_X1
X_19619_ net618 _09880_ _09852_ _10306_ VDD VSS AOI21_X1
X_19620_ _14826_ _10305_ _10306_ _10092_ _10074_ _10307_ VDD
+ VSS AOI221_X1
X_19621_ _09881_ _10023_ _10308_ VDD VSS NAND2_X1
X_19622_ _09943_ _09977_ _10308_ _10309_ VDD VSS AOI21_X1
X_19623_ _09894_ _10029_ _09991_ _14826_ _10310_ VDD VSS AOI22_X1
X_19624_ _09922_ _10310_ _10311_ VDD VSS NOR2_X1
X_19625_ _09923_ _10307_ _10309_ _10311_ _10312_ VDD VSS NOR4_X1
X_19626_ _09959_ _10304_ _10312_ _10313_ VDD VSS NOR3_X4
X_19627_ _09916_ _09979_ _10314_ VDD VSS NAND2_X2
X_19628_ _09782_ _10314_ _10315_ VDD VSS NAND2_X2
X_19629_ _09891_ _10224_ _10315_ _10316_ VDD VSS NAND3_X2
X_19630_ _10043_ _09851_ _09909_ _10317_ VDD VSS OAI21_X4
X_19631_ _09889_ _09973_ _09989_ _09831_ _10317_ _10318_ VDD
+ VSS AOI221_X2
X_19632_ _10318_ _09795_ _10319_ VDD VSS NOR2_X2
X_19633_ _09782_ _10237_ _10320_ VDD VSS NOR2_X1
X_19634_ _09903_ _09935_ _09928_ _10321_ VDD VSS OAI21_X1
X_19635_ _10320_ _09972_ _09904_ _10321_ _10294_ _09973_ _10322_
+ VDD VSS OAI33_X1
X_19636_ _09805_ _10316_ _10319_ _10322_ _09923_ _10323_ VDD
+ VSS AOI221_X2
X_19637_ _09922_ _10100_ _09968_ _10324_ VDD VSS OAI21_X1
X_19638_ _10324_ _10062_ _10100_ _10325_ VDD VSS AOI21_X1
X_19639_ net656 _10117_ _09894_ _10326_ VDD VSS OAI21_X1
X_19640_ _10049_ _10326_ _10327_ VDD VSS NAND2_X1
X_19641_ _09937_ _10042_ _10328_ VDD VSS NAND2_X1
X_19642_ _10035_ _10327_ _10328_ _10329_ VDD VSS AOI21_X1
X_19643_ _10263_ _10325_ _10329_ _10330_ VDD VSS NOR3_X1
X_19644_ _10182_ _10217_ _10331_ VDD VSS NOR2_X1
X_19645_ _09881_ _09934_ _10025_ _10332_ VDD VSS AOI21_X1
X_19646_ _09974_ _10331_ _10327_ _10332_ _10333_ VDD VSS AOI22_X1
X_19647_ _10102_ _10151_ _10333_ _10334_ VDD VSS OAI21_X1
X_19648_ _10313_ _10298_ _10102_ _10323_ _10330_ _10334_ _00045_
+ VDD VSS OAI33_X1
X_19649_ _09783_ _09851_ _09884_ _10335_ VDD VSS AOI21_X1
X_19650_ _10043_ _09852_ _09854_ _10336_ VDD VSS OAI21_X1
X_19651_ _09828_ _10039_ _10335_ _10336_ _09784_ _10337_ VDD
+ VSS AOI221_X2
X_19652_ _09933_ _09911_ _09910_ _09863_ _09781_ _10338_ VDD
+ VSS OAI221_X2
X_19653_ _14845_ _14854_ _09897_ _10339_ VDD VSS OR3_X1
X_19654_ _09996_ _10338_ _10339_ _10340_ VDD VSS AOI21_X1
X_19655_ _10182_ _10337_ _10340_ _10341_ VDD VSS NOR3_X1
X_19656_ _10014_ _09852_ _09884_ _10342_ VDD VSS OAI21_X1
X_19657_ _09948_ _10342_ _10343_ VDD VSS NAND2_X1
X_19658_ _09983_ _10029_ _09853_ _10344_ VDD VSS AOI21_X2
X_19659_ _10153_ _10198_ _10345_ VDD VSS OR2_X2
X_19660_ _09937_ _10108_ _09851_ _10346_ VDD VSS OAI21_X1
X_19661_ _10345_ _10346_ _09831_ _10347_ VDD VSS MUX2_X1
X_19662_ _09963_ _10343_ _10344_ _09984_ _10347_ _10348_ VDD
+ VSS AOI221_X2
X_19663_ _10348_ _10341_ _10276_ _10349_ VDD VSS NOR3_X2
X_19664_ _09890_ _10198_ net97 _10350_ VDD VSS OAI21_X1
X_19665_ _09948_ _09880_ _09862_ _10351_ VDD VSS AOI21_X1
X_19666_ _14835_ _10092_ _10237_ _09890_ _10352_ VDD VSS OAI22_X1
X_19667_ _09829_ _10350_ _10351_ _10352_ _09949_ _10353_ VDD
+ VSS AOI221_X1
X_19668_ _09992_ _10308_ _10354_ VDD VSS NOR2_X1
X_19669_ _10089_ _09862_ net98 _10355_ VDD VSS AOI21_X1
X_19670_ _10198_ _09905_ _10074_ _10356_ VDD VSS AOI21_X1
X_19671_ _10355_ _10356_ _14842_ _10357_ VDD VSS OAI21_X1
X_19672_ _10354_ _10357_ _10182_ _10358_ VDD VSS AOI21_X1
X_19673_ _09904_ _10089_ _10155_ _09940_ _10359_ VDD VSS OAI22_X1
X_19674_ _09996_ _10359_ net1050 _10360_ VDD VSS AOI21_X1
X_19675_ _10353_ _10358_ _10360_ _10361_ VDD VSS AOI21_X1
X_19676_ _10198_ _10011_ _10362_ VDD VSS NOR2_X1
X_19677_ _10008_ _10362_ _14844_ _09927_ net100 _10363_ VDD
+ VSS OAI221_X1
X_19678_ _09829_ _09963_ _10364_ VDD VSS NOR2_X1
X_19679_ _10153_ _10117_ _09894_ _10365_ VDD VSS AOI21_X1
X_19680_ net104 _09927_ _10365_ _14844_ _10366_ VDD VSS OAI22_X1
X_19681_ _10143_ _09905_ net103 _10367_ VDD VSS AOI21_X1
X_19682_ _14846_ _09984_ _10368_ VDD VSS NOR2_X1
X_19683_ _09884_ _09784_ _10369_ VDD VSS NOR2_X1
X_19684_ _09829_ _09924_ _10370_ VDD VSS NAND2_X1
X_19685_ net97 _09781_ _10371_ VDD VSS NOR2_X1
X_19686_ _10100_ _10367_ _10368_ _10369_ _10370_ _10371_ _10372_
+ VDD VSS OAI33_X1
X_19687_ _10364_ _10366_ _10372_ _10035_ _10373_ VDD VSS AOI22_X1
X_19688_ _09959_ _10363_ _10373_ _10374_ VDD VSS NAND3_X1
X_19689_ _10117_ _09940_ net100 _10375_ VDD VSS OAI21_X1
X_19690_ _10008_ _10099_ _10375_ _10100_ _14847_ _10376_ VDD
+ VSS OAI221_X1
X_19691_ _09784_ _09951_ _10108_ _10377_ VDD VSS OAI21_X1
X_19692_ _09975_ _10122_ _09949_ _10377_ _10294_ _10378_ VDD
+ VSS OAI221_X1
X_19693_ net617 _09955_ _10379_ VDD VSS NOR2_X1
X_19694_ _10364_ _10379_ _09938_ _09893_ _09894_ _10380_ VDD
+ VSS OAI221_X1
X_19695_ _09781_ _10038_ _10381_ VDD VSS NAND2_X1
X_19696_ _09937_ _09924_ _09863_ _10382_ VDD VSS OAI21_X1
X_19697_ _10135_ _10381_ _10294_ _10382_ _09940_ _10383_ VDD
+ VSS OAI221_X1
X_19698_ _10037_ _10378_ _10380_ _10383_ _10384_ VDD VSS AND4_X1
X_19699_ _09923_ _10376_ _10384_ _10385_ VDD VSS AOI21_X1
X_19700_ _10349_ _10361_ _10287_ _10374_ _10385_ _00046_ VDD
+ VSS AOI221_X2
X_19701_ _09853_ _10049_ _10100_ _10386_ VDD VSS NAND3_X1
X_19702_ _10386_ _10100_ _14840_ _10387_ VDD VSS OAI21_X1
X_19703_ _10110_ _10096_ _10379_ _10388_ VDD VSS OAI21_X1
X_19704_ _09806_ _10267_ _10387_ _10388_ _10069_ _10389_ VDD
+ VSS OAI221_X1
X_19705_ _10117_ _09940_ _09884_ _10390_ VDD VSS OAI21_X1
X_19706_ _09922_ _10002_ _10390_ _10100_ _14854_ _10391_ VDD
+ VSS OAI221_X2
X_19707_ _10013_ _10025_ _10023_ net98 _10392_ VDD VSS OAI211_X4
X_19708_ _10182_ _10392_ _10047_ _10393_ VDD VSS NAND3_X2
X_19709_ _10393_ _10391_ _10102_ _10394_ VDD VSS AND3_X4
X_19710_ _10394_ _10389_ _10395_ VDD VSS OR2_X4
X_19711_ _09923_ _10033_ _10396_ VDD VSS NOR2_X1
X_19712_ _09898_ _10096_ _09881_ _10397_ VDD VSS AOI21_X1
X_19713_ net98 _14826_ _10397_ _10398_ VDD VSS NOR3_X1
X_19714_ _09943_ _09891_ _10023_ _09905_ _10399_ VDD VSS NAND4_X1
X_19715_ _10399_ _09904_ _14844_ net96 _09977_ _10400_ VDD
+ VSS OAI221_X1
X_19716_ _10396_ _10398_ _10400_ _10401_ VDD VSS OAI21_X1
X_19717_ _09931_ _10033_ _10402_ VDD VSS NAND2_X1
X_19718_ _09947_ _09927_ _14835_ _10403_ VDD VSS OAI21_X1
X_19719_ _10182_ _10403_ _10404_ VDD VSS NAND2_X1
X_19720_ _09736_ _09917_ _09893_ _10405_ VDD VSS AOI21_X1
X_19721_ _10405_ _09887_ _09943_ _10406_ VDD VSS AOI21_X1
X_19722_ _10029_ _10217_ _10407_ VDD VSS NOR2_X1
X_19723_ _10404_ _10406_ _10182_ net98 _10407_ _10408_ VDD
+ VSS OAI221_X1
X_19724_ net599 _09882_ _14851_ _10244_ _10409_ VDD VSS OAI22_X4
X_19725_ _10067_ _10409_ _10102_ _10410_ VDD VSS OAI21_X2
X_19726_ _09917_ net656 _10411_ VDD VSS AND2_X1
X_19727_ _09830_ _09980_ _10269_ _10411_ _14844_ _10412_ VDD
+ VSS AOI221_X2
X_19728_ _10401_ _10402_ _10408_ _10410_ _10412_ _10413_ VDD
+ VSS OAI221_X2
X_19729_ _09887_ _10089_ _10096_ _10414_ VDD VSS AOI21_X1
X_19730_ _09830_ _09927_ _09976_ _10414_ net98 _10415_ VDD
+ VSS OAI221_X1
X_19731_ _09996_ _09927_ _14842_ _10030_ net100 _10416_ VDD
+ VSS OAI221_X1
X_19732_ _10073_ _10415_ _10416_ _10417_ VDD VSS AOI21_X1
X_19733_ _09959_ _10046_ _10417_ _10418_ VDD VSS OAI21_X1
X_19734_ _10033_ _10242_ _10419_ VDD VSS NOR2_X1
X_19735_ _10035_ _10419_ _10338_ _10420_ VDD VSS AOI21_X1
X_19736_ _10198_ net911 _10421_ VDD VSS NOR2_X1
X_19737_ _09999_ _10108_ _09973_ _10421_ _10049_ _10422_ VDD
+ VSS AOI221_X1
X_19738_ _10420_ _10422_ _10102_ _10423_ VDD VSS OAI21_X1
X_19739_ _14851_ _10131_ _09934_ _10424_ VDD VSS OAI21_X1
X_19740_ _10102_ _10015_ _10425_ VDD VSS NOR2_X1
X_19741_ _10247_ _10269_ _10038_ _10426_ VDD VSS AOI21_X1
X_19742_ _10424_ _10425_ _10426_ _10102_ _10427_ VDD VSS AOI22_X1
X_19743_ _10423_ _10427_ _10110_ _10428_ VDD VSS OAI21_X2
X_19744_ _10395_ _10418_ _10413_ _10428_ _10276_ _00047_ VDD
+ VSS OAI221_X2
X_19745_ net738 _10429_ VDD VSS INV_X1
X_19746_ _10429_ _09728_ _10430_ VDD VSS NOR2_X1
X_19747_ net740 _09728_ _10431_ VDD VSS NOR2_X1
X_19748_ sa02_sr\[7\] _10432_ VDD VSS BUF_X4
X_19749_ sa12_sr\[7\] _10433_ VDD VSS BUF_X8
X_19750_ net605 _10432_ _10434_ VDD VSS XOR2_X2
Xclone85 net945 net85 VDD VSS BUF_X4
Xclone86 _04987_ net86 VDD VSS BUF_X8
X_19753_ sa20_sub\[1\] sa12_sr\[1\] _10437_ VDD VSS XNOR2_X2
X_19754_ _10434_ _10437_ _10438_ VDD VSS XNOR2_X2
X_19755_ sa02_sr\[0\] _10439_ VDD VSS BUF_X4
Xclone5 net708 net5 VDD VSS BUF_X4
Xclone135 net495 net135 VDD VSS BUF_X4
X_19758_ net490 net483 _10442_ VDD VSS XOR2_X1
X_19759_ _10442_ _10439_ _10443_ VDD VSS XNOR2_X1
X_19760_ _10443_ _10438_ _10444_ VDD VSS XNOR2_X2
X_19761_ _10430_ _10431_ _10444_ _10445_ VDD VSS MUX2_X2
X_19762_ net739 _09100_ _00446_ _10446_ VDD VSS NOR3_X2
X_19763_ _10429_ _09075_ _10447_ VDD VSS NOR2_X2
X_19764_ _10446_ _10447_ _00446_ _10448_ VDD VSS AOI21_X4
X_19765_ _10448_ _10449_ VDD VSS INV_X1
X_19766_ _10449_ _10445_ _10450_ VDD VSS NOR2_X4
X_19767_ _10450_ _10451_ VDD VSS INV_X2
X_19768_ _10451_ _10452_ VDD VSS BUF_X8
X_19769_ _10452_ _14864_ VDD VSS BUF_X8
X_19770_ sa31_sub\[0\] _10453_ VDD VSS BUF_X8
Xclone56 net517 net56 VDD VSS BUF_X4
X_19772_ sa12_sr\[0\] sa20_sub\[0\] _10455_ VDD VSS XNOR2_X2
X_19773_ _10453_ net530 _10456_ VDD VSS XNOR2_X1
X_19774_ net732 _09023_ _10434_ _10457_ VDD VSS NAND3_X1
X_19775_ _10432_ net605 _10458_ VDD VSS XNOR2_X2
X_19776_ net732 _09027_ _10459_ VDD VSS NOR2_X1
X_19777_ _10458_ _10459_ _10460_ VDD VSS NAND2_X1
X_19778_ _10456_ _10457_ _10460_ _10461_ VDD VSS AOI21_X1
X_19779_ _10453_ net530 _10462_ VDD VSS XOR2_X1
X_19780_ _10434_ _10459_ _10463_ VDD VSS NAND2_X1
X_19781_ net732 _09194_ _10458_ _10464_ VDD VSS NAND3_X1
X_19782_ _10462_ _10463_ _10464_ _10465_ VDD VSS AOI21_X1
X_19783_ net732 _10466_ VDD VSS INV_X1
X_19784_ _10466_ _09727_ _00447_ _10467_ VDD VSS NAND3_X1
X_19785_ net732 _09028_ _10468_ VDD VSS NAND2_X1
X_19786_ _10467_ _10468_ _00447_ _10469_ VDD VSS OAI21_X1
X_19787_ _10461_ _10465_ _10469_ _10470_ VDD VSS OR3_X1
X_19788_ _10470_ _10471_ VDD VSS BUF_X4
X_19789_ _10471_ _10472_ VDD VSS INV_X2
X_19790_ _10472_ _10473_ VDD VSS BUF_X8
X_19791_ _10473_ _14867_ VDD VSS BUF_X4
Xclone115 net156 net115 VDD VSS BUF_X4
X_19793_ sa31_sub\[2\] _10475_ VDD VSS BUF_X4
X_19794_ net790 _10475_ _10476_ VDD VSS XOR2_X2
X_19795_ sa02_sr\[1\] _10476_ _10477_ VDD VSS XOR2_X1
X_19796_ sa12_sr\[2\] _10478_ VDD VSS BUF_X4
X_19797_ sa20_sub\[2\] _10479_ VDD VSS BUF_X4
X_19798_ _10479_ _10478_ _10480_ VDD VSS XOR2_X2
X_19799_ _06637_ _09011_ net1066 _10481_ VDD VSS NAND3_X1
X_19800_ _10478_ _10479_ _10482_ VDD VSS XNOR2_X2
X_19801_ _06637_ _08992_ _10483_ VDD VSS NOR2_X1
X_19802_ _10482_ _10483_ _10484_ VDD VSS NAND2_X1
X_19803_ _10477_ _10481_ _10484_ _10485_ VDD VSS AOI21_X2
X_19804_ sa02_sr\[1\] _10476_ _10486_ VDD VSS XNOR2_X1
X_19805_ net1066 _10483_ _10487_ VDD VSS NAND2_X1
X_19806_ _06637_ _09022_ _10482_ _10488_ VDD VSS NAND3_X1
X_19807_ _10486_ _10487_ _10488_ _10489_ VDD VSS AOI21_X2
X_19808_ _06637_ _10490_ VDD VSS INV_X1
X_19809_ _10490_ _09027_ _00448_ _10491_ VDD VSS NAND3_X1
X_19810_ _06637_ _09027_ _10492_ VDD VSS NAND2_X1
X_19811_ _10491_ _10492_ _00448_ _10493_ VDD VSS OAI21_X2
X_19812_ _10485_ _10489_ _10493_ _10494_ VDD VSS NOR3_X4
X_19813_ _10494_ _10495_ VDD VSS INV_X4
X_19814_ _10495_ _10496_ VDD VSS BUF_X4
X_19815_ _10496_ _10497_ VDD VSS BUF_X4
X_19816_ _10497_ _10498_ VDD VSS BUF_X4
X_19817_ _10498_ _10499_ VDD VSS BUF_X4
X_19818_ _10499_ _14883_ VDD VSS BUF_X4
X_19819_ _10471_ _14858_ VDD VSS BUF_X4
X_19820_ _10494_ _10500_ VDD VSS BUF_X4
X_19821_ _10500_ _10501_ VDD VSS BUF_X4
X_19822_ _10501_ _14876_ VDD VSS BUF_X4
X_19823_ sa12_sr\[6\] _10502_ VDD VSS CLKBUF_X3
X_19824_ sa20_sub\[7\] _10503_ VDD VSS BUF_X8
X_19825_ _10503_ _10433_ _10504_ VDD VSS XNOR2_X2
X_19826_ sa02_sr\[6\] _10505_ VDD VSS BUF_X2
X_19827_ sa31_sub\[7\] _10506_ VDD VSS BUF_X8
X_19828_ _10505_ _10506_ _10507_ VDD VSS XNOR2_X1
X_19829_ net547 _10507_ _10508_ VDD VSS XNOR2_X1
X_19830_ _10502_ _10508_ _10509_ VDD VSS XNOR2_X1
X_19831_ text_in_r\[63\] _10509_ _09158_ _10510_ VDD VSS MUX2_X2
X_19832_ _06710_ _10510_ _10511_ VDD VSS XOR2_X2
X_19833_ sa31_sub\[6\] _10512_ VDD VSS CLKBUF_X3
X_19834_ sa20_sub\[6\] _10513_ VDD VSS BUF_X2
X_19835_ _10502_ _10513_ _10514_ VDD VSS XNOR2_X2
X_19836_ sa12_sr\[5\] _10515_ VDD VSS CLKBUF_X3
X_19837_ sa02_sr\[5\] _10516_ VDD VSS BUF_X2
X_19838_ _10515_ _10516_ _10517_ VDD VSS XNOR2_X2
X_19839_ _10514_ _10517_ _10518_ VDD VSS XNOR2_X1
X_19840_ _10512_ _10518_ _10519_ VDD VSS XNOR2_X1
X_19841_ text_in_r\[62\] _10519_ _09195_ _10520_ VDD VSS MUX2_X2
X_19842_ _06696_ _10520_ _10521_ VDD VSS XNOR2_X2
X_19843_ _10511_ _10521_ _10522_ VDD VSS NAND2_X2
X_19844_ sa20_sub\[5\] _10523_ VDD VSS BUF_X2
X_19845_ sa31_sub\[5\] _10524_ VDD VSS CLKBUF_X3
X_19846_ _10523_ _10524_ _10525_ VDD VSS XNOR2_X2
X_19847_ sa12_sr\[4\] _10526_ VDD VSS CLKBUF_X3
X_19848_ sa02_sr\[4\] _10527_ VDD VSS BUF_X2
X_19849_ _10526_ _10527_ _10528_ VDD VSS XNOR2_X2
X_19850_ _10525_ _10528_ _10529_ VDD VSS XNOR2_X1
X_19851_ _10515_ _10529_ _10530_ VDD VSS XNOR2_X1
X_19852_ text_in_r\[61\] _10530_ _09076_ _10531_ VDD VSS MUX2_X2
X_19853_ _06687_ _10531_ _10532_ VDD VSS XOR2_X2
X_19854_ _10532_ _10533_ VDD VSS BUF_X4
X_19855_ _10533_ _10534_ VDD VSS BUF_X4
X_19856_ sa02_sr\[3\] _10535_ VDD VSS BUF_X2
X_19857_ sa20_sub\[4\] _10536_ VDD VSS BUF_X2
X_19858_ _10535_ _10536_ _10537_ VDD VSS XNOR2_X1
X_19859_ _10432_ _10537_ _10538_ VDD VSS XNOR2_X2
X_19860_ sa12_sr\[3\] _10539_ VDD VSS BUF_X2
X_19861_ net605 _10539_ _10540_ VDD VSS XOR2_X2
X_19862_ sa31_sub\[4\] _10541_ VDD VSS CLKBUF_X3
X_19863_ _10526_ _10541_ _10542_ VDD VSS XOR2_X1
X_19864_ _10540_ _10542_ _10543_ VDD VSS XNOR2_X1
X_19865_ _10538_ _10543_ _10544_ VDD VSS XNOR2_X1
X_19866_ text_in_r\[60\] _10544_ _09075_ _10545_ VDD VSS MUX2_X2
X_19867_ _06672_ _10545_ _10546_ VDD VSS XOR2_X2
X_19868_ _06656_ _10547_ VDD VSS INV_X1
X_19869_ _10547_ _09076_ _10548_ VDD VSS NAND2_X1
X_19870_ _06656_ _09076_ _10549_ VDD VSS NAND2_X1
X_19871_ sa02_sr\[2\] _10550_ VDD VSS BUF_X4
X_19872_ sa20_sub\[3\] _10551_ VDD VSS BUF_X2
X_19873_ _10550_ _10551_ _10552_ VDD VSS XNOR2_X1
X_19874_ _10432_ _10552_ _10553_ VDD VSS XNOR2_X2
X_19875_ sa31_sub\[3\] _10554_ VDD VSS BUF_X4
X_19876_ _10478_ _10554_ _10555_ VDD VSS XNOR2_X1
X_19877_ _10540_ _10555_ _10556_ VDD VSS XNOR2_X1
X_19878_ _10553_ _10556_ _10557_ VDD VSS XNOR2_X2
X_19879_ _10548_ _10549_ _10557_ _10558_ VDD VSS MUX2_X2
X_19880_ _10547_ net830 text_in_r\[59\] _10559_ VDD VSS OR3_X2
X_19881_ _10547_ _09728_ text_in_r\[59\] _10560_ VDD VSS NAND3_X2
X_19882_ _10559_ _10560_ _10561_ VDD VSS AND2_X1
X_19883_ _10561_ _10562_ VDD VSS BUF_X4
X_19884_ _10494_ _10558_ _10562_ _10563_ VDD VSS AOI21_X4
X_19885_ _14870_ _10564_ VDD VSS BUF_X8
X_19886_ _06656_ _09028_ _10565_ VDD VSS NOR2_X1
X_19887_ _10547_ _09028_ _10566_ VDD VSS NOR2_X1
X_19888_ _10565_ _10566_ _10557_ _10567_ VDD VSS MUX2_X1
X_19889_ _10567_ _10568_ VDD VSS BUF_X4
X_19890_ _10559_ _10560_ _10569_ VDD VSS NAND2_X4
X_19891_ net508 _10568_ _10569_ _10570_ VDD VSS NOR3_X4
X_19892_ _09118_ _10571_ VDD VSS BUF_X4
X_19893_ net739 _10571_ _10572_ VDD VSS NAND2_X1
X_19894_ _10429_ _10571_ _10573_ VDD VSS NAND2_X1
X_19895_ _10572_ _10573_ _10444_ _10574_ VDD VSS MUX2_X2
X_19896_ _10472_ _10448_ _10574_ _10575_ VDD VSS AOI21_X4
X_19897_ _10558_ _10562_ _10576_ VDD VSS NAND2_X4
X_19898_ _10570_ _10575_ _10576_ _10577_ VDD VSS AOI21_X2
X_19899_ _10494_ _10578_ VDD VSS BUF_X4
X_19900_ _10546_ _10563_ net682 _10577_ _10578_ _10579_ VDD
+ VSS AOI221_X2
X_19901_ _10568_ _10569_ _10580_ VDD VSS NOR2_X2
X_19902_ _10580_ _10581_ VDD VSS BUF_X4
X_19903_ _14862_ _10582_ VDD VSS BUF_X8
X_19904_ _10558_ _10583_ VDD VSS BUF_X4
X_19905_ _10562_ _10584_ VDD VSS BUF_X8
X_19906_ _10471_ _10583_ _10584_ _10585_ VDD VSS NAND3_X4
X_19907_ _10450_ _10586_ VDD VSS BUF_X8
X_19908_ _10500_ _10581_ _10582_ _10585_ _10586_ _10587_ VDD
+ VSS OAI221_X2
X_19909_ _06672_ _10545_ _10588_ VDD VSS XNOR2_X2
X_19910_ _10588_ _10589_ VDD VSS BUF_X4
X_19911_ _10494_ _10568_ _10569_ _10590_ VDD VSS NOR3_X4
X_19912_ _14868_ _10591_ VDD VSS CLKBUF_X3
X_19913_ _10591_ _10592_ VDD VSS INV_X2
X_19914_ _10589_ _10590_ _10592_ _10593_ VDD VSS AOI21_X2
X_19915_ _10579_ _10587_ _10593_ _10594_ VDD VSS AOI21_X2
X_19916_ _10533_ _10595_ VDD VSS CLKBUF_X3
X_19917_ _10546_ _10596_ VDD VSS BUF_X4
X_19918_ _10596_ _10597_ VDD VSS CLKBUF_X3
X_19919_ _10597_ _10598_ VDD VSS BUF_X4
X_19920_ _10576_ _10599_ VDD VSS BUF_X4
X_19921_ _10599_ _10600_ VDD VSS CLKBUF_X3
X_19922_ _14861_ _10601_ VDD VSS BUF_X4
X_19923_ _10601_ _10602_ VDD VSS BUF_X16
X_19924_ _10602_ _10603_ VDD VSS BUF_X8
X_19925_ _14881_ _10600_ _10590_ _10603_ _10604_ VDD VSS AOI22_X1
X_19926_ _10595_ _10598_ _10604_ _10605_ VDD VSS AOI21_X1
X_19927_ _10546_ _10606_ VDD VSS BUF_X4
X_19928_ _10581_ _10607_ VDD VSS BUF_X4
Xsplit147 _14865_ net147 VDD VSS BUF_X2
X_19930_ net542 _10609_ VDD VSS INV_X4
X_19931_ _10473_ _10496_ _10610_ VDD VSS NOR2_X2
X_19932_ _10609_ _10497_ _10610_ _10452_ _10611_ VDD VSS AOI22_X4
X_19933_ _10606_ _10607_ _10611_ _10612_ VDD VSS AOI21_X4
X_19934_ _10494_ _10568_ _10569_ _10613_ VDD VSS OAI21_X2
X_19935_ _10613_ _10614_ VDD VSS CLKBUF_X3
X_19936_ _14860_ _10615_ VDD VSS BUF_X2
X_19937_ _10615_ _10616_ VDD VSS CLKBUF_X3
X_19938_ _10582_ _10607_ _10617_ VDD VSS NAND2_X1
X_19939_ _10568_ _10618_ VDD VSS BUF_X4
X_19940_ _10569_ _10619_ VDD VSS BUF_X4
X_19941_ _10473_ _10618_ _10619_ _10620_ VDD VSS OAI21_X4
X_19942_ _10617_ _10620_ _10621_ VDD VSS AND2_X1
X_19943_ _10578_ _10622_ VDD VSS CLKBUF_X3
X_19944_ _10622_ _10623_ VDD VSS CLKBUF_X3
X_19945_ _10612_ _10614_ _10616_ _10621_ _10623_ _10624_ VDD
+ VSS OAI221_X2
X_19946_ _10522_ _10534_ _10594_ _10605_ _10624_ _10625_ VDD
+ VSS AOI221_X2
X_19947_ _06696_ _10520_ _10626_ VDD VSS XOR2_X2
X_19948_ _10626_ _10627_ VDD VSS BUF_X4
X_19949_ _10511_ _10627_ _10628_ VDD VSS NAND2_X2
X_19950_ _10588_ _10629_ VDD VSS CLKBUF_X3
X_19951_ _14858_ _10629_ _10600_ _10630_ VDD VSS NAND3_X1
X_19952_ _10622_ _10631_ VDD VSS CLKBUF_X3
X_19953_ _10607_ _10632_ VDD VSS CLKBUF_X3
X_19954_ _10631_ _10632_ _10609_ _10633_ VDD VSS AOI21_X1
X_19955_ _10595_ _10630_ _10633_ _10634_ VDD VSS AOI21_X1
X_19956_ _10471_ _10495_ _10635_ VDD VSS NOR2_X4
X_19957_ _10452_ _10635_ _10636_ VDD VSS NAND2_X1
X_19958_ _10471_ _10496_ _10637_ VDD VSS NAND2_X1
X_19959_ _10576_ _10637_ _10638_ VDD VSS AND2_X1
X_19960_ _10546_ _10636_ _10638_ _10639_ VDD VSS AOI21_X4
X_19961_ _14870_ _10640_ VDD VSS INV_X2
X_19962_ _10640_ _10497_ _10641_ VDD VSS NOR2_X1
X_19963_ _10495_ _10580_ _10642_ VDD VSS NOR2_X4
X_19964_ _10589_ _10607_ _10641_ _10642_ _10603_ _10643_ VDD
+ VSS AOI221_X1
X_19965_ _10634_ _10639_ _10643_ _10644_ VDD VSS OAI21_X1
X_19966_ _06687_ _10531_ _10645_ VDD VSS XNOR2_X2
X_19967_ _10645_ _10646_ VDD VSS CLKBUF_X3
X_19968_ _10646_ _10589_ _10647_ VDD VSS NOR2_X1
X_19969_ net541 _10583_ _10584_ _10648_ VDD VSS AOI21_X4
X_19970_ _10623_ _10570_ _10648_ _10649_ VDD VSS OAI21_X1
X_19971_ _10496_ _10583_ _10584_ _10650_ VDD VSS NAND3_X4
X_19972_ _10616_ _10651_ VDD VSS INV_X1
X_19973_ _10649_ _10650_ _10651_ _10652_ VDD VSS OAI21_X1
X_19974_ _10645_ _10546_ _10653_ VDD VSS NOR2_X2
X_19975_ _10581_ _10654_ VDD VSS BUF_X4
X_19976_ _10654_ _10655_ VDD VSS BUF_X4
X_19977_ _10473_ _10578_ _10656_ VDD VSS NAND2_X4
X_19978_ _10497_ _10657_ VDD VSS CLKBUF_X3
X_19979_ _10592_ _10657_ _10658_ VDD VSS NAND2_X1
X_19980_ _10655_ _10656_ _10658_ _10659_ VDD VSS AOI21_X1
X_19981_ _10576_ _10660_ VDD VSS BUF_X4
X_19982_ _10660_ _10578_ _10452_ _10661_ VDD VSS AOI21_X2
X_19983_ _10603_ _10499_ _10662_ VDD VSS NAND2_X1
X_19984_ _10659_ _10661_ _10662_ _10663_ VDD VSS AOI21_X1
X_19985_ _10647_ _10652_ _10653_ _10663_ _10664_ VDD VSS AOI22_X1
X_19986_ _10628_ _10644_ _10664_ _10665_ VDD VSS AOI21_X1
X_19987_ _10511_ _10521_ _10666_ VDD VSS NOR2_X2
X_19988_ _10666_ _10667_ VDD VSS INV_X1
X_19989_ _10452_ _10668_ VDD VSS BUF_X4
X_19990_ _10668_ _10607_ _10669_ VDD VSS NOR2_X1
X_19991_ net147 _10614_ _10637_ _10669_ _10670_ VDD VSS OAI22_X1
X_19992_ _10582_ _10496_ _10671_ VDD VSS NOR2_X1
X_19993_ _10494_ _10448_ _10574_ _10672_ VDD VSS AOI21_X4
X_19994_ _10671_ _10576_ _10672_ _10673_ VDD VSS NOR3_X2
X_19995_ _10595_ _10673_ _10674_ VDD VSS NOR2_X1
X_19996_ _10653_ _10670_ _10674_ _10639_ _10675_ VDD VSS AOI22_X1
Xsplit134 net638 net134 VDD VSS BUF_X2
X_19998_ _14874_ _10618_ _10619_ _10677_ VDD VSS OAI21_X1
X_19999_ _10668_ _10654_ _10678_ VDD VSS NAND2_X1
X_20000_ _10631_ _10677_ _10678_ _10679_ VDD VSS AND3_X1
X_20001_ _10599_ _10680_ VDD VSS BUF_X4
X_20002_ _14864_ _10680_ _10681_ VDD VSS NOR2_X1
X_20003_ _10646_ _10637_ _10681_ _10682_ VDD VSS OAI21_X1
X_20004_ _10471_ _10618_ _10619_ _10683_ VDD VSS NOR3_X4
X_20005_ _10677_ _10599_ _10452_ _10684_ VDD VSS OAI21_X1
X_20006_ _10683_ _10684_ _10498_ _10602_ _10642_ _10685_ VDD
+ VSS AOI221_X2
X_20007_ _10646_ _10686_ VDD VSS BUF_X4
X_20008_ _10598_ _10679_ _10682_ _10685_ _10686_ _10687_ VDD
+ VSS OAI221_X1
X_20009_ _10667_ _10675_ _10687_ _10688_ VDD VSS AOI21_X1
X_20010_ _10589_ _10689_ VDD VSS BUF_X4
X_20011_ _10473_ _10449_ _10445_ _10690_ VDD VSS OAI21_X2
X_20012_ _10581_ _10690_ _10691_ VDD VSS AND2_X1
X_20013_ _10499_ _10655_ _10616_ _10692_ VDD VSS OAI21_X1
X_20014_ _10602_ _10583_ _10584_ _10693_ VDD VSS NAND3_X4
X_20015_ _10693_ _10632_ _10591_ _10694_ VDD VSS OAI21_X1
X_20016_ _10657_ _10695_ VDD VSS CLKBUF_X3
X_20017_ _10689_ _10691_ _10692_ _10694_ _10695_ _10696_ VDD
+ VSS OAI221_X1
X_20018_ _10574_ _10448_ _10471_ _10697_ VDD VSS NAND3_X4
X_20019_ _10656_ _10697_ _10698_ VDD VSS NAND2_X1
X_20020_ _10632_ _10698_ _10699_ VDD VSS XNOR2_X1
X_20021_ _10696_ _10699_ _10689_ _10700_ VDD VSS OAI21_X1
X_20022_ _10511_ _10626_ _10701_ VDD VSS NOR2_X4
X_20023_ _10534_ _10701_ _10702_ VDD VSS NAND2_X1
X_20024_ _10521_ _10546_ _10703_ VDD VSS NAND2_X2
X_20025_ _10602_ _10578_ _10704_ VDD VSS NOR2_X1
X_20026_ _10450_ _10581_ _10705_ VDD VSS NAND2_X2
X_20027_ net629 _10497_ _10706_ VDD VSS NAND2_X1
X_20028_ _10601_ _10707_ VDD VSS INV_X4
X_20029_ _10707_ _10618_ _10619_ _10708_ VDD VSS NOR3_X4
X_20030_ _10703_ _10704_ _10705_ _10706_ _10708_ _10709_ VDD
+ VSS AOI221_X1
X_20031_ _10591_ _10590_ _10710_ VDD VSS NAND2_X1
X_20032_ _10495_ _10568_ _10569_ _10711_ VDD VSS NOR3_X4
X_20033_ _10563_ _10711_ _10712_ VDD VSS NOR2_X2
X_20034_ _10710_ _10712_ _10651_ _10614_ _10603_ _10713_ VDD
+ VSS OAI221_X1
X_20035_ _10627_ _10606_ _10714_ VDD VSS NOR2_X2
X_20036_ _10709_ _10714_ _10713_ _10715_ VDD VSS AOI21_X2
X_20037_ _06710_ _10510_ _10716_ VDD VSS XNOR2_X2
X_20038_ _10716_ _10646_ _10717_ VDD VSS NAND2_X1
X_20039_ _10700_ _10702_ _10715_ _10717_ _10718_ VDD VSS OAI22_X2
X_20040_ _10718_ _10665_ _10688_ _10625_ _00048_ VDD VSS NOR4_X4
X_20041_ _10686_ _10719_ VDD VSS CLKBUF_X3
X_20042_ _10626_ _10588_ _10720_ VDD VSS NAND2_X2
X_20043_ _10660_ _10690_ _10721_ VDD VSS AND2_X1
X_20044_ _14876_ _10721_ _10722_ VDD VSS NOR2_X1
X_20045_ _10602_ _10583_ _10584_ _10723_ VDD VSS AOI21_X4
X_20046_ _10609_ _10660_ _10724_ VDD VSS NOR2_X1
X_20047_ _14883_ _10723_ _10724_ _10725_ VDD VSS NOR3_X1
X_20048_ _10720_ _10722_ _10725_ _10726_ VDD VSS NOR3_X1
X_20049_ _10473_ _10583_ _10584_ _10727_ VDD VSS NAND3_X2
X_20050_ _10586_ _10727_ _10728_ VDD VSS NOR2_X1
X_20051_ _10626_ _10546_ _10729_ VDD VSS NAND2_X2
X_20052_ _14874_ _10730_ VDD VSS INV_X2
X_20053_ _10730_ _10583_ _10584_ _10731_ VDD VSS AOI21_X2
X_20054_ _14864_ _10614_ _10731_ _10623_ _10732_ VDD VSS OAI22_X1
X_20055_ _10728_ _10729_ _10732_ _10733_ VDD VSS NOR3_X1
X_20056_ _10597_ _10563_ _10734_ VDD VSS NAND2_X1
X_20057_ _10586_ _10735_ VDD VSS BUF_X8
X_20058_ _10735_ _10629_ _10655_ _10736_ VDD VSS NAND3_X1
X_20059_ _14867_ _10734_ _10736_ _10737_ VDD VSS AOI21_X1
X_20060_ _10609_ _10596_ _10654_ _10738_ VDD VSS NAND3_X1
X_20061_ _10680_ _10589_ _10707_ _10739_ VDD VSS OAI21_X1
X_20062_ _10499_ _10738_ _10739_ _10740_ VDD VSS AOI21_X1
X_20063_ _10735_ _14859_ VDD VSS BUF_X16
X_20064_ _10501_ _10589_ _10563_ _14858_ _10741_ VDD VSS AOI22_X2
X_20065_ _10606_ _10655_ _10742_ VDD VSS NAND2_X1
X_20066_ _10473_ _10496_ _10743_ VDD VSS NAND2_X2
X_20067_ _14859_ _10741_ _10742_ _10743_ _10744_ VDD VSS OAI22_X2
X_20068_ _10627_ _10737_ _10740_ _10744_ _10745_ VDD VSS NOR4_X2
X_20069_ _10719_ _10726_ _10733_ _10745_ _10746_ VDD VSS NOR4_X2
X_20070_ _10707_ _10622_ _10747_ VDD VSS NOR2_X1
X_20071_ _10730_ _10657_ _10748_ VDD VSS NOR2_X1
X_20072_ _10680_ _10747_ _10748_ _10749_ VDD VSS OAI21_X1
X_20073_ net147 _10650_ _10712_ _10735_ _10750_ VDD VSS OAI22_X2
X_20074_ _10522_ _10612_ _10749_ _10750_ _10598_ _10751_ VDD
+ VSS AOI221_X2
X_20075_ _14864_ _10620_ _10712_ _14867_ _10650_ _10707_ _10752_
+ VDD VSS OAI222_X2
X_20076_ _10598_ _10628_ _10752_ _10753_ VDD VSS NOR3_X1
X_20077_ _10473_ _10618_ _10619_ _10754_ VDD VSS NOR3_X4
X_20078_ _10631_ _10754_ _10648_ _10755_ VDD VSS NOR3_X1
X_20079_ _10707_ _10618_ _10619_ _10756_ VDD VSS OAI21_X4
X_20080_ _10756_ _10600_ _10616_ _10757_ VDD VSS OAI21_X1
X_20081_ _10755_ _10757_ _14876_ _10758_ VDD VSS AOI21_X1
X_20082_ _10511_ _10627_ _10598_ _10759_ VDD VSS NAND3_X1
X_20083_ _10716_ _10719_ _10758_ _10759_ _10760_ VDD VSS OAI22_X1
X_20084_ _10751_ _10753_ _10760_ _10761_ VDD VSS NOR3_X2
X_20085_ _10654_ _10656_ _10586_ _10500_ _10592_ _10762_ VDD
+ VSS OAI221_X2
X_20086_ _14884_ _10763_ VDD VSS INV_X1
X_20087_ _10680_ _10764_ VDD VSS CLKBUF_X3
X_20088_ _10763_ _10719_ _10764_ _10765_ VDD VSS NAND3_X1
X_20089_ _10714_ _10762_ _10765_ _10766_ VDD VSS NAND3_X1
X_20090_ _10703_ _10767_ VDD VSS INV_X1
X_20091_ _10631_ _10648_ _10683_ _10768_ VDD VSS OAI21_X2
X_20092_ net629 _10654_ _10769_ VDD VSS XNOR2_X2
X_20093_ _10686_ _10768_ _10769_ _14876_ _10770_ VDD VSS OAI211_X2
X_20094_ _14864_ _10764_ _10771_ VDD VSS NAND2_X1
X_20095_ _14867_ _10498_ _10772_ VDD VSS XNOR2_X2
X_20096_ _10610_ _14883_ _10616_ _10773_ VDD VSS AOI21_X1
X_20097_ _10534_ _10771_ _10772_ _10773_ _10764_ _10774_ VDD
+ VSS OAI221_X1
X_20098_ _10767_ _10770_ _10774_ _10775_ VDD VSS NAND3_X1
X_20099_ _10716_ _10766_ _10775_ _10776_ VDD VSS NAND3_X1
X_20100_ _10756_ _10727_ _10735_ _10777_ VDD VSS OAI21_X1
X_20101_ _10533_ _10590_ _14858_ _10777_ _10631_ _10778_ VDD
+ VSS AOI221_X2
X_20102_ _10768_ _10779_ VDD VSS INV_X1
X_20103_ _10616_ _10680_ _10780_ VDD VSS NOR2_X1
X_20104_ _10450_ _10581_ _10781_ VDD VSS NOR2_X2
X_20105_ _10623_ _10780_ _10781_ _10782_ VDD VSS NOR3_X1
X_20106_ _10719_ _10779_ _10782_ _10783_ VDD VSS NOR3_X1
X_20107_ _10695_ _10585_ _10756_ _10784_ VDD VSS NAND3_X1
X_20108_ _10570_ _10600_ _10616_ _10785_ VDD VSS AOI21_X1
X_20109_ _14876_ _10785_ _10786_ VDD VSS NAND2_X1
X_20110_ _10686_ _10784_ _10786_ _10787_ VDD VSS AOI21_X1
X_20111_ _10660_ _10788_ VDD VSS CLKBUF_X3
X_20112_ _10788_ _10690_ _10789_ VDD VSS NAND2_X1
X_20113_ _10500_ _10654_ _10582_ _10790_ VDD VSS AOI21_X1
X_20114_ _10723_ _10607_ net148 _10791_ VDD VSS AOI21_X2
X_20115_ _10533_ _10789_ _10790_ _10791_ _10501_ _10792_ VDD
+ VSS AOI221_X2
X_20116_ _10720_ _10778_ _10783_ _10787_ _10792_ _10729_ _10793_
+ VDD VSS OAI33_X1
X_20117_ _10746_ _10761_ _10793_ _10776_ _00049_ VDD VSS OAI22_X2
X_20118_ _10662_ _10661_ _10794_ VDD VSS AND2_X1
X_20119_ _10629_ _10632_ _10611_ _10795_ VDD VSS OAI21_X1
X_20120_ _10627_ _10794_ _10795_ _10796_ VDD VSS NOR3_X1
X_20121_ _14874_ _10568_ _10569_ _10797_ VDD VSS NOR3_X4
X_20122_ _10501_ _10648_ _10797_ _10798_ VDD VSS NOR3_X1
X_20123_ net682 _14867_ _10599_ _10799_ VDD VSS MUX2_X1
X_20124_ _10798_ _10799_ _10623_ _10800_ VDD VSS AOI21_X1
X_20125_ _10729_ _10800_ _10801_ VDD VSS NOR2_X1
X_20126_ _14874_ _14865_ _10494_ _10802_ VDD VSS MUX2_X1
X_20127_ _10802_ _10803_ VDD VSS INV_X1
X_20128_ _10703_ _10743_ _10781_ _10803_ _10581_ _10804_ VDD
+ VSS AOI221_X1
X_20129_ _10496_ _10576_ _10451_ _10805_ VDD VSS AOI21_X1
X_20130_ _10564_ _10558_ _10562_ _10806_ VDD VSS NAND3_X2
X_20131_ _10720_ _10805_ _10806_ _10497_ _10609_ _10807_ VDD
+ VSS AOI221_X1
X_20132_ _10717_ _10804_ _10807_ _10808_ VDD VSS OR3_X1
X_20133_ _10796_ _10801_ _10808_ _10809_ VDD VSS OR3_X1
X_20134_ _14888_ _10810_ VDD VSS INV_X1
X_20135_ _10703_ _10743_ _10781_ _10655_ _10810_ _10811_ VDD
+ VSS AOI221_X1
X_20136_ _10716_ _10534_ _10811_ _10812_ VDD VSS NOR3_X1
X_20137_ _10655_ _10813_ VDD VSS CLKBUF_X3
X_20138_ _14879_ _10813_ _10814_ VDD VSS NOR2_X1
X_20139_ _10497_ _10575_ _10815_ VDD VSS NAND2_X1
X_20140_ _10814_ _10815_ _10813_ _10816_ VDD VSS AOI21_X1
X_20141_ _10521_ _10588_ _10817_ VDD VSS NAND2_X1
X_20142_ _10597_ _10813_ _10763_ _10818_ VDD VSS AOI21_X1
X_20143_ _10697_ _10695_ _14859_ _10819_ VDD VSS OAI21_X1
X_20144_ _10818_ _10819_ _10813_ _10820_ VDD VSS OAI21_X1
X_20145_ _10615_ _10583_ _10584_ _10821_ VDD VSS NAND3_X2
X_20146_ _10695_ _10756_ _10821_ _10822_ VDD VSS NAND3_X1
X_20147_ _10591_ _10735_ _10655_ _10823_ VDD VSS MUX2_X1
X_20148_ _10822_ _10823_ _14883_ _10824_ VDD VSS OAI21_X1
X_20149_ _10820_ _10824_ _10689_ _10825_ VDD VSS OAI21_X1
X_20150_ _10812_ _10816_ _10817_ _10825_ _10521_ _10826_ VDD
+ VSS OAI221_X1
X_20151_ _10620_ _10585_ _10827_ VDD VSS NAND2_X1
X_20152_ _10817_ _10827_ _10672_ _10642_ _10730_ _10828_ VDD
+ VSS AOI221_X2
X_20153_ _10511_ _10719_ _10828_ _10829_ VDD VSS NOR3_X1
X_20154_ _10640_ _10568_ _10569_ _10830_ VDD VSS OAI21_X4
X_20155_ _10585_ _10830_ _10831_ VDD VSS AND2_X1
X_20156_ _10797_ _10680_ _10668_ _10832_ VDD VSS AOI21_X1
X_20157_ _10831_ _10832_ _10499_ _10833_ VDD VSS MUX2_X1
X_20158_ _10817_ _10729_ _10833_ _10834_ VDD VSS OAI21_X1
X_20159_ _10620_ _10693_ _10835_ VDD VSS AND2_X2
X_20160_ _14883_ _10835_ _10836_ VDD VSS NOR2_X1
X_20161_ _10582_ _10599_ _10837_ VDD VSS NAND2_X1
X_20162_ _10623_ _10837_ _10705_ _10838_ VDD VSS AOI21_X1
X_20163_ _10695_ _10754_ _10723_ _10839_ VDD VSS NOR3_X1
X_20164_ _10631_ _10806_ _10756_ _10840_ VDD VSS AOI21_X1
X_20165_ _10627_ _10836_ _10838_ _10839_ _10840_ _10597_ _10841_
+ VDD VSS OAI33_X1
X_20166_ _10829_ _10834_ _10841_ _10842_ VDD VSS OAI21_X1
X_20167_ _10716_ _10719_ _10843_ VDD VSS NOR2_X1
X_20168_ _10654_ _10690_ _10844_ VDD VSS OR2_X1
X_20169_ _10591_ _10583_ _10584_ _10845_ VDD VSS NAND3_X2
X_20170_ _10497_ _10845_ _10846_ VDD VSS AND2_X1
X_20171_ _10582_ _14865_ _10847_ VDD VSS NOR2_X2
X_20172_ _10728_ _10847_ _10788_ _10848_ VDD VSS AOI21_X1
X_20173_ _10589_ _10844_ _10846_ _10848_ _10631_ _10849_ VDD
+ VSS AOI221_X2
X_20174_ _10501_ _10756_ _10821_ _10850_ VDD VSS NAND3_X1
X_20175_ _10496_ _10618_ _10619_ _10851_ VDD VSS OAI21_X4
X_20176_ _10850_ _10851_ _10609_ _10852_ VDD VSS OAI21_X1
X_20177_ _10521_ _10598_ _10852_ _10853_ VDD VSS OAI21_X1
X_20178_ _10668_ _10501_ _10620_ _10854_ VDD VSS NAND3_X1
X_20179_ _10735_ _10788_ _10855_ VDD VSS NAND2_X1
X_20180_ _10500_ _10599_ _10452_ _10856_ VDD VSS MUX2_X1
X_20181_ _10854_ _10855_ _10635_ _10707_ _10856_ _10857_ VDD
+ VSS OAI221_X2
X_20182_ _10500_ _10575_ _10858_ VDD VSS NAND2_X1
X_20183_ _10655_ _10704_ _10859_ VDD VSS NOR2_X1
X_20184_ _14881_ _10632_ _10858_ _10859_ _10860_ VDD VSS AOI22_X1
X_20185_ _10857_ _10860_ _10689_ _10861_ VDD VSS MUX2_X1
X_20186_ _10843_ _10849_ _10853_ _10861_ _10521_ _10862_ VDD
+ VSS OAI221_X1
X_20187_ _10809_ _10826_ _10842_ _10862_ _00050_ VDD VSS AND4_X2
X_20188_ _14862_ _14865_ _10863_ VDD VSS OR2_X1
X_20189_ _10564_ _10863_ _10494_ _10864_ VDD VSS MUX2_X1
X_20190_ _10532_ _10546_ _10660_ _10864_ _10865_ VDD VSS AOI211_X2
X_20191_ _10521_ _10865_ _10762_ _10866_ VDD VSS AOI21_X1
X_20192_ _14858_ _10622_ _10705_ _10867_ VDD VSS AOI21_X1
X_20193_ _10653_ _10650_ net629 _10616_ _10613_ _10868_ VDD
+ VSS OAI221_X1
X_20194_ _10622_ _10532_ _10585_ _10869_ VDD VSS OAI21_X1
X_20195_ _10830_ _10576_ _10601_ _10870_ VDD VSS OAI21_X1
X_20196_ _10869_ _10870_ _10533_ _10871_ VDD VSS AOI21_X1
X_20197_ net148 _10599_ _10620_ _10645_ _10872_ VDD VSS OAI22_X1
X_20198_ _10606_ _10872_ _10501_ _10873_ VDD VSS OAI21_X1
X_20199_ _10866_ _10867_ _10868_ _10871_ _10873_ _10874_ VDD
+ VSS OAI221_X1
X_20200_ _10494_ _10558_ _10562_ _10875_ VDD VSS NAND3_X2
X_20201_ _10851_ _10875_ _10876_ VDD VSS NAND2_X1
X_20202_ _10640_ _10876_ _10877_ VDD VSS NOR2_X1
X_20203_ _10533_ _10788_ _10656_ _10878_ VDD VSS OAI21_X1
X_20204_ _10498_ _10731_ _10683_ _10879_ VDD VSS OAI21_X2
X_20205_ _10847_ _10619_ _10618_ _10880_ VDD VSS OAI21_X1
X_20206_ _10880_ _10599_ _10602_ _10881_ VDD VSS OAI21_X1
X_20207_ _10879_ _10881_ _10499_ _10882_ VDD VSS OAI21_X1
X_20208_ _10714_ _10877_ _10878_ _10882_ _10595_ _10883_ VDD
+ VSS OAI221_X1
X_20209_ _10735_ _10711_ _10884_ VDD VSS NAND2_X1
X_20210_ _10591_ _10618_ _10619_ _10885_ VDD VSS NOR3_X1
X_20211_ _10657_ _10723_ _10885_ _10886_ VDD VSS OAI21_X1
X_20212_ _10533_ _10884_ _10886_ _10887_ VDD VSS AOI21_X1
X_20213_ _10707_ _10533_ _10654_ _10888_ VDD VSS NAND3_X1
X_20214_ _10657_ _10837_ _10888_ _10889_ VDD VSS AOI21_X1
X_20215_ _10767_ _10887_ _10889_ _10890_ VDD VSS OAI21_X1
X_20216_ _10716_ _10874_ _10883_ _10890_ _10891_ VDD VSS AND4_X2
X_20217_ _10532_ _10596_ _10892_ VDD VSS NOR2_X2
X_20218_ _10614_ _10697_ _10743_ _10892_ _10893_ VDD VSS AND4_X1
X_20219_ _10532_ _10588_ _10894_ VDD VSS NOR2_X2
X_20220_ _10501_ _10806_ _10677_ _10895_ VDD VSS AOI21_X1
X_20221_ _10708_ _10788_ _10735_ _10896_ VDD VSS AOI21_X1
X_20222_ _10895_ _10896_ _10623_ _10897_ VDD VSS AOI21_X1
X_20223_ _10893_ _10894_ _10897_ _10898_ VDD VSS AOI21_X1
X_20224_ _10710_ _10835_ _10657_ _10655_ _10697_ _10899_ VDD
+ VSS OAI221_X1
X_20225_ _10629_ _10614_ _10592_ _10650_ _10603_ _10900_ VDD
+ VSS OAI221_X1
X_20226_ _14858_ _10563_ _10635_ _10607_ _10901_ VDD VSS AOI22_X1
X_20227_ _14859_ _10901_ _10902_ VDD VSS NOR2_X1
X_20228_ _10595_ _10899_ _10629_ _10900_ _10902_ _10903_ VDD
+ VSS OAI221_X1
X_20229_ _10628_ _10903_ _10898_ _10904_ VDD VSS AOI21_X1
X_20230_ _10708_ _10600_ _10730_ _10905_ VDD VSS AOI21_X1
X_20231_ _14876_ _10905_ _10906_ VDD VSS NAND2_X1
X_20232_ _10609_ _10788_ _10907_ VDD VSS NAND2_X1
X_20233_ _10695_ _10907_ _10705_ _10908_ VDD VSS NAND3_X1
X_20234_ _10686_ _10906_ _10908_ _10909_ VDD VSS AOI21_X1
X_20235_ _10616_ _10600_ _10910_ VDD VSS NAND2_X1
X_20236_ _14876_ _10845_ _10910_ _10911_ VDD VSS NAND3_X1
X_20237_ _10695_ _10683_ _10723_ _10912_ VDD VSS OAI21_X1
X_20238_ _10686_ _10911_ _10912_ _10913_ VDD VSS AOI21_X1
X_20239_ _10598_ _10656_ _10534_ _10914_ VDD VSS OAI21_X1
X_20240_ _10598_ _10909_ _10913_ _10914_ _10915_ VDD VSS OAI22_X2
X_20241_ _10668_ _10589_ _10916_ VDD VSS NAND2_X1
X_20242_ _10602_ _10498_ _10917_ VDD VSS NOR2_X1
X_20243_ _10754_ _10917_ _10918_ VDD VSS NOR2_X1
X_20244_ _10735_ _10606_ _10697_ _10622_ _10919_ VDD VSS AOI22_X1
X_20245_ _10686_ _10916_ _10918_ _10919_ _10600_ _10920_ VDD
+ VSS OAI221_X1
X_20246_ _10668_ _10622_ _10596_ _10921_ VDD VSS MUX2_X1
X_20247_ _10597_ _10706_ _10921_ _10603_ _10922_ VDD VSS OAI22_X1
X_20248_ _10920_ _10922_ _10764_ _10923_ VDD VSS AOI21_X1
X_20249_ _10522_ _10923_ _10924_ VDD VSS NOR2_X1
X_20250_ _10904_ _10891_ _10915_ _10924_ _00051_ VDD VSS AOI211_X2
X_20251_ _10668_ _10754_ _10925_ VDD VSS NAND2_X1
X_20252_ _10646_ _10788_ _10635_ _10926_ VDD VSS NAND3_X1
X_20253_ _10597_ _10925_ _10701_ _10926_ _10927_ VDD VSS NAND4_X1
X_20254_ _10650_ _10614_ _10646_ _10928_ VDD VSS OAI21_X1
X_20255_ _10830_ _10764_ _10646_ _10929_ VDD VSS OAI21_X1
X_20256_ _10927_ _10928_ _14859_ _14883_ _10929_ _10930_ VDD
+ VSS AOI221_X1
X_20257_ _10582_ _10690_ _10660_ _10931_ VDD VSS MUX2_X1
X_20258_ _10498_ _10533_ _10596_ _10932_ VDD VSS NAND3_X1
X_20259_ _10730_ _10590_ _10585_ _10622_ _10933_ VDD VSS AOI22_X1
X_20260_ _10645_ _10588_ _10934_ VDD VSS NAND2_X1
X_20261_ _10666_ _10931_ _10932_ _10933_ _10934_ _10935_ VDD
+ VSS OAI221_X2
X_20262_ _10645_ _10546_ _10936_ VDD VSS NAND2_X2
X_20263_ _10936_ _10769_ _10499_ _10937_ VDD VSS AOI21_X1
X_20264_ _10501_ _10907_ _10821_ _10938_ VDD VSS NAND3_X1
X_20265_ _10707_ net147 _10500_ _10939_ VDD VSS MUX2_X1
X_20266_ _10646_ _10632_ _10939_ _10940_ VDD VSS AOI21_X1
X_20267_ _10935_ _10937_ _10938_ _10639_ _10940_ _10941_ VDD
+ VSS AOI221_X1
X_20268_ _10941_ _10930_ _10942_ VDD VSS NOR2_X1
X_20269_ _10680_ _10858_ _10706_ _10943_ VDD VSS NAND3_X1
X_20270_ _10589_ _10607_ _10802_ _10944_ VDD VSS AOI21_X2
X_20271_ _10616_ _10498_ _10945_ VDD VSS NOR2_X1
X_20272_ _10680_ _10672_ _10945_ _10946_ VDD VSS OAI21_X1
X_20273_ _10595_ _10943_ _10944_ _10946_ _10612_ _10947_ VDD
+ VSS AOI221_X2
X_20274_ _10576_ _10575_ _10948_ VDD VSS NAND2_X2
X_20275_ _10596_ _10797_ _10949_ VDD VSS NOR2_X1
X_20276_ _10948_ _10949_ _10950_ VDD VSS NAND2_X1
X_20277_ _10657_ _10606_ net682 _10951_ VDD VSS AOI21_X1
X_20278_ _10588_ _10660_ _10952_ VDD VSS NAND2_X1
X_20279_ _10596_ _10654_ _10953_ VDD VSS XNOR2_X1
X_20280_ _10738_ _10952_ net682 _10953_ _10603_ _10954_ VDD
+ VSS OAI221_X1
X_20281_ _10646_ _10950_ _10951_ _10954_ _10695_ _10955_ VDD
+ VSS AOI221_X2
X_20282_ _10627_ _10947_ _10955_ _10956_ VDD VSS NOR3_X2
X_20283_ _10892_ _10697_ _10632_ _14859_ _10876_ _10957_ VDD
+ VSS OAI221_X1
X_20284_ _10957_ _10635_ _10813_ _10958_ VDD VSS AOI21_X1
X_20285_ _10578_ _10660_ _10452_ _10959_ VDD VSS AOI21_X1
X_20286_ _10596_ _10821_ _10959_ _10622_ _14867_ _10960_ VDD
+ VSS AOI221_X1
X_20287_ _10564_ _10618_ _10619_ _10961_ VDD VSS OAI21_X2
X_20288_ _10570_ _10961_ _10499_ _10962_ VDD VSS AOI21_X1
X_20289_ _10595_ _10629_ _10962_ _10963_ VDD VSS OAI21_X1
X_20290_ _10894_ _10695_ _14864_ _10651_ _10851_ _10964_ VDD
+ VSS OAI221_X1
X_20291_ _10627_ _10960_ _10963_ _10964_ _10728_ _10965_ VDD
+ VSS OAI221_X1
X_20292_ _10511_ _10958_ _10965_ _10966_ VDD VSS OAI21_X1
X_20293_ _10689_ _10701_ _10967_ VDD VSS NAND2_X1
X_20294_ _10620_ _10821_ _10968_ VDD VSS AND2_X1
X_20295_ _10948_ _10875_ _10582_ _10968_ _14876_ _10969_ VDD
+ VSS OAI221_X1
X_20296_ _14872_ _10747_ _10764_ _10970_ VDD VSS MUX2_X1
X_20297_ _10969_ _10970_ _10534_ _10971_ VDD VSS MUX2_X1
X_20298_ _10942_ _10956_ _10966_ _10967_ _10971_ _00052_ VDD
+ VSS OAI221_X2
X_20299_ _10735_ _10585_ _10972_ VDD VSS NOR2_X1
X_20300_ _10972_ _10875_ _14867_ _10973_ VDD VSS AOI21_X1
X_20301_ _10595_ _10629_ _10974_ VDD VSS NAND2_X1
X_20302_ _10666_ _10973_ _10974_ _10975_ VDD VSS OAI21_X1
X_20303_ _10532_ _10596_ _10976_ VDD VSS NAND2_X1
X_20304_ _10564_ _10497_ _10977_ VDD VSS NAND2_X1
X_20305_ _10815_ _10498_ _10602_ _10978_ VDD VSS OAI21_X1
X_20306_ _10976_ _10661_ _10977_ _10978_ _10680_ _10979_ VDD
+ VSS AOI221_X2
X_20307_ _10609_ _10578_ _10980_ VDD VSS NOR2_X1
X_20308_ _10581_ _10635_ _10980_ _10981_ VDD VSS OAI21_X1
X_20309_ _10797_ _10599_ _10591_ _10982_ VDD VSS AOI21_X1
X_20310_ _10498_ _10982_ _10983_ VDD VSS NAND2_X1
X_20311_ _10588_ _10691_ _10500_ _10984_ VDD VSS AOI21_X1
X_20312_ _10533_ _10639_ _10981_ _10983_ _10984_ _10985_ VDD
+ VSS AOI221_X1
X_20313_ _10975_ _10979_ _10985_ _10986_ VDD VSS NOR3_X1
X_20314_ _10720_ _10987_ VDD VSS INV_X1
X_20315_ _10673_ _10802_ _10599_ _10988_ VDD VSS AOI21_X1
X_20316_ _10729_ _10590_ net682 net147 _10660_ _10989_ VDD
+ VSS AOI221_X2
X_20317_ _10645_ _10987_ _10988_ _10989_ _10587_ _10990_ VDD
+ VSS AOI221_X2
X_20318_ _10452_ _10875_ _10952_ _10991_ VDD VSS AOI21_X1
X_20319_ _10592_ _10851_ _10875_ _14867_ _10992_ VDD VSS OAI22_X1
X_20320_ net629 _10596_ _10581_ _10993_ VDD VSS NAND3_X1
X_20321_ _10576_ _10613_ _10546_ _10994_ VDD VSS MUX2_X1
X_20322_ _10993_ _10994_ net629 _10995_ VDD VSS OAI21_X1
X_20323_ _10991_ _10992_ _10606_ _14867_ _10995_ _10996_ VDD
+ VSS AOI221_X1
X_20324_ _10990_ _10996_ _10627_ _10997_ VDD VSS OAI21_X2
X_20325_ _10601_ _14862_ _10580_ _10998_ VDD VSS MUX2_X1
X_20326_ _10626_ _10711_ net630 _10998_ _10496_ _10999_ VDD
+ VSS AOI221_X1
X_20327_ _10948_ _10724_ _10497_ _11000_ VDD VSS OAI21_X1
X_20328_ _10999_ _11000_ _10626_ _11001_ VDD VSS AOI21_X1
X_20329_ _10473_ _10563_ _10870_ _10578_ _11002_ VDD VSS AOI22_X1
X_20330_ _10730_ _10615_ _10576_ _11003_ VDD VSS MUX2_X1
X_20331_ _10602_ _10613_ _11003_ _10578_ _11004_ VDD VSS OAI22_X1
X_20332_ _11002_ _11004_ _10521_ _11005_ VDD VSS MUX2_X1
X_20333_ _10716_ _10894_ _11001_ _11005_ _10892_ _11006_ VDD
+ VSS AOI221_X2
X_20334_ _10595_ _10678_ _10772_ _10880_ _10499_ _11007_ VDD
+ VSS OAI221_X1
X_20335_ _10646_ _10656_ _10678_ _10632_ _10592_ _11008_ VDD
+ VSS OAI221_X1
X_20336_ _10598_ _11007_ _11008_ _11009_ VDD VSS AOI21_X1
X_20337_ net148 _10851_ _10980_ _10764_ _11010_ VDD VSS OAI22_X1
X_20338_ _10689_ _11010_ _10534_ _11011_ VDD VSS AOI21_X1
X_20339_ _10623_ _10693_ _10756_ _11012_ VDD VSS NAND3_X1
X_20340_ _10686_ _10983_ _11012_ _11013_ VDD VSS NAND3_X1
X_20341_ _11009_ _11011_ _11013_ _11014_ VDD VSS AOI21_X1
X_20342_ _10986_ _11006_ _10997_ _11014_ _10701_ _00053_ VDD
+ VSS AOI221_X2
X_20343_ _14877_ _14886_ _10600_ _11015_ VDD VSS NOR3_X1
X_20344_ _10586_ _10500_ _11016_ VDD VSS NAND2_X1
X_20345_ _11015_ _11016_ _10721_ _11017_ VDD VSS AOI21_X1
X_20346_ _10631_ _10585_ _10961_ _11018_ VDD VSS AND3_X1
X_20347_ _10603_ _10847_ _10680_ _11019_ VDD VSS MUX2_X1
X_20348_ _11018_ _11019_ _14883_ _11020_ VDD VSS AOI21_X1
X_20349_ _10974_ _11017_ _11020_ _10936_ _11021_ VDD VSS OAI22_X1
X_20350_ _10961_ _10660_ _10615_ _11022_ VDD VSS OAI21_X1
X_20351_ _10976_ _11022_ _10500_ _10563_ _10582_ _11023_ VDD
+ VSS AOI221_X1
X_20352_ _10578_ _10690_ _11024_ VDD VSS OR2_X1
X_20353_ _10581_ _10671_ _11025_ VDD VSS NOR2_X1
X_20354_ _14874_ _10564_ _10496_ _11026_ VDD VSS MUX2_X1
X_20355_ _10934_ _11024_ _11025_ _11026_ _10607_ _11027_ VDD
+ VSS AOI221_X1
X_20356_ _10628_ _11023_ _11027_ _11028_ VDD VSS OR3_X1
X_20357_ _11021_ _11028_ _11029_ VDD VSS OR2_X1
X_20358_ _10716_ _10627_ _11030_ VDD VSS NOR2_X1
X_20359_ _10622_ _10570_ _11031_ VDD VSS NOR2_X1
X_20360_ _10597_ _10948_ _11031_ _10896_ _10631_ _11032_ VDD
+ VSS AOI221_X1
X_20361_ _10597_ _10813_ _14879_ _11033_ VDD VSS OAI21_X1
X_20362_ _10764_ _10917_ _11034_ VDD VSS NOR2_X1
X_20363_ _11033_ _11034_ _10815_ _11035_ VDD VSS AOI21_X1
X_20364_ _10719_ _11032_ _11035_ _11036_ VDD VSS NOR3_X1
X_20365_ _10498_ _10654_ _10847_ _11037_ VDD VSS AOI21_X1
X_20366_ _10499_ _10835_ _11037_ _10948_ _11038_ VDD VSS AOI22_X1
X_20367_ _10600_ _10635_ _14859_ _11039_ VDD VSS OAI21_X1
X_20368_ _10595_ _10714_ _11038_ _11039_ _10593_ _11040_ VDD
+ VSS AOI221_X1
X_20369_ _11030_ _11036_ _11040_ _11041_ VDD VSS OAI21_X1
X_20370_ _10623_ _10845_ _10830_ _11042_ VDD VSS AOI21_X1
X_20371_ _10597_ _10614_ _14864_ _11043_ VDD VSS OAI21_X1
X_20372_ _11042_ _11043_ _11044_ VDD VSS OR2_X1
X_20373_ _10719_ _10795_ _11044_ _11045_ VDD VSS NAND3_X1
X_20374_ _10879_ _10614_ _10603_ _11046_ VDD VSS OAI21_X1
X_20375_ _14878_ _10764_ _10661_ _10977_ _11047_ VDD VSS AOI22_X1
X_20376_ _11046_ _11047_ _10689_ _11048_ VDD VSS MUX2_X1
X_20377_ _10701_ _11045_ _11048_ _10719_ _11049_ VDD VSS OAI211_X2
X_20378_ _10521_ _10534_ _11050_ VDD VSS NOR2_X1
X_20379_ _14859_ _10597_ _11051_ VDD VSS NAND2_X1
X_20380_ _14883_ _10630_ _11051_ _11052_ VDD VSS AND3_X1
X_20381_ _10640_ _10588_ _11053_ VDD VSS NAND2_X1
X_20382_ _10606_ _10788_ _11054_ VDD VSS NOR2_X1
X_20383_ _10657_ _10788_ _11053_ _11054_ _10603_ _11055_ VDD
+ VSS AOI221_X1
X_20384_ _11050_ _11052_ _11055_ _10689_ _10727_ _11056_ VDD
+ VSS OAI221_X1
X_20385_ _14864_ _14858_ _10629_ _11057_ VDD VSS NAND3_X1
X_20386_ _10623_ _10629_ _10797_ _11058_ VDD VSS OAI21_X1
X_20387_ _11057_ _10952_ _10656_ _14859_ _11058_ _11059_ VDD
+ VSS OAI221_X1
X_20388_ _10683_ _10610_ _14859_ _11060_ VDD VSS AOI21_X1
X_20389_ _10743_ _11060_ net148 _10813_ _10697_ _11061_ VDD
+ VSS OAI221_X1
X_20390_ _10534_ _11059_ _11061_ _10647_ _11062_ VDD VSS AOI22_X1
X_20391_ _10666_ _11056_ _11062_ _11063_ VDD VSS NAND3_X1
X_20392_ _11041_ _11029_ _11049_ _11063_ _00054_ VDD VSS NAND4_X1
X_20393_ _10588_ _10642_ _10615_ _10590_ _14858_ _11064_ VDD
+ VSS AOI221_X2
X_20394_ _10585_ _10851_ _14858_ _11065_ VDD VSS OAI21_X1
X_20395_ _10668_ _11065_ _11066_ VDD VSS NAND2_X1
X_20396_ _10631_ _10669_ _10797_ _11067_ VDD VSS OAI21_X1
X_20397_ _10606_ _10563_ _10640_ _11068_ VDD VSS AOI21_X1
X_20398_ _10686_ _11064_ _11066_ _11067_ _11068_ _11069_ VDD
+ VSS AOI221_X2
X_20399_ _10813_ _11026_ _11070_ VDD VSS NAND2_X1
X_20400_ _10764_ _10635_ _10672_ _11071_ VDD VSS OAI21_X1
X_20401_ _10892_ _11070_ _11071_ _11072_ VDD VSS NAND3_X1
X_20402_ _10730_ _10642_ _10590_ _14858_ _10876_ _10707_ _11073_
+ VDD VSS AOI222_X2
X_20403_ _11072_ _11073_ _10936_ _11074_ VDD VSS OAI21_X1
X_20404_ _10666_ _11069_ _11074_ _11075_ VDD VSS OAI21_X1
X_20405_ _10701_ _11076_ VDD VSS INV_X1
X_20406_ _10668_ _10620_ _10650_ _11077_ VDD VSS AOI21_X1
X_20407_ _10629_ _10972_ _11077_ _11078_ VDD VSS OAI21_X1
X_20408_ _10851_ _10656_ _10788_ _11079_ VDD VSS OAI21_X1
X_20409_ _10727_ _10613_ _14867_ _11080_ VDD VSS OAI21_X1
X_20410_ _14864_ _11079_ _11080_ _10606_ _11081_ VDD VSS AOI22_X1
X_20411_ _10686_ _11078_ _11081_ _11082_ VDD VSS AOI21_X1
X_20412_ _10501_ _10693_ _10844_ _10892_ _11083_ VDD VSS AND4_X1
X_20413_ _10642_ _10590_ _10473_ _11084_ VDD VSS MUX2_X1
X_20414_ _10936_ _11084_ _10452_ _10711_ _10602_ _11085_ VDD
+ VSS AOI221_X1
X_20415_ _11076_ _11082_ _11083_ _11085_ _11086_ VDD VSS OR4_X1
X_20416_ _10582_ _10657_ _10583_ _10584_ _11087_ VDD VSS NAND4_X1
X_20417_ _11087_ _10632_ _14872_ _11088_ VDD VSS OAI21_X1
X_20418_ _10522_ _10653_ _11088_ _11089_ VDD VSS AOI21_X1
X_20419_ net147 _10668_ _10657_ _11090_ VDD VSS MUX2_X1
X_20420_ _10647_ _10678_ _10635_ _11090_ _10813_ _11091_ VDD
+ VSS OAI221_X1
X_20421_ _11089_ _11091_ _11092_ VDD VSS AND2_X1
X_20422_ _14886_ _10655_ _11093_ VDD VSS NOR2_X1
X_20423_ _10600_ _10641_ _10704_ _11094_ VDD VSS NOR3_X1
X_20424_ _10934_ _11093_ _11094_ _11095_ VDD VSS NOR3_X1
X_20425_ _10723_ _10632_ _14864_ _11096_ VDD VSS AOI21_X1
X_20426_ _10784_ _11096_ _14883_ _11097_ VDD VSS OAI21_X1
X_20427_ _11095_ _11097_ _10894_ _11098_ VDD VSS AOI21_X1
X_20428_ _14876_ _10570_ _10781_ _11099_ VDD VSS NOR3_X1
X_20429_ _10689_ _10945_ _11099_ _11100_ VDD VSS OAI21_X1
X_20430_ _10589_ _10721_ _11016_ _10607_ _10609_ _11101_ VDD
+ VSS AOI221_X1
X_20431_ _10534_ _10628_ _11101_ _11102_ VDD VSS NOR3_X1
X_20432_ _11092_ _11098_ _11100_ _11102_ _11103_ VDD VSS AOI22_X1
X_20433_ _14876_ _10585_ _10961_ _11104_ VDD VSS AOI21_X1
X_20434_ _10705_ _10847_ _10614_ _11105_ VDD VSS OAI21_X1
X_20435_ _10598_ _11104_ _11105_ _11106_ VDD VSS OAI21_X1
X_20436_ _10695_ _10813_ _10591_ _11107_ VDD VSS OAI21_X1
X_20437_ _10689_ _10691_ _11107_ _10757_ _14883_ _11108_ VDD
+ VSS OAI221_X2
X_20438_ _10719_ _10628_ _11109_ VDD VSS NOR2_X1
X_20439_ _11106_ _11108_ _11109_ _11110_ VDD VSS NAND3_X1
X_20440_ _11075_ _11086_ _11103_ _11110_ _00055_ VDD VSS AND4_X1
X_20441_ _06619_ _11111_ VDD VSS INV_X1
X_20442_ _11111_ _08994_ _11112_ VDD VSS NOR2_X1
X_20443_ _06619_ _08994_ _11113_ VDD VSS NOR2_X1
Xrebuffer252 net725 net717 VDD VSS BUF_X8
Xclone92 _15293_ net92 VDD VSS BUF_X2
Xsplit88 _14738_ net88 VDD VSS CLKBUF_X2
X_20447_ sa10_sub\[0\] sa03_sr\[0\] _11117_ VDD VSS XNOR2_X2
X_20448_ sa10_sub\[1\] _11117_ _11118_ VDD VSS XNOR2_X2
X_20449_ sa03_sr\[7\] _11119_ VDD VSS BUF_X8
X_20450_ sa10_sub\[7\] _11120_ VDD VSS BUF_X8
X_20451_ _11120_ _11119_ _11121_ VDD VSS XNOR2_X2
X_20452_ sa21_sub\[1\] _11122_ VDD VSS BUF_X4
X_20453_ sa32_sub\[1\] _11122_ _11123_ VDD VSS XNOR2_X2
X_20454_ _11121_ _11123_ _11124_ VDD VSS XNOR2_X2
X_20455_ _11118_ _11124_ _11125_ VDD VSS XNOR2_X2
X_20456_ _11112_ _11113_ _11125_ _11126_ VDD VSS MUX2_X2
X_20457_ _06619_ _09728_ _00449_ _11127_ VDD VSS NAND3_X1
X_20458_ _11111_ _09730_ _11128_ VDD VSS NAND2_X1
X_20459_ _11127_ _11128_ _00449_ _11129_ VDD VSS OAI21_X4
X_20460_ _11129_ _11126_ _11130_ VDD VSS NOR2_X4
X_20461_ net657 _11131_ VDD VSS INV_X32
Xrebuffer180 _11130_ net645 VDD VSS BUF_X1
Xclone229 net849 net838 VDD VSS INV_X8
Xrebuffer238 _11130_ net842 VDD VSS BUF_X4
Xclone239 net849 net843 VDD VSS INV_X16
Xrebuffer254 sa10_sub\[1\] net719 VDD VSS BUF_X1
X_20467_ sa21_sub\[0\] _11136_ VDD VSS BUF_X4
X_20468_ sa10_sub\[0\] _11136_ _11137_ VDD VSS XNOR2_X2
X_20469_ sa32_sub\[0\] _11137_ _11138_ VDD VSS XNOR2_X1
X_20470_ _11119_ _11120_ _11139_ VDD VSS XOR2_X2
X_20471_ net736 _09023_ _11139_ _11140_ VDD VSS NAND3_X1
X_20472_ _06602_ _09027_ _11141_ VDD VSS NOR2_X1
X_20473_ _11121_ _11141_ _11142_ VDD VSS NAND2_X1
X_20474_ _11138_ _11140_ _11142_ _11143_ VDD VSS AOI21_X1
X_20475_ sa10_sub\[0\] _11136_ _11144_ VDD VSS XOR2_X2
X_20476_ net721 _11144_ _11145_ VDD VSS XNOR2_X1
X_20477_ _11139_ _11141_ _11146_ VDD VSS NAND2_X1
X_20478_ net736 _09074_ _11121_ _11147_ VDD VSS NAND3_X1
X_20479_ _11145_ _11146_ _11147_ _11148_ VDD VSS AOI21_X1
X_20480_ net736 _11149_ VDD VSS INV_X1
X_20481_ _11149_ _08973_ _00450_ _11150_ VDD VSS NAND3_X1
X_20482_ net736 _09727_ _11151_ VDD VSS NAND2_X1
X_20483_ _11150_ _11151_ _00450_ _11152_ VDD VSS OAI21_X1
X_20484_ _11143_ _11148_ _11152_ _11153_ VDD VSS OR3_X2
X_20485_ _11153_ _11154_ VDD VSS INV_X2
X_20486_ _11154_ _11155_ VDD VSS BUF_X4
X_20487_ _11155_ _14899_ VDD VSS BUF_X4
X_20488_ _06635_ _11156_ VDD VSS INV_X2
X_20489_ _11156_ net1000 _00451_ _11157_ VDD VSS NOR3_X1
X_20490_ sa10_sub\[2\] _11158_ VDD VSS BUF_X4
X_20491_ sa21_sub\[2\] _11159_ VDD VSS BUF_X4
X_20492_ _11158_ _11159_ _11160_ VDD VSS XNOR2_X2
X_20493_ _11156_ _08992_ _11160_ _11161_ VDD VSS NOR3_X1
X_20494_ _11158_ _11159_ _11162_ VDD VSS XOR2_X2
X_20495_ _11156_ _08992_ _11162_ _11163_ VDD VSS NOR3_X1
X_20496_ sa32_sub\[2\] _11164_ VDD VSS CLKBUF_X3
X_20497_ sa03_sr\[1\] _11165_ VDD VSS CLKBUF_X3
X_20498_ sa10_sub\[1\] _11165_ _11166_ VDD VSS XNOR2_X2
X_20499_ _11164_ net723 _11167_ VDD VSS XNOR2_X2
X_20500_ _11161_ _11163_ _11167_ _11168_ VDD VSS MUX2_X1
X_20501_ _09022_ _11162_ _11169_ VDD VSS NAND2_X1
X_20502_ _09022_ _11160_ _11170_ VDD VSS NAND2_X1
X_20503_ _11169_ _11170_ _11167_ _11171_ VDD VSS MUX2_X1
X_20504_ net1000 _00451_ _11172_ VDD VSS NOR2_X1
X_20505_ _06635_ _11172_ _11173_ VDD VSS NOR2_X1
X_20506_ _11157_ _11168_ _11171_ _11173_ _11174_ VDD VSS AOI211_X2
X_20507_ _11174_ _11175_ VDD VSS INV_X2
X_20508_ _11175_ _11176_ VDD VSS BUF_X4
X_20509_ _11176_ _11177_ VDD VSS CLKBUF_X3
X_20510_ _11177_ _11178_ VDD VSS BUF_X4
X_20511_ _11178_ _14915_ VDD VSS BUF_X4
X_20512_ _11153_ _11179_ VDD VSS BUF_X8
X_20513_ _11179_ _14890_ VDD VSS BUF_X4
X_20514_ _11174_ _11180_ VDD VSS BUF_X4
X_20515_ _11180_ _11181_ VDD VSS BUF_X4
X_20516_ _11181_ _11182_ VDD VSS BUF_X4
X_20517_ _11182_ _14908_ VDD VSS BUF_X4
X_20518_ sa21_sub\[7\] _11183_ VDD VSS BUF_X8
X_20519_ sa32_sub\[7\] _11184_ VDD VSS BUF_X8
X_20520_ _11184_ _11183_ _11185_ VDD VSS XNOR2_X2
X_20521_ sa10_sub\[6\] _11186_ VDD VSS CLKBUF_X3
X_20522_ sa03_sr\[6\] _11187_ VDD VSS BUF_X2
X_20523_ _11186_ _11187_ _11188_ VDD VSS XNOR2_X1
X_20524_ net815 _11188_ _11189_ VDD VSS XNOR2_X1
X_20525_ _11120_ _11189_ _11190_ VDD VSS XNOR2_X1
X_20526_ _09856_ _11191_ VDD VSS BUF_X32
X_20527_ _11191_ _11192_ VDD VSS BUF_X8
X_20528_ text_in_r\[31\] _11190_ _11192_ _11193_ VDD VSS MUX2_X2
X_20529_ _06708_ _11193_ _11194_ VDD VSS XOR2_X2
X_20530_ _06699_ _11195_ VDD VSS INV_X1
X_20531_ _11195_ _09136_ _11196_ VDD VSS NOR2_X1
X_20532_ _06699_ _09136_ _11197_ VDD VSS NOR2_X1
X_20533_ sa32_sub\[6\] _11198_ VDD VSS CLKBUF_X3
X_20534_ sa21_sub\[6\] _11199_ VDD VSS BUF_X2
X_20535_ _11186_ _11199_ _11200_ VDD VSS XNOR2_X2
X_20536_ sa10_sub\[5\] _11201_ VDD VSS BUF_X2
X_20537_ sa03_sr\[5\] _11202_ VDD VSS CLKBUF_X3
X_20538_ _11201_ _11202_ _11203_ VDD VSS XNOR2_X2
X_20539_ _11200_ _11203_ _11204_ VDD VSS XNOR2_X1
X_20540_ _11198_ _11204_ _11205_ VDD VSS XNOR2_X1
X_20541_ _11196_ _11197_ _11205_ _11206_ VDD VSS MUX2_X2
X_20542_ _11192_ _11207_ VDD VSS BUF_X4
X_20543_ _11195_ _11207_ text_in_r\[30\] _11208_ VDD VSS NOR3_X4
X_20544_ _11195_ _09136_ text_in_r\[30\] _11209_ VDD VSS AND3_X1
X_20545_ _11206_ _11208_ _11209_ _11210_ VDD VSS NOR3_X4
X_20546_ _11194_ _11210_ _11211_ VDD VSS NOR2_X2
X_20547_ _11211_ _11212_ VDD VSS INV_X1
Xclone50 _06217_ net50 VDD VSS BUF_X4
X_20549_ _14897_ _11214_ VDD VSS BUF_X4
X_20550_ _11180_ _11215_ VDD VSS BUF_X4
X_20551_ _06654_ _08993_ _11216_ VDD VSS NOR2_X1
X_20552_ _06654_ _11217_ VDD VSS INV_X1
X_20553_ _11217_ _08993_ _11218_ VDD VSS NOR2_X1
X_20554_ sa03_sr\[2\] _11219_ VDD VSS BUF_X4
X_20555_ sa21_sub\[3\] _11220_ VDD VSS BUF_X2
X_20556_ _11219_ _11220_ _11221_ VDD VSS XNOR2_X1
X_20557_ _11119_ _11221_ _11222_ VDD VSS XNOR2_X2
X_20558_ sa10_sub\[3\] _11223_ VDD VSS BUF_X2
X_20559_ _11120_ _11223_ _11224_ VDD VSS XOR2_X2
X_20560_ sa32_sub\[3\] _11225_ VDD VSS BUF_X2
X_20561_ _11158_ _11225_ _11226_ VDD VSS XNOR2_X1
X_20562_ _11224_ _11226_ _11227_ VDD VSS XNOR2_X1
X_20563_ _11222_ _11227_ _11228_ VDD VSS XNOR2_X1
X_20564_ _11216_ _11218_ _11228_ _11229_ VDD VSS MUX2_X1
X_20565_ _11229_ _11230_ VDD VSS BUF_X8
X_20566_ _11230_ _11231_ VDD VSS BUF_X8
X_20567_ _11217_ net1000 text_in_r\[27\] _11232_ VDD VSS OR3_X2
X_20568_ _11217_ _09102_ text_in_r\[27\] _11233_ VDD VSS NAND3_X2
X_20569_ _11232_ _11233_ _11234_ VDD VSS NAND2_X4
X_20570_ _11234_ _11235_ VDD VSS BUF_X8
X_20571_ _11215_ _11231_ _11235_ _11236_ VDD VSS OAI21_X4
X_20572_ _11176_ _11237_ VDD VSS BUF_X4
X_20573_ _14890_ _11237_ _11238_ VDD VSS NAND2_X1
X_20574_ _11230_ _11234_ _11239_ VDD VSS NOR2_X4
X_20575_ net647 _11239_ _11240_ VDD VSS NOR2_X1
X_20576_ _11214_ _11236_ _11238_ _11240_ _11241_ VDD VSS OAI22_X1
X_20577_ _06670_ _11242_ VDD VSS INV_X1
X_20578_ _11242_ _11192_ _11243_ VDD VSS NAND2_X1
X_20579_ _06670_ _11192_ _11244_ VDD VSS NAND2_X1
X_20580_ sa03_sr\[3\] _11245_ VDD VSS BUF_X2
X_20581_ sa21_sub\[4\] _11246_ VDD VSS BUF_X4
X_20582_ _11245_ _11246_ _11247_ VDD VSS XNOR2_X1
X_20583_ _11119_ _11247_ _11248_ VDD VSS XNOR2_X2
X_20584_ sa10_sub\[4\] _11249_ VDD VSS CLKBUF_X3
X_20585_ sa32_sub\[4\] _11250_ VDD VSS CLKBUF_X3
X_20586_ _11249_ _11250_ _11251_ VDD VSS XNOR2_X1
X_20587_ _11224_ _11251_ _11252_ VDD VSS XNOR2_X2
X_20588_ _11248_ _11252_ _11253_ VDD VSS XNOR2_X2
X_20589_ _11243_ _11244_ _11253_ _11254_ VDD VSS MUX2_X2
X_20590_ _11242_ _09135_ text_in_r\[28\] _11255_ VDD VSS NAND3_X1
X_20591_ _06670_ _09818_ _11256_ VDD VSS NAND2_X1
X_20592_ _11255_ _11256_ text_in_r\[28\] _11257_ VDD VSS OAI21_X4
X_20593_ _11257_ _11258_ VDD VSS INV_X2
X_20594_ _11254_ _11258_ _11259_ VDD VSS NAND2_X4
X_20595_ net1084 text_in_r\[29\] _11260_ VDD VSS AND2_X1
X_20596_ sa21_sub\[5\] _11261_ VDD VSS CLKBUF_X3
X_20597_ sa32_sub\[5\] _11262_ VDD VSS CLKBUF_X3
X_20598_ _11261_ _11262_ _11263_ VDD VSS XNOR2_X2
X_20599_ _11249_ _11263_ _11264_ VDD VSS XNOR2_X2
X_20600_ sa03_sr\[4\] _11265_ VDD VSS CLKBUF_X3
X_20601_ _11265_ _11201_ _11266_ VDD VSS XNOR2_X1
X_20602_ _11264_ _11266_ _11267_ VDD VSS XNOR2_X2
X_20603_ _11260_ _11267_ _09076_ _11268_ VDD VSS AOI21_X4
X_20604_ _06685_ _11268_ _11269_ VDD VSS XOR2_X2
X_20605_ _11259_ _11269_ _11270_ VDD VSS NOR2_X2
X_20606_ _11212_ _11241_ _11270_ _11271_ VDD VSS AOI21_X1
X_20607_ _11154_ _11180_ _11272_ VDD VSS NOR2_X1
X_20608_ _11232_ _11233_ _11273_ VDD VSS AND2_X1
X_20609_ _11273_ _11274_ VDD VSS BUF_X4
X_20610_ _11217_ _09195_ _11275_ VDD VSS NAND2_X1
X_20611_ _06654_ _09195_ _11276_ VDD VSS NAND2_X1
X_20612_ _11275_ _11276_ _11228_ _11277_ VDD VSS MUX2_X1
X_20613_ _11277_ _11278_ VDD VSS BUF_X4
X_20614_ _11179_ _11175_ _11279_ VDD VSS NOR2_X4
X_20615_ _11272_ _11274_ _11278_ net843 _11279_ _11280_ VDD
+ VSS AOI221_X2
X_20616_ _11259_ _11280_ _11281_ VDD VSS NOR2_X2
X_20617_ net647 _11176_ _11282_ VDD VSS NAND2_X1
X_20618_ _14894_ _11283_ VDD VSS BUF_X4
X_20619_ _11282_ _14915_ net963 _11284_ VDD VSS OAI21_X1
X_20620_ _11278_ _11274_ _11285_ VDD VSS NAND2_X4
X_20621_ _11285_ _11286_ VDD VSS BUF_X4
X_20622_ _11286_ _11287_ VDD VSS CLKBUF_X3
X_20623_ _11281_ _11284_ _11287_ _11288_ VDD VSS OAI21_X1
X_20624_ _06685_ _11268_ _11289_ VDD VSS XNOR2_X2
X_20625_ _11289_ _11290_ VDD VSS BUF_X4
X_20626_ _11290_ _11291_ VDD VSS CLKBUF_X3
X_20627_ _11291_ _11292_ VDD VSS CLKBUF_X3
X_20628_ _06670_ _08996_ _11293_ VDD VSS NOR2_X1
X_20629_ _11242_ _08996_ _11294_ VDD VSS NOR2_X1
X_20630_ _11293_ _11294_ _11253_ _11295_ VDD VSS MUX2_X2
X_20631_ _11295_ _11257_ _11296_ VDD VSS NOR2_X4
X_20632_ _11296_ _11297_ VDD VSS BUF_X4
X_20633_ _11297_ _11298_ VDD VSS CLKBUF_X3
X_20634_ _11269_ _11299_ VDD VSS BUF_X4
X_20635_ _11299_ _11300_ VDD VSS CLKBUF_X3
X_20636_ net925 _11287_ _11301_ VDD VSS NOR2_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
X_20638_ _11239_ _11303_ VDD VSS CLKBUF_X3
X_20639_ _11303_ _11304_ VDD VSS BUF_X4
X_20640_ _14906_ net843 _11304_ _11305_ VDD VSS MUX2_X1
X_20641_ _11300_ _11301_ _11238_ _11305_ _14915_ _11306_ VDD
+ VSS OAI221_X1
X_20642_ _11179_ _11230_ _11234_ _11307_ VDD VSS NOR3_X4
X_20643_ _11130_ _11308_ VDD VSS BUF_X8
X_20644_ _14906_ net144 _11303_ _11309_ VDD VSS MUX2_X1
X_20645_ _11176_ _11278_ _11274_ _11310_ VDD VSS AOI21_X4
Xclone49 _07902_ net49 VDD VSS BUF_X8
X_20647_ net474 _11312_ VDD VSS BUF_X8
X_20648_ _11307_ _11309_ _11178_ _11310_ net650 _11313_ VDD
+ VSS AOI221_X2
X_20649_ _11306_ _11313_ _11300_ _11314_ VDD VSS OAI21_X1
X_20650_ _11271_ _11288_ _11292_ _11298_ _11314_ _11315_ VDD
+ VSS OAI221_X2
X_20651_ _11210_ _11316_ VDD VSS CLKBUF_X3
X_20652_ _11269_ _11317_ VDD VSS BUF_X4
X_20653_ _11317_ _11318_ VDD VSS CLKBUF_X3
X_20654_ _11259_ _11319_ VDD VSS BUF_X4
X_20655_ _14913_ _11319_ _11287_ _11320_ VDD VSS NAND3_X1
X_20656_ _11316_ _11318_ _11320_ _11321_ VDD VSS NAND3_X1
X_20657_ _14892_ _11322_ VDD VSS BUF_X4
X_20658_ _11155_ _11231_ _11235_ _11323_ VDD VSS OAI21_X4
X_20659_ _11283_ _11278_ _11274_ _11324_ VDD VSS NAND3_X2
X_20660_ _11323_ _11324_ _11325_ VDD VSS AND2_X1
X_20661_ _11215_ _11326_ VDD VSS BUF_X4
X_20662_ _11326_ _11327_ VDD VSS BUF_X4
X_20663_ _11322_ _11236_ _11325_ _11327_ _11328_ VDD VSS OAI22_X2
X_20664_ _11297_ _11329_ VDD VSS BUF_X4
X_20665_ _11304_ _11330_ VDD VSS BUF_X4
X_20666_ _11176_ _11331_ VDD VSS BUF_X4
X_20667_ _11331_ _11332_ VDD VSS CLKBUF_X3
X_20668_ _11332_ _11333_ VDD VSS CLKBUF_X3
X_20669_ net650 _11214_ _11296_ _11334_ VDD VSS MUX2_X1
X_20670_ net649 _14890_ _11335_ VDD VSS NAND2_X1
X_20671_ _11259_ _11336_ VDD VSS CLKBUF_X3
X_20672_ _11177_ _11336_ _11337_ VDD VSS NOR2_X1
X_20673_ _11333_ _11334_ _11335_ _11337_ _11338_ VDD VSS AOI22_X1
X_20674_ _11338_ _11339_ VDD VSS INV_X1
X_20675_ _11321_ _11328_ _11329_ _11330_ _11339_ _11340_ VDD
+ VSS AOI221_X2
X_20676_ _14900_ _11341_ VDD VSS CLKBUF_X3
X_20677_ _11341_ _11342_ VDD VSS INV_X2
X_20678_ _11342_ _11231_ _11235_ _11343_ VDD VSS OAI21_X2
X_20679_ net491 _11230_ _11234_ _11344_ VDD VSS NOR3_X4
X_20680_ net982 _11180_ _11345_ VDD VSS NOR2_X4
X_20681_ _11278_ _11346_ VDD VSS BUF_X4
X_20682_ _11274_ _11347_ VDD VSS BUF_X4
X_20683_ _11179_ _11346_ _11347_ _11348_ VDD VSS AOI21_X1
X_20684_ _11348_ _11303_ net144 _11349_ VDD VSS AOI21_X1
X_20685_ _11259_ _11343_ _11345_ _11349_ _11326_ _11350_ VDD
+ VSS AOI221_X2
X_20686_ _14897_ _11230_ _11234_ _11351_ VDD VSS OAI21_X4
X_20687_ _11180_ _11351_ _11352_ VDD VSS AND2_X4
X_20688_ _11180_ _11230_ _11234_ _11353_ VDD VSS NOR3_X1
X_20689_ _11353_ _11354_ VDD VSS CLKBUF_X3
X_20690_ _11296_ _11324_ _11352_ _11354_ _11322_ _11355_ VDD
+ VSS AOI221_X1
X_20691_ _11350_ _11355_ _11316_ _11318_ _11356_ VDD VSS OR4_X2
X_20692_ _11206_ _11208_ _11209_ _11357_ VDD VSS OR3_X4
X_20693_ _11357_ _11358_ VDD VSS BUF_X4
X_20694_ _11358_ _11299_ _11359_ VDD VSS NAND2_X1
X_20695_ _11154_ _11278_ _11274_ _11360_ VDD VSS AOI21_X2
X_20696_ _11360_ _11361_ VDD VSS CLKBUF_X3
X_20697_ _11296_ _11361_ _11362_ VDD VSS NAND2_X1
X_20698_ net509 _11230_ _11234_ _11363_ VDD VSS NOR3_X4
X_20699_ _14908_ net959 _11364_ VDD VSS NOR2_X1
X_20700_ _11359_ _11362_ _11364_ _11365_ VDD VSS AOI21_X1
X_20701_ net474 _11231_ _11235_ _11366_ VDD VSS OAI21_X4
X_20702_ _14902_ _11367_ VDD VSS BUF_X4
X_20703_ _11367_ _11368_ VDD VSS BUF_X4
X_20704_ _11368_ _11346_ _11347_ _11369_ VDD VSS NAND3_X2
X_20705_ _11333_ _11366_ _11369_ _11370_ VDD VSS AOI21_X1
X_20706_ _11298_ _11370_ _11371_ VDD VSS NOR2_X1
X_20707_ _11365_ _11371_ _11281_ _11372_ VDD VSS OAI21_X1
X_20708_ _11285_ _11373_ VDD VSS BUF_X4
X_20709_ _11373_ _11374_ VDD VSS CLKBUF_X3
X_20710_ _11179_ _11231_ _11235_ _11375_ VDD VSS OAI21_X4
X_20711_ _11308_ _11376_ VDD VSS BUF_X16
X_20712_ _11327_ _11374_ _11283_ _11375_ _11376_ _11377_ VDD
+ VSS OAI221_X1
X_20713_ _11180_ _11278_ _11274_ _11378_ VDD VSS AOI21_X4
X_20714_ _11368_ _11378_ _11379_ VDD VSS NAND2_X1
X_20715_ _11316_ _11270_ _11377_ _11379_ _11380_ VDD VSS NAND4_X1
X_20716_ _11342_ _11354_ _11381_ VDD VSS NAND2_X1
X_20717_ _11179_ _11346_ _11347_ _11382_ VDD VSS NAND3_X4
X_20718_ _11327_ _11304_ _11283_ _11382_ _11376_ _11383_ VDD
+ VSS OAI221_X2
X_20719_ _11297_ _11299_ _11384_ VDD VSS NOR2_X1
X_20720_ _11316_ _11381_ _11383_ _11384_ _11385_ VDD VSS NAND4_X1
X_20721_ _11194_ _11380_ _11385_ _11386_ VDD VSS AND3_X1
X_20722_ _11356_ _11372_ _11386_ _11387_ VDD VSS NAND3_X2
X_20723_ _06708_ _11193_ _11388_ VDD VSS XNOR2_X2
X_20724_ _11388_ _11316_ _11389_ VDD VSS NAND2_X1
X_20725_ _11296_ _11390_ VDD VSS BUF_X4
X_20726_ _11289_ _11391_ VDD VSS CLKBUF_X3
X_20727_ _11390_ _11391_ _11392_ VDD VSS NAND2_X1
X_20728_ _11332_ _11344_ _11393_ VDD VSS NOR2_X1
X_20729_ _11341_ _11231_ _11235_ _11394_ VDD VSS OAI21_X1
X_20730_ _11393_ _11394_ _11395_ VDD VSS NAND2_X1
X_20731_ net838 _11307_ _11396_ VDD VSS NAND2_X2
X_20732_ _11322_ _11373_ _11397_ VDD VSS NAND2_X2
X_20733_ _11333_ _11396_ _11397_ _11398_ VDD VSS NAND3_X1
X_20734_ _11392_ _11395_ _11398_ _11399_ VDD VSS AOI21_X1
X_20735_ _11175_ _11230_ _11234_ _11400_ VDD VSS NOR3_X4
X_20736_ _11378_ _11400_ _11401_ VDD VSS NOR2_X4
X_20737_ net474 _11402_ VDD VSS INV_X8
X_20738_ _11381_ _11401_ _11322_ _11236_ net143 _11403_ VDD
+ VSS OAI221_X2
X_20739_ _11319_ _11290_ _11404_ VDD VSS NOR2_X2
X_20740_ _11319_ _11405_ VDD VSS CLKBUF_X3
X_20741_ _11181_ _11406_ VDD VSS BUF_X4
X_20742_ _11406_ _11317_ _14899_ _11407_ VDD VSS OAI21_X1
X_20743_ _11179_ _11215_ _11408_ VDD VSS NOR2_X1
X_20744_ _11331_ _11289_ _11409_ VDD VSS NOR2_X2
X_20745_ net839 _11407_ _11408_ _11391_ _11409_ net650 _11410_
+ VDD VSS AOI222_X2
X_20746_ net647 _11155_ _11411_ VDD VSS NOR2_X1
X_20747_ _11290_ _11279_ _11411_ _11412_ VDD VSS OAI21_X1
X_20748_ _11239_ _11413_ VDD VSS CLKBUF_X3
X_20749_ _11413_ _11414_ VDD VSS CLKBUF_X3
X_20750_ _11312_ _11406_ _11391_ _11415_ VDD VSS NOR3_X1
X_20751_ _11414_ _11415_ _11416_ VDD VSS NOR2_X1
X_20752_ _11330_ _11410_ _11412_ _11416_ _11417_ VDD VSS AOI22_X2
X_20753_ _11399_ _11403_ _11404_ _11405_ _11417_ _11418_ VDD
+ VSS AOI221_X2
X_20754_ _11315_ _11340_ _11387_ _11418_ _11389_ _00056_ VDD
+ VSS OAI221_X2
X_20755_ _11388_ _11357_ _11419_ VDD VSS NOR2_X2
X_20756_ _11130_ _11420_ VDD VSS BUF_X4
X_20757_ _11420_ _11177_ _11375_ _11421_ VDD VSS AOI21_X1
X_20758_ _11270_ _11382_ net649 _11237_ _11413_ _11422_ VDD
+ VSS OAI221_X1
X_20759_ _11419_ _11421_ _11422_ _11423_ VDD VSS OAI21_X1
X_20760_ _14897_ _11346_ _11347_ _11424_ VDD VSS NAND3_X2
X_20761_ _11331_ _11366_ _11424_ _11425_ VDD VSS AOI21_X1
X_20762_ _11181_ _11307_ _11361_ _11426_ VDD VSS NOR3_X1
X_20763_ _11391_ _11425_ _11426_ _11427_ VDD VSS OAI21_X1
X_20764_ _11331_ _11303_ _11428_ VDD VSS NAND2_X1
X_20765_ _11214_ _11428_ _11401_ _11420_ _11429_ VDD VSS OAI22_X1
X_20766_ _11427_ _11429_ _11290_ _11430_ VDD VSS OAI21_X1
X_20767_ _11326_ net965 _11424_ _11431_ VDD VSS AOI21_X2
X_20768_ net144 _11382_ _11432_ VDD VSS NOR2_X2
X_20769_ _11181_ _11303_ net666 _11433_ VDD VSS OAI21_X1
X_20770_ _11432_ _11433_ _11434_ VDD VSS NOR2_X1
X_20771_ _11431_ _11434_ _11435_ VDD VSS OR2_X1
X_20772_ _11423_ _11430_ _11319_ _11435_ _11404_ _11436_ VDD
+ VSS AOI221_X2
X_20773_ _11336_ _11437_ VDD VSS CLKBUF_X3
X_20774_ _11402_ _11231_ _11235_ _11438_ VDD VSS OAI21_X4
X_20775_ _11155_ _11278_ _11274_ _11439_ VDD VSS NAND3_X4
X_20776_ _11438_ _11439_ net645 _11440_ VDD VSS OAI21_X4
X_20777_ _11289_ _11354_ _11179_ _11440_ _11181_ _11441_ VDD
+ VSS AOI221_X2
X_20778_ _14892_ _11442_ VDD VSS INV_X1
X_20779_ _11442_ _11239_ _11443_ VDD VSS NAND2_X1
X_20780_ _11180_ _11285_ net647 _11444_ VDD VSS AOI21_X2
X_20781_ _11269_ _11352_ _11382_ _11443_ _11444_ _11445_ VDD
+ VSS AOI221_X1
X_20782_ _11437_ _11441_ _11445_ _11446_ VDD VSS OR3_X2
X_20783_ _14906_ _11346_ _11347_ _11447_ VDD VSS NAND3_X4
X_20784_ _11438_ _11447_ _11448_ VDD VSS NAND2_X1
X_20785_ _11129_ _11449_ VDD VSS INV_X1
X_20786_ _06619_ _11207_ _11450_ VDD VSS NAND2_X1
X_20787_ _11111_ _11207_ _11451_ VDD VSS NAND2_X1
X_20788_ _11450_ _11451_ _11125_ _11452_ VDD VSS MUX2_X1
X_20789_ _11179_ _11449_ _11452_ _11453_ VDD VSS AOI21_X4
X_20790_ _11286_ _11453_ _11454_ VDD VSS NAND2_X1
X_20791_ net957 _11230_ _11234_ _11455_ VDD VSS NOR3_X4
X_20792_ _11181_ _11289_ _11455_ _11456_ VDD VSS NOR3_X1
X_20793_ _11390_ _11409_ _11448_ _11454_ _11456_ _11457_ VDD
+ VSS AOI221_X2
X_20794_ _11182_ _11439_ _11366_ _11458_ VDD VSS AOI21_X2
X_20795_ _11455_ _11374_ _11322_ _11459_ VDD VSS AOI21_X1
X_20796_ _11458_ _11459_ _14908_ _11460_ VDD VSS AOI21_X1
X_20797_ _11457_ _11460_ _11318_ _11461_ VDD VSS OAI21_X1
X_20798_ _11358_ _11446_ _11461_ _11462_ VDD VSS NAND3_X2
X_20799_ _11285_ _11279_ _11131_ _11331_ _11341_ _11463_ VDD
+ VSS AOI221_X2
X_20800_ _14916_ _11391_ _11413_ _11464_ VDD VSS NOR3_X1
X_20801_ _11437_ _11463_ _11464_ _11465_ VDD VSS NOR3_X1
X_20802_ _11358_ _11465_ _11466_ VDD VSS NOR2_X1
X_20803_ net643 _11239_ _11467_ VDD VSS OR2_X4
X_20804_ _11409_ _11439_ _11467_ _11468_ VDD VSS NAND3_X1
X_20805_ _11131_ _11239_ _11469_ VDD VSS XNOR2_X1
X_20806_ _11182_ _11391_ _11469_ _11470_ VDD VSS OR3_X1
X_20807_ _11155_ _11176_ _11471_ VDD VSS NOR2_X2
X_20808_ net144 _11303_ _11408_ _11471_ _11472_ VDD VSS OR4_X1
X_20809_ _11442_ _11326_ _11473_ VDD VSS NOR2_X1
X_20810_ _11304_ _11471_ _11473_ _11474_ VDD VSS OAI21_X1
X_20811_ _11290_ _11472_ _11474_ _11475_ VDD VSS NAND3_X1
X_20812_ _11437_ _11468_ _11470_ _11475_ _11476_ VDD VSS NAND4_X1
X_20813_ _11194_ _11466_ _11476_ _11477_ VDD VSS AOI21_X1
X_20814_ _11388_ _11210_ _11478_ VDD VSS NOR2_X2
X_20815_ _11317_ _11307_ net839 _11479_ VDD VSS AOI21_X1
X_20816_ _14906_ _11480_ VDD VSS INV_X1
X_20817_ _11480_ _11303_ _11481_ VDD VSS NOR2_X2
X_20818_ _11479_ _11481_ _11182_ net651 _11236_ _11482_ VDD
+ VSS OAI221_X1
X_20819_ _11237_ _11351_ _11483_ VDD VSS NAND2_X1
X_20820_ _11438_ _11373_ _11322_ _11484_ VDD VSS OAI21_X1
X_20821_ _11317_ _11307_ _11483_ _11484_ _11332_ _11485_ VDD
+ VSS OAI221_X1
X_20822_ _11482_ _11485_ _11486_ VDD VSS AND2_X1
X_20823_ net143 _11428_ _11401_ _14899_ _11323_ net649 _11487_
+ VDD VSS OAI222_X2
X_20824_ _11237_ _11424_ _11438_ _11488_ VDD VSS AOI21_X2
X_20825_ _11303_ _11453_ _11489_ VDD VSS NOR2_X1
X_20826_ _11488_ _11489_ _11332_ _11490_ VDD VSS AOI21_X1
X_20827_ _11487_ _11490_ _11290_ _11491_ VDD VSS MUX2_X1
X_20828_ _11486_ _11491_ _11329_ _11492_ VDD VSS MUX2_X1
X_20829_ _11436_ _11462_ _11477_ _11478_ _11492_ _00057_ VDD
+ VSS AOI221_X2
X_20830_ _14911_ _11297_ _11493_ VDD VSS NAND2_X1
X_20831_ _11155_ _11176_ _11494_ VDD VSS NAND2_X1
X_20832_ net925 _11319_ _11494_ _11495_ VDD VSS NAND3_X1
X_20833_ _11287_ _11493_ _11495_ _11496_ VDD VSS NAND3_X1
X_20834_ _11179_ _11331_ _11126_ _11129_ _11497_ VDD VSS OAI211_X2
X_20835_ _14920_ _11497_ _11390_ _11498_ VDD VSS MUX2_X1
X_20836_ _11414_ _11498_ _11499_ VDD VSS NAND2_X1
X_20837_ _11318_ _11419_ _11496_ _11499_ _11500_ VDD VSS NAND4_X1
X_20838_ _11292_ _11419_ _11501_ VDD VSS NAND2_X1
X_20839_ _11286_ _11453_ _11502_ VDD VSS NOR2_X1
X_20840_ _11283_ _11214_ _11503_ VDD VSS NOR2_X1
X_20841_ _11406_ _11413_ _11503_ _11504_ VDD VSS OAI21_X1
X_20842_ _11332_ _11374_ _11341_ _11505_ VDD VSS OAI21_X1
X_20843_ _11437_ _11502_ _11504_ _11505_ _11489_ _11506_ VDD
+ VSS OAI221_X1
X_20844_ _11366_ _11286_ _11322_ _11507_ VDD VSS OAI21_X2
X_20845_ _11214_ _11378_ _11507_ _11327_ _11508_ VDD VSS AOI22_X1
X_20846_ _11506_ _11508_ _11405_ _11509_ VDD VSS OAI21_X1
X_20847_ _11500_ _11501_ _11509_ _11510_ VDD VSS OAI21_X1
X_20848_ _11367_ _11231_ _11235_ _11511_ VDD VSS OAI21_X4
X_20849_ _11332_ _11439_ _11511_ _11512_ VDD VSS AOI21_X1
X_20850_ net585 _11231_ _11235_ _11513_ VDD VSS NOR3_X4
X_20851_ _11513_ _11326_ _11514_ VDD VSS NOR2_X4
X_20852_ net839 _11374_ _11515_ VDD VSS NAND2_X1
X_20853_ _11512_ _11514_ _11515_ _11516_ VDD VSS AOI21_X1
X_20854_ _11316_ _11384_ _11516_ _11517_ VDD VSS AOI21_X1
X_20855_ _11327_ _11323_ _11369_ _11518_ VDD VSS NAND3_X1
X_20856_ _11178_ _11351_ _11447_ _11519_ VDD VSS NAND3_X1
X_20857_ _11518_ _11519_ _11520_ VDD VSS NAND2_X1
X_20858_ _11405_ _11318_ _11520_ _11521_ VDD VSS NAND3_X1
X_20859_ _11332_ _11369_ _11438_ _11522_ VDD VSS NAND3_X1
X_20860_ _11327_ _11439_ net965 _11523_ VDD VSS NAND3_X1
X_20861_ _11291_ _11522_ _11523_ _11524_ VDD VSS NAND3_X1
X_20862_ _11214_ _11237_ _11525_ VDD VSS AND2_X1
X_20863_ _11369_ _11413_ _11420_ _11526_ VDD VSS OAI21_X1
X_20864_ _11525_ _11526_ _11327_ _11527_ VDD VSS AOI21_X1
X_20865_ _11524_ _11527_ _11291_ _11528_ VDD VSS OAI21_X1
X_20866_ _11517_ _11521_ _11405_ _11528_ _11529_ VDD VSS OAI211_X2
X_20867_ _11176_ _11239_ net645 _11530_ VDD VSS AOI21_X2
X_20868_ net647 _11360_ _11531_ VDD VSS NAND2_X1
X_20869_ _11289_ _11345_ _11467_ _11530_ _11531_ _11532_ VDD
+ VSS AOI221_X2
X_20870_ net666 _11331_ _11303_ _11307_ _11282_ _11361_ _11533_
+ VDD VSS OAI33_X1
X_20871_ _11532_ _11533_ _11391_ _11534_ VDD VSS AOI21_X2
X_20872_ _11357_ _11336_ _11535_ VDD VSS NOR2_X1
X_20873_ _11215_ _11323_ _11447_ _11536_ VDD VSS AOI21_X1
X_20874_ _14897_ _11400_ _11537_ VDD VSS AND2_X1
X_20875_ _11391_ _11240_ _11536_ _11537_ _11538_ VDD VSS NOR4_X1
X_20876_ _11210_ _11336_ _11539_ VDD VSS NAND2_X1
X_20877_ _11538_ _11539_ _11540_ VDD VSS NOR2_X1
X_20878_ _11331_ net923 _11541_ VDD VSS OR2_X4
X_20879_ _11177_ _11413_ net963 _11542_ VDD VSS OAI21_X1
X_20880_ net144 _11373_ _11543_ VDD VSS NOR2_X2
X_20881_ _11290_ _11541_ _11361_ _11542_ _11543_ _11544_ VDD
+ VSS OAI221_X2
X_20882_ _11194_ _11534_ _11535_ _11540_ _11544_ _11545_ VDD
+ VSS AOI221_X2
X_20883_ _11406_ _11343_ _11286_ _11420_ _11546_ VDD VSS OAI211_X2
X_20884_ _11546_ _11507_ _11182_ _11547_ VDD VSS OAI21_X1
X_20885_ _11155_ _11215_ _11548_ VDD VSS NAND2_X2
X_20886_ _11420_ _11286_ _11548_ _11549_ VDD VSS NAND3_X1
X_20887_ net838 _11326_ _11550_ VDD VSS NAND2_X1
X_20888_ _11215_ _11373_ _11131_ _11551_ VDD VSS MUX2_X1
X_20889_ _11549_ _11550_ _11348_ net143 _11551_ _11552_ VDD
+ VSS OAI221_X1
X_20890_ _11547_ _11552_ _11290_ _11553_ VDD VSS MUX2_X1
X_20891_ _11312_ _11215_ _11554_ VDD VSS NOR2_X4
X_20892_ _11308_ _11155_ _11555_ VDD VSS NOR2_X1
X_20893_ _11554_ _11347_ _11346_ _11406_ _11555_ _11556_ VDD
+ VSS AOI221_X2
X_20894_ _11317_ _11304_ _14913_ _11557_ VDD VSS AOI21_X1
X_20895_ _11557_ _11558_ VDD VSS INV_X1
X_20896_ _11411_ _11347_ _11346_ net649 _11326_ _11559_ VDD
+ VSS AOI221_X2
X_20897_ _11299_ _11287_ _14916_ _11560_ VDD VSS OAI21_X1
X_20898_ _11556_ _11558_ _11559_ _11560_ _11561_ VDD VSS OAI22_X1
X_20899_ _11553_ _11561_ _11329_ _11562_ VDD VSS MUX2_X1
X_20900_ _11510_ _11529_ _11545_ _11562_ _11478_ _00058_ VDD
+ VSS AOI221_X2
X_20901_ _11419_ _11563_ VDD VSS INV_X1
X_20902_ _11327_ _11319_ _11287_ _11564_ VDD VSS NAND3_X1
X_20903_ _11180_ _11295_ _11257_ _11565_ VDD VSS NOR3_X4
X_20904_ net925 _11565_ _11566_ VDD VSS NAND2_X1
X_20905_ _11564_ _11565_ net965 _11330_ _11566_ _11567_ VDD
+ VSS OAI221_X1
X_20906_ net176 _11414_ _11548_ _11568_ VDD VSS NAND3_X1
X_20907_ _11319_ _11408_ net925 _11569_ VDD VSS AOI21_X1
X_20908_ _11279_ _11354_ net843 _11570_ VDD VSS AOI21_X1
X_20909_ _11568_ _11569_ _11570_ _11437_ _11571_ VDD VSS AOI22_X1
X_20910_ _11292_ _11567_ _11571_ _11572_ VDD VSS OR3_X1
X_20911_ _11406_ _11336_ _11573_ VDD VSS NAND2_X1
X_20912_ _11341_ _11304_ _11574_ VDD VSS NAND2_X1
X_20913_ _11573_ _11574_ _11397_ _11575_ VDD VSS AOI21_X1
X_20914_ _11215_ _11254_ _11258_ _11576_ VDD VSS AOI21_X4
X_20915_ net650 _11413_ _11577_ VDD VSS NOR2_X1
X_20916_ _11307_ _11577_ _11578_ VDD VSS NOR2_X1
X_20917_ _11541_ _11481_ _11483_ _11543_ _11579_ VDD VSS OAI22_X2
X_20918_ _11575_ _11576_ _11578_ _11579_ _11329_ _11580_ VDD
+ VSS AOI221_X2
X_20919_ _11572_ _11580_ _11300_ _11581_ VDD VSS OAI21_X1
X_20920_ net963 _11287_ _11344_ _11290_ _11582_ VDD VSS AOI22_X1
X_20921_ _14915_ _11582_ _11583_ VDD VSS OR2_X1
X_20922_ _14915_ _11300_ net965 _11574_ _11584_ VDD VSS NAND4_X1
X_20923_ _11376_ _14891_ VDD VSS BUF_X32
X_20924_ net177 _11300_ _11400_ _11585_ VDD VSS NAND3_X1
X_20925_ _11405_ _11583_ _11584_ _11585_ _11586_ VDD VSS NAND4_X1
X_20926_ _11368_ _11401_ _11279_ _11304_ _11587_ VDD VSS AOI22_X2
X_20927_ _11333_ _11307_ _11481_ _11588_ VDD VSS OAI21_X1
X_20928_ _11390_ _11317_ _11589_ VDD VSS NAND2_X1
X_20929_ _11374_ _11503_ _11590_ VDD VSS NAND2_X1
X_20930_ _11589_ _11393_ _11590_ _11591_ VDD VSS AOI21_X1
X_20931_ _11194_ _11270_ _11587_ _11588_ _11591_ _11592_ VDD
+ VSS AOI221_X2
X_20932_ _11358_ _11586_ _11592_ _11593_ VDD VSS AOI21_X1
X_20933_ _11259_ _11310_ _11442_ _11353_ net647 _11594_ VDD
+ VSS AOI221_X1
X_20934_ _11594_ _11530_ _14890_ _11595_ VDD VSS OAI21_X1
X_20935_ _11346_ net492 _11347_ _11596_ VDD VSS NAND3_X4
X_20936_ _11511_ _11596_ _11597_ VDD VSS AND2_X1
X_20937_ _11182_ _11319_ _11597_ _11598_ VDD VSS NAND3_X1
X_20938_ _11375_ _11447_ _11576_ _11599_ VDD VSS NAND3_X1
X_20939_ _11194_ _11317_ _11600_ VDD VSS NOR2_X1
X_20940_ _11595_ _11598_ _11599_ _11600_ _11601_ VDD VSS AND4_X1
X_20941_ net666 _11181_ _11602_ VDD VSS NOR2_X1
X_20942_ _11336_ _11413_ _11602_ _11603_ VDD VSS OAI21_X1
X_20943_ _11413_ _11565_ _11604_ VDD VSS NOR2_X1
X_20944_ _11307_ _11336_ _11420_ _11605_ VDD VSS AOI21_X1
X_20945_ _11603_ _11604_ _11335_ _11178_ _11605_ _11606_ VDD
+ VSS OAI221_X1
X_20946_ _11390_ _11286_ _11607_ VDD VSS NOR2_X1
X_20947_ _11368_ _11237_ _11608_ VDD VSS NAND2_X1
X_20948_ _11608_ _11177_ _11312_ _11609_ VDD VSS OAI21_X1
X_20949_ _11290_ _11607_ _11609_ _11610_ VDD VSS AOI21_X1
X_20950_ _11388_ _11606_ _11610_ _11611_ VDD VSS AOI21_X1
X_20951_ _11259_ _11310_ _11341_ _11354_ _11402_ _11612_ VDD
+ VSS AOI221_X2
X_20952_ _14899_ _11400_ _11272_ _11286_ _11613_ VDD VSS AOI22_X1
X_20953_ _11612_ _11613_ net176 _11614_ VDD VSS OAI21_X1
X_20954_ _11342_ _11180_ _11615_ VDD VSS NOR2_X2
X_20955_ _11296_ _11239_ _11615_ _11361_ _11308_ _11616_ VDD
+ VSS AOI221_X2
X_20956_ _11616_ _11541_ _11361_ _11617_ VDD VSS OAI21_X4
X_20957_ _11617_ _11614_ _11291_ _11618_ VDD VSS NAND3_X2
X_20958_ _11304_ _11257_ _11295_ _11480_ _11406_ _11619_ VDD
+ VSS OAI221_X1
X_20959_ _11299_ _11279_ _11619_ _11620_ VDD VSS OAI21_X1
X_20960_ _11367_ _11621_ VDD VSS INV_X1
X_20961_ _11207_ _11621_ _11622_ VDD VSS NAND2_X1
X_20962_ _11156_ _11167_ _11160_ _11623_ VDD VSS NOR3_X1
X_20963_ _11167_ _11162_ _11624_ VDD VSS XNOR2_X1
X_20964_ _11623_ _11624_ _11156_ _11625_ VDD VSS AOI21_X1
X_20965_ _11231_ _11235_ _11622_ _11625_ _11626_ VDD VSS OAI22_X1
X_20966_ _14897_ _14894_ _11627_ VDD VSS OR2_X4
X_20967_ _06635_ _00451_ _11628_ VDD VSS XNOR2_X1
X_20968_ _11368_ _11627_ _11628_ _11629_ VDD VSS MUX2_X1
X_20969_ _11629_ _09136_ _11630_ VDD VSS NAND2_X2
X_20970_ _11156_ _11367_ _11162_ _11631_ VDD VSS NOR3_X1
X_20971_ _09136_ _11167_ _11631_ _11632_ VDD VSS AOI21_X1
X_20972_ _11156_ _11624_ _11633_ VDD VSS XNOR2_X1
X_20973_ _11632_ _11633_ _11627_ _11634_ VDD VSS OAI21_X1
X_20974_ _11626_ _11634_ _11630_ _11635_ VDD VSS AOI21_X4
X_20975_ _11319_ _11463_ _11635_ _11636_ VDD VSS NOR3_X4
X_20976_ _11358_ _11620_ _11636_ _11637_ VDD VSS OAI21_X2
X_20977_ _11601_ _11618_ _11611_ _11637_ _11388_ _11638_ VDD
+ VSS AOI221_X2
X_20978_ _11563_ _11581_ _11593_ _11638_ _00059_ VDD VSS OAI22_X1
X_20979_ _11194_ _11357_ _11639_ VDD VSS NOR2_X2
X_20980_ _11402_ _11215_ _11640_ VDD VSS NOR2_X1
X_20981_ _14904_ _11640_ _11373_ _11641_ VDD VSS MUX2_X1
X_20982_ _11639_ _11641_ _11392_ _11642_ VDD VSS OAI21_X1
X_20983_ _11432_ _11511_ _11332_ _11643_ VDD VSS AOI21_X1
X_20984_ _11336_ _11391_ _11644_ VDD VSS NAND2_X1
X_20985_ _11644_ _11310_ net176 _11645_ VDD VSS AOI21_X1
X_20986_ _11360_ _11239_ _11130_ _11646_ VDD VSS AOI21_X1
X_20987_ _11176_ _11285_ _11647_ VDD VSS NAND2_X2
X_20988_ _11396_ _11646_ _11331_ _11647_ _11621_ _11648_ VDD
+ VSS OAI221_X1
X_20989_ _11442_ _11354_ _11361_ net645 _11649_ VDD VSS AOI22_X1
X_20990_ _11649_ _11325_ _11237_ _11650_ VDD VSS OAI21_X1
X_20991_ _11648_ _11650_ _11390_ _11651_ VDD VSS MUX2_X1
X_20992_ _11642_ _11643_ _11645_ _11651_ _11299_ _11652_ VDD
+ VSS AOI221_X2
X_20993_ _11554_ _11182_ _11214_ _11653_ VDD VSS AOI21_X2
X_20994_ _11317_ _11455_ _11576_ _11653_ _11281_ _11654_ VDD
+ VSS AOI221_X2
X_20995_ _14890_ _11565_ _11655_ VDD VSS NAND2_X1
X_20996_ _11453_ _11337_ _11576_ _11656_ VDD VSS OAI21_X1
X_20997_ _11655_ _11656_ _11657_ VDD VSS AND2_X1
X_20998_ _11654_ _11657_ _11330_ _11658_ VDD VSS OAI21_X1
X_20999_ _11259_ _11354_ _11480_ _11382_ _11326_ _11659_ VDD
+ VSS AOI221_X1
X_21000_ _11296_ _11352_ _11443_ _11469_ _11237_ _11660_ VDD
+ VSS AOI221_X2
X_21001_ _11318_ _11659_ _11660_ _11661_ VDD VSS OAI21_X1
X_21002_ _11211_ _11661_ _11662_ VDD VSS AND2_X1
X_21003_ _14892_ _11239_ _11663_ VDD VSS NAND2_X1
X_21004_ _11259_ _11663_ _11444_ _11326_ _11155_ _11664_ VDD
+ VSS AOI221_X2
X_21005_ _11455_ _11511_ _11177_ _11665_ VDD VSS AOI21_X1
X_21006_ _11297_ _11665_ _11666_ VDD VSS NOR2_X1
X_21007_ _11666_ _11318_ _11664_ _11316_ _11667_ VDD VSS NOR4_X2
X_21008_ net651 _11406_ _11390_ _11668_ VDD VSS NAND3_X1
X_21009_ _11322_ _11576_ _11669_ VDD VSS NAND2_X1
X_21010_ _11304_ _11668_ _11669_ _11670_ VDD VSS AOI21_X1
X_21011_ net649 _14899_ _11565_ _11671_ VDD VSS OAI21_X1
X_21012_ _11374_ _11548_ _11671_ _11672_ VDD VSS AOI21_X1
X_21013_ net651 _11362_ _11573_ _11673_ VDD VSS AOI21_X1
X_21014_ _11359_ _11670_ _11672_ _11673_ _11674_ VDD VSS NOR4_X2
X_21015_ _11621_ _11177_ _11675_ VDD VSS NOR2_X1
X_21016_ _11299_ _11431_ _11675_ _11676_ VDD VSS NOR3_X1
X_21017_ _11363_ _11176_ _11677_ VDD VSS NOR2_X2
X_21018_ net1016 _11285_ _11308_ _11678_ VDD VSS AOI21_X2
X_21019_ _11289_ _11677_ _11531_ _11678_ _11237_ _11679_ VDD
+ VSS AOI221_X2
X_21020_ _11679_ _11676_ _11539_ _11680_ VDD VSS NOR3_X2
X_21021_ _11680_ _11667_ _11674_ _11388_ _11681_ VDD VSS NOR4_X2
X_21022_ _14908_ _11397_ _11682_ VDD VSS NAND2_X1
X_21023_ _11240_ net958 _11683_ VDD VSS OR2_X1
X_21024_ _11300_ _11432_ _11682_ _11683_ _14908_ _11684_ VDD
+ VSS OAI221_X1
X_21025_ _11308_ _11375_ _11685_ VDD VSS NOR2_X1
X_21026_ _11178_ _11513_ _11686_ VDD VSS OR2_X1
X_21027_ _11291_ _11685_ _11686_ _11597_ _14908_ _11687_ VDD
+ VSS OAI221_X1
X_21028_ _11535_ _11684_ _11687_ _11688_ VDD VSS NAND3_X1
X_21029_ _11652_ _11658_ _11662_ _11688_ _11681_ _00060_ VDD
+ VSS AOI221_X2
X_21030_ _11388_ _11358_ _11318_ _11689_ VDD VSS NOR3_X1
X_21031_ _14891_ _11329_ _11414_ _11690_ VDD VSS OAI21_X1
X_21032_ _11341_ _11378_ _11400_ _14890_ _11691_ VDD VSS AOI22_X1
X_21033_ _11689_ _11690_ _11354_ _11691_ _11298_ _11692_ VDD
+ VSS OAI221_X1
X_21034_ _11405_ _11330_ _11693_ VDD VSS NAND2_X1
X_21035_ net177 _11329_ _11330_ _11694_ VDD VSS AOI21_X1
X_21036_ net177 _11693_ _11694_ _11564_ _11695_ VDD VSS AOI22_X1
X_21037_ _11692_ _11695_ _14899_ _11696_ VDD VSS AOI21_X1
X_21038_ _11291_ _11478_ _11697_ VDD VSS NAND2_X1
X_21039_ _11390_ _11286_ _11214_ _11354_ _11368_ _11698_ VDD
+ VSS AOI221_X2
X_21040_ _11178_ _11324_ _11351_ _11699_ VDD VSS AOI21_X1
X_21041_ _11699_ _11309_ _11333_ _11700_ VDD VSS AOI21_X2
X_21042_ _11697_ _11698_ _11383_ _11298_ _11700_ _11701_ VDD
+ VSS AOI221_X2
X_21043_ _11696_ _11701_ _11702_ VDD VSS NOR2_X1
X_21044_ _11358_ _11400_ _14890_ _11361_ net177 _11703_ VDD
+ VSS OAI221_X1
X_21045_ _11548_ _11238_ _11357_ _11704_ VDD VSS OAI21_X1
X_21046_ _11357_ net837 _11705_ VDD VSS NOR2_X1
X_21047_ _11437_ _11543_ _11704_ _11705_ _11310_ _11706_ VDD
+ VSS AOI221_X1
X_21048_ _11703_ _11706_ _11707_ VDD VSS AND2_X1
X_21049_ _11178_ _11374_ _11368_ _11375_ _11376_ _11708_ VDD
+ VSS OAI221_X2
X_21050_ net965 _11374_ _11420_ _11709_ VDD VSS OAI21_X1
X_21051_ _11316_ _11709_ _11327_ _11710_ VDD VSS AOI21_X1
X_21052_ net584 _11647_ _11525_ _11287_ _11711_ VDD VSS OAI22_X2
X_21053_ _11329_ _11708_ _11710_ _11711_ _11316_ _11712_ VDD
+ VSS AOI221_X2
X_21054_ _11600_ _11712_ _11707_ _11713_ VDD VSS OAI21_X1
X_21055_ _11318_ _11211_ _11714_ VDD VSS NAND2_X1
X_21056_ _11406_ _11343_ _11447_ _11715_ VDD VSS AOI21_X1
X_21057_ _11715_ _11502_ _11327_ _11716_ VDD VSS AOI21_X2
X_21058_ _11414_ _11279_ _11525_ _11717_ VDD VSS OAI21_X1
X_21059_ _11714_ _11716_ _11437_ _11281_ _11717_ _11718_ VDD
+ VSS AOI221_X2
X_21060_ _11299_ _11639_ _11719_ VDD VSS NAND2_X1
X_21061_ _14908_ _11596_ _11438_ _11720_ VDD VSS AND3_X1
X_21062_ _11405_ _11715_ _11720_ _11721_ VDD VSS OAI21_X1
X_21063_ _11298_ _11330_ _11342_ _11396_ _14915_ _11722_ VDD
+ VSS OAI221_X1
X_21064_ _11719_ _11721_ _11722_ _11723_ VDD VSS AOI21_X1
X_21065_ _11182_ _11596_ _11511_ _11724_ VDD VSS NAND3_X2
X_21066_ _11336_ _11378_ _14899_ _11725_ VDD VSS AOI21_X1
X_21067_ net651 _11361_ _11424_ _11182_ _11726_ VDD VSS AOI22_X1
X_21068_ _11316_ _11724_ _11725_ _11726_ _11319_ _11727_ VDD
+ VSS AOI221_X2
X_21069_ _11194_ _11300_ _11728_ VDD VSS NAND2_X1
X_21070_ _11324_ _11366_ _11729_ VDD VSS NAND2_X1
X_21071_ _11539_ _11729_ _11332_ _11400_ net176 _11730_ VDD
+ VSS AOI221_X2
X_21072_ _11210_ _11390_ _11731_ VDD VSS NAND2_X1
X_21073_ _11731_ _11514_ _11397_ _11402_ _11310_ _11732_ VDD
+ VSS AOI221_X2
X_21074_ _11732_ _11728_ _11730_ _11727_ _11733_ VDD VSS NOR4_X2
X_21075_ _11723_ _11718_ _11733_ _11734_ VDD VSS NOR3_X1
X_21076_ _11734_ _11713_ _11702_ _00061_ VDD VSS NAND3_X1
X_21077_ _11376_ _11437_ _11735_ VDD VSS NAND2_X1
X_21078_ _14915_ _11362_ _11735_ _11736_ VDD VSS AND3_X1
X_21079_ _11414_ _11297_ _11621_ _11737_ VDD VSS AOI21_X1
X_21080_ _11437_ _11596_ _11738_ VDD VSS NOR2_X1
X_21081_ _14915_ _11737_ _11738_ _11739_ VDD VSS NOR3_X1
X_21082_ _11300_ _11736_ _11739_ _11693_ _14890_ _11740_ VDD
+ VSS OAI221_X1
X_21083_ _11307_ _11471_ net177 _11741_ VDD VSS AOI21_X1
X_21084_ _11494_ _11375_ net925 _11741_ net584 _11742_ VDD
+ VSS OAI221_X1
X_21085_ net651 _14890_ _11390_ _11743_ VDD VSS NAND3_X1
X_21086_ _14908_ _11297_ _11513_ _11744_ VDD VSS OAI21_X1
X_21087_ _11297_ _11287_ _11745_ VDD VSS NAND2_X1
X_21088_ _11743_ _11744_ net177 _11548_ _11745_ _11746_ VDD
+ VSS OAI221_X1
X_21089_ _11384_ _11742_ _11746_ _11292_ _11747_ VDD VSS AOI22_X1
X_21090_ _11211_ _11740_ _11747_ _11748_ VDD VSS NAND3_X1
X_21091_ _11382_ _11511_ _11749_ VDD VSS AND2_X1
X_21092_ _11344_ net836 _11373_ _11750_ VDD VSS AOI21_X1
X_21093_ _11749_ _11750_ _11237_ _11751_ VDD VSS MUX2_X1
X_21094_ _11511_ _11374_ _11322_ _11752_ VDD VSS OAI21_X1
X_21095_ _14908_ _11752_ _11753_ VDD VSS NAND2_X1
X_21096_ _11299_ _11378_ net963 _11754_ VDD VSS AOI21_X1
X_21097_ _11297_ _11751_ _11299_ _11753_ _11754_ _11755_ VDD
+ VSS AOI221_X2
X_21098_ _11333_ _11369_ _11756_ VDD VSS NAND2_X1
X_21099_ net963 _11757_ VDD VSS INV_X1
X_21100_ _11447_ _11414_ _11757_ _11758_ VDD VSS OAI21_X1
X_21101_ _11404_ _11489_ _11756_ _11758_ _14915_ _11759_ VDD
+ VSS OAI221_X1
X_21102_ _11453_ _11347_ _11346_ _11420_ _11326_ _11760_ VDD
+ VSS AOI221_X2
X_21103_ _14909_ _14918_ _11374_ _11761_ VDD VSS NOR3_X1
X_21104_ _11392_ _11760_ _11761_ _11762_ VDD VSS OR3_X1
X_21105_ _11358_ _11759_ _11762_ _11763_ VDD VSS NAND3_X1
X_21106_ _11194_ _11755_ _11763_ _11764_ VDD VSS OAI21_X2
X_21107_ _11215_ _11455_ _11765_ VDD VSS OR2_X1
X_21108_ _11596_ _11303_ net838 _11766_ VDD VSS OAI21_X2
X_21109_ _11391_ _11685_ _11765_ _11766_ _11177_ _11767_ VDD
+ VSS OAI221_X1
X_21110_ _11181_ net836 _11373_ _11768_ VDD VSS OAI21_X4
X_21111_ _11323_ _11596_ _11769_ VDD VSS NAND2_X1
X_21112_ _11317_ _11768_ _11685_ _11769_ _11406_ _11770_ VDD
+ VSS OAI221_X2
X_21113_ _11767_ _11770_ _11771_ VDD VSS AND2_X2
X_21114_ _11286_ _11279_ _11420_ _11772_ VDD VSS OAI21_X1
X_21115_ _11381_ _11772_ _11773_ VDD VSS AND2_X1
X_21116_ _11297_ _11318_ _11773_ _11774_ VDD VSS AOI21_X1
X_21117_ _11497_ _11177_ _11312_ _11775_ VDD VSS OAI21_X1
X_21118_ _14911_ _11775_ _11413_ _11776_ VDD VSS MUX2_X1
X_21119_ _11291_ _11776_ _11777_ VDD VSS NAND2_X1
X_21120_ _11358_ _11329_ _11771_ _11774_ _11777_ _11778_ VDD
+ VSS AOI221_X2
X_21121_ _11214_ _11368_ _11259_ _11779_ VDD VSS MUX2_X1
X_21122_ _11177_ _11336_ _11420_ _11780_ VDD VSS AOI21_X1
X_21123_ _11333_ _11779_ _11780_ _11743_ _11781_ VDD VSS AOI22_X1
X_21124_ _11291_ _11615_ _11607_ _11781_ _11287_ _11782_ VDD
+ VSS AOI221_X1
X_21125_ _14910_ _11414_ _11783_ VDD VSS NOR2_X1
X_21126_ _11608_ _14915_ net177 _11784_ VDD VSS OAI21_X1
X_21127_ _11783_ _11784_ _11330_ _11785_ VDD VSS AOI21_X1
X_21128_ _11329_ _11310_ net143 _11786_ VDD VSS AOI21_X1
X_21129_ _11298_ _11785_ _11786_ _11588_ _11787_ VDD VSS AOI22_X1
X_21130_ _11782_ _11787_ _11292_ _11788_ VDD VSS AOI21_X1
X_21131_ _11748_ _11764_ _11778_ _11389_ _11788_ _00062_ VDD
+ VSS OAI221_X2
X_21132_ _11405_ _11478_ _11789_ VDD VSS NAND2_X1
X_21133_ _11333_ _11382_ _11511_ _11790_ VDD VSS NAND3_X1
X_21134_ _11301_ _11504_ _11790_ _11791_ VDD VSS AOI21_X1
X_21135_ _11300_ _11791_ _11792_ VDD VSS NOR2_X1
X_21136_ _11292_ net959 _11760_ _11793_ VDD VSS NOR3_X1
X_21137_ _11480_ _11310_ _11354_ _14890_ _11794_ VDD VSS AOI22_X1
X_21138_ _11794_ _11401_ _11312_ _11795_ VDD VSS OAI21_X1
X_21139_ _11291_ _11236_ _11442_ _11428_ _14899_ _11796_ VDD
+ VSS OAI221_X1
X_21140_ _14899_ _11378_ _11797_ VDD VSS NAND2_X1
X_21141_ net176 _11382_ _11797_ _11798_ VDD VSS AOI21_X1
X_21142_ _11292_ _11795_ _11796_ _11798_ _11799_ VDD VSS OAI22_X1
X_21143_ _11792_ _11789_ _11793_ _11799_ _11298_ _11212_ _11800_
+ VDD VSS OAI33_X1
X_21144_ net925 _11414_ _11801_ VDD VSS NAND2_X1
X_21145_ _11214_ net839 _11332_ _11802_ VDD VSS MUX2_X1
X_21146_ _11405_ _11279_ _11801_ _11802_ _11330_ _11803_ VDD
+ VSS OAI221_X1
X_21147_ _11283_ _11178_ _11346_ _11347_ _11804_ VDD VSS NAND4_X1
X_21148_ _11804_ _11414_ _14904_ _11805_ VDD VSS OAI21_X1
X_21149_ _11298_ _11805_ _11806_ VDD VSS NAND2_X1
X_21150_ _11292_ _11803_ _11806_ _11807_ VDD VSS NAND3_X1
X_21151_ _11402_ _11368_ _11181_ _11808_ VDD VSS MUX2_X1
X_21152_ _14918_ _11808_ _11304_ _11809_ VDD VSS MUX2_X1
X_21153_ _11298_ _11809_ _11810_ VDD VSS NAND2_X2
X_21154_ _11405_ _11458_ _11811_ VDD VSS NAND2_X1
X_21155_ _14908_ _11295_ _11257_ _11543_ _11577_ _11812_ VDD
+ VSS OAI221_X1
X_21156_ _11810_ _11300_ _11811_ _11812_ _11813_ VDD VSS NAND4_X4
X_21157_ _11563_ _11813_ _11807_ _11814_ VDD VSS AOI21_X4
X_21158_ _11178_ _11323_ _11447_ _11815_ VDD VSS AOI21_X1
X_21159_ _11815_ _11526_ _11333_ _11816_ VDD VSS AOI21_X1
X_21160_ _11194_ _11292_ _11816_ _11817_ VDD VSS NOR3_X2
X_21161_ _11331_ _11394_ _11818_ VDD VSS AND2_X1
X_21162_ _11317_ _11396_ _11818_ _11484_ _11182_ _11819_ VDD
+ VSS AOI221_X2
X_21163_ _11322_ _11178_ _11820_ VDD VSS NOR2_X1
X_21164_ _11181_ _11455_ _11373_ net838 _11821_ VDD VSS AOI211_X2
X_21165_ _11291_ _11820_ _11821_ _11822_ VDD VSS NOR3_X1
X_21166_ _11388_ _11819_ _11822_ _11823_ VDD VSS NOR3_X1
X_21167_ _11600_ _11678_ _11333_ _11647_ _11368_ _11824_ VDD
+ VSS OAI221_X1
X_21168_ _11358_ _11298_ _11824_ _11825_ VDD VSS NAND3_X1
X_21169_ _11825_ _11823_ _11817_ _11826_ VDD VSS NOR3_X2
X_21170_ _11155_ _11236_ _11494_ _11373_ _11827_ VDD VSS OAI22_X1
X_21171_ _11296_ _11400_ net650 _11827_ net838 _11828_ VDD
+ VSS AOI221_X1
X_21172_ _11337_ _11454_ _11596_ _11829_ VDD VSS AND3_X1
X_21173_ _11719_ _11828_ _11829_ _11830_ VDD VSS OR3_X1
X_21174_ _11378_ _11279_ _11330_ _11831_ VDD VSS AOI21_X1
X_21175_ net177 _11831_ _11832_ VDD VSS NOR2_X1
X_21176_ net843 _11400_ _11361_ _11833_ VDD VSS NOR3_X1
X_21177_ _11329_ _11432_ _11833_ _11834_ VDD VSS OAI21_X1
X_21178_ _11439_ _11236_ _14899_ _11835_ VDD VSS OAI21_X1
X_21179_ _11437_ _11835_ _11836_ VDD VSS NAND2_X1
X_21180_ _11292_ _11639_ _11834_ _11836_ _11837_ VDD VSS NAND4_X1
X_21181_ _11830_ _11832_ _11837_ _11838_ VDD VSS OAI21_X1
X_21182_ _11826_ _11800_ _11814_ _11838_ _00063_ VDD VSS NOR4_X2
X_21183_ _06255_ _11839_ VDD VSS INV_X1
X_21184_ _11839_ _09102_ _11840_ VDD VSS NOR2_X1
X_21185_ _08993_ _11841_ VDD VSS BUF_X4
X_21186_ _06255_ _11841_ _11842_ VDD VSS NOR2_X1
X_21187_ _08979_ _09151_ _11843_ VDD VSS XNOR2_X2
X_21188_ _08987_ sa00_sr\[1\] _11844_ VDD VSS XNOR2_X2
X_21189_ _11843_ _11844_ _11845_ VDD VSS XNOR2_X2
X_21190_ sa20_sr\[1\] _09007_ _11846_ VDD VSS XNOR2_X2
X_21191_ _11845_ _11846_ _11847_ VDD VSS XNOR2_X2
X_21192_ _11840_ _11842_ _11847_ _11848_ VDD VSS MUX2_X2
X_21193_ _06255_ _09728_ _00452_ _11849_ VDD VSS NAND3_X1
X_21194_ _11839_ _08974_ _11850_ VDD VSS NAND2_X1
X_21195_ _11849_ _11850_ _00452_ _11851_ VDD VSS OAI21_X4
X_21196_ _11851_ _11848_ _11852_ VDD VSS NOR2_X4
X_21197_ net523 _11853_ VDD VSS INV_X16
Xclone99 net875 net99 VDD VSS BUF_X4
X_21199_ _11853_ _11855_ VDD VSS BUF_X32
X_21200_ _11855_ _14928_ VDD VSS BUF_X32
X_21201_ sa30_sr\[0\] sa00_sr\[0\] _11856_ VDD VSS XNOR2_X2
X_21202_ _09006_ net880 _11857_ VDD VSS XNOR2_X1
X_21203_ _08979_ net624 _11858_ VDD VSS XOR2_X2
X_21204_ _06241_ _09011_ _11858_ _11859_ VDD VSS NAND3_X1
X_21205_ _06241_ _08992_ _11860_ VDD VSS NOR2_X1
X_21206_ net754 _11860_ _11861_ VDD VSS NAND2_X1
X_21207_ _11857_ _11859_ _11861_ _11862_ VDD VSS AOI21_X1
X_21208_ _09006_ _11856_ _11863_ VDD VSS XOR2_X1
X_21209_ _11858_ _11860_ _11864_ VDD VSS NAND2_X1
X_21210_ _06241_ _09022_ net754 _11865_ VDD VSS NAND3_X1
X_21211_ _11863_ _11864_ _11865_ _11866_ VDD VSS AOI21_X1
X_21212_ _06241_ _11867_ VDD VSS INV_X1
X_21213_ _11867_ _09726_ _00453_ _11868_ VDD VSS NAND3_X1
X_21214_ _06241_ _09027_ _11869_ VDD VSS NAND2_X1
X_21215_ _11868_ _11869_ _00453_ _11870_ VDD VSS OAI21_X1
X_21216_ _11862_ _11866_ _11870_ _11871_ VDD VSS OR3_X2
X_21217_ _11871_ _11872_ VDD VSS BUF_X4
X_21218_ _11872_ _11873_ VDD VSS INV_X2
X_21219_ _11873_ _11874_ VDD VSS BUF_X8
X_21220_ _11874_ _14931_ VDD VSS BUF_X4
X_21221_ _09037_ _09088_ _11875_ VDD VSS XNOR2_X2
X_21222_ _09041_ _11875_ _11876_ VDD VSS XNOR2_X1
X_21223_ net535 net640 _11877_ VDD VSS XOR2_X2
X_21224_ _06296_ _09074_ _11877_ _11878_ VDD VSS NAND3_X1
X_21225_ _06296_ net1083 _11879_ VDD VSS NOR2_X1
X_21226_ _08983_ _11879_ _11880_ VDD VSS NAND2_X1
X_21227_ _11876_ _11878_ _11880_ _11881_ VDD VSS AOI21_X2
X_21228_ _09037_ _09088_ _11882_ VDD VSS XOR2_X2
X_21229_ _09041_ _11882_ _11883_ VDD VSS XNOR2_X1
X_21230_ _11877_ _11879_ _11884_ VDD VSS NAND2_X1
X_21231_ _06296_ net828 _08983_ _11885_ VDD VSS NAND3_X1
X_21232_ _11883_ _11884_ _11885_ _11886_ VDD VSS AOI21_X2
X_21233_ _06296_ _11887_ VDD VSS INV_X1
X_21234_ _11887_ _08993_ _00454_ _11888_ VDD VSS NAND3_X1
X_21235_ _06296_ _08993_ _11889_ VDD VSS NAND2_X1
X_21236_ _11888_ _11889_ _00454_ _11890_ VDD VSS OAI21_X2
X_21237_ _11881_ _11886_ _11890_ _11891_ VDD VSS NOR3_X4
X_21238_ _11891_ _11892_ VDD VSS INV_X4
X_21239_ _11892_ _11893_ VDD VSS BUF_X4
X_21240_ _11893_ _11894_ VDD VSS BUF_X4
X_21241_ _11894_ _14947_ VDD VSS BUF_X4
X_21242_ _11872_ _14922_ VDD VSS BUF_X4
X_21243_ _11891_ _11895_ VDD VSS BUF_X4
X_21244_ _11895_ _11896_ VDD VSS BUF_X4
X_21245_ _11896_ _14940_ VDD VSS BUF_X4
X_21246_ _09071_ _09154_ _11897_ VDD VSS XNOR2_X2
X_21247_ _09165_ _09067_ _11898_ VDD VSS XNOR2_X1
X_21248_ _11897_ _11898_ _11899_ VDD VSS XNOR2_X1
X_21249_ _09070_ _11899_ _11900_ VDD VSS XNOR2_X1
X_21250_ text_in_r\[118\] _11900_ _10571_ _11901_ VDD VSS
+ MUX2_X2
X_21251_ _06575_ _11901_ _11902_ VDD VSS XNOR2_X2
X_21252_ _11902_ _11903_ VDD VSS BUF_X4
X_21253_ _11903_ _11904_ VDD VSS BUF_X4
X_21254_ _11904_ _11905_ VDD VSS CLKBUF_X3
X_21255_ _09190_ _09151_ _11906_ VDD VSS XNOR2_X1
X_21256_ _09089_ _11906_ _11907_ VDD VSS XNOR2_X1
X_21257_ _09187_ _09162_ _11908_ VDD VSS XOR2_X1
X_21258_ _09093_ _11908_ _11909_ VDD VSS XNOR2_X1
X_21259_ _11907_ _11909_ _11910_ VDD VSS XNOR2_X1
X_21260_ text_in_r\[116\] _11910_ _09116_ _11911_ VDD VSS
+ MUX2_X2
X_21261_ _06281_ _11911_ _11912_ VDD VSS XOR2_X2
X_21262_ _11912_ _11913_ VDD VSS BUF_X4
X_21263_ _11913_ _11914_ VDD VSS CLKBUF_X3
X_21264_ _14924_ _11915_ VDD VSS CLKBUF_X3
X_21265_ _11915_ _11916_ VDD VSS INV_X2
X_21266_ _06221_ net830 _11917_ VDD VSS NAND2_X1
X_21267_ _06221_ _11918_ VDD VSS INV_X1
X_21268_ _11918_ net830 _11919_ VDD VSS NAND2_X1
X_21269_ _09042_ _11843_ _11920_ VDD VSS XNOR2_X1
X_21270_ _09094_ _09186_ _11921_ VDD VSS XOR2_X1
X_21271_ _09089_ _11921_ _11922_ VDD VSS XNOR2_X1
X_21272_ _11920_ _11922_ _11923_ VDD VSS XNOR2_X2
X_21273_ _11917_ _11919_ _11923_ _11924_ VDD VSS MUX2_X1
X_21274_ _11924_ _11925_ VDD VSS BUF_X4
X_21275_ _11925_ _11926_ VDD VSS BUF_X4
X_21276_ _11918_ net1000 text_in_r\[115\] _11927_ VDD VSS
+ OR3_X2
X_21277_ _11918_ _09102_ text_in_r\[115\] _11928_ VDD VSS
+ NAND3_X2
X_21278_ _11927_ _11928_ _11929_ VDD VSS AND2_X1
X_21279_ _11929_ _11930_ VDD VSS BUF_X4
X_21280_ _11930_ _11931_ VDD VSS BUF_X4
X_21281_ _11892_ _11926_ _11931_ _11932_ VDD VSS NAND3_X2
X_21282_ _11932_ _11933_ VDD VSS BUF_X4
X_21283_ _11916_ _11933_ _11934_ VDD VSS NOR2_X1
Xclone100 net101 net100 VDD VSS BUF_X2
X_21285_ _11931_ _11926_ _14926_ _11936_ VDD VSS NAND3_X2
X_21286_ _14929_ _11937_ VDD VSS BUF_X8
X_21287_ _08993_ _11938_ VDD VSS BUF_X4
X_21288_ _11918_ _11938_ _11939_ VDD VSS NOR2_X1
X_21289_ _06221_ _11938_ _11940_ VDD VSS NOR2_X1
X_21290_ _11939_ _11940_ _11923_ _11941_ VDD VSS MUX2_X1
X_21291_ _11941_ _11942_ VDD VSS BUF_X8
X_21292_ _11942_ _11943_ VDD VSS BUF_X4
X_21293_ _11927_ _11928_ _11944_ VDD VSS NAND2_X4
X_21294_ _11944_ _11945_ VDD VSS BUF_X4
X_21295_ _11937_ _11943_ _11945_ _11946_ VDD VSS OAI21_X4
X_21296_ _11896_ _11936_ _11946_ _11947_ VDD VSS AND3_X4
X_21297_ _11914_ _11934_ _11947_ _11948_ VDD VSS OAI21_X2
X_21298_ _09161_ _09065_ _11949_ VDD VSS XNOR2_X1
X_21299_ _09187_ _11949_ _11950_ VDD VSS XNOR2_X2
X_21300_ _06269_ _11192_ _09167_ _11951_ VDD VSS NAND3_X2
X_21301_ _06269_ net1085 _11952_ VDD VSS NOR2_X1
X_21302_ _09169_ _11952_ _11953_ VDD VSS NAND2_X1
X_21303_ _11950_ _11951_ _11953_ _11954_ VDD VSS AOI21_X4
X_21304_ _09167_ _11950_ _11952_ _11955_ VDD VSS NAND3_X1
X_21305_ _06269_ _11192_ _09169_ _11950_ _11956_ VDD VSS NAND4_X1
X_21306_ _11955_ _11956_ _11957_ VDD VSS NAND2_X2
X_21307_ _06269_ net1039 text_in_r\[117\] _11958_ VDD VSS
+ OR3_X1
X_21308_ _06269_ _08996_ text_in_r\[117\] _11959_ VDD VSS
+ NAND3_X1
X_21309_ _11958_ _11959_ _11960_ VDD VSS NAND2_X2
X_21310_ _11954_ _11957_ _11960_ _11961_ VDD VSS OR3_X4
X_21311_ _11961_ _11962_ VDD VSS BUF_X4
X_21312_ _11962_ _11963_ VDD VSS BUF_X4
X_21313_ _11912_ _11964_ VDD VSS CLKBUF_X3
X_21314_ _11895_ _11965_ VDD VSS CLKBUF_X3
X_21315_ _11855_ _11965_ _11966_ VDD VSS NAND2_X1
X_21316_ _11925_ _11930_ _11967_ VDD VSS NAND2_X4
X_21317_ _11967_ _11968_ VDD VSS BUF_X4
X_21318_ _14925_ _11969_ VDD VSS BUF_X4
X_21319_ _11969_ _11970_ VDD VSS INV_X8
X_21320_ _11970_ _11891_ _11971_ VDD VSS NOR2_X4
X_21321_ _11968_ _11971_ _11972_ VDD VSS NOR2_X2
X_21322_ _11964_ _11972_ _11966_ _11973_ VDD VSS AOI21_X4
X_21323_ _11967_ _11974_ VDD VSS BUF_X4
X_21324_ _11974_ _11975_ VDD VSS BUF_X4
X_21325_ _14932_ _11976_ VDD VSS CLKBUF_X3
X_21326_ _11976_ _11965_ _11977_ VDD VSS NOR2_X1
X_21327_ _11872_ _11892_ _11978_ VDD VSS NOR2_X2
X_21328_ _11978_ _11979_ VDD VSS BUF_X4
X_21329_ _11975_ _11977_ _11979_ _11980_ VDD VSS OAI21_X1
X_21330_ _11963_ _11980_ _11973_ _11981_ VDD VSS AOI21_X2
X_21331_ _11891_ _11926_ _11931_ _11982_ VDD VSS AOI21_X4
X_21332_ _11874_ _11891_ _11983_ VDD VSS NOR2_X4
X_21333_ _11983_ _11931_ _11926_ _11853_ _11978_ _11984_ VDD
+ VSS AOI221_X2
X_21334_ _11982_ _11984_ _11964_ _11985_ VDD VSS OAI21_X1
X_21335_ _06281_ _11911_ _11986_ VDD VSS XNOR2_X2
X_21336_ _11986_ _11987_ VDD VSS BUF_X4
X_21337_ _11987_ _11988_ VDD VSS BUF_X4
X_21338_ _11892_ _11989_ VDD VSS BUF_X4
X_21339_ _11989_ _11990_ VDD VSS BUF_X4
X_21340_ _14934_ _11925_ _11930_ _11991_ VDD VSS NAND3_X4
X_21341_ net68 _11943_ _11945_ _11992_ VDD VSS OAI21_X1
X_21342_ _11990_ _11991_ _11992_ _11993_ VDD VSS AOI21_X1
X_21343_ _11988_ _11993_ _11994_ VDD VSS NOR2_X1
X_21344_ _11913_ _11984_ _11995_ VDD VSS NOR2_X2
X_21345_ _11937_ _11996_ VDD VSS INV_X2
X_21346_ _11985_ _11994_ _11995_ _11996_ _11933_ _11997_ VDD
+ VSS OAI221_X2
X_21347_ _11963_ _11998_ VDD VSS BUF_X4
X_21348_ _11905_ _11948_ _11981_ _11997_ _11998_ _11999_ VDD
+ VSS AOI221_X2
X_21349_ _09068_ net583 _12000_ VDD VSS XOR2_X2
X_21350_ _08978_ _12000_ _12001_ VDD VSS XNOR2_X1
X_21351_ text_in_r\[119\] _12001_ _09076_ _12002_ VDD VSS
+ MUX2_X2
X_21352_ _06587_ _12002_ _12003_ VDD VSS XOR2_X2
X_21353_ _12003_ _12004_ VDD VSS CLKBUF_X3
X_21354_ _11954_ _11957_ _11960_ _12005_ VDD VSS NOR3_X4
X_21355_ _12005_ _12006_ VDD VSS CLKBUF_X3
X_21356_ _12006_ _12007_ VDD VSS CLKBUF_X3
X_21357_ _11987_ _12008_ VDD VSS CLKBUF_X3
X_21358_ _11968_ _12009_ VDD VSS CLKBUF_X3
X_21359_ _11891_ _11942_ _11944_ _12010_ VDD VSS NOR3_X4
X_21360_ _11969_ _12011_ VDD VSS CLKBUF_X3
X_21361_ _14945_ _12009_ _12010_ _12011_ _12012_ VDD VSS AOI22_X1
X_21362_ _12008_ _12012_ _12013_ VDD VSS OR2_X1
X_21363_ _11988_ _12014_ VDD VSS CLKBUF_X3
X_21364_ _11874_ _11892_ _12015_ VDD VSS NOR2_X4
X_21365_ _11853_ _12016_ VDD VSS BUF_X4
X_21366_ _14929_ net935 _12017_ VDD VSS NOR2_X4
X_21367_ _11968_ _12015_ _12016_ net961 _11894_ _12018_ VDD
+ VSS AOI221_X2
X_21368_ _11942_ _11944_ _12019_ VDD VSS NOR2_X4
X_21369_ _12019_ _12020_ VDD VSS BUF_X4
X_21370_ _12020_ _12021_ VDD VSS CLKBUF_X3
X_21371_ _12021_ _12022_ VDD VSS CLKBUF_X3
X_21372_ _11965_ _12023_ VDD VSS CLKBUF_X3
X_21373_ _11916_ _12023_ _12024_ VDD VSS NAND2_X1
X_21374_ _14931_ _11894_ _12025_ VDD VSS NAND2_X1
X_21375_ _12022_ _12024_ _12025_ _12026_ VDD VSS AOI21_X1
X_21376_ _12014_ _12018_ _12026_ _12027_ VDD VSS OAI21_X1
X_21377_ _12007_ _12013_ _12027_ _12028_ VDD VSS AOI21_X1
X_21378_ _14934_ _12029_ VDD VSS BUF_X4
X_21379_ _14926_ _12030_ VDD VSS INV_X2
X_21380_ _12019_ _12031_ VDD VSS BUF_X4
X_21381_ _11874_ _11925_ _11930_ _12032_ VDD VSS AOI21_X4
X_21382_ _12030_ _12031_ _12032_ _12016_ _12033_ VDD VSS AOI22_X2
X_21383_ _11964_ _11982_ _12029_ _12033_ _12023_ _12034_ VDD
+ VSS AOI221_X1
X_21384_ _11895_ _11943_ _11945_ _12035_ VDD VSS OAI21_X1
X_21385_ _11912_ _12035_ _12030_ _12036_ VDD VSS OAI21_X2
X_21386_ _11968_ _12015_ _12016_ _11894_ _11976_ _12037_ VDD
+ VSS AOI221_X1
X_21387_ _12006_ _12036_ _12037_ _12038_ VDD VSS OAI21_X1
X_21388_ _11905_ _12034_ _12038_ _12039_ VDD VSS OAI21_X1
X_21389_ _12004_ _12028_ _12039_ _12040_ VDD VSS OAI21_X1
X_21390_ _11964_ _12041_ VDD VSS CLKBUF_X3
X_21391_ _11969_ _11926_ _11931_ _12042_ VDD VSS NAND3_X2
X_21392_ _11895_ _12043_ VDD VSS BUF_X4
X_21393_ _12016_ _12043_ _12044_ VDD VSS NOR2_X1
X_21394_ _11970_ _11989_ _12045_ VDD VSS NAND2_X2
X_21395_ _12016_ _11968_ _12046_ VDD VSS NOR2_X2
X_21396_ _11904_ _12042_ _12044_ _12045_ _12046_ _12047_ VDD
+ VSS OAI221_X2
X_21397_ _14938_ _12048_ VDD VSS BUF_X4
X_21398_ _12048_ _12049_ VDD VSS INV_X2
X_21399_ _12049_ _11926_ _11931_ _12050_ VDD VSS AOI21_X4
X_21400_ _12050_ _12021_ _14928_ _12051_ VDD VSS AOI21_X1
Xclone145 net627 net626 VDD VSS BUF_X8
X_21402_ net626 _12031_ _12053_ VDD VSS NAND2_X2
X_21403_ _14940_ _12051_ _12053_ _11983_ _12054_ VDD VSS AOI22_X1
X_21404_ _12047_ _12054_ _11905_ _12055_ VDD VSS OAI21_X1
X_21405_ _12041_ _12055_ _12056_ VDD VSS AND2_X1
X_21406_ _12006_ _12003_ _12057_ VDD VSS NOR2_X1
X_21407_ _06575_ _11901_ _12058_ VDD VSS XOR2_X2
X_21408_ _12058_ _12059_ VDD VSS CLKBUF_X3
X_21409_ _11914_ _12059_ _12060_ VDD VSS NOR2_X2
X_21410_ _11892_ _11942_ _11944_ _12061_ VDD VSS NOR3_X4
X_21411_ _11982_ _12061_ _12062_ VDD VSS NOR2_X4
X_21412_ _11916_ _12062_ _12063_ VDD VSS NOR2_X1
X_21413_ _11976_ _12064_ VDD VSS INV_X1
X_21414_ _12035_ _12065_ VDD VSS CLKBUF_X3
X_21415_ _12064_ _11933_ _12065_ _12011_ _12066_ VDD VSS OAI22_X1
X_21416_ _12060_ _12063_ _12066_ _12067_ VDD VSS OAI21_X1
Xrebuffer297 _09739_ net762 VDD VSS BUF_X2
X_21418_ _11990_ _12069_ VDD VSS BUF_X4
X_21419_ _14926_ net877 _12069_ _12070_ VDD VSS MUX2_X1
X_21420_ _11905_ _12070_ _12022_ _12071_ VDD VSS AOI21_X1
X_21421_ _11995_ _12071_ _12072_ VDD VSS NAND2_X1
X_21422_ _12057_ _12067_ _12072_ _12073_ VDD VSS NAND3_X1
X_21423_ _06587_ _12002_ _12074_ VDD VSS XNOR2_X2
X_21424_ _12074_ _12075_ VDD VSS BUF_X4
X_21425_ _11987_ _12058_ _12076_ VDD VSS NOR2_X2
X_21426_ _11979_ _14922_ net875 _12077_ VDD VSS AOI21_X1
X_21427_ _12009_ _12077_ _12078_ VDD VSS XNOR2_X1
X_21428_ _12076_ _12078_ _12079_ VDD VSS NAND2_X1
X_21429_ _11990_ _12080_ VDD VSS BUF_X4
X_21430_ _12080_ _12050_ _12046_ _12081_ VDD VSS OAI21_X2
X_21431_ _11892_ _11925_ _11930_ _12082_ VDD VSS AOI21_X4
X_21432_ _12011_ _12082_ _12083_ VDD VSS NAND2_X1
X_21433_ _11874_ _11926_ _11931_ _12084_ VDD VSS NAND3_X4
X_21434_ _11987_ _11903_ _12085_ VDD VSS NOR2_X1
X_21435_ _12081_ _12083_ _12084_ _12085_ _12086_ VDD VSS NAND4_X1
X_21436_ _12007_ _12075_ _12079_ _12086_ _12087_ VDD VSS NAND4_X1
X_21437_ _11893_ _11968_ _11976_ _12088_ VDD VSS AOI21_X1
X_21438_ _12088_ _12009_ _12011_ _12089_ VDD VSS OAI21_X1
X_21439_ net875 _14923_ VDD VSS BUF_X32
X_21440_ _14947_ _12021_ _11916_ _12084_ _14923_ _12090_ VDD
+ VSS OAI221_X1
X_21441_ _12059_ _12089_ _12090_ _12091_ VDD VSS AOI21_X1
X_21442_ net2 _11974_ _12092_ VDD VSS NAND2_X2
X_21443_ _11903_ _12082_ _11996_ _12092_ _11983_ _12093_ VDD
+ VSS AOI221_X1
X_21444_ _12041_ _12091_ _12093_ _12094_ VDD VSS NOR3_X1
X_21445_ _11999_ _12040_ _12056_ _12073_ _12087_ _12094_ _00064_
+ VDD VSS OAI222_X2
X_21446_ _11913_ _11902_ _12095_ VDD VSS NAND2_X2
X_21447_ _12069_ _12005_ _12095_ _12096_ VDD VSS NOR3_X1
X_21448_ _12084_ _12020_ net876 _12097_ VDD VSS OAI21_X1
X_21449_ _11967_ _11978_ _11853_ _14932_ _11893_ _12098_ VDD
+ VSS AOI221_X2
X_21450_ _12098_ _12099_ VDD VSS INV_X1
X_21451_ _11987_ _11903_ _12100_ VDD VSS NAND2_X1
X_21452_ _12005_ _12031_ _12101_ VDD VSS NOR2_X1
X_21453_ _14948_ _12102_ VDD VSS INV_X1
X_21454_ _12100_ _12101_ _12102_ _12103_ VDD VSS AOI21_X1
X_21455_ _12003_ _12096_ _12097_ _12099_ _12103_ _12104_ VDD
+ VSS AOI221_X1
X_21456_ _11916_ _11895_ _12105_ VDD VSS NOR2_X1
X_21457_ _12022_ _12015_ _12105_ _12106_ VDD VSS OAI21_X1
X_21458_ _14928_ _11943_ _11945_ _11983_ _11979_ _12107_ VDD
+ VSS OAI221_X1
X_21459_ _11998_ _12106_ _12107_ _12108_ VDD VSS AOI21_X1
X_21460_ _12020_ _12109_ VDD VSS BUF_X4
X_21461_ _11855_ _12109_ _12110_ VDD VSS NAND2_X1
X_21462_ _12023_ _12110_ _12092_ _12111_ VDD VSS AOI21_X1
X_21463_ _12108_ _12111_ _11998_ _12112_ VDD VSS AOI21_X1
X_21464_ _12104_ _12112_ _12095_ _12113_ VDD VSS OAI21_X1
X_21465_ _11969_ _11925_ _11930_ _12114_ VDD VSS AOI21_X4
X_21466_ _11872_ _11943_ _11945_ _12115_ VDD VSS NOR3_X4
X_21467_ net968 _12115_ net991 _12116_ VDD VSS AOI21_X1
X_21468_ _12008_ _11933_ _14931_ _12116_ _14947_ _12117_ VDD
+ VSS OAI221_X1
X_21469_ _12048_ _11925_ _11930_ _12118_ VDD VSS NAND3_X4
X_21470_ _12023_ _12118_ _12119_ VDD VSS NAND2_X1
X_21471_ _11873_ _11851_ net550 _12120_ VDD VSS OAI21_X4
X_21472_ net962 _12120_ _11974_ _12121_ VDD VSS MUX2_X1
X_21473_ _12041_ net968 _12119_ _12121_ _14940_ _12122_ VDD
+ VSS OAI221_X1
X_21474_ _11998_ _12059_ _12117_ _12122_ _12123_ VDD VSS AND4_X1
X_21475_ _11915_ net2 _11967_ _12124_ VDD VSS MUX2_X1
X_21476_ _12097_ _12124_ _11894_ _12125_ VDD VSS MUX2_X1
X_21477_ _12041_ _12125_ _12126_ VDD VSS OR2_X1
X_21478_ _11970_ _11926_ _11931_ _12127_ VDD VSS AOI21_X4
X_21479_ _12043_ _12127_ _12115_ _12128_ VDD VSS NOR3_X2
X_21480_ _11936_ _12031_ _11915_ _12129_ VDD VSS OAI21_X1
X_21481_ _12069_ _12129_ _12130_ VDD VSS NOR2_X1
X_21482_ _12128_ _11988_ _12130_ _12131_ VDD VSS OR3_X2
X_21483_ _12007_ _12059_ _12126_ _12131_ _12132_ VDD VSS AND4_X2
X_21484_ _11872_ _11942_ _11944_ _12133_ VDD VSS OAI21_X4
X_21485_ net99 _12069_ _12133_ _12134_ VDD VSS AOI21_X1
X_21486_ _11961_ _11912_ _12135_ VDD VSS NOR2_X2
X_21487_ _11874_ _11942_ _11944_ _12136_ VDD VSS NOR3_X4
X_21488_ net877 _12136_ _12137_ VDD VSS NAND2_X1
X_21489_ _12065_ _12135_ _12137_ _12138_ VDD VSS NAND3_X1
X_21490_ _11903_ _12134_ _12138_ _12139_ VDD VSS OAI21_X1
X_21491_ _11962_ _11987_ _12140_ VDD VSS NOR2_X2
X_21492_ _11990_ _12133_ _12084_ _12141_ VDD VSS NAND3_X1
X_21493_ _14929_ _11942_ _11944_ _12142_ VDD VSS NOR3_X2
X_21494_ _12114_ _12142_ _12143_ VDD VSS OR2_X1
X_21495_ _12141_ _12143_ _12080_ _12144_ VDD VSS OAI21_X1
X_21496_ _11964_ _11932_ net876 _12062_ net877 _12145_ VDD
+ VSS OAI221_X1
X_21497_ _12049_ _11989_ _12146_ VDD VSS NOR2_X1
X_21498_ _12020_ _11971_ _12146_ _12147_ VDD VSS OR3_X2
X_21499_ _11937_ _11895_ _12148_ VDD VSS NOR2_X2
X_21500_ _12148_ _12015_ _12016_ _12149_ VDD VSS AOI21_X4
X_21501_ _12147_ _12149_ _11975_ _12150_ VDD VSS OAI21_X2
X_21502_ _12145_ _12150_ _11914_ _12151_ VDD VSS OAI21_X2
X_21503_ _12139_ _12140_ _12144_ _12151_ _11963_ _12152_ VDD
+ VSS AOI221_X2
X_21504_ _12048_ _12153_ VDD VSS BUF_X4
X_21505_ _12153_ _11943_ _11945_ _12154_ VDD VSS OAI21_X1
X_21506_ _12023_ _12120_ _12155_ VDD VSS NAND2_X1
X_21507_ _12065_ _12154_ _12155_ _12156_ VDD VSS NAND3_X1
X_21508_ _12005_ _11913_ _12157_ VDD VSS NAND2_X1
X_21509_ _12157_ _12082_ net877 _12158_ VDD VSS AOI21_X1
X_21510_ _12156_ _12158_ _12159_ VDD VSS AND2_X1
X_21511_ _12005_ _11986_ _12160_ VDD VSS NAND2_X1
X_21512_ _12120_ _11967_ _12161_ VDD VSS NAND2_X1
X_21513_ _12114_ _12109_ net876 _12162_ VDD VSS AOI21_X1
X_21514_ _12043_ _12163_ VDD VSS BUF_X4
X_21515_ _12161_ _12162_ _12163_ _12164_ VDD VSS MUX2_X1
X_21516_ _11962_ _11987_ _12165_ VDD VSS NAND2_X1
X_21517_ net68 _12010_ _12166_ VDD VSS NAND2_X1
X_21518_ _11874_ _11942_ _11944_ _12167_ VDD VSS OAI21_X4
X_21519_ _12166_ _12062_ _14931_ _12167_ net992 _12168_ VDD
+ VSS OAI221_X1
X_21520_ _12160_ _12164_ _12165_ _12168_ _12169_ VDD VSS OAI22_X1
X_21521_ _11916_ _11943_ _11945_ _12170_ VDD VSS NOR3_X1
X_21522_ _12043_ _12127_ _12170_ _12171_ VDD VSS OAI21_X1
X_21523_ _12080_ _11946_ _12084_ _12172_ VDD VSS NAND3_X1
X_21524_ _11963_ _11914_ _12171_ _12172_ _12173_ VDD VSS NAND4_X1
X_21525_ _12059_ _12173_ _12174_ VDD VSS NAND2_X1
X_21526_ _12159_ _12169_ _12174_ _12175_ VDD VSS NOR3_X1
X_21527_ _12132_ _12113_ _12123_ _12075_ _12175_ _12152_ _00065_
+ VDD VSS OAI33_X1
X_21528_ _12029_ _11943_ _11945_ _12176_ VDD VSS OAI21_X4
X_21529_ _11896_ _12084_ _12176_ _12177_ VDD VSS NAND3_X1
X_21530_ _11894_ _12118_ _12109_ _11855_ _12178_ VDD VSS OAI211_X2
X_21531_ _12157_ _12177_ _12178_ _12179_ VDD VSS AOI21_X1
X_21532_ _11896_ _11991_ _12109_ net99 _12180_ VDD VSS OAI211_X2
X_21533_ _11913_ _12148_ _12181_ VDD VSS NOR2_X1
X_21534_ _12005_ _12180_ _12181_ _12182_ VDD VSS AOI21_X1
X_21535_ _11896_ _11991_ _12167_ _12183_ VDD VSS NAND3_X1
X_21536_ _11990_ _11946_ _12118_ _12184_ VDD VSS NAND3_X1
X_21537_ _11964_ _12183_ _12184_ _12185_ VDD VSS NAND3_X1
X_21538_ _12163_ _11992_ _12084_ _12186_ VDD VSS NAND3_X1
X_21539_ _12069_ _11991_ _12187_ VDD VSS NAND2_X1
X_21540_ _12186_ _12187_ net968 _12188_ VDD VSS OAI21_X1
X_21541_ _12179_ _12182_ _12185_ _12135_ _12188_ _12189_ VDD
+ VSS AOI221_X2
X_21542_ _12114_ _12170_ _12190_ VDD VSS NOR2_X1
X_21543_ _12080_ _12190_ _12191_ VDD VSS NAND2_X1
X_21544_ _12005_ _12053_ _12088_ _12192_ VDD VSS AOI21_X1
X_21545_ net2 _12019_ _12015_ _12193_ VDD VSS NOR3_X1
X_21546_ net990 _11989_ _12194_ VDD VSS NOR2_X2
X_21547_ _11989_ _12019_ _11852_ _12195_ VDD VSS MUX2_X1
X_21548_ _12193_ _12194_ _12133_ _11970_ _12195_ _12196_ VDD
+ VSS AOI221_X2
X_21549_ _12008_ _12191_ _12192_ _12196_ _12006_ _12197_ VDD
+ VSS AOI221_X2
X_21550_ net1081 _14922_ _11963_ _12198_ VDD VSS NAND3_X1
X_21551_ _11963_ _12045_ _12199_ VDD VSS OR2_X1
X_21552_ _12041_ _12022_ _12200_ VDD VSS NOR2_X1
X_21553_ _14940_ _11962_ _14922_ _11851_ _11848_ _12201_ VDD
+ VSS OAI221_X1
X_21554_ _12198_ _12199_ _12200_ _12201_ _12202_ VDD VSS NAND4_X1
X_21555_ _14945_ _12102_ _11962_ _12203_ VDD VSS MUX2_X1
X_21556_ _12014_ _12022_ _12203_ _12204_ VDD VSS NAND3_X1
X_21557_ _12004_ _12202_ _12204_ _12205_ VDD VSS NAND3_X1
X_21558_ _12004_ _12189_ _12197_ _12205_ _12206_ VDD VSS OAI22_X1
X_21559_ _12135_ _12141_ net877 _12153_ _12065_ _12207_ VDD
+ VSS OAI221_X1
X_21560_ _12074_ _12207_ _12208_ VDD VSS NAND2_X1
X_21561_ net68 _11942_ _11944_ _12209_ VDD VSS NOR3_X4
X_21562_ _12032_ _12209_ _12210_ VDD VSS NOR2_X1
X_21563_ _14926_ net2 _12019_ _12211_ VDD VSS MUX2_X1
X_21564_ _12210_ _12211_ _11893_ _12212_ VDD VSS MUX2_X1
X_21565_ _12118_ _12167_ _12213_ VDD VSS AND2_X4
X_21566_ _11895_ _12020_ _12214_ VDD VSS NAND2_X2
X_21567_ _12092_ _12213_ _12043_ _12214_ _11996_ _12215_ VDD
+ VSS OAI221_X2
X_21568_ _12212_ _12215_ _11962_ _12216_ VDD VSS MUX2_X1
X_21569_ _12021_ _12149_ _12217_ VDD VSS NOR2_X1
X_21570_ _12006_ _12217_ _12218_ VDD VSS NOR2_X1
X_21571_ _12208_ _12041_ _12216_ _11973_ _12218_ _12219_ VDD
+ VSS AOI221_X2
X_21572_ _11962_ _12120_ _11933_ _12220_ VDD VSS AOI21_X1
X_21573_ _14952_ _12005_ _11975_ _12221_ VDD VSS NOR3_X1
X_21574_ _12008_ _12220_ _12221_ _12222_ VDD VSS OR3_X1
X_21575_ _14940_ _11963_ _14922_ _12223_ VDD VSS AOI21_X1
X_21576_ _12223_ _11998_ net1081 _12224_ VDD VSS AOI21_X1
X_21577_ _12222_ _12224_ _12009_ _12225_ VDD VSS AOI21_X1
X_21578_ _11913_ _11982_ _11937_ _12190_ _12163_ _12226_ VDD
+ VSS AOI221_X2
X_21579_ _11976_ _11933_ net960 _12065_ _12227_ VDD VSS OAI22_X1
X_21580_ _12006_ _12008_ _12227_ _12228_ VDD VSS OAI21_X1
X_21581_ _11872_ _11851_ _11848_ _12229_ VDD VSS OAI21_X1
X_21582_ _14940_ _12009_ _12229_ _12230_ VDD VSS NOR3_X1
X_21583_ _12006_ _11964_ _12231_ VDD VSS NOR2_X1
X_21584_ _14943_ _12232_ VDD VSS INV_X1
X_21585_ _12231_ _12022_ _12232_ _12233_ VDD VSS OAI21_X1
X_21586_ _12004_ _12226_ _12228_ _12230_ _12233_ _12234_ VDD
+ VSS OAI221_X1
X_21587_ _11905_ _12225_ _12234_ _12235_ VDD VSS OAI21_X1
X_21588_ _11905_ _12206_ _12235_ _12219_ _00066_ VDD VSS OAI22_X1
X_21589_ _11979_ _12021_ _11982_ _14922_ _12236_ VDD VSS AOI22_X1
X_21590_ net1081 _12236_ _12237_ VDD VSS NOR2_X1
X_21591_ _12008_ _11933_ _12011_ _12065_ _12064_ _12238_ VDD
+ VSS OAI221_X1
X_21592_ _11852_ _12133_ _12239_ VDD VSS NOR2_X2
X_21593_ _12167_ _11975_ _11976_ _12240_ VDD VSS OAI21_X1
X_21594_ _12239_ _12061_ _11970_ _12240_ _12080_ _12241_ VDD
+ VSS AOI221_X2
X_21595_ _12007_ _12237_ _12238_ _12241_ _12014_ _12242_ VDD
+ VSS OAI221_X1
X_21596_ _12011_ _11988_ _12243_ VDD VSS NOR2_X1
X_21597_ _14940_ _12008_ _12092_ _12243_ _12009_ _12244_ VDD
+ VSS OAI221_X1
X_21598_ net1081 _14922_ _12014_ _12245_ VDD VSS NAND3_X1
X_21599_ _11914_ _11991_ _12246_ VDD VSS NAND2_X1
X_21600_ _14947_ _12050_ _12246_ _12041_ _14931_ _12247_ VDD
+ VSS OAI221_X1
X_21601_ _11998_ _12244_ _12245_ _12247_ _12248_ VDD VSS NAND4_X1
X_21602_ _12004_ _12242_ _12248_ _12249_ VDD VSS NAND3_X1
X_21603_ _11979_ _11974_ _12250_ VDD VSS NOR2_X1
X_21604_ _11961_ _11912_ _12251_ VDD VSS NAND2_X2
X_21605_ _12251_ _11894_ _12153_ _12252_ VDD VSS AOI21_X1
X_21606_ _11896_ net960 _12253_ VDD VSS NAND2_X1
X_21607_ _12029_ _11895_ _12254_ VDD VSS NOR2_X2
X_21608_ _12109_ _12254_ _12255_ VDD VSS NOR2_X1
X_21609_ _12098_ _12253_ _12255_ _12256_ VDD VSS AOI21_X1
X_21610_ _12003_ _12250_ _12252_ _12256_ _12231_ _12257_ VDD
+ VSS AOI221_X1
X_21611_ _12023_ _12133_ _12118_ _12258_ VDD VSS AOI21_X1
X_21612_ _11990_ _12042_ _12176_ _12259_ VDD VSS AOI21_X2
X_21613_ _12157_ _12258_ _12259_ _12260_ VDD VSS NOR3_X1
X_21614_ _14931_ _14947_ _12046_ _12261_ VDD VSS OAI21_X1
X_21615_ _12160_ _12010_ net992 _11916_ _12082_ _12262_ VDD
+ VSS AOI221_X2
X_21616_ _12260_ _12261_ _12262_ _12263_ VDD VSS AOI21_X1
X_21617_ _11905_ _12257_ _12263_ _12264_ VDD VSS AOI21_X1
X_21618_ net626 _12043_ _12136_ _12265_ VDD VSS NOR3_X1
X_21619_ _12265_ _12250_ net99 _12011_ _12082_ _12266_ VDD
+ VSS AOI221_X2
X_21620_ _12004_ _12266_ _12267_ VDD VSS NAND2_X1
X_21621_ _12163_ _12154_ _12084_ _12268_ VDD VSS AOI21_X1
X_21622_ _12209_ net960 _12009_ _12269_ VDD VSS AOI21_X1
X_21623_ _12268_ _12269_ _14940_ _12270_ VDD VSS AOI21_X1
X_21624_ _12006_ _12075_ _12270_ _12271_ VDD VSS AOI21_X1
X_21625_ _12080_ _11946_ _12110_ _12272_ VDD VSS AND3_X1
X_21626_ _14947_ _12050_ _12209_ _12273_ VDD VSS NOR3_X1
X_21627_ _12004_ _12272_ _12273_ _12274_ VDD VSS OAI21_X1
X_21628_ _12003_ _12062_ _12029_ _11979_ _12109_ _12275_ VDD
+ VSS AOI221_X2
X_21629_ _11998_ _12275_ _12276_ VDD VSS NOR2_X1
X_21630_ _12267_ _12271_ _12274_ _12276_ _12277_ VDD VSS AOI22_X1
X_21631_ _12114_ _12115_ _12043_ _12278_ VDD VSS NOR3_X2
X_21632_ _11915_ _11976_ _12020_ _12279_ VDD VSS MUX2_X1
X_21633_ _12278_ _12279_ _11896_ _12280_ VDD VSS AOI21_X1
X_21634_ _12127_ _12020_ _12016_ _12281_ VDD VSS AOI21_X2
X_21635_ _11872_ _12061_ _12281_ _11990_ _12282_ VDD VSS AOI22_X2
X_21636_ _12280_ _12282_ _11962_ _12283_ VDD VSS MUX2_X1
X_21637_ _11976_ _11894_ _12284_ VDD VSS NAND2_X1
X_21638_ _12021_ _11966_ _12284_ _12285_ VDD VSS NAND3_X1
X_21639_ _12074_ _12285_ _12006_ _12286_ VDD VSS OAI21_X1
X_21640_ _11990_ _11961_ _12287_ VDD VSS NOR2_X1
X_21641_ _12069_ _12101_ _12287_ _12021_ _12288_ VDD VSS AOI22_X1
X_21642_ _12011_ _12288_ _12289_ VDD VSS NOR2_X1
X_21643_ _12075_ _12283_ _12014_ _12286_ _12289_ _12036_ _12290_
+ VDD VSS OAI33_X1
X_21644_ _12249_ _12264_ _12277_ _12060_ _12290_ _11905_ _00067_
+ VDD VSS AOI222_X2
X_21645_ _12058_ _12003_ _12291_ VDD VSS NOR2_X1
X_21646_ _14936_ _11971_ _11968_ _12292_ VDD VSS MUX2_X1
X_21647_ _12291_ _12292_ _12160_ _12293_ VDD VSS OAI21_X1
X_21648_ _12029_ _12294_ VDD VSS INV_X1
X_21649_ _11893_ _11943_ _11945_ _12295_ VDD VSS OAI21_X4
X_21650_ _12032_ _12019_ net2 _12296_ VDD VSS AOI21_X1
X_21651_ _12294_ _12295_ _12084_ net875 _12296_ _11893_ _12297_
+ VDD VSS OAI222_X2
X_21652_ _11915_ _11926_ _11931_ _12298_ VDD VSS NAND3_X1
X_21653_ _12167_ _12298_ _12299_ VDD VSS NAND2_X1
X_21654_ _12239_ _12061_ _12030_ _12299_ _11989_ _12300_ VDD
+ VSS AOI221_X1
X_21655_ _12297_ _12300_ _11987_ _12301_ VDD VSS MUX2_X1
X_21656_ net991 _12136_ _12176_ _12080_ _12302_ VDD VSS AOI22_X2
X_21657_ _12293_ _12301_ _11963_ _12158_ _12302_ _12303_ VDD
+ VSS AOI221_X2
X_21658_ _11896_ _11975_ _12153_ _12304_ VDD VSS OAI21_X1
X_21659_ _12042_ _12176_ _12305_ VDD VSS AND2_X1
X_21660_ _11988_ _12239_ _12304_ _12305_ _12023_ _12306_ VDD
+ VSS OAI221_X1
X_21661_ _12029_ _11895_ _12307_ VDD VSS NAND2_X1
X_21662_ _12307_ _12143_ _12023_ _12308_ VDD VSS OAI21_X1
X_21663_ _12306_ _12308_ _12008_ _12309_ VDD VSS OAI21_X1
X_21664_ _12007_ _11905_ _12004_ _12309_ _12310_ VDD VSS AND4_X1
X_21665_ net990 _12136_ _12311_ VDD VSS NAND2_X1
X_21666_ _11989_ _11967_ _11915_ _12312_ VDD VSS AOI21_X1
X_21667_ _12142_ _11974_ _11852_ _12313_ VDD VSS AOI21_X1
X_21668_ _11913_ _12311_ _12312_ _12313_ _11990_ _12314_ VDD
+ VSS AOI221_X1
X_21669_ net990 _12032_ _12315_ VDD VSS NAND2_X1
X_21670_ _12069_ _12142_ _12316_ VDD VSS NOR2_X1
X_21671_ _12153_ _12016_ _11974_ _12317_ VDD VSS MUX2_X1
X_21672_ _12315_ _12316_ _12317_ _12080_ _12318_ VDD VSS AOI22_X1
X_21673_ _12314_ _12318_ _12041_ _12319_ VDD VSS AOI21_X1
X_21674_ _12319_ _12059_ _12075_ _12007_ _12320_ VDD VSS NOR4_X2
X_21675_ net876 _11965_ _12321_ VDD VSS NAND2_X1
X_21676_ _11975_ _12045_ _12321_ _12322_ VDD VSS AOI21_X1
X_21677_ _11914_ _11984_ _12322_ _12323_ VDD VSS NOR3_X1
X_21678_ _14940_ _11988_ _12121_ _12324_ VDD VSS NOR3_X1
X_21679_ _11998_ _12323_ _12324_ _12325_ VDD VSS NOR3_X1
X_21680_ _11916_ _11926_ _11931_ _12326_ VDD VSS NAND3_X1
X_21681_ _12163_ _11946_ _12326_ _12327_ VDD VSS AND3_X1
X_21682_ _12111_ _12251_ _12327_ _12328_ VDD VSS NOR3_X1
X_21683_ _11904_ _12003_ _12329_ VDD VSS NOR2_X1
X_21684_ _12153_ _11933_ _12136_ _12080_ _12330_ VDD VSS OAI22_X1
X_21685_ _12329_ _12330_ _12165_ _12331_ VDD VSS OAI21_X1
X_21686_ _11891_ _11967_ _11853_ _12332_ VDD VSS AOI21_X2
X_21687_ _11912_ _12298_ _12332_ _11965_ _14931_ _12333_ VDD
+ VSS AOI221_X2
X_21688_ _12030_ _12019_ _12334_ VDD VSS NAND2_X1
X_21689_ _11986_ _11974_ _12029_ _12334_ _12043_ _12335_ VDD
+ VSS AOI221_X1
X_21690_ _11963_ _12333_ _12335_ _12336_ VDD VSS NOR3_X1
X_21691_ _11893_ _12133_ _11986_ _12337_ VDD VSS MUX2_X1
X_21692_ net992 _12337_ _12338_ VDD VSS NOR2_X1
X_21693_ _12016_ _11965_ _11987_ _12339_ VDD VSS NAND3_X1
X_21694_ _11913_ _12105_ _12340_ VDD VSS NAND2_X1
X_21695_ _12109_ _12339_ _12340_ _12341_ VDD VSS AOI21_X1
X_21696_ _11874_ _11893_ _11986_ _12342_ VDD VSS AOI21_X1
X_21697_ _11975_ _12044_ _12342_ _12343_ VDD VSS NOR3_X1
X_21698_ _12006_ _12338_ _12341_ _12343_ _12344_ VDD VSS NOR4_X1
X_21699_ _12059_ _12003_ _12345_ VDD VSS NAND2_X1
X_21700_ _12325_ _12328_ _12331_ _12336_ _12344_ _12345_ _12346_
+ VDD VSS OAI33_X1
X_21701_ _12303_ _12310_ _12320_ _12346_ _00068_ VDD VSS NOR4_X1
X_21702_ _12069_ _11975_ _12029_ _12133_ net626 _12347_ VDD
+ VSS OAI221_X2
X_21703_ net968 _12031_ net99 _12348_ VDD VSS AOI21_X4
X_21704_ _11903_ _12163_ _12348_ _12349_ VDD VSS AOI21_X2
X_21705_ _11996_ _11965_ _12350_ VDD VSS NOR2_X1
X_21706_ _12153_ _12295_ _12350_ _12009_ _12351_ VDD VSS OAI22_X2
X_21707_ _12008_ _12347_ _12349_ _12351_ _11904_ _12352_ VDD
+ VSS AOI221_X2
X_21708_ net1081 _14922_ _12061_ _12353_ VDD VSS OAI21_X1
X_21709_ _11905_ _12133_ _12353_ _12354_ VDD VSS AOI21_X1
X_21710_ _11979_ _11983_ _11903_ _12355_ VDD VSS AOI21_X1
X_21711_ _11967_ _11902_ _12356_ VDD VSS NAND2_X2
X_21712_ _12014_ _12110_ _12355_ _12356_ _12253_ _12357_ VDD
+ VSS OAI221_X2
X_21713_ _12075_ _12354_ _12357_ _12358_ VDD VSS OAI21_X1
X_21714_ _12254_ _12359_ VDD VSS INV_X1
X_21715_ _11968_ _12015_ _12016_ _12360_ VDD VSS AOI21_X1
X_21716_ _12036_ _12359_ _12360_ _12361_ VDD VSS AOI21_X1
X_21717_ _11894_ _11936_ _11946_ _12362_ VDD VSS AOI21_X1
X_21718_ _11914_ _12362_ _12363_ VDD VSS NOR2_X1
X_21719_ _11904_ _11946_ _12361_ _12363_ _12081_ _12364_ VDD
+ VSS AOI221_X2
X_21720_ _12120_ _12009_ _12010_ _14928_ _12365_ VDD VSS OAI22_X1
X_21721_ _12076_ _12214_ _14931_ _12064_ _12295_ _12366_ VDD
+ VSS OAI221_X2
X_21722_ net991 _12082_ _12367_ VDD VSS NAND2_X1
X_21723_ _14922_ _12053_ _12367_ _12368_ VDD VSS AOI21_X1
X_21724_ _12004_ _12100_ _12365_ _12366_ _12368_ _12369_ VDD
+ VSS OAI221_X2
X_21725_ _12352_ _12358_ _12364_ _12369_ _12370_ VDD VSS OAI22_X2
X_21726_ _11965_ _12167_ _12371_ VDD VSS NOR2_X1
X_21727_ _12163_ _12305_ _12372_ VDD VSS AND2_X1
X_21728_ _12059_ _12371_ _12372_ _12373_ VDD VSS OAI21_X1
X_21729_ net68 _12035_ _12374_ VDD VSS NOR2_X1
X_21730_ _12118_ _12031_ _11915_ _12375_ VDD VSS OAI21_X1
X_21731_ _12374_ _12375_ _12069_ _12376_ VDD VSS AOI21_X1
X_21732_ _11914_ _11904_ _12376_ _12377_ VDD VSS AOI21_X1
X_21733_ _11902_ _12315_ _11893_ _12031_ net876 _12378_ VDD
+ VSS AOI221_X2
X_21734_ _12014_ _12378_ _12379_ VDD VSS NOR2_X1
X_21735_ _11992_ _11936_ _12380_ VDD VSS AND2_X1
X_21736_ _11904_ _12214_ net991 _12380_ _14940_ _12381_ VDD
+ VSS OAI221_X2
X_21737_ _12075_ _12373_ _12377_ _12379_ _12381_ _12382_ VDD
+ VSS AOI221_X2
X_21738_ _12060_ _12214_ _12120_ _12022_ _12064_ _12383_ VDD
+ VSS OAI221_X2
X_21739_ _11970_ _11943_ _11945_ _12384_ VDD VSS NOR3_X4
X_21740_ _14947_ _12384_ net968 _12385_ VDD VSS NOR3_X1
X_21741_ _12118_ _12031_ _11976_ _12386_ VDD VSS OAI21_X1
X_21742_ _12385_ _12386_ _14947_ _12387_ VDD VSS AOI21_X1
X_21743_ _12075_ _12383_ _12387_ _12095_ _12388_ VDD VSS OAI211_X2
X_21744_ _12021_ _12350_ _11979_ _12389_ VDD VSS OAI21_X1
X_21745_ _12120_ _12061_ _12386_ _12069_ _12390_ VDD VSS AOI22_X1
X_21746_ _11904_ _12389_ _11995_ _12390_ _11914_ _12391_ VDD
+ VSS AOI221_X1
X_21747_ _11998_ _12388_ _12391_ _12392_ VDD VSS OAI21_X1
X_21748_ _11998_ _12370_ _12382_ _12392_ _00069_ VDD VSS OAI22_X2
X_21749_ _12153_ _11894_ _12393_ VDD VSS NOR2_X1
X_21750_ _11988_ _12025_ _12393_ _12021_ _12394_ VDD VSS AOI22_X1
X_21751_ _11874_ _12043_ _12395_ VDD VSS NAND2_X1
X_21752_ _12008_ _12009_ _12396_ VDD VSS NAND2_X1
X_21753_ _12329_ _12394_ net1081 _12395_ _12396_ _12397_ VDD
+ VSS OAI221_X1
X_21754_ _12115_ _12015_ net1081 _12398_ VDD VSS AOI21_X1
X_21755_ _12025_ _12133_ net991 _12398_ _12153_ _12399_ VDD
+ VSS OAI221_X2
X_21756_ _12007_ _12397_ _12399_ _12140_ _12400_ VDD VSS AOI22_X1
X_21757_ _12041_ _12374_ _12268_ _12401_ VDD VSS OAI21_X1
X_21758_ _12294_ net877 _12163_ _12402_ VDD VSS MUX2_X1
X_21759_ _14942_ _12402_ _12022_ _12403_ VDD VSS MUX2_X1
X_21760_ _12401_ _12403_ _12041_ _12404_ VDD VSS OAI21_X1
X_21761_ _12400_ _12404_ _12291_ _12405_ VDD VSS AOI21_X1
X_21762_ _11968_ _12058_ _12406_ VDD VSS NOR2_X1
X_21763_ _11969_ _14932_ _11912_ _12407_ VDD VSS MUX2_X1
X_21764_ _11893_ net960 _12408_ VDD VSS OR2_X1
X_21765_ _12406_ _12407_ _11965_ _12408_ _11913_ _12409_ VDD
+ VSS OAI221_X1
X_21766_ net990 _11874_ _11986_ _12410_ VDD VSS AOI21_X1
X_21767_ _11872_ _11892_ _12411_ VDD VSS NAND2_X1
X_21768_ _11912_ _12411_ _12412_ VDD VSS NOR2_X1
X_21769_ _11979_ _12356_ _12410_ _12412_ _12413_ VDD VSS OR4_X1
X_21770_ _12003_ _12409_ _12413_ _12414_ VDD VSS AND3_X2
X_21771_ _11892_ _11991_ _12415_ VDD VSS AND2_X1
X_21772_ _14926_ _11967_ _12416_ VDD VSS NAND2_X1
X_21773_ _11891_ _12118_ _12417_ VDD VSS AND2_X1
X_21774_ _11912_ _12161_ _12415_ _12416_ _12417_ _12418_ VDD
+ VSS AOI221_X1
X_21775_ _11989_ _12017_ _12419_ VDD VSS NAND2_X2
X_21776_ _11912_ _12419_ _12019_ _11932_ _11970_ _12420_ VDD
+ VSS OAI221_X2
X_21777_ _12084_ _12020_ _12029_ _12421_ VDD VSS OAI21_X1
X_21778_ _12420_ _12421_ _12043_ _12422_ VDD VSS AOI21_X2
X_21779_ _12422_ _12418_ _11903_ _12423_ VDD VSS OR3_X4
X_21780_ _12029_ _12064_ _12020_ _12424_ VDD VSS MUX2_X1
X_21781_ _12076_ _12424_ _12023_ _12065_ net991 _12425_ VDD
+ VSS OAI221_X1
X_21782_ _12058_ _12295_ _14931_ _12426_ VDD VSS OAI21_X1
X_21783_ _11988_ _12149_ _12356_ _12426_ _12259_ _12427_ VDD
+ VSS OAI221_X2
X_21784_ _12065_ _12163_ net992 _12428_ VDD VSS OAI21_X1
X_21785_ _12085_ _12428_ _12115_ _12429_ VDD VSS OAI21_X1
X_21786_ _12425_ _12427_ _12429_ _12430_ VDD VSS NAND3_X1
X_21787_ _12007_ _12423_ _12414_ _12430_ _12075_ _12431_ VDD
+ VSS AOI221_X2
X_21788_ _11904_ _12022_ _14943_ _12432_ VDD VSS OAI21_X1
X_21789_ _12011_ _12229_ _12080_ _12433_ VDD VSS MUX2_X1
X_21790_ _12432_ _12433_ _12022_ _12434_ VDD VSS AOI21_X1
X_21791_ _12326_ _12176_ _12435_ VDD VSS NAND2_X1
X_21792_ _11903_ _12435_ _12163_ _11982_ net962 _12436_ VDD
+ VSS AOI221_X2
X_21793_ _12014_ _12434_ _12436_ _12437_ VDD VSS NOR3_X1
X_21794_ _12161_ _12194_ _12438_ VDD VSS NOR2_X1
X_21795_ _14941_ _14950_ _11975_ _12439_ VDD VSS OR3_X1
X_21796_ _12014_ _12059_ _12439_ _12440_ VDD VSS NAND3_X1
X_21797_ _11990_ _12384_ _11975_ net99 _12441_ VDD VSS AOI211_X2
X_21798_ _12441_ _12033_ _14947_ _12442_ VDD VSS AOI21_X1
X_21799_ _12438_ _12440_ _12442_ _12100_ _12443_ VDD VSS OAI22_X1
X_21800_ _12004_ _12437_ _12443_ _12444_ VDD VSS OAI21_X1
X_21801_ _12007_ _12414_ _12423_ _12445_ VDD VSS AOI21_X1
X_21802_ _12431_ _12405_ _12444_ _12445_ _00070_ VDD VSS OAI22_X1
X_21803_ _11989_ _12114_ _12019_ net990 _12446_ VDD VSS AOI211_X2
X_21804_ _11964_ _12128_ _12446_ _12447_ VDD VSS OAI21_X2
X_21805_ _14950_ _12031_ _12448_ VDD VSS NOR2_X1
X_21806_ _12020_ _12045_ _12307_ _12449_ VDD VSS AND3_X1
X_21807_ _11987_ _12448_ _12449_ _12450_ VDD VSS OAI21_X1
X_21808_ _11962_ _12447_ _12450_ _12451_ VDD VSS AND3_X4
X_21809_ _14936_ _12109_ _12452_ VDD VSS NOR2_X1
X_21810_ _12030_ _11965_ _11968_ _12453_ VDD VSS NOR3_X1
X_21811_ _11988_ _12452_ _12453_ _12454_ VDD VSS OAI21_X1
X_21812_ _11937_ _11853_ _11989_ _12455_ VDD VSS MUX2_X1
X_21813_ _12395_ _12031_ _12456_ VDD VSS NAND2_X1
X_21814_ _11964_ _12109_ _12455_ _12456_ net626 _12457_ VDD
+ VSS OAI221_X1
X_21815_ _11963_ _12454_ _12457_ _12458_ VDD VSS AOI21_X1
X_21816_ _12458_ _12075_ _12451_ _12059_ _12459_ VDD VSS NOR4_X4
X_21817_ _11904_ _12074_ _12460_ VDD VSS NAND2_X1
X_21818_ _12010_ _12082_ _11872_ _12461_ VDD VSS MUX2_X1
X_21819_ _12251_ _12461_ _11855_ _12061_ net68 _12462_ VDD
+ VSS AOI221_X2
X_21820_ _12120_ _12109_ _12463_ VDD VSS NOR2_X1
X_21821_ _14947_ _12384_ _12463_ _12165_ _12464_ VDD VSS NOR4_X1
X_21822_ _12460_ _12462_ _12464_ _12465_ VDD VSS NOR3_X1
X_21823_ _11933_ _12167_ _12466_ VDD VSS NAND2_X1
X_21824_ net877 _12466_ _12467_ VDD VSS NAND2_X1
X_21825_ _11914_ _12311_ _12467_ _12468_ VDD VSS AOI21_X1
X_21826_ _11982_ _12021_ _11979_ _12469_ VDD VSS AOI21_X1
X_21827_ _12115_ _12082_ _14922_ _12470_ VDD VSS AOI21_X1
X_21828_ net1081 _12469_ _12470_ _11988_ _12471_ VDD VSS OAI22_X1
X_21829_ _12007_ _12468_ _12471_ _12472_ VDD VSS OAI21_X1
X_21830_ net990 _11974_ _12473_ VDD VSS NAND2_X1
X_21831_ _11964_ _12473_ _12415_ _12213_ _12023_ _12474_ VDD
+ VSS AOI221_X1
X_21832_ _14931_ _11933_ _12065_ _12153_ _12011_ _12062_ _12475_
+ VDD VSS OAI222_X2
X_21833_ _12014_ _12475_ _12476_ VDD VSS NOR2_X1
X_21834_ _12057_ _12474_ _12476_ _12477_ VDD VSS OAI21_X1
X_21835_ _12005_ _12334_ _12332_ _11895_ _11916_ _12478_ VDD
+ VSS AOI221_X1
X_21836_ _11976_ _11974_ _12115_ _11853_ _12479_ VDD VSS AOI22_X1
X_21837_ _11896_ _11961_ _12479_ _12480_ VDD VSS NOR3_X1
X_21838_ _11913_ _12074_ _12481_ VDD VSS NOR2_X1
X_21839_ _12481_ _12171_ _11962_ _12482_ VDD VSS OAI21_X1
X_21840_ _12478_ _12480_ _12482_ _12483_ VDD VSS OR3_X1
X_21841_ _12161_ _12194_ _12484_ VDD VSS OR2_X1
X_21842_ _12074_ _12142_ _12251_ _12485_ VDD VSS NOR3_X1
X_21843_ _12473_ _12417_ _12486_ VDD VSS NAND2_X1
X_21844_ _12005_ _11986_ _12074_ _12487_ VDD VSS NAND3_X1
X_21845_ _12487_ _12254_ _11974_ _12488_ VDD VSS AOI21_X1
X_21846_ _11903_ _12484_ _12485_ _12486_ _12488_ _12489_ VDD
+ VSS AOI221_X1
X_21847_ net992 _12136_ _12371_ _12490_ VDD VSS OAI21_X1
X_21848_ _11872_ _12010_ _12082_ _11915_ _12491_ VDD VSS AOI22_X1
X_21849_ _12074_ _12140_ _12490_ _12491_ _12492_ VDD VSS NAND4_X1
X_21850_ _12053_ _12421_ _11896_ net960 _12065_ _12493_ VDD
+ VSS OAI221_X1
X_21851_ _12003_ _12140_ _12493_ _12494_ VDD VSS NAND3_X1
X_21852_ _12483_ _12489_ _12492_ _12494_ _12495_ VDD VSS AND4_X1
X_21853_ _12459_ _12465_ _12472_ _12477_ _12495_ _00071_ VDD
+ VSS AOI221_X2
X_21854_ _06256_ _09023_ _12496_ VDD VSS NAND2_X1
X_21855_ _06256_ _09015_ _12497_ VDD VSS OR2_X1
X_21856_ net771 sa30_sub\[1\] _12498_ VDD VSS XNOR2_X2
X_21857_ _12498_ _09797_ _12499_ VDD VSS XNOR2_X2
X_21858_ net497 _09739_ _12500_ VDD VSS XNOR2_X1
X_21859_ _12499_ _12500_ _12501_ VDD VSS XNOR2_X2
X_21860_ _12496_ _12497_ _12501_ _12502_ VDD VSS MUX2_X2
X_21861_ _06256_ _09194_ _00455_ _12503_ VDD VSS NOR3_X2
X_21862_ _06256_ _09727_ _12504_ VDD VSS AND2_X1
X_21863_ _12503_ _12504_ _00455_ _12505_ VDD VSS AOI21_X4
X_21864_ _12502_ _12505_ _12506_ VDD VSS AND2_X4
Xrebuffer307 net889 net772 VDD VSS BUF_X4
X_21866_ net888 _12508_ VDD VSS INV_X32
Xclone169 _15204_ net169 VDD VSS BUF_X2
Xrebuffer511 _00945_ net1134 VDD VSS BUF_X4
X_21869_ sa01_sr\[0\] sa30_sub\[0\] _12510_ VDD VSS XNOR2_X2
X_21870_ net768 net595 _12511_ VDD VSS XNOR2_X1
X_21871_ _09796_ net563 _12512_ VDD VSS XOR2_X2
X_21872_ _09012_ _06242_ _12512_ _12513_ VDD VSS NAND3_X4
X_21873_ _06242_ _09015_ _12514_ VDD VSS NOR2_X1
X_21874_ _09797_ _12514_ _12515_ VDD VSS NAND2_X1
X_21875_ _12511_ _12515_ _12513_ _12516_ VDD VSS AOI21_X4
X_21876_ net893 net505 _12517_ VDD VSS XOR2_X2
X_21877_ net768 _12517_ _12518_ VDD VSS XNOR2_X1
X_21878_ _12512_ _12514_ _12519_ VDD VSS NAND2_X1
X_21879_ _06242_ _09023_ _09797_ _12520_ VDD VSS NAND3_X1
X_21880_ _12518_ _12519_ _12520_ _12521_ VDD VSS AOI21_X2
X_21881_ _06242_ _12522_ VDD VSS INV_X1
X_21882_ _12522_ _09028_ _00456_ _12523_ VDD VSS NAND3_X1
X_21883_ _06242_ _09030_ _12524_ VDD VSS NAND2_X1
X_21884_ _12523_ _12524_ _00456_ _12525_ VDD VSS OAI21_X1
X_21885_ _12516_ _12521_ _12525_ _12526_ VDD VSS OR3_X4
X_21886_ _12526_ _12527_ VDD VSS INV_X8
Xsplit91 net747 net91 VDD VSS BUF_X2
X_21888_ _12527_ _14963_ VDD VSS BUF_X8
X_21889_ _09759_ _09835_ _12529_ VDD VSS XNOR2_X2
X_21890_ _09763_ _12529_ _12530_ VDD VSS XNOR2_X1
X_21891_ _06297_ _12531_ VDD VSS INV_X1
X_21892_ _12531_ net1083 net538 _12532_ VDD VSS OR3_X1
X_21893_ _12531_ net1000 net538 _12533_ VDD VSS NAND3_X1
X_21894_ _12530_ _12532_ _12533_ _12534_ VDD VSS AOI21_X2
X_21895_ _09759_ _09835_ _12535_ VDD VSS XOR2_X2
X_21896_ _09763_ _12535_ _12536_ VDD VSS XNOR2_X1
X_21897_ _06297_ _08992_ net538 _12537_ VDD VSS OR3_X1
X_21898_ _06297_ net828 net539 _12538_ VDD VSS NAND3_X1
X_21899_ _12536_ _12537_ _12538_ _12539_ VDD VSS AOI21_X2
X_21900_ _12531_ _09015_ _00457_ _12540_ VDD VSS NAND3_X1
X_21901_ _06297_ _09015_ _12541_ VDD VSS NAND2_X1
X_21902_ _12540_ _12541_ _00457_ _12542_ VDD VSS OAI21_X2
X_21903_ _12534_ _12539_ _12542_ _12543_ VDD VSS NOR3_X4
X_21904_ _12543_ _12544_ VDD VSS INV_X2
X_21905_ _12544_ _12545_ VDD VSS BUF_X4
X_21906_ _12545_ _12546_ VDD VSS BUF_X4
X_21907_ _12546_ _12547_ VDD VSS BUF_X4
X_21908_ _12547_ _14979_ VDD VSS BUF_X4
X_21909_ _12526_ _12548_ VDD VSS BUF_X16
X_21910_ _12548_ _12549_ VDD VSS BUF_X32
X_21911_ _12549_ _14954_ VDD VSS BUF_X32
X_21912_ _12543_ _12550_ VDD VSS BUF_X4
X_21913_ _12550_ _12551_ VDD VSS BUF_X4
X_21914_ _12551_ _12552_ VDD VSS BUF_X4
X_21915_ _12552_ _14972_ VDD VSS BUF_X4
X_21916_ _06282_ _12553_ VDD VSS INV_X1
X_21917_ _12553_ _09028_ _12554_ VDD VSS NOR2_X1
X_21918_ _06282_ _09028_ _12555_ VDD VSS NOR2_X1
X_21919_ _09872_ _09796_ _12556_ VDD VSS XNOR2_X1
X_21920_ _09836_ _12556_ _12557_ VDD VSS XNOR2_X2
X_21921_ _09869_ _09813_ _12558_ VDD VSS XOR2_X1
X_21922_ _09840_ _12558_ _12559_ VDD VSS XNOR2_X1
X_21923_ _12557_ _12559_ _12560_ VDD VSS XNOR2_X1
X_21924_ _12554_ _12555_ _12560_ _12561_ VDD VSS MUX2_X2
X_21925_ _12553_ _11938_ text_in_r\[84\] _12562_ VDD VSS NAND3_X1
X_21926_ _06282_ _11841_ _12563_ VDD VSS NAND2_X1
X_21927_ _12562_ _12563_ text_in_r\[84\] _12564_ VDD VSS OAI21_X4
X_21928_ _12561_ _12564_ _12565_ VDD VSS OR2_X1
X_21929_ _12565_ _12566_ VDD VSS BUF_X4
X_21930_ _12566_ _12567_ VDD VSS BUF_X4
X_21931_ _12567_ _12568_ VDD VSS CLKBUF_X3
X_21932_ _08992_ text_in_r\[83\] _12569_ VDD VSS NAND2_X2
X_21933_ _06222_ net1084 _12569_ _12570_ VDD VSS NAND3_X2
X_21934_ _06222_ _12569_ _12571_ VDD VSS OR2_X1
X_21935_ _12570_ _12571_ _12572_ VDD VSS AND2_X2
X_21936_ _06222_ _12569_ _12573_ VDD VSS NAND2_X1
X_21937_ _06222_ _09727_ _12574_ VDD VSS OR2_X1
X_21938_ _09841_ _09796_ _12575_ VDD VSS XNOR2_X2
X_21939_ _09764_ _12575_ _12576_ VDD VSS XNOR2_X1
X_21940_ _09836_ _09868_ _12577_ VDD VSS XOR2_X2
X_21941_ net564 _12577_ _12578_ VDD VSS XNOR2_X2
X_21942_ _12576_ _12578_ _12579_ VDD VSS XNOR2_X2
X_21943_ _12573_ _12574_ _12579_ _12580_ VDD VSS MUX2_X2
X_21944_ _12572_ _12580_ _12581_ VDD VSS NAND2_X4
X_21945_ _12581_ _12582_ VDD VSS BUF_X4
X_21946_ net1007 _12582_ _12583_ VDD VSS NOR2_X1
X_21947_ net1122 _12547_ _12584_ VDD VSS NAND2_X1
Xsplit171 net938 net171 VDD VSS CLKBUF_X2
X_21949_ _12570_ _12571_ _12586_ VDD VSS NAND2_X4
X_21950_ _06222_ _12569_ _12587_ VDD VSS AND2_X1
X_21951_ _06222_ net1086 _12588_ VDD VSS NOR2_X1
X_21952_ _12587_ _12588_ _12579_ _12589_ VDD VSS MUX2_X1
X_21953_ _12589_ _12590_ VDD VSS BUF_X8
X_21954_ _12586_ _12590_ _12591_ VDD VSS NOR2_X4
X_21955_ _12591_ _12592_ VDD VSS BUF_X4
X_21956_ _12592_ _12593_ VDD VSS BUF_X4
X_21957_ net168 net1009 _12593_ _12594_ VDD VSS MUX2_X1
X_21958_ _12568_ _12583_ _12584_ _12594_ _14979_ _12595_ VDD
+ VSS OAI221_X1
X_21959_ _12572_ _12596_ VDD VSS BUF_X8
X_21960_ _12580_ _12597_ VDD VSS BUF_X8
X_21961_ _12543_ _12596_ _12597_ _12598_ VDD VSS AOI21_X2
X_21962_ _12598_ _12599_ VDD VSS BUF_X4
X_21963_ net773 _12599_ _12600_ VDD VSS NAND2_X2
X_21964_ _12550_ _12601_ VDD VSS BUF_X4
X_21965_ _12596_ _12602_ VDD VSS BUF_X4
X_21966_ _12597_ _12603_ VDD VSS BUF_X4
X_21967_ _12601_ _12602_ _12603_ _12604_ VDD VSS NAND3_X2
X_21968_ _14958_ _12605_ VDD VSS BUF_X4
X_21969_ _12506_ _12606_ VDD VSS BUF_X8
X_21970_ _12606_ _14955_ VDD VSS BUF_X16
X_21971_ _12550_ _12586_ _12590_ _12607_ VDD VSS NOR3_X4
X_21972_ _12544_ _12596_ _12597_ _12608_ VDD VSS AOI21_X4
X_21973_ _12608_ _12609_ VDD VSS BUF_X4
X_21974_ _12607_ _12609_ _14963_ _12610_ VDD VSS AOI21_X1
X_21975_ _12600_ _12604_ _12605_ _14955_ _12610_ _12611_ VDD
+ VSS OAI221_X1
X_21976_ _12568_ _12612_ VDD VSS CLKBUF_X3
X_21977_ _12595_ _12611_ _12612_ _12613_ VDD VSS OAI21_X1
X_21978_ _09809_ _09789_ _12614_ VDD VSS XNOR2_X2
X_21979_ _09869_ _12614_ _12615_ VDD VSS XNOR2_X2
X_21980_ _09808_ _09814_ _12616_ VDD VSS XNOR2_X1
X_21981_ _12615_ _12616_ _12617_ VDD VSS XNOR2_X1
X_21982_ text_in_r\[85\] _12617_ net871 _12618_ VDD VSS MUX2_X2
X_21983_ _06270_ _12618_ _12619_ VDD VSS XOR2_X2
X_21984_ _12619_ _12620_ VDD VSS BUF_X4
X_21985_ _12620_ _12621_ VDD VSS BUF_X4
X_21986_ _12621_ _12622_ VDD VSS CLKBUF_X3
X_21987_ _09712_ _09799_ _12623_ VDD VSS XNOR2_X2
X_21988_ _09788_ net576 _12624_ VDD VSS XNOR2_X1
X_21989_ _09796_ _12624_ _12625_ VDD VSS XNOR2_X1
X_21990_ text_in_r\[87\] _12625_ _09803_ _12626_ VDD VSS MUX2_X2
X_21991_ _06588_ _12626_ _12627_ VDD VSS XOR2_X2
X_21992_ _09790_ _09798_ _12628_ VDD VSS XNOR2_X1
X_21993_ _09814_ _12628_ _12629_ VDD VSS XNOR2_X2
X_21994_ _09785_ _09787_ _12630_ VDD VSS XNOR2_X1
X_21995_ _12629_ _12630_ _12631_ VDD VSS XNOR2_X1
X_21996_ text_in_r\[86\] _12631_ _11192_ _12632_ VDD VSS MUX2_X2
X_21997_ _06576_ _12632_ _12633_ VDD VSS XNOR2_X2
X_21998_ _12633_ _12634_ VDD VSS BUF_X4
X_21999_ _12622_ _12627_ _12634_ _12635_ VDD VSS NOR3_X1
X_22000_ _06270_ _12618_ _12636_ VDD VSS XNOR2_X2
X_22001_ _12636_ _12637_ VDD VSS BUF_X4
X_22002_ _12637_ _12633_ _12638_ VDD VSS NAND2_X1
X_22003_ _12627_ _12638_ _12639_ VDD VSS NOR2_X1
X_22004_ _12508_ _12543_ _12640_ VDD VSS NOR2_X1
X_22005_ _14957_ _12641_ VDD VSS BUF_X8
X_22006_ net1091 _12602_ _12603_ _12642_ VDD VSS NAND3_X4
X_22007_ _12641_ _12643_ VDD VSS INV_X16
X_22008_ _12544_ _12644_ VDD VSS CLKBUF_X3
X_22009_ _12644_ _12645_ VDD VSS CLKBUF_X3
X_22010_ _12643_ _12645_ _12646_ VDD VSS NAND2_X1
X_22011_ _12640_ _12642_ _12646_ _12583_ _12647_ VDD VSS OAI22_X1
X_22012_ _14964_ _12648_ VDD VSS BUF_X2
X_22013_ _12648_ _12649_ VDD VSS INV_X2
X_22014_ _12649_ _12607_ _12650_ VDD VSS NAND2_X1
X_22015_ _12544_ _12586_ _12590_ _12651_ VDD VSS NOR3_X2
X_22016_ _12598_ _12651_ _12652_ VDD VSS NOR2_X2
Xclone127 net678 net127 VDD VSS BUF_X8
X_22018_ _12586_ _12654_ VDD VSS BUF_X4
X_22019_ _12590_ _12655_ VDD VSS BUF_X4
X_22020_ _12601_ _12654_ _12655_ _12656_ VDD VSS OAI21_X4
X_22021_ _12650_ _12652_ _14956_ _12656_ _12643_ _12657_ VDD
+ VSS OAI221_X1
X_22022_ _12561_ _12564_ _12658_ VDD VSS NOR2_X4
X_22023_ _12658_ _12659_ VDD VSS BUF_X4
X_22024_ _12659_ _12660_ VDD VSS BUF_X4
X_22025_ _12660_ _12661_ VDD VSS BUF_X4
X_22026_ _12647_ _12657_ _12661_ _12662_ VDD VSS MUX2_X1
X_22027_ _12613_ _12635_ _12639_ _12662_ _12663_ VDD VSS AOI22_X2
X_22028_ _06588_ _12626_ _12664_ VDD VSS XNOR2_X2
X_22029_ _06576_ _12632_ _12665_ VDD VSS XOR2_X2
X_22030_ _12665_ _12666_ VDD VSS CLKBUF_X3
X_22031_ _12660_ _12667_ VDD VSS CLKBUF_X3
X_22032_ _12526_ _12586_ _12590_ _12668_ VDD VSS NOR3_X4
X_22033_ _14970_ _12602_ _12603_ _12669_ VDD VSS AOI21_X2
X_22034_ _12669_ _12592_ net1008 _12670_ VDD VSS AOI21_X2
X_22035_ _12641_ _12671_ VDD VSS BUF_X16
X_22036_ _12668_ _12670_ _12546_ net1090 _12609_ _12672_ VDD
+ VSS AOI221_X2
X_22037_ _12508_ _12591_ _12673_ VDD VSS NOR2_X2
X_22038_ _12584_ _12673_ _12674_ VDD VSS NOR2_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
X_22040_ _14961_ _12676_ VDD VSS BUF_X4
X_22041_ _12661_ _12656_ net890 _12677_ VDD VSS OAI21_X1
X_22042_ _12666_ _12667_ _12672_ _12674_ _12677_ _12678_ VDD
+ VSS OAI221_X1
X_22043_ _12567_ _12679_ VDD VSS BUF_X4
X_22044_ _12665_ _12679_ _12680_ VDD VSS NOR2_X1
X_22045_ _12644_ _12681_ VDD VSS BUF_X4
X_22046_ _12681_ _12682_ VDD VSS CLKBUF_X3
X_22047_ _12671_ _12654_ _12655_ _12683_ VDD VSS NOR3_X4
X_22048_ _12649_ _12596_ _12597_ _12684_ VDD VSS AOI21_X4
X_22049_ _12682_ net1055 _12684_ _12685_ VDD VSS NOR3_X1
X_22050_ _12601_ _12686_ VDD VSS CLKBUF_X3
X_22051_ _12686_ _12687_ VDD VSS CLKBUF_X3
X_22052_ _12582_ _12688_ VDD VSS CLKBUF_X3
X_22053_ _12688_ _12689_ VDD VSS CLKBUF_X3
X_22054_ _12687_ _12689_ net515 _12690_ VDD VSS AOI21_X1
X_22055_ net1008 _12668_ _12691_ VDD VSS NAND2_X4
X_22056_ _12685_ _12690_ _12691_ _12692_ VDD VSS AOI21_X1
X_22057_ _12665_ _12660_ _12693_ VDD VSS NOR2_X2
X_22058_ net773 _12545_ _12694_ VDD VSS NOR2_X2
X_22059_ _12606_ _12695_ VDD VSS CLKBUF_X3
X_22060_ _12694_ _14954_ _12695_ _12696_ VDD VSS AOI21_X1
X_22061_ _12689_ _12696_ _12697_ VDD VSS XNOR2_X1
X_22062_ _12680_ _12692_ _12693_ _12697_ _12698_ VDD VSS AOI22_X1
X_22063_ _12622_ _12664_ _12678_ _12698_ _12699_ VDD VSS NAND4_X1
X_22064_ _12636_ _12665_ _12700_ VDD VSS NOR2_X2
X_22065_ _12581_ _12701_ VDD VSS CLKBUF_X3
X_22066_ _12701_ _12702_ VDD VSS CLKBUF_X3
X_22067_ _12548_ _12586_ _12590_ _12703_ VDD VSS OAI21_X4
X_22068_ _12687_ _12702_ _12605_ _12703_ _14955_ _12704_ VDD
+ VSS OAI221_X1
Xsplit170 _15270_ net170 VDD VSS BUF_X1
X_22070_ _14966_ _12599_ _12706_ VDD VSS NAND2_X1
X_22071_ _12667_ _12704_ _12706_ _12707_ VDD VSS AND3_X1
X_22072_ _12545_ _12602_ _12603_ _12708_ VDD VSS NAND3_X4
X_22073_ _12648_ _12708_ _12709_ VDD VSS NOR2_X1
X_22074_ _12605_ _12710_ VDD VSS INV_X1
X_22075_ _12527_ _12654_ _12655_ _12711_ VDD VSS NOR3_X4
X_22076_ _12546_ _12582_ _12710_ _12711_ net1007 _12712_ VDD
+ VSS AOI221_X2
X_22077_ _12667_ _12709_ _12712_ _12713_ VDD VSS NOR3_X1
X_22078_ _12700_ _12707_ _12713_ _12714_ VDD VSS OAI21_X1
X_22079_ _12637_ _12715_ VDD VSS CLKBUF_X3
X_22080_ _12715_ _12716_ VDD VSS CLKBUF_X3
X_22081_ _12716_ _12634_ _12717_ VDD VSS NOR2_X1
X_22082_ _12605_ _12654_ _12655_ _12718_ VDD VSS NOR3_X4
X_22083_ _12676_ _12602_ _12603_ _12719_ VDD VSS AOI21_X2
X_22084_ _12718_ _12719_ _12720_ VDD VSS NOR2_X1
X_22085_ _14979_ _12720_ _12721_ VDD VSS NOR2_X1
X_22086_ _14956_ _12722_ VDD VSS INV_X4
X_22087_ _12568_ _12708_ _12722_ _12723_ VDD VSS OAI21_X1
X_22088_ _12526_ _12596_ _12597_ _12724_ VDD VSS AOI21_X4
X_22089_ _12591_ _12725_ VDD VSS CLKBUF_X3
X_22090_ _12725_ _12726_ VDD VSS CLKBUF_X3
X_22091_ _12724_ _12726_ _14955_ _12727_ VDD VSS AOI21_X1
X_22092_ _12683_ _12702_ _12649_ _12728_ VDD VSS AOI21_X2
X_22093_ _12727_ _12728_ _12682_ _12729_ VDD VSS MUX2_X1
X_22094_ _12717_ _12721_ _12723_ _12612_ _12729_ _12730_ VDD
+ VSS OAI221_X2
X_22095_ _12627_ _12730_ _12714_ _12731_ VDD VSS NAND3_X2
X_22096_ _12641_ _12596_ _12597_ _12732_ VDD VSS AOI21_X4
X_22097_ net1123 _12654_ _12655_ _12733_ VDD VSS NOR3_X2
X_22098_ _12687_ net766 _12733_ _12734_ VDD VSS OAI21_X1
X_22099_ net887 _12735_ VDD VSS INV_X8
X_22100_ _12735_ _12607_ _12736_ VDD VSS NAND2_X1
X_22101_ _12666_ _12568_ _12734_ _12736_ _12737_ VDD VSS NAND4_X1
X_22102_ _12735_ _12726_ _12738_ VDD VSS NAND2_X1
X_22103_ _12665_ _12661_ _12600_ _12738_ _12739_ VDD VSS NAND4_X1
X_22104_ _12548_ _12505_ net518 _12740_ VDD VSS AOI21_X4
X_22105_ _12592_ _12740_ _12741_ VDD VSS NOR2_X2
X_22106_ _14979_ _12741_ _12742_ VDD VSS NOR2_X1
X_22107_ _12737_ _12739_ _12742_ _12743_ VDD VSS OAI21_X1
X_22108_ _12641_ _12545_ _12744_ VDD VSS NAND2_X2
X_22109_ _12592_ _12744_ _12745_ VDD VSS NAND2_X1
X_22110_ _12745_ _12725_ _14977_ _12746_ VDD VSS OAI21_X1
X_22111_ _12527_ _12544_ _12747_ VDD VSS NOR2_X2
X_22112_ _12545_ _12735_ _12747_ net1007 _12748_ VDD VSS AOI22_X4
X_22113_ _12566_ _12748_ _12592_ _12749_ VDD VSS AOI21_X4
X_22114_ _12605_ _12602_ _12603_ _12750_ VDD VSS NAND3_X2
X_22115_ _12527_ _12586_ _12590_ _12751_ VDD VSS OAI21_X4
X_22116_ _12551_ _12750_ _12751_ _12752_ VDD VSS AOI21_X1
X_22117_ _12752_ _12609_ _12722_ _12753_ VDD VSS AOI21_X1
X_22118_ _12665_ _12679_ _12746_ _12749_ _12753_ _12754_ VDD
+ VSS AOI221_X2
X_22119_ _12622_ _12743_ _12754_ _12755_ VDD VSS NOR3_X2
X_22120_ _12663_ _12699_ _12755_ _12731_ _00072_ VDD VSS OAI211_X2
X_22121_ _12664_ _12665_ _12756_ VDD VSS NAND2_X1
X_22122_ _12620_ _12757_ VDD VSS BUF_X4
X_22123_ _12701_ _12740_ _12758_ VDD VSS NAND2_X1
X_22124_ _12551_ _12718_ _12759_ VDD VSS NOR2_X1
X_22125_ _14970_ _12586_ _12590_ _12760_ VDD VSS NOR3_X4
X_22126_ _12681_ _12760_ _12761_ VDD VSS NOR2_X1
X_22127_ net1091 _12654_ _12655_ _12762_ VDD VSS OAI21_X4
X_22128_ _12757_ _12758_ _12759_ _12761_ _12762_ _12763_ VDD
+ VSS AOI221_X2
X_22129_ net766 _12711_ _12686_ _12764_ VDD VSS NOR3_X4
X_22130_ _12722_ _12654_ _12655_ _12765_ VDD VSS OAI21_X2
X_22131_ _12547_ _12750_ _12765_ _12766_ VDD VSS AOI21_X1
X_22132_ _12716_ _12764_ _12766_ _12767_ VDD VSS NOR3_X1
X_22133_ _12612_ _12763_ _12767_ _12768_ VDD VSS OAI21_X1
X_22134_ _12643_ _12654_ _12655_ _12769_ VDD VSS OAI21_X2
X_22135_ _12682_ _12769_ _12691_ _12770_ VDD VSS AOI21_X1
X_22136_ _12715_ _12708_ _14963_ _12771_ VDD VSS OAI21_X1
X_22137_ _12548_ _12602_ _12603_ _12772_ VDD VSS NAND3_X4
X_22138_ _12676_ _12654_ _12655_ _12773_ VDD VSS OAI21_X1
X_22139_ _12645_ _12772_ _12773_ _12774_ VDD VSS AOI21_X2
X_22140_ _12508_ _12775_ VDD VSS BUF_X4
X_22141_ _12722_ _12775_ _12688_ _12776_ VDD VSS MUX2_X1
X_22142_ _12774_ _12776_ _14979_ _12777_ VDD VSS AOI21_X1
X_22143_ _12667_ _12770_ _12771_ _12777_ _12716_ _12778_ VDD
+ VSS OAI221_X1
X_22144_ _12756_ _12768_ _12778_ _12779_ VDD VSS AOI21_X2
X_22145_ _12664_ _12634_ _12780_ VDD VSS NOR2_X2
X_22146_ _12651_ _12781_ VDD VSS BUF_X4
X_22147_ _14954_ _12599_ _12781_ _12782_ VDD VSS OAI21_X1
X_22148_ _12671_ _12607_ _12724_ _14955_ _12783_ VDD VSS AOI22_X1
X_22149_ _12716_ _12782_ _12783_ _12784_ VDD VSS NAND3_X1
X_22150_ _12547_ _12726_ _12740_ _12785_ VDD VSS OAI21_X1
X_22151_ _12596_ _14961_ _12597_ _12786_ VDD VSS NAND3_X2
X_22152_ _12687_ _12769_ _12786_ _12787_ VDD VSS NAND3_X1
X_22153_ _12621_ _12785_ _12787_ _12788_ VDD VSS NAND3_X1
X_22154_ _12667_ _12780_ _12784_ _12788_ _12789_ VDD VSS NAND4_X1
X_22155_ _12612_ _12780_ _12790_ VDD VSS NAND2_X1
X_22156_ _14970_ _12791_ VDD VSS INV_X1
X_22157_ _12791_ _12602_ _12603_ _12792_ VDD VSS AOI21_X2
X_22158_ _14972_ _12792_ _12793_ VDD VSS NOR2_X1
X_22159_ _12508_ _12656_ _12794_ VDD VSS NOR2_X1
X_22160_ _12621_ _12691_ _12795_ VDD VSS NAND2_X1
X_22161_ _12722_ _12586_ _12590_ _12796_ VDD VSS NOR3_X4
X_22162_ _12643_ _12596_ _12597_ _12797_ VDD VSS AOI21_X4
X_22163_ _12796_ _12797_ _12798_ VDD VSS NOR2_X4
X_22164_ _12547_ _12798_ _12799_ VDD VSS NOR2_X1
X_22165_ _12735_ _12725_ _12800_ VDD VSS NOR2_X1
X_22166_ _12552_ _12800_ _12668_ _12801_ VDD VSS NOR3_X1
X_22167_ _12793_ _12794_ _12795_ _12799_ _12801_ _12621_ _12802_
+ VDD VSS OAI33_X1
X_22168_ _12789_ _12790_ _12802_ _12803_ VDD VSS OAI21_X1
X_22169_ _12744_ _12644_ _12791_ _12804_ VDD VSS OAI21_X1
X_22170_ _12701_ _12804_ _12805_ VDD VSS NAND2_X1
X_22171_ _12736_ _12652_ _12695_ _12806_ VDD VSS OAI21_X1
X_22172_ _12757_ _12805_ _12749_ _12806_ _12679_ _12807_ VDD
+ VSS AOI221_X2
X_22173_ _12566_ _12591_ _12808_ VDD VSS NAND2_X2
X_22174_ _14961_ net773 _12545_ _12809_ VDD VSS MUX2_X1
X_22175_ _12643_ _12659_ _12810_ VDD VSS NOR2_X4
X_22176_ _12620_ _12808_ _12809_ _12810_ _12656_ _12811_ VDD
+ VSS OAI221_X2
X_22177_ _12644_ _12566_ _12582_ _12812_ VDD VSS NAND3_X1
X_22178_ _12606_ _12659_ _12592_ _12813_ VDD VSS NAND3_X1
X_22179_ _12812_ _12813_ _12814_ VDD VSS NAND2_X1
X_22180_ _12600_ _12567_ _12645_ _12815_ VDD VSS OAI21_X1
X_22181_ _12811_ _12814_ net1093 _12815_ net1009 _12816_ VDD
+ VSS AOI221_X2
X_22182_ _12627_ _12634_ _12817_ VDD VSS NAND2_X1
X_22183_ _12816_ _12807_ _12817_ _12818_ VDD VSS NOR3_X2
X_22184_ _12664_ _12634_ _12819_ VDD VSS NAND2_X2
X_22185_ net1007 _12582_ _12820_ VDD VSS NAND2_X1
X_22186_ _12527_ _12546_ _12821_ VDD VSS XNOR2_X1
X_22187_ _12747_ _12681_ _14956_ _12822_ VDD VSS AOI21_X1
X_22188_ _12757_ _12820_ _12821_ _12822_ _12702_ _12823_ VDD
+ VSS OAI221_X1
X_22189_ _12695_ _12725_ _12824_ VDD VSS XNOR2_X1
X_22190_ _12774_ _12824_ _12682_ _12825_ VDD VSS AOI21_X1
X_22191_ _12823_ _12564_ _12561_ _12825_ _12621_ _12826_ VDD
+ VSS OAI221_X2
X_22192_ _12648_ _12740_ _12550_ _12827_ VDD VSS MUX2_X1
X_22193_ _12636_ _12581_ _12828_ VDD VSS NAND2_X1
X_22194_ _12661_ _12689_ _12827_ _12828_ _14980_ _12829_ VDD
+ VSS OAI221_X1
X_22195_ _12819_ _12826_ _12829_ _12830_ VDD VSS AOI21_X2
X_22196_ _12779_ _12803_ _12818_ _12830_ _00073_ VDD VSS NOR4_X2
X_22197_ _12642_ _12751_ _12831_ VDD VSS NAND2_X1
X_22198_ _12605_ _12606_ _12591_ _12832_ VDD VSS MUX2_X1
X_22199_ _12831_ _12832_ _12546_ _12833_ VDD VSS MUX2_X1
X_22200_ _12637_ _12659_ _12834_ VDD VSS NOR2_X2
X_22201_ _12833_ _12834_ _12835_ VDD VSS AND2_X1
X_22202_ _12819_ _12836_ VDD VSS INV_X1
X_22203_ _12620_ _12658_ _12837_ VDD VSS NAND2_X2
X_22204_ _12527_ _12602_ _12603_ _12838_ VDD VSS AOI21_X2
X_22205_ net774 _12601_ _12838_ _12668_ _12839_ VDD VSS OR4_X1
X_22206_ _12839_ _12656_ net168 _12840_ VDD VSS OAI21_X1
X_22207_ _12836_ _12837_ _12840_ _12841_ VDD VSS OAI21_X1
X_22208_ _12619_ _12566_ _12842_ VDD VSS NOR2_X4
X_22209_ _12695_ _12546_ _12843_ VDD VSS NOR2_X1
X_22210_ _12842_ _12843_ _12745_ _12593_ _12748_ _12844_ VDD
+ VSS OAI221_X1
X_22211_ _12637_ _12679_ _12845_ VDD VSS NAND2_X1
X_22212_ _14970_ _12596_ _12597_ _12846_ VDD VSS NAND3_X1
X_22213_ _12751_ _12846_ _12847_ VDD VSS NAND2_X1
X_22214_ _12673_ _12847_ _12644_ _12781_ net890 _12848_ VDD
+ VSS AOI221_X1
X_22215_ _12844_ _12845_ _12848_ _12849_ VDD VSS OAI21_X1
X_22216_ _12620_ _12658_ _12850_ VDD VSS NOR2_X4
X_22217_ _12550_ _12760_ _12851_ VDD VSS OR2_X1
X_22218_ _12838_ _12733_ _12852_ VDD VSS OR2_X1
X_22219_ _12719_ _12851_ _12852_ _12645_ _12853_ VDD VSS OAI22_X1
X_22220_ _12850_ _12853_ _12854_ VDD VSS AND2_X1
X_22221_ _12627_ _12634_ _12855_ VDD VSS NOR2_X2
X_22222_ _14966_ _12856_ VDD VSS INV_X4
X_22223_ _12551_ _12582_ _12856_ _12857_ VDD VSS OAI21_X1
X_22224_ _12606_ _12591_ _12858_ VDD VSS NOR2_X1
X_22225_ _12842_ _12857_ _12858_ _12686_ net890 _12859_ VDD
+ VSS OAI221_X1
X_22226_ _12658_ _12860_ VDD VSS CLKBUF_X3
X_22227_ _12551_ _12711_ net765 _12861_ VDD VSS OAI21_X1
X_22228_ _12644_ _12733_ _12797_ _12862_ VDD VSS OAI21_X1
X_22229_ _12620_ _12860_ _12861_ _12862_ _12863_ VDD VSS NAND4_X1
X_22230_ _12855_ _12859_ _12863_ _12864_ VDD VSS NAND3_X1
X_22231_ _12772_ _12592_ net1124 _12865_ VDD VSS OAI21_X1
X_22232_ _12645_ _12865_ _12851_ _12858_ _12866_ VDD VSS OAI22_X1
X_22233_ _12834_ _12866_ _12867_ VDD VSS AND2_X1
X_22234_ _12835_ _12841_ _12849_ _12854_ _12864_ _12867_ _12868_
+ VDD VSS OAI33_X1
X_22235_ _14977_ _12592_ _12869_ VDD VSS NAND2_X1
X_22236_ net773 _12550_ _12870_ VDD VSS NAND2_X1
X_22237_ _12582_ _12870_ net774 _12601_ _12671_ _12871_ VDD
+ VSS OAI221_X2
X_22238_ _12837_ _12869_ _12871_ _12872_ VDD VSS AOI21_X1
X_22239_ _12684_ _12591_ net889 _12873_ VDD VSS AOI21_X1
X_22240_ _12732_ _12796_ _12874_ VDD VSS NOR2_X2
X_22241_ _12873_ _12874_ _12545_ _12875_ VDD VSS MUX2_X1
X_22242_ _14980_ _12591_ _12876_ VDD VSS AND2_X1
X_22243_ _12548_ _12550_ _12508_ _12877_ VDD VSS MUX2_X1
X_22244_ _12876_ _12877_ _12581_ _12878_ VDD VSS AOI21_X1
X_22245_ _12875_ _12878_ _12658_ _12879_ VDD VSS MUX2_X1
X_22246_ net889 _12545_ _12724_ _12880_ VDD VSS NOR3_X1
X_22247_ _12527_ _12550_ _12881_ VDD VSS NAND2_X2
X_22248_ net772 _12581_ _12882_ VDD VSS NOR2_X2
X_22249_ _12882_ _12640_ _12883_ VDD VSS OR2_X1
X_22250_ _12880_ _12881_ _12673_ _12671_ _12883_ _12884_ VDD
+ VSS AOI221_X2
X_22251_ _12872_ _12879_ _12637_ _12834_ _12884_ _12885_ VDD
+ VSS AOI221_X2
X_22252_ _12820_ _12547_ _14963_ _12886_ VDD VSS AOI21_X1
X_22253_ _12715_ _12702_ _14984_ _12887_ VDD VSS OAI21_X1
X_22254_ _12688_ _12740_ _12888_ VDD VSS NOR2_X1
X_22255_ _14958_ _14961_ _12889_ VDD VSS NOR2_X2
X_22256_ _12552_ _12593_ _12889_ _12890_ VDD VSS OAI21_X1
X_22257_ _12649_ _12602_ _12603_ _12891_ VDD VSS NAND3_X2
X_22258_ _12681_ _12891_ _12892_ VDD VSS NAND2_X1
X_22259_ _12888_ _12890_ _12892_ _12741_ _12893_ VDD VSS OAI22_X1
X_22260_ _12568_ _12886_ _12887_ _12893_ _12716_ _12894_ VDD
+ VSS OAI221_X1
X_22261_ _12527_ _12505_ net518 _12895_ VDD VSS AOI21_X2
X_22262_ _12681_ _12593_ _12895_ _12896_ VDD VSS NAND3_X1
X_22263_ _14975_ _12688_ _12897_ VDD VSS NAND2_X1
X_22264_ _12757_ _12896_ _12897_ _12898_ VDD VSS AOI21_X1
X_22265_ net890 _12599_ _12874_ _12687_ _12899_ VDD VSS AOI22_X1
X_22266_ _12898_ _12899_ _12621_ _12900_ VDD VSS AOI21_X1
X_22267_ _12894_ _12900_ _12612_ _12901_ VDD VSS OAI21_X1
X_22268_ _12817_ _12902_ VDD VSS INV_X1
X_22269_ _12868_ _12780_ _12885_ _12901_ _12902_ _00074_ VDD
+ VSS AOI221_X1
X_22270_ _12780_ _12903_ VDD VSS INV_X1
X_22271_ net772 _12703_ _12904_ VDD VSS NOR2_X4
X_22272_ _12687_ _12751_ _12891_ _12905_ VDD VSS AOI21_X1
X_22273_ net1090 _12604_ _12906_ VDD VSS NOR2_X1
X_22274_ _12904_ _12905_ _12906_ _12907_ VDD VSS NOR3_X1
X_22275_ _12903_ _12834_ _12907_ _12908_ VDD VSS AOI21_X1
X_22276_ _12757_ _12567_ _12906_ _12609_ _12775_ _12909_ VDD
+ VSS AOI221_X1
X_22277_ _12609_ net1122 _14955_ _12910_ VDD VSS AOI21_X1
X_22278_ _12909_ _12910_ _12612_ _12911_ VDD VSS OAI21_X1
X_22279_ net168 _12701_ _12912_ VDD VSS NAND2_X1
X_22280_ _12860_ _12725_ net1124 _12913_ VDD VSS AOI21_X1
X_22281_ _12552_ _12912_ _12913_ _12660_ net1122 _12914_ VDD
+ VSS AOI221_X2
X_22282_ _12527_ _12781_ _12915_ VDD VSS NAND2_X1
X_22283_ _12695_ _12600_ _12915_ _12916_ VDD VSS AOI21_X1
X_22284_ _12916_ _12609_ _12648_ _12643_ _12607_ _12917_ VDD
+ VSS AOI221_X2
X_22285_ _12908_ _12911_ _12914_ _12917_ _12837_ _12918_ VDD
+ VSS OAI221_X2
X_22286_ _12682_ _12769_ _12891_ _12919_ VDD VSS NAND3_X1
X_22287_ _12919_ _12832_ _14979_ _12920_ VDD VSS OAI21_X1
X_22288_ _12681_ _12792_ _12668_ _12921_ VDD VSS OAI21_X2
X_22289_ _12715_ _12660_ _12922_ VDD VSS NAND2_X1
X_22290_ _12702_ _12889_ _12923_ VDD VSS NAND2_X1
X_22291_ _12547_ _12683_ _12924_ VDD VSS NOR2_X1
X_22292_ _12922_ _12923_ _12924_ _12925_ VDD VSS AOI21_X1
X_22293_ _12850_ _12920_ _12921_ _12925_ _12926_ VDD VSS AOI22_X1
X_22294_ _14972_ _12568_ _12927_ VDD VSS NAND2_X1
X_22295_ net1055 _12689_ _12605_ _12928_ VDD VSS AOI21_X1
X_22296_ _14963_ _12781_ _12652_ net1123 _12929_ VDD VSS AOI22_X1
X_22297_ _12622_ _12927_ _12928_ _12929_ _12568_ _12930_ VDD
+ VSS OAI221_X1
X_22298_ _12666_ _12926_ _12930_ _12931_ VDD VSS AOI21_X1
X_22299_ _12701_ _12827_ _12932_ VDD VSS OR2_X1
X_22300_ _12889_ _12933_ VDD VSS INV_X1
X_22301_ net1123 _12933_ _12550_ _12934_ VDD VSS MUX2_X1
X_22302_ _12620_ _12701_ _12934_ _12935_ VDD VSS AOI21_X1
X_22303_ _14963_ _12681_ _12583_ _12936_ VDD VSS OAI21_X1
X_22304_ _12637_ _12607_ net1007 _12608_ _12722_ _12937_ VDD
+ VSS AOI221_X2
X_22305_ _12679_ _12932_ _12935_ _12936_ _12937_ _12938_ VDD
+ VSS AOI221_X2
X_22306_ _12645_ _12860_ _12939_ VDD VSS NOR2_X1
X_22307_ _12642_ _12593_ _12856_ _12940_ VDD VSS OAI21_X1
X_22308_ _12637_ _12593_ _12941_ VDD VSS NAND2_X1
X_22309_ _12939_ _12940_ _12715_ _12941_ _14963_ _12942_ VDD
+ VSS OAI221_X1
X_22310_ _12552_ _12660_ _12943_ VDD VSS NOR2_X1
X_22311_ _12943_ _12751_ _12715_ net168 _12689_ _12944_ VDD
+ VSS OAI221_X1
X_22312_ _12666_ _12942_ _12944_ _12945_ VDD VSS NAND3_X1
X_22313_ _12664_ _12938_ _12945_ _12946_ VDD VSS OAI21_X1
X_22314_ _12547_ _12660_ _12947_ VDD VSS XNOR2_X1
X_22315_ _12644_ _12659_ _12948_ VDD VSS NAND2_X1
X_22316_ _12689_ _12947_ net1090 _12948_ net1009 _12949_ VDD
+ VSS OAI221_X1
X_22317_ net1007 _12566_ _12582_ _12694_ _12950_ VDD VSS NOR4_X1
X_22318_ _12551_ _12860_ net1093 _12951_ VDD VSS AOI21_X1
X_22319_ _12950_ _12951_ _12882_ _14963_ _12939_ _12952_ VDD
+ VSS AOI221_X1
X_22320_ _12716_ _12949_ _12952_ _12953_ VDD VSS NAND3_X1
X_22321_ _12765_ _12891_ _12954_ VDD VSS NAND2_X1
X_22322_ net765 _12668_ _12955_ VDD VSS OR2_X4
X_22323_ _12954_ _12955_ _12681_ _12956_ VDD VSS MUX2_X1
X_22324_ _12669_ _12725_ net1090 _12957_ VDD VSS AOI21_X1
X_22325_ _12719_ _12725_ _12695_ _12958_ VDD VSS AOI21_X1
X_22326_ _12957_ _12958_ _12681_ _12959_ VDD VSS MUX2_X1
X_22327_ _12956_ _12959_ _12661_ _12960_ VDD VSS MUX2_X1
X_22328_ _12953_ _12960_ _12716_ _12961_ VDD VSS OAI21_X2
X_22329_ _12918_ _12931_ _12946_ _12961_ _12817_ _00075_ VDD
+ VSS OAI221_X1
X_22330_ _12644_ _12760_ _12962_ VDD VSS OR2_X1
X_22331_ _12567_ _12904_ _12962_ _12963_ VDD VSS NOR3_X1
X_22332_ _12786_ _12544_ _12964_ VDD VSS AND2_X4
X_22333_ _12658_ _12762_ _12964_ _12601_ _12856_ _12965_ VDD
+ VSS AOI221_X2
X_22334_ _12856_ _12596_ _12597_ _12966_ VDD VSS AOI21_X4
X_22335_ _12966_ _12591_ _12641_ _12967_ VDD VSS AOI21_X2
X_22336_ _12700_ _12948_ _12967_ _12968_ VDD VSS OAI21_X1
X_22337_ _12601_ _12581_ _12676_ _12969_ VDD VSS OAI21_X1
X_22338_ _12673_ _12851_ _12969_ _12904_ _12970_ VDD VSS OAI22_X1
X_22339_ _12965_ _12963_ _12968_ _12970_ _12860_ _12638_ _12971_
+ VDD VSS OAI33_X1
X_22340_ net772 _12703_ _12972_ VDD VSS NAND2_X1
X_22341_ _12972_ _12652_ net774 _12973_ VDD VSS OAI21_X1
X_22342_ _12842_ _12915_ _12974_ VDD VSS AND2_X1
X_22343_ _14956_ _12599_ _12975_ VDD VSS NAND2_X1
X_22344_ net772 _12550_ _12976_ VDD VSS NAND2_X1
X_22345_ _12691_ _12850_ _12976_ _12977_ VDD VSS AND3_X1
X_22346_ _12633_ _12973_ _12974_ _12975_ _12977_ _12978_ VDD
+ VSS AOI221_X2
X_22347_ _12659_ _12881_ _12979_ VDD VSS NAND2_X1
X_22348_ _12551_ _12796_ _12858_ _12980_ VDD VSS NOR3_X1
X_22349_ _12856_ _12725_ _12718_ _12546_ _12981_ VDD VSS OAI22_X1
X_22350_ _12757_ _12979_ _12980_ _12981_ _12660_ _12982_ VDD
+ VSS OAI221_X2
X_22351_ _12722_ _12601_ _12983_ VDD VSS NAND2_X1
X_22352_ _12983_ _12686_ _12695_ _12984_ VDD VSS OAI21_X1
X_22353_ _12638_ _12984_ _12702_ _12985_ VDD VSS AOI21_X1
X_22354_ _12971_ _12978_ _12982_ _12749_ _12985_ _12986_ VDD
+ VSS AOI221_X2
X_22355_ _14968_ _12654_ _12655_ _12987_ VDD VSS NOR3_X1
X_22356_ _12987_ _12744_ _12701_ _12988_ VDD VSS AOI21_X2
X_22357_ _12567_ _12656_ net1008 _12989_ VDD VSS OAI21_X1
X_22358_ _14955_ _12772_ _12966_ _12686_ _12990_ VDD VSS OAI22_X2
X_22359_ _12621_ _12679_ _12988_ _12989_ _12990_ _12991_ VDD
+ VSS OAI221_X2
X_22360_ _12842_ _12703_ _12775_ net515 _12708_ _12992_ VDD
+ VSS OAI221_X1
X_22361_ _12547_ _12750_ _12751_ _12993_ VDD VSS AOI21_X1
X_22362_ _12682_ _12882_ _12724_ _12994_ VDD VSS NOR3_X1
X_22363_ _12706_ _12691_ _12850_ _12995_ VDD VSS NAND3_X1
X_22364_ _12991_ _12992_ _12993_ _12994_ _12995_ _12996_ VDD
+ VSS OAI221_X1
X_22365_ _12645_ _12719_ _12796_ _12997_ VDD VSS OR3_X1
X_22366_ _12775_ _12593_ _12998_ VDD VSS XNOR2_X1
X_22367_ _12568_ _12997_ _12998_ _14972_ _12999_ VDD VSS OAI211_X2
X_22368_ _12679_ _12781_ _14954_ _13000_ VDD VSS AOI21_X1
X_22369_ _12621_ _12851_ _13000_ _13001_ VDD VSS AOI21_X1
X_22370_ _12634_ _12999_ _13001_ _13002_ VDD VSS AOI21_X1
X_22371_ _12701_ _12740_ _13003_ VDD VSS AND2_X1
X_22372_ _12724_ net1055 _13004_ VDD VSS NOR2_X1
X_22373_ _12661_ _13003_ _12969_ _13004_ _12687_ _13005_ VDD
+ VSS OAI221_X1
X_22374_ _12943_ _13003_ _12718_ _13006_ VDD VSS OAI21_X1
X_22375_ _12622_ _13005_ _13006_ _13007_ VDD VSS NAND3_X1
X_22376_ _12634_ _12996_ _13002_ _13007_ _13008_ VDD VSS AOI22_X1
X_22377_ _12986_ _13008_ _12664_ _00076_ VDD VSS MUX2_X1
X_22378_ _12566_ _12608_ _13009_ VDD VSS NAND2_X1
X_22379_ net774 _12659_ _12592_ _13010_ VDD VSS AOI21_X1
X_22380_ _12549_ _13009_ _13010_ _12808_ _14955_ _13011_ VDD
+ VSS AOI221_X2
X_22381_ _12648_ _12599_ _12781_ net1093 _13012_ VDD VSS AOI22_X2
X_22382_ _12781_ _12702_ _12660_ _13013_ VDD VSS AOI21_X1
X_22383_ _12621_ _12661_ _13012_ _13013_ net1009 _13014_ VDD
+ VSS OAI221_X2
X_22384_ _12765_ _12846_ _13015_ VDD VSS NAND2_X1
X_22385_ _12567_ _12609_ _12643_ _13015_ _12681_ _13016_ VDD
+ VSS AOI221_X2
X_22386_ _12552_ _12750_ _12762_ _13017_ VDD VSS AOI21_X1
X_22387_ _12679_ _12604_ _12508_ _13018_ VDD VSS OAI21_X1
X_22388_ _12716_ _13017_ _13018_ _13019_ VDD VSS OAI21_X1
X_22389_ _13011_ _13014_ _13016_ _13019_ _13020_ VDD VSS OAI22_X2
X_22390_ _12757_ _12726_ _12735_ _12708_ _12856_ _13021_ VDD
+ VSS OAI221_X1
X_22391_ _12667_ _12712_ _13021_ _13022_ VDD VSS NOR3_X1
X_22392_ net1009 _12838_ _12786_ _14972_ _13023_ VDD VSS AOI22_X1
X_22393_ _12612_ _13023_ _12622_ _13024_ VDD VSS OAI21_X1
X_22394_ _14972_ _12715_ _13025_ VDD VSS NOR2_X1
X_22395_ _12682_ _12715_ _13026_ VDD VSS NOR2_X1
X_22396_ _12670_ _13025_ _13026_ _12720_ _13027_ VDD VSS AOI22_X1
X_22397_ _13022_ _13024_ _13027_ _13028_ VDD VSS AOI21_X1
X_22398_ _14979_ _12689_ _13029_ VDD VSS NAND2_X1
X_22399_ _12842_ _12940_ _14979_ _13029_ net1122 _13030_ VDD
+ VSS OAI221_X1
X_22400_ _12666_ _13030_ _13031_ VDD VSS NAND2_X1
X_22401_ _12627_ _12666_ _13020_ _13028_ _13031_ _13032_ VDD
+ VSS OAI221_X1
X_22402_ _12775_ _12725_ _13033_ VDD VSS NAND2_X1
X_22403_ _12667_ _13033_ _12821_ _12933_ _12656_ _13034_ VDD
+ VSS OAI221_X1
X_22404_ _12735_ _12687_ _13035_ VDD VSS NOR2_X1
X_22405_ _12568_ _12689_ _13035_ _13029_ net168 _13036_ VDD
+ VSS OAI221_X1
X_22406_ _12622_ _13034_ _13036_ _13037_ VDD VSS NAND3_X1
X_22407_ _12686_ _12684_ _12760_ _13038_ VDD VSS OR3_X1
X_22408_ _14972_ _12683_ _12797_ _13039_ VDD VSS OAI21_X1
X_22409_ _12850_ _13038_ _13039_ _13040_ VDD VSS NAND3_X1
X_22410_ _14979_ _12691_ _13041_ VDD VSS NOR2_X1
X_22411_ _12842_ _13041_ _12684_ _13042_ VDD VSS OAI21_X1
X_22412_ _12836_ _13037_ _13040_ _13042_ _13043_ VDD VSS NAND4_X1
X_22413_ _14963_ _12715_ _12882_ _12941_ _12687_ net890 _13044_
+ VDD VSS OAI33_X1
X_22414_ _12621_ _12726_ _13045_ VDD VSS NAND2_X1
X_22415_ net1009 _12715_ _12702_ _13046_ VDD VSS NAND3_X1
X_22416_ _12881_ _13045_ _13046_ _13047_ VDD VSS AOI21_X1
X_22417_ _12612_ _12756_ _13044_ _13047_ _13048_ VDD VSS NOR4_X1
X_22418_ _12622_ _12604_ _13049_ VDD VSS NOR2_X1
X_22419_ net1122 _12599_ _13049_ _13050_ VDD VSS OAI21_X1
X_22420_ _12769_ _12688_ _12775_ _13051_ VDD VSS OAI21_X1
X_22421_ _12686_ _12733_ _13052_ VDD VSS OR2_X1
X_22422_ _12682_ _13051_ _13052_ _12904_ _13053_ VDD VSS OAI22_X1
X_22423_ _12688_ _12740_ _13054_ VDD VSS OR2_X1
X_22424_ _13038_ _13054_ _12682_ _13055_ VDD VSS OAI21_X1
X_22425_ _13053_ _13055_ _12716_ _13056_ VDD VSS MUX2_X1
X_22426_ _12667_ _12756_ _13057_ VDD VSS NOR2_X1
X_22427_ _13048_ _13050_ _13056_ _13057_ _13058_ VDD VSS AOI22_X1
X_22428_ _13032_ _13043_ _13058_ _00077_ VDD VSS NAND3_X1
X_22429_ _12757_ _12627_ _13059_ VDD VSS NAND2_X1
X_22430_ _12665_ _12567_ _13060_ VDD VSS NAND2_X1
X_22431_ _13060_ _12599_ _12605_ _13061_ VDD VSS AOI21_X1
X_22432_ net515 _12701_ _13062_ VDD VSS NOR2_X1
X_22433_ _12552_ _13062_ _12966_ _13063_ VDD VSS OAI21_X1
X_22434_ _12671_ _12546_ _13064_ VDD VSS NOR2_X1
X_22435_ _13064_ _12895_ _12645_ _13065_ VDD VSS AOI21_X1
X_22436_ _12897_ _13065_ _12702_ _13066_ VDD VSS OAI21_X1
X_22437_ _13059_ _13061_ _13063_ _12693_ _13066_ _13067_ VDD
+ VSS AOI221_X2
X_22438_ _12552_ _12718_ _13068_ VDD VSS OR2_X1
X_22439_ _12642_ _12726_ _12775_ _13069_ VDD VSS OAI21_X1
X_22440_ _12904_ _13068_ _13069_ _12682_ _13070_ VDD VSS OAI22_X1
X_22441_ _14973_ _14982_ _12688_ _13071_ VDD VSS NOR3_X1
X_22442_ _13071_ _12976_ _12741_ _13072_ VDD VSS AOI21_X1
X_22443_ _13070_ _13072_ _12666_ _13073_ VDD VSS MUX2_X1
X_22444_ _13067_ _13073_ _12612_ _13074_ VDD VSS OAI21_X2
X_22445_ _14972_ _12689_ _12933_ _13075_ VDD VSS OAI21_X1
X_22446_ _12680_ _12831_ _14972_ _13075_ _12904_ _13076_ VDD
+ VSS OAI221_X1
X_22447_ _12689_ _12694_ _14955_ _13077_ VDD VSS OAI21_X1
X_22448_ _12650_ _12693_ _13077_ _13078_ VDD VSS NAND3_X1
X_22449_ _12716_ _12627_ _13076_ _13078_ _13079_ VDD VSS NAND4_X1
X_22450_ _14979_ _12711_ _12966_ _13080_ VDD VSS NOR3_X1
X_22451_ _12726_ _12889_ _13081_ VDD VSS NOR2_X1
X_22452_ _14972_ net1055 _13081_ _13082_ VDD VSS NOR3_X1
X_22453_ _12612_ _13080_ _13082_ _13083_ VDD VSS OAI21_X1
X_22454_ _12605_ _12726_ _13084_ VDD VSS NOR2_X1
X_22455_ _12667_ _13084_ _12962_ _13052_ _13003_ _13085_ VDD
+ VSS OAI221_X1
X_22456_ _12634_ _13083_ _13085_ _13086_ VDD VSS AOI21_X1
X_22457_ _12676_ _12686_ _12870_ _12695_ _13087_ VDD VSS OAI22_X1
X_22458_ _12679_ _12702_ _13087_ _13088_ VDD VSS AOI21_X1
X_22459_ _12856_ _12648_ _12592_ _13089_ VDD VSS MUX2_X1
X_22460_ _12989_ _13089_ _12547_ _13090_ VDD VSS AOI21_X1
X_22461_ _12659_ _12581_ _13091_ VDD VSS NOR2_X1
X_22462_ _12546_ _13091_ _12967_ _12659_ _13092_ VDD VSS AOI211_X2
X_22463_ _12695_ _12567_ _13093_ VDD VSS NAND2_X1
X_22464_ _12549_ _12860_ _12701_ _13094_ VDD VSS NAND3_X1
X_22465_ _12552_ _13093_ _13094_ _13095_ VDD VSS AOI21_X1
X_22466_ _12665_ _12808_ net1122 _13096_ VDD VSS OAI21_X1
X_22467_ _12666_ _13088_ _13090_ _13092_ _13095_ _13096_ _13097_
+ VDD VSS OAI33_X1
X_22468_ _12566_ _12644_ _12527_ net520 _12505_ _13098_ VDD
+ VSS AOI221_X2
X_22469_ _12791_ _12561_ _12564_ _13099_ VDD VSS OAI21_X1
X_22470_ _12775_ _12860_ _12703_ _13099_ _12582_ _12644_ _13100_
+ VDD VSS OAI33_X1
X_22471_ _12567_ _12725_ _12881_ _13101_ VDD VSS NOR3_X1
X_22472_ _12549_ _12686_ _12860_ _13102_ VDD VSS NOR3_X1
X_22473_ _13098_ _13100_ _13101_ _13102_ _13103_ VDD VSS NOR4_X2
X_22474_ _14974_ _12688_ _13104_ VDD VSS AND2_X1
X_22475_ _12856_ _12601_ _13105_ VDD VSS NOR2_X1
X_22476_ _12581_ _13105_ net1007 _12551_ _13106_ VDD VSS AOI211_X2
X_22477_ _12661_ _13104_ _13106_ _13107_ VDD VSS OAI21_X1
X_22478_ _12660_ _12609_ _12643_ _13108_ VDD VSS AOI21_X1
X_22479_ _12665_ _12921_ _13108_ _13109_ VDD VSS AOI21_X1
X_22480_ _12666_ _13103_ _13107_ _13109_ _13110_ VDD VSS AOI22_X1
X_22481_ _13097_ _13110_ _12622_ _13111_ VDD VSS MUX2_X1
X_22482_ _13074_ _13079_ _13086_ _13111_ _12627_ _00078_ VDD
+ VSS OAI221_X2
X_22483_ net1090 _12599_ _12781_ _13112_ VDD VSS OAI21_X1
X_22484_ _14963_ _12607_ _12609_ _14970_ _13113_ VDD VSS AOI22_X1
X_22485_ _12855_ _12850_ _13112_ _13113_ _13114_ VDD VSS NAND4_X1
X_22486_ _12855_ _12834_ _13115_ VDD VSS NAND2_X1
X_22487_ _12772_ _12751_ _12551_ _13116_ VDD VSS OAI21_X1
X_22488_ net514 _12609_ _13116_ _12775_ _12549_ _12607_ _13117_
+ VDD VSS AOI222_X2
X_22489_ _12757_ _12751_ _13118_ VDD VSS NOR2_X1
X_22490_ _12645_ _12637_ _12760_ _13119_ VDD VSS NOR3_X1
X_22491_ net1009 _13118_ _13119_ _13120_ VDD VSS OAI21_X1
X_22492_ _12661_ _12855_ _13120_ _13121_ VDD VSS NAND3_X1
X_22493_ _12856_ _12637_ _12581_ _13122_ VDD VSS OAI21_X1
X_22494_ net1008 _13122_ _12828_ _13123_ VDD VSS MUX2_X1
X_22495_ _12846_ _12751_ _12620_ _13124_ VDD VSS OAI21_X1
X_22496_ _13123_ _13124_ _12552_ _13125_ VDD VSS MUX2_X1
X_22497_ _13114_ _13115_ _13117_ _13121_ _13125_ _13126_ VDD
+ VSS OAI221_X2
X_22498_ _12527_ _13009_ _13127_ VDD VSS NOR2_X1
X_22499_ _12607_ _12581_ _12658_ _13128_ VDD VSS AOI21_X1
X_22500_ net1093 _13128_ _13129_ VDD VSS NOR2_X1
X_22501_ _12775_ _13127_ _13129_ _13130_ VDD VSS OAI21_X1
X_22502_ _12620_ _12658_ _12545_ _12781_ net1091 _13131_ VDD
+ VSS AOI221_X2
X_22503_ net774 _12772_ _13132_ VDD VSS NOR2_X1
X_22504_ net1007 _12708_ _12751_ _13133_ VDD VSS AOI21_X1
X_22505_ _12860_ _13132_ _13133_ _13134_ VDD VSS OAI21_X1
X_22506_ _12668_ _12608_ net1093 _13135_ VDD VSS AOI21_X1
X_22507_ _12599_ _12781_ _12527_ _13136_ VDD VSS AOI21_X1
X_22508_ _13134_ _13135_ _12860_ _12695_ _13136_ _13137_ VDD
+ VSS OAI221_X2
X_22509_ _12819_ _13130_ _13131_ _13137_ _12757_ _13138_ VDD
+ VSS AOI221_X2
X_22510_ _12622_ _12666_ _13139_ VDD VSS NOR2_X1
X_22511_ _14982_ _12593_ _13140_ VDD VSS OR2_X1
X_22512_ net1123 _12686_ _13141_ VDD VSS NAND2_X1
X_22513_ _12726_ _12646_ _13141_ _13142_ VDD VSS NAND3_X1
X_22514_ _12661_ _13140_ _13142_ _13143_ VDD VSS NAND3_X1
X_22515_ _12769_ _12688_ _14955_ _13144_ VDD VSS OAI21_X1
X_22516_ _12764_ _13144_ _12687_ _13145_ VDD VSS AOI21_X2
X_22517_ _13143_ _12667_ _13145_ _13146_ VDD VSS OAI21_X2
X_22518_ _12664_ _13139_ _13146_ _13147_ VDD VSS AOI21_X1
X_22519_ _12676_ net1007 _12546_ _13148_ VDD VSS MUX2_X1
X_22520_ _12679_ _13033_ _12694_ _13148_ _12726_ _13149_ VDD
+ VSS OAI221_X1
X_22521_ _12605_ _12645_ _13150_ VDD VSS NAND2_X1
X_22522_ _14968_ _13150_ _12593_ _13151_ VDD VSS MUX2_X1
X_22523_ _13149_ _13151_ _12568_ _13152_ VDD VSS OAI21_X1
X_22524_ _12735_ _12593_ _12741_ _12976_ _13153_ VDD VSS AOI22_X1
X_22525_ _12845_ _13153_ _13154_ VDD VSS OR2_X1
X_22526_ _12601_ _12684_ _13155_ VDD VSS NOR2_X1
X_22527_ _12837_ _13155_ _12691_ _12798_ _12551_ _13156_ VDD
+ VSS AOI221_X2
X_22528_ _12637_ _12659_ _12983_ _13157_ VDD VSS NAND3_X1
X_22529_ _13157_ _12759_ _12820_ _13158_ VDD VSS AOI21_X1
X_22530_ net519 _12505_ net773 _12545_ _13159_ VDD VSS AOI22_X2
X_22531_ _12620_ _12561_ _12564_ _12582_ _13159_ _13160_ VDD
+ VSS OAI221_X2
X_22532_ _13160_ _12934_ _12688_ _13161_ VDD VSS AOI21_X1
X_22533_ _13161_ _13156_ _13158_ _12634_ _13162_ VDD VSS NOR4_X2
X_22534_ _12700_ _13152_ _13154_ _13162_ _13163_ VDD VSS AOI22_X2
X_22535_ _13126_ _13138_ _13163_ _13147_ _00079_ VDD VSS AOI211_X2
X_22536_ _06260_ _13164_ VDD VSS INV_X1
X_22537_ _13164_ _08995_ _13165_ VDD VSS NOR2_X1
X_22538_ _06260_ _08995_ _13166_ VDD VSS NOR2_X1
X_22539_ sa31_sub\[1\] sa02_sr\[1\] _13167_ VDD VSS XNOR2_X2
X_22540_ _13167_ _10504_ _13168_ VDD VSS XNOR2_X2
X_22541_ _10455_ net793 _13169_ VDD VSS XNOR2_X2
X_22542_ _13169_ _13168_ _13170_ VDD VSS XNOR2_X2
X_22543_ _13165_ _13166_ _13170_ _13171_ VDD VSS MUX2_X2
X_22544_ _06260_ _09818_ _00458_ _13172_ VDD VSS NAND3_X2
X_22545_ _13164_ _09818_ _13173_ VDD VSS NAND2_X2
X_22546_ _13172_ _00458_ _13173_ _13174_ VDD VSS OAI21_X4
X_22547_ _13174_ _13171_ _13175_ VDD VSS NOR2_X4
X_22548_ net501 _13176_ VDD VSS INV_X8
X_22549_ _13176_ _13177_ VDD VSS BUF_X16
X_22550_ _13177_ _13178_ VDD VSS BUF_X32
X_22551_ _13178_ _14992_ VDD VSS BUF_X32
X_22552_ _10439_ _10453_ _13179_ VDD VSS XNOR2_X2
X_22553_ sa20_sub\[0\] _13179_ _13180_ VDD VSS XNOR2_X1
X_22554_ _10433_ _10503_ _13181_ VDD VSS XOR2_X2
X_22555_ _06247_ _09074_ _13181_ _13182_ VDD VSS NAND3_X1
X_22556_ _06247_ _08972_ _13183_ VDD VSS NOR2_X1
X_22557_ net546 _13183_ _13184_ VDD VSS NAND2_X1
X_22558_ _13180_ _13182_ _13184_ _13185_ VDD VSS AOI21_X1
X_22559_ _10439_ _10453_ _13186_ VDD VSS XOR2_X2
X_22560_ sa20_sub\[0\] _13186_ _13187_ VDD VSS XNOR2_X1
X_22561_ _13181_ _13183_ _13188_ VDD VSS NAND2_X1
X_22562_ _06247_ _09099_ net546 _13189_ VDD VSS NAND3_X1
X_22563_ _13187_ _13188_ _13189_ _13190_ VDD VSS AOI21_X1
X_22564_ _06247_ _13191_ VDD VSS INV_X1
X_22565_ _13191_ _09015_ _00459_ _13192_ VDD VSS NAND3_X1
X_22566_ _06247_ _08993_ _13193_ VDD VSS NAND2_X1
X_22567_ _13192_ _13193_ _00459_ _13194_ VDD VSS OAI21_X1
X_22568_ _13185_ _13190_ _13194_ _13195_ VDD VSS OR3_X2
X_22569_ _13195_ _13196_ VDD VSS BUF_X4
X_22570_ _13196_ _13197_ VDD VSS INV_X4
X_22571_ _13197_ _14995_ VDD VSS BUF_X4
X_22572_ _10475_ _10550_ _13198_ VDD VSS XNOR2_X2
X_22573_ _10479_ _13198_ _13199_ VDD VSS XNOR2_X1
X_22574_ net789 net792 _13200_ VDD VSS XOR2_X2
X_22575_ _06299_ _09009_ _13200_ _13201_ VDD VSS NAND3_X1
X_22576_ _06299_ _08970_ _13202_ VDD VSS NOR2_X1
X_22577_ net852 _13202_ _13203_ VDD VSS NAND2_X1
X_22578_ _13199_ _13201_ _13203_ _13204_ VDD VSS AOI21_X2
X_22579_ _10475_ _10550_ _13205_ VDD VSS XOR2_X2
X_22580_ _10479_ _13205_ _13206_ VDD VSS XNOR2_X1
X_22581_ _13200_ _13202_ _13207_ VDD VSS NAND2_X1
X_22582_ _06299_ _09009_ net852 _13208_ VDD VSS NAND3_X1
X_22583_ _13206_ _13207_ _13208_ _13209_ VDD VSS AOI21_X2
X_22584_ _06306_ _08971_ _00460_ _13210_ VDD VSS NAND3_X1
X_22585_ _06299_ net831 _13211_ VDD VSS NAND2_X1
X_22586_ _13210_ _13211_ _00460_ _13212_ VDD VSS OAI21_X2
X_22587_ _13209_ _13204_ _13212_ _13213_ VDD VSS NOR3_X4
X_22588_ net862 _13214_ VDD VSS INV_X2
X_22589_ _13214_ _13215_ VDD VSS BUF_X4
X_22590_ _13215_ _13216_ VDD VSS BUF_X4
X_22591_ _13216_ _13217_ VDD VSS BUF_X4
X_22592_ _13217_ _13218_ VDD VSS BUF_X4
X_22593_ _13218_ _15011_ VDD VSS BUF_X4
X_22594_ _13196_ _13219_ VDD VSS BUF_X4
X_22595_ _13219_ _14986_ VDD VSS BUF_X4
X_22596_ net863 _13220_ VDD VSS BUF_X4
X_22597_ _13220_ _13221_ VDD VSS BUF_X4
X_22598_ _13221_ _13222_ VDD VSS BUF_X4
X_22599_ _13222_ _13223_ VDD VSS BUF_X4
X_22600_ _13223_ _15004_ VDD VSS BUF_X4
X_22601_ _10432_ _10506_ _13224_ VDD VSS XNOR2_X2
X_22602_ _10514_ net794 _13225_ VDD VSS XNOR2_X1
X_22603_ _10503_ _13225_ _13226_ VDD VSS XNOR2_X1
X_22604_ text_in_r\[55\] _13226_ _09175_ _13227_ VDD VSS MUX2_X2
X_22605_ _06590_ _13227_ _13228_ VDD VSS XNOR2_X2
X_22606_ _10512_ _10505_ _13229_ VDD VSS XNOR2_X2
X_22607_ _10523_ _10513_ _13230_ VDD VSS XNOR2_X1
X_22608_ _13229_ _13230_ _13231_ VDD VSS XNOR2_X1
X_22609_ _10515_ _13231_ _13232_ VDD VSS XNOR2_X1
X_22610_ text_in_r\[54\] _13232_ _11191_ _13233_ VDD VSS MUX2_X2
X_22611_ _06578_ _13233_ _13234_ VDD VSS XOR2_X2
X_22612_ _13234_ _13235_ VDD VSS BUF_X4
X_22613_ _13228_ _13235_ _13236_ VDD VSS NOR2_X2
X_22614_ _13216_ _13237_ VDD VSS BUF_X4
X_22615_ _13237_ _13238_ VDD VSS CLKBUF_X3
Xclone123 _13284_ net123 VDD VSS BUF_X8
X_22617_ _14990_ _13240_ VDD VSS BUF_X4
X_22618_ _06228_ net828 _13241_ VDD VSS NAND2_X1
X_22619_ _06228_ _13242_ VDD VSS INV_X1
X_22620_ _13242_ net828 _13243_ VDD VSS NAND2_X1
X_22621_ _10480_ _10504_ _13244_ VDD VSS XNOR2_X1
X_22622_ _10554_ _10535_ _13245_ VDD VSS XOR2_X1
X_22623_ _10551_ _13245_ _13246_ VDD VSS XNOR2_X1
X_22624_ _13244_ _13246_ _13247_ VDD VSS XNOR2_X1
X_22625_ _13241_ _13243_ _13247_ _13248_ VDD VSS MUX2_X1
X_22626_ _13248_ _13249_ VDD VSS BUF_X8
X_22627_ _13242_ net829 text_in_r\[51\] _13250_ VDD VSS OR3_X2
X_22628_ _13242_ _09027_ text_in_r\[51\] _13251_ VDD VSS NAND3_X2
X_22629_ _13250_ _13251_ _13252_ VDD VSS AND2_X1
X_22630_ _13252_ _13253_ VDD VSS BUF_X8
X_22631_ _13249_ _13253_ _13254_ VDD VSS NAND2_X1
X_22632_ _13254_ _13255_ VDD VSS BUF_X4
X_22633_ _13255_ _13256_ VDD VSS BUF_X8
X_22634_ _13256_ _13257_ VDD VSS BUF_X4
X_22635_ _13240_ _13257_ _13258_ VDD VSS NOR2_X1
X_22636_ _13242_ _09726_ _13259_ VDD VSS NOR2_X1
X_22637_ _06228_ _09726_ _13260_ VDD VSS NOR2_X1
X_22638_ _13259_ _13260_ _13247_ _13261_ VDD VSS MUX2_X1
X_22639_ _13261_ _13262_ VDD VSS BUF_X8
X_22640_ _13250_ _13251_ _13263_ VDD VSS NAND2_X4
X_22641_ _13196_ _13262_ _13263_ _13264_ VDD VSS OAI21_X4
X_22642_ net156 _13264_ _13265_ VDD VSS NOR2_X1
X_22643_ _13238_ _13258_ _13265_ _13266_ VDD VSS NOR3_X1
X_22644_ _10541_ _10503_ _13267_ VDD VSS XNOR2_X1
X_22645_ _10551_ _13267_ _13268_ VDD VSS XNOR2_X1
X_22646_ _10536_ _10527_ _13269_ VDD VSS XOR2_X1
X_22647_ _10540_ _13269_ _13270_ VDD VSS XNOR2_X1
X_22648_ _13268_ _13270_ _13271_ VDD VSS XNOR2_X1
X_22649_ text_in_r\[52\] _13271_ _09023_ _13272_ VDD VSS MUX2_X2
X_22650_ _06284_ _13272_ _13273_ VDD VSS XNOR2_X2
X_22651_ _13273_ _13274_ VDD VSS BUF_X4
X_22652_ _13274_ _13275_ VDD VSS BUF_X4
X_22653_ _13275_ _13276_ VDD VSS BUF_X4
X_22654_ _14998_ _13277_ VDD VSS BUF_X4
X_22655_ net862 _13249_ _13253_ _13278_ VDD VSS AOI21_X4
X_22656_ _13277_ _13278_ _13279_ VDD VSS NAND2_X1
X_22657_ _13276_ _13279_ _13280_ VDD VSS NAND2_X1
X_22658_ _13262_ _13263_ _13281_ VDD VSS NOR2_X4
X_22659_ _13281_ _13282_ VDD VSS BUF_X4
X_22660_ _13196_ _13249_ _13253_ _13283_ VDD VSS NAND3_X4
X_22661_ _13175_ _13284_ VDD VSS BUF_X8
X_22662_ _13222_ _13282_ _13240_ _13283_ _13284_ _13285_ VDD
+ VSS OAI221_X2
X_22663_ _13249_ _13286_ VDD VSS BUF_X4
X_22664_ _13253_ _13287_ VDD VSS BUF_X4
X_22665_ _13214_ _13286_ _13287_ _13288_ VDD VSS NAND3_X4
X_22666_ _14996_ _13289_ VDD VSS BUF_X4
X_22667_ _13285_ _13288_ _13289_ _13290_ VDD VSS OAI21_X1
X_22668_ _13236_ _13266_ _13280_ _13290_ _13276_ _13291_ VDD
+ VSS OAI221_X1
X_22669_ _10536_ _10516_ _13292_ VDD VSS XNOR2_X1
X_22670_ _10525_ _13292_ _13293_ VDD VSS XNOR2_X1
X_22671_ _10526_ _13293_ _13294_ VDD VSS XNOR2_X1
X_22672_ text_in_r\[53\] _13294_ net828 _13295_ VDD VSS MUX2_X2
X_22673_ _06272_ _13295_ _13296_ VDD VSS XNOR2_X2
X_22674_ _13296_ _13297_ VDD VSS BUF_X4
X_22675_ _13297_ _13298_ VDD VSS BUF_X4
X_22676_ _06284_ _13272_ _13299_ VDD VSS XOR2_X2
X_22677_ _13299_ _13300_ VDD VSS BUF_X4
X_22678_ _06590_ _13227_ _13301_ VDD VSS XOR2_X2
X_22679_ _13301_ _13234_ _13302_ VDD VSS NAND2_X2
X_22680_ _13300_ _13302_ _13303_ VDD VSS NOR2_X1
X_22681_ _13289_ _13286_ _13287_ _13304_ VDD VSS AOI21_X2
X_22682_ _14989_ _13305_ VDD VSS BUF_X4
X_22683_ _13305_ _13262_ _13263_ _13306_ VDD VSS NOR3_X4
X_22684_ _13221_ _13304_ _13306_ _13307_ VDD VSS NOR3_X1
X_22685_ net155 _13219_ _13255_ _13308_ VDD VSS MUX2_X1
X_22686_ _13220_ _13309_ VDD VSS BUF_X4
X_22687_ _13307_ _13308_ _13309_ _13310_ VDD VSS AOI21_X1
X_22688_ _14990_ _13249_ _13253_ _13311_ VDD VSS NAND3_X1
Xclone125 _15125_ net125 VDD VSS BUF_X2
X_22690_ net502 _13262_ _13263_ _13313_ VDD VSS OAI21_X4
X_22691_ _13313_ _13311_ _13220_ _13314_ VDD VSS AND3_X4
X_22692_ _13262_ _13315_ VDD VSS BUF_X8
X_22693_ _13263_ _13316_ VDD VSS BUF_X8
X_22694_ _13220_ _13315_ _13316_ _13317_ VDD VSS NOR3_X4
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
X_22696_ _13314_ _13317_ _14988_ _13319_ VDD VSS AOI21_X2
X_22697_ _13275_ _13302_ _13320_ VDD VSS NOR2_X1
X_22698_ _13298_ _13303_ _13310_ _13319_ _13320_ _13321_ VDD
+ VSS AOI221_X2
X_22699_ _13291_ _13321_ _13322_ VDD VSS AND2_X1
X_22700_ _06578_ _13233_ _13323_ VDD VSS XNOR2_X2
X_22701_ _13323_ _13300_ _13324_ VDD VSS NOR2_X2
X_22702_ _13176_ _13281_ _13325_ VDD VSS NOR2_X2
X_22703_ _14986_ _13218_ _13326_ VDD VSS NAND2_X1
X_22704_ _13220_ _13315_ _13316_ _13327_ VDD VSS OAI21_X2
X_22705_ _13327_ _13328_ VDD VSS BUF_X4
X_22706_ _14993_ _13329_ VDD VSS BUF_X8
X_22707_ _13325_ _13326_ _13328_ _13329_ _13330_ VDD VSS OAI22_X1
X_22708_ _13301_ _13324_ _13330_ _13331_ VDD VSS AOI21_X1
X_22709_ _13305_ _13332_ VDD VSS INV_X8
X_22710_ _13332_ _13249_ _13253_ _13333_ VDD VSS NAND3_X2
X_22711_ _13256_ _13334_ VDD VSS CLKBUF_X3
X_22712_ _13289_ _13334_ _13335_ VDD VSS NAND2_X1
X_22713_ _13238_ _13333_ _13335_ _13336_ VDD VSS AOI21_X1
X_22714_ _13309_ _13337_ VDD VSS CLKBUF_X3
X_22715_ _13337_ _13338_ VDD VSS CLKBUF_X3
X_22716_ _13219_ _13315_ _13316_ _13339_ VDD VSS NOR3_X4
X_22717_ _13178_ _13339_ _13340_ VDD VSS NAND2_X2
X_22718_ _14988_ _13334_ _13341_ VDD VSS NAND2_X1
X_22719_ _13338_ _13340_ _13341_ _13342_ VDD VSS AOI21_X1
X_22720_ _13336_ _13342_ _13343_ VDD VSS NOR2_X1
X_22721_ _13323_ _13275_ _13344_ VDD VSS NAND2_X2
X_22722_ _13276_ _13345_ VDD VSS CLKBUF_X3
X_22723_ _13282_ _13346_ VDD VSS BUF_X4
X_22724_ _13346_ _13347_ VDD VSS BUF_X4
X_22725_ _13309_ _13348_ VDD VSS CLKBUF_X3
X_22726_ _14986_ _13348_ _13323_ _13349_ VDD VSS AOI21_X1
X_22727_ _13219_ _13174_ _13171_ _13350_ VDD VSS OAI21_X2
X_22728_ _13235_ _13350_ _13351_ VDD VSS NOR2_X1
X_22729_ _13347_ _13349_ _13351_ _13352_ VDD VSS OAI21_X1
X_22730_ _13305_ _13353_ VDD VSS BUF_X8
X_22731_ _13353_ _14995_ _13323_ _13354_ VDD VSS MUX2_X1
X_22732_ _15002_ _13355_ VDD VSS BUF_X4
X_22733_ _13355_ _13356_ VDD VSS INV_X8
X_22734_ _13356_ _13221_ _13357_ VDD VSS NOR2_X2
X_22735_ _13223_ _13354_ _13357_ _13235_ _13358_ VDD VSS AOI22_X2
X_22736_ _13264_ _13288_ _13235_ _13359_ VDD VSS MUX2_X1
X_22737_ _13352_ _13358_ _13347_ net160 _13359_ _13360_ VDD
+ VSS OAI221_X2
X_22738_ _13331_ _13343_ _13344_ _13345_ _13360_ _13361_ VDD
+ VSS OAI221_X2
X_22739_ _13300_ _13362_ VDD VSS BUF_X4
X_22740_ _13362_ _13363_ VDD VSS CLKBUF_X3
X_22741_ _13235_ _13364_ VDD VSS CLKBUF_X3
X_22742_ _13356_ _13346_ _13365_ VDD VSS NOR2_X1
X_22743_ _13175_ _13255_ _13366_ VDD VSS NOR2_X2
X_22744_ _13238_ _13365_ _13366_ _13367_ VDD VSS NOR3_X1
X_22745_ _13176_ _13255_ _13368_ VDD VSS NOR2_X4
X_22746_ _13368_ _13326_ _13369_ VDD VSS NOR2_X1
X_22747_ _13364_ _13367_ _13369_ _13370_ VDD VSS OAI21_X1
X_22748_ _13323_ _13371_ VDD VSS BUF_X4
X_22749_ _13305_ _13249_ _13253_ _13372_ VDD VSS NAND3_X4
X_22750_ net160 _13223_ _13373_ VDD VSS NOR2_X1
X_22751_ net589 _13238_ _13374_ VDD VSS NAND2_X1
X_22752_ _13371_ _13372_ _13373_ _13374_ _13368_ _13375_ VDD
+ VSS OAI221_X1
X_22753_ _13363_ _13370_ _13375_ _13376_ VDD VSS NAND3_X1
X_22754_ _06272_ _13295_ _13377_ VDD VSS XOR2_X2
X_22755_ _13377_ _13378_ VDD VSS BUF_X4
X_22756_ _13378_ _13379_ VDD VSS BUF_X4
X_22757_ _13289_ _13288_ _13380_ VDD VSS NOR2_X1
X_22758_ _13215_ _13286_ _13287_ _13381_ VDD VSS AOI21_X4
X_22759_ _13215_ _13315_ _13316_ _13382_ VDD VSS OAI21_X2
X_22760_ net862 _13249_ _13253_ _13383_ VDD VSS NAND3_X4
X_22761_ _13382_ _13383_ _13384_ VDD VSS NAND2_X1
X_22762_ _14988_ _13385_ VDD VSS INV_X2
X_22763_ _13380_ _13381_ net590 _13384_ _13385_ _13386_ VDD
+ VSS AOI221_X1
X_22764_ _13324_ _13383_ _13240_ _14995_ _13382_ _13387_ VDD
+ VSS OAI221_X1
X_22765_ _13284_ _13388_ VDD VSS BUF_X16
X_22766_ _13317_ _13381_ _14995_ _13389_ VDD VSS AOI21_X1
X_22767_ _13388_ _13389_ _13390_ VDD VSS NOR2_X1
X_22768_ _13344_ _13386_ _13387_ _13390_ _13391_ VDD VSS OAI22_X1
X_22769_ _13301_ _13379_ _13391_ _13392_ VDD VSS NOR3_X1
X_22770_ _13257_ _13393_ VDD VSS CLKBUF_X3
X_22771_ _15009_ _13393_ _13317_ _13353_ _13394_ VDD VSS AOI22_X1
X_22772_ _13364_ _13363_ _13394_ _13395_ VDD VSS AOI21_X1
X_22773_ _13219_ _13220_ _13396_ VDD VSS NAND2_X2
X_22774_ _13329_ _13309_ _13396_ _13284_ _13397_ VDD VSS OAI22_X4
X_22775_ _13275_ _13334_ _13397_ _13398_ VDD VSS OAI21_X2
X_22776_ _13197_ _13315_ _13316_ _13399_ VDD VSS OAI21_X4
X_22777_ _13311_ _13399_ _13400_ VDD VSS NAND2_X1
X_22778_ _13238_ _13400_ _13401_ VDD VSS NAND2_X1
X_22779_ _13401_ _13328_ _14988_ _13402_ VDD VSS OAI21_X1
X_22780_ _13395_ _13398_ _13402_ _13403_ VDD VSS OAI21_X1
X_22781_ _13301_ _13297_ _13404_ VDD VSS NAND2_X2
X_22782_ net590 _13282_ _13405_ VDD VSS NOR2_X2
X_22783_ _13277_ _13315_ _13316_ _13406_ VDD VSS NOR3_X4
X_22784_ _13337_ _13405_ _13406_ _13407_ VDD VSS OAI21_X1
X_22785_ _13234_ _13300_ _13408_ VDD VSS NAND2_X1
X_22786_ _13329_ _13288_ _13409_ VDD VSS NOR2_X2
X_22787_ _13408_ _13409_ _13410_ VDD VSS NOR2_X1
X_22788_ _13174_ _13411_ VDD VSS INV_X1
X_22789_ _06260_ _10571_ _13412_ VDD VSS NAND2_X1
X_22790_ _13164_ _10571_ _13413_ VDD VSS NAND2_X1
X_22791_ _13412_ _13413_ _13170_ _13414_ VDD VSS MUX2_X2
X_22792_ _13196_ _13411_ _13414_ _13415_ VDD VSS AOI21_X4
X_22793_ _13282_ _13415_ _13416_ VDD VSS NOR2_X1
X_22794_ _13329_ _13286_ _13287_ _13417_ VDD VSS NAND3_X2
X_22795_ _13399_ _13417_ _13418_ VDD VSS NAND2_X1
X_22796_ _13416_ _13418_ _13217_ _13419_ VDD VSS MUX2_X1
X_22797_ _13404_ _13407_ _13410_ _13419_ _13324_ _13420_ VDD
+ VSS AOI221_X2
X_22798_ _13361_ _13322_ _13376_ _13392_ _13403_ _13420_ _00080_
+ VDD VSS AOI222_X2
X_22799_ _13234_ _13274_ _13421_ VDD VSS NAND2_X2
X_22800_ _13298_ _13422_ VDD VSS CLKBUF_X3
X_22801_ _13237_ _13283_ _13313_ _13423_ VDD VSS AOI21_X2
X_22802_ _13385_ net158 _13256_ _13424_ VDD VSS MUX2_X1
X_22803_ _13423_ _13424_ _13238_ _13425_ VDD VSS AOI21_X1
X_22804_ _13332_ _13262_ _13263_ _13426_ VDD VSS OAI21_X4
X_22805_ _13218_ _13340_ _13426_ _13427_ VDD VSS AOI21_X1
X_22806_ _13298_ _13283_ _13223_ _13428_ VDD VSS OAI21_X1
X_22807_ _13422_ _13425_ _13427_ _13428_ _13429_ VDD VSS OAI22_X1
X_22808_ _15012_ _13430_ VDD VSS INV_X1
X_22809_ _13347_ _13298_ _13430_ _13431_ VDD VSS AOI21_X1
X_22810_ _13289_ _13415_ _13223_ _13432_ VDD VSS MUX2_X1
X_22811_ _13431_ _13432_ _13347_ _13433_ VDD VSS AOI21_X1
X_22812_ _13228_ _13421_ _13429_ _13433_ _13344_ _13434_ VDD
+ VSS OAI221_X1
X_22813_ _13309_ _13283_ _13426_ _13435_ VDD VSS AOI21_X1
X_22814_ _13240_ _13436_ VDD VSS INV_X1
X_22815_ _13436_ _13334_ _13437_ VDD VSS NOR2_X1
X_22816_ _14988_ _13286_ _13287_ _13438_ VDD VSS AOI21_X2
X_22817_ _15011_ _13437_ _13438_ _13439_ VDD VSS NOR3_X1
X_22818_ _13379_ _13435_ _13439_ _13440_ VDD VSS OAI21_X1
X_22819_ _13255_ _13415_ _13441_ VDD VSS AND2_X1
X_22820_ _13218_ _13334_ _13240_ _13442_ VDD VSS OAI21_X1
X_22821_ _13332_ _13286_ _13287_ _13443_ VDD VSS AOI21_X2
X_22822_ _13262_ net835 _13263_ _13444_ VDD VSS NOR3_X4
X_22823_ _13443_ _13444_ _13445_ VDD VSS OR2_X1
X_22824_ _13422_ _13441_ _13442_ _13445_ _15011_ _13446_ VDD
+ VSS OAI221_X1
X_22825_ _13408_ _13440_ _13446_ _13447_ VDD VSS AOI21_X1
X_22826_ net500 _13282_ _13448_ VDD VSS NOR2_X4
X_22827_ _13197_ _13215_ _13449_ VDD VSS NAND2_X2
X_22828_ _13396_ _13449_ _13450_ VDD VSS AND2_X1
X_22829_ _13396_ _13222_ _13385_ _13451_ VDD VSS OAI21_X1
X_22830_ _13297_ _13448_ _13450_ _13451_ _13346_ _13452_ VDD
+ VSS AOI221_X2
X_22831_ _13284_ _13282_ _13453_ VDD VSS XNOR2_X1
X_22832_ _13423_ _13453_ _13218_ _13454_ VDD VSS AOI21_X1
X_22833_ _13378_ _13454_ _13455_ VDD VSS NOR2_X1
X_22834_ _13364_ _13345_ _13452_ _13455_ _13456_ VDD VSS NOR4_X1
X_22835_ _13301_ _13379_ _13457_ VDD VSS NAND2_X1
X_22836_ _13348_ _13275_ _13339_ _13458_ VDD VSS NOR3_X1
X_22837_ _13302_ _13313_ _13458_ _13459_ VDD VSS AOI21_X1
X_22838_ _14995_ _13382_ _13383_ _13460_ VDD VSS AOI21_X1
X_22839_ net589 _13288_ _13399_ _13178_ _13461_ VDD VSS OAI22_X1
X_22840_ _13276_ _13460_ _13461_ _13462_ VDD VSS OAI21_X1
X_22841_ _13362_ _13463_ VDD VSS BUF_X4
X_22842_ _13305_ _13315_ _13316_ _13464_ VDD VSS OAI21_X4
X_22843_ _14988_ _13286_ _13287_ _13465_ VDD VSS NAND3_X2
X_22844_ _13218_ _13464_ _13465_ _13466_ VDD VSS AOI21_X1
X_22845_ _13463_ _13466_ _13467_ VDD VSS NAND2_X1
X_22846_ _13459_ _13462_ _13467_ _13468_ VDD VSS NAND3_X1
X_22847_ _13353_ _13237_ _13469_ VDD VSS NAND2_X1
X_22848_ net157 _13222_ _13470_ VDD VSS NAND2_X1
X_22849_ _13346_ _13469_ _13470_ _13471_ VDD VSS AOI21_X2
X_22850_ _13409_ _13384_ _13178_ _13472_ VDD VSS AOI21_X1
X_22851_ _13236_ _13398_ _13471_ _13472_ _13276_ _13473_ VDD
+ VSS OAI221_X1
X_22852_ _13457_ _13468_ _13473_ _13474_ VDD VSS AND3_X1
X_22853_ _13388_ _14987_ VDD VSS BUF_X32
X_22854_ _14987_ _13278_ _13339_ _13475_ VDD VSS OAI21_X1
X_22855_ _13363_ _13449_ _13475_ _13476_ VDD VSS AOI21_X1
X_22856_ _13364_ _13298_ _13477_ VDD VSS NOR2_X1
X_22857_ _13417_ _13464_ _13478_ VDD VSS AND2_X1
X_22858_ _13222_ _13362_ _13479_ VDD VSS NAND2_X1
X_22859_ _13477_ _13478_ _13479_ _13480_ VDD VSS OAI21_X1
X_22860_ _13197_ _13315_ _13316_ _13481_ VDD VSS NOR3_X4
X_22861_ _13481_ _13463_ net160 _13482_ VDD VSS OAI21_X1
X_22862_ _13338_ _13399_ _13482_ _13483_ VDD VSS AOI21_X1
X_22863_ _13476_ _13480_ _13483_ _13484_ VDD VSS NOR3_X1
X_22864_ _13348_ _13416_ _13485_ VDD VSS NOR2_X1
X_22865_ _13222_ _13426_ _13417_ _13486_ VDD VSS AND3_X1
X_22866_ _13337_ _13257_ net157 _13487_ VDD VSS AOI21_X1
X_22867_ _13362_ _13328_ net159 _13488_ VDD VSS OAI21_X1
X_22868_ _13177_ _14995_ _13489_ VDD VSS NAND2_X1
X_22869_ _13257_ _13489_ _13490_ VDD VSS NOR2_X1
X_22870_ _13486_ _13485_ _13463_ _13487_ _13488_ _13490_ _13491_
+ VDD VSS OAI33_X1
X_22871_ _13371_ _13422_ _13491_ _13492_ VDD VSS NOR3_X1
X_22872_ _13434_ _13447_ _13456_ _13474_ _13484_ _13492_ _00081_
+ VDD VSS OAI33_X1
X_22873_ _13274_ _13377_ _13493_ VDD VSS NOR2_X2
X_22874_ _13348_ _13426_ _13465_ _13494_ VDD VSS AOI21_X1
X_22875_ _13282_ _13495_ VDD VSS BUF_X4
X_22876_ _13216_ _13304_ _13495_ net158 _13496_ VDD VSS AOI211_X2
X_22877_ _13371_ _13494_ _13496_ _13497_ VDD VSS NOR3_X1
X_22878_ _15016_ _13498_ VDD VSS INV_X1
X_22879_ _13234_ _13448_ _13449_ _13346_ _13498_ _13499_ VDD
+ VSS AOI221_X2
X_22880_ _13493_ _13497_ _13499_ _13500_ VDD VSS OAI21_X1
X_22881_ _13274_ _13297_ _13501_ VDD VSS NAND2_X1
X_22882_ _13234_ _13381_ _13502_ VDD VSS NAND2_X1
X_22883_ _13237_ _13323_ _13481_ _13503_ VDD VSS NAND3_X1
X_22884_ _13388_ _13502_ _13503_ _13504_ VDD VSS AOI21_X1
X_22885_ _13234_ _13256_ _15007_ _13505_ VDD VSS AOI21_X1
X_22886_ _13197_ _13249_ _13253_ _13506_ VDD VSS AOI21_X4
X_22887_ _15012_ _13495_ _13506_ net115 _13507_ VDD VSS AOI22_X1
X_22888_ _13505_ _13507_ _13235_ _13508_ VDD VSS AOI21_X1
X_22889_ _13501_ _13504_ _13508_ _13509_ VDD VSS OR3_X1
X_22890_ _13301_ _13500_ _13509_ _13510_ VDD VSS AND3_X1
X_22891_ _14992_ _13223_ _13399_ _13511_ VDD VSS NAND3_X1
X_22892_ _14995_ _13222_ _13512_ VDD VSS NAND2_X1
X_22893_ net123 _13334_ _13512_ _13513_ VDD VSS NAND3_X1
X_22894_ _13511_ _13513_ _13514_ VDD VSS NAND2_X1
X_22895_ _13222_ _13257_ _13177_ _13515_ VDD VSS MUX2_X1
X_22896_ _13235_ _13515_ net589 _13516_ VDD VSS OAI21_X1
X_22897_ _14990_ _14993_ _13517_ VDD VSS NOR2_X1
X_22898_ _13215_ _13255_ _13517_ _13339_ _13176_ _13518_ VDD
+ VSS AOI221_X2
X_22899_ _13348_ _13346_ _13289_ _13519_ VDD VSS AOI21_X1
X_22900_ _13334_ _13415_ _13520_ VDD VSS NAND2_X1
X_22901_ _13518_ _13519_ _13520_ _13521_ VDD VSS AOI21_X1
X_22902_ _13363_ _13514_ _13516_ _13521_ _13364_ _13522_ VDD
+ VSS OAI221_X1
X_22903_ _13393_ _13396_ _14987_ _13338_ _13353_ _13523_ VDD
+ VSS OAI221_X1
X_22904_ _13421_ _13347_ _15009_ _13524_ VDD VSS AOI21_X1
X_22905_ _13338_ _13426_ _13465_ _13525_ VDD VSS NAND3_X1
X_22906_ _13344_ _13278_ net926 _13526_ VDD VSS AOI21_X1
X_22907_ _13523_ _13524_ _13525_ _13526_ _13527_ VDD VSS AOI22_X1
X_22908_ _13379_ _13522_ _13527_ _13528_ VDD VSS NAND3_X1
X_22909_ _13234_ _13362_ _13529_ VDD VSS NOR2_X1
X_22910_ _14998_ _13249_ _13253_ _13530_ VDD VSS AOI21_X4
X_22911_ _13218_ _13481_ _13530_ _13531_ VDD VSS NOR3_X1
X_22912_ _13337_ _13448_ _13444_ _13532_ VDD VSS NOR3_X1
X_22913_ _13408_ _13531_ _13532_ _13533_ VDD VSS NOR3_X1
X_22914_ _13337_ _13406_ _13443_ _13534_ VDD VSS NOR3_X1
X_22915_ _13405_ _13481_ _13237_ _13535_ VDD VSS NOR3_X1
X_22916_ _13217_ _13399_ _13372_ _13536_ VDD VSS AOI21_X4
X_22917_ _13240_ _13286_ _13287_ _13537_ VDD VSS AOI21_X1
X_22918_ _13222_ _13537_ _13366_ _13538_ VDD VSS NOR3_X1
X_22919_ _13463_ _13534_ _13535_ _13536_ _13538_ _13235_ _13539_
+ VDD VSS OAI33_X1
X_22920_ _13539_ _13533_ _13529_ _13540_ VDD VSS OR3_X1
X_22921_ _13228_ _13379_ _13541_ VDD VSS NAND2_X1
X_22922_ net623 _13348_ _13506_ _13339_ _13542_ VDD VSS NOR4_X1
X_22923_ net157 _13328_ _13543_ VDD VSS NOR2_X1
X_22924_ _13344_ _13542_ _13543_ _13544_ VDD VSS NOR3_X1
X_22925_ _13541_ _13544_ _13545_ VDD VSS NOR2_X1
X_22926_ net1141 _13220_ _13546_ VDD VSS NOR2_X4
X_22927_ _13277_ _13282_ _13547_ VDD VSS AND2_X1
X_22928_ _13217_ _13448_ _13547_ _13548_ VDD VSS NOR3_X1
X_22929_ _13421_ _13546_ _13548_ _13549_ VDD VSS NOR3_X2
X_22930_ _13217_ _13265_ _13368_ _13550_ VDD VSS NOR3_X1
X_22931_ _13329_ _13286_ _13287_ _13551_ VDD VSS AOI21_X2
X_22932_ _13309_ _13551_ _13306_ _13552_ VDD VSS NOR3_X1
X_22933_ _13550_ _13552_ _13553_ VDD VSS OR2_X1
X_22934_ _13216_ _13506_ _13406_ _13554_ VDD VSS NOR3_X1
X_22935_ _13551_ _13309_ _13444_ _13555_ VDD VSS NOR3_X1
X_22936_ _13555_ _13554_ _13323_ _13556_ VDD VSS NOR3_X1
X_22937_ _13214_ _13262_ _13263_ _13557_ VDD VSS NOR3_X4
X_22938_ _13399_ _13255_ _13356_ _13558_ VDD VSS OAI21_X2
X_22939_ _13325_ net926 _13557_ _13558_ _13216_ _13559_ VDD
+ VSS AOI221_X2
X_22940_ _13556_ _13559_ _13323_ _13560_ VDD VSS AOI21_X2
X_22941_ _13549_ _13553_ _13529_ _13463_ _13560_ _13561_ VDD
+ VSS AOI221_X2
X_22942_ _13301_ _13379_ _13562_ VDD VSS NOR2_X2
X_22943_ _13510_ _13528_ _13545_ _13540_ _13562_ _13561_ _00082_
+ VDD VSS AOI222_X2
X_22944_ _13236_ _13378_ _13563_ VDD VSS NAND2_X1
X_22945_ _13289_ _13393_ _13564_ VDD VSS NOR2_X1
X_22946_ _15011_ _13564_ _13438_ _13565_ VDD VSS NOR3_X1
X_22947_ _13338_ _13339_ _13405_ _13566_ VDD VSS NOR3_X1
X_22948_ _13363_ _13565_ _13566_ _13567_ VDD VSS OAI21_X1
X_22949_ _13356_ _13393_ _13568_ VDD VSS NAND2_X1
X_22950_ _15004_ _13372_ _13568_ _13569_ VDD VSS NAND3_X1
X_22951_ _13338_ _13551_ _13368_ _13570_ VDD VSS OR3_X1
X_22952_ _13345_ _13569_ _13570_ _13571_ VDD VSS NAND3_X1
X_22953_ _13563_ _13567_ _13571_ _13572_ VDD VSS AOI21_X1
X_22954_ _13289_ _13573_ VDD VSS INV_X1
X_22955_ _13275_ _13288_ _13353_ _13328_ _13573_ _13574_ VDD
+ VSS OAI221_X1
X_22956_ _14995_ _13382_ _13512_ _13393_ _13575_ VDD VSS OAI22_X1
X_22957_ _13574_ _13575_ net160 _13576_ VDD VSS AOI21_X1
X_22958_ _13463_ _13264_ _13178_ _13288_ _13573_ _13577_ VDD
+ VSS OAI221_X1
X_22959_ _13379_ _13536_ _13577_ _13578_ VDD VSS OAI21_X1
X_22960_ _13302_ _13576_ _13578_ _13579_ VDD VSS NOR3_X2
X_22961_ _13228_ _13235_ _13378_ _13580_ VDD VSS NOR3_X2
X_22962_ net115 _13221_ _13299_ _13282_ _13581_ VDD VSS NOR4_X1
X_22963_ _13217_ _13274_ _13582_ VDD VSS NAND2_X1
X_22964_ _13581_ _13582_ _13443_ _13362_ _13381_ _13583_ VDD
+ VSS AOI221_X1
X_22965_ _13219_ _13217_ _13274_ _13584_ VDD VSS NOR3_X1
X_22966_ _13219_ _13274_ _13585_ VDD VSS NAND2_X1
X_22967_ net115 _13288_ _13586_ VDD VSS NOR2_X1
X_22968_ _13219_ _13215_ _13587_ VDD VSS NOR2_X2
X_22969_ _13300_ _13587_ _13588_ VDD VSS NOR2_X1
X_22970_ _13584_ _13585_ _13586_ _13588_ _13368_ _13589_ VDD
+ VSS AOI221_X1
X_22971_ _13580_ _13583_ _13589_ _13590_ VDD VSS NAND3_X1
X_22972_ _13273_ _13197_ net155 _13591_ VDD VSS OAI21_X1
X_22973_ net590 _13383_ _13592_ VDD VSS NOR2_X1
X_22974_ _13449_ _13339_ net158 _13593_ VDD VSS OAI21_X1
X_22975_ _13378_ _13591_ _13592_ _13593_ _13274_ _13594_ VDD
+ VSS AOI221_X2
X_22976_ _13547_ _13393_ net157 _13595_ VDD VSS AOI21_X1
X_22977_ _13216_ _13299_ _13596_ VDD VSS NAND2_X1
X_22978_ _13594_ _13595_ _13596_ net623 _13328_ _13597_ VDD
+ VSS OAI221_X1
X_22979_ _13590_ _13597_ _13302_ _13598_ VDD VSS OAI21_X1
X_22980_ _13196_ _13383_ _13599_ VDD VSS NOR2_X2
X_22981_ _13277_ _13377_ _13600_ VDD VSS AND2_X1
X_22982_ _13278_ _13557_ _13601_ VDD VSS NOR2_X2
X_22983_ _13299_ _13377_ _13599_ _13600_ _13601_ _13602_ VDD
+ VSS AOI221_X2
X_22984_ net1 _14990_ _13603_ VDD VSS OR2_X4
X_22985_ _13603_ _13263_ _13262_ _13604_ VDD VSS OAI21_X2
X_22986_ _13372_ _13604_ _13605_ VDD VSS AND2_X2
X_22987_ _13283_ _13281_ _13355_ _13606_ VDD VSS OAI21_X1
X_22988_ _13605_ _13606_ _13215_ _13607_ VDD VSS MUX2_X1
X_22989_ _13436_ _13281_ _13333_ _13296_ _13608_ VDD VSS OAI22_X1
X_22990_ _13273_ _13608_ _13221_ _13609_ VDD VSS AOI21_X2
X_22991_ _13426_ _13254_ _14996_ _13610_ VDD VSS OAI21_X1
X_22992_ net156 _13557_ _13610_ _13215_ _13611_ VDD VSS AOI22_X2
X_22993_ _13234_ _13607_ _13602_ _13609_ _13611_ _13612_ VDD
+ VSS AOI221_X2
X_22994_ _13378_ _13602_ _13609_ _13613_ VDD VSS OAI21_X1
X_22995_ _13273_ _13297_ _13614_ VDD VSS NOR2_X2
X_22996_ _13220_ _13306_ _13530_ _13615_ VDD VSS OAI21_X1
X_22997_ _13264_ _13255_ _13356_ _13616_ VDD VSS OAI21_X1
X_22998_ _13615_ _13616_ _13221_ _13617_ VDD VSS OAI21_X1
X_22999_ _13256_ _13357_ _13618_ VDD VSS NOR2_X1
X_23000_ _13299_ _13297_ _13619_ VDD VSS NAND2_X1
X_23001_ _13619_ _13587_ _13620_ VDD VSS NOR2_X1
X_23002_ _13323_ _13614_ _13617_ _13618_ _13620_ _13621_ VDD
+ VSS AOI221_X2
X_23003_ _13216_ _13256_ _13573_ _13622_ VDD VSS OAI21_X1
X_23004_ _13622_ _13530_ _13623_ VDD VSS OR2_X1
X_23005_ _13501_ _13518_ _13624_ VDD VSS NOR2_X1
X_23006_ _14995_ _13237_ _13368_ _13625_ VDD VSS OAI21_X1
X_23007_ _13273_ _13377_ _13626_ VDD VSS NAND2_X1
X_23008_ _13626_ _13317_ net155 _13385_ _13381_ _13627_ VDD
+ VSS AOI221_X2
X_23009_ _13623_ _13624_ _13625_ _13627_ _13628_ VDD VSS AOI22_X2
X_23010_ _13301_ _13613_ _13612_ _13621_ _13628_ _13629_ VDD
+ VSS AOI221_X2
X_23011_ _13629_ _13579_ _13598_ _13572_ _00083_ VDD VSS NOR4_X2
X_23012_ _15000_ _13346_ _13630_ VDD VSS NAND2_X1
X_23013_ _13630_ _13469_ _13347_ _13631_ VDD VSS OAI21_X1
X_23014_ _15004_ _13399_ _13465_ _13632_ VDD VSS AOI21_X1
X_23015_ _13422_ _13383_ _13240_ net623 _13264_ _13633_ VDD
+ VSS OAI221_X1
X_23016_ _13345_ _13422_ _13631_ _13632_ _13633_ _13634_ VDD
+ VSS OAI221_X1
X_23017_ _13347_ _13350_ _13635_ VDD VSS AND2_X1
X_23018_ _15004_ _13635_ _13448_ _13636_ VDD VSS OAI21_X1
X_23019_ _13279_ _13614_ _13636_ _13637_ VDD VSS NAND3_X1
X_23020_ _13228_ _13371_ _13638_ VDD VSS NAND2_X1
X_23021_ _13279_ _13340_ _13493_ _13639_ VDD VSS AND3_X1
X_23022_ _15004_ _13506_ _13368_ _13640_ VDD VSS OAI21_X1
X_23023_ _13638_ _13639_ _13640_ _13641_ VDD VSS AOI21_X1
X_23024_ _13634_ _13637_ _13641_ _13642_ VDD VSS NAND3_X1
X_23025_ _13197_ _13216_ _13273_ _13643_ VDD VSS AOI21_X1
X_23026_ _13495_ _13643_ net115 _13219_ _13217_ _13644_ VDD
+ VSS OAI221_X2
X_23027_ net158 _13309_ _13645_ VDD VSS NAND2_X1
X_23028_ _13256_ _13596_ _13385_ _13645_ _13300_ _13646_ VDD
+ VSS OAI221_X2
X_23029_ _13274_ _13506_ _13647_ VDD VSS NAND2_X1
X_23030_ _13479_ _13647_ _13648_ VDD VSS NAND2_X1
X_23031_ _13404_ _13644_ _13646_ _13648_ net123 _13649_ VDD
+ VSS AOI221_X2
X_23032_ _13228_ _13298_ _13650_ VDD VSS NOR2_X1
X_23033_ _13277_ _13315_ _13316_ _13651_ VDD VSS OAI21_X2
X_23034_ _13237_ _13651_ _13652_ VDD VSS AND2_X1
X_23035_ _13463_ _13258_ _13652_ _13653_ VDD VSS OAI21_X1
X_23036_ _13237_ _13495_ _13388_ _13654_ VDD VSS OAI21_X2
X_23037_ _13385_ _13257_ _13655_ VDD VSS NOR2_X1
X_23038_ _13588_ _13654_ _13655_ _13656_ VDD VSS OAI21_X1
X_23039_ _13650_ _13653_ _13656_ _13657_ VDD VSS AND3_X1
X_23040_ _13236_ _13649_ _13657_ _13658_ VDD VSS NOR3_X1
X_23041_ _13300_ _13377_ _13659_ VDD VSS NAND2_X1
X_23042_ _13309_ _13417_ _13464_ _13660_ VDD VSS AOI21_X1
X_23043_ _13660_ _13337_ _13277_ _13661_ VDD VSS AOI21_X1
X_23044_ _13371_ _13659_ _13661_ _13662_ VDD VSS OAI21_X1
X_23045_ _13306_ _13530_ _13663_ VDD VSS NOR2_X1
X_23046_ _13215_ _13444_ _13664_ VDD VSS NOR2_X1
X_23047_ net155 _13506_ _13665_ VDD VSS NAND2_X2
X_23048_ _13297_ _13663_ _13215_ _13664_ _13665_ _13666_ VDD
+ VSS AOI221_X1
X_23049_ _13197_ _13214_ _13667_ VDD VSS NOR2_X1
X_23050_ net155 _13667_ _13668_ VDD VSS NAND2_X1
X_23051_ _13255_ _13546_ _13669_ VDD VSS NOR2_X2
X_23052_ _13385_ _13220_ _13670_ VDD VSS NAND2_X1
X_23053_ _13670_ _13220_ _13175_ _13671_ VDD VSS OAI21_X1
X_23054_ _13299_ _13669_ _13668_ _13671_ _13255_ _13672_ VDD
+ VSS AOI221_X2
X_23055_ _13666_ _13672_ _13297_ _13673_ VDD VSS AOI21_X2
X_23056_ _13444_ _13256_ _13284_ _13674_ VDD VSS AOI21_X1
X_23057_ _13315_ net926 _13316_ _13675_ VDD VSS NOR3_X4
X_23058_ _13217_ _13675_ _13676_ VDD VSS NOR2_X1
X_23059_ _13218_ _13674_ _13676_ _13665_ _13677_ VDD VSS AOI22_X1
X_23060_ _13672_ _13677_ _13678_ VDD VSS NOR2_X1
X_23061_ _13662_ _13673_ _13276_ _13298_ _13678_ _13679_ VDD
+ VSS AOI221_X2
X_23062_ _13301_ _13371_ _13680_ VDD VSS NOR2_X1
X_23063_ _13680_ _13681_ VDD VSS INV_X1
X_23064_ _15004_ _13276_ _13682_ VDD VSS NOR2_X1
X_23065_ _13422_ _13441_ _13682_ _13683_ VDD VSS AOI21_X1
X_23066_ _13675_ _13415_ _13393_ _13684_ VDD VSS AOI21_X1
X_23067_ _15004_ _13363_ _13684_ _13685_ VDD VSS OAI21_X1
X_23068_ _13332_ _13240_ _13362_ _13686_ VDD VSS MUX2_X1
X_23069_ _13647_ _13686_ _13393_ _13687_ VDD VSS OAI21_X1
X_23070_ _13685_ _13687_ _15004_ _13688_ VDD VSS OAI21_X1
X_23071_ _13313_ _13257_ _14988_ _13689_ VDD VSS OAI21_X1
X_23072_ _13453_ _13689_ _13337_ _13690_ VDD VSS MUX2_X1
X_23073_ _13223_ _13283_ _13317_ _13356_ _13691_ VDD VSS AOI22_X1
X_23074_ _13690_ _13691_ _13276_ _13692_ VDD VSS MUX2_X1
X_23075_ _13683_ _13688_ _13692_ _13422_ _13693_ VDD VSS AOI22_X2
X_23076_ _13642_ _13658_ _13679_ _13681_ _13693_ _00084_ VDD
+ VSS OAI221_X1
X_23077_ _13377_ _13327_ _13603_ _13694_ VDD VSS OAI21_X2
X_23078_ _13356_ _13216_ _13695_ VDD VSS NAND2_X1
X_23079_ net926 _13317_ _13695_ _13256_ _13696_ VDD VSS AOI22_X4
X_23080_ _13694_ _13300_ _13696_ _13366_ _13450_ _13697_ VDD
+ VSS AOI221_X2
X_23081_ _13501_ _13557_ _13415_ _13289_ _13257_ _13698_ VDD
+ VSS AOI221_X1
X_23082_ _13698_ _13697_ _13699_ VDD VSS NOR2_X1
X_23083_ _13276_ _13378_ _13696_ _13700_ VDD VSS AOI21_X1
X_23084_ _13223_ _13306_ _13443_ _13701_ VDD VSS OAI21_X1
X_23085_ _13304_ _13282_ _13355_ _13702_ VDD VSS AOI21_X1
X_23086_ _13701_ _13702_ _13338_ _13703_ VDD VSS OAI21_X1
X_23087_ _13700_ _13703_ _13379_ _13704_ VDD VSS OAI21_X1
X_23088_ _13638_ _13704_ _13699_ _13705_ VDD VSS AOI21_X1
X_23089_ _13356_ _13176_ _13281_ _13706_ VDD VSS MUX2_X1
X_23090_ _13314_ _13216_ _13706_ _13707_ VDD VSS AOI21_X2
X_23091_ _13377_ _13278_ _13197_ _13708_ VDD VSS AOI21_X1
X_23092_ _13362_ _13707_ _13377_ _13708_ _13615_ _13709_ VDD
+ VSS AOI221_X2
X_23093_ _13223_ _13417_ _13710_ VDD VSS NAND2_X1
X_23094_ _13619_ _13710_ _13665_ _13711_ VDD VSS AOI21_X1
X_23095_ _13277_ _13317_ _13712_ VDD VSS NAND2_X1
X_23096_ _13285_ _13313_ _13614_ _13712_ _13713_ VDD VSS AND4_X1
X_23097_ _13709_ _13302_ _13711_ _13713_ _13714_ VDD VSS NOR4_X2
X_23098_ _13348_ _13311_ _13464_ _13715_ VDD VSS AOI21_X1
X_23099_ _13362_ _13383_ net159 _13716_ VDD VSS OAI21_X1
X_23100_ _13438_ _13495_ _13355_ _13717_ VDD VSS AOI21_X1
X_23101_ _13353_ _13328_ _13717_ _13348_ _13718_ VDD VSS OAI22_X1
X_23102_ _13580_ _13715_ _13716_ _13718_ _13463_ _13719_ VDD
+ VSS OAI221_X1
X_23103_ _13300_ _13495_ _13720_ VDD VSS NOR2_X2
X_23104_ _13388_ _13557_ _13720_ _13721_ VDD VSS OAI21_X1
X_23105_ _13289_ _13278_ _13557_ _14986_ _13722_ VDD VSS AOI22_X1
X_23106_ _13300_ _13495_ _13723_ VDD VSS NAND2_X1
X_23107_ _13256_ _13327_ _13299_ _13724_ VDD VSS MUX2_X1
X_23108_ _13723_ _13724_ _13177_ _13725_ VDD VSS MUX2_X1
X_23109_ _13721_ _13722_ _13276_ _14986_ _13725_ _13726_ VDD
+ VSS OAI221_X1
X_23110_ _13719_ _13726_ _13563_ _13727_ VDD VSS OAI21_X1
X_23111_ _13409_ _13441_ _13221_ _13384_ _13219_ _13728_ VDD
+ VSS AOI221_X2
X_23112_ _13501_ _13728_ _13729_ VDD VSS NOR2_X1
X_23113_ _13221_ _13406_ _13730_ VDD VSS NOR2_X1
X_23114_ _13368_ _13405_ _13731_ VDD VSS NOR2_X1
X_23115_ _13659_ _13730_ _13665_ _13731_ _13309_ _13732_ VDD
+ VSS AOI221_X2
X_23116_ _13493_ _13702_ _13222_ _13415_ _13383_ _13733_ VDD
+ VSS OAI221_X1
X_23117_ net158 _13495_ _13734_ VDD VSS NAND2_X1
X_23118_ _13599_ _13734_ _14986_ _13735_ VDD VSS AOI21_X1
X_23119_ _13733_ _13735_ _13626_ _13736_ VDD VSS OAI21_X1
X_23120_ _13681_ _13729_ _13732_ _13736_ _13737_ VDD VSS NOR4_X1
X_23121_ _13714_ _13705_ _13727_ _13737_ _00085_ VDD VSS OR4_X2
X_23122_ _13353_ _13275_ _13738_ VDD VSS NAND2_X1
X_23123_ _13238_ _13275_ _13530_ _13738_ _13347_ _13739_ VDD
+ VSS AOI221_X2
X_23124_ net623 _13363_ _13720_ _14986_ _13740_ VDD VSS AOI22_X1
X_23125_ _13422_ _13723_ _14986_ _13740_ _15004_ _13741_ VDD
+ VSS OAI221_X2
X_23126_ _13337_ _13444_ _13275_ _13742_ VDD VSS OAI21_X2
X_23127_ net123 _13742_ _13585_ _13743_ VDD VSS AOI21_X2
X_23128_ _13339_ _13667_ net123 _13744_ VDD VSS AOI21_X1
X_23129_ _13449_ _13744_ net157 net159 _13264_ _13745_ VDD
+ VSS OAI221_X2
X_23130_ _13743_ _13720_ _13587_ _13363_ _13745_ _13746_ VDD
+ VSS AOI221_X2
X_23131_ _13680_ _13739_ _13741_ _13422_ _13746_ _13747_ VDD
+ VSS OAI221_X2
X_23132_ _13228_ _13345_ _13748_ VDD VSS NOR2_X1
X_23133_ _15011_ _13333_ _13604_ _13749_ VDD VSS NAND3_X1
X_23134_ _13338_ _13283_ _13651_ _13750_ VDD VSS NAND3_X1
X_23135_ _13379_ _13749_ _13750_ _13751_ VDD VSS AOI21_X1
X_23136_ _13651_ _13257_ _14988_ _13752_ VDD VSS OAI21_X1
X_23137_ _13297_ _13752_ _13337_ _13278_ _13240_ _13753_ VDD
+ VSS AOI221_X2
X_23138_ _13371_ _13751_ _13753_ _13754_ VDD VSS NOR3_X1
X_23139_ _15007_ _13495_ _13755_ VDD VSS NOR2_X1
X_23140_ _13353_ _13350_ _13217_ _13756_ VDD VSS MUX2_X1
X_23141_ _13298_ _13755_ _13756_ _13346_ _13757_ VDD VSS AOI211_X2
X_23142_ _13346_ _13512_ net160 _13758_ VDD VSS AOI21_X1
X_23143_ _13380_ _13378_ _13758_ _13759_ VDD VSS NOR3_X1
X_23144_ _13364_ _13757_ _13759_ _13760_ VDD VSS NOR3_X2
X_23145_ _13748_ _13754_ _13760_ _13761_ VDD VSS OAI21_X1
X_23146_ _13415_ _13287_ _13286_ net115 _13221_ _13762_ VDD
+ VSS AOI221_X2
X_23147_ _15005_ _15014_ _13334_ _13763_ VDD VSS NOR3_X1
X_23148_ _13379_ _13762_ _13763_ _13764_ VDD VSS OAI21_X1
X_23149_ _13337_ _13406_ _13765_ VDD VSS OR2_X1
X_23150_ _13444_ _13537_ _13766_ VDD VSS OR2_X2
X_23151_ _13298_ _13441_ _13765_ _13766_ _15011_ _13767_ VDD
+ VSS OAI221_X1
X_23152_ _13303_ _13764_ _13767_ _13768_ VDD VSS NAND3_X1
X_23153_ _13238_ _13399_ _13372_ _13769_ VDD VSS NAND3_X1
X_23154_ _13223_ _13603_ _13334_ _13264_ net123 _13770_ VDD
+ VSS OAI221_X2
X_23155_ _13422_ _13770_ _13769_ _13771_ VDD VSS NAND3_X1
X_23156_ _13372_ _13346_ net159 _13772_ VDD VSS OAI21_X1
X_23157_ _13378_ _13442_ _13265_ _13772_ _15011_ _13773_ VDD
+ VSS OAI221_X1
X_23158_ _13236_ _13345_ _13771_ _13773_ _13774_ VDD VSS NAND4_X1
X_23159_ _13393_ _13238_ _13277_ _13775_ VDD VSS AOI21_X1
X_23160_ _13237_ _13411_ _13414_ _13776_ VDD VSS AOI21_X1
X_23161_ _13463_ _13298_ _13776_ _13777_ VDD VSS NOR3_X1
X_23162_ _13638_ _13775_ _13777_ _13778_ VDD VSS AOI21_X1
X_23163_ _13614_ _13606_ _13338_ _13353_ _13328_ _13779_ VDD
+ VSS OAI221_X1
X_23164_ _13493_ _13622_ _13530_ _13325_ _15011_ _13780_ VDD
+ VSS OAI221_X1
X_23165_ _15006_ _13297_ _13781_ VDD VSS OR2_X1
X_23166_ _13720_ _13781_ _13378_ _13397_ _13782_ VDD VSS OAI211_X2
X_23167_ _13778_ _13779_ _13780_ _13782_ _13783_ VDD VSS NAND4_X1
X_23168_ _13774_ _13768_ _13783_ _13784_ VDD VSS AND3_X2
X_23169_ _13747_ _13761_ _13784_ _00086_ VDD VSS NAND3_X1
X_23170_ net926 _14992_ _13218_ _13785_ VDD VSS MUX2_X1
X_23171_ _13371_ _13734_ _13587_ _13785_ _13347_ _13786_ VDD
+ VSS OAI221_X2
X_23172_ _13338_ _13283_ _13651_ _13787_ VDD VSS AOI21_X1
X_23173_ net160 _13393_ _13604_ _13238_ _13788_ VDD VSS OAI22_X1
X_23174_ _13364_ _13787_ _13788_ _13789_ VDD VSS OAI21_X1
X_23175_ _13363_ _13786_ _13789_ _13790_ VDD VSS NAND3_X1
X_23176_ _15004_ _13335_ _13340_ _13791_ VDD VSS AOI21_X1
X_23177_ _13371_ _13466_ _13792_ VDD VSS OR2_X1
X_23178_ _13240_ _13218_ _13793_ VDD VSS NAND2_X1
X_23179_ _15000_ _13793_ _13347_ _13794_ VDD VSS MUX2_X1
X_23180_ _13345_ _13791_ _13792_ _13794_ _13364_ _13795_ VDD
+ VSS OAI221_X1
X_23181_ _13650_ _13790_ _13795_ _13796_ VDD VSS NAND3_X1
X_23182_ _13323_ _13274_ _13481_ _13237_ _13797_ VDD VSS AOI211_X2
X_23183_ _13797_ _13328_ _13355_ _13353_ _13601_ _13798_ VDD
+ VSS OAI221_X2
X_23184_ net159 _14986_ _13362_ _13381_ _13799_ VDD VSS NAND4_X1
X_23185_ _13317_ _13334_ _13275_ _13800_ VDD VSS AOI21_X1
X_23186_ _13799_ _13800_ _13489_ _13801_ VDD VSS OAI21_X1
X_23187_ _13371_ _13463_ _13348_ _13383_ net589 _13802_ VDD
+ VSS OAI221_X2
X_23188_ _15011_ _13558_ _13654_ _13547_ _13803_ VDD VSS OAI22_X2
X_23189_ _13798_ _13801_ _13802_ _13803_ _13421_ _13804_ VDD
+ VSS OAI221_X2
X_23190_ _13332_ _13277_ _13221_ _13805_ VDD VSS MUX2_X1
X_23191_ _15014_ _13805_ _13495_ _13806_ VDD VSS MUX2_X1
X_23192_ _13670_ _13654_ _13258_ _13807_ VDD VSS OAI21_X1
X_23193_ _13806_ _13807_ _13364_ _13808_ VDD VSS MUX2_X1
X_23194_ _13363_ _13404_ _13809_ VDD VSS NOR2_X1
X_23195_ _13345_ _13404_ _13810_ VDD VSS NOR2_X1
X_23196_ _13464_ _13257_ _13177_ _13811_ VDD VSS OAI21_X1
X_23197_ _13435_ _13811_ _13348_ _13812_ VDD VSS AOI21_X1
X_23198_ _13675_ _13762_ _13813_ VDD VSS NOR2_X1
X_23199_ _13812_ _13813_ _13235_ _13814_ VDD VSS MUX2_X1
X_23200_ _13562_ _13804_ _13808_ _13809_ _13814_ _13810_ _13815_
+ VDD VSS AOI222_X2
X_23201_ _13481_ _13278_ _14995_ _13816_ VDD VSS AOI21_X1
X_23202_ _13797_ _13816_ net623 _13328_ _13385_ _13817_ VDD
+ VSS OAI221_X2
X_23203_ _13324_ _13674_ _15011_ _13382_ _13277_ _13818_ VDD
+ VSS OAI221_X1
X_23204_ _13541_ _13817_ _13818_ _13819_ VDD VSS AOI21_X1
X_23205_ net623 _13283_ _13820_ VDD VSS NOR2_X1
X_23206_ net160 _13288_ _13399_ _13821_ VDD VSS AOI21_X1
X_23207_ _13345_ _13820_ _13821_ _13822_ VDD VSS OAI21_X1
X_23208_ _13339_ _13381_ _14986_ _13823_ VDD VSS AOI21_X1
X_23209_ _13278_ _13599_ _13824_ VDD VSS NOR2_X1
X_23210_ _13822_ _13823_ _13345_ net623 _13824_ _13825_ VDD
+ VSS OAI221_X1
X_23211_ _13364_ _13541_ _13826_ VDD VSS NOR2_X1
X_23212_ _13819_ _13825_ _13826_ _13827_ VDD VSS AOI21_X1
X_23213_ _13815_ _13796_ _13827_ _00087_ VDD VSS NAND3_X1
X_23214_ net780 _13828_ VDD VSS INV_X1
X_23215_ _13828_ _08994_ _13829_ VDD VSS NOR2_X1
X_23216_ net780 _08994_ _13830_ VDD VSS NOR2_X1
X_23217_ _11165_ _11137_ _13831_ VDD VSS XNOR2_X1
X_23218_ _11120_ _11183_ _13832_ VDD VSS XNOR2_X2
X_23219_ net900 _13832_ _13833_ VDD VSS XNOR2_X2
X_23220_ _13831_ _13833_ _13834_ VDD VSS XNOR2_X2
X_23221_ _13829_ _13830_ _13834_ _13835_ VDD VSS MUX2_X2
X_23222_ net780 _09179_ _00461_ _13836_ VDD VSS NAND3_X2
X_23223_ _13828_ _09728_ _13837_ VDD VSS NAND2_X1
X_23224_ _13836_ _13837_ _00461_ _13838_ VDD VSS OAI21_X4
X_23225_ _13838_ _13835_ _13839_ VDD VSS NOR2_X4
X_23226_ _13839_ _13840_ VDD VSS INV_X4
Xrebuffer425 _05867_ net1052 VDD VSS BUF_X2
X_23228_ _13840_ _15024_ VDD VSS BUF_X16
X_23229_ sa03_sr\[0\] sa32_sub\[0\] _13842_ VDD VSS XNOR2_X2
X_23230_ _11136_ net724 _13843_ VDD VSS XNOR2_X1
X_23231_ _11120_ _11183_ _13844_ VDD VSS XOR2_X2
X_23232_ net786 _09100_ _13844_ _13845_ VDD VSS NAND3_X4
X_23233_ net784 _08993_ _13846_ VDD VSS NOR2_X1
X_23234_ _13832_ _13846_ _13847_ VDD VSS NAND2_X1
X_23235_ _13843_ _13845_ _13847_ _13848_ VDD VSS AOI21_X4
X_23236_ _11136_ net724 _13849_ VDD VSS XOR2_X1
X_23237_ _13844_ _13846_ _13850_ VDD VSS NAND2_X1
X_23238_ net784 _09023_ _13832_ _13851_ VDD VSS NAND3_X1
X_23239_ _13849_ _13850_ _13851_ _13852_ VDD VSS AOI21_X1
X_23240_ net784 _13853_ VDD VSS INV_X1
X_23241_ _13853_ _09030_ _00462_ _13854_ VDD VSS NAND3_X1
X_23242_ net784 _09102_ _13855_ VDD VSS NAND2_X1
X_23243_ _13854_ _13855_ _00462_ _13856_ VDD VSS OAI21_X1
X_23244_ _13852_ _13848_ _13856_ _13857_ VDD VSS OR3_X4
X_23245_ _13857_ _13858_ VDD VSS INV_X4
X_23246_ _13858_ _13859_ VDD VSS BUF_X8
X_23247_ _13859_ _15027_ VDD VSS BUF_X8
X_23248_ net720 _11159_ _13860_ VDD VSS XOR2_X2
X_23249_ _11122_ _13860_ _13861_ VDD VSS XOR2_X1
X_23250_ _11164_ _11219_ _13862_ VDD VSS XOR2_X2
X_23251_ _06295_ _09012_ _13862_ _13863_ VDD VSS NAND3_X1
X_23252_ _11164_ _11219_ _13864_ VDD VSS XNOR2_X2
X_23253_ _06295_ _09015_ _13865_ VDD VSS NOR2_X1
X_23254_ _13864_ _13865_ _13866_ VDD VSS NAND2_X1
X_23255_ _13861_ _13863_ _13866_ _13867_ VDD VSS AOI21_X2
X_23256_ _11122_ _13860_ _13868_ VDD VSS XNOR2_X1
X_23257_ _13862_ _13865_ _13869_ VDD VSS NAND2_X1
X_23258_ _06295_ _09194_ _13864_ _13870_ VDD VSS NAND3_X1
X_23259_ _13868_ _13869_ _13870_ _13871_ VDD VSS AOI21_X2
X_23260_ _06308_ _09727_ _00463_ _13872_ VDD VSS NAND3_X1
X_23261_ _06295_ _09028_ _13873_ VDD VSS NAND2_X1
X_23262_ _13872_ _13873_ _00463_ _13874_ VDD VSS OAI21_X2
X_23263_ _13871_ _13867_ _13874_ _13875_ VDD VSS NOR3_X4
X_23264_ net896 _13876_ VDD VSS INV_X4
X_23265_ _13876_ _13877_ VDD VSS BUF_X4
X_23266_ _13877_ _13878_ VDD VSS BUF_X4
X_23267_ _13878_ _13879_ VDD VSS BUF_X4
X_23268_ _13879_ _15043_ VDD VSS BUF_X4
X_23269_ _13857_ _13880_ VDD VSS BUF_X16
X_23270_ _13880_ _15018_ VDD VSS BUF_X16
X_23271_ net896 _13881_ VDD VSS BUF_X4
X_23272_ _13881_ _13882_ VDD VSS BUF_X4
X_23273_ _13882_ _13883_ VDD VSS BUF_X4
X_23274_ _13883_ _15036_ VDD VSS BUF_X4
X_23275_ _06268_ _13884_ VDD VSS INV_X1
X_23276_ _11246_ _11202_ _13885_ VDD VSS XNOR2_X1
X_23277_ _13884_ net1085 _13885_ _13886_ VDD VSS NOR3_X1
X_23278_ _06268_ net1085 _13885_ _13887_ VDD VSS NOR3_X1
X_23279_ _13886_ _13887_ _11264_ _13888_ VDD VSS MUX2_X1
X_23280_ _11246_ _11202_ _13889_ VDD VSS XOR2_X2
X_23281_ _06268_ _08975_ _13889_ _13890_ VDD VSS NOR3_X1
X_23282_ _13884_ _08975_ _13889_ _13891_ VDD VSS NOR3_X1
X_23283_ _13890_ _13891_ _11264_ _13892_ VDD VSS MUX2_X1
X_23284_ _06268_ _08996_ text_in_r\[21\] _13893_ VDD VSS NAND3_X1
X_23285_ _13884_ _08996_ _13894_ VDD VSS NAND2_X1
X_23286_ _13893_ _13894_ text_in_r\[21\] _13895_ VDD VSS OAI21_X2
X_23287_ _13888_ _13892_ _13895_ _13896_ VDD VSS OR3_X2
X_23288_ _13896_ _13897_ VDD VSS BUF_X4
X_23289_ _13897_ _13898_ VDD VSS CLKBUF_X3
X_23290_ net815 _11200_ _13899_ VDD VSS XNOR2_X1
X_23291_ _11119_ _13899_ _13900_ VDD VSS XNOR2_X1
X_23292_ text_in_r\[23\] _13900_ _09803_ _13901_ VDD VSS MUX2_X2
X_23293_ _06586_ _13901_ _13902_ VDD VSS XOR2_X2
X_23294_ _11201_ _11199_ _13903_ VDD VSS XNOR2_X1
X_23295_ _11198_ _11187_ _13904_ VDD VSS XNOR2_X2
X_23296_ _11261_ _13904_ _13905_ VDD VSS XNOR2_X1
X_23297_ _13903_ _13905_ _13906_ VDD VSS XNOR2_X1
X_23298_ text_in_r\[22\] _13906_ _11207_ _13907_ VDD VSS MUX2_X2
X_23299_ _06574_ _13907_ _13908_ VDD VSS XNOR2_X1
X_23300_ _13908_ _13909_ VDD VSS CLKBUF_X3
X_23301_ _06285_ _13910_ VDD VSS INV_X1
X_23302_ _13910_ _09823_ _13911_ VDD VSS NOR2_X1
X_23303_ _06285_ _09823_ _13912_ VDD VSS NOR2_X1
X_23304_ _11250_ _11183_ _13913_ VDD VSS XNOR2_X1
X_23305_ _11220_ _13913_ _13914_ VDD VSS XNOR2_X1
X_23306_ _11246_ _11265_ _13915_ VDD VSS XOR2_X1
X_23307_ _11224_ _13915_ _13916_ VDD VSS XNOR2_X1
X_23308_ _13914_ _13916_ _13917_ VDD VSS XNOR2_X1
X_23309_ _13911_ _13912_ _13917_ _13918_ VDD VSS MUX2_X2
X_23310_ _13910_ _09135_ text_in_r\[20\] _13919_ VDD VSS NAND3_X2
X_23311_ _06285_ _09180_ _13920_ VDD VSS NAND2_X1
X_23312_ _13919_ _13920_ text_in_r\[20\] _13921_ VDD VSS OAI21_X4
X_23313_ _13918_ _13921_ _13922_ VDD VSS NOR2_X4
X_23314_ _13922_ _13923_ VDD VSS BUF_X4
X_23315_ _13923_ _13924_ VDD VSS CLKBUF_X3
X_23316_ _13909_ _13924_ _13925_ VDD VSS NOR2_X1
X_23317_ _15021_ _13926_ VDD VSS BUF_X4
X_23318_ _06229_ net1039 _13927_ VDD VSS NAND2_X1
X_23319_ _06229_ _13928_ VDD VSS INV_X1
X_23320_ _13928_ _09076_ _13929_ VDD VSS NAND2_X1
X_23321_ _11159_ _11225_ _13930_ VDD VSS XNOR2_X2
X_23322_ _13844_ _13930_ _13931_ VDD VSS XNOR2_X1
X_23323_ _11220_ _11245_ _13932_ VDD VSS XOR2_X1
X_23324_ _11158_ _13932_ _13933_ VDD VSS XNOR2_X1
X_23325_ _13931_ _13933_ _13934_ VDD VSS XNOR2_X2
X_23326_ _13927_ _13929_ _13934_ _13935_ VDD VSS MUX2_X2
X_23327_ text_in_r\[19\] _13936_ VDD VSS CLKBUF_X3
X_23328_ _06229_ _09728_ _13937_ VDD VSS NAND2_X1
X_23329_ _13936_ _13937_ _13938_ VDD VSS NOR2_X1
X_23330_ _06229_ net871 _13939_ VDD VSS NOR2_X2
X_23331_ _13938_ _13939_ _13936_ _13940_ VDD VSS AOI21_X4
X_23332_ _13926_ _13935_ _13940_ _13941_ VDD VSS AOI21_X4
X_23333_ _13928_ net1084 _13942_ VDD VSS NOR2_X1
X_23334_ _06229_ net1084 _13943_ VDD VSS NOR2_X1
X_23335_ _13942_ _13943_ _13934_ _13944_ VDD VSS MUX2_X2
X_23336_ _13944_ _13945_ VDD VSS BUF_X8
X_23337_ _13936_ _13939_ _13946_ VDD VSS NAND2_X1
X_23338_ _13946_ _13937_ _13936_ _13947_ VDD VSS OAI21_X4
X_23339_ _13947_ _13948_ VDD VSS BUF_X8
X_23340_ _13945_ _13948_ _13949_ VDD VSS NOR2_X4
X_23341_ _13949_ _13950_ VDD VSS BUF_X4
X_23342_ _13950_ _13951_ VDD VSS CLKBUF_X3
X_23343_ _15030_ _13952_ VDD VSS BUF_X4
X_23344_ _13952_ _13953_ VDD VSS INV_X2
X_23345_ _13941_ _13951_ _13953_ _13954_ VDD VSS AOI21_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
X_23347_ _15025_ _13956_ VDD VSS BUF_X4
X_23348_ _13935_ _13957_ VDD VSS BUF_X8
X_23349_ _13940_ _13958_ VDD VSS BUF_X8
X_23350_ _13876_ _13957_ _13958_ _13959_ VDD VSS NAND3_X1
X_23351_ _13959_ _13960_ VDD VSS CLKBUF_X3
X_23352_ _13925_ _13954_ _13879_ net905 _13960_ _13961_ VDD
+ VSS OAI221_X1
X_23353_ _13918_ _13921_ _13962_ VDD VSS OR2_X1
X_23354_ _13962_ _13963_ VDD VSS CLKBUF_X3
X_23355_ _13963_ _13964_ VDD VSS BUF_X4
X_23356_ _13877_ _13965_ VDD VSS BUF_X4
X_23357_ _13935_ _13940_ _13966_ VDD VSS NAND2_X4
X_23358_ _13966_ _13967_ VDD VSS BUF_X4
X_23359_ _13859_ _13838_ net895 _13968_ VDD VSS OAI21_X4
X_23360_ _13965_ _13967_ _13968_ _13969_ VDD VSS AOI21_X1
X_23361_ _13945_ _13970_ VDD VSS BUF_X4
X_23362_ _13948_ _13971_ VDD VSS BUF_X4
X_23363_ _13876_ _13970_ _13971_ _13972_ VDD VSS OAI21_X4
X_23364_ _13956_ _13967_ _13972_ _13859_ _13973_ VDD VSS OAI22_X2
X_23365_ _13964_ _13969_ _13973_ _13974_ VDD VSS NOR3_X1
X_23366_ _13940_ _13935_ _15022_ _13975_ VDD VSS NAND3_X2
X_23367_ _13858_ _13945_ _13948_ _13976_ VDD VSS OAI21_X4
X_23368_ _13975_ _13976_ _13977_ VDD VSS AND2_X4
X_23369_ net896 _13949_ _15025_ _13978_ VDD VSS AOI21_X1
Xclone131 _13838_ net895 net131 VDD VSS NOR2_X4
X_23371_ _15020_ _13980_ VDD VSS INV_X2
X_23372_ _13857_ _13957_ _13958_ _13981_ VDD VSS NAND3_X4
X_23373_ _13980_ _13949_ _13981_ net131 _13982_ VDD VSS OAI22_X2
X_23374_ _13963_ _13977_ _13978_ _13982_ _13882_ _13983_ VDD
+ VSS AOI221_X2
X_23375_ net898 _13945_ _13948_ _13984_ VDD VSS NOR3_X4
X_23376_ net1002 _13985_ VDD VSS BUF_X16
X_23377_ _15041_ _13967_ _13984_ _13985_ _13986_ VDD VSS AOI22_X1
X_23378_ _13908_ _13986_ _13924_ _13987_ VDD VSS OAI21_X1
X_23379_ _13909_ _13974_ _13983_ _13987_ _13988_ VDD VSS OAI22_X1
X_23380_ _13898_ _13902_ _13961_ _13988_ _13989_ VDD VSS AND4_X1
X_23381_ _13888_ _13892_ _13895_ _13990_ VDD VSS NOR3_X4
X_23382_ _13990_ _13991_ VDD VSS BUF_X4
X_23383_ _13991_ _13992_ VDD VSS BUF_X4
X_23384_ _13902_ _13993_ VDD VSS CLKBUF_X3
X_23385_ _06574_ _13907_ _13994_ VDD VSS XOR2_X2
X_23386_ _13926_ _13995_ VDD VSS INV_X8
X_23387_ _13995_ _13945_ _13948_ _13996_ VDD VSS NOR3_X4
X_23388_ _13839_ _13876_ _13997_ VDD VSS NAND2_X1
X_23389_ _13926_ net897 _13998_ VDD VSS NOR2_X2
X_23390_ net131 _13949_ _13999_ VDD VSS NAND2_X2
X_23391_ _13922_ _13997_ _13996_ _13998_ _13999_ _14000_ VDD
+ VSS AOI221_X2
X_23392_ _15028_ _14001_ VDD VSS BUF_X4
X_23393_ _14001_ _13984_ _14002_ VDD VSS NAND2_X1
X_23394_ net899 _13935_ _13940_ _14003_ VDD VSS AOI21_X4
X_23395_ _13876_ _13945_ _13948_ _14004_ VDD VSS NOR3_X4
X_23396_ _14003_ _14004_ _14005_ VDD VSS NOR2_X2
X_23397_ _13881_ _13970_ _13971_ _14006_ VDD VSS OAI21_X4
X_23398_ _14002_ _14005_ _13980_ _14006_ net1107 _14007_ VDD
+ VSS OAI221_X2
X_23399_ _13994_ _14000_ _14007_ _13924_ _14008_ VDD VSS AOI211_X2
X_23400_ _13992_ _13993_ _14008_ _14009_ VDD VSS NOR3_X1
X_23401_ _13994_ _14010_ VDD VSS CLKBUF_X3
X_23402_ _13963_ _14011_ VDD VSS BUF_X4
X_23403_ _14011_ _14012_ VDD VSS BUF_X4
X_23404_ net1139 _13965_ _14013_ VDD VSS NAND2_X1
X_23405_ _13840_ _14014_ VDD VSS CLKBUF_X3
X_23406_ _13967_ _14015_ VDD VSS CLKBUF_X3
X_23407_ _14014_ _14015_ _14016_ VDD VSS NOR2_X1
X_23408_ _15034_ _14017_ VDD VSS BUF_X8
X_23409_ _13949_ _14018_ VDD VSS BUF_X4
X_23410_ _14017_ _14014_ _14018_ _14019_ VDD VSS MUX2_X1
X_23411_ _13876_ _14020_ VDD VSS CLKBUF_X3
X_23412_ _14020_ _14021_ VDD VSS BUF_X4
X_23413_ _14021_ _14022_ VDD VSS BUF_X4
X_23414_ _14012_ _14013_ _14016_ _14019_ _14022_ _14023_ VDD
+ VSS OAI221_X2
X_23415_ _15022_ _14024_ VDD VSS BUF_X8
X_23416_ _13883_ _13951_ _14025_ VDD VSS NAND2_X1
X_23417_ _13857_ _13876_ _14026_ VDD VSS NOR2_X4
X_23418_ _13984_ _14026_ _14015_ _14027_ VDD VSS AOI21_X1
X_23419_ _13839_ _14028_ VDD VSS BUF_X4
X_23420_ _14028_ _14029_ VDD VSS BUF_X4
X_23421_ _14024_ _14025_ _14027_ _14029_ _15027_ _13972_ _14030_
+ VDD VSS OAI222_X2
X_23422_ _13964_ _14031_ VDD VSS CLKBUF_X3
X_23423_ _14023_ _14030_ _14031_ _14032_ VDD VSS OAI21_X1
X_23424_ _14010_ _14032_ _14033_ VDD VSS NAND2_X1
X_23425_ _13897_ _14034_ VDD VSS CLKBUF_X3
X_23426_ _14034_ _13902_ _14035_ VDD VSS NOR2_X1
X_23427_ _13966_ _14036_ VDD VSS BUF_X4
X_23428_ _14011_ _14006_ _13995_ net1139 _14036_ _14037_ VDD
+ VSS OAI221_X1
X_23429_ _14017_ _13957_ _13958_ _14038_ VDD VSS AOI21_X4
X_23430_ _14018_ _14039_ VDD VSS CLKBUF_X3
X_23431_ _14038_ _14039_ _14014_ _14040_ VDD VSS AOI21_X1
X_23432_ _14037_ _14040_ _14022_ _14041_ VDD VSS AOI21_X1
X_23433_ _14014_ _14018_ _14042_ VDD VSS NOR2_X2
X_23434_ _13859_ _13918_ _13921_ _14043_ VDD VSS NOR3_X2
X_23435_ _13878_ _14043_ _14044_ VDD VSS NAND2_X1
X_23436_ _13967_ _13922_ _14045_ VDD VSS NAND2_X1
X_23437_ _15025_ _14046_ VDD VSS INV_X2
X_23438_ _13881_ _14047_ VDD VSS CLKBUF_X3
X_23439_ _14046_ _14047_ _14048_ VDD VSS NAND2_X1
X_23440_ _13994_ _14042_ _14044_ _14045_ _14048_ _14049_ VDD
+ VSS OAI221_X1
X_23441_ _14035_ _14041_ _14049_ _14050_ VDD VSS OAI21_X1
X_23442_ _13923_ _14051_ VDD VSS BUF_X4
X_23443_ net581 _13984_ _14052_ VDD VSS NAND2_X1
X_23444_ _15022_ _13945_ _13948_ _14053_ VDD VSS NOR3_X4
X_23445_ _15025_ _13957_ _13958_ _14054_ VDD VSS AOI21_X4
X_23446_ _15036_ _14053_ _14054_ _14055_ VDD VSS OAI21_X1
X_23447_ _14051_ _14052_ _14055_ _14056_ VDD VSS AOI21_X1
X_23448_ net896 _13838_ _13835_ _14057_ VDD VSS OAI21_X2
X_23449_ _13966_ _13877_ _13985_ _14058_ VDD VSS AOI21_X2
X_23450_ _13859_ net896 _14059_ VDD VSS NAND2_X4
X_23451_ _14059_ _14047_ _14001_ _14060_ VDD VSS OAI21_X1
X_23452_ _13967_ _14061_ VDD VSS BUF_X4
X_23453_ _14011_ _14057_ _14058_ _14060_ _14061_ _14062_ VDD
+ VSS AOI221_X2
X_23454_ _14056_ _14062_ _14063_ VDD VSS NOR2_X1
X_23455_ _14010_ _14050_ _14063_ _14064_ VDD VSS NAND3_X1
X_23456_ _13990_ _14065_ VDD VSS BUF_X4
X_23457_ _14065_ _13902_ _14066_ VDD VSS NAND2_X1
X_23458_ _13859_ _13945_ _13948_ _14067_ VDD VSS NOR3_X2
X_23459_ net1106 _14067_ _14068_ VDD VSS NAND2_X2
X_23460_ _14024_ _14069_ VDD VSS INV_X2
X_23461_ _13877_ _13966_ _14069_ _14070_ VDD VSS AOI21_X4
X_23462_ _14001_ _14071_ VDD VSS INV_X1
X_23463_ _13923_ _14068_ _14070_ _13984_ _14071_ _14072_ VDD
+ VSS AOI221_X1
X_23464_ _13858_ _13935_ _13940_ _14073_ VDD VSS AOI21_X4
X_23465_ net1106 _14073_ _14074_ VDD VSS NAND2_X4
X_23466_ _14020_ _14053_ _14075_ VDD VSS NOR2_X1
X_23467_ _14011_ _14074_ _14075_ _14003_ _13952_ _14076_ VDD
+ VSS AOI221_X2
X_23468_ _14072_ _13994_ _14076_ _14077_ VDD VSS NOR3_X1
X_23469_ _13857_ _13944_ _13947_ _14078_ VDD VSS NOR3_X4
X_23470_ _13840_ _14078_ _14079_ VDD VSS NAND2_X1
X_23471_ net896 _13966_ _15020_ _14080_ VDD VSS AOI21_X1
X_23472_ _13926_ _13945_ _13948_ _14081_ VDD VSS NOR3_X4
X_23473_ _14081_ _13966_ _15028_ _14082_ VDD VSS AOI21_X1
X_23474_ _13963_ _14079_ _14080_ _14082_ _13881_ _14083_ VDD
+ VSS AOI221_X2
X_23475_ _14026_ net1139 net131 _14084_ VDD VSS AOI21_X1
X_23476_ _14036_ _14084_ _14085_ VDD VSS XNOR2_X1
X_23477_ _13994_ _14083_ _14085_ _13964_ _14086_ VDD VSS AOI211_X2
X_23478_ _14066_ _14077_ _14086_ _14050_ _14087_ VDD VSS OAI22_X2
X_23479_ _13989_ _14033_ _14009_ _14064_ _14087_ _00088_ VDD
+ VSS AOI221_X2
X_23480_ _14031_ _14088_ VDD VSS CLKBUF_X3
X_23481_ _14078_ _14089_ VDD VSS CLKBUF_X3
X_23482_ _13878_ _14089_ _14054_ _14090_ VDD VSS NOR3_X1
X_23483_ _13839_ _13950_ _14091_ VDD VSS XNOR2_X1
X_23484_ _14090_ _14091_ _15043_ _14092_ VDD VSS AOI21_X1
X_23485_ _14028_ _14018_ _14093_ VDD VSS NOR2_X2
X_23486_ net1139 _13882_ _14094_ VDD VSS NOR2_X1
X_23487_ _13859_ _13876_ _14095_ VDD VSS NOR2_X2
X_23488_ _14094_ _14095_ _14096_ VDD VSS NOR2_X1
X_23489_ _14093_ _14096_ _14097_ VDD VSS AND2_X1
X_23490_ _14061_ _14098_ VDD VSS CLKBUF_X3
X_23491_ _13880_ _13881_ _14099_ VDD VSS NAND2_X2
X_23492_ net579 _13877_ _14100_ VDD VSS NAND2_X1
X_23493_ _14098_ _14099_ _14100_ _14101_ VDD VSS AOI21_X1
X_23494_ _13898_ _14101_ _14102_ VDD VSS OR2_X1
X_23495_ _14088_ _13992_ _14092_ _14097_ _14102_ _14103_ VDD
+ VSS OAI221_X1
X_23496_ _06586_ _13901_ _14104_ VDD VSS XNOR2_X2
X_23497_ _13909_ _14104_ _14105_ VDD VSS NAND2_X1
X_23498_ _14071_ _13968_ _13881_ _14106_ VDD VSS MUX2_X1
X_23499_ _13964_ _14106_ _14039_ _14107_ VDD VSS AOI21_X2
X_23500_ _13951_ _14108_ VDD VSS CLKBUF_X3
X_23501_ _15044_ _14108_ _13991_ _14109_ VDD VSS OR3_X1
X_23502_ _14105_ _14107_ _14109_ _14110_ VDD VSS AOI21_X1
X_23503_ _13995_ _13957_ _13958_ _14111_ VDD VSS AOI21_X4
X_23504_ _13878_ _14089_ _14111_ _14112_ VDD VSS OAI21_X2
X_23505_ _13876_ _13957_ _13958_ _14113_ VDD VSS AOI21_X4
X_23506_ _13980_ _14113_ _14114_ VDD VSS NAND2_X1
X_23507_ _13991_ _14112_ _14114_ _14115_ VDD VSS AND3_X2
X_23508_ _14003_ _13968_ _14116_ VDD VSS AND2_X1
X_23509_ _15034_ _14117_ VDD VSS INV_X2
X_23510_ net1175 _13883_ _14117_ _14118_ VDD VSS AOI21_X2
X_23511_ _13965_ _14119_ VDD VSS BUF_X4
X_23512_ _13995_ _13970_ _13971_ _14120_ VDD VSS OAI21_X4
X_23513_ _14017_ _13957_ _13958_ _14121_ VDD VSS NAND3_X2
X_23514_ _14119_ _14120_ _14121_ _14122_ VDD VSS AOI21_X4
X_23515_ _14122_ _13992_ _14118_ _14116_ _14123_ VDD VSS NOR4_X4
X_23516_ _14004_ _13992_ net1099 _14124_ VDD VSS OAI21_X1
X_23517_ _14088_ _14115_ _14123_ _14124_ _14069_ _14125_ VDD
+ VSS OAI221_X2
X_23518_ _13994_ _14104_ _14126_ VDD VSS NAND2_X1
X_23519_ net578 _13970_ _13971_ _14127_ VDD VSS NOR3_X2
X_23520_ _13879_ _14093_ _14127_ _14128_ VDD VSS OAI21_X1
X_23521_ _13918_ _13921_ _13896_ _14129_ VDD VSS OR3_X4
X_23522_ _14090_ _14129_ _14130_ VDD VSS NOR2_X1
X_23523_ _13941_ _14089_ _14014_ _14131_ VDD VSS AOI21_X1
X_23524_ _15027_ _13960_ _14131_ _14022_ _14132_ VDD VSS OAI22_X1
X_23525_ _14011_ _13990_ _14133_ VDD VSS NOR2_X2
X_23526_ _14126_ _14128_ _14130_ _14132_ _14133_ _14134_ VDD
+ VSS AOI221_X1
X_23527_ _14103_ _14110_ _14125_ _14134_ _14135_ VDD VSS AOI22_X2
X_23528_ _14031_ _14034_ _14136_ VDD VSS NAND2_X1
X_23529_ _14046_ _13957_ _13958_ _14137_ VDD VSS AOI21_X2
X_23530_ _15036_ _14089_ _14137_ _14138_ VDD VSS NOR3_X1
X_23531_ _14022_ _13941_ _14127_ _14139_ VDD VSS NOR3_X1
X_23532_ _14136_ _14138_ _14139_ _14140_ VDD VSS NOR3_X1
X_23533_ _13993_ _14140_ _13909_ _14141_ VDD VSS OAI21_X1
X_23534_ _14028_ _13880_ _14142_ VDD VSS NOR2_X2
X_23535_ _13967_ _13922_ _14143_ VDD VSS NOR2_X2
X_23536_ _14061_ _13923_ net1099 _14144_ VDD VSS OAI21_X1
X_23537_ _14066_ _14142_ _14143_ _14144_ _13879_ _14145_ VDD
+ VSS AOI221_X1
X_23538_ net1112 _15024_ _14012_ _14146_ VDD VSS MUX2_X1
X_23539_ _13956_ _13877_ _14147_ VDD VSS NOR2_X1
X_23540_ _15043_ _14142_ _14120_ _14147_ _14148_ VDD VSS AOI22_X1
X_23541_ _14145_ _14146_ _14006_ _14088_ _14148_ _14149_ VDD
+ VSS OAI221_X1
X_23542_ _15018_ _14003_ _14004_ _14150_ VDD VSS OAI21_X1
X_23543_ _13880_ _13957_ _13958_ _14151_ VDD VSS AOI21_X4
X_23544_ _13839_ _14152_ VDD VSS BUF_X8
X_23545_ _14152_ _15019_ VDD VSS BUF_X16
X_23546_ net1107 _13984_ _14151_ net1101 _14153_ VDD VSS AOI22_X1
X_23547_ _13993_ _14133_ _14150_ _14153_ _14154_ VDD VSS NAND4_X1
X_23548_ _14149_ _14141_ _14154_ _14155_ VDD VSS AND3_X2
X_23549_ _13985_ _13970_ _13971_ _14156_ VDD VSS OAI21_X4
X_23550_ _14156_ _14036_ _14046_ _14157_ VDD VSS OAI21_X4
X_23551_ _13879_ _13924_ _14158_ VDD VSS NOR2_X1
X_23552_ _13898_ _14157_ _14158_ _14159_ VDD VSS AOI21_X1
X_23553_ _15027_ _14021_ _14160_ VDD VSS NAND2_X1
X_23554_ _15019_ _14089_ _14003_ _14161_ VDD VSS OAI21_X1
X_23555_ _14160_ _14161_ _14162_ VDD VSS AND2_X1
X_23556_ _13981_ _14051_ net1101 _14163_ VDD VSS AOI21_X1
X_23557_ _14151_ _14163_ _14164_ VDD VSS NOR2_X1
X_23558_ _14159_ _14162_ _14088_ _15036_ _14164_ _14165_ VDD
+ VSS OAI221_X1
X_23559_ _13896_ _14166_ VDD VSS BUF_X4
X_23560_ _13923_ _14166_ _14167_ VDD VSS NAND2_X1
X_23561_ _14119_ _14038_ _14168_ VDD VSS NOR2_X1
X_23562_ _14167_ _14119_ _14157_ _14168_ _14068_ _14169_ VDD
+ VSS AOI221_X2
X_23563_ net905 _13960_ _14005_ net1101 _14170_ VDD VSS OAI22_X1
X_23564_ _13924_ _14065_ _14171_ VDD VSS NOR2_X1
X_23565_ _14169_ _14170_ _14171_ _14172_ VDD VSS AOI21_X2
X_23566_ _14010_ _14172_ _14165_ _14173_ VDD VSS AOI21_X2
X_23567_ _14135_ _14173_ _14155_ _00089_ VDD VSS OAI21_X2
X_23568_ _13924_ _14174_ VDD VSS CLKBUF_X3
X_23569_ _13883_ _14039_ _14065_ _13968_ _14175_ VDD VSS NAND4_X1
X_23570_ _14024_ net907 _14176_ VDD VSS NOR2_X4
X_23571_ _14006_ _14176_ _14177_ VDD VSS OR2_X1
X_23572_ _14175_ _14177_ _13897_ _00629_ VDD VSS OAI21_X1
X_23573_ _14036_ _00630_ VDD VSS CLKBUF_X3
X_23574_ _13882_ _14166_ _00631_ VDD VSS NOR2_X2
X_23575_ _00630_ _00631_ _00632_ VDD VSS NAND2_X1
X_23576_ _13951_ _00631_ _00633_ VDD VSS NAND2_X1
X_23577_ _14142_ _00632_ _00633_ _14001_ _00634_ VDD VSS OAI22_X1
X_23578_ _14166_ _14015_ _15048_ _00635_ VDD VSS OAI21_X1
X_23579_ _00635_ _14160_ _14093_ _00636_ VDD VSS AOI21_X1
X_23580_ _14174_ _00629_ _00634_ _00636_ _00637_ VDD VSS NOR4_X2
X_23581_ net905 _14003_ _00638_ VDD VSS NAND2_X1
X_23582_ _13883_ _14111_ _14127_ _00639_ VDD VSS OAI21_X1
X_23583_ _14034_ _00638_ _00639_ _00640_ VDD VSS AOI21_X1
X_23584_ _15039_ _14015_ _00641_ VDD VSS AND2_X1
X_23585_ _14029_ _14061_ _14013_ _00642_ VDD VSS NOR3_X1
X_23586_ _13991_ _00641_ _00642_ _00643_ VDD VSS NOR3_X1
X_23587_ _14088_ _00640_ _00643_ _00644_ VDD VSS NOR3_X1
X_23588_ _13998_ _14095_ _14014_ _00645_ VDD VSS AOI21_X1
X_23589_ _15041_ _00645_ _00630_ _00646_ VDD VSS MUX2_X1
X_23590_ _13994_ _14129_ _00646_ _00647_ VDD VSS OAI21_X1
X_23591_ _14028_ _13878_ _00648_ VDD VSS NOR2_X1
X_23592_ _15024_ _15027_ _00649_ VDD VSS NOR2_X1
X_23593_ _14108_ _00648_ _00649_ _00650_ VDD VSS NOR3_X1
X_23594_ _14133_ _14098_ _15044_ _00651_ VDD VSS OAI21_X1
X_23595_ _00650_ _00651_ _00652_ VDD VSS NOR2_X1
X_23596_ _15028_ _13970_ _13971_ _00653_ VDD VSS OAI21_X1
X_23597_ _00653_ _14015_ _14014_ _00654_ VDD VSS OAI21_X1
X_23598_ _13980_ _13945_ _13948_ _00655_ VDD VSS NOR3_X2
X_23599_ _14047_ _00655_ _00656_ VDD VSS OR2_X1
X_23600_ _14171_ _00654_ _13879_ _00656_ _13941_ _00657_ VDD
+ VSS OAI221_X2
X_23601_ _14020_ _13950_ _13840_ _00658_ VDD VSS MUX2_X1
X_23602_ _14042_ _14059_ _13976_ _00648_ _00658_ net1107 _00659_
+ VDD VSS AOI222_X2
X_23603_ _14012_ _13991_ _00660_ VDD VSS NAND2_X1
X_23604_ _00657_ _00659_ _00660_ _00661_ VDD VSS OAI21_X1
X_23605_ _14010_ _00637_ _00644_ _00647_ _00652_ _00661_ _00662_
+ VDD VSS OAI33_X1
X_23606_ _14028_ _13881_ _14078_ _14073_ _00663_ VDD VSS OR4_X1
X_23607_ _14011_ _14113_ _14117_ _00664_ VDD VSS AOI21_X1
X_23608_ _14047_ net1097 _14151_ _00665_ VDD VSS OAI21_X4
X_23609_ _13878_ _14018_ _14024_ _00666_ VDD VSS OAI21_X1
X_23610_ net902 _14036_ _00667_ VDD VSS NOR2_X1
X_23611_ _00665_ _00666_ _00667_ _00668_ VDD VSS OAI21_X4
X_23612_ _13897_ _00663_ _00664_ _00668_ _14012_ _00669_ VDD
+ VSS AOI221_X2
X_23613_ _13956_ _13882_ _14099_ _14028_ _00670_ VDD VSS OAI22_X2
X_23614_ _14011_ _14058_ _14057_ _00670_ _14015_ _00671_ VDD
+ VSS AOI221_X2
X_23615_ _14017_ _15025_ _13881_ _00672_ VDD VSS MUX2_X1
X_23616_ _13964_ _00672_ _14061_ _00673_ VDD VSS OAI21_X1
X_23617_ _00673_ _14160_ _14093_ _00674_ VDD VSS AOI21_X1
X_23618_ _13992_ _00671_ _00674_ _00675_ VDD VSS NOR3_X1
X_23619_ _14117_ _13970_ _13971_ _00676_ VDD VSS NOR3_X4
X_23620_ _14137_ _00676_ _00677_ VDD VSS NOR2_X2
X_23621_ _14011_ _14059_ _13950_ _00677_ _13882_ _00678_ VDD
+ VSS OAI221_X2
X_23622_ _13956_ _13965_ _00679_ VDD VSS NAND2_X1
X_23623_ _13840_ _13881_ _13967_ _00680_ VDD VSS NAND3_X1
X_23624_ _13923_ _00679_ _00680_ _00681_ VDD VSS NAND3_X1
X_23625_ _14065_ _00678_ _00681_ _14004_ _13952_ _00682_ VDD
+ VSS AOI221_X2
X_23626_ _13877_ _13941_ _00683_ VDD VSS NOR2_X4
X_23627_ _14120_ _14015_ _13953_ _00684_ VDD VSS OAI21_X1
X_23628_ _14129_ _00683_ _13981_ _00684_ _14119_ _00685_ VDD
+ VSS AOI221_X2
X_23629_ _14089_ _14061_ _13952_ _00686_ VDD VSS AOI21_X1
X_23630_ _13883_ _00676_ _00687_ VDD VSS NOR2_X1
X_23631_ _14152_ _14061_ _00688_ VDD VSS NAND2_X1
X_23632_ _13883_ _00686_ _00687_ _00688_ _00689_ VDD VSS AOI22_X1
X_23633_ _13994_ _00660_ _00689_ _00690_ VDD VSS OAI21_X1
X_23634_ _00675_ _00669_ _14010_ _00682_ _00685_ _00690_ _00691_
+ VDD VSS OAI33_X1
X_23635_ _00662_ _00691_ _14104_ _00090_ VDD VSS MUX2_X1
X_23636_ _14010_ _13898_ _00692_ VDD VSS NOR2_X1
X_23637_ _14001_ _14039_ _00693_ VDD VSS NAND2_X1
X_23638_ _13879_ _00630_ net580 _00694_ VDD VSS AOI21_X1
X_23639_ _00693_ _00694_ _00695_ VDD VSS NAND2_X1
X_23640_ _15043_ _14089_ _13941_ _00696_ VDD VSS OAI21_X1
X_23641_ _14088_ _13993_ _00695_ _00696_ _00697_ VDD VSS NAND4_X1
X_23642_ _15043_ _14038_ net1001 _00698_ VDD VSS NOR3_X1
X_23643_ _14054_ _14108_ net1101 _00699_ VDD VSS AOI21_X1
X_23644_ _00698_ _00699_ _15043_ _00700_ VDD VSS AOI21_X1
X_23645_ _14174_ _13993_ _00700_ _00701_ VDD VSS NAND3_X1
X_23646_ _13883_ _13964_ _00702_ VDD VSS NAND2_X1
X_23647_ _14081_ _14098_ _14024_ _00703_ VDD VSS AOI21_X1
X_23648_ _14108_ _14026_ _14005_ _13952_ _00704_ VDD VSS AOI22_X1
X_23649_ _14104_ _00702_ _00703_ _00704_ _14088_ _00705_ VDD
+ VSS OAI221_X1
X_23650_ _00692_ _00697_ _00701_ _00705_ _00706_ VDD VSS NAND4_X1
X_23651_ _13909_ _13898_ _00707_ VDD VSS NAND2_X1
X_23652_ _14104_ _14158_ _15027_ _00708_ VDD VSS AOI21_X1
X_23653_ net1101 _15036_ _14043_ _00709_ VDD VSS NOR3_X1
X_23654_ _15024_ _14012_ _14026_ _00710_ VDD VSS NOR3_X1
X_23655_ _14098_ _00709_ _00710_ _00711_ VDD VSS NOR3_X1
X_23656_ _14029_ _13883_ _13964_ _00712_ VDD VSS NOR3_X1
X_23657_ net1112 _13879_ _13924_ _00713_ VDD VSS AOI21_X1
X_23658_ _14108_ _14158_ _00712_ _00713_ _00714_ VDD VSS NOR4_X1
X_23659_ _00708_ _00711_ _00714_ _00715_ VDD VSS OAI21_X1
X_23660_ net1106 _14018_ _00716_ VDD VSS NAND2_X1
X_23661_ _14111_ _13951_ _14001_ _00717_ VDD VSS AOI21_X1
X_23662_ _13924_ _00716_ _14070_ _00717_ _14119_ _00718_ VDD
+ VSS AOI221_X2
X_23663_ _14047_ _14038_ _14067_ _00719_ VDD VSS NOR3_X2
X_23664_ _14081_ _14176_ _14098_ _00720_ VDD VSS AOI21_X1
X_23665_ _00719_ _00720_ _15036_ _00721_ VDD VSS AOI21_X1
X_23666_ _00718_ _00721_ _14174_ _00722_ VDD VSS AOI21_X1
X_23667_ _00715_ _00722_ _13993_ _00723_ VDD VSS OAI21_X1
X_23668_ _13953_ _14176_ _14047_ _00724_ VDD VSS MUX2_X1
X_23669_ _14107_ _00724_ _14108_ _00725_ VDD VSS OAI21_X1
X_23670_ _14026_ _14119_ net1099 _00726_ VDD VSS AOI21_X1
X_23671_ _13991_ _14143_ _00726_ _00727_ VDD VSS AOI21_X1
X_23672_ _13965_ _14018_ _14028_ _00728_ VDD VSS AOI21_X1
X_23673_ _14114_ _00728_ _15018_ _13960_ _14029_ _00729_ VDD
+ VSS OAI221_X1
X_23674_ _15030_ _13957_ _13958_ _00730_ VDD VSS AOI21_X4
X_23675_ _14081_ _00730_ _00731_ VDD VSS NOR2_X2
X_23676_ _14017_ _13970_ _13971_ _00732_ VDD VSS NOR3_X4
X_23677_ _14151_ _00732_ _00733_ VDD VSS NOR2_X1
X_23678_ _00731_ _00733_ _13878_ _00734_ VDD VSS MUX2_X1
X_23679_ _00729_ _00734_ _14012_ _00735_ VDD VSS MUX2_X1
X_23680_ _13993_ _00725_ _00727_ _00735_ _13992_ _00736_ VDD
+ VSS AOI221_X2
X_23681_ _14129_ _14113_ _14001_ net1112 _13984_ _00737_ VDD
+ VSS AOI221_X1
X_23682_ _14108_ _14026_ _14003_ _15018_ _00738_ VDD VSS AOI22_X1
X_23683_ _00737_ _00738_ net1101 _00739_ VDD VSS OAI21_X1
X_23684_ _14028_ _14073_ _00740_ VDD VSS NAND2_X2
X_23685_ _14002_ _00665_ _00740_ _00741_ VDD VSS NAND3_X1
X_23686_ _00739_ _00741_ _00660_ _00742_ VDD VSS OAI21_X1
X_23687_ _14020_ net1097 _14036_ _14028_ _00743_ VDD VSS AOI211_X2
X_23688_ _14038_ _14039_ _13953_ _00744_ VDD VSS AOI21_X1
X_23689_ _00743_ _00744_ _15043_ _00745_ VDD VSS AOI21_X1
X_23690_ _14113_ _00649_ _14094_ _00746_ VDD VSS NOR3_X1
X_23691_ _13993_ _00745_ _14136_ _00746_ _14167_ _00747_ VDD
+ VSS OAI221_X1
X_23692_ _14010_ _00747_ _00742_ _00748_ VDD VSS OAI21_X1
X_23693_ _00706_ _00707_ _00723_ _00748_ _00736_ _00091_ VDD
+ VSS OAI221_X1
X_23694_ _13994_ _13902_ _00749_ VDD VSS NAND2_X2
X_23695_ _13883_ _00630_ _13952_ _00750_ VDD VSS AOI21_X1
X_23696_ _14031_ _14053_ _00750_ _00751_ VDD VSS OAI21_X1
X_23697_ _14051_ _14093_ _00656_ _14022_ _15018_ _00752_ VDD
+ VSS OAI221_X1
X_23698_ _13992_ _00751_ _00752_ _00753_ VDD VSS AND3_X1
X_23699_ _13859_ _13965_ _13922_ _00754_ VDD VSS AOI21_X1
X_23700_ _13951_ _00754_ net902 _15018_ _14021_ _00755_ VDD
+ VSS OAI221_X2
X_23701_ _14057_ _14100_ _13963_ _00756_ VDD VSS MUX2_X1
X_23702_ _00630_ _00756_ _00757_ VDD VSS NAND2_X1
X_23703_ _00702_ _14045_ _15027_ _00758_ VDD VSS OAI21_X1
X_23704_ _13991_ _00755_ _00757_ _00758_ net1101 _00759_ VDD
+ VSS AOI221_X2
X_23705_ _00749_ _00753_ _00759_ _00760_ VDD VSS NOR3_X2
X_23706_ _15025_ _13970_ _13971_ _00761_ VDD VSS NOR3_X1
X_23707_ _13965_ _00761_ _00762_ VDD VSS NOR2_X1
X_23708_ _00762_ _13976_ _14152_ _00763_ VDD VSS OAI21_X1
X_23709_ net1097 _14073_ _13882_ _00764_ VDD VSS NOR3_X4
X_23710_ _00764_ _14166_ _00765_ VDD VSS NOR2_X2
X_23711_ net1099 _13960_ _14067_ _14119_ _00766_ VDD VSS OAI22_X1
X_23712_ _14012_ _00765_ _00763_ _00766_ _14034_ _00767_ VDD
+ VSS AOI221_X2
X_23713_ _14020_ _14054_ _00655_ _00768_ VDD VSS NOR3_X1
X_23714_ _00768_ _14091_ _14021_ _00769_ VDD VSS AOI21_X1
X_23715_ _14024_ _14061_ _13976_ net902 _00770_ VDD VSS OAI22_X1
X_23716_ _14051_ _13897_ _00769_ _00770_ _00631_ _00771_ VDD
+ VSS AOI221_X2
X_23717_ _00767_ _14126_ _00771_ _00772_ VDD VSS NOR3_X2
X_23718_ _13909_ _13902_ _00773_ VDD VSS NAND2_X1
X_23719_ _14021_ _00732_ _00774_ VDD VSS NOR2_X1
X_23720_ _14129_ _00731_ _14021_ _00774_ _14074_ _00775_ VDD
+ VSS AOI221_X2
X_23721_ net905 _14014_ _14015_ _00776_ VDD VSS MUX2_X1
X_23722_ _14068_ _00694_ _00776_ _14022_ _00777_ VDD VSS AOI22_X1
X_23723_ _00775_ _00777_ _14133_ _00778_ VDD VSS AOI21_X1
X_23724_ _00732_ _14036_ net902 _00779_ VDD VSS AOI21_X2
X_23725_ _14074_ _00762_ _00779_ _14022_ _00780_ VDD VSS AOI22_X2
X_23726_ _13991_ _15043_ _13952_ _00781_ VDD VSS OAI21_X1
X_23727_ _15036_ _14157_ _00782_ VDD VSS NOR2_X1
X_23728_ _14088_ _13992_ _00780_ _00781_ _00782_ _00783_ VDD
+ VSS OAI221_X1
X_23729_ _00773_ _00778_ _00783_ _00784_ VDD VSS AOI21_X1
X_23730_ _14061_ _14166_ _00785_ VDD VSS NOR2_X1
X_23731_ _13879_ _00730_ _00785_ _00786_ VDD VSS OAI21_X1
X_23732_ _13859_ _14113_ _13896_ _00787_ VDD VSS NAND3_X1
X_23733_ _14011_ _14068_ _00787_ _00788_ VDD VSS NAND3_X1
X_23734_ _13960_ _14166_ _14006_ _00789_ VDD VSS OAI21_X1
X_23735_ _00788_ _00789_ _14029_ _00790_ VDD VSS AOI21_X1
X_23736_ _00740_ _13977_ _13965_ net579 _13960_ _00791_ VDD
+ VSS OAI221_X2
X_23737_ _13967_ _13882_ _13995_ _00792_ VDD VSS OAI21_X1
X_23738_ _00792_ _14015_ _15032_ _00793_ VDD VSS OAI21_X1
X_23739_ _00791_ _00793_ _14065_ _00794_ VDD VSS MUX2_X1
X_23740_ _14105_ _00786_ _00790_ _00794_ _14051_ _00795_ VDD
+ VSS AOI221_X2
X_23741_ _00784_ _00772_ _00760_ _00795_ _00092_ VDD VSS NOR4_X2
X_23742_ _13897_ _13969_ _13973_ _14059_ _00630_ _00796_ VDD
+ VSS OAI221_X1
X_23743_ _14065_ _13981_ _14029_ _14004_ _15018_ _00797_ VDD
+ VSS OAI221_X1
X_23744_ _14051_ _00796_ _00797_ _00798_ VDD VSS AND3_X1
X_23745_ _14121_ _13950_ _14001_ _00799_ VDD VSS OAI21_X1
X_23746_ _13968_ _14004_ _14022_ _00799_ _00800_ VDD VSS AOI22_X1
X_23747_ _14047_ _13951_ _13953_ _00801_ VDD VSS AOI21_X1
X_23748_ _13999_ _00683_ _00801_ _14074_ _00802_ VDD VSS AOI22_X1
X_23749_ _14136_ _00800_ _00802_ _00660_ _00803_ VDD VSS OAI22_X1
X_23750_ _14126_ _00798_ _00803_ _00804_ VDD VSS OR3_X2
X_23751_ _14031_ _13972_ _14071_ _14099_ _14098_ _00805_ VDD
+ VSS OAI221_X1
X_23752_ _14051_ _13984_ _15024_ _00806_ VDD VSS OAI21_X1
X_23753_ _13898_ _00805_ _00806_ _00807_ VDD VSS AOI21_X1
X_23754_ _15027_ _14143_ _15024_ _00808_ VDD VSS OAI21_X1
X_23755_ _15024_ _00630_ _14012_ _00809_ VDD VSS OAI21_X1
X_23756_ _00809_ _14113_ _14031_ _00810_ VDD VSS AOI21_X1
X_23757_ _00807_ _00808_ _00810_ _00811_ VDD VSS OAI21_X1
X_23758_ _14156_ net1175 _00812_ VDD VSS AND2_X4
X_23759_ _14031_ _14025_ _15024_ _00812_ _15036_ _00813_ VDD
+ VSS OAI221_X2
X_23760_ _00676_ _14098_ _13980_ _00814_ VDD VSS AOI21_X1
X_23761_ _14174_ _14006_ net1107 _00814_ _15036_ _00815_ VDD
+ VSS OAI221_X1
X_23762_ _13898_ _00813_ _00815_ _00816_ VDD VSS NAND3_X1
X_23763_ _00816_ _13993_ _00811_ _13909_ _00817_ VDD VSS NAND4_X2
X_23764_ net905 _13950_ _14074_ _14020_ _00818_ VDD VSS AOI22_X1
X_23765_ _15030_ _13876_ _00819_ VDD VSS NAND2_X1
X_23766_ _13967_ _00819_ _00820_ VDD VSS NOR2_X1
X_23767_ _14166_ _14137_ _00820_ _00821_ VDD VSS NOR3_X1
X_23768_ _14068_ _14070_ _00822_ VDD VSS NAND2_X1
X_23769_ _13924_ _14166_ _00818_ _00821_ _00822_ _00823_ VDD
+ VSS AOI221_X2
X_23770_ _14133_ _00731_ _13879_ _13972_ _15018_ _00824_ VDD
+ VSS OAI221_X1
X_23771_ _14015_ _00672_ _00825_ VDD VSS AND2_X4
X_23772_ _14024_ net902 _13878_ _00826_ VDD VSS MUX2_X1
X_23773_ _00825_ _00826_ _14108_ _00827_ VDD VSS AOI21_X4
X_23774_ _00824_ _14129_ _00827_ _00828_ VDD VSS OAI21_X4
X_23775_ _00828_ _00823_ _00749_ _00829_ VDD VSS OR3_X4
X_23776_ _13985_ _13950_ _00830_ VDD VSS NAND2_X4
X_23777_ _13990_ _00683_ _00830_ _00799_ _13878_ _00831_ VDD
+ VSS AOI221_X2
X_23778_ _14117_ _13965_ _00832_ VDD VSS NAND2_X1
X_23779_ _14166_ _13984_ _13956_ _00832_ _14036_ _00833_ VDD
+ VSS AOI221_X1
X_23780_ _14174_ _00831_ _00833_ _00834_ VDD VSS OR3_X2
X_23781_ _13897_ _14176_ _14113_ _14096_ _00667_ _00835_ VDD
+ VSS AOI221_X1
X_23782_ _14065_ _14142_ _14004_ _00630_ _14001_ _00836_ VDD
+ VSS AOI221_X1
X_23783_ _14174_ _00835_ _00836_ _00837_ VDD VSS OAI21_X1
X_23784_ _00834_ _14104_ _13909_ _00837_ _00838_ VDD VSS NAND4_X4
X_23785_ _00838_ _00817_ _00804_ _00829_ _00093_ VDD VSS AND4_X4
X_23786_ _13953_ _14036_ _00839_ VDD VSS NAND2_X1
X_23787_ _13877_ _00655_ _00840_ VDD VSS NOR2_X2
X_23788_ _13897_ _00839_ _00840_ _14003_ _14024_ _00841_ VDD
+ VSS AOI221_X2
X_23789_ _14022_ _14089_ _00730_ _00842_ VDD VSS NOR3_X1
X_23790_ net1001 _14176_ _14098_ _00843_ VDD VSS AOI21_X1
X_23791_ _00842_ _00843_ _15043_ _00844_ VDD VSS AOI21_X1
X_23792_ _00841_ _00844_ _13898_ _00845_ VDD VSS AOI21_X1
X_23793_ _00845_ _14174_ _13909_ _00846_ VDD VSS NOR3_X1
X_23794_ _14021_ _14061_ _14024_ _00847_ VDD VSS AOI21_X1
X_23795_ _13952_ _00630_ _13976_ _14029_ _00848_ VDD VSS OAI22_X1
X_23796_ _13991_ _14121_ _00847_ _00848_ _14022_ _00849_ VDD
+ VSS AOI221_X2
X_23797_ _13968_ _13971_ _13970_ net1106 _14020_ _00850_ VDD
+ VSS OAI221_X2
X_23798_ _15037_ _15046_ _00630_ _00851_ VDD VSS OR3_X1
X_23799_ _13992_ _00850_ _00851_ _00852_ VDD VSS NAND3_X1
X_23800_ _14010_ _14174_ _00852_ _00853_ VDD VSS NAND3_X1
X_23801_ _13993_ _00849_ _00853_ _00854_ VDD VSS OAI21_X1
X_23802_ _15039_ _13951_ _00855_ VDD VSS OR2_X1
X_23803_ _14039_ _14013_ _14152_ _14119_ net1107 _00856_ VDD
+ VSS OAI221_X1
X_23804_ _13991_ _00855_ _00856_ _00857_ VDD VSS NAND3_X1
X_23805_ _14029_ _14026_ _00858_ VDD VSS NOR2_X1
X_23806_ _14034_ _13960_ _14001_ _00858_ _14108_ _00859_ VDD
+ VSS OAI221_X1
X_23807_ _14031_ _00857_ _00859_ _00860_ VDD VSS AND3_X1
X_23808_ _14020_ _13950_ _14176_ _00861_ VDD VSS AOI21_X4
X_23809_ net1097 _14151_ _00862_ VDD VSS NOR2_X2
X_23810_ _14065_ _00861_ _14074_ _00862_ _14021_ _00863_ VDD
+ VSS AOI221_X2
X_23811_ _13882_ _13950_ _14069_ _14073_ _13840_ _00864_ VDD
+ VSS AOI221_X2
X_23812_ _00743_ _14034_ _00864_ _00865_ VDD VSS NOR3_X2
X_23813_ _00863_ _00865_ _14088_ _00866_ VDD VSS NOR3_X2
X_23814_ _14010_ _00860_ _00866_ _00867_ VDD VSS NOR3_X1
X_23815_ _13994_ _14166_ _00868_ VDD VSS NAND2_X1
X_23816_ _14028_ _14073_ _13922_ _00869_ VDD VSS MUX2_X1
X_23817_ _00868_ _00869_ _14119_ _14012_ _14089_ _00870_ VDD
+ VSS AOI221_X2
X_23818_ _14108_ _14051_ _13953_ _00871_ VDD VSS AOI21_X1
X_23819_ _00871_ net1001 _14174_ _00872_ VDD VSS AOI21_X1
X_23820_ _00870_ _00872_ _15043_ _00873_ VDD VSS OAI21_X1
X_23821_ _14104_ _00873_ _00874_ VDD VSS NAND2_X1
X_23822_ _00719_ _14113_ net1112 _00875_ VDD VSS AOI21_X1
X_23823_ _15036_ _00693_ _00839_ _00876_ VDD VSS AOI21_X1
X_23824_ _14034_ _14006_ _15024_ _00877_ VDD VSS OAI21_X1
X_23825_ _14088_ _13898_ _00875_ _00876_ _00877_ _00878_ VDD
+ VSS OAI221_X1
X_23826_ _15038_ _14098_ _00879_ VDD VSS NAND2_X1
X_23827_ _14039_ _14057_ _00819_ _00880_ VDD VSS NAND3_X1
X_23828_ _14034_ _00879_ _00880_ _00881_ VDD VSS AOI21_X1
X_23829_ _14098_ _13897_ _00670_ _00882_ VDD VSS AND3_X1
X_23830_ _14174_ _00881_ _00882_ _00883_ VDD VSS OAI21_X1
X_23831_ _14010_ _00878_ _00883_ _00884_ VDD VSS AOI21_X1
X_23832_ _14045_ _14059_ _00885_ VDD VSS NOR2_X1
X_23833_ _13882_ _13922_ _00732_ _00886_ VDD VSS OAI21_X1
X_23834_ _00886_ _14011_ _15027_ _00887_ VDD VSS OAI21_X1
X_23835_ _14078_ _14095_ net131 _00888_ VDD VSS AOI21_X1
X_23836_ _00740_ _00888_ net1099 net1139 _14047_ _00889_ VDD
+ VSS OAI221_X2
X_23837_ _00885_ _00887_ _14014_ _13964_ _00889_ _00890_ VDD
+ VSS AOI221_X2
X_23838_ _13909_ _13898_ _00890_ _00891_ VDD VSS NOR3_X1
X_23839_ _00846_ _00867_ _00854_ _00874_ _00884_ _00891_ _00094_
+ VDD VSS OAI33_X1
X_23840_ _14065_ _13972_ _13952_ _00779_ _14119_ _00892_ VDD
+ VSS OAI221_X2
X_23841_ _13949_ _13990_ _00893_ VDD VSS NOR2_X1
X_23842_ _14059_ _13881_ net131 _00894_ VDD VSS OAI21_X1
X_23843_ _00819_ _14020_ _14117_ _00895_ VDD VSS OAI21_X1
X_23844_ _13963_ _00893_ _00894_ _00895_ _14018_ _00896_ VDD
+ VSS AOI221_X2
X_23845_ _13990_ _13959_ _13859_ _14006_ _13980_ _00897_ VDD
+ VSS OAI221_X1
X_23846_ _13981_ _13972_ _13880_ _00898_ VDD VSS OAI21_X1
X_23847_ _00897_ _00898_ _15024_ _00899_ VDD VSS AOI21_X1
X_23848_ _14117_ _14006_ _13960_ _15018_ _14005_ net1112 _00900_
+ VDD VSS OAI222_X2
X_23849_ _00899_ _00900_ _14034_ _00901_ VDD VSS AOI21_X1
X_23850_ _14126_ _00892_ _00896_ _00901_ _14031_ _00902_ VDD
+ VSS AOI221_X2
X_23851_ _14147_ _13878_ _14152_ _00903_ VDD VSS AOI21_X1
X_23852_ _13964_ _00716_ _14026_ _00903_ _13951_ _00904_ VDD
+ VSS OAI221_X2
X_23853_ _14024_ _14020_ _13950_ _00905_ VDD VSS NAND3_X1
X_23854_ _00905_ _14018_ _15032_ _00906_ VDD VSS OAI21_X1
X_23855_ _13897_ _00906_ _13923_ _00907_ VDD VSS AOI21_X1
X_23856_ _13923_ _14018_ _15046_ _00908_ VDD VSS OAI21_X1
X_23857_ _13998_ _14047_ _13952_ _00909_ VDD VSS AOI21_X1
X_23858_ _00908_ _00909_ _13951_ _00910_ VDD VSS AOI21_X1
X_23859_ _14156_ _14036_ _14014_ _00911_ VDD VSS OAI21_X1
X_23860_ _14112_ _00911_ _14021_ _00912_ VDD VSS OAI21_X1
X_23861_ _00910_ _00912_ _14012_ _00913_ VDD VSS AOI21_X2
X_23862_ _00773_ _00904_ _00907_ _00913_ _14034_ _00914_ VDD
+ VSS AOI221_X2
X_23863_ _14047_ _14078_ _00730_ _00915_ VDD VSS NOR3_X1
X_23864_ _13999_ _14176_ _14006_ _00916_ VDD VSS OAI21_X1
X_23865_ _14065_ _00915_ _00916_ _00917_ VDD VSS OAI21_X1
X_23866_ _13990_ _00761_ _00918_ VDD VSS NOR2_X1
X_23867_ _13923_ _00850_ _00918_ _00919_ VDD VSS AOI21_X1
X_23868_ net578 _13877_ _00920_ VDD VSS NOR2_X1
X_23869_ _14053_ _13966_ net1106 _00921_ VDD VSS AOI21_X1
X_23870_ _00920_ _00921_ _13965_ _00922_ VDD VSS AOI21_X1
X_23871_ _13877_ _00653_ _00923_ VDD VSS AND2_X1
X_23872_ _14156_ _00840_ _00923_ _14079_ _00924_ VDD VSS AOI22_X1
X_23873_ _00922_ _00924_ _13990_ _00925_ VDD VSS MUX2_X1
X_23874_ _00749_ _00917_ _00919_ _00925_ _14051_ _00926_ VDD
+ VSS AOI221_X2
X_23875_ _13990_ _14004_ _13985_ _14021_ _13923_ _00927_ VDD
+ VSS AOI221_X2
X_23876_ _14039_ _13924_ _14099_ _00928_ VDD VSS NOR3_X1
X_23877_ _13960_ _13964_ _14039_ _00929_ VDD VSS OAI21_X1
X_23878_ _00928_ _00929_ _15027_ _00930_ VDD VSS AOI21_X1
X_23879_ _00927_ _00930_ net1101 _00931_ VDD VSS OAI21_X1
X_23880_ _14029_ _13984_ _14151_ _00932_ VDD VSS OAI21_X1
X_23881_ _14031_ _14068_ _00932_ _00933_ VDD VSS AOI21_X1
X_23882_ _14003_ _14026_ _14039_ _00934_ VDD VSS AOI21_X1
X_23883_ _14089_ _14113_ _15018_ _00935_ VDD VSS AOI21_X1
X_23884_ _14029_ _00934_ _00935_ _14051_ _00936_ VDD VSS OAI22_X1
X_23885_ _13992_ _00933_ _00936_ _00937_ VDD VSS OAI21_X1
X_23886_ _14105_ _00931_ _00937_ _00938_ VDD VSS AOI21_X1
X_23887_ _00926_ _00914_ _00902_ _00938_ _00095_ VDD VSS OR4_X4
X_23888_ _08987_ net571 _00939_ VDD VSS XOR2_X2
X_23889_ _00939_ _09153_ _00940_ VDD VSS XNOR2_X2
X_23890_ net633 _09006_ _00941_ VDD VSS XOR2_X1
X_23891_ _00941_ net536 _00942_ VDD VSS XNOR2_X1
X_23892_ _00942_ _00940_ _00943_ VDD VSS XNOR2_X1
X_23893_ _00464_ _00943_ _09195_ _00944_ VDD VSS MUX2_X2
X_23894_ _06465_ _00944_ _00945_ VDD VSS XOR2_X2
X_23895_ net1134 _00946_ VDD VSS INV_X8
Xrebuffer521 _07905_ net1149 VDD VSS BUF_X4
Xclone514 _13857_ net1139 VDD VSS BUF_X8
X_23898_ _08986_ net642 _00948_ VDD VSS XNOR2_X1
X_23899_ _06450_ _09118_ net582 _00949_ VDD VSS NAND3_X4
X_23900_ _06450_ _11841_ net582 _00950_ VDD VSS OR3_X1
X_23901_ _00948_ _00949_ _00950_ _00951_ VDD VSS AOI21_X4
X_23902_ _08986_ net642 _00952_ VDD VSS XOR2_X1
X_23903_ _06450_ _00953_ VDD VSS INV_X1
X_23904_ _00953_ _09116_ net582 _00954_ VDD VSS NAND3_X1
X_23905_ _00953_ _09030_ net582 _00955_ VDD VSS OR3_X1
X_23906_ _00952_ _00954_ _00955_ _00956_ VDD VSS AOI21_X2
X_23907_ _00953_ _09179_ _00465_ _00957_ VDD VSS NAND3_X1
X_23908_ _06450_ _09179_ _00958_ VDD VSS NAND2_X1
X_23909_ _00957_ _00958_ _00465_ _00959_ VDD VSS OAI21_X1
X_23910_ _00951_ _00956_ _00959_ _00960_ VDD VSS OR3_X4
X_23911_ _00960_ _00961_ VDD VSS INV_X8
X_23912_ _00961_ _00962_ VDD VSS BUF_X16
X_23913_ _00962_ _15061_ VDD VSS BUF_X16
X_23914_ net640 _09040_ _00963_ VDD VSS XOR2_X2
X_23915_ _08987_ _00963_ _00964_ VDD VSS XOR2_X1
X_23916_ _06480_ _09116_ _11882_ _00965_ VDD VSS NAND3_X1
X_23917_ _06480_ _09028_ _00966_ VDD VSS NOR2_X1
X_23918_ _11875_ _00966_ _00967_ VDD VSS NAND2_X1
X_23919_ _00964_ _00965_ _00967_ _00968_ VDD VSS AOI21_X2
X_23920_ _08987_ _00963_ _00969_ VDD VSS XNOR2_X1
X_23921_ _11882_ _00966_ _00970_ VDD VSS NAND2_X1
X_23922_ _06480_ _09075_ _11875_ _00971_ VDD VSS NAND3_X1
X_23923_ _00969_ _00970_ _00971_ _00972_ VDD VSS AOI21_X2
X_23924_ _06480_ _00973_ VDD VSS INV_X1
X_23925_ _00973_ _09730_ _00466_ _00974_ VDD VSS NAND3_X1
X_23926_ _06480_ _09730_ _00975_ VDD VSS NAND2_X1
X_23927_ _00974_ _00975_ _00466_ _00976_ VDD VSS OAI21_X2
X_23928_ _00976_ _00972_ _00968_ _00977_ VDD VSS NOR3_X4
X_23929_ net686 _00978_ VDD VSS INV_X8
X_23930_ _00978_ _00979_ VDD VSS BUF_X8
X_23931_ _00979_ _00980_ VDD VSS BUF_X4
X_23932_ _00980_ _00981_ VDD VSS BUF_X4
X_23933_ _00981_ _15077_ VDD VSS BUF_X8
X_23934_ _00945_ _15051_ VDD VSS BUF_X8
X_23935_ net691 _00982_ VDD VSS BUF_X4
X_23936_ _00982_ _00983_ VDD VSS BUF_X4
X_23937_ _00983_ _15070_ VDD VSS BUF_X4
X_23938_ _09071_ _09152_ _00984_ VDD VSS XNOR2_X1
X_23939_ _09014_ _00984_ _00985_ VDD VSS XNOR2_X1
X_23940_ _09067_ _00985_ _00986_ VDD VSS XNOR2_X1
X_23941_ text_in_r\[111\] _00986_ _09175_ _00987_ VDD VSS
+ MUX2_X1
X_23942_ _06564_ _00987_ _00988_ VDD VSS XNOR2_X2
X_23943_ _00988_ _00989_ VDD VSS INV_X2
X_23944_ _06542_ _00990_ VDD VSS INV_X1
X_23945_ _08994_ _00991_ VDD VSS BUF_X8
X_23946_ _09187_ _09166_ _00992_ VDD VSS XNOR2_X1
X_23947_ _00990_ _00991_ _00992_ _00993_ VDD VSS NOR3_X1
X_23948_ _06542_ _00991_ _00992_ _00994_ VDD VSS NOR3_X1
X_23949_ _09070_ _09065_ _00995_ VDD VSS XNOR2_X1
X_23950_ _09190_ _00995_ _00996_ VDD VSS XNOR2_X2
X_23951_ _00993_ _00994_ _00996_ _00997_ VDD VSS MUX2_X1
X_23952_ _09187_ _09166_ _00998_ VDD VSS XOR2_X1
X_23953_ _06542_ _09103_ _00998_ _00999_ VDD VSS NOR3_X1
X_23954_ _00990_ _09103_ _00998_ _01000_ VDD VSS NOR3_X1
X_23955_ _00999_ _01000_ _00996_ _01001_ VDD VSS MUX2_X1
X_23956_ _06542_ _09180_ text_in_r\[109\] _01002_ VDD VSS
+ NAND3_X1
X_23957_ _00990_ _09180_ _01003_ VDD VSS NAND2_X1
X_23958_ _01002_ _01003_ text_in_r\[109\] _01004_ VDD VSS
+ OAI21_X2
X_23959_ _00997_ _01001_ _01004_ _01005_ VDD VSS OR3_X2
X_23960_ _01005_ _01006_ VDD VSS BUF_X4
X_23961_ _01006_ _01007_ VDD VSS CLKBUF_X3
X_23962_ _09169_ _11897_ _01008_ VDD VSS XNOR2_X1
X_23963_ _09066_ _01008_ _01009_ VDD VSS XNOR2_X1
X_23964_ text_in_r\[110\] _01009_ net826 _01010_ VDD VSS MUX2_X2
X_23965_ _06555_ _01010_ _01011_ VDD VSS XOR2_X2
X_23966_ _06527_ _09175_ _01012_ VDD VSS NAND2_X1
X_23967_ _06527_ _01013_ VDD VSS INV_X1
X_23968_ _01013_ _09175_ _01014_ VDD VSS NAND2_X1
X_23969_ _09094_ _09152_ _01015_ VDD VSS XNOR2_X1
X_23970_ _09163_ _01015_ _01016_ VDD VSS XNOR2_X2
X_23971_ _11907_ _01016_ _01017_ VDD VSS XNOR2_X1
X_23972_ _01012_ _01014_ _01017_ _01018_ VDD VSS MUX2_X1
X_23973_ _01013_ _09138_ text_in_r\[108\] _01019_ VDD VSS
+ NOR3_X1
X_23974_ _06527_ _10571_ _01020_ VDD VSS NOR2_X1
X_23975_ _01019_ _01020_ text_in_r\[108\] _01021_ VDD VSS
+ AOI21_X2
X_23976_ _01018_ _01021_ _01022_ VDD VSS NAND2_X1
X_23977_ _01022_ _01023_ VDD VSS BUF_X4
X_23978_ _01023_ _01024_ VDD VSS BUF_X4
X_23979_ _01011_ _01024_ _01025_ VDD VSS NOR2_X2
X_23980_ _00979_ _01026_ VDD VSS BUF_X4
X_23981_ _01026_ _01027_ VDD VSS CLKBUF_X3
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
X_23983_ _06510_ _01029_ VDD VSS INV_X1
X_23984_ _01029_ _08995_ _01030_ VDD VSS NOR2_X1
X_23985_ _06510_ _08995_ _01031_ VDD VSS NOR2_X1
X_23986_ _09186_ _09152_ _01032_ VDD VSS XNOR2_X1
X_23987_ _09037_ _09092_ _01033_ VDD VSS XNOR2_X1
X_23988_ _01032_ _01033_ _01034_ VDD VSS XNOR2_X2
X_23989_ _09094_ _09151_ _01035_ VDD VSS XNOR2_X1
X_23990_ _09041_ _01035_ _01036_ VDD VSS XNOR2_X1
X_23991_ _01034_ _01036_ _01037_ VDD VSS XNOR2_X2
X_23992_ _01030_ _01031_ _01037_ _01038_ VDD VSS MUX2_X2
X_23993_ _01038_ _01039_ VDD VSS BUF_X4
X_23994_ _01039_ _01040_ VDD VSS BUF_X4
X_23995_ _01029_ _09075_ text_in_r\[107\] _01041_ VDD VSS
+ OR3_X2
X_23996_ _01029_ _08995_ text_in_r\[107\] _01042_ VDD VSS
+ NAND3_X2
X_23997_ _01041_ _01042_ _01043_ VDD VSS NAND2_X4
X_23998_ _01043_ _01044_ VDD VSS BUF_X4
X_23999_ _01044_ _01045_ VDD VSS BUF_X4
X_24000_ net696 _01040_ _01045_ _01046_ VDD VSS NOR3_X2
X_24001_ _15052_ _01047_ VDD VSS CLKBUF_X3
X_24002_ _06510_ net826 _01048_ VDD VSS NAND2_X1
X_24003_ _01029_ net826 _01049_ VDD VSS NAND2_X1
X_24004_ _01048_ _01049_ _01037_ _01050_ VDD VSS MUX2_X2
X_24005_ _01050_ _01051_ VDD VSS BUF_X8
X_24006_ _01051_ _01052_ VDD VSS BUF_X4
X_24007_ _01041_ _01042_ _01053_ VDD VSS AND2_X1
X_24008_ _01053_ _01054_ VDD VSS BUF_X8
X_24009_ _01054_ _01055_ VDD VSS BUF_X4
X_24010_ _01047_ _01052_ _01055_ _01056_ VDD VSS AOI21_X1
X_24011_ _01027_ _01046_ _01056_ _01057_ VDD VSS NOR3_X1
X_24012_ net701 _01052_ _01055_ _01058_ VDD VSS AOI21_X4
X_24013_ _15054_ _01059_ VDD VSS BUF_X4
X_24014_ _01059_ net1137 _01060_ VDD VSS NOR2_X4
X_24015_ _01040_ _01045_ _01060_ _01061_ VDD VSS NOR3_X2
X_24016_ _00983_ _01058_ _01061_ _01062_ VDD VSS NOR3_X1
X_24017_ _01025_ _01057_ _01062_ _01063_ VDD VSS OAI21_X1
X_24018_ _01011_ _01064_ VDD VSS CLKBUF_X3
X_24019_ _01018_ _01021_ _01065_ VDD VSS AND2_X1
X_24020_ _01065_ _01066_ VDD VSS BUF_X4
X_24021_ _01066_ _01067_ VDD VSS BUF_X4
X_24022_ _01067_ _01068_ VDD VSS BUF_X4
Xrebuffer385 _15066_ net850 VDD VSS BUF_X4
X_24024_ _15066_ _01070_ VDD VSS INV_X2
X_24025_ _00978_ _01051_ _01054_ _01071_ VDD VSS AOI21_X4
X_24026_ _01070_ _01071_ _01072_ VDD VSS NAND2_X1
X_24027_ net1137 _01073_ VDD VSS BUF_X8
X_24028_ _01073_ _01074_ VDD VSS INV_X16
X_24029_ _01074_ _01040_ _01045_ _01075_ VDD VSS NOR3_X4
X_24030_ _01027_ _01058_ _01075_ _01076_ VDD VSS OAI21_X1
X_24031_ _01064_ _01068_ _01072_ _01076_ _01077_ VDD VSS NAND4_X1
X_24032_ _00989_ _01007_ _01063_ _01077_ _01078_ VDD VSS AND4_X2
X_24033_ _01050_ _01053_ _01079_ VDD VSS NAND2_X2
X_24034_ _01079_ _01080_ VDD VSS BUF_X4
X_24035_ _01080_ _01081_ VDD VSS BUF_X4
X_24036_ net690 _01039_ _01044_ _01082_ VDD VSS NOR3_X2
X_24037_ _01082_ _01083_ VDD VSS BUF_X4
X_24038_ net486 _01084_ VDD VSS BUF_X16
X_24039_ _01011_ _01081_ _15075_ _01083_ net706 _01085_ VDD
+ VSS AOI221_X2
X_24040_ _01084_ _01051_ _01054_ _01086_ VDD VSS AOI21_X4
X_24041_ _15064_ _01087_ VDD VSS BUF_X8
X_24042_ _01087_ _01040_ _01045_ _01088_ VDD VSS NOR3_X2
X_24043_ _15070_ _01086_ _01088_ _01089_ VDD VSS OAI21_X1
X_24044_ _01038_ _01043_ _01090_ VDD VSS NOR2_X4
X_24045_ _01090_ _01091_ VDD VSS BUF_X4
X_24046_ _00979_ _01091_ _01092_ VDD VSS NAND2_X4
X_24047_ _01089_ _01092_ net703 _01093_ VDD VSS OAI21_X1
X_24048_ _01085_ _01093_ _01064_ _01094_ VDD VSS AOI21_X1
X_24049_ _00988_ _01007_ _01095_ VDD VSS NAND2_X1
X_24050_ _01024_ _01096_ VDD VSS BUF_X4
X_24051_ _01059_ _00978_ _01097_ VDD VSS NOR2_X2
X_24052_ _01079_ _01097_ net705 _00979_ _01098_ VDD VSS AOI211_X2
X_24053_ _01090_ _01099_ VDD VSS BUF_X4
X_24054_ net700 _15050_ VDD VSS BUF_X16
X_24055_ net850 _15050_ _00978_ _01100_ VDD VSS MUX2_X1
X_24056_ _01011_ _01100_ _01099_ _01101_ VDD VSS OAI21_X2
X_24057_ _01096_ _01098_ _01101_ _01102_ VDD VSS NOR3_X2
X_24058_ _15062_ _01103_ VDD VSS BUF_X4
X_24059_ _01103_ _01083_ _01104_ VDD VSS NAND2_X1
X_24060_ net686 _01052_ _01055_ _01105_ VDD VSS AOI21_X4
X_24061_ _00978_ _01039_ _01044_ _01106_ VDD VSS NOR3_X4
X_24062_ _01105_ _01106_ _01107_ VDD VSS NOR2_X2
X_24063_ _01047_ _01108_ VDD VSS INV_X2
X_24064_ _00982_ _01040_ _01045_ _01109_ VDD VSS OAI21_X4
X_24065_ _01104_ _01107_ _01108_ _01109_ net706 _01110_ VDD
+ VSS OAI221_X2
X_24066_ _01102_ _01095_ _01110_ _01025_ _01111_ VDD VSS AOI211_X2
X_24067_ _00983_ _01058_ _01046_ _01112_ VDD VSS NOR3_X1
X_24068_ _15068_ _01113_ VDD VSS BUF_X8
X_24069_ _01113_ _01039_ _01044_ _01114_ VDD VSS OAI21_X1
X_24070_ _00983_ _01114_ _01115_ VDD VSS AND2_X1
X_24071_ net886 _01099_ _01116_ VDD VSS NAND2_X1
X_24072_ _01112_ _01115_ _01116_ _01117_ VDD VSS AOI21_X1
X_24073_ net486 _01118_ VDD VSS INV_X8
X_24074_ _01118_ _01039_ _01044_ _01119_ VDD VSS NOR3_X4
X_24075_ _01119_ _00983_ net859 _01120_ VDD VSS OAI21_X1
X_24076_ _01118_ _00981_ _01121_ VDD VSS NAND2_X1
X_24077_ _01080_ _01122_ VDD VSS BUF_X4
X_24078_ _00946_ _01122_ _01123_ VDD VSS NOR2_X2
X_24079_ _01120_ _01121_ _01123_ _01124_ VDD VSS OAI21_X1
X_24080_ _06555_ _01010_ _01125_ VDD VSS XNOR2_X2
X_24081_ _01117_ _01124_ _01125_ _01126_ VDD VSS MUX2_X1
X_24082_ _01078_ _01094_ _01111_ _01126_ _01127_ VDD VSS AOI22_X1
X_24083_ _01111_ _01078_ _01128_ VDD VSS NOR2_X1
X_24084_ _01096_ _01129_ VDD VSS CLKBUF_X3
X_24085_ _01011_ _01022_ _01130_ VDD VSS NAND2_X1
X_24086_ _01059_ _01051_ _01054_ _01131_ VDD VSS NAND3_X2
X_24087_ _00978_ _01079_ _01073_ _01132_ VDD VSS AOI21_X1
X_24088_ _01130_ _01131_ _01132_ _01083_ _01047_ _01133_ VDD
+ VSS AOI221_X1
X_24089_ _00988_ _01133_ _01134_ VDD VSS OR2_X2
X_24090_ _01046_ _01081_ _01059_ _01135_ VDD VSS AOI21_X1
X_24091_ _01103_ _01092_ _01135_ _00981_ _01136_ VDD VSS OAI22_X2
X_24092_ _01064_ _01068_ _01137_ VDD VSS NOR2_X1
X_24093_ _01026_ _01058_ _01138_ VDD VSS OR2_X1
X_24094_ _01103_ _01052_ _01055_ _01139_ VDD VSS AOI21_X2
X_24095_ _01043_ _01038_ net487 _01140_ VDD VSS NOR3_X4
X_24096_ _01139_ net1042 _01141_ VDD VSS OR2_X4
X_24097_ net688 _01142_ VDD VSS BUF_X4
X_24098_ _01142_ _01143_ VDD VSS BUF_X4
X_24099_ _01143_ _01144_ VDD VSS CLKBUF_X3
X_24100_ _01064_ _01123_ _01138_ _01141_ _01144_ _01145_ VDD
+ VSS OAI221_X2
X_24101_ _01091_ _01146_ VDD VSS BUF_X4
X_24102_ net698 _01147_ VDD VSS BUF_X8
X_24103_ _01131_ _01146_ _01147_ _01148_ VDD VSS OAI21_X1
X_24104_ _01144_ _01148_ _01105_ net1142 _01149_ VDD VSS AOI22_X1
X_24105_ _01145_ _01149_ _01064_ _01150_ VDD VSS OAI21_X2
X_24106_ _01068_ _01151_ VDD VSS CLKBUF_X3
X_24107_ _01134_ _01136_ _01137_ _01150_ _01151_ _01152_ VDD
+ VSS AOI221_X2
X_24108_ _00997_ _01001_ _01004_ _01153_ VDD VSS NOR3_X4
X_24109_ _01153_ _01154_ VDD VSS BUF_X4
X_24110_ _01154_ _01155_ VDD VSS BUF_X4
X_24111_ _01155_ _01156_ VDD VSS BUF_X4
X_24112_ _00988_ _01129_ _01157_ VDD VSS NAND2_X1
X_24113_ _01080_ _01158_ VDD VSS BUF_X4
X_24114_ _01158_ _01159_ VDD VSS CLKBUF_X3
X_24115_ _00961_ _01142_ _01160_ VDD VSS NAND2_X2
X_24116_ _01160_ _00962_ _00946_ _01161_ VDD VSS OAI21_X1
X_24117_ _01159_ _01161_ _01162_ VDD VSS XNOR2_X1
X_24118_ _01084_ _01040_ _01045_ _01163_ VDD VSS OAI21_X4
X_24119_ _00961_ _01051_ _01054_ _01164_ VDD VSS NAND3_X4
X_24120_ _01163_ _00982_ _01164_ _01165_ VDD VSS AND3_X4
X_24121_ net696 _01051_ _01054_ _01166_ VDD VSS NAND3_X4
X_24122_ _01166_ _01091_ _01113_ _01167_ VDD VSS OAI21_X1
X_24123_ _01165_ _01167_ _00981_ _01168_ VDD VSS AOI21_X1
X_24124_ _01162_ _01168_ _01064_ _01169_ VDD VSS MUX2_X1
X_24125_ _01096_ _01170_ VDD VSS BUF_X4
X_24126_ _00978_ _01171_ VDD VSS CLKBUF_X3
X_24127_ _01171_ _01172_ VDD VSS CLKBUF_X3
X_24128_ _01172_ _01139_ _01119_ _01173_ VDD VSS NOR3_X1
X_24129_ _00982_ _01174_ VDD VSS CLKBUF_X3
X_24130_ net850 _01040_ _01045_ _01175_ VDD VSS NOR3_X4
X_24131_ _01175_ _01056_ _01174_ _01176_ VDD VSS NOR3_X1
X_24132_ _01064_ _01173_ _01176_ _01177_ VDD VSS NOR3_X1
X_24133_ net696 _01039_ _01044_ _01178_ VDD VSS OAI21_X2
X_24134_ _01178_ _01080_ _00961_ _01179_ VDD VSS OAI21_X1
X_24135_ _01125_ _01179_ _01171_ _01071_ _01074_ _01180_ VDD
+ VSS AOI221_X1
X_24136_ _01170_ _01177_ _01180_ _01181_ VDD VSS OR3_X1
X_24137_ _01156_ _01157_ _01169_ _00989_ _01181_ _01182_ VDD
+ VSS OAI221_X1
X_24138_ _01127_ _01128_ _01129_ _01152_ _01182_ _00096_ VDD
+ VSS OAI221_X1
X_24139_ _00989_ _01125_ _01183_ VDD VSS NOR2_X2
X_24140_ _01023_ _01154_ _01184_ VDD VSS NAND2_X4
X_24141_ _01172_ _01185_ VDD VSS CLKBUF_X3
X_24142_ _01108_ _01040_ _01045_ _01186_ VDD VSS OAI21_X2
X_24143_ _01185_ _01131_ _01186_ _01187_ VDD VSS AOI21_X1
X_24144_ _01142_ _01163_ _01164_ _01188_ VDD VSS AOI21_X1
X_24145_ _01187_ _01188_ _01189_ VDD VSS OR2_X1
X_24146_ _01007_ _01190_ VDD VSS CLKBUF_X3
X_24147_ _01146_ _01191_ VDD VSS CLKBUF_X3
X_24148_ _15066_ _01192_ VDD VSS BUF_X4
X_24149_ net885 _01191_ _01192_ _01193_ VDD VSS AOI21_X1
X_24150_ _01190_ _01193_ _15077_ _01092_ _15061_ _01194_ VDD
+ VSS OAI221_X1
X_24151_ _01129_ _01194_ _01195_ VDD VSS NOR2_X1
X_24152_ net701 _01038_ _01043_ _01196_ VDD VSS NOR3_X4
X_24153_ _01073_ _01051_ _01054_ _01197_ VDD VSS AOI21_X4
X_24154_ _01172_ _01196_ _01197_ _01198_ VDD VSS NOR3_X1
X_24155_ _01108_ net859 _01159_ _01199_ VDD VSS MUX2_X1
X_24156_ _01198_ _01199_ _15077_ _01200_ VDD VSS AOI21_X1
X_24157_ _01118_ _01039_ _01044_ _01201_ VDD VSS OAI21_X2
X_24158_ _01113_ _01052_ _01055_ _01202_ VDD VSS NAND3_X1
X_24159_ _01185_ _01201_ _01202_ _01203_ VDD VSS AOI21_X1
X_24160_ _01070_ _01040_ _01045_ _01204_ VDD VSS OAI21_X1
X_24161_ _01144_ _01131_ _01204_ _01205_ VDD VSS AOI21_X1
X_24162_ _01170_ _01203_ _01205_ _01206_ VDD VSS OAI21_X1
X_24163_ _01151_ _01200_ _01206_ _01190_ _01207_ VDD VSS AOI22_X1
X_24164_ _01183_ _01184_ _01189_ _01195_ _01207_ _01208_ VDD
+ VSS OAI221_X1
X_24165_ _00988_ _01125_ _01209_ VDD VSS NOR2_X2
X_24166_ _00979_ _01040_ _01045_ _01210_ VDD VSS OAI21_X2
X_24167_ _01113_ _01211_ VDD VSS INV_X4
X_24168_ net694 _01212_ VDD VSS CLKBUF_X3
X_24169_ _01212_ _01099_ _01213_ VDD VSS NOR2_X2
X_24170_ _01175_ _01213_ _01214_ VDD VSS NOR2_X1
X_24171_ _01129_ _01210_ _01211_ _01214_ _15077_ _01215_ VDD
+ VSS OAI221_X1
X_24172_ net885 _01075_ _01216_ VDD VSS NOR2_X1
X_24173_ _01151_ _01210_ _01192_ _01216_ _15077_ _01217_ VDD
+ VSS OAI221_X1
X_24174_ _01156_ _01209_ _01215_ _01217_ _01218_ VDD VSS NAND4_X1
X_24175_ _00988_ _01011_ _01219_ VDD VSS NOR2_X2
X_24176_ _01154_ _01219_ _01220_ VDD VSS NAND2_X1
X_24177_ _01023_ _01196_ net8 _01221_ VDD VSS AOI21_X2
X_24178_ net696 _01090_ _01222_ VDD VSS NOR2_X1
X_24179_ net8 _01079_ _01223_ VDD VSS NOR2_X2
X_24180_ _01171_ _01222_ _01223_ _01224_ VDD VSS OAI21_X1
X_24181_ _00961_ _01051_ _01054_ _01225_ VDD VSS AOI21_X4
X_24182_ _01171_ _01196_ _01225_ _01226_ VDD VSS OAI21_X1
X_24183_ net1137 _01038_ _01043_ _01227_ VDD VSS NOR3_X4
X_24184_ _01086_ _01227_ _01228_ VDD VSS NOR2_X1
X_24185_ _01226_ _01228_ _01171_ _01229_ VDD VSS OAI21_X1
X_24186_ _01220_ _01221_ _01224_ _01024_ _01229_ _01230_ VDD
+ VSS AOI221_X2
X_24187_ _00946_ net687 _01231_ VDD VSS NAND2_X2
X_24188_ _01079_ _01074_ _00978_ _01232_ VDD VSS AOI21_X4
X_24189_ _15082_ _01233_ VDD VSS INV_X1
X_24190_ _01066_ _01231_ _01232_ _01122_ _01233_ _01234_ VDD
+ VSS AOI221_X2
X_24191_ _01086_ _01227_ _01235_ VDD VSS OR2_X2
X_24192_ _01167_ _01235_ _00980_ _01236_ VDD VSS MUX2_X1
X_24193_ _01234_ _01236_ _01068_ _01237_ VDD VSS AOI21_X2
X_24194_ _00989_ _01125_ _01238_ VDD VSS NAND2_X2
X_24195_ _01155_ _01238_ _01239_ VDD VSS NOR2_X1
X_24196_ _00989_ _01011_ _01240_ VDD VSS NOR2_X2
X_24197_ _01103_ _15066_ net689 _01241_ VDD VSS MUX2_X2
X_24198_ _01006_ _01242_ VDD VSS BUF_X4
X_24199_ _01081_ _01242_ _01243_ VDD VSS NAND2_X1
X_24200_ _01067_ _01081_ _01241_ _01243_ _15078_ _01244_ VDD
+ VSS OAI221_X2
X_24201_ _01067_ _01242_ _01245_ VDD VSS NOR2_X1
X_24202_ _01047_ _01051_ _01054_ _01246_ VDD VSS NAND3_X2
X_24203_ _01172_ _01178_ _01246_ _01247_ VDD VSS NAND3_X1
X_24204_ net850 _01051_ _01054_ _01248_ VDD VSS AOI21_X4
X_24205_ _01174_ _01196_ _01248_ _01249_ VDD VSS OAI21_X1
X_24206_ _01245_ _01247_ _01249_ _01250_ VDD VSS NAND3_X1
X_24207_ _01240_ _01244_ _01250_ _01251_ VDD VSS AND3_X1
X_24208_ _01067_ _01154_ _01252_ VDD VSS NOR2_X2
X_24209_ net555 _01090_ _01253_ VDD VSS XNOR2_X2
X_24210_ _01198_ _01253_ _01185_ _01254_ VDD VSS AOI21_X1
X_24211_ _01252_ _01254_ _01255_ VDD VSS NAND2_X1
X_24212_ _01230_ _01237_ _01239_ _01251_ _01255_ _01256_ VDD
+ VSS AOI221_X2
X_24213_ _00983_ _01163_ _01246_ _01257_ VDD VSS NAND3_X2
X_24214_ _01081_ _01258_ VDD VSS CLKBUF_X3
X_24215_ _01196_ _01258_ net703 _01259_ VDD VSS AOI21_X1
X_24216_ _01257_ _01259_ _15070_ _01260_ VDD VSS OAI21_X1
X_24217_ _01142_ _01052_ _01055_ _01261_ VDD VSS NAND3_X1
X_24218_ net1152 _01210_ _01261_ _01262_ VDD VSS AOI21_X1
X_24219_ _01262_ _01058_ _01212_ net706 _01083_ _01263_ VDD
+ VSS AOI221_X2
X_24220_ _01260_ _01263_ _01151_ _01264_ VDD VSS MUX2_X1
X_24221_ _01190_ _01264_ _01209_ _01265_ VDD VSS NAND3_X1
X_24222_ _01208_ _01218_ _01256_ _01265_ _00097_ VDD VSS NAND4_X1
X_24223_ _01018_ _01021_ _01006_ _01266_ VDD VSS AND3_X1
X_24224_ net692 _01052_ _01055_ _01267_ VDD VSS NAND3_X4
X_24225_ _01143_ _01267_ _01268_ VDD VSS NAND2_X1
X_24226_ _01266_ _01268_ _01213_ _00983_ net703 _01269_ VDD
+ VSS OAI221_X2
X_24227_ net692 _01039_ _01044_ _01270_ VDD VSS OAI21_X2
X_24228_ _00980_ _01270_ _01164_ _01271_ VDD VSS AOI21_X1
X_24229_ _01039_ _01113_ _01044_ _01272_ VDD VSS NOR3_X4
X_24230_ _00982_ _01272_ _01273_ VDD VSS NOR2_X2
X_24231_ _00946_ _01080_ _01274_ VDD VSS NAND2_X2
X_24232_ _01271_ _01273_ _01274_ _01275_ VDD VSS AOI21_X1
X_24233_ _01183_ _01269_ _01275_ _01184_ _01276_ VDD VSS OAI211_X2
X_24234_ _01027_ _01088_ _01225_ _01277_ VDD VSS NOR3_X1
X_24235_ _01174_ _01197_ net948 _01278_ VDD VSS NOR3_X1
X_24236_ _01252_ _01277_ _01278_ _01279_ VDD VSS OAI21_X1
X_24237_ _01171_ _01201_ _01267_ _01280_ VDD VSS AND3_X2
X_24238_ _01066_ _01153_ _01281_ VDD VSS NAND2_X2
X_24239_ _01165_ _01280_ _01281_ _01282_ VDD VSS OR3_X4
X_24240_ _01282_ _01279_ _01283_ VDD VSS NAND2_X4
X_24241_ net697 _01284_ VDD VSS INV_X1
X_24242_ _01073_ _01284_ _01142_ _01285_ VDD VSS MUX2_X1
X_24243_ _01068_ _01146_ _01285_ _01286_ VDD VSS OAI21_X2
X_24244_ _01118_ _01142_ _01287_ VDD VSS NOR2_X1
X_24245_ _01146_ _00980_ _01212_ _01288_ VDD VSS OAI21_X1
X_24246_ _01007_ _01287_ _01288_ _01289_ VDD VSS OAI21_X1
X_24247_ net948 _01158_ _01147_ _01290_ VDD VSS AOI21_X4
X_24248_ _00980_ _01227_ _01291_ VDD VSS NOR2_X1
X_24249_ _01290_ _01027_ _01291_ _01274_ _01292_ VDD VSS AOI22_X2
X_24250_ _01023_ _01006_ _01293_ VDD VSS NAND2_X2
X_24251_ _01286_ _01289_ _01292_ _01293_ _01294_ VDD VSS OAI22_X4
X_24252_ _01192_ _01158_ _01295_ VDD VSS NAND2_X1
X_24253_ _01174_ _01166_ _01295_ _01296_ VDD VSS AOI21_X1
X_24254_ _01023_ _01006_ _01297_ VDD VSS NOR2_X1
X_24255_ _01297_ _01109_ _01113_ _01298_ VDD VSS OAI21_X1
X_24256_ _01140_ _01026_ _01225_ _01299_ VDD VSS NOR3_X4
X_24257_ _01059_ _01300_ VDD VSS INV_X1
X_24258_ _01143_ _01081_ _01300_ _01301_ VDD VSS AOI21_X1
X_24259_ _01299_ _01301_ _01116_ _01302_ VDD VSS AOI21_X2
X_24260_ _01240_ _01296_ _01298_ _01302_ _01184_ _01303_ VDD
+ VSS OAI221_X2
X_24261_ _01283_ _01276_ _01303_ _01294_ _01304_ VDD VSS OAI22_X4
X_24262_ _15075_ _01006_ _01305_ VDD VSS NOR2_X1
X_24263_ _01305_ _01242_ _15078_ _01306_ VDD VSS AOI21_X1
X_24264_ _01096_ _01191_ _01306_ _01307_ VDD VSS AOI21_X1
X_24265_ net696 _00979_ _01006_ _01308_ VDD VSS NOR3_X1
X_24266_ _01084_ _01005_ _01309_ VDD VSS NOR2_X1
X_24267_ _01309_ _01005_ net8 _01310_ VDD VSS AOI21_X2
X_24268_ net705 _01154_ _01311_ VDD VSS NOR2_X1
X_24269_ _01308_ _01310_ _01171_ net1152 _01311_ _01312_ VDD
+ VSS AOI221_X2
X_24270_ _01307_ _01312_ _01191_ _01313_ VDD VSS OAI21_X2
X_24271_ _01026_ _01139_ _01314_ VDD VSS OR2_X1
X_24272_ _01201_ _01246_ _01315_ VDD VSS AND2_X1
X_24273_ _01007_ _01223_ _01314_ _01315_ _00983_ _01316_ VDD
+ VSS OAI221_X1
X_24274_ net693 _01081_ _01160_ _01317_ VDD VSS NAND3_X1
X_24275_ _01212_ _01058_ _01318_ VDD VSS OR2_X1
X_24276_ _00982_ _01122_ net705 _01319_ VDD VSS MUX2_X1
X_24277_ _01317_ _01318_ _01172_ _01319_ _01118_ _01320_ VDD
+ VSS OAI221_X1
X_24278_ _01316_ _01320_ _01007_ _01321_ VDD VSS OAI21_X1
X_24279_ _01313_ _01321_ _01151_ _01322_ VDD VSS OAI21_X2
X_24280_ net697 _00978_ _01323_ VDD VSS NAND2_X1
X_24281_ _01080_ _01323_ _01324_ VDD VSS AND2_X1
X_24282_ _01066_ _01231_ _01324_ _01146_ _15084_ _01325_ VDD
+ VSS AOI221_X2
X_24283_ _15073_ _01159_ _01083_ _01147_ _01326_ VDD VSS AOI22_X1
X_24284_ _01096_ _01326_ _01327_ VDD VSS NOR2_X1
X_24285_ _01007_ _01325_ _01327_ _01328_ VDD VSS OAI21_X1
X_24286_ _01024_ _01105_ net703 _01315_ _01143_ _01329_ VDD
+ VSS AOI221_X2
X_24287_ _01159_ _01060_ _01330_ VDD VSS NAND2_X1
X_24288_ _01104_ _01107_ _01070_ _01330_ _00981_ _01331_ VDD
+ VSS OAI221_X1
X_24289_ _01329_ _01331_ _01170_ _01332_ VDD VSS AOI21_X1
X_24290_ _01328_ _01332_ _01190_ _01333_ VDD VSS OAI21_X1
X_24291_ _01304_ _01322_ _01209_ _01219_ _01333_ _00098_ VDD
+ VSS AOI221_X2
X_24292_ _00988_ _01125_ _01334_ VDD VSS NAND2_X1
X_24293_ _01172_ _01242_ _01335_ VDD VSS NAND2_X1
X_24294_ _01191_ _01310_ _01027_ _01335_ _01103_ _01336_ VDD
+ VSS OAI221_X1
X_24295_ _01258_ _01335_ net706 _01300_ _00981_ _01337_ VDD
+ VSS OAI221_X1
X_24296_ _01170_ _01336_ _01337_ _01338_ VDD VSS AND3_X1
X_24297_ _01142_ _01164_ _01114_ _01339_ VDD VSS AOI21_X1
X_24298_ _01140_ _01060_ _01080_ _01340_ VDD VSS AOI21_X2
X_24299_ _01339_ _01340_ _00982_ _01341_ VDD VSS AOI21_X1
X_24300_ net1142 _01107_ _01342_ VDD VSS NAND2_X1
X_24301_ _01242_ _01106_ _15061_ _01343_ VDD VSS AOI21_X1
X_24302_ _01096_ _01242_ _01341_ _01342_ _01343_ _01344_ VDD
+ VSS AOI221_X2
X_24303_ _00946_ _15050_ _01066_ _01091_ _01345_ VDD VSS NAND4_X1
X_24304_ _00961_ _01142_ _01023_ net554 _01346_ VDD VSS AOI22_X2
X_24305_ _01091_ _01066_ _01118_ _01347_ VDD VSS AOI21_X1
X_24306_ _01345_ _01346_ _01122_ _01231_ _01347_ _01348_ VDD
+ VSS OAI221_X2
X_24307_ _01171_ _01023_ _01349_ VDD VSS NAND2_X1
X_24308_ _01212_ _01066_ _01350_ VDD VSS NAND2_X1
X_24309_ _01349_ _01350_ _01351_ VDD VSS NAND2_X1
X_24310_ net859 _01143_ _01024_ _01352_ VDD VSS NOR3_X1
X_24311_ _01348_ _01351_ net1125 _01258_ _01352_ _01353_ VDD
+ VSS AOI221_X2
X_24312_ _01007_ _01160_ _01068_ _01354_ VDD VSS OAI21_X1
X_24313_ _01344_ _01338_ _01334_ _01353_ _01354_ _01238_ _01355_
+ VDD VSS OAI33_X1
X_24314_ _00988_ _01064_ _01356_ VDD VSS NAND2_X1
X_24315_ _01158_ _01241_ _01357_ VDD VSS NOR2_X1
X_24316_ _01066_ _01006_ _01358_ VDD VSS NAND2_X2
X_24317_ _01087_ _00979_ _01359_ VDD VSS NAND2_X1
X_24318_ _00979_ _01060_ _01360_ VDD VSS OR2_X4
X_24319_ _01099_ _01359_ _01360_ _01361_ VDD VSS AOI21_X4
X_24320_ _01357_ _01358_ _01361_ _01362_ VDD VSS NOR3_X2
X_24321_ net1152 _01122_ _01154_ _01363_ VDD VSS NAND3_X1
X_24322_ _01067_ _01273_ _01363_ _01364_ VDD VSS AOI21_X1
X_24323_ _01309_ _01006_ _15050_ _01365_ VDD VSS AOI21_X2
X_24324_ _01122_ _01154_ _01366_ VDD VSS NAND2_X1
X_24325_ _01143_ _01158_ _01365_ _01366_ net1142 _01367_ VDD
+ VSS OAI221_X2
X_24326_ _15061_ _01027_ _01123_ _01368_ VDD VSS OAI21_X1
X_24327_ _01281_ _01082_ net705 _01108_ _01071_ _01369_ VDD
+ VSS AOI221_X2
X_24328_ _01362_ _01364_ _01367_ _01368_ _01369_ _01370_ VDD
+ VSS AOI221_X2
X_24329_ _01356_ _01370_ _01371_ VDD VSS NOR2_X2
X_24330_ _00989_ _01064_ _01372_ VDD VSS NAND2_X2
X_24331_ _01160_ _00962_ _01212_ _01373_ VDD VSS OAI21_X1
X_24332_ _01358_ _01373_ _01099_ _01105_ _01147_ _01374_ VDD
+ VSS AOI221_X2
X_24333_ _01171_ _01114_ _01375_ VDD VSS AND2_X1
X_24334_ _00980_ _01140_ _01376_ VDD VSS NOR2_X1
X_24335_ _01293_ _01267_ _01375_ _01376_ _01274_ _01377_ VDD
+ VSS AOI221_X2
X_24336_ _01118_ _01052_ _01055_ _01378_ VDD VSS NAND3_X4
X_24337_ _01174_ _01378_ _01178_ _01379_ VDD VSS AOI21_X1
X_24338_ _01027_ _01139_ _01175_ _01380_ VDD VSS NOR3_X1
X_24339_ _01212_ _01225_ _01381_ VDD VSS NAND2_X1
X_24340_ _01104_ _01381_ _01382_ VDD VSS NAND2_X1
X_24341_ _01281_ _01379_ _01380_ _01299_ _01382_ _01184_ _01383_
+ VDD VSS OAI33_X1
X_24342_ _01383_ _01374_ _01377_ _01372_ _01384_ VDD VSS NOR4_X2
X_24343_ _01212_ _01091_ _01385_ VDD VSS NAND2_X1
X_24344_ _00982_ _01197_ _01386_ VDD VSS NOR2_X1
X_24345_ _01119_ _01158_ _01211_ _01387_ VDD VSS AOI21_X1
X_24346_ _01024_ _01385_ _01386_ _01387_ _01174_ _01388_ VDD
+ VSS AOI221_X1
X_24347_ _01185_ _01201_ _01164_ _01389_ VDD VSS NAND3_X1
X_24348_ _01186_ _01258_ _01103_ _01390_ VDD VSS OAI21_X1
X_24349_ _01389_ _01390_ _01185_ _01391_ VDD VSS OAI21_X1
X_24350_ _01388_ _01391_ _01129_ _01392_ VDD VSS AOI21_X1
X_24351_ _01220_ _01392_ _01393_ VDD VSS NOR2_X1
X_24352_ _01371_ _01355_ _01384_ _01393_ _00099_ VDD VSS NOR4_X2
X_24353_ _00981_ _01274_ _01246_ _01394_ VDD VSS NAND3_X1
X_24354_ _01067_ _01160_ _01395_ VDD VSS AND2_X1
X_24355_ _01027_ _01270_ _01396_ VDD VSS NAND2_X1
X_24356_ _01396_ _01258_ _01059_ _01397_ VDD VSS OAI21_X1
X_24357_ _01007_ _01394_ _01395_ _01397_ _01170_ _01398_ VDD
+ VSS AOI221_X2
X_24358_ net1152 _01026_ _01066_ _01399_ VDD VSS AOI21_X1
X_24359_ _01146_ _01399_ net693 net1183 _01172_ _01400_ VDD
+ VSS OAI221_X2
X_24360_ net705 _01066_ _01401_ VDD VSS NAND2_X1
X_24361_ _01081_ _01349_ _01108_ _01401_ _01172_ _01402_ VDD
+ VSS OAI221_X2
X_24362_ _01174_ _01225_ _01067_ _01403_ VDD VSS MUX2_X1
X_24363_ _01156_ _01400_ _01402_ _01403_ net693 _01404_ VDD
+ VSS AOI221_X2
X_24364_ _01209_ _01398_ _01404_ _01405_ VDD VSS OAI21_X1
X_24365_ _01026_ _01158_ _01047_ _01406_ VDD VSS AOI21_X2
X_24366_ _15051_ _01081_ _01407_ VDD VSS NAND2_X1
X_24367_ _00983_ _01227_ _01408_ VDD VSS NOR2_X1
X_24368_ _01096_ _01166_ _01406_ _01407_ _01408_ _01409_ VDD
+ VSS AOI221_X2
X_24369_ _01227_ _01159_ _01147_ _01410_ VDD VSS AOI21_X1
X_24370_ _01068_ _01407_ _01273_ _01410_ _01144_ _01411_ VDD
+ VSS AOI221_X1
X_24371_ _01190_ _01409_ _01411_ _01412_ VDD VSS OAI21_X1
X_24372_ _15070_ _01228_ _01413_ VDD VSS NOR2_X1
X_24373_ _01087_ _00979_ _01414_ VDD VSS NOR2_X1
X_24374_ _01068_ _01414_ _01415_ VDD VSS OR2_X1
X_24375_ _01178_ _01258_ _01113_ _01416_ VDD VSS OAI21_X1
X_24376_ _01378_ _01091_ _01087_ _01417_ VDD VSS OAI21_X2
X_24377_ _01416_ _01417_ _01185_ _01418_ VDD VSS MUX2_X1
X_24378_ _01156_ _01413_ _01415_ _01418_ _01129_ _01419_ VDD
+ VSS OAI221_X1
X_24379_ _01219_ _01412_ _01419_ _01420_ VDD VSS NAND3_X1
X_24380_ _01125_ _01024_ _01421_ VDD VSS NAND2_X1
X_24381_ _01212_ _01080_ _01154_ _01422_ VDD VSS NOR3_X1
X_24382_ net1183 _00980_ _01422_ _01423_ VDD VSS OAI21_X1
X_24383_ _01005_ _01166_ net686 _01424_ VDD VSS AOI21_X2
X_24384_ _01090_ _01153_ _01425_ VDD VSS NOR2_X2
X_24385_ net686 _01090_ _01005_ _01426_ VDD VSS OAI21_X1
X_24386_ _01424_ _01425_ _00961_ net8 _01426_ _01427_ VDD
+ VSS AOI221_X2
X_24387_ _01421_ _01427_ _01423_ _01105_ net1142 _01428_ VDD
+ VSS AOI221_X2
X_24388_ _01192_ _01287_ _01158_ _01429_ VDD VSS MUX2_X1
X_24389_ _01025_ _01429_ _01007_ _01430_ VDD VSS OAI21_X1
X_24390_ _01300_ _01039_ _01044_ _01431_ VDD VSS NOR3_X1
X_24391_ _01431_ _01058_ _01432_ VDD VSS NOR2_X1
X_24392_ _01381_ _01432_ _00981_ _01092_ _01047_ _01433_ VDD
+ VSS OAI221_X1
X_24393_ _01430_ _01433_ _01190_ _01434_ VDD VSS AOI21_X1
X_24394_ _01428_ _00989_ _01434_ _01435_ VDD VSS OR3_X2
X_24395_ _01273_ _01106_ net1183 _01436_ VDD VSS AOI21_X1
X_24396_ _01064_ _01358_ _01436_ _01437_ VDD VSS OAI21_X1
X_24397_ _00982_ _01253_ _01438_ VDD VSS NOR2_X2
X_24398_ _01142_ _01006_ _01439_ VDD VSS NOR2_X2
X_24399_ _01431_ _01248_ _01440_ VDD VSS NOR2_X1
X_24400_ _01246_ _01099_ net703 _01441_ VDD VSS OAI21_X1
X_24401_ _01438_ _01439_ _01440_ _01174_ _01441_ _01442_ VDD
+ VSS AOI221_X2
X_24402_ _01067_ _01440_ _01439_ _01443_ VDD VSS AOI21_X1
X_24403_ net1042 _01058_ _01143_ _01444_ VDD VSS NOR3_X4
X_24404_ _01026_ _01075_ _01248_ _01445_ VDD VSS NOR3_X1
X_24405_ _01444_ _01096_ _01445_ _01446_ VDD VSS NOR3_X2
X_24406_ _01446_ _01443_ _01447_ VDD VSS OR2_X2
X_24407_ _01437_ _01442_ _01170_ _01447_ _01156_ _01448_ VDD
+ VSS AOI221_X2
X_24408_ _01405_ _01420_ _01435_ _01448_ _00100_ VDD VSS OAI211_X2
X_24409_ _01170_ _01098_ _01449_ VDD VSS OR2_X1
X_24410_ _01211_ _01074_ _01174_ _01450_ VDD VSS MUX2_X1
X_24411_ _01156_ _01450_ _01191_ _01451_ VDD VSS OAI21_X1
X_24412_ _15061_ _01105_ _01417_ _01144_ _01452_ VDD VSS AOI22_X1
X_24413_ _01449_ _01451_ _01452_ _01358_ _01453_ VDD VSS OAI22_X1
X_24414_ _01439_ _01197_ _01088_ _01454_ VDD VSS OAI21_X1
X_24415_ _01155_ _01146_ _01059_ _01455_ VDD VSS OAI21_X1
X_24416_ _01425_ _01455_ _01074_ _01456_ VDD VSS AOI21_X1
X_24417_ _01425_ _01106_ _01155_ _01457_ VDD VSS AOI21_X1
X_24418_ _01454_ _01456_ _15077_ _01284_ _01457_ _01458_ VDD
+ VSS OAI221_X2
X_24419_ _01151_ _01372_ _01459_ VDD VSS NOR2_X1
X_24420_ _01209_ _01453_ _01458_ _01459_ _01460_ VDD VSS AOI22_X1
X_24421_ _01192_ _01060_ _01080_ _01461_ VDD VSS MUX2_X1
X_24422_ _01242_ _01461_ _01143_ _01083_ _01147_ _01462_ VDD
+ VSS AOI221_X2
X_24423_ _01155_ _01106_ _01192_ _01159_ _01103_ _01463_ VDD
+ VSS AOI221_X1
X_24424_ _01129_ _01462_ _01463_ _01464_ VDD VSS NOR3_X1
X_24425_ _01272_ _01122_ _01103_ _01465_ VDD VSS AOI21_X1
X_24426_ _01119_ net885 _01466_ VDD VSS NOR2_X1
X_24427_ _01465_ _01466_ _00983_ _01467_ VDD VSS MUX2_X1
X_24428_ _01159_ _00981_ _01073_ _01468_ VDD VSS AOI21_X1
X_24429_ _01468_ _01105_ _01211_ _01469_ VDD VSS AOI21_X1
X_24430_ _01467_ _01293_ _01469_ _01184_ _01470_ VDD VSS OAI22_X2
X_24431_ _01240_ _01470_ _01464_ _01471_ VDD VSS OAI21_X2
X_24432_ _01144_ _01131_ _01163_ _01472_ VDD VSS AOI21_X1
X_24433_ net859 _01261_ _01473_ VDD VSS NOR2_X1
X_24434_ _01144_ _01186_ _01202_ _01474_ VDD VSS AOI21_X1
X_24435_ net706 _01109_ _01475_ VDD VSS NOR2_X1
X_24436_ _01293_ _01472_ _01473_ _01474_ _01358_ _01475_ _01476_
+ VDD VSS OAI33_X1
X_24437_ _01023_ _01080_ _01477_ VDD VSS NAND2_X1
X_24438_ _01155_ _01241_ _01477_ _01350_ _01092_ _01478_ VDD
+ VSS OAI221_X2
X_24439_ _01092_ _01401_ _01479_ VDD VSS NAND2_X1
X_24440_ _01158_ _01196_ _01023_ _01480_ VDD VSS MUX2_X1
X_24441_ _01478_ _01479_ net1183 net859 _01480_ _01481_ VDD
+ VSS AOI221_X2
X_24442_ _01219_ _01476_ _01481_ _01482_ VDD VSS OAI21_X1
X_24443_ _15061_ _01242_ _01483_ VDD VSS XNOR2_X1
X_24444_ _01074_ _01083_ _01071_ _01192_ _01484_ VDD VSS AOI22_X1
X_24445_ _01151_ _01261_ _01483_ _01484_ _01156_ _01485_ VDD
+ VSS OAI221_X1
X_24446_ _01155_ _01116_ _01486_ VDD VSS NAND2_X1
X_24447_ _15061_ _01210_ _01486_ _01487_ VDD VSS AOI21_X1
X_24448_ _01267_ _01091_ net698 _01488_ VDD VSS OAI21_X1
X_24449_ _01026_ net885 _01489_ VDD VSS NOR2_X1
X_24450_ _01242_ _01488_ _01026_ _01489_ _01385_ _01490_ VDD
+ VSS AOI221_X1
X_24451_ _01154_ _01106_ _01070_ _01465_ _00980_ _01491_ VDD
+ VSS AOI221_X1
X_24452_ _01490_ _01491_ _01492_ VDD VSS OR2_X1
X_24453_ _01183_ _01485_ _01487_ _01492_ _01151_ _01493_ VDD
+ VSS OAI221_X1
X_24454_ _01471_ _01460_ _01482_ _01493_ _00101_ VDD VSS AND4_X2
X_24455_ _01087_ _01494_ VDD VSS INV_X1
X_24456_ _01494_ _01103_ _01099_ _01495_ VDD VSS MUX2_X1
X_24457_ _01068_ _01071_ net693 _01495_ _01185_ _01496_ VDD
+ VSS AOI221_X1
X_24458_ _01190_ _01286_ _01497_ VDD VSS NAND2_X1
X_24459_ _01129_ _01475_ _01339_ _01498_ VDD VSS OAI21_X1
X_24460_ _01170_ _01258_ _15072_ _01499_ VDD VSS AOI21_X1
X_24461_ _01359_ _15077_ net693 _01500_ VDD VSS OAI21_X1
X_24462_ _01499_ _01500_ _01258_ _01501_ VDD VSS OAI21_X1
X_24463_ _01498_ _01501_ _01502_ VDD VSS NAND2_X1
X_24464_ _01240_ _01496_ _01497_ _01502_ _01190_ _01503_ VDD
+ VSS OAI221_X2
X_24465_ _15071_ _15080_ _01122_ _01504_ VDD VSS OR3_X1
X_24466_ _00962_ _00982_ _01212_ _01505_ VDD VSS MUX2_X1
X_24467_ _01504_ _01505_ _01146_ _01506_ VDD VSS OAI21_X1
X_24468_ _01297_ _01506_ _01507_ VDD VSS AND2_X1
X_24469_ _01270_ _01122_ _01047_ _01508_ VDD VSS OAI21_X1
X_24470_ _01184_ _01508_ _01143_ _01105_ _01059_ _01509_ VDD
+ VSS AOI221_X1
X_24471_ _01211_ _01494_ _00979_ _01510_ VDD VSS MUX2_X1
X_24472_ _01266_ _01510_ _01081_ _01511_ VDD VSS OAI21_X4
X_24473_ _01097_ _01055_ _01052_ _01192_ _01026_ _01512_ VDD
+ VSS AOI221_X2
X_24474_ _01270_ _01158_ net1152 _01513_ VDD VSS OAI21_X1
X_24475_ _01378_ _01060_ _01099_ _01514_ VDD VSS OAI21_X1
X_24476_ _01513_ _01514_ _00980_ _01515_ VDD VSS MUX2_X1
X_24477_ _01511_ _01512_ _01515_ _01293_ _01516_ VDD VSS OAI22_X4
X_24478_ _01516_ _01372_ _01509_ _01507_ _01517_ VDD VSS OR4_X4
X_24479_ _01323_ _00981_ _01084_ _01518_ VDD VSS OAI21_X1
X_24480_ _15073_ _01518_ _01191_ _01519_ VDD VSS MUX2_X1
X_24481_ _15070_ _01140_ _01213_ _01520_ VDD VSS OAI21_X2
X_24482_ _01281_ _01148_ _15077_ _01521_ VDD VSS AOI21_X1
X_24483_ _01245_ _01519_ _01520_ _01521_ _01522_ VDD VSS AOI22_X2
X_24484_ _15077_ _01222_ _01061_ _01523_ VDD VSS NOR3_X1
X_24485_ _15070_ _01140_ _01225_ _01524_ VDD VSS NOR3_X1
X_24486_ _01266_ _01523_ _01524_ _01525_ VDD VSS OAI21_X2
X_24487_ _01103_ net859 _01159_ _01526_ VDD VSS MUX2_X1
X_24488_ _01252_ _01526_ _15070_ _01109_ _01147_ _01527_ VDD
+ VSS OAI221_X1
X_24489_ _01219_ _01522_ _01525_ _01527_ _01528_ VDD VSS NAND4_X2
X_24490_ _01147_ _01083_ _01071_ _15061_ _01529_ VDD VSS AOI22_X1
X_24491_ net859 _15070_ _01225_ _01530_ VDD VSS OAI21_X1
X_24492_ _01151_ _01529_ _01530_ _01531_ VDD VSS NAND3_X1
X_24493_ _15061_ _01185_ _01106_ _01211_ _01532_ VDD VSS AOI22_X1
X_24494_ _01129_ _01381_ _01532_ _01533_ VDD VSS NAND3_X1
X_24495_ _01190_ _01531_ _01533_ _01534_ VDD VSS AOI21_X1
X_24496_ _01172_ _01417_ _01535_ VDD VSS OR2_X2
X_24497_ _01024_ _01105_ net1183 _01536_ VDD VSS AOI21_X1
X_24498_ _01284_ _00980_ _01537_ VDD VSS NAND2_X1
X_24499_ _01146_ _01160_ _01537_ _01538_ VDD VSS NAND3_X1
X_24500_ _01538_ _01191_ _01233_ _01539_ VDD VSS OAI21_X1
X_24501_ _01155_ _01536_ _01535_ _01539_ _01170_ _01540_ VDD
+ VSS AOI221_X2
X_24502_ _01183_ _01540_ _01534_ _01541_ VDD VSS OAI21_X2
X_24503_ _01503_ _01517_ _01528_ _01541_ _00102_ VDD VSS NAND4_X4
X_24504_ _01156_ _01227_ _01542_ VDD VSS NOR2_X1
X_24505_ _01542_ _01505_ _01191_ _01543_ VDD VSS OAI21_X1
X_24506_ _01270_ _01159_ _01192_ _01544_ VDD VSS OAI21_X1
X_24507_ _01144_ _01191_ _01060_ _01545_ VDD VSS OAI21_X1
X_24508_ _01156_ _01544_ _01144_ _01545_ _01123_ _01546_ VDD
+ VSS OAI221_X1
X_24509_ _01151_ _01543_ _01546_ _01547_ VDD VSS AOI21_X1
X_24510_ _01027_ _01139_ _01175_ _01548_ VDD VSS OAI21_X1
X_24511_ _01155_ _01257_ _01548_ _01549_ VDD VSS AND3_X2
X_24512_ _01142_ _01091_ _01300_ _01550_ VDD VSS AOI21_X1
X_24513_ _01154_ _01274_ _01550_ _01174_ _01108_ _01551_ VDD
+ VSS AOI221_X1
X_24514_ _01129_ _01549_ _01551_ _01552_ VDD VSS NOR3_X2
X_24515_ _01372_ _01547_ _01552_ _01553_ VDD VSS NOR3_X1
X_24516_ _01083_ _01258_ _01068_ _01554_ VDD VSS AOI21_X1
X_24517_ _15070_ _01170_ _01554_ _01070_ _01555_ VDD VSS OAI22_X1
X_24518_ _01018_ _01021_ _01052_ _01055_ _01556_ VDD VSS AOI22_X2
X_24519_ _01119_ _01556_ _01147_ _01557_ VDD VSS AOI21_X1
X_24520_ _15077_ _01557_ _01558_ VDD VSS NOR2_X1
X_24521_ _01190_ _01555_ _01558_ _01559_ VDD VSS OAI21_X1
X_24522_ _00962_ _01171_ _01560_ VDD VSS NOR2_X1
X_24523_ _01192_ _01143_ _01561_ VDD VSS NOR2_X1
X_24524_ _01023_ _01122_ _01562_ VDD VSS NOR2_X1
X_24525_ _01242_ _01560_ _01556_ _01561_ _01562_ _01563_ VDD
+ VSS AOI221_X1
X_24526_ net859 _01024_ _01146_ _01564_ VDD VSS NOR3_X1
X_24527_ _01564_ _01191_ _01096_ _01565_ VDD VSS AOI21_X1
X_24528_ _01105_ _01562_ _15070_ _01566_ VDD VSS AOI21_X1
X_24529_ _01563_ _01565_ net1183 net693 _01566_ _01567_ VDD
+ VSS OAI221_X1
X_24530_ _01334_ _01559_ _01567_ _01568_ VDD VSS AOI21_X1
X_24531_ _15061_ _01092_ _01109_ _01113_ _01084_ _01107_ _01569_
+ VDD VSS OAI222_X2
X_24532_ _01185_ _01196_ _01248_ _01570_ VDD VSS OAI21_X1
X_24533_ _01184_ _01406_ _01166_ _01571_ VDD VSS AOI21_X1
X_24534_ _01252_ _01569_ _01570_ _01571_ _01572_ VDD VSS AOI22_X1
X_24535_ _01160_ _01144_ net693 _01573_ VDD VSS OAI21_X1
X_24536_ _01511_ _01573_ _01258_ _01574_ VDD VSS AOI21_X2
X_24537_ net948 _01159_ net693 _01575_ VDD VSS AOI21_X1
X_24538_ net1142 _01210_ _01575_ _01185_ _01576_ VDD VSS OAI22_X1
X_24539_ _01574_ _01576_ _01297_ _01577_ VDD VSS AOI21_X2
X_24540_ _01356_ _01572_ _01577_ _01578_ VDD VSS AOI21_X2
X_24541_ _01067_ _01188_ _01579_ VDD VSS NOR2_X1
X_24542_ net885 _01223_ _01580_ VDD VSS NOR2_X1
X_24543_ _01579_ _01580_ _01027_ _01581_ VDD VSS OAI21_X2
X_24544_ _01091_ _01287_ _01414_ _01582_ VDD VSS OAI21_X1
X_24545_ _01582_ _01099_ _15080_ _01583_ VDD VSS OAI21_X1
X_24546_ _01155_ _01583_ _01067_ _01584_ VDD VSS AOI21_X1
X_24547_ _01197_ _01099_ _01147_ _01585_ VDD VSS AOI21_X1
X_24548_ _01024_ _01585_ _01172_ _01586_ VDD VSS OAI21_X1
X_24549_ _01248_ _01083_ _01059_ _01587_ VDD VSS AOI21_X1
X_24550_ _01438_ _01586_ _01587_ _01096_ _01588_ VDD VSS OAI22_X2
X_24551_ _01238_ _01581_ _01584_ _01588_ _01156_ _01589_ VDD
+ VSS AOI221_X2
X_24552_ _01578_ _01568_ _01589_ _01553_ _00103_ VDD VSS NOR4_X2
X_24553_ _06466_ _01590_ VDD VSS INV_X1
X_24554_ _01590_ _08975_ _01591_ VDD VSS NOR2_X1
X_24555_ _06466_ _08975_ _01592_ VDD VSS NOR2_X1
X_24556_ sa01_sr\[1\] sa30_sub\[1\] _01593_ VDD VSS XOR2_X2
X_24557_ _09796_ _09799_ _01594_ VDD VSS XNOR2_X2
X_24558_ _01594_ _01593_ _01595_ VDD VSS XNOR2_X1
X_24559_ net505 sa21_sr\[0\] _01596_ VDD VSS XOR2_X2
X_24560_ sa11_sr\[1\] _01596_ _01597_ VDD VSS XNOR2_X2
X_24561_ _01595_ _01597_ _01598_ VDD VSS XNOR2_X2
X_24562_ _01591_ _01592_ _01598_ _01599_ VDD VSS MUX2_X2
X_24563_ _06466_ _09180_ _00467_ _01600_ VDD VSS NAND3_X1
X_24564_ _01590_ _09818_ _01601_ VDD VSS NAND2_X2
X_24565_ _01600_ _00467_ _01601_ _01602_ VDD VSS OAI21_X4
X_24566_ _01599_ _01602_ _01603_ VDD VSS NOR2_X4
X_24567_ net824 _01604_ VDD VSS INV_X16
Xrebuffer359 _01603_ net824 VDD VSS BUF_X8
X_24569_ _01604_ _15092_ VDD VSS BUF_X32
X_24570_ _09720_ _01594_ _01606_ VDD VSS XNOR2_X1
X_24571_ _06451_ _09118_ net891 _01607_ VDD VSS NAND3_X4
X_24572_ _06451_ _08994_ _01608_ VDD VSS NOR2_X1
X_24573_ _01608_ net596 _01609_ VDD VSS NAND2_X2
X_24574_ _01606_ _01609_ _01607_ _01610_ VDD VSS AOI21_X4
X_24575_ _09720_ _01594_ _01611_ VDD VSS XOR2_X1
X_24576_ net892 _01608_ _01612_ VDD VSS NAND2_X1
X_24577_ _06451_ _09116_ net596 _01613_ VDD VSS NAND3_X1
X_24578_ _01611_ _01612_ _01613_ _01614_ VDD VSS AOI21_X1
X_24579_ _06451_ _01615_ VDD VSS INV_X1
X_24580_ _01615_ _09179_ _00468_ _01616_ VDD VSS NAND3_X2
X_24581_ _06451_ _09103_ _01617_ VDD VSS NAND2_X1
X_24582_ _01616_ _01617_ _00468_ _01618_ VDD VSS OAI21_X2
X_24583_ _01610_ _01614_ _01618_ _01619_ VDD VSS OR3_X4
X_24584_ _01619_ _15097_ VDD VSS INV_X4
X_24585_ net496 _09762_ _01620_ VDD VSS XOR2_X2
X_24586_ net608 _01620_ _01621_ VDD VSS XOR2_X1
X_24587_ _06483_ _09195_ _12535_ _01622_ VDD VSS NAND3_X1
X_24588_ _06483_ _09727_ _01623_ VDD VSS NOR2_X1
X_24589_ _12529_ _01623_ _01624_ VDD VSS NAND2_X1
X_24590_ _01621_ _01622_ _01624_ _01625_ VDD VSS AOI21_X2
X_24591_ net610 _01620_ _01626_ VDD VSS XNOR2_X1
X_24592_ _12535_ _01623_ _01627_ VDD VSS NAND2_X1
X_24593_ _06483_ net1004 _12529_ _01628_ VDD VSS NAND3_X1
X_24594_ _01626_ _01627_ _01628_ _01629_ VDD VSS AOI21_X2
X_24595_ _06486_ _11938_ _00469_ _01630_ VDD VSS NAND3_X1
X_24596_ _06483_ _11938_ _01631_ VDD VSS NAND2_X1
X_24597_ _01630_ _01631_ _00469_ _01632_ VDD VSS OAI21_X2
X_24598_ _01625_ _01629_ _01632_ _01633_ VDD VSS NOR3_X4
X_24599_ _01633_ _01634_ VDD VSS INV_X1
X_24600_ _01634_ _01635_ VDD VSS BUF_X4
X_24601_ _01635_ _01636_ VDD VSS BUF_X4
X_24602_ _01636_ _01637_ VDD VSS BUF_X4
X_24603_ _01637_ _15113_ VDD VSS BUF_X4
X_24604_ _01603_ _15087_ VDD VSS BUF_X8
X_24605_ _01633_ _01638_ VDD VSS BUF_X4
X_24606_ _01638_ _01639_ VDD VSS BUF_X4
X_24607_ _01639_ _01640_ VDD VSS BUF_X4
X_24608_ _01640_ _15106_ VDD VSS BUF_X4
X_24609_ _06543_ _09158_ _01641_ VDD VSS NAND2_X1
X_24610_ _06543_ _01642_ VDD VSS INV_X1
X_24611_ _01642_ _09158_ _01643_ VDD VSS NAND2_X1
X_24612_ _09872_ _09785_ _01644_ VDD VSS XNOR2_X1
X_24613_ _12615_ _01644_ _01645_ VDD VSS XNOR2_X2
X_24614_ _01641_ _01643_ _01645_ _01646_ VDD VSS MUX2_X2
X_24615_ _01642_ _09158_ text_in_r\[77\] _01647_ VDD VSS NOR3_X2
X_24616_ _06543_ _09803_ _01648_ VDD VSS NOR2_X1
X_24617_ _01647_ _01648_ text_in_r\[77\] _01649_ VDD VSS AOI21_X4
X_24618_ _01646_ _01649_ _01650_ VDD VSS AND2_X1
X_24619_ _01650_ _01651_ VDD VSS BUF_X4
X_24620_ _01651_ _01652_ VDD VSS BUF_X4
X_24621_ _09809_ _09786_ _01653_ VDD VSS XNOR2_X1
X_24622_ _12629_ _01653_ _01654_ VDD VSS XNOR2_X2
X_24623_ text_in_r\[78\] _01654_ _09803_ _01655_ VDD VSS MUX2_X2
X_24624_ _06556_ _01655_ _01656_ VDD VSS XOR2_X2
X_24625_ _09787_ _09799_ _01657_ VDD VSS XNOR2_X1
X_24626_ _09790_ _09742_ _01658_ VDD VSS XNOR2_X1
X_24627_ _01657_ _01658_ _01659_ VDD VSS XNOR2_X1
X_24628_ text_in_r\[79\] _01659_ _09158_ _01660_ VDD VSS MUX2_X2
X_24629_ _06565_ _01660_ _01661_ VDD VSS XNOR2_X2
X_24630_ _01656_ _01661_ _01662_ VDD VSS NOR2_X2
X_24631_ _01652_ _01662_ _01663_ VDD VSS NAND2_X1
X_24632_ _06528_ _01664_ VDD VSS INV_X1
X_24633_ net826 text_in_r\[76\] _01665_ VDD VSS NOR2_X1
X_24634_ _09813_ _09799_ _01666_ VDD VSS XNOR2_X1
X_24635_ _09841_ _09808_ _01667_ VDD VSS XNOR2_X1
X_24636_ _01666_ _01667_ _01668_ VDD VSS XNOR2_X2
X_24637_ _12557_ _01668_ _01669_ VDD VSS XOR2_X2
X_24638_ _01664_ _01665_ _01669_ _09175_ _01670_ VDD VSS AOI211_X2
X_24639_ net1084 text_in_r\[76\] _01671_ VDD VSS NAND2_X2
X_24640_ _01671_ _01672_ VDD VSS INV_X1
X_24641_ _12557_ _01668_ _01673_ VDD VSS XNOR2_X2
X_24642_ _06528_ _01672_ _01673_ _09175_ _01674_ VDD VSS AOI211_X2
X_24643_ _06511_ _09175_ _01675_ VDD VSS NAND2_X1
X_24644_ _06511_ _01676_ VDD VSS INV_X1
X_24645_ _01676_ _09138_ _01677_ VDD VSS NAND2_X1
X_24646_ _09868_ _09799_ _01678_ VDD VSS XNOR2_X1
X_24647_ _09759_ _09839_ _01679_ VDD VSS XNOR2_X1
X_24648_ _01678_ _01679_ _01680_ VDD VSS XNOR2_X2
X_24649_ _09763_ _12575_ _01681_ VDD VSS XNOR2_X1
X_24650_ _01680_ _01681_ _01682_ VDD VSS XNOR2_X2
X_24651_ _01675_ _01677_ _01682_ _01683_ VDD VSS MUX2_X1
X_24652_ _01683_ _01684_ VDD VSS BUF_X8
X_24653_ _01684_ _01685_ VDD VSS BUF_X4
X_24654_ _01676_ _09116_ text_in_r\[75\] _01686_ VDD VSS OR3_X2
X_24655_ _01676_ _09180_ text_in_r\[75\] _01687_ VDD VSS NAND3_X2
X_24656_ _01686_ _01687_ _01688_ VDD VSS AND2_X1
X_24657_ _01688_ _01689_ VDD VSS BUF_X8
X_24658_ _01689_ _01690_ VDD VSS BUF_X8
X_24659_ _01670_ _01674_ _01685_ _01690_ _01691_ VDD VSS AOI211_X2
X_24660_ _01663_ _01691_ _15111_ _01692_ VDD VSS AOI21_X1
X_24661_ _01676_ _08995_ _01693_ VDD VSS NOR2_X1
X_24662_ _06511_ _08995_ _01694_ VDD VSS NOR2_X1
X_24663_ _01693_ _01694_ _01682_ _01695_ VDD VSS MUX2_X1
X_24664_ _01695_ _01696_ VDD VSS BUF_X4
X_24665_ _01686_ _01687_ _01697_ VDD VSS NAND2_X4
X_24666_ _01696_ _01697_ _01698_ VDD VSS NOR2_X2
X_24667_ _01698_ _01699_ VDD VSS BUF_X4
X_24668_ _01699_ _01700_ VDD VSS CLKBUF_X3
X_24669_ _01700_ _01701_ VDD VSS CLKBUF_X3
X_24670_ _01670_ _01674_ _01702_ VDD VSS NOR2_X2
X_24671_ _01702_ _01703_ VDD VSS BUF_X4
X_24672_ _01703_ _01704_ VDD VSS BUF_X4
X_24673_ _01704_ _01705_ VDD VSS CLKBUF_X3
X_24674_ _15089_ _01706_ VDD VSS BUF_X4
X_24675_ _01706_ _01707_ VDD VSS INV_X8
X_24676_ _01633_ _01707_ _01708_ VDD VSS NOR2_X4
X_24677_ _01705_ _01708_ _01709_ VDD VSS NAND2_X1
X_24678_ _09803_ text_in_r\[76\] _01710_ VDD VSS OR2_X1
X_24679_ _06528_ _01710_ _01673_ _09136_ _01711_ VDD VSS OAI211_X4
X_24680_ _01664_ _01671_ _01669_ _09136_ _01712_ VDD VSS OAI211_X4
X_24681_ _01711_ _01712_ _01713_ VDD VSS NAND2_X4
X_24682_ net1006 _01714_ VDD VSS INV_X2
X_24683_ _15095_ _01714_ _01638_ _01715_ VDD VSS MUX2_X2
X_24684_ _01713_ _01715_ _01716_ VDD VSS NAND2_X1
X_24685_ _01709_ _01716_ _01717_ VDD VSS NAND2_X1
X_24686_ _15088_ _01718_ VDD VSS BUF_X4
X_24687_ _01696_ _01719_ VDD VSS BUF_X4
X_24688_ _01697_ _01720_ VDD VSS BUF_X4
X_24689_ _01638_ _01719_ _01720_ _01721_ VDD VSS OAI21_X2
X_24690_ _01721_ _01722_ VDD VSS CLKBUF_X3
X_24691_ _01619_ _01684_ _01689_ _01723_ VDD VSS AOI21_X4
X_24692_ _01699_ _01724_ VDD VSS CLKBUF_X3
X_24693_ _15090_ _01725_ VDD VSS CLKBUF_X3
X_24694_ _01723_ _01724_ _01725_ _01726_ VDD VSS AOI21_X1
X_24695_ _01718_ _01722_ _01726_ _15106_ _01727_ VDD VSS OAI22_X1
X_24696_ _01713_ _01728_ VDD VSS BUF_X4
X_24697_ _01728_ _01729_ VDD VSS CLKBUF_X3
X_24698_ _01701_ _01717_ _01727_ _01729_ _01730_ VDD VSS AOI22_X1
X_24699_ _01692_ _01730_ _01731_ VDD VSS NAND2_X1
X_24700_ _01652_ _01732_ VDD VSS BUF_X4
X_24701_ _06556_ _01655_ _01733_ VDD VSS XNOR2_X2
X_24702_ _01733_ _01734_ VDD VSS BUF_X4
X_24703_ _01734_ _01735_ VDD VSS BUF_X4
X_24704_ _06565_ _01660_ _01736_ VDD VSS XOR2_X2
X_24705_ _01735_ _01736_ _01737_ VDD VSS NAND2_X1
X_24706_ _01732_ _01737_ _01738_ VDD VSS NOR2_X1
X_24707_ _01703_ _01739_ VDD VSS CLKBUF_X3
X_24708_ _01739_ _01740_ VDD VSS CLKBUF_X3
X_24709_ net1006 _01684_ _01689_ _01741_ VDD VSS AOI21_X4
X_24710_ _01741_ _01699_ _01725_ _01742_ VDD VSS AOI21_X2
X_24711_ _01635_ _01743_ VDD VSS BUF_X4
X_24712_ _01684_ _01689_ _01744_ VDD VSS NAND2_X4
X_24713_ _01743_ _01744_ _01745_ VDD VSS NAND2_X2
X_24714_ _15100_ _01746_ VDD VSS BUF_X2
X_24715_ _01746_ _01747_ VDD VSS INV_X1
X_24716_ _15113_ _01742_ _01745_ _01747_ _01748_ VDD VSS OAI22_X1
X_24717_ _01740_ _01748_ _01749_ VDD VSS NOR2_X1
X_24718_ _01638_ _01750_ VDD VSS BUF_X4
X_24719_ _15093_ _01751_ VDD VSS BUF_X4
X_24720_ _01751_ _01685_ _01690_ _01752_ VDD VSS NAND3_X2
X_24721_ _01725_ _01753_ VDD VSS INV_X2
X_24722_ _01696_ _01754_ VDD VSS BUF_X4
X_24723_ _01697_ _01755_ VDD VSS BUF_X4
X_24724_ _01753_ _01754_ _01755_ _01756_ VDD VSS OAI21_X1
X_24725_ _01750_ _01752_ _01756_ _01757_ VDD VSS AND3_X2
X_24726_ _01635_ _01685_ _01690_ _01758_ VDD VSS NAND3_X4
X_24727_ _15098_ _01759_ VDD VSS BUF_X4
X_24728_ _01705_ _01758_ _01759_ _01760_ VDD VSS OAI21_X1
X_24729_ _01757_ _01760_ _01761_ VDD VSS NOR2_X1
X_24730_ _01738_ _01749_ _01761_ _01762_ VDD VSS OAI21_X1
X_24731_ _01646_ _01649_ _01763_ VDD VSS NAND2_X2
X_24732_ _01763_ _01713_ _01764_ VDD VSS NAND2_X2
X_24733_ _01718_ _01743_ _01765_ VDD VSS NAND2_X2
X_24734_ _01759_ _01640_ _01766_ VDD VSS NAND2_X1
X_24735_ _01724_ _01765_ _01766_ _01767_ VDD VSS AOI21_X1
X_24736_ _01744_ _01768_ VDD VSS CLKBUF_X3
X_24737_ _01768_ _01769_ VDD VSS CLKBUF_X3
Xclone109 net822 net109 VDD VSS BUF_X4
X_24739_ _15102_ _01771_ VDD VSS BUF_X4
X_24740_ _01743_ _01772_ VDD VSS BUF_X4
X_24741_ _01771_ _01772_ _01773_ VDD VSS NAND2_X1
X_24742_ _01707_ _01774_ VDD VSS BUF_X16
X_24743_ net840 _01640_ _01775_ VDD VSS NAND2_X1
X_24744_ _01769_ _01773_ _01775_ _01776_ VDD VSS AOI21_X1
X_24745_ _01764_ _01767_ _01776_ _01777_ VDD VSS NOR3_X1
X_24746_ _01734_ _01661_ _01778_ VDD VSS NAND2_X1
X_24747_ _01777_ _01778_ _01779_ VDD VSS NOR2_X1
X_24748_ _01774_ _01721_ _01758_ _01759_ _01780_ VDD VSS OAI22_X1
X_24749_ _01633_ _01684_ _01689_ _01781_ VDD VSS AOI21_X4
X_24750_ _01634_ _01696_ _01697_ _01782_ VDD VSS NOR3_X4
X_24751_ _01781_ _01782_ _01783_ VDD VSS OR2_X1
X_24752_ _01718_ _01784_ VDD VSS INV_X1
X_24753_ _01780_ _01783_ _01784_ _01785_ VDD VSS AOI21_X1
X_24754_ net823 _01684_ _01689_ _01786_ VDD VSS NAND3_X4
X_24755_ _01743_ _01787_ VDD VSS BUF_X4
X_24756_ _01786_ _01787_ net108 _01788_ VDD VSS AOI21_X2
X_24757_ net823 _01789_ VDD VSS BUF_X8
X_24758_ _01789_ _01750_ _01790_ VDD VSS NOR2_X2
X_24759_ _01603_ _01791_ VDD VSS CLKBUF_X3
X_24760_ _01698_ _01792_ VDD VSS BUF_X4
X_24761_ _01792_ _01793_ VDD VSS BUF_X4
X_24762_ _01791_ _01793_ _01794_ VDD VSS NAND2_X1
X_24763_ _01788_ _01790_ _01794_ _01795_ VDD VSS AOI21_X1
X_24764_ _01785_ _01795_ _01739_ _01796_ VDD VSS MUX2_X1
X_24765_ _01763_ _01797_ VDD VSS BUF_X4
X_24766_ _01797_ _01798_ VDD VSS CLKBUF_X3
X_24767_ _01763_ _01799_ VDD VSS BUF_X4
X_24768_ _01799_ _01704_ _01800_ VDD VSS NAND2_X2
X_24769_ _01769_ _01801_ VDD VSS CLKBUF_X3
X_24770_ _01619_ _01802_ VDD VSS BUF_X16
X_24771_ _01802_ _01635_ _01803_ VDD VSS NOR2_X4
X_24772_ _01803_ net825 net108 _01804_ VDD VSS AOI21_X2
X_24773_ _01801_ _01804_ _01805_ VDD VSS XNOR2_X1
X_24774_ _01779_ _01796_ _01798_ _01800_ _01805_ _01806_ VDD
+ VSS OAI221_X1
X_24775_ _01656_ _01807_ VDD VSS BUF_X4
X_24776_ _01736_ _01808_ VDD VSS BUF_X4
X_24777_ _01746_ _01809_ VDD VSS BUF_X4
X_24778_ _01809_ _01640_ _01793_ _01704_ _01810_ VDD VSS NAND4_X1
X_24779_ _01774_ _01771_ _01713_ _01811_ VDD VSS MUX2_X1
X_24780_ _01810_ _01811_ _01722_ _01812_ VDD VSS OAI21_X1
X_24781_ _01802_ _01754_ _01755_ _01813_ VDD VSS OAI21_X4
X_24782_ _01704_ _01813_ _01814_ VDD VSS NOR2_X1
X_24783_ _15095_ _01815_ VDD VSS INV_X4
X_24784_ _01815_ _01685_ _01690_ _01816_ VDD VSS NAND3_X2
X_24785_ _01772_ _01816_ _01817_ VDD VSS NAND2_X1
X_24786_ _01652_ _01814_ _01817_ _01818_ VDD VSS OAI21_X1
X_24787_ _01743_ _01723_ _01699_ net108 _01819_ VDD VSS AOI211_X2
X_24788_ _01759_ _01719_ _01720_ _01820_ VDD VSS OAI21_X4
X_24789_ _01640_ _01786_ _01820_ _01821_ VDD VSS AOI21_X1
X_24790_ _01739_ _01819_ _01821_ _01822_ VDD VSS NOR3_X1
X_24791_ _01768_ _01823_ VDD VSS CLKBUF_X3
X_24792_ _01753_ _01639_ _01824_ VDD VSS NAND2_X2
X_24793_ _01823_ _01765_ _01824_ _01825_ VDD VSS AOI21_X1
X_24794_ _15095_ _01826_ VDD VSS BUF_X4
X_24795_ _01704_ _01722_ _01826_ _01827_ VDD VSS OAI21_X1
X_24796_ _01797_ _01825_ _01827_ _01828_ VDD VSS OAI21_X1
X_24797_ _01808_ _01812_ _01818_ _01822_ _01828_ _01829_ VDD
+ VSS OAI221_X2
X_24798_ _01728_ _01830_ VDD VSS BUF_X4
X_24799_ _01787_ _01602_ _01599_ _01831_ VDD VSS OAI21_X1
X_24800_ _01724_ _01824_ _01831_ _01832_ VDD VSS NAND3_X1
X_24801_ net825 _01639_ _01833_ VDD VSS NOR2_X1
X_24802_ _01771_ _01787_ _01834_ VDD VSS NOR2_X1
X_24803_ _01769_ _01833_ _01834_ _01835_ VDD VSS OAI21_X1
X_24804_ _01652_ _01830_ _01832_ _01835_ _01836_ VDD VSS NAND4_X1
X_24805_ _01651_ _01713_ _01837_ VDD VSS NOR2_X2
X_24806_ _01639_ _01838_ VDD VSS BUF_X4
X_24807_ _01802_ _01685_ _01690_ _01839_ VDD VSS NAND3_X4
X_24808_ _01774_ _01719_ _01720_ _01840_ VDD VSS OAI21_X4
X_24809_ _01838_ _01839_ _01840_ _01841_ VDD VSS NAND3_X1
X_24810_ _01787_ _01842_ VDD VSS BUF_X4
Xclone144 net645 net144 VDD VSS BUF_X2
X_24812_ _15104_ _01844_ VDD VSS INV_X4
X_24813_ _01844_ _01754_ _01755_ _01845_ VDD VSS OAI21_X1
X_24814_ _01842_ _01752_ _01845_ _01846_ VDD VSS NAND3_X1
X_24815_ _01837_ _01841_ _01846_ _01847_ VDD VSS NAND3_X1
X_24816_ _01652_ _01739_ _01848_ VDD VSS NOR2_X1
X_24817_ _01826_ _01722_ _01849_ VDD VSS NOR2_X1
X_24818_ _01751_ _01719_ _01720_ _01850_ VDD VSS OAI21_X4
X_24819_ _01838_ _01839_ _01850_ _01851_ VDD VSS AOI21_X1
X_24820_ _01848_ _01849_ _01851_ _01852_ VDD VSS OAI21_X1
X_24821_ _01646_ _01649_ _01711_ _01712_ _01853_ VDD VSS NAND4_X4
X_24822_ _01751_ _01719_ _01720_ _01854_ VDD VSS NOR3_X4
X_24823_ _01640_ _01723_ _01853_ _01854_ _01855_ VDD VSS NOR4_X1
X_24824_ _01842_ _01853_ _01856_ VDD VSS NOR2_X1
X_24825_ _01844_ _01791_ _01699_ _01857_ VDD VSS MUX2_X1
X_24826_ _01855_ _01856_ _01857_ _01858_ VDD VSS AOI21_X1
X_24827_ _01836_ _01847_ _01852_ _01858_ _01859_ VDD VSS NAND4_X1
X_24828_ _01807_ _01829_ _01859_ _01808_ _01860_ VDD VSS OAI211_X2
X_24829_ _01806_ _01762_ _01731_ _01860_ _00104_ VDD VSS AND4_X2
X_24830_ _01802_ _15086_ VDD VSS BUF_X32
X_24831_ _01734_ _01661_ _01861_ VDD VSS NOR2_X2
X_24832_ net823 _01684_ _01689_ _01862_ VDD VSS AOI21_X4
X_24833_ _01862_ _01699_ _01826_ _01863_ VDD VSS AOI21_X2
X_24834_ _01799_ _01745_ _01771_ _01772_ _01863_ _01864_ VDD
+ VSS OAI221_X1
X_24835_ _15097_ _01719_ _01720_ _01865_ VDD VSS OAI21_X2
X_24836_ _01604_ _01865_ _01758_ net840 _01866_ VDD VSS OAI22_X1
X_24837_ _01866_ _01783_ _15086_ _01867_ VDD VSS AOI21_X1
X_24838_ _01864_ _01674_ _01670_ _01797_ _01867_ _01868_ VDD
+ VSS OAI221_X1
X_24839_ _01718_ _01696_ _01697_ _01869_ VDD VSS NOR3_X4
X_24840_ _01750_ _01862_ _01869_ _01870_ VDD VSS OAI21_X1
X_24841_ net825 _01754_ _01755_ _01871_ VDD VSS NOR3_X2
X_24842_ _01815_ _01684_ _01689_ _01872_ VDD VSS AOI21_X4
X_24843_ _01787_ _01871_ _01872_ _01873_ VDD VSS OAI21_X1
X_24844_ _01651_ _01870_ _01873_ _01874_ VDD VSS NAND3_X1
X_24845_ _01771_ net108 _01744_ _01875_ VDD VSS MUX2_X1
X_24846_ _01799_ _01745_ _01844_ _01875_ _01772_ _01876_ VDD
+ VSS OAI221_X1
X_24847_ _01739_ _01874_ _01876_ _01877_ VDD VSS NAND3_X1
X_24848_ _01861_ _01877_ _01868_ _01878_ VDD VSS AND3_X2
X_24849_ _01826_ _01638_ _01879_ VDD VSS NOR2_X1
X_24850_ _01602_ _01880_ VDD VSS INV_X1
X_24851_ _06466_ _11207_ _01881_ VDD VSS NAND2_X1
X_24852_ _01590_ _11207_ _01882_ VDD VSS NAND2_X1
X_24853_ _01881_ _01882_ _01598_ _01883_ VDD VSS MUX2_X1
X_24854_ _01635_ _01880_ _01883_ _01884_ VDD VSS AOI21_X2
X_24855_ _01713_ _01879_ _01884_ _01885_ VDD VSS OR3_X1
X_24856_ _01768_ _01716_ _01885_ _01886_ VDD VSS AOI21_X1
X_24857_ _15104_ _01638_ _01887_ VDD VSS NAND2_X1
X_24858_ _01702_ _01708_ _01888_ VDD VSS NOR2_X2
X_24859_ _01698_ _01888_ _01887_ _01703_ _15118_ _01889_ VDD
+ VSS AOI221_X2
X_24860_ _01889_ _01886_ _01797_ _01890_ VDD VSS OR3_X2
X_24861_ _01838_ _01816_ _01840_ _01891_ VDD VSS NAND3_X1
X_24862_ _15097_ _01696_ _01697_ _01892_ VDD VSS NOR3_X4
X_24863_ _01637_ _01723_ _01892_ _01893_ VDD VSS OAI21_X1
X_24864_ _01891_ _01893_ _01894_ VDD VSS NAND2_X1
X_24865_ _15097_ _01793_ _01895_ VDD VSS NAND2_X2
X_24866_ _01741_ _01700_ net1070 _01896_ VDD VSS AOI21_X1
X_24867_ _01750_ _01897_ VDD VSS CLKBUF_X3
X_24868_ net1070 _01895_ _01896_ _01897_ _01898_ VDD VSS OAI22_X1
X_24869_ _01890_ _01894_ _01800_ _01898_ _01764_ _01899_ VDD
+ VSS OAI221_X2
X_24870_ _15102_ _01900_ VDD VSS INV_X2
X_24871_ _01900_ _01696_ _01697_ _01901_ VDD VSS NOR3_X2
X_24872_ _01638_ _01862_ _01901_ _01902_ VDD VSS OAI21_X1
X_24873_ _01763_ _01892_ _01635_ _01903_ VDD VSS AOI21_X1
X_24874_ _01635_ _01892_ _01872_ _01904_ VDD VSS NOR3_X1
X_24875_ _01869_ _01744_ _01604_ _01905_ VDD VSS AOI21_X1
X_24876_ _01904_ _01905_ _01743_ _01906_ VDD VSS AOI21_X1
X_24877_ _01703_ _01902_ _01903_ _01906_ _01799_ _01907_ VDD
+ VSS AOI221_X1
X_24878_ _01636_ _01839_ _01840_ _01908_ VDD VSS NAND3_X2
X_24879_ _01753_ _01685_ _01690_ _01909_ VDD VSS NAND3_X2
X_24880_ _01909_ _01699_ _01784_ _01910_ VDD VSS OAI21_X1
X_24881_ _01908_ _01910_ _01772_ _01911_ VDD VSS OAI21_X1
X_24882_ _01719_ _01844_ _01720_ _01912_ VDD VSS NOR3_X4
X_24883_ _01636_ _01862_ _01912_ _01913_ VDD VSS NOR3_X2
X_24884_ _15102_ _01719_ _01720_ _01914_ VDD VSS OAI21_X4
X_24885_ _01909_ _01914_ _01915_ VDD VSS NAND2_X1
X_24886_ _01913_ _01915_ _01772_ _01916_ VDD VSS AOI21_X1
X_24887_ _01800_ _01911_ _01853_ _01916_ _01917_ VDD VSS OAI22_X1
X_24888_ _01917_ _01907_ _01735_ _01918_ VDD VSS OR3_X2
X_24889_ _01772_ _01741_ _01869_ _01919_ VDD VSS OAI21_X1
X_24890_ _01750_ _01839_ _01914_ _01920_ VDD VSS NAND3_X1
X_24891_ _01837_ _01919_ _01920_ _01921_ VDD VSS AND3_X1
X_24892_ _01759_ _15102_ _01638_ _01922_ VDD VSS MUX2_X1
X_24893_ _01922_ _01768_ _01923_ VDD VSS NOR2_X2
X_24894_ _15114_ _01799_ _01793_ _01924_ VDD VSS NOR3_X1
X_24895_ _01739_ _01923_ _01924_ _01925_ VDD VSS NOR3_X1
X_24896_ _01763_ _01713_ _01926_ VDD VSS NOR2_X2
X_24897_ _01604_ _01792_ _01927_ VDD VSS XNOR2_X1
X_24898_ _01637_ _01926_ _01927_ _01928_ VDD VSS AND3_X1
X_24899_ _01921_ _01925_ _01928_ _01929_ VDD VSS NOR3_X1
X_24900_ _01892_ _01872_ _01930_ VDD VSS NOR2_X1
X_24901_ _01807_ _01856_ _01930_ _01931_ VDD VSS AOI21_X1
X_24902_ _01808_ _01929_ _01931_ _01932_ VDD VSS AOI21_X1
X_24903_ _01878_ _01899_ _01662_ _01932_ _01918_ _00105_ VDD
+ VSS AOI221_X2
X_24904_ _01791_ net825 _01651_ _01933_ VDD VSS NAND3_X1
X_24905_ _01823_ _01933_ _01934_ VDD VSS NAND2_X1
X_24906_ _01751_ net827 _01651_ _01935_ VDD VSS MUX2_X1
X_24907_ _01934_ _01935_ _01838_ _01797_ _01790_ _01936_ VDD
+ VSS AOI221_X2
X_24908_ _15114_ _01797_ _01937_ VDD VSS NOR2_X1
X_24909_ _01937_ _01798_ _15111_ _01938_ VDD VSS AOI21_X1
X_24910_ _01729_ _01938_ _01801_ _01939_ VDD VSS OAI21_X1
X_24911_ _01862_ _01699_ _01718_ _01940_ VDD VSS AOI21_X2
X_24912_ _01759_ _01941_ VDD VSS INV_X1
X_24913_ _01941_ net827 _01792_ _01942_ VDD VSS MUX2_X1
X_24914_ _01940_ _01942_ _01838_ _01943_ VDD VSS MUX2_X1
X_24915_ net827 _01792_ _01803_ _01944_ VDD VSS NOR3_X1
X_24916_ _01635_ _01792_ _01604_ _01945_ VDD VSS MUX2_X1
X_24917_ _01944_ _01884_ _01865_ _01789_ _01945_ _01946_ VDD
+ VSS AOI221_X1
X_24918_ _01943_ _01946_ _01798_ _01947_ VDD VSS MUX2_X1
X_24919_ _01861_ _01936_ _01939_ _01947_ _01729_ _01948_ VDD
+ VSS OAI221_X2
X_24920_ _01839_ _01700_ _01809_ _01949_ VDD VSS OAI21_X1
X_24921_ _01844_ _01685_ _01690_ _01950_ VDD VSS NAND3_X4
X_24922_ _01950_ _01700_ _01791_ _01951_ VDD VSS OAI21_X1
X_24923_ _01949_ _01951_ _01842_ _01952_ VDD VSS MUX2_X1
X_24924_ _01950_ _01700_ _01826_ _01953_ VDD VSS OAI21_X1
X_24925_ _01813_ _01823_ _01809_ _01954_ VDD VSS OAI21_X1
X_24926_ _01953_ _01954_ _01838_ _01955_ VDD VSS MUX2_X1
X_24927_ _01837_ _01952_ _01955_ _01926_ _01956_ VDD VSS AOI22_X1
X_24928_ _01746_ _01684_ _01689_ _01957_ VDD VSS NAND3_X2
X_24929_ _01840_ _01957_ _01958_ VDD VSS AND2_X1
X_24930_ _01841_ _01958_ _01897_ _01959_ VDD VSS OAI21_X1
X_24931_ _01743_ _01744_ _01604_ _01960_ VDD VSS AOI21_X2
X_24932_ _01879_ _01957_ _01960_ _01961_ VDD VSS AOI21_X1
X_24933_ _01959_ _01961_ _01652_ _01962_ VDD VSS MUX2_X1
X_24934_ _01956_ _01962_ _01740_ _01963_ VDD VSS OAI21_X1
X_24935_ _01807_ _01661_ _01964_ VDD VSS NAND2_X2
X_24936_ _01661_ _01965_ VDD VSS BUF_X4
X_24937_ net827 _01639_ _01966_ VDD VSS NAND2_X1
X_24938_ _01966_ _01755_ _01754_ _01714_ _01750_ _01967_ VDD
+ VSS OAI221_X2
X_24939_ _01799_ _01793_ _15120_ _01968_ VDD VSS AOI21_X1
X_24940_ _01638_ _01719_ _01720_ _01969_ VDD VSS NOR3_X4
X_24941_ _01753_ _01815_ _01970_ VDD VSS NAND2_X2
X_24942_ _01970_ _01690_ _01685_ _01971_ VDD VSS AOI21_X4
X_24943_ _01759_ _01969_ _01971_ _01639_ _01972_ VDD VSS AOI22_X1
X_24944_ _01781_ _01782_ _01973_ VDD VSS NOR2_X1
X_24945_ _01972_ _01973_ _01900_ _01974_ VDD VSS OAI21_X1
X_24946_ _01830_ _01967_ _01968_ _01974_ _01797_ _01975_ VDD
+ VSS AOI221_X2
X_24947_ _01651_ _01781_ _01826_ _01940_ _01640_ _01976_ VDD
+ VSS AOI221_X2
X_24948_ _01768_ _01977_ VDD VSS CLKBUF_X3
X_24949_ _15109_ _01977_ _01978_ VDD VSS NAND2_X1
X_24950_ _01751_ _01969_ _01979_ VDD VSS NAND2_X1
X_24951_ _01798_ _01978_ _01979_ _01980_ VDD VSS AOI21_X1
X_24952_ _01740_ _01976_ _01980_ _01981_ VDD VSS NOR3_X1
X_24953_ _01965_ _01975_ _01981_ _01982_ VDD VSS NOR3_X1
X_24954_ _01637_ _01865_ _01786_ _01983_ VDD VSS AOI21_X1
X_24955_ _01725_ _01791_ _01793_ _01984_ VDD VSS MUX2_X1
X_24956_ _01787_ _01985_ VDD VSS BUF_X4
X_24957_ _01983_ _01984_ _01985_ _01986_ VDD VSS AOI21_X1
X_24958_ _15106_ _01752_ _01914_ _01987_ VDD VSS AOI21_X1
X_24959_ _01848_ _01722_ _15104_ _01988_ VDD VSS OAI21_X1
X_24960_ _01965_ _01800_ _01986_ _01987_ _01988_ _01989_ VDD
+ VSS OAI221_X1
X_24961_ _01799_ _01704_ _01990_ VDD VSS NOR2_X1
X_24962_ _01823_ _01884_ _01991_ VDD VSS OR2_X1
X_24963_ _01990_ _01991_ _01708_ _01715_ _01701_ _01992_ VDD
+ VSS OAI221_X1
X_24964_ _01842_ _01850_ _01950_ _01993_ VDD VSS AND3_X1
X_24965_ _01826_ _01754_ _01755_ _01994_ VDD VSS NOR3_X1
X_24966_ _01994_ _01977_ net1070 _01995_ VDD VSS AOI21_X1
X_24967_ _01993_ _01995_ _15106_ _01996_ VDD VSS AOI21_X1
X_24968_ _01992_ _01996_ _01853_ _01997_ VDD VSS OAI21_X1
X_24969_ _01735_ _01989_ _01997_ _01998_ VDD VSS OAI21_X1
X_24970_ _01948_ _01963_ _01964_ _01982_ _01998_ _00106_ VDD
+ VSS OAI221_X2
X_24971_ _01807_ _01808_ _01999_ VDD VSS NOR2_X1
X_24972_ _01652_ _01830_ _02000_ VDD VSS NAND2_X2
X_24973_ _01789_ _01754_ _01755_ _02001_ VDD VSS NOR3_X4
X_24974_ _01985_ _01971_ _02001_ _02002_ VDD VSS NOR3_X1
X_24975_ _15104_ _01768_ _02003_ VDD VSS NAND2_X1
X_24976_ _01897_ _01895_ _02003_ _02004_ VDD VSS AOI21_X2
X_24977_ _01747_ _01783_ _02005_ VDD VSS NOR2_X1
X_24978_ _15097_ _01782_ _02006_ VDD VSS AND2_X1
X_24979_ _02000_ _02002_ _02004_ _02005_ _02006_ _01764_ _02007_
+ VDD VSS OAI33_X1
X_24980_ _01725_ _01769_ _02008_ VDD VSS NAND2_X1
X_24981_ _01791_ _01651_ _01700_ _02009_ VDD VSS NAND3_X1
X_24982_ _01985_ _02008_ _02009_ _02010_ VDD VSS AOI21_X1
X_24983_ _01759_ _01797_ _01758_ _02011_ VDD VSS NOR3_X1
X_24984_ _01838_ _01799_ _01700_ _02012_ VDD VSS NAND3_X1
X_24985_ _01637_ _01651_ _01823_ _02013_ VDD VSS NAND3_X1
X_24986_ _01789_ _02012_ _02013_ _02014_ VDD VSS AOI21_X1
X_24987_ _01729_ _02010_ _02011_ _02014_ _02015_ VDD VSS NOR4_X1
X_24988_ _01999_ _02007_ _02015_ _02016_ VDD VSS OAI21_X1
X_24989_ _01663_ _01740_ _01803_ _02017_ VDD VSS AOI21_X1
X_24990_ _01823_ _01704_ _01791_ _15097_ _01838_ _02018_ VDD
+ VSS AOI221_X2
X_24991_ _15106_ _01729_ _15086_ _02019_ VDD VSS AOI21_X1
X_24992_ _02018_ _02019_ net109 _02020_ VDD VSS OAI21_X1
X_24993_ _01897_ _01739_ _02021_ VDD VSS XNOR2_X1
X_24994_ _01635_ _01670_ _01674_ _02022_ VDD VSS OAI21_X2
X_24995_ _01801_ _02021_ _01789_ _02022_ net1070 _02023_ VDD
+ VSS OAI221_X1
X_24996_ _02017_ _02020_ _02023_ _02024_ VDD VSS NAND3_X1
X_24997_ _01743_ _01651_ _01957_ _02025_ VDD VSS AND3_X1
X_24998_ _01799_ _02001_ _02026_ VDD VSS NOR2_X1
X_24999_ _01728_ _02003_ _02025_ _02026_ _01960_ _02027_ VDD
+ VSS AOI221_X2
X_25000_ net840 _01941_ _01636_ _02028_ VDD VSS MUX2_X1
X_25001_ _01804_ _02028_ _01724_ _02029_ VDD VSS MUX2_X1
X_25002_ _02027_ _02029_ _01732_ _02030_ VDD VSS OAI21_X2
X_25003_ _01803_ _15086_ net827 _02031_ VDD VSS AOI21_X1
X_25004_ _01990_ _02031_ _01769_ _01745_ _01714_ _02032_ VDD
+ VSS OAI221_X1
X_25005_ _01774_ _01754_ _01755_ _02033_ VDD VSS NOR3_X4
X_25006_ _02033_ _01741_ _01639_ _02034_ VDD VSS NOR3_X2
X_25007_ _01771_ _01685_ _01690_ _02035_ VDD VSS NAND3_X1
X_25008_ _01636_ _01820_ _02035_ _02036_ VDD VSS AOI21_X1
X_25009_ _02034_ _01764_ _02036_ _02037_ VDD VSS OR3_X2
X_25010_ _01861_ _02032_ _02037_ _02038_ VDD VSS AND3_X4
X_25011_ _01718_ _01685_ _01690_ _02039_ VDD VSS AOI21_X2
X_25012_ _01759_ _01754_ _01755_ _02040_ VDD VSS NOR3_X1
X_25013_ _01842_ _02039_ _02040_ _02041_ VDD VSS NOR3_X1
X_25014_ _01897_ _01871_ _01862_ _02042_ VDD VSS NOR3_X1
X_25015_ _01705_ _02041_ _02042_ _02043_ VDD VSS OAI21_X1
X_25016_ _01897_ _01786_ _01845_ _02044_ VDD VSS NAND3_X1
X_25017_ _01872_ _01724_ net1070 _02045_ VDD VSS AOI21_X1
X_25018_ _02044_ _02045_ _15106_ _02046_ VDD VSS OAI21_X1
X_25019_ _02043_ _02046_ _01740_ _02047_ VDD VSS OAI21_X1
X_25020_ _02038_ _02030_ _02047_ _01738_ _02048_ VDD VSS AOI22_X4
X_25021_ _01964_ _02049_ VDD VSS INV_X1
X_25022_ _15086_ _01897_ _01794_ _02050_ VDD VSS AOI21_X1
X_25023_ _01718_ _01722_ _01758_ net109 _02051_ VDD VSS OAI22_X1
X_25024_ _01652_ _02050_ _02051_ _02052_ VDD VSS NOR3_X1
X_25025_ _01746_ _01743_ _02053_ VDD VSS NAND2_X2
X_25026_ _01639_ _01970_ _02054_ VDD VSS NAND2_X1
X_25027_ _01699_ _02053_ _02054_ _02055_ VDD VSS AOI21_X1
X_25028_ _01797_ _01923_ _02055_ _02056_ VDD VSS NOR3_X1
X_25029_ _01705_ _02056_ _02057_ VDD VSS OR2_X2
X_25030_ _01750_ _01799_ _01723_ _01793_ _01844_ _02058_ VDD
+ VSS AOI221_X2
X_25031_ _01985_ _01652_ _01892_ _02059_ VDD VSS AOI21_X1
X_25032_ _01746_ _01719_ _01720_ _02060_ VDD VSS OAI21_X1
X_25033_ _01786_ _02060_ _02061_ VDD VSS AND2_X4
X_25034_ _01798_ _02061_ _02062_ VDD VSS NAND2_X1
X_25035_ _02058_ _02059_ _02062_ _02063_ VDD VSS AOI21_X1
X_25036_ _02049_ _02057_ _02052_ _02063_ _01729_ _02064_ VDD
+ VSS OAI221_X2
X_25037_ _02048_ _02024_ _02016_ _02064_ _00107_ VDD VSS AND4_X4
X_25038_ _01809_ _01704_ _02065_ VDD VSS NAND2_X1
X_25039_ _01950_ _01850_ _01713_ _02066_ VDD VSS NAND3_X4
X_25040_ _01772_ _02066_ _02065_ _02067_ VDD VSS AOI21_X4
X_25041_ _01826_ _01744_ _01713_ _02068_ VDD VSS NOR3_X1
X_25042_ _01744_ _01703_ _02069_ VDD VSS XNOR2_X1
X_25043_ _01792_ _01703_ _02070_ VDD VSS NOR2_X1
X_25044_ _02068_ _02069_ net840 _01747_ _02070_ _02071_ VDD
+ VSS AOI221_X2
X_25045_ _02067_ _01652_ _02071_ _01985_ _02072_ VDD VSS AOI211_X2
X_25046_ _01787_ _01816_ _01850_ _02073_ VDD VSS AOI21_X1
X_25047_ _01950_ _01792_ net827 _02074_ VDD VSS OAI21_X2
X_25048_ _02073_ _02074_ _01985_ _02075_ VDD VSS AOI21_X1
X_25049_ _01769_ _01715_ _02076_ VDD VSS NOR2_X1
X_25050_ _01639_ _01880_ _01883_ _02077_ VDD VSS AOI21_X2
X_25051_ _02077_ _01897_ _01784_ _02078_ VDD VSS AOI21_X1
X_25052_ _02076_ _02078_ _01977_ _02079_ VDD VSS AOI21_X1
X_25053_ _01808_ _01853_ _02075_ _02079_ _02000_ _02080_ VDD
+ VSS OAI221_X2
X_25054_ _01700_ _01765_ _01824_ _02081_ VDD VSS NAND3_X1
X_25055_ _02081_ _01804_ _01724_ _02082_ VDD VSS OAI21_X1
X_25056_ _01901_ _01708_ _01977_ _02083_ VDD VSS AOI21_X1
X_25057_ _01965_ _02000_ _02082_ _02083_ _01764_ _02084_ VDD
+ VSS OAI221_X2
X_25058_ _01604_ _15097_ _01768_ _02085_ VDD VSS MUX2_X1
X_25059_ _01926_ _02085_ _01637_ _01895_ _15087_ _02086_ VDD
+ VSS OAI221_X2
X_25060_ _01854_ _01823_ net1072 _02087_ VDD VSS AOI21_X1
X_25061_ _01837_ _02087_ _01985_ _02088_ VDD VSS OAI21_X1
X_25062_ _01809_ _01781_ _02086_ _02088_ _02089_ VDD VSS AOI22_X2
X_25063_ _02080_ _02072_ _02084_ _02089_ _02090_ VDD VSS OAI22_X2
X_25064_ _01599_ _01602_ _01670_ _01674_ _02091_ VDD VSS OAI22_X2
X_25065_ _01823_ _01728_ _01765_ _02091_ _01637_ _02092_ VDD
+ VSS OAI221_X1
X_25066_ _01823_ _01803_ _02093_ VDD VSS OR2_X1
X_25067_ _01791_ _15086_ _02022_ _02094_ VDD VSS AOI21_X1
X_25068_ _02092_ _02093_ _02094_ _02095_ VDD VSS OAI21_X1
X_25069_ _01842_ _01728_ _02096_ VDD VSS NOR2_X1
X_25070_ net109 _01814_ _02096_ _02097_ VDD VSS OAI21_X1
X_25071_ _01965_ _02095_ _02097_ _02098_ VDD VSS AOI21_X1
X_25072_ net1071 _01758_ _01892_ _01787_ _02099_ VDD VSS OAI22_X1
X_25073_ _01661_ _01739_ _02099_ _02100_ VDD VSS OAI21_X1
X_25074_ _01838_ _01872_ _01869_ _02101_ VDD VSS OAI21_X1
X_25075_ _02101_ _01927_ _01897_ _02102_ VDD VSS OAI21_X1
X_25076_ _02100_ _02102_ _01705_ _02103_ VDD VSS AOI21_X1
X_25077_ _01637_ _01786_ _01813_ _02104_ VDD VSS NAND3_X1
X_25078_ _01816_ _01914_ _02105_ VDD VSS NAND2_X1
X_25079_ _02104_ _02105_ _01842_ _02106_ VDD VSS OAI21_X1
X_25080_ _01808_ _01705_ _02106_ _02107_ VDD VSS NOR3_X1
X_25081_ _01636_ _01792_ _01603_ _02108_ VDD VSS OAI21_X1
X_25082_ _02108_ _01700_ _01718_ _02109_ VDD VSS AOI21_X1
X_25083_ _01704_ _01803_ _02110_ VDD VSS NOR2_X1
X_25084_ _01736_ _02110_ _02111_ VDD VSS NAND2_X1
X_25085_ _01661_ _01739_ _01915_ _02112_ VDD VSS NAND3_X1
X_25086_ _01798_ _02109_ _02111_ _02112_ _15106_ _02113_ VDD
+ VSS OAI221_X1
X_25087_ _01736_ _01703_ _02114_ VDD VSS NAND2_X1
X_25088_ _02114_ _01909_ _01639_ _01809_ _01768_ _02115_ VDD
+ VSS AOI221_X2
X_25089_ _01798_ _02098_ _02103_ _02107_ _02113_ _02115_ _02116_
+ VDD VSS OAI33_X1
X_25090_ _02090_ _02116_ _01807_ _00108_ VDD VSS MUX2_X1
X_25091_ _01735_ _01786_ _01840_ _02117_ VDD VSS NAND3_X1
X_25092_ _01900_ _01807_ _01701_ _02118_ VDD VSS NAND3_X1
X_25093_ _15113_ _02117_ _02118_ _02119_ VDD VSS AOI21_X1
X_25094_ _15113_ _01820_ _01950_ _02120_ VDD VSS NAND3_X1
X_25095_ _01965_ _02120_ _02121_ VDD VSS NAND2_X1
X_25096_ _01789_ _01725_ _01792_ _02122_ VDD VSS MUX2_X1
X_25097_ _01656_ _01782_ _01791_ _02122_ _01842_ _02123_ VDD
+ VSS AOI221_X2
X_25098_ _15106_ _01801_ _01815_ _02124_ VDD VSS OAI21_X1
X_25099_ _01850_ _02124_ _02125_ VDD VSS NAND2_X1
X_25100_ _02123_ _02125_ _01807_ _02126_ VDD VSS AOI21_X1
X_25101_ _01926_ _02119_ _02121_ _02126_ _01965_ _02127_ VDD
+ VSS OAI221_X1
X_25102_ _01750_ _02061_ _02128_ VDD VSS NAND2_X1
X_25103_ _01734_ _01723_ _01636_ _02129_ VDD VSS AOI21_X1
X_25104_ _01636_ _01912_ _02039_ _02130_ VDD VSS OAI21_X1
X_25105_ _02130_ _01721_ _01789_ _02131_ VDD VSS OAI21_X1
X_25106_ _01661_ _02128_ _02129_ _02131_ _01734_ _02132_ VDD
+ VSS AOI221_X1
X_25107_ _01771_ _01782_ _02133_ VDD VSS NAND2_X1
X_25108_ _01734_ _01820_ _02134_ VDD VSS AND2_X1
X_25109_ _01900_ _01721_ _01758_ _01826_ _02135_ VDD VSS OAI22_X1
X_25110_ _02135_ _01783_ _15086_ _02136_ VDD VSS AOI21_X1
X_25111_ _01736_ _02133_ _02134_ _02136_ _01656_ _02137_ VDD
+ VSS AOI221_X1
X_25112_ _02000_ _02132_ _02137_ _02138_ VDD VSS OR3_X2
X_25113_ _01844_ _01637_ _02139_ VDD VSS NAND2_X1
X_25114_ _01728_ _01969_ _01826_ _02139_ _01769_ _02140_ VDD
+ VSS AOI221_X1
X_25115_ _15106_ _01901_ _01971_ _02141_ VDD VSS OAI21_X1
X_25116_ _01705_ _01979_ _02141_ _02142_ VDD VSS AOI21_X1
X_25117_ _01965_ _02140_ _02142_ _02143_ VDD VSS OAI21_X1
X_25118_ _15113_ _01892_ _02144_ VDD VSS NAND2_X1
X_25119_ _01724_ _01830_ _01922_ _02145_ VDD VSS NOR3_X1
X_25120_ _01871_ _02091_ _02146_ VDD VSS NOR2_X1
X_25121_ _02145_ _02146_ _02147_ VDD VSS NOR2_X1
X_25122_ net1070 _02022_ _02148_ VDD VSS NOR2_X1
X_25123_ net109 _15086_ _01728_ _02149_ VDD VSS NOR3_X1
X_25124_ _01701_ _02148_ _02149_ _02150_ VDD VSS OAI21_X1
X_25125_ _01808_ _02144_ _02147_ _02150_ _02151_ VDD VSS NAND4_X1
X_25126_ _01798_ _01735_ _02143_ _02151_ _02152_ VDD VSS NAND4_X1
X_25127_ _01768_ _02053_ _02153_ VDD VSS NOR2_X1
X_25128_ _01757_ _01872_ _02114_ _02153_ _02154_ VDD VSS NOR4_X2
X_25129_ _15097_ _01782_ _02155_ VDD VSS NAND2_X1
X_25130_ net825 _01768_ net108 _02156_ VDD VSS OAI21_X1
X_25131_ _01736_ _01711_ _01712_ _02155_ _02156_ _02157_ VDD
+ VSS AOI221_X2
X_25132_ _02154_ _01735_ _01732_ _02157_ _02158_ VDD VSS NOR4_X2
X_25133_ _01844_ _01815_ _01640_ _02159_ VDD VSS MUX2_X1
X_25134_ _01832_ _02159_ _01701_ _01670_ _01674_ _02160_ VDD
+ VSS OAI221_X1
X_25135_ _01862_ _01701_ net109 _02161_ VDD VSS AOI21_X1
X_25136_ _01957_ _01701_ _01751_ _02162_ VDD VSS OAI21_X1
X_25137_ _02161_ _02162_ _15113_ _02163_ VDD VSS MUX2_X1
X_25138_ _01965_ _01740_ _02164_ VDD VSS NAND2_X1
X_25139_ _02158_ _02160_ _01965_ _02163_ _02164_ _02165_ VDD
+ VSS OAI221_X1
X_25140_ _02127_ _02138_ _02152_ _02165_ _00109_ VDD VSS NAND4_X1
X_25141_ _01734_ _01830_ _02166_ VDD VSS NOR2_X1
X_25142_ _01869_ _01769_ _01809_ _02167_ VDD VSS AOI21_X1
X_25143_ _02166_ _02167_ _01985_ _01753_ _01745_ _02168_ VDD
+ VSS OAI221_X2
X_25144_ net840 _01699_ _02169_ VDD VSS NAND2_X1
X_25145_ _01704_ _02169_ _01960_ _01742_ _01772_ _02170_ VDD
+ VSS AOI221_X2
X_25146_ _01774_ _01751_ _01635_ _02171_ VDD VSS MUX2_X1
X_25147_ _15109_ _02171_ _01793_ _02172_ VDD VSS MUX2_X1
X_25148_ _01735_ _02172_ _01830_ _02173_ VDD VSS OAI21_X2
X_25149_ _01734_ _01739_ _02174_ VDD VSS NOR2_X1
X_25150_ _02174_ _02175_ VDD VSS INV_X1
X_25151_ _15107_ _15116_ _01769_ _02176_ VDD VSS NOR3_X1
X_25152_ _15086_ _01772_ _01791_ _02177_ VDD VSS MUX2_X1
X_25153_ _02176_ _02177_ _01801_ _02178_ VDD VSS AOI21_X1
X_25154_ _02168_ _02173_ _02170_ _02175_ _02178_ _02179_ VDD
+ VSS OAI221_X1
X_25155_ _02179_ _01808_ _01798_ _02180_ VDD VSS NAND3_X1
X_25156_ _01830_ _01715_ _01724_ _02181_ VDD VSS OAI21_X1
X_25157_ _01751_ _01802_ _01638_ _02182_ VDD VSS MUX2_X1
X_25158_ _15118_ _02182_ _01793_ _02183_ VDD VSS MUX2_X1
X_25159_ _01735_ _02181_ _02183_ _01705_ _02184_ VDD VSS AOI22_X2
X_25160_ _01733_ _02022_ _02185_ VDD VSS NOR2_X1
X_25161_ _01636_ _01734_ _01703_ _02186_ VDD VSS NOR3_X1
X_25162_ _01736_ _01813_ _02185_ _02186_ _02061_ _02187_ VDD
+ VSS AOI221_X2
X_25163_ net1070 _01722_ _02188_ VDD VSS NOR2_X1
X_25164_ _01830_ _01778_ _02188_ _02189_ VDD VSS NOR3_X1
X_25165_ _01809_ _01724_ _02190_ VDD VSS NOR2_X1
X_25166_ _01941_ _01823_ _02191_ VDD VSS NOR2_X1
X_25167_ _01985_ _02190_ _02191_ _02192_ VDD VSS OAI21_X1
X_25168_ _02184_ _02187_ _02189_ _02192_ _02193_ VDD VSS AOI22_X2
X_25169_ _01977_ _01773_ _01824_ _02194_ VDD VSS NAND3_X1
X_25170_ _15104_ _01809_ _01636_ _02195_ VDD VSS MUX2_X1
X_25171_ _01701_ _02195_ _02196_ VDD VSS NAND2_X1
X_25172_ _02174_ _02194_ _02196_ _02197_ VDD VSS NAND3_X1
X_25173_ _01807_ _01830_ _02198_ VDD VSS NOR2_X1
X_25174_ _02198_ _02191_ _02108_ _01751_ _01722_ _02199_ VDD
+ VSS OAI221_X1
X_25175_ _01808_ _02197_ _02199_ _02200_ VDD VSS NAND3_X1
X_25176_ _01807_ _01705_ _02201_ VDD VSS NAND2_X1
X_25177_ _01640_ _01839_ _02060_ _02202_ VDD VSS AND3_X1
X_25178_ _02001_ _01970_ _01977_ _02203_ VDD VSS AOI21_X1
X_25179_ _02202_ _02203_ _15113_ _02204_ VDD VSS AOI21_X1
X_25180_ _01838_ _01865_ _01786_ _02205_ VDD VSS AOI21_X1
X_25181_ _01741_ _01970_ _01724_ _02206_ VDD VSS AOI21_X1
X_25182_ _02205_ _02206_ _15106_ _02207_ VDD VSS AOI21_X1
X_25183_ _01735_ _01729_ _02208_ VDD VSS NAND2_X1
X_25184_ _02201_ _02204_ _02207_ _02208_ _02209_ VDD VSS OAI22_X2
X_25185_ _01732_ _02193_ _02200_ _02209_ _02210_ VDD VSS OAI211_X2
X_25186_ net1071 _01743_ _01754_ _01755_ _02211_ VDD VSS NOR4_X2
X_25187_ _01734_ _01728_ _01833_ _02211_ _02212_ VDD VSS NOR4_X2
X_25188_ _02212_ _02185_ _01752_ _02213_ VDD VSS AOI21_X1
X_25189_ _01813_ _02212_ net1070 _02214_ VDD VSS AOI21_X1
X_25190_ _02213_ _02214_ _02215_ VDD VSS OR2_X1
X_25191_ _01793_ _02053_ _02216_ VDD VSS AND2_X1
X_25192_ _15108_ _01977_ _01966_ _02216_ _02217_ VDD VSS AOI22_X1
X_25193_ _01705_ _01722_ _01789_ _02218_ VDD VSS OAI21_X1
X_25194_ _01735_ _01740_ _02217_ _02218_ _02004_ _02219_ VDD
+ VSS OAI221_X1
X_25195_ _01801_ _01803_ _02220_ VDD VSS NAND2_X1
X_25196_ net109 _01979_ _02174_ _02220_ _02221_ VDD VSS NAND4_X1
X_25197_ _01732_ _01808_ _02222_ VDD VSS NOR2_X1
X_25198_ _02215_ _02219_ _02221_ _02222_ _02223_ VDD VSS NAND4_X1
X_25199_ _02180_ _02210_ _02223_ _00110_ VDD VSS AND3_X4
X_25200_ _01732_ _01807_ _01965_ _02224_ VDD VSS NAND3_X1
X_25201_ _02144_ _01722_ _15104_ _01789_ _01973_ _02225_ VDD
+ VSS OAI221_X1
X_25202_ _01740_ _02224_ _02225_ _02226_ VDD VSS OAI21_X1
X_25203_ _01798_ _01701_ _01771_ _01758_ _01753_ _02227_ VDD
+ VSS OAI221_X1
X_25204_ _01662_ _02227_ _02228_ VDD VSS NAND2_X1
X_25205_ _01809_ _01842_ _02229_ VDD VSS NOR2_X1
X_25206_ _01801_ _01708_ _02229_ _02230_ VDD VSS NOR3_X1
X_25207_ _02230_ _01801_ _15116_ _02231_ VDD VSS AOI21_X1
X_25208_ _02228_ _02231_ _01732_ _02232_ VDD VSS AOI21_X1
X_25209_ _01740_ _02195_ _01701_ _02233_ VDD VSS AOI21_X1
X_25210_ _01801_ _01803_ _02077_ _02234_ VDD VSS OAI21_X1
X_25211_ _02224_ _02233_ _02234_ _02235_ VDD VSS AOI21_X1
X_25212_ _02226_ _02232_ _02235_ _02236_ VDD VSS OAI21_X1
X_25213_ _01725_ _01977_ _02237_ VDD VSS NOR2_X1
X_25214_ _01990_ _02108_ _02237_ _15113_ _01718_ _02238_ VDD
+ VSS OAI221_X1
X_25215_ _01861_ _02238_ _02239_ VDD VSS AND2_X1
X_25216_ _01994_ _02177_ _01801_ _02240_ VDD VSS AOI21_X1
X_25217_ _01985_ _01820_ _02035_ _02241_ VDD VSS NAND3_X1
X_25218_ _01729_ _01870_ _02241_ _02242_ VDD VSS AND3_X1
X_25219_ _01787_ _01971_ _01700_ net827 _02243_ VDD VSS AOI211_X2
X_25220_ _02060_ _01977_ _01771_ _02244_ VDD VSS OAI21_X1
X_25221_ _02243_ _02244_ _15113_ _02245_ VDD VSS AOI21_X1
X_25222_ _02242_ _02245_ _01740_ _02246_ VDD VSS AOI21_X1
X_25223_ _02239_ _02240_ _01853_ _02246_ _01732_ _02247_ VDD
+ VSS OAI221_X2
X_25224_ _01771_ _01703_ _02248_ VDD VSS NOR2_X1
X_25225_ _15097_ _01787_ _02249_ VDD VSS NOR2_X1
X_25226_ _01651_ _01969_ _02248_ _02249_ _01691_ _02250_ VDD
+ VSS AOI221_X2
X_25227_ _01977_ _01728_ _02251_ VDD VSS NOR2_X1
X_25228_ _02251_ _02070_ net109 _02252_ VDD VSS AOI21_X1
X_25229_ _01781_ _01782_ _01729_ _02253_ VDD VSS AOI21_X1
X_25230_ _02250_ _02252_ _15086_ _02253_ net109 _02254_ VDD
+ VSS OAI221_X2
X_25231_ _01969_ _01728_ _01769_ _02255_ VDD VSS AOI21_X1
X_25232_ _02033_ _01691_ _01751_ _02256_ VDD VSS AOI21_X1
X_25233_ _02022_ _02255_ _01900_ _02256_ _15113_ _02257_ VDD
+ VSS OAI221_X1
X_25234_ _01778_ _02257_ _01732_ _02258_ VDD VSS AOI21_X1
X_25235_ _01703_ _01781_ _01747_ _02074_ _01750_ _02259_ VDD
+ VSS AOI221_X1
X_25236_ _01640_ _01839_ _01914_ _02260_ VDD VSS AOI21_X1
X_25237_ _01637_ _01854_ _02039_ _02261_ VDD VSS NOR3_X1
X_25238_ _01830_ _02260_ _02261_ _02262_ VDD VSS NOR3_X1
X_25239_ _02259_ _02262_ _02263_ VDD VSS OR2_X1
X_25240_ _01732_ _01964_ _02264_ VDD VSS NOR2_X1
X_25241_ _01789_ net822 _01792_ _02265_ VDD VSS MUX2_X1
X_25242_ _01908_ _02265_ _01842_ _02266_ VDD VSS OAI21_X1
X_25243_ _01750_ _01854_ _01872_ _02267_ VDD VSS OAI21_X1
X_25244_ _02267_ _01927_ _01897_ _02268_ VDD VSS OAI21_X1
X_25245_ _02266_ _02268_ _01797_ _02269_ VDD VSS MUX2_X1
X_25246_ _01737_ _01729_ _02270_ VDD VSS NOR2_X1
X_25247_ _02254_ _02258_ _02263_ _02264_ _02269_ _02270_ _02271_
+ VDD VSS AOI222_X2
X_25248_ _02236_ _02247_ _02271_ _00111_ VDD VSS NAND3_X1
X_25249_ _10506_ _10503_ _02272_ VDD VSS XNOR2_X2
X_25250_ net994 _02272_ _02273_ VDD VSS XNOR2_X2
X_25251_ _10453_ sa20_sub\[0\] _02274_ VDD VSS XOR2_X2
X_25252_ _02274_ net1021 _02275_ VDD VSS XNOR2_X2
X_25253_ _02275_ _02273_ _02276_ VDD VSS XNOR2_X1
X_25254_ _00470_ _02276_ _09100_ _02277_ VDD VSS MUX2_X1
X_25255_ _06470_ _02277_ _02278_ VDD VSS XOR2_X2
X_25256_ net677 _02279_ VDD VSS INV_X8
Xclone380 net523 net990 VDD VSS INV_X4
X_25258_ _02279_ _15128_ VDD VSS BUF_X32
X_25259_ sa12_sr\[0\] _02272_ _02281_ VDD VSS XNOR2_X1
X_25260_ _06456_ _09099_ _13186_ _02282_ VDD VSS NAND3_X1
X_25261_ _06456_ _08972_ _02283_ VDD VSS NOR2_X1
X_25262_ _13179_ _02283_ _02284_ VDD VSS NAND2_X1
X_25263_ _02281_ _02282_ _02284_ _02285_ VDD VSS AOI21_X1
X_25264_ net489 _02272_ _02286_ VDD VSS XOR2_X1
X_25265_ _13186_ _02283_ _02287_ VDD VSS NAND2_X1
X_25266_ _06456_ _09011_ _13179_ _02288_ VDD VSS NAND3_X1
X_25267_ _02286_ _02287_ _02288_ _02289_ VDD VSS AOI21_X1
X_25268_ _06456_ _02290_ VDD VSS INV_X1
X_25269_ _02290_ _09027_ _00471_ _02291_ VDD VSS NAND3_X1
X_25270_ _06456_ _09015_ _02292_ VDD VSS NAND2_X1
X_25271_ _02291_ _02292_ _00471_ _02293_ VDD VSS OAI21_X1
X_25272_ _02285_ _02289_ _02293_ _02294_ VDD VSS OR3_X2
X_25273_ _02294_ _02295_ VDD VSS BUF_X4
X_25274_ _02295_ _02296_ VDD VSS INV_X4
X_25275_ _02296_ _15133_ VDD VSS BUF_X4
X_25276_ net793 _10478_ _02297_ VDD VSS XOR2_X2
X_25277_ net484 _02297_ _02298_ VDD VSS XOR2_X2
X_25278_ _06482_ _09194_ _13205_ _02299_ VDD VSS NAND3_X1
X_25279_ _06482_ _09027_ _02300_ VDD VSS NOR2_X1
X_25280_ _13198_ _02300_ _02301_ VDD VSS NAND2_X1
X_25281_ _02298_ _02299_ _02301_ _02302_ VDD VSS AOI21_X2
X_25282_ net483 _02297_ _02303_ VDD VSS XNOR2_X1
X_25283_ _13205_ _02300_ _02304_ VDD VSS NAND2_X1
X_25284_ _06482_ _09074_ _13198_ _02305_ VDD VSS NAND3_X1
X_25285_ _02303_ _02304_ _02305_ _02306_ VDD VSS AOI21_X2
X_25286_ _06489_ net1086 _00472_ _02307_ VDD VSS NAND3_X1
X_25287_ _06482_ _08973_ _02308_ VDD VSS NAND2_X1
X_25288_ _02307_ _02308_ _00472_ _02309_ VDD VSS OAI21_X2
X_25289_ _02306_ _02302_ _02309_ _02310_ VDD VSS NOR3_X4
X_25290_ net954 _02311_ VDD VSS INV_X4
X_25291_ _02311_ _02312_ VDD VSS BUF_X4
X_25292_ _02312_ _02313_ VDD VSS BUF_X4
X_25293_ _02313_ _15149_ VDD VSS BUF_X4
X_25294_ _02278_ _02314_ VDD VSS BUF_X8
X_25295_ _02314_ _15123_ VDD VSS BUF_X16
X_25296_ _02310_ _02315_ VDD VSS BUF_X4
X_25297_ _02315_ _02316_ VDD VSS BUF_X4
X_25298_ _02316_ _02317_ VDD VSS BUF_X4
X_25299_ _02317_ _02318_ VDD VSS BUF_X4
X_25300_ _02318_ _02319_ VDD VSS BUF_X4
X_25301_ _02319_ _15142_ VDD VSS BUF_X4
X_25302_ _10541_ _10517_ _02320_ VDD VSS XNOR2_X2
X_25303_ _10536_ _10524_ _02321_ VDD VSS XNOR2_X1
X_25304_ _02320_ _02321_ _02322_ VDD VSS XNOR2_X1
X_25305_ text_in_r\[45\] _02322_ _09023_ _02323_ VDD VSS MUX2_X2
X_25306_ _06545_ _02323_ _02324_ VDD VSS XOR2_X2
X_25307_ _02324_ _02325_ VDD VSS BUF_X4
X_25308_ _10512_ _10506_ _02326_ VDD VSS XNOR2_X1
X_25309_ _10458_ _02326_ _02327_ VDD VSS XNOR2_X1
X_25310_ _10513_ _02327_ _02328_ VDD VSS XNOR2_X1
X_25311_ text_in_r\[47\] _02328_ _09158_ _02329_ VDD VSS MUX2_X2
X_25312_ _06567_ _02329_ _02330_ VDD VSS XOR2_X2
X_25313_ _02325_ _02330_ _02331_ VDD VSS NAND2_X1
X_25314_ _15126_ _02332_ VDD VSS INV_X2
X_25315_ text_in_r\[43\] _02333_ VDD VSS BUF_X1
X_25316_ _10535_ _10506_ _02334_ VDD VSS XNOR2_X1
X_25317_ _10475_ _10539_ _02335_ VDD VSS XNOR2_X1
X_25318_ _02334_ _02335_ _02336_ VDD VSS XNOR2_X2
X_25319_ _10554_ _10503_ _02337_ VDD VSS XNOR2_X1
X_25320_ _10479_ _02337_ _02338_ VDD VSS XNOR2_X1
X_25321_ _02336_ _02338_ _02339_ VDD VSS XNOR2_X2
X_25322_ _02333_ _02339_ _09099_ _02340_ VDD VSS MUX2_X2
X_25323_ _06516_ _02340_ _02341_ VDD VSS XNOR2_X2
X_25324_ _02341_ _02342_ VDD VSS BUF_X4
X_25325_ _02342_ _02343_ VDD VSS BUF_X4
X_25326_ _02343_ _02344_ VDD VSS BUF_X4
X_25327_ _02332_ _02344_ _02345_ VDD VSS NAND2_X1
X_25328_ _15129_ _02346_ VDD VSS BUF_X4
X_25329_ _06516_ _02347_ VDD VSS INV_X1
X_25330_ _02347_ _02340_ _02348_ VDD VSS XNOR2_X2
X_25331_ _02348_ _02349_ VDD VSS BUF_X4
X_25332_ _02349_ _02350_ VDD VSS BUF_X8
X_25333_ _02346_ _02350_ _02351_ VDD VSS NAND2_X1
X_25334_ _15142_ _02345_ _02351_ _02352_ VDD VSS NAND3_X1
X_25335_ _10525_ _13229_ _02353_ VDD VSS XNOR2_X1
X_25336_ _10502_ _02353_ _02354_ VDD VSS XNOR2_X1
X_25337_ text_in_r\[46\] _02354_ net1039 _02355_ VDD VSS MUX2_X2
X_25338_ _06558_ _02355_ _02356_ VDD VSS XNOR2_X2
X_25339_ _10554_ _10506_ _02357_ VDD VSS XOR2_X2
X_25340_ _10528_ _02357_ _02358_ VDD VSS XNOR2_X2
X_25341_ _13268_ _02358_ _02359_ VDD VSS XOR2_X1
X_25342_ text_in_r\[44\] _02359_ _09075_ _02360_ VDD VSS MUX2_X2
X_25343_ _06532_ _02360_ _02361_ VDD VSS XNOR2_X2
X_25344_ _02361_ _02362_ VDD VSS BUF_X4
X_25345_ _02356_ _02362_ _02363_ VDD VSS NAND2_X2
X_25346_ _02315_ _02341_ _02364_ VDD VSS NOR2_X4
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
X_25348_ _15136_ _02366_ VDD VSS CLKBUF_X3
X_25349_ _02363_ _02364_ _02366_ _02367_ VDD VSS AOI21_X1
X_25350_ _02331_ _02352_ _02367_ _02368_ VDD VSS AOI21_X1
X_25351_ _06532_ _02360_ _02369_ VDD VSS XOR2_X2
X_25352_ _02356_ _02369_ _02370_ VDD VSS NAND2_X2
X_25353_ _15134_ _02371_ VDD VSS CLKBUF_X3
X_25354_ _02371_ _02315_ _02348_ _02372_ VDD VSS NOR3_X2
X_25355_ _02370_ _02372_ _02373_ VDD VSS OR2_X1
X_25356_ _15129_ _02374_ VDD VSS INV_X2
X_25357_ _02342_ _02375_ VDD VSS BUF_X4
X_25358_ _02375_ _02376_ VDD VSS BUF_X4
X_25359_ _02374_ _02376_ _02377_ VDD VSS NAND2_X1
X_25360_ _15126_ _02378_ VDD VSS BUF_X4
X_25361_ _02349_ _02379_ VDD VSS BUF_X4
X_25362_ _02379_ _02380_ VDD VSS CLKBUF_X3
X_25363_ _02378_ _02380_ _02381_ VDD VSS NAND2_X1
X_25364_ _02313_ _02377_ _02381_ _02382_ VDD VSS AOI21_X2
X_25365_ _02369_ _02383_ VDD VSS BUF_X4
X_25366_ _02383_ _02384_ VDD VSS BUF_X4
X_25367_ _02279_ _02350_ _02385_ VDD VSS NOR2_X2
X_25368_ _02295_ _02342_ _02386_ VDD VSS NOR2_X4
X_25369_ _15149_ _02385_ _02386_ _02387_ VDD VSS NOR3_X1
X_25370_ _02371_ _02344_ _02388_ VDD VSS NOR2_X1
X_25371_ _15125_ _02389_ VDD VSS BUF_X4
X_25372_ net947 _02390_ VDD VSS BUF_X4
X_25373_ _02350_ _02391_ VDD VSS BUF_X4
X_25374_ _02390_ _02391_ _02392_ VDD VSS NOR2_X1
X_25375_ _15142_ _02388_ _02392_ _02393_ VDD VSS NOR3_X1
X_25376_ _02384_ _02387_ _02393_ _02394_ VDD VSS NOR3_X1
X_25377_ _06558_ _02355_ _02395_ VDD VSS XOR2_X2
X_25378_ _02395_ _02396_ VDD VSS BUF_X4
X_25379_ _02396_ _02397_ VDD VSS BUF_X4
Xsplit181 _15242_ net181 VDD VSS CLKBUF_X2
X_25381_ _15131_ _02399_ VDD VSS BUF_X4
X_25382_ _02391_ _02400_ VDD VSS CLKBUF_X3
X_25383_ _02378_ _02399_ _02400_ _02401_ VDD VSS MUX2_X1
X_25384_ _02311_ _02402_ VDD VSS BUF_X4
X_25385_ _02341_ _02403_ VDD VSS BUF_X4
X_25386_ _02402_ _02403_ _02404_ VDD VSS NAND2_X4
X_25387_ _15124_ _02405_ VDD VSS CLKBUF_X3
X_25388_ _02405_ _02406_ VDD VSS INV_X2
X_25389_ _02406_ _02407_ VDD VSS BUF_X4
X_25390_ _02384_ _02401_ _15149_ _02404_ _02407_ _02408_ VDD
+ VSS OAI221_X1
X_25391_ _02397_ _02408_ _02409_ VDD VSS NAND2_X1
X_25392_ _02368_ _02373_ _02382_ _02394_ _02409_ _02410_ VDD
+ VSS OAI221_X2
X_25393_ _02343_ _02411_ VDD VSS BUF_X4
X_25394_ _02390_ _02366_ _02411_ _02412_ VDD VSS MUX2_X1
X_25395_ _02397_ _02404_ _02399_ _02412_ _15149_ _02413_ VDD
+ VSS OAI221_X1
X_25396_ _02356_ _02414_ VDD VSS BUF_X4
X_25397_ _02379_ _02415_ VDD VSS BUF_X4
X_25398_ _02415_ _02416_ VDD VSS BUF_X4
X_25399_ _15147_ _02416_ _02417_ VDD VSS AND2_X1
X_25400_ net947 _02311_ _02418_ VDD VSS NAND2_X2
X_25401_ _02350_ _02418_ _02419_ VDD VSS NOR2_X2
X_25402_ _02414_ _02417_ _02419_ _02420_ VDD VSS OAI21_X1
X_25403_ _02384_ _02413_ _02420_ _02421_ VDD VSS NAND3_X1
X_25404_ _15131_ _02422_ VDD VSS INV_X2
X_25405_ _02422_ _02346_ _02315_ _02423_ VDD VSS MUX2_X1
X_25406_ _02415_ _02423_ _02424_ VDD VSS OR2_X4
X_25407_ _02295_ _02315_ _02425_ VDD VSS NOR2_X2
X_25408_ _02312_ _02426_ VDD VSS CLKBUF_X3
X_25409_ _02426_ _02427_ VDD VSS CLKBUF_X3
X_25410_ _02405_ _02427_ _02428_ VDD VSS NOR2_X1
X_25411_ _02416_ _02425_ _02428_ _02429_ VDD VSS OAI21_X1
X_25412_ _02317_ _02379_ _02430_ VDD VSS NOR2_X2
X_25413_ _02363_ _02430_ _02378_ _02431_ VDD VSS AOI21_X1
X_25414_ _02424_ _02429_ _02431_ _02432_ VDD VSS NAND3_X1
X_25415_ _06545_ _02323_ _02433_ VDD VSS XNOR2_X2
X_25416_ _02433_ _02434_ VDD VSS CLKBUF_X3
X_25417_ _02434_ _02435_ VDD VSS CLKBUF_X3
X_25418_ _02330_ _02436_ VDD VSS BUF_X4
X_25419_ _02435_ _02436_ _02437_ VDD VSS NAND2_X1
X_25420_ _02437_ _02438_ VDD VSS INV_X1
X_25421_ _02356_ _02383_ _02439_ VDD VSS NOR2_X2
X_25422_ _02344_ _02440_ VDD VSS BUF_X4
X_25423_ _02386_ _02440_ _02399_ _02441_ VDD VSS AOI21_X1
X_25424_ _15138_ _02442_ VDD VSS CLKBUF_X3
X_25425_ _02442_ _02443_ VDD VSS BUF_X4
X_25426_ _02315_ _02348_ _02444_ VDD VSS NAND2_X2
X_25427_ _02439_ _02441_ _15142_ _02443_ _02444_ _02445_ VDD
+ VSS OAI221_X2
X_25428_ _02421_ _02432_ _02438_ _02445_ _02446_ VDD VSS NAND4_X2
X_25429_ _02325_ _02447_ VDD VSS BUF_X4
X_25430_ _02447_ _02436_ _02448_ VDD VSS NOR2_X1
X_25431_ _02356_ _02362_ _02449_ VDD VSS NOR2_X2
X_25432_ net870 _02416_ _02450_ VDD VSS NOR2_X1
X_25433_ _15142_ _02386_ _02450_ _02451_ VDD VSS NOR3_X1
Xclone3 net4 net3 VDD VSS BUF_X4
X_25435_ net680 _02453_ VDD VSS INV_X8
X_25436_ _02453_ _02343_ _02454_ VDD VSS NOR2_X4
X_25437_ _15123_ _02391_ _02455_ VDD VSS NOR2_X2
X_25438_ _15149_ _02454_ _02455_ _02456_ VDD VSS NOR3_X1
X_25439_ _02449_ _02451_ _02456_ _02457_ VDD VSS OAI21_X1
X_25440_ net678 _02312_ _02458_ VDD VSS NAND2_X2
X_25441_ _06516_ _00991_ _02459_ VDD VSS NOR2_X1
X_25442_ net503 _02459_ _02460_ VDD VSS NAND2_X1
X_25443_ _02347_ _00991_ _02461_ VDD VSS NOR2_X1
X_25444_ _02389_ _02461_ _02462_ VDD VSS NAND2_X1
X_25445_ _02460_ _02462_ _02339_ _02463_ VDD VSS MUX2_X1
X_25446_ _02333_ _02464_ VDD VSS INV_X1
X_25447_ _02464_ _02389_ _02465_ VDD VSS NAND2_X1
X_25448_ _02347_ net1085 _02466_ VDD VSS NAND2_X1
X_25449_ _06516_ net1085 _02467_ VDD VSS NAND2_X1
X_25450_ _02333_ net503 _02468_ VDD VSS NAND2_X2
X_25451_ _02465_ _02466_ _02468_ _02467_ _02469_ VDD VSS OAI22_X2
X_25452_ _02469_ _02470_ VDD VSS INV_X2
X_25453_ net569 _02470_ _02471_ VDD VSS NAND2_X4
X_25454_ _02390_ _02317_ _02472_ VDD VSS NOR2_X1
X_25455_ net126 _02375_ _02473_ VDD VSS NAND2_X2
X_25456_ _02370_ _02471_ _02458_ _02472_ _02473_ _02474_ VDD
+ VSS AOI221_X2
X_25457_ _02383_ _02475_ VDD VSS CLKBUF_X3
X_25458_ _02279_ _02402_ _02476_ VDD VSS NAND2_X1
X_25459_ _02378_ _02402_ _02477_ VDD VSS NOR2_X2
X_25460_ _02415_ _02477_ _02478_ VDD VSS NOR2_X1
X_25461_ _02475_ _02476_ _02478_ _02479_ VDD VSS AOI21_X1
X_25462_ _02443_ _02312_ _02480_ VDD VSS NOR2_X1
X_25463_ _02380_ _02425_ _02480_ _02481_ VDD VSS OAI21_X1
X_25464_ _02395_ _02481_ _02482_ VDD VSS AND2_X1
X_25465_ _02311_ _02341_ _02483_ VDD VSS NOR2_X4
X_25466_ _02315_ _02341_ _02484_ VDD VSS XNOR2_X2
X_25467_ _02372_ _02483_ _02390_ _02484_ _02407_ _02485_ VDD
+ VSS AOI221_X2
X_25468_ _02396_ _02384_ _02486_ VDD VSS NOR2_X2
X_25469_ _02474_ _02479_ _02482_ _02485_ _02486_ _02487_ VDD
+ VSS AOI221_X2
X_25470_ _02448_ _02457_ _02487_ _02488_ VDD VSS NAND3_X2
X_25471_ _02399_ _02444_ _02489_ VDD VSS NOR2_X1
X_25472_ _02295_ _15122_ VDD VSS BUF_X4
X_25473_ _15122_ _02344_ _02490_ VDD VSS NAND2_X2
X_25474_ _15142_ _02351_ _02490_ _02491_ VDD VSS AOI21_X1
X_25475_ _02439_ _02489_ _02491_ _02492_ VDD VSS OAI21_X1
X_25476_ _15149_ _02388_ _02471_ _02493_ VDD VSS NOR3_X1
X_25477_ _02407_ _02416_ _02494_ VDD VSS NAND2_X1
X_25478_ _02442_ _02495_ VDD VSS INV_X2
X_25479_ _02495_ _02411_ _02496_ VDD VSS NAND2_X1
X_25480_ _15149_ _02494_ _02496_ _02497_ VDD VSS AND3_X1
X_25481_ _02486_ _02493_ _02497_ _02498_ VDD VSS OAI21_X1
X_25482_ _02296_ _02343_ _02499_ VDD VSS NAND2_X1
X_25483_ _02426_ _02415_ _02390_ _02500_ VDD VSS AOI21_X2
X_25484_ _02499_ _02500_ _02501_ VDD VSS AND2_X1
X_25485_ _15142_ _02450_ _02454_ _02502_ VDD VSS NOR3_X1
X_25486_ _02449_ _02501_ _02502_ _02503_ VDD VSS OAI21_X1
X_25487_ _06567_ _02329_ _02504_ VDD VSS XNOR2_X2
X_25488_ _02447_ _02504_ _02505_ VDD VSS NAND2_X1
X_25489_ _02296_ net956 _02506_ VDD VSS NAND2_X4
X_25490_ _02506_ _15133_ _15128_ _02507_ VDD VSS OAI21_X1
X_25491_ _02440_ _02507_ _02508_ VDD VSS XNOR2_X1
X_25492_ _02362_ _02509_ VDD VSS BUF_X4
X_25493_ _02396_ _02509_ _02510_ VDD VSS NOR2_X1
X_25494_ _02505_ _02508_ _02510_ _02511_ VDD VSS AOI21_X1
X_25495_ _02492_ _02498_ _02503_ _02511_ _02512_ VDD VSS NAND4_X2
X_25496_ _02410_ _02488_ _02446_ _02512_ _00112_ VDD VSS NAND4_X4
X_25497_ _02399_ _02391_ _02513_ VDD VSS NAND2_X1
X_25498_ _02426_ _02499_ _02513_ _02514_ VDD VSS NAND3_X1
X_25499_ _02406_ _02311_ _02515_ VDD VSS NOR2_X1
X_25500_ _02361_ _02403_ _02515_ _02483_ net125 _02516_ VDD
+ VSS AOI221_X2
X_25501_ _02419_ _02484_ _02295_ _02386_ net126 _02517_ VDD
+ VSS AOI221_X2
X_25502_ _02361_ _02518_ VDD VSS BUF_X4
X_25503_ _02518_ _02519_ VDD VSS BUF_X4
X_25504_ _02447_ _02514_ _02516_ _02517_ _02519_ _02520_ VDD
+ VSS AOI221_X2
X_25505_ net947 _02521_ VDD VSS INV_X4
X_25506_ _02521_ _02379_ _02522_ VDD VSS NAND2_X2
X_25507_ _02399_ _02403_ _02523_ VDD VSS NAND2_X1
X_25508_ _02427_ _02522_ _02523_ _02524_ VDD VSS AOI21_X1
X_25509_ _02509_ _02325_ _02525_ VDD VSS NAND2_X1
X_25510_ _02311_ _02349_ _02526_ VDD VSS NAND2_X2
X_25511_ _02443_ _02526_ _02527_ VDD VSS NOR2_X1
X_25512_ _02279_ _02350_ _02528_ VDD VSS NAND2_X1
X_25513_ _02313_ _02496_ _02528_ _02529_ VDD VSS AOI21_X1
X_25514_ _02384_ _02447_ _02530_ VDD VSS NAND2_X1
X_25515_ net681 _02426_ _02531_ VDD VSS NAND2_X1
X_25516_ _02440_ _02531_ _02532_ VDD VSS NOR2_X1
X_25517_ _02524_ _02525_ _02527_ _02529_ _02530_ _02532_ _02533_
+ VDD VSS OAI33_X1
X_25518_ _02414_ _02520_ _02533_ _02534_ VDD VSS OR3_X2
X_25519_ _02369_ _02433_ _02535_ VDD VSS NAND2_X1
X_25520_ _02279_ _02317_ _02536_ VDD VSS NAND2_X2
X_25521_ net592 _02316_ _02537_ VDD VSS NOR2_X2
X_25522_ _02415_ _02537_ _02538_ VDD VSS NOR2_X1
X_25523_ _15154_ _02539_ VDD VSS INV_X1
X_25524_ _02535_ _02536_ _02538_ _02416_ _02539_ _02540_ VDD
+ VSS AOI221_X2
X_25525_ _02422_ _02440_ _02541_ VDD VSS NAND2_X1
X_25526_ _02402_ _02350_ _02521_ _02542_ VDD VSS AOI21_X2
X_25527_ _02530_ _02541_ _02542_ _02543_ VDD VSS AOI21_X1
X_25528_ _02296_ _02348_ _02544_ VDD VSS NOR2_X4
X_25529_ _15149_ _02386_ _02544_ _02545_ VDD VSS OAI21_X1
X_25530_ _02540_ _02543_ _02545_ _02546_ VDD VSS AOI21_X1
X_25531_ _02361_ _02433_ _02547_ VDD VSS NAND2_X4
X_25532_ _02316_ _02548_ VDD VSS BUF_X4
X_25533_ net521 _02548_ _02549_ VDD VSS NAND2_X1
X_25534_ _02376_ _02418_ _02549_ _02550_ VDD VSS AOI21_X1
X_25535_ _02547_ _02550_ _02551_ VDD VSS NOR2_X1
X_25536_ _02346_ _02344_ _02552_ VDD VSS NOR2_X2
X_25537_ _02427_ _02552_ _02455_ _02553_ VDD VSS OAI21_X1
X_25538_ _02295_ _02391_ _02554_ VDD VSS NOR2_X2
X_25539_ _02525_ _02554_ net127 _02555_ VDD VSS AOI21_X1
X_25540_ _02396_ _02424_ _02551_ _02553_ _02555_ _02556_ VDD
+ VSS AOI221_X2
X_25541_ _02504_ _02546_ _02556_ _02557_ VDD VSS AOI21_X2
X_25542_ _02383_ _02404_ _02296_ _02522_ _02318_ _02558_ VDD
+ VSS OAI221_X2
X_25543_ _02405_ _02379_ _02559_ VDD VSS NAND2_X1
X_25544_ _02427_ _02345_ _02559_ _02560_ VDD VSS AOI21_X1
X_25545_ _02319_ _02440_ _02422_ _02561_ VDD VSS OAI21_X1
X_25546_ _02313_ _02400_ _02405_ _02562_ VDD VSS OAI21_X1
X_25547_ net678 _02342_ _02563_ VDD VSS NOR2_X2
X_25548_ _02544_ _02561_ _02562_ _02563_ _02564_ VDD VSS OAI22_X1
X_25549_ _02447_ _02558_ _02560_ _02564_ _02384_ _02565_ VDD
+ VSS OAI221_X2
X_25550_ _02442_ _02350_ _02566_ VDD VSS NAND2_X2
X_25551_ _02548_ _02376_ _02332_ _02567_ VDD VSS AOI21_X2
X_25552_ _02453_ _02403_ _02568_ VDD VSS NAND2_X1
X_25553_ _02509_ _02566_ _02567_ _02568_ _02500_ _02569_ VDD
+ VSS AOI221_X2
X_25554_ _02442_ _02375_ _02570_ VDD VSS NAND2_X1
X_25555_ _02475_ _02542_ _02570_ _02490_ _02313_ _02571_ VDD
+ VSS AOI221_X2
X_25556_ _02435_ _02569_ _02571_ _02572_ VDD VSS OAI21_X1
X_25557_ _02397_ _02565_ _02572_ _02573_ VDD VSS NAND3_X2
X_25558_ _02519_ _02440_ _15150_ _02574_ VDD VSS OAI21_X1
X_25559_ _02435_ _02574_ _02575_ VDD VSS NAND2_X1
X_25560_ _02371_ _02442_ _02317_ _02576_ VDD VSS MUX2_X2
X_25561_ _02362_ _02343_ _02577_ VDD VSS NAND2_X2
X_25562_ _02443_ _02319_ _02400_ _02578_ VDD VSS NAND3_X1
X_25563_ _02316_ _02403_ _02579_ VDD VSS NAND2_X4
X_25564_ _02578_ _02562_ _02552_ _15133_ _02579_ _02580_ VDD
+ VSS OAI221_X2
X_25565_ _02575_ _02576_ _02577_ _02580_ _02519_ _02581_ VDD
+ VSS OAI221_X2
X_25566_ _02362_ _02325_ _02582_ VDD VSS NOR2_X2
X_25567_ net678 _02403_ _02583_ VDD VSS XNOR2_X2
X_25568_ _02544_ _02561_ _02583_ _15142_ _02584_ VDD VSS OAI22_X1
X_25569_ _02397_ _02582_ _02584_ _02585_ VDD VSS AOI21_X1
X_25570_ _02436_ _02581_ _02585_ _02586_ VDD VSS AOI21_X2
X_25571_ _02534_ _02557_ _02573_ _02586_ _00113_ VDD VSS AOI22_X4
X_25572_ _02356_ _02504_ _02587_ VDD VSS NAND2_X1
X_25573_ _02587_ _02588_ VDD VSS INV_X1
X_25574_ net870 _02375_ _02589_ VDD VSS NAND2_X1
X_25575_ _02548_ _02589_ _02566_ _02590_ VDD VSS AOI21_X1
X_25576_ _02369_ _02433_ _02591_ VDD VSS NOR2_X4
X_25577_ _02591_ _02444_ net521 _02592_ VDD VSS OAI21_X1
X_25578_ _02350_ _02316_ _02279_ _02593_ VDD VSS AOI21_X1
X_25579_ _02418_ _02593_ _02594_ VDD VSS AND2_X1
X_25580_ _02383_ _02423_ _02379_ _02595_ VDD VSS AOI21_X2
X_25581_ _02434_ _02595_ _02596_ VDD VSS NAND2_X1
X_25582_ _02588_ _02590_ _02592_ _02594_ _02596_ _02597_ VDD
+ VSS OAI221_X2
X_25583_ _02402_ _02598_ VDD VSS BUF_X4
X_25584_ _02598_ _02386_ _02471_ _02599_ VDD VSS NOR3_X2
X_25585_ _02332_ _02375_ _02600_ VDD VSS NOR2_X1
X_25586_ _02318_ _02385_ _02600_ _02601_ VDD VSS NOR3_X1
X_25587_ _02599_ _02601_ _02602_ VDD VSS NOR2_X2
X_25588_ _02361_ _02433_ _02603_ VDD VSS NOR2_X4
X_25589_ _02351_ _02568_ _02604_ VDD VSS AND2_X1
X_25590_ net592 _02349_ _02605_ VDD VSS NOR2_X1
X_25591_ _02563_ _02605_ _02606_ VDD VSS NOR2_X1
X_25592_ _02604_ _02606_ _02318_ _02607_ VDD VSS MUX2_X1
X_25593_ _02597_ _02603_ _02602_ _02607_ _02582_ _02608_ VDD
+ VSS AOI221_X2
X_25594_ _02332_ _02422_ _02609_ VDD VSS NAND2_X1
X_25595_ _02372_ _02483_ _02609_ _02484_ _02495_ _02610_ VDD
+ VSS AOI221_X1
X_25596_ net125 _02406_ _02342_ _02611_ VDD VSS MUX2_X1
X_25597_ _02399_ _02364_ _02611_ _02548_ _02612_ VDD VSS AOI22_X1
X_25598_ _02610_ _02612_ _02518_ _02613_ VDD VSS MUX2_X1
X_25599_ _02346_ _02312_ _02614_ VDD VSS NAND2_X1
X_25600_ _02383_ _02614_ _02536_ _02615_ VDD VSS AND3_X1
X_25601_ _02415_ _02475_ _15145_ _02616_ VDD VSS OAI21_X1
X_25602_ _15156_ _02614_ _02362_ _02617_ VDD VSS MUX2_X1
X_25603_ _02615_ _02616_ _02617_ _02400_ _02618_ VDD VSS OAI22_X1
X_25604_ _02613_ _02618_ _02435_ _02619_ VDD VSS MUX2_X1
X_25605_ _02396_ _02504_ _02620_ VDD VSS NOR2_X1
X_25606_ _02395_ _02361_ _02621_ VDD VSS NAND2_X2
X_25607_ _02435_ _02621_ _02622_ VDD VSS NOR2_X1
X_25608_ _02318_ _02376_ _02390_ _02623_ VDD VSS OAI21_X1
X_25609_ _02521_ _02376_ _02624_ VDD VSS NOR2_X1
X_25610_ _02426_ _02380_ _02366_ _02625_ VDD VSS OAI21_X1
X_25611_ _02622_ _02623_ _02544_ _02624_ _02625_ _02626_ VDD
+ VSS OAI221_X2
X_25612_ _02366_ _02316_ _02627_ VDD VSS NAND2_X1
X_25613_ _02400_ _02531_ _02627_ _02628_ VDD VSS AOI21_X1
X_25614_ net594 _02311_ _02629_ VDD VSS NAND2_X1
X_25615_ _02411_ _02506_ _02629_ _02630_ VDD VSS AOI21_X1
X_25616_ _02384_ _02628_ _02630_ _02631_ VDD VSS OAI21_X1
X_25617_ _02475_ _02537_ _02632_ VDD VSS NOR2_X1
X_25618_ _02366_ _15128_ _02380_ _02633_ VDD VSS MUX2_X1
X_25619_ _02632_ _02633_ _02427_ _02634_ VDD VSS OAI21_X1
X_25620_ _02397_ _02435_ _02631_ _02634_ _02635_ VDD VSS NAND4_X1
X_25621_ _02317_ _02636_ VDD VSS BUF_X4
X_25622_ _15136_ _02461_ _02637_ VDD VSS NAND2_X1
X_25623_ _15136_ _02459_ _02638_ VDD VSS NAND2_X1
X_25624_ _02637_ _02638_ _02339_ _02639_ VDD VSS MUX2_X2
X_25625_ _15136_ _02640_ VDD VSS INV_X4
X_25626_ _02333_ _02640_ _02467_ _02641_ VDD VSS NOR3_X2
X_25627_ _02464_ _02640_ _02466_ _02642_ VDD VSS NOR3_X2
X_25628_ _02641_ _02642_ _02643_ VDD VSS NOR2_X4
X_25629_ _02636_ _02639_ _02643_ _02644_ VDD VSS NAND3_X1
X_25630_ _02313_ _02400_ _02453_ _02645_ VDD VSS OAI21_X1
X_25631_ _02279_ _02375_ _02646_ VDD VSS NOR2_X1
X_25632_ _02554_ _02644_ _02645_ _02646_ _02647_ VDD VSS OAI22_X1
X_25633_ _02436_ _02603_ _02647_ _02648_ VDD VSS AOI21_X1
X_25634_ _02626_ _02635_ _02648_ _02414_ _02649_ VDD VSS OAI211_X2
X_25635_ net126 _02295_ _02434_ _02650_ VDD VSS NAND3_X1
X_25636_ _02380_ _02650_ _02651_ VDD VSS NAND2_X1
X_25637_ _02346_ _02279_ _02433_ _02652_ VDD VSS MUX2_X1
X_25638_ _02651_ _02472_ _02325_ _02636_ _02652_ _02653_ VDD
+ VSS AOI221_X2
X_25639_ _15150_ _02434_ _02654_ VDD VSS NAND2_X1
X_25640_ _02654_ _02434_ _15147_ _02655_ VDD VSS OAI21_X1
X_25641_ _02519_ _02416_ _02655_ _02656_ VDD VSS OAI21_X1
X_25642_ net127 _02400_ _02506_ _02657_ VDD VSS NAND3_X1
X_25643_ _02548_ _02380_ _02279_ _02658_ VDD VSS MUX2_X1
X_25644_ _02657_ _02536_ _02386_ _02521_ _02658_ _02659_ VDD
+ VSS OAI221_X1
X_25645_ _02427_ _02388_ _02455_ _02660_ VDD VSS NOR3_X1
X_25646_ _02434_ _02611_ _02319_ _02661_ VDD VSS OAI21_X1
X_25647_ _02435_ _02659_ _02660_ _02661_ _02662_ VDD VSS OAI22_X1
X_25648_ _02436_ _02653_ _02656_ _02662_ _02519_ _02663_ VDD
+ VSS OAI221_X2
X_25649_ _02608_ _02619_ _02620_ _02649_ _02663_ _00114_ VDD
+ VSS AOI221_X2
X_25650_ _02427_ _02454_ _02554_ _02664_ VDD VSS OAI21_X1
X_25651_ _02311_ _02341_ _02521_ _02665_ VDD VSS AOI21_X2
X_25652_ _02378_ net593 _02666_ VDD VSS NOR2_X4
X_25653_ _02379_ _02666_ _02667_ VDD VSS NAND2_X1
X_25654_ _02547_ _02665_ _02667_ _02668_ VDD VSS AOI21_X1
X_25655_ _02380_ _02506_ _02669_ VDD VSS NOR2_X2
X_25656_ _02426_ _02376_ _02670_ VDD VSS XNOR2_X1
X_25657_ _02669_ _02670_ _02366_ _02671_ VDD VSS AOI21_X1
X_25658_ _02664_ _02668_ _02671_ _02591_ _02672_ VDD VSS AOI22_X1
X_25659_ _02324_ _02312_ _02371_ _02673_ VDD VSS AOI21_X1
X_25660_ _02518_ _02593_ _02673_ _02483_ _02378_ _02674_ VDD
+ VSS AOI221_X2
X_25661_ _02526_ _02579_ _02325_ _02675_ VDD VSS MUX2_X1
X_25662_ _02674_ _02675_ _02390_ _02676_ VDD VSS OAI21_X1
X_25663_ _02587_ _02672_ _02676_ _02677_ VDD VSS AOI21_X1
X_25664_ net125 _02349_ _02678_ VDD VSS NAND2_X1
X_25665_ _02316_ _02544_ _02679_ VDD VSS NOR2_X1
X_25666_ _02312_ _02375_ _02371_ _02680_ VDD VSS AOI21_X1
X_25667_ _02362_ _02678_ _02679_ _02680_ _02559_ _02681_ VDD
+ VSS AOI221_X1
X_25668_ _02426_ _02518_ _02513_ _02682_ VDD VSS NAND3_X1
X_25669_ _02455_ _02682_ _02683_ VDD VSS NOR2_X1
X_25670_ _02318_ _02518_ _02684_ VDD VSS NAND2_X1
X_25671_ _02392_ _02454_ _02684_ _02685_ VDD VSS NOR3_X1
X_25672_ _02435_ _02681_ _02683_ _02685_ _02686_ VDD VSS OR4_X1
X_25673_ _02319_ _02473_ _02522_ _02687_ VDD VSS AOI21_X1
X_25674_ _02582_ _02579_ _15133_ _02688_ VDD VSS OAI21_X1
X_25675_ _02620_ _02687_ _02688_ _02689_ VDD VSS OAI21_X1
X_25676_ _15123_ _02548_ _02690_ VDD VSS NOR2_X1
X_25677_ _02690_ _02490_ _02506_ _02385_ _02691_ VDD VSS AOI22_X1
X_25678_ _02390_ _02483_ _02692_ VDD VSS NAND2_X1
X_25679_ _02547_ _02691_ _02692_ _02693_ VDD VSS AOI21_X1
X_25680_ _02689_ _02693_ _02694_ VDD VSS NOR2_X1
X_25681_ _02506_ _02296_ net126 _02695_ VDD VSS OAI21_X1
X_25682_ _02547_ _02695_ _02341_ _02364_ net870 _02696_ VDD
+ VSS AOI221_X2
X_25683_ _02324_ _02348_ _02279_ _02697_ VDD VSS AOI21_X1
X_25684_ _02324_ _02341_ _02366_ _02698_ VDD VSS AOI21_X1
X_25685_ _02315_ _02348_ net521 _02699_ VDD VSS AOI21_X2
X_25686_ _02361_ _02665_ _02697_ _02698_ _02699_ _02700_ VDD
+ VSS AOI221_X2
X_25687_ net125 _02311_ _02701_ VDD VSS NOR2_X1
X_25688_ _02433_ _02701_ _02403_ _02702_ VDD VSS AOI21_X1
X_25689_ _02371_ _02295_ _02348_ _02703_ VDD VSS MUX2_X1
X_25690_ _02702_ _02703_ _02316_ _02528_ _02296_ _02704_ VDD
+ VSS OAI221_X2
X_25691_ _02371_ _02442_ _02342_ _02705_ VDD VSS MUX2_X1
X_25692_ _02402_ _02350_ net125 _02706_ VDD VSS OAI21_X2
X_25693_ _02374_ _02342_ _02707_ VDD VSS NOR2_X2
X_25694_ _02598_ _02705_ _02706_ _02707_ _02708_ VDD VSS OAI22_X2
X_25695_ _02696_ _02700_ _02704_ _02708_ _02591_ _02709_ VDD
+ VSS AOI221_X2
X_25696_ _15133_ _02391_ _02325_ _02710_ VDD VSS NOR3_X1
X_25697_ _02463_ _02470_ _02639_ _02643_ _02711_ VDD VSS NAND4_X4
X_25698_ _02548_ _02434_ _02711_ _02712_ VDD VSS OAI21_X2
X_25699_ _02426_ _02380_ net521 _02713_ VDD VSS OAI21_X1
X_25700_ _15122_ _02376_ _02434_ _02714_ VDD VSS NOR3_X1
X_25701_ _02475_ _02710_ _02712_ _02713_ _02714_ _02715_ VDD
+ VSS OAI221_X1
X_25702_ _02591_ _02404_ net127 _02405_ _02444_ _02716_ VDD
+ VSS OAI221_X1
X_25703_ _15122_ _02636_ _02473_ _02717_ VDD VSS AOI21_X1
X_25704_ _02598_ _02666_ _02718_ VDD VSS NOR2_X1
X_25705_ _02640_ net955 _02719_ VDD VSS NOR2_X2
X_25706_ _02415_ _02718_ _02719_ _02720_ VDD VSS OAI21_X1
X_25707_ _02720_ _02576_ _02400_ _02721_ VDD VSS OAI21_X1
X_25708_ _02715_ _02716_ _02717_ _02721_ _02547_ _02722_ VDD
+ VSS OAI221_X1
X_25709_ _02709_ _02722_ _02504_ _02723_ VDD VSS MUX2_X1
X_25710_ _02677_ _02686_ _02694_ _02723_ _02397_ _00115_ VDD
+ VSS AOI221_X2
X_25711_ _02427_ _02519_ _02583_ _02577_ net680 _02724_ VDD
+ VSS OAI221_X2
X_25712_ _02509_ _02411_ _02725_ VDD VSS NOR2_X1
X_25713_ _02407_ _15122_ _02518_ _02726_ VDD VSS MUX2_X1
X_25714_ _02399_ _02725_ _02726_ _02440_ _02727_ VDD VSS AOI22_X1
X_25715_ _02397_ _02724_ _02727_ _15149_ _02728_ VDD VSS OAI211_X2
X_25716_ _02639_ _02643_ _02729_ VDD VSS NAND2_X2
X_25717_ _02407_ _02548_ _02730_ VDD VSS NOR2_X1
X_25718_ _02475_ _02415_ _02477_ _02730_ _02731_ VDD VSS NOR4_X1
X_25719_ _15128_ _02356_ _02732_ VDD VSS NAND2_X1
X_25720_ _15142_ _02370_ _02729_ _02725_ _02731_ _02732_ _02733_
+ VDD VSS OAI33_X1
X_25721_ _15122_ _02733_ _02734_ VDD VSS NAND2_X1
X_25722_ _02414_ _02477_ _02730_ _02735_ VDD VSS OAI21_X1
X_25723_ _02577_ _02735_ _02736_ VDD VSS NOR2_X1
X_25724_ _02370_ _02458_ _02729_ _02737_ VDD VSS NOR3_X1
X_25725_ _02447_ _02736_ _02737_ _02738_ VDD VSS NOR3_X1
X_25726_ _02319_ _02519_ _02440_ _02407_ _02739_ VDD VSS AOI22_X1
X_25727_ _02384_ _02440_ _02719_ _02740_ VDD VSS OAI21_X1
X_25728_ _15133_ _02414_ _02739_ _02740_ _02741_ VDD VSS NAND4_X1
X_25729_ _02728_ _02734_ _02738_ _02741_ _02742_ VDD VSS NAND4_X1
X_25730_ _02578_ _02706_ _02386_ _02579_ _02399_ _02743_ VDD
+ VSS OAI221_X1
X_25731_ _02521_ _02636_ _02744_ VDD VSS NOR2_X1
X_25732_ _02416_ _02744_ _02745_ VDD VSS NAND2_X1
X_25733_ _02396_ _02440_ _02443_ _02746_ VDD VSS AOI21_X1
X_25734_ _02384_ _02745_ _02746_ _02747_ VDD VSS AOI21_X1
X_25735_ _02427_ _02396_ _02748_ VDD VSS NAND2_X1
X_25736_ _02748_ _02566_ _02345_ _02749_ VDD VSS AOI21_X1
X_25737_ _02621_ _02743_ _02747_ _02749_ _02750_ VDD VSS OAI22_X1
X_25738_ _15142_ _02450_ _02563_ _02751_ VDD VSS OAI21_X1
X_25739_ _02370_ _02364_ _02366_ _02752_ VDD VSS AOI21_X1
X_25740_ _02435_ _02751_ _02752_ _02753_ VDD VSS AOI21_X1
X_25741_ _02436_ _02750_ _02753_ _02754_ VDD VSS AOI21_X1
X_25742_ _02453_ net126 _02349_ _02755_ VDD VSS MUX2_X1
X_25743_ _02319_ _02755_ _02756_ VDD VSS NOR2_X1
X_25744_ _02313_ _02707_ _02605_ _02757_ VDD VSS NOR3_X1
X_25745_ _02519_ _02756_ _02757_ _02758_ VDD VSS OR3_X1
X_25746_ _02416_ _02428_ _02690_ _02759_ VDD VSS OAI21_X1
X_25747_ _02519_ _02424_ _02759_ _02760_ VDD VSS NAND3_X1
X_25748_ _02414_ _02758_ _02760_ _02761_ VDD VSS NAND3_X1
X_25749_ _02295_ _02379_ _02762_ VDD VSS NAND2_X1
X_25750_ _15128_ _02762_ _02763_ VDD VSS NOR2_X1
X_25751_ _02439_ _02484_ net127 _02764_ VDD VSS OAI21_X1
X_25752_ _02669_ _02763_ _02764_ _02765_ VDD VSS NOR3_X1
X_25753_ net678 _02316_ _02766_ VDD VSS NAND2_X1
X_25754_ _02449_ _02766_ _02767_ VDD VSS NAND2_X1
X_25755_ _02767_ _02554_ _15128_ _02405_ _02364_ _02768_ VDD
+ VSS AOI221_X2
X_25756_ _02437_ _02765_ _02768_ _02769_ VDD VSS NOR3_X1
X_25757_ _02407_ _02416_ _02770_ VDD VSS NOR2_X1
X_25758_ _02319_ _02770_ _02563_ _02771_ VDD VSS NOR3_X1
X_25759_ _02397_ _02506_ _02772_ VDD VSS NAND2_X1
X_25760_ _02604_ _02711_ _02427_ _02773_ VDD VSS MUX2_X1
X_25761_ _02519_ _02771_ _02772_ _02773_ _02397_ _02774_ VDD
+ VSS OAI221_X2
X_25762_ _02426_ _02356_ _02775_ VDD VSS XNOR2_X1
X_25763_ _02384_ _02345_ _02414_ _02775_ _02366_ _02776_ VDD
+ VSS OAI221_X1
X_25764_ _02411_ _02396_ _02422_ _02777_ VDD VSS OAI21_X1
X_25765_ _02777_ _02522_ _02396_ _02778_ VDD VSS OAI21_X1
X_25766_ _02776_ _02778_ _15149_ _02779_ VDD VSS AOI21_X1
X_25767_ _02331_ _02779_ _02780_ VDD VSS NOR2_X1
X_25768_ _02742_ _02754_ _02761_ _02769_ _02774_ _02780_ _00116_
+ VDD VSS AOI222_X2
X_25769_ _02396_ _02436_ _02781_ VDD VSS NAND2_X1
X_25770_ _02379_ _02425_ _02782_ VDD VSS NAND2_X1
X_25771_ _02402_ _02711_ _02783_ VDD VSS NOR2_X4
X_25772_ _02783_ _02369_ _02784_ VDD VSS NOR2_X2
X_25773_ _02707_ _02523_ _02317_ _02785_ VDD VSS AOI21_X1
X_25774_ _02325_ _02784_ _02782_ _02785_ _02383_ _02786_ VDD
+ VSS AOI221_X2
X_25775_ _02379_ _02477_ _02787_ VDD VSS OR2_X1
X_25776_ _02453_ _02315_ _02788_ VDD VSS NOR2_X1
X_25777_ _02788_ _02318_ _02399_ _02789_ VDD VSS AOI21_X1
X_25778_ _02509_ _02690_ _02787_ _02789_ _02411_ _02790_ VDD
+ VSS OAI221_X1
X_25779_ _02475_ _02344_ _02422_ _02404_ _02640_ _02791_ VDD
+ VSS OAI221_X1
X_25780_ _02790_ _02791_ _02382_ _02792_ VDD VSS OAI21_X1
X_25781_ _02781_ _02786_ _02792_ _02447_ _02793_ VDD VSS AOI211_X2
X_25782_ _02570_ _02667_ _02794_ VDD VSS AND2_X1
X_25783_ _02509_ _02404_ _02374_ _02794_ _02313_ _02795_ VDD
+ VSS OAI221_X1
X_25784_ _02361_ _02342_ _02629_ _02364_ _02453_ _02796_ VDD
+ VSS AOI221_X1
X_25785_ _02434_ _02796_ _02797_ VDD VSS NOR2_X1
X_25786_ _02371_ _02315_ _02798_ VDD VSS NOR2_X1
X_25787_ _02788_ _02798_ _02349_ _02799_ VDD VSS MUX2_X1
X_25788_ _02390_ _02375_ _02800_ VDD VSS NAND2_X1
X_25789_ _02799_ _02542_ _02800_ _02801_ VDD VSS AOI21_X1
X_25790_ _02371_ _02802_ VDD VSS INV_X1
X_25791_ _02802_ _02343_ _02579_ _02495_ _02803_ VDD VSS OAI22_X1
X_25792_ _02801_ _02803_ _02518_ _02804_ VDD VSS MUX2_X1
X_25793_ _02587_ _02795_ _02797_ _02804_ _02435_ _02805_ VDD
+ VSS AOI221_X1
X_25794_ _02603_ _02623_ _02385_ _02625_ _02707_ _02806_ VDD
+ VSS OAI221_X1
X_25795_ _02403_ _02537_ _02807_ VDD VSS AND2_X1
X_25796_ _02807_ _02484_ _02295_ _02483_ _02443_ _02808_ VDD
+ VSS AOI221_X2
X_25797_ _02806_ _02808_ _02547_ _02809_ VDD VSS OAI21_X1
X_25798_ _15133_ _02344_ _15128_ _02810_ VDD VSS AOI21_X1
X_25799_ _02591_ _02669_ _02810_ _02811_ VDD VSS OAI21_X1
X_25800_ _02582_ _02579_ _02443_ _02812_ VDD VSS OAI21_X1
X_25801_ _02811_ _02812_ _02799_ _02813_ VDD VSS OAI21_X1
X_25802_ _02414_ _02436_ _02809_ _02813_ _02814_ VDD VSS NOR4_X1
X_25803_ _02414_ _02436_ _02815_ VDD VSS NAND2_X1
X_25804_ _02362_ _02391_ _02816_ VDD VSS NAND2_X1
X_25805_ _15133_ _02383_ _02344_ _02817_ VDD VSS NAND3_X1
X_25806_ net127 _02816_ _02817_ _02818_ VDD VSS AOI21_X1
X_25807_ _02509_ _02411_ _02576_ _02819_ VDD VSS NOR3_X1
X_25808_ _02279_ _02518_ _02376_ _02598_ _02820_ VDD VSS AOI22_X1
X_25809_ _02325_ _02458_ _02577_ _02820_ _15133_ _02821_ VDD
+ VSS OAI221_X2
X_25810_ _02818_ _02819_ _02821_ _02822_ VDD VSS NOR3_X2
X_25811_ _02378_ _02411_ _02823_ VDD VSS NAND2_X1
X_25812_ _02636_ _02823_ _02678_ _02824_ VDD VSS AOI21_X1
X_25813_ _02582_ _02579_ _15128_ _02825_ VDD VSS OAI21_X1
X_25814_ _02824_ _02825_ _02826_ VDD VSS NOR2_X1
X_25815_ net680 _02407_ _02349_ _02827_ VDD VSS MUX2_X1
X_25816_ _02547_ _02827_ _02598_ _02483_ _02521_ _02828_ VDD
+ VSS AOI221_X2
X_25817_ _02815_ _02822_ _02826_ _02828_ _02829_ VDD VSS NOR4_X1
X_25818_ _02793_ _02805_ _02814_ _02829_ _00117_ VDD VSS OR4_X2
X_25819_ _02370_ _02499_ _02699_ _02522_ _02636_ _02830_ VDD
+ VSS AOI221_X2
X_25820_ _02391_ _02719_ _02831_ VDD VSS NOR2_X1
X_25821_ _02363_ _02536_ _02831_ _02415_ _15144_ _02832_ VDD
+ VSS AOI221_X2
X_25822_ _02434_ _02436_ _02833_ VDD VSS NOR2_X1
X_25823_ _02449_ _02318_ _15122_ net680 _02579_ _02834_ VDD
+ VSS OAI221_X1
X_25824_ _02439_ _02506_ _02344_ _02404_ _02374_ _02835_ VDD
+ VSS OAI221_X1
X_25825_ net127 _02313_ _02762_ _02836_ VDD VSS AOI21_X1
X_25826_ _02833_ _02763_ _02834_ _02835_ _02836_ _02837_ VDD
+ VSS OAI221_X1
X_25827_ _02341_ _02296_ _02279_ _02838_ VDD VSS AOI21_X2
X_25828_ _15143_ _15152_ _02839_ VDD VSS NOR2_X1
X_25829_ _02621_ _02766_ _02838_ _02839_ _02375_ _02840_ VDD
+ VSS AOI221_X1
X_25830_ _02331_ _02840_ _02841_ VDD VSS OR2_X1
X_25831_ _15145_ _02375_ _02842_ VDD VSS OR2_X1
X_25832_ _02521_ _02317_ _02843_ VDD VSS NAND2_X1
X_25833_ _02376_ _02614_ _02843_ _02844_ VDD VSS NAND3_X1
X_25834_ _02356_ _02842_ _02844_ _02845_ VDD VSS NAND3_X1
X_25835_ _02548_ _02391_ _02378_ _02846_ VDD VSS AOI21_X1
X_25836_ _02729_ _02402_ _02403_ _02407_ _02847_ VDD VSS AOI211_X2
X_25837_ _02395_ _02847_ _02846_ _02848_ VDD VSS OAI21_X2
X_25838_ _02475_ _02845_ _02848_ _02849_ VDD VSS AND3_X2
X_25839_ _02471_ _02598_ _02646_ _02850_ VDD VSS OR3_X4
X_25840_ _02351_ _02567_ _02851_ VDD VSS NAND2_X1
X_25841_ _02363_ _02851_ _02850_ _02852_ VDD VSS AOI21_X2
X_25842_ _02830_ _02832_ _02837_ _02852_ _02841_ _02849_ _02853_
+ VDD VSS OAI33_X1
X_25843_ _02544_ _02644_ _02854_ VDD VSS NOR2_X1
X_25844_ _02344_ _02666_ _02855_ VDD VSS NOR2_X1
X_25845_ _02319_ _02392_ _02855_ _02856_ VDD VSS NOR3_X1
X_25846_ _02449_ _02854_ _02856_ _02857_ VDD VSS OAI21_X1
X_25847_ _02706_ _02416_ _15122_ _02858_ VDD VSS AOI21_X1
X_25848_ _02636_ _02415_ _02666_ _02859_ VDD VSS OAI21_X1
X_25849_ _02552_ _02859_ _02860_ VDD VSS NOR2_X1
X_25850_ _02486_ _02858_ _02860_ _02861_ VDD VSS OAI21_X1
X_25851_ _02495_ _02364_ _02483_ _02378_ _02862_ VDD VSS AOI22_X1
X_25852_ _02719_ _02316_ net522 _02863_ VDD VSS AOI21_X2
X_25853_ _02400_ _02863_ _02864_ VDD VSS OR2_X1
X_25854_ _02439_ _02862_ _02864_ _02865_ VDD VSS NAND3_X1
X_25855_ _02646_ _02411_ _02802_ _02866_ VDD VSS AOI21_X1
X_25856_ _02510_ _02444_ net870 _02866_ _02319_ _02867_ VDD
+ VSS OAI221_X1
X_25857_ _02857_ _02861_ _02865_ _02867_ _02868_ VDD VSS NAND4_X1
X_25858_ _02598_ _02762_ _02869_ VDD VSS NAND2_X1
X_25859_ _02506_ _02317_ net870 _02870_ VDD VSS OAI21_X1
X_25860_ _02539_ _02870_ _02343_ _02871_ VDD VSS MUX2_X1
X_25861_ _02356_ _02784_ _02869_ _02871_ _02475_ _02872_ VDD
+ VSS AOI221_X1
X_25862_ _02640_ _02371_ _02342_ _02873_ VDD VSS MUX2_X1
X_25863_ _02362_ _02483_ net127 _02873_ _02598_ _02874_ VDD
+ VSS AOI221_X2
X_25864_ _02397_ _02595_ _02874_ _02875_ VDD VSS NOR3_X1
X_25865_ _02872_ _02875_ _02876_ VDD VSS OR2_X1
X_25866_ _02853_ _02868_ _02438_ _02876_ _02448_ _00118_ VDD
+ VSS AOI221_X2
X_25867_ _02426_ _02473_ _02678_ _02877_ VDD VSS AOI21_X1
X_25868_ _02558_ _02877_ _02878_ VDD VSS OR2_X1
X_25869_ _02627_ _02317_ _02390_ _02879_ VDD VSS OAI21_X1
X_25870_ _15152_ _02879_ _02343_ _02880_ VDD VSS MUX2_X1
X_25871_ _02447_ _02880_ _02509_ _02881_ VDD VSS AOI21_X1
X_25872_ _02509_ _02411_ _02443_ _02404_ _02332_ _02882_ VDD
+ VSS OAI221_X1
X_25873_ _02636_ _02518_ _02583_ _02883_ VDD VSS OR3_X1
X_25874_ _02636_ _02475_ _02377_ _02513_ _02884_ VDD VSS NAND4_X1
X_25875_ _02882_ _02883_ _02884_ _02885_ VDD VSS NAND3_X1
X_25876_ _02815_ _02878_ _02881_ _02885_ _02447_ _02886_ VDD
+ VSS AOI221_X2
X_25877_ _15129_ _02311_ _02887_ VDD VSS NOR2_X1
X_25878_ _02342_ _02425_ _02887_ _02888_ VDD VSS OAI21_X1
X_25879_ _02888_ _02526_ _02442_ _02405_ _02444_ _02889_ VDD
+ VSS OAI221_X2
X_25880_ _02402_ _02403_ _02366_ _02890_ VDD VSS OAI21_X1
X_25881_ _02890_ _02755_ _02312_ _02891_ VDD VSS OAI21_X1
X_25882_ _02330_ _02603_ _02889_ _02891_ _02591_ _02892_ VDD
+ VSS AOI221_X2
X_25883_ _02369_ _02349_ _02893_ VDD VSS NOR2_X1
X_25884_ _02361_ _02349_ _02506_ _02894_ VDD VSS AND3_X1
X_25885_ _02324_ _02893_ _02863_ _02894_ _02476_ _02895_ VDD
+ VSS AOI221_X2
X_25886_ _15122_ _02430_ _02483_ _02453_ _02521_ _02484_ _02896_
+ VDD VSS AOI222_X2
X_25887_ _02895_ _02896_ _02509_ _02897_ VDD VSS OAI21_X1
X_25888_ _02312_ _02639_ _02643_ _02898_ VDD VSS NAND3_X1
X_25889_ _02898_ _02376_ _02495_ _02899_ VDD VSS AOI21_X1
X_25890_ _02598_ _02380_ _02609_ _02900_ VDD VSS AOI21_X1
X_25891_ _02899_ _02900_ _02473_ _02901_ VDD VSS AOI21_X1
X_25892_ _02318_ _02380_ _02407_ _02902_ VDD VSS OAI21_X1
X_25893_ _02624_ _02902_ _02705_ _02636_ _02903_ VDD VSS OAI22_X1
X_25894_ _02603_ _02901_ _02903_ _02591_ _02904_ VDD VSS AOI22_X2
X_25895_ _02766_ _02838_ _02905_ VDD VSS NAND2_X1
X_25896_ _02605_ _02535_ _02906_ VDD VSS NOR2_X1
X_25897_ _02402_ _02350_ _02378_ _02907_ VDD VSS OAI21_X1
X_25898_ _02405_ _02312_ _02563_ _02907_ _02908_ VDD VSS OAI22_X1
X_25899_ _02547_ _02909_ VDD VSS INV_X1
X_25900_ _02504_ _02905_ _02906_ _02908_ _02909_ _02910_ VDD
+ VSS AOI221_X2
X_25901_ _02414_ _02892_ _02897_ _02904_ _02910_ _02911_ VDD
+ VSS AOI221_X2
X_25902_ _02318_ _02471_ _02707_ _02912_ VDD VSS OAI21_X2
X_25903_ _02518_ _02430_ _02443_ _02913_ VDD VSS AOI21_X1
X_25904_ _02684_ _02400_ _02443_ _02914_ VDD VSS AOI21_X1
X_25905_ _02447_ _02912_ _02913_ _02914_ _02800_ _02915_ VDD
+ VSS AOI221_X2
X_25906_ _02495_ _02598_ _02362_ _02343_ _02916_ VDD VSS NAND4_X1
X_25907_ _15122_ _02548_ _02383_ _02391_ _02917_ VDD VSS NAND4_X1
X_25908_ _02325_ _02916_ _02917_ _02918_ VDD VSS NAND3_X1
X_25909_ _02383_ _02343_ _02919_ VDD VSS NAND2_X1
X_25910_ _02919_ _02816_ _15128_ _02920_ VDD VSS OAI21_X1
X_25911_ _02526_ _02577_ _02313_ _02921_ VDD VSS OAI21_X1
X_25912_ _02918_ _02920_ _15133_ _02921_ _15128_ _02922_ VDD
+ VSS AOI221_X2
X_25913_ _02915_ _02587_ _02922_ _02923_ VDD VSS NOR3_X1
X_25914_ _02923_ _02911_ _02886_ _00119_ VDD VSS OR3_X2
X_25915_ _06471_ _02924_ VDD VSS INV_X1
X_25916_ _02924_ _09823_ _02925_ VDD VSS NOR2_X1
X_25917_ _06471_ _09823_ _02926_ VDD VSS NOR2_X1
X_25918_ net1098 _11165_ _02927_ VDD VSS XNOR2_X2
X_25919_ _11185_ _02927_ _02928_ VDD VSS XNOR2_X2
X_25920_ net1059 _11136_ _02929_ VDD VSS XNOR2_X2
X_25921_ _02929_ net719 _02930_ VDD VSS XNOR2_X2
X_25922_ _02928_ _02930_ _02931_ VDD VSS XNOR2_X2
X_25923_ _02925_ _02926_ _02931_ _02932_ VDD VSS MUX2_X1
X_25924_ _06471_ _09135_ _00473_ _02933_ VDD VSS NAND3_X2
X_25925_ _02924_ _09135_ _02934_ VDD VSS NAND2_X2
X_25926_ _02933_ _02934_ _00473_ _02935_ VDD VSS OAI21_X4
X_25927_ _02932_ _02935_ _02936_ VDD VSS NOR2_X4
X_25928_ net813 _02937_ VDD VSS INV_X16
Xclone345 net811 net810 VDD VSS BUF_X2
X_25930_ _02937_ _15164_ VDD VSS BUF_X32
X_25931_ net722 net646 _02939_ VDD VSS XNOR2_X1
X_25932_ _11183_ _11184_ _02940_ VDD VSS XOR2_X2
X_25933_ _06457_ _11191_ _02940_ _02941_ VDD VSS NAND3_X4
X_25934_ _06457_ _11938_ _02942_ VDD VSS NOR2_X1
X_25935_ net816 _02942_ _02943_ VDD VSS NAND2_X1
X_25936_ _02939_ _02943_ _02941_ _02944_ VDD VSS AOI21_X4
X_25937_ net721 net646 _02945_ VDD VSS XOR2_X1
X_25938_ _02940_ _02942_ _02946_ VDD VSS NAND2_X1
X_25939_ _06457_ _09116_ net816 _02947_ VDD VSS NAND3_X1
X_25940_ _02945_ _02946_ _02947_ _02948_ VDD VSS AOI21_X1
X_25941_ _06457_ _02949_ VDD VSS INV_X1
X_25942_ _02949_ _09103_ _00474_ _02950_ VDD VSS NAND3_X1
X_25943_ _06457_ _09103_ _02951_ VDD VSS NAND2_X1
X_25944_ _02950_ _02951_ _00474_ _02952_ VDD VSS OAI21_X1
X_25945_ _02948_ _02944_ _02952_ _02953_ VDD VSS OR3_X4
X_25946_ _02953_ _02954_ VDD VSS BUF_X16
X_25947_ _02954_ _02955_ VDD VSS INV_X16
X_25948_ _02955_ _15169_ VDD VSS BUF_X32
X_25949_ _11158_ _13864_ _02956_ VDD VSS XNOR2_X1
X_25950_ _06491_ _09030_ net900 _02957_ VDD VSS OR3_X1
X_25951_ _06491_ _09195_ net900 _02958_ VDD VSS NAND3_X1
X_25952_ _02956_ _02957_ _02958_ _02959_ VDD VSS AOI21_X2
X_25953_ _11158_ _13862_ _02960_ VDD VSS XNOR2_X1
X_25954_ _06479_ _09727_ net900 _02961_ VDD VSS OR3_X1
X_25955_ _06479_ _09856_ net901 _02962_ VDD VSS NAND3_X1
X_25956_ _02960_ _02961_ _02962_ _02963_ VDD VSS AOI21_X2
X_25957_ _06491_ _09730_ _00475_ _02964_ VDD VSS NAND3_X1
X_25958_ _06479_ _09730_ _02965_ VDD VSS NAND2_X1
X_25959_ _02964_ _02965_ _00475_ _02966_ VDD VSS OAI21_X2
X_25960_ _02966_ _02963_ _02959_ _02967_ VDD VSS NOR3_X4
X_25961_ _02967_ _02968_ VDD VSS INV_X4
X_25962_ _02968_ _02969_ VDD VSS BUF_X4
X_25963_ _02969_ _02970_ VDD VSS BUF_X4
X_25964_ _02970_ _02971_ VDD VSS BUF_X4
X_25965_ _02971_ _15185_ VDD VSS BUF_X4
X_25966_ _02936_ _02972_ VDD VSS BUF_X8
Xclone413 _02954_ net1040 VDD VSS BUF_X16
X_25968_ _02967_ _02973_ VDD VSS BUF_X4
X_25969_ _02973_ _02974_ VDD VSS BUF_X4
X_25970_ _02974_ _02975_ VDD VSS BUF_X4
X_25971_ _02975_ _15178_ VDD VSS BUF_X4
X_25972_ _15176_ _02976_ VDD VSS BUF_X8
X_25973_ _11841_ text_in_r\[11\] _02977_ VDD VSS NAND2_X1
X_25974_ _06517_ _08975_ _02977_ _02978_ VDD VSS NAND3_X2
X_25975_ _06517_ _02977_ _02979_ VDD VSS OR2_X1
X_25976_ _02978_ _02979_ _02980_ VDD VSS AND2_X1
X_25977_ _02980_ _02981_ VDD VSS BUF_X4
X_25978_ _02981_ _02982_ VDD VSS BUF_X8
X_25979_ _06517_ _02977_ _02983_ VDD VSS NAND2_X1
X_25980_ _06517_ _00991_ _02984_ VDD VSS OR2_X1
X_25981_ _11245_ _11184_ _02985_ VDD VSS XNOR2_X1
X_25982_ _11164_ _11223_ _02986_ VDD VSS XNOR2_X1
X_25983_ _02985_ _02986_ _02987_ VDD VSS XNOR2_X2
X_25984_ _11183_ _13930_ _02988_ VDD VSS XNOR2_X1
X_25985_ _02987_ _02988_ _02989_ VDD VSS XNOR2_X2
X_25986_ _02983_ _02984_ _02989_ _02990_ VDD VSS MUX2_X2
X_25987_ net818 _02991_ VDD VSS BUF_X8
X_25988_ _02976_ _02982_ _02991_ _02992_ VDD VSS AOI21_X4
X_25989_ _02978_ _02979_ _02993_ VDD VSS NAND2_X4
X_25990_ _06517_ _02977_ _02994_ VDD VSS AND2_X1
X_25991_ _06517_ _08975_ _02995_ VDD VSS NOR2_X1
X_25992_ _02994_ _02995_ _02989_ _02996_ VDD VSS MUX2_X2
X_25993_ _02993_ _02996_ _02997_ VDD VSS NOR2_X4
X_25994_ _02997_ _02998_ VDD VSS BUF_X4
X_25995_ _02998_ _02999_ VDD VSS CLKBUF_X3
X_25996_ _02936_ _03000_ VDD VSS BUF_X4
X_25997_ _02970_ _02992_ _02999_ _03000_ _03001_ VDD VSS AOI211_X2
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
X_25999_ _02993_ _03003_ VDD VSS BUF_X8
X_26000_ _02996_ _03004_ VDD VSS BUF_X8
X_26001_ net566 _03003_ _03004_ _03005_ VDD VSS NOR3_X4
X_26002_ _02954_ _02982_ _02991_ _03006_ VDD VSS AOI21_X2
X_26003_ _03005_ _03006_ _03007_ VDD VSS OR2_X1
X_26004_ _03001_ _03007_ _15185_ _03008_ VDD VSS AOI21_X1
X_26005_ _11265_ _11184_ _03009_ VDD VSS XNOR2_X1
X_26006_ _11225_ _11249_ _03010_ VDD VSS XNOR2_X1
X_26007_ _03009_ _03010_ _03011_ VDD VSS XNOR2_X2
X_26008_ _13914_ _03011_ _03012_ VDD VSS XNOR2_X1
X_26009_ text_in_r\[12\] _03012_ _09075_ _03013_ VDD VSS MUX2_X2
X_26010_ _06533_ _03013_ _03014_ VDD VSS XNOR2_X2
X_26011_ _03014_ _03015_ VDD VSS BUF_X4
X_26012_ _11246_ _11262_ _03016_ VDD VSS XOR2_X1
X_26013_ _06546_ _09175_ _03016_ _03017_ VDD VSS NAND3_X1
X_26014_ _06546_ _09179_ _03018_ VDD VSS NOR2_X1
X_26015_ _03016_ _03018_ _03019_ VDD VSS NAND2_X1
X_26016_ _11250_ _11203_ _03020_ VDD VSS XNOR2_X2
X_26017_ _03017_ _03019_ _03020_ _03021_ VDD VSS MUX2_X1
X_26018_ _11246_ _11262_ _03022_ VDD VSS XNOR2_X1
X_26019_ _03022_ _03018_ _03023_ VDD VSS NAND2_X1
X_26020_ _06546_ _09076_ _03022_ _03024_ VDD VSS NAND3_X1
X_26021_ _03023_ _03024_ _03020_ _03025_ VDD VSS MUX2_X1
X_26022_ _06546_ _09138_ text_in_r\[13\] _03026_ VDD VSS OR3_X2
X_26023_ _06546_ _09824_ text_in_r\[13\] _03027_ VDD VSS NAND3_X2
X_26024_ _03021_ _03025_ _03026_ _03027_ _03028_ VDD VSS AND4_X1
X_26025_ _03028_ _03029_ VDD VSS BUF_X4
X_26026_ _03015_ _03029_ _03030_ VDD VSS NOR2_X4
X_26027_ _03021_ _03025_ _03026_ _03027_ _03031_ VDD VSS NAND4_X4
X_26028_ _03031_ _03032_ VDD VSS BUF_X4
X_26029_ _03015_ _03032_ _03033_ VDD VSS NOR2_X2
X_26030_ _02975_ _03034_ VDD VSS CLKBUF_X3
X_26031_ _02955_ _03003_ _03004_ _03035_ VDD VSS NOR3_X4
X_26032_ _15161_ _03036_ VDD VSS BUF_X4
X_26033_ _03036_ _02982_ _02991_ _03037_ VDD VSS AOI21_X4
X_26034_ _03034_ _03035_ _03037_ _03038_ VDD VSS OAI21_X1
X_26035_ _02997_ _03039_ VDD VSS BUF_X4
X_26036_ _02992_ _03039_ net568 _03040_ VDD VSS AOI21_X1
X_26037_ _03038_ _03040_ _15178_ _03041_ VDD VSS OAI21_X1
X_26038_ _03008_ _03030_ _03033_ _03041_ _03042_ VDD VSS AOI22_X2
X_26039_ _06533_ _03013_ _03043_ VDD VSS XOR2_X2
X_26040_ _03043_ _03044_ VDD VSS BUF_X4
X_26041_ _03044_ _03032_ _03045_ VDD VSS NOR2_X4
X_26042_ _02982_ _03046_ VDD VSS BUF_X4
X_26043_ _02991_ _03047_ VDD VSS BUF_X4
X_26044_ net999 _03046_ _03047_ _03048_ VDD VSS NAND3_X4
X_26045_ _03003_ _03049_ VDD VSS BUF_X4
X_26046_ _03004_ _03050_ VDD VSS BUF_X4
X_26047_ net567 _03049_ _03050_ _03051_ VDD VSS OAI21_X2
X_26048_ _15178_ _03048_ _03051_ _03052_ VDD VSS AOI21_X1
X_26049_ _15167_ _03053_ VDD VSS BUF_X8
X_26050_ _02973_ _03003_ _03004_ _03054_ VDD VSS OAI21_X4
X_26051_ _03053_ _03054_ _03055_ VDD VSS NOR2_X1
X_26052_ _03045_ _03052_ _03055_ _03056_ VDD VSS OAI21_X1
X_26053_ _11263_ _13904_ _03057_ VDD VSS XNOR2_X1
X_26054_ _11186_ _03057_ _03058_ VDD VSS XNOR2_X1
X_26055_ text_in_r\[14\] _03058_ _09803_ _03059_ VDD VSS MUX2_X2
X_26056_ _06554_ _03059_ _03060_ VDD VSS XOR2_X2
X_26057_ _11198_ _11184_ _03061_ VDD VSS XNOR2_X1
X_26058_ net602 _03061_ _03062_ VDD VSS XNOR2_X1
X_26059_ _11199_ _03062_ _03063_ VDD VSS XNOR2_X1
X_26060_ text_in_r\[15\] _03063_ _10571_ _03064_ VDD VSS MUX2_X2
X_26061_ _06563_ _03064_ _03065_ VDD VSS XNOR2_X2
X_26062_ _03060_ _03065_ _03066_ VDD VSS NAND2_X2
X_26063_ _03066_ _03067_ VDD VSS INV_X1
X_26064_ _02981_ _02990_ _03068_ VDD VSS NAND2_X1
X_26065_ _03068_ _03069_ VDD VSS CLKBUF_X3
X_26066_ _03069_ _03070_ VDD VSS CLKBUF_X3
Xrebuffer384 _15174_ net993 VDD VSS BUF_X4
X_26068_ net993 _03072_ VDD VSS INV_X8
X_26069_ _03072_ _02955_ _02968_ _03073_ VDD VSS MUX2_X1
X_26070_ _03044_ _03073_ _03070_ _03074_ VDD VSS AOI21_X2
X_26071_ _03074_ _03075_ VDD VSS INV_X1
X_26072_ _03032_ _03076_ VDD VSS CLKBUF_X3
X_26073_ _03076_ _03077_ VDD VSS CLKBUF_X3
X_26074_ net1114 _02975_ _03078_ VDD VSS NOR2_X2
X_26075_ _03039_ _03079_ VDD VSS CLKBUF_X3
X_26076_ _15162_ _03080_ VDD VSS BUF_X4
X_26077_ _03079_ _02971_ net810 _03081_ VDD VSS OAI21_X1
X_26078_ _03077_ _03078_ _03081_ _03082_ VDD VSS OAI21_X1
X_26079_ _03075_ _03082_ _03083_ VDD VSS OR2_X2
X_26080_ _03042_ _03056_ _03067_ _03083_ _03084_ VDD VSS NAND4_X4
X_26081_ _03060_ _03065_ _03085_ VDD VSS NOR2_X2
X_26082_ _03029_ _03086_ VDD VSS BUF_X4
X_26083_ _03086_ _03087_ VDD VSS BUF_X4
X_26084_ _03087_ _03088_ VDD VSS BUF_X4
X_26085_ _03044_ _03089_ VDD VSS BUF_X4
X_26086_ _03089_ _03090_ VDD VSS BUF_X4
X_26087_ _03005_ _03070_ net810 _03091_ VDD VSS AOI21_X1
X_26088_ _02970_ _03092_ VDD VSS CLKBUF_X3
X_26089_ _02968_ _02981_ net820 _03093_ VDD VSS NAND3_X4
X_26090_ _15170_ _03094_ VDD VSS BUF_X4
X_26091_ _03090_ _03091_ _03092_ _03093_ _03094_ _03095_ VDD
+ VSS OAI221_X1
X_26092_ _03015_ _03096_ VDD VSS CLKBUF_X3
X_26093_ _03096_ _03097_ VDD VSS CLKBUF_X3
X_26094_ _15165_ _03098_ VDD VSS INV_X4
X_26095_ _03098_ _02981_ net818 _03099_ VDD VSS AOI21_X4
X_26096_ _15162_ _02993_ _02996_ _03100_ VDD VSS NOR3_X4
X_26097_ _03099_ _03100_ _03101_ VDD VSS OR2_X1
X_26098_ _02968_ _03003_ _03004_ _03102_ VDD VSS OAI21_X4
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
X_26100_ _15172_ _03104_ VDD VSS INV_X2
X_26101_ _03097_ _03101_ _03092_ _03102_ _03104_ _03105_ VDD
+ VSS OAI221_X1
X_26102_ _03088_ _03095_ _03105_ _03106_ VDD VSS AND3_X1
X_26103_ _03086_ _03107_ VDD VSS CLKBUF_X3
X_26104_ _15160_ _03108_ VDD VSS BUF_X4
X_26105_ _03108_ _02982_ _02991_ _03109_ VDD VSS AOI21_X2
X_26106_ _02974_ _03005_ _03109_ _03110_ VDD VSS OAI21_X2
X_26107_ net812 _03003_ _03004_ _03111_ VDD VSS NOR3_X4
X_26108_ _03044_ _03111_ _03053_ _03112_ VDD VSS AOI21_X1
X_26109_ _03110_ _03112_ _03113_ VDD VSS AND2_X1
X_26110_ _02969_ _03114_ VDD VSS CLKBUF_X3
X_26111_ _03114_ _03115_ VDD VSS BUF_X4
X_26112_ _02955_ _03003_ _03004_ _03116_ VDD VSS OAI21_X4
X_26113_ _03069_ _03117_ VDD VSS CLKBUF_X3
X_26114_ _03080_ _03118_ VDD VSS INV_X1
X_26115_ _03116_ _03117_ _03118_ _03119_ VDD VSS OAI21_X1
X_26116_ _03115_ _03119_ _03120_ VDD VSS NAND2_X1
X_26117_ _03070_ _03121_ VDD VSS BUF_X4
X_26118_ _03036_ _03122_ VDD VSS BUF_X16
X_26119_ _15183_ _03121_ _03111_ _03122_ _03123_ VDD VSS AOI22_X1
X_26120_ _03107_ _03113_ _03120_ _03123_ _03090_ _03124_ VDD
+ VSS AOI221_X2
X_26121_ _03085_ _03124_ _03106_ _03125_ VDD VSS OAI21_X2
X_26122_ _02972_ net999 _03126_ VDD VSS NAND2_X1
X_26123_ _02955_ _02973_ _03127_ VDD VSS NAND2_X2
X_26124_ _03032_ _03126_ _03127_ _03039_ _03089_ _03128_ VDD
+ VSS AOI221_X1
X_26125_ _03015_ _02997_ _03129_ VDD VSS NOR2_X1
X_26126_ net809 _02974_ _03130_ VDD VSS NOR2_X2
X_26127_ _03130_ _03131_ VDD VSS INV_X1
X_26128_ _03129_ _03131_ _03107_ _03132_ VDD VSS OAI21_X1
X_26129_ _03036_ _03133_ VDD VSS INV_X8
X_26130_ _02969_ _03134_ VDD VSS BUF_X4
X_26131_ _03133_ _03134_ _03086_ _03135_ VDD VSS NOR3_X1
X_26132_ _03096_ _03121_ _03135_ _03136_ VDD VSS NOR3_X1
X_26133_ _02954_ _15158_ VDD VSS BUF_X32
X_26134_ _03115_ _03087_ _15158_ _03137_ VDD VSS AOI21_X1
X_26135_ _15169_ _03029_ _03138_ VDD VSS NAND2_X1
X_26136_ _03136_ _03137_ net1114 _03034_ _03138_ _03139_ VDD
+ VSS OAI221_X1
X_26137_ _03128_ _03132_ _03139_ _03140_ VDD VSS AOI21_X1
X_26138_ _06554_ _03059_ _03141_ VDD VSS XNOR2_X2
X_26139_ _03141_ _03065_ _03142_ VDD VSS NAND2_X2
X_26140_ _03134_ _03143_ VDD VSS CLKBUF_X3
X_26141_ _03094_ _02981_ net819 _03144_ VDD VSS AOI21_X4
X_26142_ _03049_ _03133_ _03050_ _03145_ VDD VSS NOR3_X4
X_26143_ net1174 _03144_ _03143_ _03146_ VDD VSS NOR3_X4
X_26144_ net993 _03003_ _03004_ _03147_ VDD VSS NOR3_X4
X_26145_ _02975_ _03109_ _03147_ _03148_ VDD VSS NOR3_X1
X_26146_ _03045_ _03148_ _03146_ _03149_ VDD VSS OAI21_X4
X_26147_ _03122_ _03054_ _03150_ VDD VSS NOR2_X1
X_26148_ _02973_ _02982_ _02991_ _03151_ VDD VSS NAND3_X4
X_26149_ _03102_ _03151_ _03152_ VDD VSS NAND2_X1
X_26150_ _03150_ _03152_ _03108_ _03094_ _03111_ _03153_ VDD
+ VSS AOI221_X2
X_26151_ _03014_ _03031_ _03154_ VDD VSS NAND2_X2
X_26152_ _03149_ _03153_ _03154_ _03155_ VDD VSS OAI21_X4
X_26153_ _03155_ _03142_ _03140_ _03156_ VDD VSS OR3_X4
X_26154_ _02973_ _03157_ VDD VSS BUF_X4
X_26155_ _03053_ _02982_ _02991_ _03158_ VDD VSS AOI21_X4
X_26156_ _03157_ _03100_ _03158_ _03159_ VDD VSS OAI21_X1
X_26157_ _03015_ _03111_ _03108_ _03160_ VDD VSS AOI21_X1
X_26158_ _03116_ _03069_ net996 _03161_ VDD VSS OAI21_X1
X_26159_ _03003_ _03036_ _03004_ _03162_ VDD VSS NOR3_X4
X_26160_ _03162_ _03144_ _03163_ VDD VSS OR2_X2
X_26161_ _03161_ _03163_ _03114_ _03164_ VDD VSS MUX2_X1
X_26162_ _03076_ _03159_ _03160_ _03096_ _03164_ _03165_ VDD
+ VSS AOI221_X2
X_26163_ _06563_ _03064_ _03166_ VDD VSS XOR2_X2
X_26164_ _03060_ _03166_ _03167_ VDD VSS NAND2_X1
X_26165_ _02955_ _03046_ _03047_ _03168_ VDD VSS AOI21_X4
X_26166_ _03015_ _03168_ _03169_ VDD VSS NAND2_X1
X_26167_ net807 _02993_ _02996_ _03170_ VDD VSS NOR3_X4
X_26168_ _03157_ _03170_ _03171_ VDD VSS NOR2_X1
X_26169_ net809 _03049_ _03050_ _03172_ VDD VSS OAI21_X4
X_26170_ _02991_ _02982_ net1051 _03173_ VDD VSS NAND3_X4
X_26171_ _02969_ _03172_ _03173_ _03174_ VDD VSS AOI21_X1
X_26172_ _03015_ _03174_ _03175_ VDD VSS OR2_X1
X_26173_ _03087_ _03169_ _03171_ _03075_ _03175_ _03176_ VDD
+ VSS AOI221_X2
X_26174_ _03176_ _03165_ _03167_ _03177_ VDD VSS OR3_X4
X_26175_ _03177_ _03125_ _03156_ _03084_ _00120_ VDD VSS NAND4_X4
X_26176_ _03043_ _03029_ _03178_ VDD VSS NAND2_X2
X_26177_ net817 _02981_ net818 _03179_ VDD VSS AOI21_X4
X_26178_ _03072_ _03046_ _03047_ _03180_ VDD VSS NAND3_X1
X_26179_ _03180_ _02998_ net927 _03181_ VDD VSS OAI21_X1
X_26180_ _02974_ _03182_ VDD VSS BUF_X4
X_26181_ _02976_ _03179_ _03181_ _03182_ _03183_ VDD VSS AOI22_X2
X_26182_ _03133_ _03049_ _03050_ _03184_ VDD VSS OAI21_X4
X_26183_ _15167_ _03185_ VDD VSS INV_X2
X_26184_ _03184_ _03070_ _03185_ _03186_ VDD VSS OAI21_X1
X_26185_ _03072_ _03179_ _03186_ _03157_ _03187_ VDD VSS AOI22_X2
X_26186_ _03015_ _03029_ _03188_ VDD VSS NAND2_X2
X_26187_ net927 _03006_ _03122_ _03111_ _03189_ VDD VSS AOI22_X4
X_26188_ _02968_ _02993_ _02996_ _03190_ VDD VSS NOR3_X4
X_26189_ _03179_ _03190_ _03191_ VDD VSS NOR2_X2
X_26190_ _03189_ _03191_ _15169_ _03192_ VDD VSS OAI21_X4
X_26191_ _03178_ _03183_ _03187_ _03188_ _03192_ _03154_ _03193_
+ VDD VSS OAI222_X2
X_26192_ _03044_ _03032_ _03194_ VDD VSS NAND2_X2
X_26193_ _03185_ _03117_ _03195_ VDD VSS NAND2_X1
X_26194_ _03182_ _03048_ _03195_ _03196_ VDD VSS AOI21_X1
X_26195_ _03108_ _02982_ _02991_ _03197_ VDD VSS NAND3_X2
X_26196_ _02969_ _03172_ _03197_ _03198_ VDD VSS AOI21_X2
X_26197_ _03194_ _03196_ _03198_ _03199_ VDD VSS NOR3_X2
X_26198_ _03193_ _03167_ _03199_ _03200_ VDD VSS NOR3_X2
X_26199_ _03182_ _03048_ _03184_ _03201_ VDD VSS AOI21_X2
X_26200_ _03100_ _03117_ _03108_ _03202_ VDD VSS AOI21_X1
X_26201_ _03033_ _03202_ _03143_ _03203_ VDD VSS OAI21_X1
X_26202_ _03133_ _03046_ _03047_ _03204_ VDD VSS AOI21_X2
X_26203_ _15176_ _02993_ _02996_ _03205_ VDD VSS NOR3_X4
X_26204_ _03157_ _03204_ _03205_ _03206_ VDD VSS OAI21_X1
X_26205_ _15174_ _03207_ VDD VSS BUF_X8
X_26206_ _03100_ _03117_ net995 _03208_ VDD VSS AOI21_X1
X_26207_ _03206_ _03208_ _02975_ _03209_ VDD VSS OAI21_X1
X_26208_ _03201_ _03203_ _03209_ _03194_ _03210_ VDD VSS OAI22_X1
X_26209_ _03044_ _03086_ _03211_ VDD VSS NOR2_X4
X_26210_ _03037_ _03039_ _03207_ _03212_ VDD VSS AOI21_X4
X_26211_ _03211_ _03212_ _02970_ _03093_ _15169_ _03213_ VDD
+ VSS OAI221_X2
X_26212_ net999 _03049_ _03050_ _03214_ VDD VSS NOR3_X4
X_26213_ _03114_ _03214_ _03158_ _03215_ VDD VSS NOR3_X1
X_26214_ _03108_ _03216_ VDD VSS INV_X1
X_26215_ _03216_ _03049_ _03050_ _03217_ VDD VSS NOR3_X1
X_26216_ _03217_ _03117_ _03000_ _03218_ VDD VSS AOI21_X1
X_26217_ _03215_ _03218_ _03143_ _03219_ VDD VSS AOI21_X1
X_26218_ _03213_ _03219_ _03188_ _03220_ VDD VSS OAI21_X2
X_26219_ _03060_ _03210_ _03220_ _03221_ VDD VSS OAI21_X2
X_26220_ _03094_ _03207_ _02973_ _03222_ VDD VSS MUX2_X1
X_26221_ _03222_ _03117_ _03223_ VDD VSS NOR2_X2
X_26222_ _15186_ _02998_ _03086_ _03224_ VDD VSS NOR3_X1
X_26223_ _03223_ _03089_ _03224_ _03225_ VDD VSS NOR3_X2
X_26224_ _02970_ _03099_ _03217_ _03226_ VDD VSS OAI21_X1
X_26225_ _03072_ _02955_ _02997_ _03227_ VDD VSS MUX2_X1
X_26226_ _03226_ _03227_ _03143_ _03228_ VDD VSS OAI21_X1
X_26227_ _03225_ _03228_ _03033_ _03229_ VDD VSS AOI21_X2
X_26228_ _02972_ _02998_ _03230_ VDD VSS XNOR2_X1
X_26229_ _03215_ _03230_ _03143_ _03231_ VDD VSS AOI21_X1
X_26230_ _03060_ _03231_ _03030_ _03232_ VDD VSS AOI21_X1
X_26231_ _03166_ _03232_ _03229_ _03233_ VDD VSS AOI21_X2
X_26232_ _03089_ _03234_ VDD VSS CLKBUF_X3
X_26233_ _03115_ _03037_ _03170_ _03235_ VDD VSS NOR3_X1
X_26234_ _03182_ _03116_ _03048_ _03236_ VDD VSS AOI21_X1
X_26235_ _03076_ _03235_ _03236_ _03237_ VDD VSS NOR3_X1
X_26236_ _03032_ _02999_ _15190_ _03238_ VDD VSS OAI21_X1
X_26237_ _03069_ _03239_ VDD VSS CLKBUF_X3
X_26238_ _03239_ _03115_ _03185_ _03240_ VDD VSS AOI21_X1
X_26239_ net996 _02973_ _03241_ VDD VSS NAND2_X2
X_26240_ _03238_ _03240_ _03241_ _03242_ VDD VSS AOI21_X1
X_26241_ _03234_ _03237_ _03242_ _03243_ VDD VSS OAI21_X1
X_26242_ _03115_ _03037_ _03170_ _03244_ VDD VSS OAI21_X1
X_26243_ _03244_ _03040_ _02971_ _03245_ VDD VSS OAI21_X1
X_26244_ _03000_ _03117_ _03246_ VDD VSS NOR2_X2
X_26245_ net568 _02998_ _03247_ VDD VSS NOR2_X4
X_26246_ _02971_ _03246_ _03247_ _03248_ VDD VSS OAI21_X1
X_26247_ _03076_ _03214_ net1114 _03249_ VDD VSS AOI21_X1
X_26248_ _03077_ _03245_ _03248_ _03249_ _03250_ VDD VSS AOI22_X1
X_26249_ _03243_ _03250_ _03234_ _03251_ VDD VSS OAI21_X1
X_26250_ _03200_ _03221_ _03233_ _03085_ _03251_ _00121_ VDD
+ VSS AOI221_X2
X_26251_ net556 _03049_ _03050_ _03252_ VDD VSS NOR3_X2
X_26252_ _03092_ _03168_ _03252_ _03253_ VDD VSS NOR3_X1
X_26253_ _03034_ _03158_ _03205_ _03254_ VDD VSS NOR3_X1
X_26254_ _03077_ _03253_ _03254_ _03255_ VDD VSS OAI21_X1
X_26255_ net556 _03046_ _03047_ _03256_ VDD VSS AOI21_X1
X_26256_ _03092_ _03035_ _03256_ _03257_ VDD VSS NOR3_X1
X_26257_ _03239_ _03258_ VDD VSS CLKBUF_X3
X_26258_ _03205_ _03258_ net998 _03259_ VDD VSS AOI21_X1
X_26259_ _03257_ _03259_ _15185_ _03260_ VDD VSS AOI21_X1
X_26260_ _03255_ _03260_ _03077_ _03261_ VDD VSS OAI21_X1
X_26261_ _03097_ _03166_ _03262_ VDD VSS NOR2_X1
X_26262_ _03097_ _03065_ _03263_ VDD VSS NOR2_X1
X_26263_ _03143_ _03184_ _03197_ _03264_ VDD VSS NAND3_X1
X_26264_ _03144_ _02999_ _15164_ _03265_ VDD VSS AOI21_X1
X_26265_ _03264_ _03265_ _03092_ _03266_ VDD VSS OAI21_X1
X_26266_ net999 _02968_ _03267_ VDD VSS NOR2_X2
X_26267_ _02937_ _02997_ _03267_ _03268_ VDD VSS NOR3_X1
X_26268_ net814 _02969_ _03269_ VDD VSS NOR2_X2
X_26269_ _02969_ _02997_ _02937_ _03270_ VDD VSS MUX2_X1
X_26270_ _03268_ _03269_ _03116_ net1003 _03270_ _03271_ VDD
+ VSS AOI221_X2
X_26271_ _03266_ _03271_ _03088_ _03272_ VDD VSS MUX2_X1
X_26272_ _03261_ _03262_ _03263_ _03272_ _03273_ VDD VSS AOI22_X1
X_26273_ _03046_ _03047_ _03029_ net809 _03274_ VDD VSS AOI22_X1
X_26274_ _03274_ _03086_ net927 _03275_ VDD VSS OAI21_X1
X_26275_ _03138_ _03086_ _03104_ _03276_ VDD VSS OAI21_X1
X_26276_ _03275_ _03276_ _03239_ _03277_ VDD VSS OAI21_X1
X_26277_ _03086_ _03184_ _03173_ _03278_ VDD VSS AND3_X1
X_26278_ _02970_ _03087_ _03053_ _03279_ VDD VSS OAI21_X1
X_26279_ _03092_ _03277_ _03278_ _03279_ _03280_ VDD VSS OAI22_X2
X_26280_ _03089_ _03166_ _03281_ VDD VSS NOR2_X1
X_26281_ _03090_ _03065_ _03282_ VDD VSS NOR2_X1
X_26282_ _03039_ _03087_ _03130_ _03283_ VDD VSS AOI21_X1
X_26283_ _03098_ net927 _03032_ _03284_ VDD VSS MUX2_X1
X_26284_ _03283_ _03126_ _03087_ _03143_ _03284_ _03285_ VDD
+ VSS OAI221_X1
X_26285_ _15186_ _03032_ _03286_ VDD VSS NAND2_X1
X_26286_ _03286_ _03076_ _15183_ _03287_ VDD VSS OAI21_X1
X_26287_ _03285_ _03287_ _03258_ _03288_ VDD VSS OAI21_X1
X_26288_ _03141_ _03280_ _03281_ _03282_ _03288_ _03289_ VDD
+ VSS AOI221_X2
X_26289_ _02975_ _03006_ _03145_ _03290_ VDD VSS OAI21_X4
X_26290_ _03143_ _02999_ _03080_ _03291_ VDD VSS OAI21_X1
X_26291_ _03290_ _03090_ _03291_ _03246_ _03292_ VDD VSS OAI211_X4
X_26292_ _02976_ _03054_ _03293_ VDD VSS NOR2_X1
X_26293_ net567 _03046_ _03047_ _03294_ VDD VSS NAND3_X1
X_26294_ _03207_ _03049_ _03050_ _03295_ VDD VSS OAI21_X1
X_26295_ _03182_ _03294_ _03295_ _03296_ VDD VSS AOI21_X1
X_26296_ _03097_ _03293_ _03296_ _03297_ VDD VSS OAI21_X1
X_26297_ _03077_ _03297_ _03292_ _03298_ VDD VSS AOI21_X4
X_26298_ _03185_ _15165_ _02973_ _03299_ VDD VSS MUX2_X1
X_26299_ _03044_ _03070_ _03299_ _03300_ VDD VSS AOI21_X1
X_26300_ net809 _02969_ _03301_ VDD VSS NAND2_X1
X_26301_ _02998_ _03301_ _03241_ _03302_ VDD VSS NAND3_X1
X_26302_ _03099_ _03205_ _03303_ VDD VSS NOR2_X1
X_26303_ _03170_ _03069_ _02937_ _03304_ VDD VSS AOI21_X1
X_26304_ _03303_ _03304_ _02974_ _03305_ VDD VSS MUX2_X1
X_26305_ _03087_ _03300_ _03302_ _03305_ _03089_ _03306_ VDD
+ VSS AOI221_X2
X_26306_ _03298_ _03166_ _03306_ _03307_ VDD VSS OR3_X4
X_26307_ _15181_ _03121_ _03111_ net568 _03308_ VDD VSS AOI22_X1
X_26308_ _03166_ _03154_ _03308_ _03309_ VDD VSS OAI21_X1
X_26309_ _03188_ _03179_ _03053_ _03310_ VDD VSS AOI21_X1
X_26310_ _15178_ _03184_ _03197_ _03311_ VDD VSS NAND3_X1
X_26311_ _03309_ _03310_ _03311_ _03312_ VDD VSS AOI21_X1
X_26312_ _03098_ _02973_ _03313_ VDD VSS NOR2_X2
X_26313_ _02998_ _03313_ _03314_ VDD VSS NOR2_X1
X_26314_ _03194_ _03241_ _03314_ _02999_ _15192_ _03315_ VDD
+ VSS AOI221_X1
X_26315_ _03157_ _03316_ VDD VSS CLKBUF_X3
X_26316_ _03080_ _03053_ _03317_ VDD VSS NOR2_X4
X_26317_ _03316_ _03258_ _03317_ _03318_ VDD VSS NAND3_X1
X_26318_ _03094_ _03319_ VDD VSS INV_X1
X_26319_ _03318_ _03191_ _03072_ _03319_ _03093_ _03320_ VDD
+ VSS OAI221_X1
X_26320_ _03315_ _03320_ _03033_ _03321_ VDD VSS AOI21_X1
X_26321_ _03060_ _03312_ _03321_ _03322_ VDD VSS AOI21_X1
X_26322_ _03273_ _03289_ _03322_ _03307_ _00122_ VDD VSS AOI22_X4
X_26323_ _02974_ _02992_ _03035_ _03323_ VDD VSS NOR3_X2
X_26324_ _03162_ _03317_ _03117_ _03324_ VDD VSS AOI21_X1
X_26325_ _03323_ _03324_ _02975_ _03325_ VDD VSS AOI21_X1
X_26326_ _15169_ _03190_ _03191_ net557 _03326_ VDD VSS AOI22_X2
X_26327_ _03142_ _03211_ _03325_ _03326_ _03045_ _03327_ VDD
+ VSS AOI221_X2
X_26328_ _15178_ _03079_ _03088_ _03328_ VDD VSS NAND3_X1
X_26329_ _15185_ _03258_ _03077_ _03329_ VDD VSS NAND3_X1
X_26330_ net1003 _03328_ _03329_ _03330_ VDD VSS AOI21_X1
X_26331_ _03094_ _03107_ _03331_ VDD VSS OR2_X1
X_26332_ net996 _03239_ _03332_ VDD VSS NOR2_X2
X_26333_ net810 _03258_ _03332_ _03076_ _03333_ VDD VSS AOI22_X1
X_26334_ _03234_ _03093_ _03331_ _03333_ _15185_ _03334_ VDD
+ VSS OAI221_X1
X_26335_ _03327_ _03330_ _03334_ _03335_ VDD VSS OAI21_X1
X_26336_ _03141_ _03065_ _03336_ VDD VSS NOR2_X2
X_26337_ _03032_ _03111_ _03094_ net1114 _03168_ _03337_ VDD
+ VSS AOI221_X2
X_26338_ _03234_ _03290_ _03337_ _03338_ VDD VSS NAND3_X2
X_26339_ _03034_ _02992_ _03252_ _03339_ VDD VSS NOR3_X1
X_26340_ net1057 _03239_ _03000_ _03340_ VDD VSS AOI21_X4
X_26341_ _03339_ _15178_ _03340_ _03341_ VDD VSS AOI21_X4
X_26342_ _03338_ _03341_ _03194_ _03342_ VDD VSS OAI21_X4
X_26343_ _15185_ _03099_ _03162_ _03343_ VDD VSS OAI21_X1
X_26344_ _02971_ _03144_ _03147_ _03344_ VDD VSS OR3_X1
X_26345_ _03045_ _03343_ _03344_ _03345_ VDD VSS NAND3_X1
X_26346_ _03267_ net1040 net998 _03346_ VDD VSS AOI21_X1
X_26347_ _03211_ _03346_ _03258_ _03102_ _03098_ _03347_ VDD
+ VSS OAI221_X1
X_26348_ _03345_ _03347_ _03348_ VDD VSS NAND2_X1
X_26349_ _03336_ _03348_ _03342_ _03349_ VDD VSS OAI21_X4
X_26350_ _03079_ _03138_ _03350_ VDD VSS NOR2_X1
X_26351_ _02976_ _03351_ VDD VSS INV_X1
X_26352_ _03351_ _03046_ _03047_ _03352_ VDD VSS NAND3_X2
X_26353_ _15185_ _03352_ _03353_ VDD VSS NAND2_X1
X_26354_ _02991_ _02982_ _03036_ _03354_ VDD VSS NAND3_X4
X_26355_ _15172_ _03003_ _03004_ _03355_ VDD VSS OAI21_X4
X_26356_ _03354_ _03355_ _03356_ VDD VSS AND2_X4
X_26357_ _03035_ _03356_ _03107_ _03357_ VDD VSS MUX2_X1
X_26358_ _03234_ _03350_ _03353_ _03357_ _15185_ _03358_ VDD
+ VSS OAI221_X1
X_26359_ _02974_ _03317_ _03359_ VDD VSS AND2_X1
X_26360_ _03258_ _03034_ net557 _03360_ VDD VSS OAI21_X1
X_26361_ _03211_ _03359_ _03360_ _03222_ _03258_ _03361_ VDD
+ VSS OAI221_X1
X_26362_ _03188_ _03111_ net998 _03362_ VDD VSS AOI21_X1
X_26363_ _03092_ _03332_ _03363_ VDD VSS NOR2_X1
X_26364_ _03362_ _03363_ net1040 _03108_ _03054_ _03364_ VDD
+ VSS OAI221_X1
X_26365_ _03358_ _03067_ _03361_ _03364_ _03365_ VDD VSS NAND4_X1
X_26366_ _03037_ _03079_ net1114 _03366_ VDD VSS AOI21_X1
X_26367_ _03030_ _03151_ _15169_ _03366_ _15178_ _03367_ VDD
+ VSS OAI221_X1
X_26368_ _03134_ _03046_ _03047_ _03368_ VDD VSS AOI21_X2
X_26369_ net1003 _03368_ _03078_ _03048_ _03127_ _03332_ _03369_
+ VDD VSS AOI222_X2
X_26370_ _03367_ _03369_ _03154_ _03370_ VDD VSS OAI21_X1
X_26371_ _03094_ _03049_ _03050_ _03371_ VDD VSS NOR3_X2
X_26372_ _02975_ _03109_ _03371_ _03372_ VDD VSS OAI21_X1
X_26373_ _02971_ _03048_ _03172_ _03373_ VDD VSS NAND3_X1
X_26374_ _03090_ _03372_ _03373_ _03374_ VDD VSS AND3_X1
X_26375_ _02971_ _02992_ net1057 _03375_ VDD VSS NOR3_X4
X_26376_ _02974_ _03158_ _03039_ _03000_ _03376_ VDD VSS AOI211_X2
X_26377_ _03234_ _03375_ _03376_ _03377_ VDD VSS NOR3_X4
X_26378_ _03377_ _03077_ _03374_ _03378_ VDD VSS NOR3_X4
X_26379_ _03085_ _03370_ _03378_ _03379_ VDD VSS OAI21_X2
X_26380_ _03379_ _03349_ _03335_ _03365_ _00123_ VDD VSS NAND4_X2
X_26381_ _03076_ _03034_ _03104_ _03380_ VDD VSS AOI21_X1
X_26382_ _03097_ _03244_ _03380_ _03381_ VDD VSS AOI21_X1
X_26383_ _15178_ _03099_ _03170_ _03382_ VDD VSS OAI21_X1
X_26384_ _03205_ _03239_ _03000_ _03383_ VDD VSS AOI21_X1
X_26385_ _03382_ _03383_ _15178_ _03384_ VDD VSS OAI21_X1
X_26386_ _03381_ _03384_ _03088_ _03385_ VDD VSS OAI21_X1
X_26387_ _03143_ _03051_ _03352_ _03386_ VDD VSS AOI21_X1
X_26388_ _03386_ _03356_ _03092_ _03387_ VDD VSS AOI21_X1
X_26389_ _03188_ _03387_ _03388_ VDD VSS OR2_X1
X_26390_ _03088_ _03078_ _03258_ _03389_ VDD VSS AOI21_X1
X_26391_ _03113_ _03389_ _03390_ VDD VSS NAND2_X1
X_26392_ _03085_ _03385_ _03388_ _03390_ _03391_ VDD VSS NAND4_X1
X_26393_ _03005_ _03239_ net998 _03392_ VDD VSS AOI21_X1
X_26394_ _03089_ _03102_ _03104_ _03392_ _02971_ _03393_ VDD
+ VSS OAI221_X1
X_26395_ _03072_ _03301_ _03239_ _03394_ VDD VSS MUX2_X1
X_26396_ _03393_ _03394_ _03090_ _03395_ VDD VSS OAI21_X1
X_26397_ _03116_ _03197_ _03396_ VDD VSS NAND2_X1
X_26398_ _03044_ _03190_ _03118_ _03396_ _03134_ _03397_ VDD
+ VSS AOI221_X2
X_26399_ net999 _03054_ _03093_ net996 _03398_ VDD VSS OAI22_X2
X_26400_ _03116_ _02974_ net996 _03399_ VDD VSS OAI21_X1
X_26401_ _03015_ _03398_ _03399_ _03104_ _03400_ VDD VSS AOI211_X2
X_26402_ _03043_ _03069_ _03401_ VDD VSS NAND2_X1
X_26403_ _03080_ _03096_ _03039_ _03402_ VDD VSS NAND3_X1
X_26404_ _02971_ _03401_ _03402_ _03403_ VDD VSS AOI21_X1
X_26405_ _03216_ _02970_ _03096_ _03039_ _03404_ VDD VSS NAND4_X1
X_26406_ _03096_ _03355_ _03405_ VDD VSS OR2_X1
X_26407_ _03000_ _03157_ _03096_ _03406_ VDD VSS OAI21_X1
X_26408_ net1040 _03404_ _03405_ _03406_ _03407_ VDD VSS NAND4_X1
X_26409_ _03397_ _03400_ _03403_ _03407_ _03408_ VDD VSS OAI22_X1
X_26410_ _03395_ _03408_ _03077_ _03409_ VDD VSS MUX2_X1
X_26411_ _03134_ _03044_ _03410_ VDD VSS NAND2_X1
X_26412_ _03239_ _03241_ _03044_ _03410_ _03216_ _03411_ VDD
+ VSS OAI221_X1
X_26413_ _15169_ _03134_ _03096_ _03412_ VDD VSS AOI21_X1
X_26414_ _03127_ _03412_ _03000_ _03413_ VDD VSS OAI21_X1
X_26415_ _03411_ _03413_ _03121_ _03414_ VDD VSS OAI21_X1
X_26416_ _03169_ _03096_ _02970_ _03415_ VDD VSS OAI21_X1
X_26417_ _03087_ _03415_ net1114 _03416_ VDD VSS AOI21_X1
X_26418_ _03197_ _02998_ net927 _03417_ VDD VSS OAI21_X1
X_26419_ _03127_ _03417_ _03182_ _03418_ VDD VSS OAI21_X1
X_26420_ _03355_ _03100_ _02970_ _03419_ VDD VSS OAI21_X1
X_26421_ _03418_ _03419_ _03089_ _03420_ VDD VSS MUX2_X1
X_26422_ _03065_ _03414_ _03416_ _03420_ _03088_ _03421_ VDD
+ VSS AOI221_X2
X_26423_ net1040 _03190_ _03352_ _03092_ _03422_ VDD VSS AOI22_X1
X_26424_ _03065_ _03154_ _03422_ _03423_ VDD VSS OAI21_X1
X_26425_ _03185_ _02970_ _03424_ VDD VSS NOR2_X1
X_26426_ _02999_ _03130_ _03424_ _03425_ VDD VSS OAI21_X1
X_26427_ _03425_ _03074_ _03426_ VDD VSS AND2_X2
X_26428_ _03208_ _03410_ _03427_ VDD VSS NOR2_X1
X_26429_ _03053_ _03216_ _03039_ _03428_ VDD VSS MUX2_X1
X_26430_ _03092_ _03428_ _03429_ VDD VSS NOR2_X1
X_26431_ _02975_ _03230_ _03430_ VDD VSS NOR2_X1
X_26432_ _03077_ _03426_ _03427_ _03429_ _03430_ _03194_ _03431_
+ VDD VSS OAI33_X1
X_26433_ _03060_ _03431_ _03423_ _03432_ VDD VSS OAI21_X1
X_26434_ _03391_ _03409_ _03142_ _03432_ _03421_ _00124_ VDD
+ VSS OAI221_X1
X_26435_ _03144_ _02997_ _02976_ _03433_ VDD VSS AOI21_X2
X_26436_ _03089_ _03151_ net995 _03433_ _03157_ _03434_ VDD
+ VSS OAI221_X2
X_26437_ net997 _02954_ _02968_ _03435_ VDD VSS MUX2_X1
X_26438_ _03043_ _02997_ _03436_ VDD VSS NOR2_X1
X_26439_ _03185_ net812 _03437_ VDD VSS NOR2_X1
X_26440_ _03043_ _03068_ _03437_ _03438_ VDD VSS NOR3_X2
X_26441_ _03029_ _03435_ _03436_ _03438_ _03127_ _03439_ VDD
+ VSS AOI221_X2
X_26442_ net1114 _03048_ _03190_ net1040 _03440_ VDD VSS OAI22_X1
X_26443_ _03066_ _03434_ _03439_ _03440_ _03045_ _03441_ VDD
+ VSS AOI221_X2
X_26444_ _03053_ _02998_ _03051_ _03114_ _03442_ VDD VSS AOI22_X1
X_26445_ _03336_ _03442_ _03194_ _03443_ VDD VSS OAI21_X1
X_26446_ _03182_ _03356_ _03444_ VDD VSS NAND2_X1
X_26447_ _03154_ _03006_ _03134_ _03445_ VDD VSS AOI21_X1
X_26448_ _03351_ _02937_ _02997_ _03446_ VDD VSS MUX2_X1
X_26449_ _03188_ _03446_ _03115_ _03447_ VDD VSS AOI21_X1
X_26450_ _03443_ _03444_ _03445_ _03447_ _03159_ _03448_ VDD
+ VSS AOI221_X2
X_26451_ _03178_ _03441_ _03448_ _03449_ VDD VSS OAI21_X1
X_26452_ _03094_ _03359_ _03086_ _03450_ VDD VSS MUX2_X1
X_26453_ _03079_ _03450_ _03451_ VDD VSS NOR2_X1
X_26454_ _03117_ _03086_ _03313_ _03157_ net995 _03452_ VDD
+ VSS AOI221_X1
X_26455_ _03234_ _03451_ _03452_ _03453_ VDD VSS NOR3_X1
X_26456_ _02976_ _03102_ _03437_ _03121_ _03454_ VDD VSS OAI22_X1
X_26457_ _03166_ _03454_ _03033_ _03455_ VDD VSS AOI21_X1
X_26458_ _03316_ _03184_ _03354_ _03456_ VDD VSS NAND3_X1
X_26459_ _03456_ _03433_ _03034_ _03457_ VDD VSS OAI21_X1
X_26460_ _03455_ _03457_ _03194_ _03458_ VDD VSS OAI21_X1
X_26461_ _15158_ _03096_ net1114 _03459_ VDD VSS AOI21_X1
X_26462_ _03107_ _03401_ _03222_ _03459_ _03093_ _03460_ VDD
+ VSS OAI221_X1
X_26463_ _03090_ _03214_ _03461_ VDD VSS XNOR2_X1
X_26464_ _03460_ _03461_ net998 _03462_ VDD VSS AOI21_X1
X_26465_ _03204_ _02999_ net810 _03463_ VDD VSS AOI21_X1
X_26466_ _03030_ _03151_ net998 _03463_ _03034_ _03464_ VDD
+ VSS OAI221_X1
X_26467_ _03109_ _02999_ _02976_ _03465_ VDD VSS AOI21_X1
X_26468_ _03211_ _03465_ _03316_ _03054_ net1003 _03466_ VDD
+ VSS OAI221_X1
X_26469_ _03166_ _03464_ _03466_ _03467_ VDD VSS NAND3_X1
X_26470_ _03141_ _03453_ _03458_ _03462_ _03467_ _03468_ VDD
+ VSS OAI221_X1
X_26471_ _15185_ _03099_ _03252_ _03469_ VDD VSS OAI21_X1
X_26472_ _03469_ _03366_ _15185_ _03470_ VDD VSS OAI21_X1
X_26473_ _03115_ _03091_ _03471_ VDD VSS NOR2_X1
X_26474_ _03471_ _03111_ net557 _03258_ _03053_ _03472_ VDD
+ VSS AOI221_X2
X_26475_ _03441_ _03470_ _03472_ _03448_ _03473_ VDD VSS AOI22_X1
X_26476_ _03449_ _03468_ _03473_ _00125_ VDD VSS AND3_X2
X_26477_ _03122_ _03115_ _03474_ VDD VSS NOR2_X1
X_26478_ _03117_ _03313_ _03475_ VDD VSS OR2_X2
X_26479_ _03107_ _03475_ _03474_ _03079_ _15181_ _03476_ VDD
+ VSS OAI221_X2
X_26480_ _03371_ _03121_ _02972_ _03477_ VDD VSS AOI21_X1
X_26481_ _03076_ _03054_ net568 _03477_ _03316_ _03478_ VDD
+ VSS OAI221_X1
X_26482_ _03476_ _03234_ _03478_ _03479_ VDD VSS NAND3_X2
X_26483_ _03182_ _03116_ _03354_ _03480_ VDD VSS AOI21_X1
X_26484_ _03070_ _03317_ _03481_ VDD VSS NOR2_X1
X_26485_ _03115_ _03247_ _03481_ _03482_ VDD VSS NOR3_X1
X_26486_ _03154_ _03480_ _03482_ _03483_ VDD VSS OR3_X2
X_26487_ _03316_ _03340_ _03484_ VDD VSS AND2_X1
X_26488_ _03316_ _03101_ _03485_ VDD VSS NOR2_X1
X_26489_ _03045_ _03484_ _03485_ _03486_ VDD VSS OAI21_X2
X_26490_ _03085_ _03479_ _03483_ _03486_ _03487_ VDD VSS AND4_X4
X_26491_ _03256_ _03079_ _03094_ _03488_ VDD VSS AOI21_X1
X_26492_ _03090_ _03054_ net998 _03488_ _15178_ _03489_ VDD
+ VSS OAI221_X1
X_26493_ _03088_ _03300_ _03490_ VDD VSS NOR2_X1
X_26494_ _03489_ _03490_ _03491_ VDD VSS NAND2_X1
X_26495_ _03090_ _03150_ _03323_ _03492_ VDD VSS OAI21_X1
X_26496_ _03089_ _03121_ _15180_ _03493_ VDD VSS AOI21_X1
X_26497_ _03079_ _03316_ _03104_ _03494_ VDD VSS OAI21_X1
X_26498_ _03493_ _03494_ _03269_ _03495_ VDD VSS OAI21_X1
X_26499_ _03088_ _03492_ _03495_ _03496_ VDD VSS NAND3_X1
X_26500_ _03142_ _03491_ _03496_ _03497_ VDD VSS AOI21_X1
X_26501_ _03355_ _03070_ _03108_ _03498_ VDD VSS OAI21_X1
X_26502_ _03032_ _03179_ net810 _03498_ _03157_ _03499_ VDD
+ VSS AOI221_X2
X_26503_ _03316_ _03048_ _03355_ _03500_ VDD VSS NAND3_X1
X_26504_ _03080_ _03053_ _03049_ _03050_ _03501_ VDD VSS OAI22_X2
X_26505_ _03501_ _03121_ _03122_ _03502_ VDD VSS OAI21_X1
X_26506_ _03500_ _03502_ _03034_ _03503_ VDD VSS OAI21_X1
X_26507_ _03499_ _03503_ _03077_ _03504_ VDD VSS AOI21_X2
X_26508_ _03234_ _03336_ _03505_ VDD VSS NAND2_X1
X_26509_ _03097_ _03336_ _03506_ VDD VSS NAND2_X1
X_26510_ _03205_ _03070_ _03118_ _03507_ VDD VSS AOI21_X1
X_26511_ _03173_ _02998_ _03207_ _03508_ VDD VSS OAI21_X1
X_26512_ _03507_ _03508_ _03134_ _03509_ VDD VSS MUX2_X1
X_26513_ _15179_ _15188_ _03070_ _03510_ VDD VSS NOR3_X1
X_26514_ _02954_ _03114_ _02972_ _03511_ VDD VSS MUX2_X1
X_26515_ _03510_ _03511_ _03239_ _03512_ VDD VSS AOI21_X1
X_26516_ _03509_ _03512_ _03107_ _03513_ VDD VSS MUX2_X1
X_26517_ _03504_ _03505_ _03506_ _03513_ _03514_ VDD VSS OAI22_X4
X_26518_ net998 _03316_ _03168_ _03515_ VDD VSS OAI21_X1
X_26519_ _15169_ _03368_ _03111_ net567 _03516_ VDD VSS AOI22_X1
X_26520_ _03107_ _03515_ _03516_ _03517_ VDD VSS NAND3_X1
X_26521_ _03354_ _03157_ _03355_ _03518_ VDD VSS AND3_X4
X_26522_ _03182_ _03168_ _03519_ VDD VSS NOR2_X1
X_26523_ _03518_ _03087_ _03519_ _03520_ VDD VSS OR3_X4
X_26524_ _03097_ _03517_ _03520_ _03521_ VDD VSS NAND3_X4
X_26525_ _03267_ _03114_ _03098_ _03522_ VDD VSS AOI21_X1
X_26526_ _15190_ _03522_ _03039_ _03523_ VDD VSS MUX2_X1
X_26527_ _03107_ _03126_ _03079_ _03524_ VDD VSS OAI21_X1
X_26528_ net1040 _03316_ _03151_ _02976_ _03525_ VDD VSS OAI22_X1
X_26529_ _03234_ _03523_ _03088_ _03524_ _03525_ _03526_ VDD
+ VSS OAI221_X2
X_26530_ _03066_ _03526_ _03521_ _03527_ VDD VSS AOI21_X4
X_26531_ _03487_ _03497_ _03514_ _03527_ _00126_ VDD VSS NOR4_X4
X_26532_ _03354_ _03401_ _03098_ _03528_ VDD VSS OAI21_X1
X_26533_ _03182_ _03528_ _03529_ VDD VSS NAND2_X1
X_26534_ _03093_ _02997_ _03043_ _03530_ VDD VSS OAI21_X1
X_26535_ _03029_ _03530_ net995 _02969_ _03014_ _03531_ VDD
+ VSS AOI221_X2
X_26536_ _03207_ _02973_ _03043_ _03069_ _03532_ VDD VSS NOR4_X1
X_26537_ _15169_ _03114_ _03533_ VDD VSS NOR2_X1
X_26538_ _03532_ _03533_ _03129_ _03534_ VDD VSS AOI21_X1
X_26539_ _03015_ _03069_ _03535_ VDD VSS NOR2_X1
X_26540_ _03535_ _03436_ _02972_ _03536_ VDD VSS AOI21_X1
X_26541_ _03114_ _03043_ _03069_ _03537_ VDD VSS NOR3_X1
X_26542_ _03179_ _03537_ _03538_ VDD VSS NOR2_X1
X_26543_ _03534_ _03536_ _15158_ _03538_ _03000_ _03539_ VDD
+ VSS OAI221_X2
X_26544_ _03142_ _03529_ _03531_ _03539_ _03087_ _03540_ VDD
+ VSS AOI221_X2
X_26545_ _03143_ _03294_ _03195_ _03541_ VDD VSS AOI21_X1
X_26546_ _03090_ _03430_ _03541_ _03542_ VDD VSS OAI21_X1
X_26547_ _03097_ _03079_ net995 _03093_ _03118_ _03543_ VDD
+ VSS OAI221_X1
X_26548_ _03088_ _03542_ _03543_ _03544_ VDD VSS NAND3_X1
X_26549_ _03104_ _03134_ _03545_ VDD VSS NOR2_X1
X_26550_ _03121_ _03130_ _03545_ _03546_ VDD VSS NOR3_X1
X_26551_ _03211_ _02999_ _15188_ _03547_ VDD VSS OAI21_X1
X_26552_ _03085_ _03546_ _03547_ _03548_ VDD VSS OAI21_X1
X_26553_ _03246_ _03037_ _03549_ VDD VSS NOR2_X1
X_26554_ _03201_ _03549_ _03034_ _03550_ VDD VSS AOI21_X1
X_26555_ _03548_ _03550_ _03030_ _03551_ VDD VSS AOI21_X1
X_26556_ _03108_ _02969_ _03552_ VDD VSS NOR2_X1
X_26557_ _03100_ _03069_ _02937_ _03553_ VDD VSS AOI21_X1
X_26558_ _03552_ _03553_ _03114_ _03554_ VDD VSS AOI21_X1
X_26559_ _02974_ _03144_ _03147_ _03555_ VDD VSS NOR3_X1
X_26560_ _03198_ _03555_ _03556_ VDD VSS OR2_X1
X_26561_ _03065_ _03211_ _03554_ _03045_ _03556_ _03557_ VDD
+ VSS AOI221_X2
X_26562_ _03501_ _03070_ net996 _03558_ VDD VSS OAI21_X1
X_26563_ _03180_ _03355_ _03559_ VDD VSS NAND2_X1
X_26564_ _03558_ _03559_ _03134_ _03560_ VDD VSS MUX2_X1
X_26565_ _03170_ _03511_ _03121_ _03561_ VDD VSS AOI21_X1
X_26566_ _03560_ _03561_ _03076_ _03562_ VDD VSS MUX2_X1
X_26567_ _03557_ _03562_ _03097_ _03563_ VDD VSS OAI21_X2
X_26568_ _03178_ _03114_ _03227_ _03564_ VDD VSS AOI21_X2
X_26569_ _02976_ _03054_ _03093_ _15169_ _03191_ net1003 _03565_
+ VDD VSS OAI222_X2
X_26570_ _03166_ _03110_ _03564_ _03565_ _03030_ _03566_ VDD
+ VSS AOI221_X2
X_26571_ _03107_ _03102_ net557 _03383_ _02971_ _03567_ VDD
+ VSS OAI221_X1
X_26572_ _02976_ _03046_ _03047_ _03568_ VDD VSS NAND3_X1
X_26573_ _02975_ _03116_ _03568_ _03569_ VDD VSS NAND3_X1
X_26574_ _03115_ _03173_ _02999_ _03000_ _03570_ VDD VSS OAI211_X2
X_26575_ _03076_ _03569_ _03570_ _03571_ VDD VSS NAND3_X1
X_26576_ _03097_ _03567_ _03571_ _03572_ VDD VSS NAND3_X1
X_26577_ _03141_ _03572_ _03566_ _03573_ VDD VSS AOI21_X2
X_26578_ _03540_ _03544_ _03551_ _03563_ _03573_ _00127_ VDD
+ VSS AOI221_X2
X_26579_ _06340_ _03574_ VDD VSS INV_X1
X_26580_ _03574_ _09730_ _03575_ VDD VSS NOR2_X1
X_26581_ _06340_ _09728_ _03576_ VDD VSS NOR2_X1
X_26582_ _09152_ _08978_ _03577_ VDD VSS XNOR2_X2
X_26583_ _03577_ _11856_ _03578_ VDD VSS XNOR2_X2
X_26584_ _08983_ sa00_sr\[1\] _03579_ VDD VSS XNOR2_X2
X_26585_ _03578_ _03579_ _03580_ VDD VSS XNOR2_X2
X_26586_ _03575_ _03576_ _03580_ _03581_ VDD VSS MUX2_X2
X_26587_ _06340_ _09856_ _00476_ _03582_ VDD VSS OR3_X2
X_26588_ _06340_ _09103_ _00476_ _03583_ VDD VSS NAND3_X2
X_26589_ _03583_ _03582_ _03584_ VDD VSS NAND2_X4
X_26590_ _03581_ _03584_ _03585_ VDD VSS NOR2_X4
X_26591_ net632 _03586_ VDD VSS INV_X8
Xclone138 net495 net138 VDD VSS INV_X4
X_26593_ _03586_ _03588_ VDD VSS BUF_X16
Xclone489 _03586_ net1108 VDD VSS BUF_X8
X_26595_ sa00_sr\[0\] _03577_ _03589_ VDD VSS XNOR2_X1
X_26596_ _06325_ _09022_ _09019_ _03590_ VDD VSS NAND3_X1
X_26597_ _06325_ net831 _03591_ VDD VSS NOR2_X1
X_26598_ _09007_ _03591_ _03592_ VDD VSS NAND2_X1
X_26599_ _03589_ _03590_ _03592_ _03593_ VDD VSS AOI21_X1
X_26600_ sa00_sr\[0\] net951 _03594_ VDD VSS XOR2_X1
X_26601_ _09019_ _03591_ _03595_ VDD VSS NAND2_X1
X_26602_ _06325_ net829 _09007_ _03596_ VDD VSS NAND3_X1
X_26603_ _03594_ _03595_ _03596_ _03597_ VDD VSS AOI21_X1
X_26604_ _06325_ _03598_ VDD VSS INV_X1
X_26605_ _03598_ net1083 _00477_ _03599_ VDD VSS NAND3_X1
X_26606_ _06325_ _09726_ _03600_ VDD VSS NAND2_X1
X_26607_ _03599_ _03600_ _00477_ _03601_ VDD VSS OAI21_X1
X_26608_ _03593_ _03597_ _03601_ _03602_ VDD VSS OR3_X4
X_26610_ _03602_ _03604_ VDD VSS INV_X8
X_26611_ _03604_ _03605_ VDD VSS BUF_X16
X_26612_ _03605_ _15203_ VDD VSS BUF_X16
X_26613_ _09088_ _09042_ _03606_ VDD VSS XNOR2_X1
X_26614_ _06355_ _03607_ VDD VSS INV_X1
X_26615_ _03607_ _11938_ _11844_ _03608_ VDD VSS NOR3_X1
X_26616_ _06355_ _11841_ net625 _03609_ VDD VSS NOR3_X1
X_26617_ _03606_ _03608_ _03609_ _03610_ VDD VSS OAI21_X1
X_26618_ _09088_ _09044_ _03611_ VDD VSS XNOR2_X1
X_26619_ _06355_ _08994_ _11844_ _03612_ VDD VSS NOR3_X1
X_26620_ _03607_ _11841_ net625 _03613_ VDD VSS NOR3_X1
X_26621_ _03611_ _03612_ _03613_ _03614_ VDD VSS OAI21_X1
X_26622_ _06355_ _09030_ _03615_ VDD VSS NAND2_X1
X_26623_ _03607_ _09030_ _03616_ VDD VSS NAND2_X1
X_26624_ _03615_ _03616_ _00478_ _03617_ VDD VSS MUX2_X1
X_26625_ _03610_ _03614_ _03617_ _03618_ VDD VSS AND3_X4
X_26626_ _03618_ _03619_ VDD VSS INV_X4
X_26627_ _03619_ _03620_ VDD VSS BUF_X4
X_26628_ _03620_ _03621_ VDD VSS CLKBUF_X3
X_26629_ _03621_ _15219_ VDD VSS BUF_X4
X_26630_ _03602_ _15194_ VDD VSS BUF_X4
X_26631_ _03618_ _03622_ VDD VSS BUF_X4
X_26632_ _03622_ _03623_ VDD VSS CLKBUF_X3
X_26633_ _03623_ _03624_ VDD VSS BUF_X4
X_26634_ _03624_ _15212_ VDD VSS BUF_X4
X_26635_ _09138_ text_in_r\[100\] _03625_ VDD VSS OR2_X1
X_26636_ _09189_ _01016_ _03626_ VDD VSS XNOR2_X2
X_26637_ _06403_ _03625_ _03626_ _09824_ _03627_ VDD VSS OAI211_X4
X_26638_ _06403_ _03628_ VDD VSS INV_X1
X_26639_ _09824_ text_in_r\[100\] _03629_ VDD VSS NAND2_X1
X_26640_ _09189_ _01016_ _03630_ VDD VSS XOR2_X2
X_26641_ _03628_ _03629_ _03630_ _09824_ _03631_ VDD VSS OAI211_X4
X_26642_ _03627_ _03631_ _03632_ VDD VSS NAND2_X4
X_26643_ _03632_ _03633_ VDD VSS CLKBUF_X3
X_26644_ _09162_ _09165_ _03634_ VDD VSS XOR2_X2
X_26645_ _06417_ _09158_ _03634_ _03635_ VDD VSS NAND3_X1
X_26646_ _06417_ _09180_ _03636_ VDD VSS NOR2_X1
X_26647_ _03634_ _03636_ _03637_ VDD VSS NAND2_X1
X_26648_ _03635_ _03637_ _00996_ _03638_ VDD VSS MUX2_X2
X_26649_ _09162_ _09165_ _03639_ VDD VSS XNOR2_X1
X_26650_ _03639_ _03636_ _03640_ VDD VSS NAND2_X1
X_26651_ _06417_ _09158_ _03639_ _03641_ VDD VSS NAND3_X1
X_26652_ _03640_ _03641_ _00996_ _03642_ VDD VSS MUX2_X2
X_26653_ _06417_ _09803_ text_in_r\[101\] _03643_ VDD VSS
+ OR3_X2
X_26654_ _06417_ _09136_ text_in_r\[101\] _03644_ VDD VSS
+ NAND3_X2
X_26655_ _03638_ _03642_ _03643_ _03644_ _03645_ VDD VSS AND4_X4
X_26656_ _03645_ _03646_ VDD VSS CLKBUF_X3
X_26657_ _03619_ _03647_ VDD VSS BUF_X4
Xclone2 _11851_ _11848_ net2 VDD VSS NOR2_X2
X_26659_ _15210_ _03649_ VDD VSS INV_X4
X_26660_ _06386_ _03650_ VDD VSS INV_X1
X_26661_ text_in_r\[99\] _03651_ VDD VSS BUF_X2
X_26662_ _09116_ _03651_ _03652_ VDD VSS NOR2_X1
X_26663_ _09091_ _01034_ _03653_ VDD VSS XOR2_X2
X_26664_ _03650_ _03652_ _03653_ _09175_ _03654_ VDD VSS AOI211_X4
X_26665_ _03654_ _03655_ VDD VSS BUF_X8
X_26666_ _03651_ _03656_ VDD VSS INV_X1
X_26667_ net871 _03656_ _03657_ VDD VSS NOR2_X1
X_26668_ _09091_ _01034_ _03658_ VDD VSS XNOR2_X2
X_26669_ _06386_ _03657_ _03658_ net1039 _03659_ VDD VSS AOI211_X4
X_26670_ _03659_ _03660_ VDD VSS BUF_X8
X_26671_ _03655_ _03649_ _03660_ _03661_ VDD VSS NOR3_X4
X_26672_ _08996_ _03656_ _03662_ VDD VSS NAND2_X1
X_26673_ _06386_ _03662_ _03658_ _09824_ _03663_ VDD VSS OAI211_X4
X_26674_ _03663_ _03664_ VDD VSS BUF_X8
X_26675_ _09135_ _03651_ _03665_ VDD VSS NAND2_X1
X_26676_ _03650_ _03665_ _03653_ _09824_ _03666_ VDD VSS OAI211_X4
X_26677_ _03666_ _03667_ VDD VSS BUF_X8
X_26678_ net532 net805 _03664_ _03667_ _03668_ VDD VSS AOI211_X2
X_26679_ _03647_ _03661_ _03668_ _03669_ VDD VSS OAI21_X2
X_26680_ _03622_ _03664_ _03667_ _03670_ VDD VSS NAND3_X1
X_26681_ _03670_ _03671_ VDD VSS BUF_X4
X_26682_ _15197_ _03672_ VDD VSS BUF_X4
X_26683_ _03672_ _03673_ VDD VSS INV_X4
X_26684_ _03673_ _03674_ VDD VSS BUF_X4
X_26685_ _03654_ _03659_ _03675_ VDD VSS NOR2_X4
X_26686_ _03675_ _03676_ VDD VSS BUF_X4
X_26687_ _03676_ _03677_ VDD VSS BUF_X4
X_26688_ _03669_ _03671_ net137 _15194_ _03677_ _03678_ VDD
+ VSS OAI221_X1
X_26689_ _06340_ _11192_ _03679_ VDD VSS NAND2_X1
X_26690_ _03574_ _11192_ _03680_ VDD VSS NAND2_X1
X_26691_ _03679_ _03680_ net637 _03681_ VDD VSS MUX2_X2
X_26692_ _03582_ _03583_ _03682_ VDD VSS AND2_X2
X_26693_ _03681_ _03682_ _03655_ _03660_ _03683_ VDD VSS OAI211_X4
X_26694_ _03605_ _03618_ _03684_ VDD VSS NOR2_X2
X_26695_ _03646_ _03683_ _03684_ _03685_ VDD VSS AOI21_X1
X_26696_ _03623_ _03686_ VDD VSS BUF_X4
X_26697_ _03686_ _03687_ VDD VSS CLKBUF_X3
X_26698_ _03664_ _03688_ VDD VSS BUF_X4
X_26699_ _03667_ _03689_ VDD VSS BUF_X4
X_26700_ net638 _03688_ _03689_ _03690_ VDD VSS NAND3_X1
X_26701_ net533 net805 _03654_ _03659_ _03691_ VDD VSS OAI22_X4
X_26702_ _03687_ _03690_ _03691_ _03692_ VDD VSS NAND3_X1
X_26703_ _03633_ _03646_ _03678_ _03685_ _03692_ _03693_ VDD
+ VSS AOI221_X1
X_26704_ _09014_ _11897_ _03694_ VDD VSS XNOR2_X1
X_26705_ _09151_ _03694_ _03695_ VDD VSS XNOR2_X1
X_26706_ text_in_r\[103\] _03695_ _11192_ _03696_ VDD VSS
+ MUX2_X2
X_26707_ _06439_ _03696_ _03697_ VDD VSS XNOR2_X1
X_26708_ _03697_ _03698_ VDD VSS CLKBUF_X3
Xclone136 _03716_ net136 VDD VSS BUF_X8
X_26710_ _15201_ _03700_ VDD VSS INV_X4
X_26711_ _03620_ _03655_ _03660_ _03701_ VDD VSS NOR3_X4
X_26712_ _03681_ _03682_ _03663_ _03666_ _03702_ VDD VSS NAND4_X4
X_26713_ _03700_ _03701_ _03702_ _03684_ _03703_ VDD VSS AOI22_X1
X_26714_ _03632_ _03645_ _03704_ VDD VSS NAND2_X2
X_26715_ _03704_ _03705_ VDD VSS BUF_X4
X_26716_ _03627_ _03631_ _03706_ VDD VSS AND2_X1
X_26717_ _03706_ _03707_ VDD VSS CLKBUF_X3
X_26718_ _03707_ _03708_ VDD VSS BUF_X4
X_26719_ _03663_ _03666_ _03709_ VDD VSS NAND2_X4
X_26720_ _03602_ _03619_ _03710_ VDD VSS NOR2_X4
X_26721_ _03709_ _03684_ _03710_ _03586_ _03711_ VDD VSS AOI211_X2
X_26722_ _03708_ _03711_ _03712_ VDD VSS OR2_X1
X_26723_ _03638_ _03642_ _03643_ _03644_ _03713_ VDD VSS NAND4_X4
X_26724_ _03713_ _03714_ VDD VSS BUF_X4
X_26725_ _03714_ _03715_ VDD VSS BUF_X4
X_26726_ _03585_ _03716_ VDD VSS BUF_X8
X_26727_ net135 _03686_ _03717_ VDD VSS NOR2_X1
X_26728_ _03709_ _03718_ VDD VSS BUF_X4
X_26729_ _03718_ _03719_ VDD VSS CLKBUF_X3
X_26730_ _03621_ _03720_ VDD VSS CLKBUF_X3
X_26731_ _15198_ _03721_ VDD VSS BUF_X2
X_26732_ _03721_ _03722_ VDD VSS BUF_X4
X_26733_ _03719_ _03720_ _03722_ _03723_ VDD VSS OAI21_X1
X_26734_ _03715_ _03717_ _03723_ _03724_ VDD VSS OAI21_X1
X_26735_ _03698_ _03703_ _03705_ _03712_ _03724_ _03725_ VDD
+ VSS OAI221_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
X_26737_ _03709_ _03727_ VDD VSS BUF_X4
X_26738_ _15206_ _03727_ _03728_ VDD VSS NAND2_X1
X_26739_ _03708_ _03671_ net137 _03728_ _03621_ _03729_ VDD
+ VSS OAI221_X1
X_26740_ _03605_ _03654_ _03659_ _03730_ VDD VSS NOR3_X4
X_26741_ _03632_ _03730_ _03731_ VDD VSS NAND2_X1
X_26742_ _15201_ _03732_ VDD VSS BUF_X4
X_26743_ _03732_ _03677_ _03733_ VDD VSS NOR2_X1
X_26744_ _03687_ _03733_ _03734_ VDD VSS NOR2_X1
X_26745_ _03646_ _03712_ _03729_ _03731_ _03734_ _03735_ VDD
+ VSS AOI221_X1
X_26746_ _06439_ _03696_ _03736_ VDD VSS XOR2_X2
X_26747_ _03727_ _03737_ VDD VSS BUF_X4
X_26748_ _03672_ _03738_ VDD VSS BUF_X4
X_26749_ _03738_ _03647_ _03739_ VDD VSS NAND2_X1
X_26750_ _03622_ net805 net532 _03740_ VDD VSS OAI21_X4
X_26751_ _03737_ _03739_ _03740_ _03741_ VDD VSS NAND3_X1
X_26752_ _03677_ _03742_ VDD VSS BUF_X4
X_26753_ _15204_ _03743_ VDD VSS BUF_X4
X_26754_ _03743_ _03686_ _03744_ VDD VSS NOR2_X1
X_26755_ _03742_ _03710_ _03744_ _03745_ VDD VSS OAI21_X1
X_26756_ _03741_ _03745_ _03746_ VDD VSS NAND2_X1
X_26757_ _03708_ _03645_ _03747_ VDD VSS NAND2_X4
X_26758_ _03622_ _03655_ _03660_ _03748_ VDD VSS OAI21_X4
X_26759_ _03732_ _03671_ _03748_ _03722_ _03749_ VDD VSS OAI22_X1
X_26760_ _03622_ _03688_ _03689_ _03750_ VDD VSS AOI21_X4
Xclone139 _03586_ net139 VDD VSS BUF_X4
X_26762_ _03749_ _03750_ _15196_ _03752_ VDD VSS AOI21_X1
X_26763_ _03736_ _03705_ _03746_ _03747_ _03752_ _03753_ VDD
+ VSS OAI221_X1
X_26764_ _03693_ _03725_ _03735_ _03753_ _03754_ VDD VSS OAI22_X1
X_26765_ _03721_ _03664_ _03667_ _03755_ VDD VSS AOI21_X4
X_26766_ _03755_ _03730_ net138 _03756_ VDD VSS AOI21_X1
X_26767_ _03622_ _03655_ _03660_ _03757_ VDD VSS NOR3_X2
X_26768_ _03757_ _03758_ VDD VSS BUF_X4
X_26769_ _03705_ _03756_ _03687_ _03758_ net804 _03759_ VDD
+ VSS AOI221_X2
X_26770_ _03736_ _03760_ VDD VSS CLKBUF_X3
X_26771_ _03715_ _03761_ VDD VSS CLKBUF_X3
X_26772_ _03707_ _03762_ VDD VSS BUF_X4
X_26773_ _03762_ _03763_ VDD VSS BUF_X4
X_26774_ _03602_ net805 net532 _03764_ VDD VSS OAI21_X2
X_26775_ _03718_ _03764_ _03647_ _03765_ VDD VSS OAI21_X2
X_26776_ _03743_ _03766_ VDD VSS INV_X2
X_26777_ _03766_ _03623_ _03767_ VDD VSS NOR2_X2
X_26778_ _03722_ _03688_ _03689_ _03768_ VDD VSS NAND3_X2
X_26779_ _03763_ _03765_ _03767_ _03768_ _15219_ _03769_ VDD
+ VSS OAI221_X1
X_26780_ _03760_ _03761_ _03769_ _03770_ VDD VSS OAI21_X1
X_26781_ _03646_ _03771_ VDD VSS BUF_X4
X_26782_ _03632_ _03772_ VDD VSS BUF_X4
X_26783_ _15196_ _03773_ VDD VSS INV_X2
X_26784_ _03772_ _03748_ _03764_ _03671_ _03773_ _03774_ VDD
+ VSS OAI221_X1
X_26785_ _03730_ _03755_ _03775_ VDD VSS OR2_X1
X_26786_ _03774_ _03775_ _03720_ _03776_ VDD VSS AOI21_X1
X_26787_ net635 _03655_ _03660_ _03777_ VDD VSS OAI21_X4
X_26788_ _03620_ _03707_ _03778_ VDD VSS NAND2_X2
X_26789_ _03707_ _03676_ _03779_ VDD VSS NAND2_X1
X_26790_ _15217_ _03780_ VDD VSS INV_X1
X_26791_ _03777_ _03778_ _03779_ _03780_ _03781_ VDD VSS OAI22_X1
X_26792_ _03700_ _03762_ _03765_ _03782_ VDD VSS NOR3_X1
X_26793_ _03771_ _03776_ _03781_ _03782_ _03783_ VDD VSS NOR4_X2
X_26794_ _03627_ _03631_ _03655_ _03660_ _03784_ VDD VSS OAI211_X4
X_26795_ _03738_ _03687_ _03715_ _03785_ VDD VSS NAND3_X1
X_26796_ _03605_ _03647_ _03786_ VDD VSS NAND2_X2
X_26797_ _03716_ _15195_ VDD VSS BUF_X16
X_26798_ _03647_ _03787_ VDD VSS CLKBUF_X3
X_26799_ _03787_ _03646_ _15194_ _03788_ VDD VSS AOI21_X1
X_26800_ _03785_ _03786_ _03715_ net136 _03788_ _03789_ VDD
+ VSS OAI221_X1
X_26801_ _03784_ _03789_ _03790_ VDD VSS NOR2_X1
X_26802_ _03766_ _03742_ _03791_ VDD VSS NAND2_X1
X_26803_ _03674_ _03688_ _03689_ _03792_ VDD VSS AOI21_X4
X_26804_ _03621_ _03792_ _03793_ VDD VSS NOR2_X2
X_26805_ _03654_ _03794_ VDD VSS BUF_X4
X_26806_ _03659_ _03795_ VDD VSS BUF_X4
X_26807_ net661 _03794_ _03795_ _03796_ VDD VSS NOR3_X2
X_26808_ _03604_ net805 net532 _03797_ VDD VSS OAI21_X4
X_26809_ _03796_ _03797_ _03737_ _03798_ VDD VSS AOI21_X1
X_26810_ _03791_ _03793_ _03798_ _03720_ _03799_ VDD VSS AOI22_X2
X_26811_ _03705_ _03799_ _03800_ VDD VSS NOR2_X1
X_26812_ _03674_ _03670_ _03801_ VDD VSS NOR2_X2
X_26813_ _03620_ _03655_ _03660_ _03802_ VDD VSS OAI21_X4
X_26814_ _03743_ _03802_ _03803_ VDD VSS NOR2_X1
X_26815_ _03632_ _03713_ _03804_ VDD VSS NAND2_X4
X_26816_ _03619_ _03664_ _03667_ _03805_ VDD VSS NAND3_X4
X_26817_ _15196_ _03748_ _03805_ _03806_ VDD VSS AOI21_X1
X_26818_ _03801_ _03803_ _03804_ _03806_ _03807_ VDD VSS OR4_X2
X_26819_ _03772_ _03718_ _03808_ VDD VSS NOR2_X2
X_26820_ _03710_ _15194_ _15195_ _03809_ VDD VSS AOI21_X1
X_26821_ _03787_ _03715_ _03810_ VDD VSS NAND2_X1
X_26822_ _03808_ _03809_ _03715_ _03810_ _03738_ _03811_ VDD
+ VSS OAI221_X2
X_26823_ _03698_ _03807_ _03811_ _03812_ VDD VSS NAND3_X1
X_26824_ _03759_ _03770_ _03783_ _03800_ _03790_ _03812_ _03813_
+ VDD VSS OAI33_X1
X_26825_ _09166_ _09154_ _03814_ VDD VSS XNOR2_X1
X_26826_ _09069_ _03814_ _03815_ VDD VSS XNOR2_X2
X_26827_ text_in_r\[102\] _03815_ _11207_ _03816_ VDD VSS
+ MUX2_X2
X_26828_ _06431_ _03816_ _03817_ VDD VSS XNOR2_X2
X_26829_ _03817_ _03818_ VDD VSS BUF_X4
X_26830_ _03818_ _03819_ VDD VSS CLKBUF_X3
X_26831_ _03754_ _03813_ _03819_ _00128_ VDD VSS MUX2_X1
X_26832_ _03771_ _03820_ VDD VSS BUF_X4
X_26833_ _06431_ _03816_ _03821_ VDD VSS XOR2_X2
X_26834_ _03708_ _03714_ _03822_ VDD VSS NAND2_X2
X_26835_ _03738_ _03688_ _03689_ _03823_ VDD VSS NAND3_X2
X_26836_ _15196_ _03655_ _03660_ _03824_ VDD VSS OAI21_X2
X_26837_ _03624_ _03823_ _03824_ _03825_ VDD VSS NAND3_X1
X_26838_ _03602_ _03664_ _03667_ _03826_ VDD VSS AOI21_X4
X_26839_ _03700_ _03654_ _03659_ _03827_ VDD VSS NOR3_X2
X_26840_ _03787_ _03826_ _03827_ _03828_ VDD VSS OAI21_X1
X_26841_ _03825_ _03828_ _03829_ VDD VSS AND2_X1
X_26842_ _03605_ _03619_ _03830_ VDD VSS NOR2_X4
X_26843_ _03748_ _03718_ _03716_ _03831_ VDD VSS OAI21_X1
X_26844_ net137 _03750_ _03830_ _03742_ _03831_ _15203_ _03832_
+ VDD VSS AOI222_X2
X_26845_ _03821_ _03822_ _03829_ _03832_ _03804_ _03833_ VDD
+ VSS OAI221_X2
X_26846_ _03674_ _03649_ _03623_ _03834_ VDD VSS MUX2_X1
X_26847_ _03772_ _03834_ _03737_ _03835_ VDD VSS OAI21_X2
X_26848_ _03676_ _03830_ _03586_ _03647_ _03700_ _03836_ VDD
+ VSS AOI221_X1
X_26849_ _03715_ _03835_ _03836_ _03837_ VDD VSS OAI21_X1
X_26850_ _03700_ _03750_ _03838_ VDD VSS NAND2_X1
X_26851_ _03620_ _03688_ _03689_ _03839_ VDD VSS AOI21_X4
X_26852_ net1108 _03839_ _03758_ _03840_ VDD VSS OAI21_X1
X_26853_ _03633_ _03838_ _03840_ _03841_ VDD VSS AOI21_X1
X_26854_ _03819_ _03837_ _03841_ _03842_ VDD VSS OAI21_X1
X_26855_ _03820_ _03833_ _03842_ _03843_ VDD VSS AOI21_X1
X_26856_ _03837_ _03841_ _03844_ VDD VSS OR2_X1
X_26857_ _03686_ _03845_ VDD VSS CLKBUF_X3
X_26858_ _03605_ _03688_ _03689_ _03846_ VDD VSS NAND3_X2
X_26859_ _03605_ _03664_ _03667_ _03847_ VDD VSS AOI21_X4
X_26860_ _03847_ _03762_ net1108 _03848_ VDD VSS OAI21_X1
X_26861_ _03845_ _03846_ _03848_ _03849_ VDD VSS AOI21_X1
X_26862_ _03732_ _03794_ _03795_ _03850_ VDD VSS OAI21_X2
X_26863_ _03633_ _03823_ _03850_ _03851_ VDD VSS AOI21_X1
X_26864_ _03849_ _03851_ _15212_ _03852_ VDD VSS AOI21_X1
X_26865_ _03772_ _03853_ VDD VSS CLKBUF_X3
X_26866_ _03602_ _03623_ _03854_ VDD VSS NOR2_X1
X_26867_ _03605_ _03794_ _03795_ _03855_ VDD VSS OAI21_X2
X_26868_ net139 _03855_ _03805_ _03856_ VDD VSS AOI21_X1
X_26869_ _03853_ _03854_ _03856_ _03857_ VDD VSS OAI21_X1
X_26870_ _03819_ _03844_ _03852_ _03857_ _03858_ VDD VSS AND4_X1
X_26871_ _03633_ _03826_ _03588_ _03859_ VDD VSS AOI21_X1
X_26872_ _03859_ _03661_ _03845_ net662 _03671_ _03860_ VDD
+ VSS OAI221_X1
X_26873_ _03673_ _03664_ _03667_ _03861_ VDD VSS NAND3_X4
X_26874_ _03720_ _03861_ _03850_ _03862_ VDD VSS AOI21_X1
X_26875_ _03862_ _03758_ _03797_ _03863_ VDD VSS AOI21_X1
X_26876_ _03708_ _03864_ VDD VSS BUF_X4
X_26877_ _03864_ _03865_ VDD VSS BUF_X4
X_26878_ _03860_ _03863_ _03865_ _03866_ VDD VSS OAI21_X1
X_26879_ _03760_ _03833_ _03866_ _03867_ VDD VSS OAI21_X1
X_26880_ _03619_ _03827_ _03868_ VDD VSS OR2_X2
X_26881_ _03691_ _03702_ _03869_ VDD VSS AND2_X1
X_26882_ _03761_ _03847_ _03868_ _03869_ _15212_ _03870_ VDD
+ VSS OAI221_X1
X_26883_ net138 _03676_ _03871_ VDD VSS NAND2_X1
X_26884_ _03830_ _03854_ _03872_ VDD VSS OR2_X1
X_26885_ _03830_ _15219_ net659 _03873_ VDD VSS AOI21_X1
X_26886_ _03771_ _03871_ _03872_ _03873_ _03742_ _03874_ VDD
+ VSS OAI221_X1
X_26887_ _03865_ _03870_ _03874_ _03875_ VDD VSS NAND3_X1
X_26888_ _03675_ _03710_ _03586_ _03620_ net169 _03876_ VDD
+ VSS AOI221_X2
X_26889_ _03762_ _03876_ _03877_ VDD VSS NOR2_X2
X_26890_ _03714_ _03677_ _03878_ VDD VSS NAND2_X1
X_26891_ _03877_ _03878_ _15220_ _03879_ VDD VSS OAI21_X1
X_26892_ _03821_ _03875_ _03879_ _03880_ VDD VSS AOI21_X1
X_26893_ _03861_ _03855_ _03716_ _03881_ VDD VSS OAI21_X1
X_26894_ _03804_ _03881_ _03686_ _03750_ _15194_ _03882_ VDD
+ VSS AOI221_X2
X_26895_ net638 _03794_ _03795_ _03883_ VDD VSS OAI21_X2
X_26896_ net635 _03654_ _03659_ _03884_ VDD VSS NOR3_X4
X_26897_ _03647_ _03884_ _03885_ VDD VSS NOR2_X2
X_26898_ _03721_ _03675_ _03886_ VDD VSS OR2_X1
X_26899_ _03886_ _03797_ _03727_ _03887_ VDD VSS OAI21_X2
X_26900_ _03822_ _03883_ _03885_ _03887_ _03787_ _03888_ VDD
+ VSS AOI221_X2
X_26901_ _03732_ _03794_ _03795_ _03889_ VDD VSS NOR3_X4
X_26902_ _03624_ _03826_ _03889_ _03890_ VDD VSS OAI21_X1
X_26903_ _15196_ _03675_ _03891_ VDD VSS NOR2_X2
X_26904_ _03621_ _03718_ net136 _03892_ VDD VSS OAI21_X1
X_26905_ _03890_ _03891_ _03892_ _03893_ VDD VSS OAI21_X1
X_26906_ _03676_ _03894_ VDD VSS BUF_X4
X_26907_ _03755_ _03894_ net659 _03895_ VDD VSS AOI21_X1
X_26908_ _03686_ _03884_ _03896_ VDD VSS NOR2_X1
X_26909_ _03602_ _03655_ _03660_ _03897_ VDD VSS OAI21_X2
X_26910_ _03687_ _03895_ _03896_ _03897_ _03898_ VDD VSS AOI22_X1
X_26911_ _03705_ _03893_ _03898_ _03747_ _03899_ VDD VSS OAI22_X1
X_26912_ _03899_ _03882_ _03888_ _03819_ _03900_ VDD VSS NOR4_X1
X_26913_ _03858_ _03843_ _03867_ _03880_ _03900_ _03760_ _00129_
+ VDD VSS OAI33_X1
X_26914_ net662 _15219_ _03855_ _03901_ VDD VSS NAND3_X1
X_26915_ _03853_ _03730_ _03901_ _03671_ net134 _03902_ VDD
+ VSS OAI221_X1
X_26916_ _03621_ _03846_ _03777_ _03903_ VDD VSS AOI21_X4
X_26917_ _15212_ _03683_ _03768_ _03904_ VDD VSS AOI21_X1
X_26918_ _03865_ _03903_ _03904_ _03905_ VDD VSS OAI21_X1
X_26919_ _03820_ _03902_ _03905_ _03906_ VDD VSS NAND3_X1
X_26920_ _03649_ _03700_ _03618_ _03907_ VDD VSS MUX2_X1
X_26921_ _03714_ _03784_ _03907_ _03908_ VDD VSS OAI21_X2
X_26922_ net662 _03786_ _03909_ VDD VSS NAND2_X1
X_26923_ _03908_ _03909_ _03808_ _03910_ VDD VSS AOI21_X1
X_26924_ _03853_ _03741_ _03911_ VDD VSS NAND2_X1
X_26925_ net138 _03830_ _03912_ VDD VSS NAND2_X2
X_26926_ _03622_ _03913_ VDD VSS BUF_X4
X_26927_ _03732_ _03913_ _03914_ VDD VSS NOR2_X1
X_26928_ _03914_ _03915_ VDD VSS INV_X1
X_26929_ _03737_ _03912_ _03915_ _03916_ VDD VSS AOI21_X2
X_26930_ _03910_ _03911_ _03916_ _03917_ VDD VSS OAI21_X1
X_26931_ _03760_ _03821_ _03918_ VDD VSS NOR2_X1
X_26932_ _03906_ _03917_ _03918_ _03919_ VDD VSS NAND3_X1
X_26933_ _15220_ _03920_ VDD VSS INV_X1
X_26934_ _03762_ _03737_ _03920_ _03921_ VDD VSS AOI21_X1
X_26935_ _03740_ _15203_ net1108 _03922_ VDD VSS OAI21_X1
X_26936_ _03921_ _03922_ _03719_ _03923_ VDD VSS OAI21_X1
X_26937_ _03623_ _03707_ _03924_ VDD VSS NAND2_X1
X_26938_ _03691_ _03727_ _03743_ _03925_ VDD VSS OAI21_X1
X_26939_ _03924_ _03925_ _03926_ VDD VSS NOR2_X1
X_26940_ _03778_ _03861_ _03824_ _03927_ VDD VSS AOI21_X1
X_26941_ _03646_ _03926_ _03927_ _03928_ VDD VSS NOR3_X1
X_26942_ net635 _03618_ _03929_ VDD VSS NOR2_X1
X_26943_ _03709_ _03929_ _03930_ VDD VSS NOR2_X1
X_26944_ _03708_ _03912_ _03930_ _03727_ _15217_ _03931_ VDD
+ VSS AOI221_X1
X_26945_ _03681_ _03682_ _03688_ _03689_ _03932_ VDD VSS AOI22_X2
X_26946_ net534 net806 _03622_ _03933_ VDD VSS NOR3_X2
X_26947_ _03738_ _03932_ _03933_ _03934_ VDD VSS OAI21_X1
X_26948_ _03602_ _03794_ _03795_ _03935_ VDD VSS NOR3_X4
X_26949_ _03934_ _03935_ _03740_ _03702_ _03710_ _03936_ VDD
+ VSS OAI221_X1
X_26950_ _03931_ _03936_ _03763_ _03937_ VDD VSS AOI21_X1
X_26951_ _03818_ _03923_ _03928_ _03937_ _03771_ _03938_ VDD
+ VSS AOI221_X2
X_26952_ _06386_ _03658_ _03657_ _03939_ VDD VSS NOR3_X1
X_26953_ _03650_ _09136_ _03940_ VDD VSS NOR2_X1
X_26954_ _03939_ _03940_ _03658_ _03941_ VDD VSS AOI21_X2
X_26955_ _03721_ _15201_ _03942_ VDD VSS OR2_X4
X_26956_ _06386_ _09158_ _03651_ _03943_ VDD VSS NOR3_X1
X_26957_ _03943_ _03657_ _06386_ _03944_ VDD VSS AOI21_X2
X_26958_ _03942_ _03944_ _03945_ VDD VSS AND2_X4
X_26959_ _03619_ _03709_ _03797_ _03941_ _03945_ _03946_ VDD
+ VSS AOI221_X2
X_26960_ _15204_ _03663_ _03666_ _03947_ VDD VSS AOI21_X2
X_26961_ _03622_ _03947_ _03797_ _03675_ _03948_ VDD VSS AOI211_X2
X_26962_ _03762_ _03948_ _03946_ _03949_ VDD VSS OAI21_X2
X_26963_ _03913_ _03861_ _03824_ _03950_ VDD VSS NAND3_X1
X_26964_ _03707_ _03757_ _03732_ _03951_ VDD VSS AOI21_X1
X_26965_ _03714_ _03950_ _03951_ _03952_ VDD VSS AOI21_X1
X_26966_ _15215_ _03953_ VDD VSS INV_X1
X_26967_ _03632_ _03802_ _03764_ _03727_ _03953_ _03954_ VDD
+ VSS OAI221_X1
X_26968_ net135 _03727_ _03854_ _03955_ VDD VSS NOR3_X1
X_26969_ _03708_ _03677_ _15224_ _03956_ VDD VSS OAI21_X1
X_26970_ _03954_ _03955_ _03956_ _03957_ VDD VSS OAI21_X1
X_26971_ _03821_ _03952_ _03949_ _03957_ _03715_ _03958_ VDD
+ VSS AOI221_X2
X_26972_ _03958_ _03698_ _03959_ VDD VSS OR2_X2
X_26973_ _03720_ _03728_ _03846_ _03960_ VDD VSS AOI21_X1
X_26974_ net636 _03664_ _03667_ _03961_ VDD VSS AOI21_X4
X_26975_ _03845_ _03889_ _03961_ _03962_ VDD VSS NOR3_X1
X_26976_ _15206_ _03794_ _03795_ _03963_ VDD VSS NOR3_X1
X_26977_ _03720_ _03847_ _03963_ _03964_ VDD VSS NOR3_X1
X_26978_ _03716_ _03727_ _03965_ VDD VSS NOR2_X1
X_26979_ _03687_ _03965_ _03961_ _03966_ VDD VSS NOR3_X1
X_26980_ _03822_ _03960_ _03962_ _03964_ _03966_ _03747_ _03967_
+ VDD VSS OAI33_X1
X_26981_ _03760_ _03819_ _03967_ _03968_ VDD VSS OR3_X1
X_26982_ _03861_ _03897_ _03969_ VDD VSS NAND2_X1
X_26983_ _03715_ _03728_ _03896_ _03969_ _15212_ _03970_ VDD
+ VSS AOI221_X2
X_26984_ _15206_ _03971_ VDD VSS INV_X4
X_26985_ _03971_ _03676_ _03972_ VDD VSS NOR2_X2
X_26986_ _15219_ _03972_ _03965_ _03973_ VDD VSS NOR3_X1
X_26987_ _03820_ _03914_ _03973_ _03974_ VDD VSS NOR3_X1
X_26988_ _03865_ _03970_ _03974_ _03975_ VDD VSS NOR3_X1
X_26989_ _03919_ _03938_ _03959_ _03968_ _03975_ _00130_ VDD
+ VSS OAI221_X2
X_26990_ _03772_ _03671_ _03766_ _03802_ _03738_ _03976_ VDD
+ VSS OAI221_X2
X_26991_ _03605_ _03622_ _03977_ VDD VSS NAND2_X4
X_26992_ _03894_ _03977_ _03805_ _15203_ _03978_ VDD VSS OAI22_X1
X_26993_ _03976_ _03978_ net139 _03979_ VDD VSS AOI21_X1
X_26994_ _03602_ _03664_ _03667_ _03980_ VDD VSS NAND3_X1
X_26995_ _03586_ _03980_ _03981_ VDD VSS NOR2_X1
X_26996_ _03762_ _03802_ _03766_ _03982_ VDD VSS OAI21_X1
X_26997_ _03903_ _03981_ _03982_ _03983_ VDD VSS NOR3_X1
X_26998_ _03983_ _03761_ _03979_ _03698_ _03984_ VDD VSS OR4_X2
X_26999_ _03702_ _03777_ _03985_ VDD VSS AND2_X1
X_27000_ _15212_ _03865_ _03985_ _03986_ VDD VSS NAND3_X1
X_27001_ _03661_ _03972_ _03987_ VDD VSS NOR2_X1
X_27002_ _03701_ _03977_ _03764_ _03988_ VDD VSS AOI21_X1
X_27003_ _03986_ _03987_ _03778_ _03988_ _03865_ _03989_ VDD
+ VSS OAI221_X1
X_27004_ _03736_ _03714_ _03990_ VDD VSS NAND2_X1
X_27005_ _15206_ _03623_ _03991_ VDD VSS NOR2_X1
X_27006_ _03718_ _03991_ _03992_ VDD VSS NOR2_X1
X_27007_ _03992_ net1103 _03787_ _03993_ VDD VSS OAI21_X1
X_27008_ _03784_ _03720_ net134 _03994_ VDD VSS AOI21_X1
X_27009_ _03771_ _03877_ _03993_ _03994_ _03977_ _03995_ VDD
+ VSS AOI221_X2
X_27010_ _15194_ _03913_ _03683_ _03996_ VDD VSS AOI21_X1
X_27011_ _03996_ _03750_ net138 _03773_ _03701_ _03997_ VDD
+ VSS AOI221_X2
X_27012_ _03845_ _03935_ _03961_ _03998_ VDD VSS NOR3_X1
X_27013_ net952 _03709_ _03971_ _03999_ VDD VSS OAI21_X4
X_27014_ _03998_ _03999_ _15212_ _04000_ VDD VSS AOI21_X1
X_27015_ _03698_ _03705_ _03997_ _04000_ _03747_ _04001_ VDD
+ VSS OAI221_X1
X_27016_ _03984_ _03989_ _03990_ _03995_ _04001_ _04002_ VDD
+ VSS OAI221_X2
X_27017_ _15212_ _03683_ _03861_ _04003_ VDD VSS AOI21_X1
X_27018_ _03763_ _03748_ _15203_ _04004_ VDD VSS OAI21_X1
X_27019_ _03801_ _03717_ _03897_ _03977_ _03668_ _04005_ VDD
+ VSS AOI221_X2
X_27020_ _03761_ _04003_ _04004_ _04005_ _03865_ _04006_ VDD
+ VSS OAI221_X2
X_27021_ _03686_ _03889_ _04007_ VDD VSS NOR2_X1
X_27022_ _03649_ _03742_ _04008_ VDD VSS NAND2_X1
X_27023_ _03864_ _03683_ _04007_ _04008_ _03793_ _04009_ VDD
+ VSS AOI221_X1
X_27024_ _03826_ _03778_ _03884_ _03796_ _03947_ _03924_ _04010_
+ VDD VSS OAI33_X1
X_27025_ _03820_ _04009_ _04010_ _04011_ VDD VSS OAI21_X1
X_27026_ _03760_ _04006_ _04011_ _04012_ VDD VSS NAND3_X1
X_27027_ _03714_ _03794_ _03795_ _04013_ VDD VSS OAI21_X1
X_27028_ _03767_ _04013_ _04014_ VDD VSS NOR2_X1
X_27029_ _03633_ _03740_ _04014_ _03701_ _03722_ _04015_ VDD
+ VSS AOI221_X1
X_27030_ _03845_ _03646_ _04016_ VDD VSS NAND2_X1
X_27031_ _03810_ _04016_ _03719_ _04017_ VDD VSS MUX2_X1
X_27032_ _04015_ _04017_ _03738_ _04018_ VDD VSS OAI21_X1
X_27033_ _03839_ _03758_ _04019_ VDD VSS NOR2_X1
X_27034_ _03705_ _03710_ _03737_ _04019_ net803 _04020_ VDD
+ VSS AOI221_X2
X_27035_ _03624_ _03690_ _03855_ _04021_ VDD VSS AOI21_X1
X_27036_ _03672_ _03688_ _03689_ _04022_ VDD VSS AOI21_X2
X_27037_ _03794_ _03795_ net1102 _04023_ VDD VSS NOR3_X1
X_27038_ _03720_ _04022_ _04023_ _04024_ VDD VSS NOR3_X1
X_27039_ _04024_ _04021_ _03804_ _04025_ VDD VSS NOR3_X1
X_27040_ _04025_ _04020_ _03760_ _04026_ VDD VSS NOR3_X1
X_27041_ _03821_ _04026_ _04018_ _04027_ VDD VSS AOI21_X2
X_27042_ _03821_ _04002_ _04012_ _04027_ _00131_ VDD VSS AOI22_X1
X_27043_ _15208_ _04028_ VDD VSS INV_X1
X_27044_ _04028_ _03739_ _03677_ _04029_ VDD VSS MUX2_X1
X_27045_ _03771_ _04029_ _04030_ VDD VSS NAND2_X1
X_27046_ _03730_ _03755_ _04031_ VDD VSS NOR2_X1
X_27047_ _03981_ _04031_ _03913_ _03773_ _03750_ _04032_ VDD
+ VSS AOI221_X2
X_27048_ _04030_ _04032_ _03771_ _04033_ VDD VSS OAI21_X1
X_27049_ _03698_ _03853_ _03818_ _04034_ VDD VSS NAND3_X1
X_27050_ _03698_ _03763_ _03818_ _04035_ VDD VSS NAND3_X1
X_27051_ _03586_ _03847_ _04036_ VDD VSS NAND2_X1
X_27052_ _03963_ _03718_ _03645_ _04037_ VDD VSS AOI21_X1
X_27053_ _04036_ _04037_ _03624_ _03977_ _03878_ _04038_ VDD
+ VSS OAI221_X1
X_27054_ _03714_ _03727_ _04039_ VDD VSS NOR2_X1
X_27055_ _03737_ _04039_ _03624_ _04040_ VDD VSS MUX2_X1
X_27056_ _04038_ _04040_ net136 _04041_ VDD VSS AOI21_X1
X_27057_ _04033_ _04034_ _04035_ _04041_ _04042_ VDD VSS OAI22_X1
X_27058_ _03676_ _03740_ _03707_ _03778_ _03773_ _04043_ VDD
+ VSS OAI221_X1
X_27059_ _03605_ _03620_ _03632_ _04044_ VDD VSS AOI21_X1
X_27060_ _03977_ _04044_ net135 _04045_ VDD VSS OAI21_X1
X_27061_ _04043_ _04045_ _03894_ _04046_ VDD VSS OAI21_X1
X_27062_ _03731_ _03924_ _04047_ VDD VSS NAND2_X1
X_27063_ _03990_ _04047_ net135 _04048_ VDD VSS AOI21_X1
X_27064_ _03736_ _03646_ _04049_ VDD VSS NOR2_X1
X_27065_ _03708_ _03868_ _03891_ _03869_ _03913_ _04050_ VDD
+ VSS OAI221_X2
X_27066_ net134 _03802_ _03847_ _03647_ _04051_ VDD VSS OAI22_X1
X_27067_ _04050_ _04051_ _03762_ _04052_ VDD VSS OAI21_X2
X_27068_ _03818_ _04046_ _04048_ _04052_ _04049_ _04053_ VDD
+ VSS AOI221_X2
X_27069_ _03971_ _03709_ _04054_ VDD VSS NOR2_X2
X_27070_ _04054_ _03886_ _03623_ _04055_ VDD VSS AOI21_X1
X_27071_ _03621_ _03824_ _03871_ _04056_ VDD VSS NAND3_X1
X_27072_ _03708_ _03710_ _04057_ VDD VSS NOR2_X1
X_27073_ _03697_ _03762_ _04055_ _04056_ _04057_ _04058_ VDD
+ VSS AOI221_X1
X_27074_ _03913_ _03632_ _04059_ VDD VSS NOR2_X1
X_27075_ _03700_ _03620_ _04060_ VDD VSS NOR2_X1
X_27076_ _03718_ _03929_ _04060_ _04061_ VDD VSS OAI21_X1
X_27077_ _03708_ _03711_ _04062_ VDD VSS NOR2_X1
X_27078_ _03736_ _04059_ _03887_ _04061_ _04062_ _04063_ VDD
+ VSS AOI221_X1
X_27079_ _03820_ _04058_ _04063_ _04064_ VDD VSS OAI21_X1
X_27080_ _03760_ _03819_ _04065_ VDD VSS NAND2_X1
X_27081_ _04065_ _04066_ VDD VSS INV_X1
X_27082_ _03779_ _03933_ _04067_ VDD VSS NOR2_X1
X_27083_ _03623_ _03709_ _03773_ _03897_ net495 _04068_ VDD
+ VSS OAI221_X1
X_27084_ _03702_ _03676_ _03732_ _04069_ VDD VSS OAI21_X1
X_27085_ _04068_ _04069_ _03913_ _04070_ VDD VSS OAI21_X1
X_27086_ _03908_ _04067_ _03912_ _04070_ _03772_ _04071_ VDD
+ VSS AOI221_X1
X_27087_ net138 _03730_ _04072_ VDD VSS NAND2_X2
X_27088_ _03620_ _03961_ _04073_ VDD VSS NOR2_X1
X_27089_ _03704_ _04072_ _04073_ _03999_ _03621_ _04074_ VDD
+ VSS AOI221_X1
X_27090_ _03971_ _03687_ _04075_ VDD VSS NAND2_X1
X_27091_ _03787_ _03823_ _03850_ _04076_ VDD VSS NAND3_X1
X_27092_ _03747_ _04075_ _04076_ _04077_ VDD VSS AOI21_X1
X_27093_ _04071_ _04077_ _04074_ _04078_ VDD VSS OR3_X2
X_27094_ _04042_ _04064_ _04053_ _04078_ _04066_ _00132_ VDD
+ VSS AOI221_X2
X_27095_ net662 _03719_ _03710_ _04079_ VDD VSS NAND3_X1
X_27096_ _04079_ _03719_ _03766_ _04080_ VDD VSS OAI21_X1
X_27097_ _03691_ _03872_ net1102 _03671_ _04081_ VDD VSS OAI22_X2
X_27098_ _03819_ _03804_ _04080_ _04081_ _03705_ _04082_ VDD
+ VSS OAI221_X2
X_27099_ _03913_ _03961_ _03677_ net169 _04083_ VDD VSS AOI211_X2
X_27100_ _15219_ _03792_ _03884_ _04084_ VDD VSS NOR3_X1
X_27101_ net1019 _03820_ _04084_ _04085_ VDD VSS NOR3_X4
X_27102_ _03732_ _03621_ _04086_ VDD VSS NAND2_X1
X_27103_ _03649_ _03758_ _04086_ _03719_ _04087_ VDD VSS AOI22_X1
X_27104_ _03865_ _03761_ _04087_ _04088_ VDD VSS OAI21_X1
X_27105_ _04085_ _04088_ _04089_ VDD VSS NOR2_X2
X_27106_ _03913_ _03727_ _03971_ _04090_ VDD VSS AOI21_X1
X_27107_ _03747_ _04072_ _04090_ _03885_ _03683_ _04091_ VDD
+ VSS AOI221_X2
X_27108_ _15194_ _03691_ _03710_ _03737_ _04092_ VDD VSS AOI22_X1
X_27109_ _03698_ _03705_ _04092_ _04093_ VDD VSS OAI21_X1
X_27110_ _03894_ _03977_ _04086_ _04094_ VDD VSS AOI21_X1
X_27111_ _04094_ _03771_ _03711_ _03763_ _04095_ VDD VSS NOR4_X2
X_27112_ _03624_ _03737_ _03797_ _04096_ VDD VSS AND3_X1
X_27113_ _03822_ _04083_ _04096_ _04097_ VDD VSS NOR3_X2
X_27114_ _04097_ _04093_ _04095_ _04091_ _04098_ VDD VSS NOR4_X2
X_27115_ _04082_ _04089_ _04098_ _03918_ _04099_ VDD VSS OAI22_X2
X_27116_ _03747_ _03894_ _03732_ _03722_ _03701_ _04100_ VDD
+ VSS AOI221_X1
X_27117_ _04100_ _03991_ _03765_ _04101_ VDD VSS OAI21_X1
X_27118_ _03698_ _03819_ _04102_ VDD VSS NOR2_X1
X_27119_ net662 _03730_ _03850_ _15212_ _04103_ VDD VSS AOI22_X1
X_27120_ _03822_ _04103_ _04104_ VDD VSS OR2_X1
X_27121_ _04101_ _04102_ _04104_ _04105_ VDD VSS NAND3_X1
X_27122_ _15219_ _03889_ _03755_ _04106_ VDD VSS OR3_X1
X_27123_ _03761_ _03669_ _04106_ _04107_ VDD VSS AOI21_X1
X_27124_ _15194_ _03805_ _03999_ _15219_ _04108_ VDD VSS OAI22_X1
X_27125_ _03853_ _03820_ _04108_ _04109_ VDD VSS OAI21_X1
X_27126_ _04107_ _04109_ _04110_ VDD VSS NOR2_X1
X_27127_ _03796_ _03719_ net639 _04111_ VDD VSS AOI21_X1
X_27128_ _03633_ _03671_ _03738_ _04111_ _03845_ _04112_ VDD
+ VSS OAI221_X1
X_27129_ _03763_ _03748_ net1108 _04113_ VDD VSS OAI21_X1
X_27130_ _03722_ _03719_ _04114_ VDD VSS NAND2_X1
X_27131_ _15212_ _03823_ _04114_ _04115_ VDD VSS AOI21_X1
X_27132_ _04112_ _04113_ _04115_ _04116_ VDD VSS OAI21_X1
X_27133_ net136 _03633_ _03802_ _04117_ VDD VSS NAND3_X1
X_27134_ net139 _03762_ _03894_ _04118_ VDD VSS OAI21_X1
X_27135_ _04118_ _03808_ _03845_ _04119_ VDD VSS AOI21_X1
X_27136_ _03632_ _03676_ _04120_ VDD VSS NOR2_X2
X_27137_ _15203_ _04120_ net139 _04121_ VDD VSS OAI21_X1
X_27138_ _15194_ _03839_ _03758_ net169 _04122_ VDD VSS AOI22_X1
X_27139_ _04117_ _04119_ _04121_ _04122_ _03853_ _04123_ VDD
+ VSS OAI221_X1
X_27140_ _04116_ _04123_ _03820_ _04124_ VDD VSS MUX2_X1
X_27141_ _04099_ _04105_ _04110_ _04065_ _04124_ _00133_ VDD
+ VSS OAI221_X1
X_27142_ _03687_ _03891_ _04054_ _04125_ VDD VSS OAI21_X1
X_27143_ _03772_ _03758_ _03722_ _04126_ VDD VSS AOI21_X1
X_27144_ _03681_ _03682_ _03623_ _04127_ VDD VSS NAND3_X1
X_27145_ _03676_ _03797_ _04127_ _04128_ VDD VSS AND3_X1
X_27146_ _15213_ _15222_ _03677_ _04129_ VDD VSS NOR3_X1
X_27147_ _04128_ _04129_ _04130_ VDD VSS OR2_X1
X_27148_ _03818_ _04125_ _04126_ _04130_ _03853_ _04131_ VDD
+ VSS AOI221_X2
X_27149_ _03686_ _03755_ _04132_ VDD VSS NOR2_X1
X_27150_ _03704_ _04072_ _04132_ _03985_ _03687_ _04133_ VDD
+ VSS AOI221_X2
X_27151_ _03894_ _03684_ net138 _03624_ net137 _04134_ VDD
+ VSS AOI221_X1
X_27152_ _03763_ _03719_ _15215_ _04135_ VDD VSS OAI21_X1
X_27153_ _03818_ _04134_ _04135_ _04136_ VDD VSS OAI21_X1
X_27154_ _04133_ _04136_ _03820_ _04137_ VDD VSS AOI21_X2
X_27155_ _03687_ _03772_ _03768_ _03883_ _04138_ VDD VSS NAND4_X1
X_27156_ _03821_ _04138_ _04139_ VDD VSS NAND2_X1
X_27157_ _03845_ _03864_ _03972_ _04140_ VDD VSS NOR3_X1
X_27158_ _03742_ _03797_ _04141_ VDD VSS NAND2_X1
X_27159_ _03847_ _03677_ _15206_ _04142_ VDD VSS AOI21_X1
X_27160_ _04022_ net1102 _03677_ _04143_ VDD VSS AOI21_X1
X_27161_ _04142_ _04143_ _03787_ _04144_ VDD VSS MUX2_X1
X_27162_ _04139_ _04140_ _04141_ _03865_ _04144_ _04145_ VDD
+ VSS AOI221_X2
X_27163_ _03722_ _03732_ _04146_ VDD VSS NOR2_X1
X_27164_ _03621_ _03718_ _04146_ _04147_ VDD VSS AOI21_X1
X_27165_ _03935_ _03792_ _04148_ VDD VSS NOR2_X1
X_27166_ _03864_ _04147_ _04072_ _04148_ _03720_ _04149_ VDD
+ VSS AOI221_X2
X_27167_ _03719_ _03977_ net1108 _04150_ VDD VSS AOI21_X1
X_27168_ _03763_ _03802_ net169 _04151_ VDD VSS OAI21_X1
X_27169_ _03819_ _04150_ _04151_ _04152_ VDD VSS OAI21_X1
X_27170_ _03761_ _04149_ _04152_ _04153_ VDD VSS OAI21_X1
X_27171_ _03760_ _04131_ _04137_ _04145_ _04153_ _04154_ VDD
+ VSS OAI221_X2
X_27172_ _03714_ _03818_ _04155_ VDD VSS NOR2_X1
X_27173_ _03772_ _03894_ _04156_ VDD VSS NAND2_X1
X_27174_ _03772_ _03786_ _03961_ _03686_ _04157_ VDD VSS AOI22_X1
X_27175_ _04155_ _04156_ _03977_ _04157_ net136 _04158_ VDD
+ VSS OAI221_X1
X_27176_ _03826_ _03830_ net135 _04159_ VDD VSS AOI21_X1
X_27177_ _03786_ _04159_ net134 net139 _03980_ _04160_ VDD
+ VSS OAI221_X1
X_27178_ _04158_ _04160_ _03763_ _04161_ VDD VSS AOI21_X1
X_27179_ _03686_ _03784_ _04162_ VDD VSS AND2_X1
X_27180_ _04162_ _03999_ _03864_ _04163_ VDD VSS OAI21_X1
X_27181_ net495 _03730_ _03632_ _04164_ VDD VSS MUX2_X1
X_27182_ _03817_ _04120_ _15203_ _04164_ _03647_ _04165_ VDD
+ VSS AOI221_X2
X_27183_ _03771_ _04163_ _04165_ _04166_ VDD VSS AOI21_X1
X_27184_ net136 _03701_ _04167_ VDD VSS NAND2_X1
X_27185_ _03743_ _03750_ _03758_ _03971_ _04168_ VDD VSS AOI22_X1
X_27186_ _03864_ _04167_ _04168_ _04169_ VDD VSS NAND3_X1
X_27187_ _03818_ _04169_ _03916_ _03864_ _04170_ VDD VSS OAI211_X2
X_27188_ _03761_ _03821_ _04171_ VDD VSS NOR2_X1
X_27189_ _15214_ _03742_ _04172_ VDD VSS NAND2_X1
X_27190_ _03740_ _03795_ _03794_ _03971_ _03624_ _04173_ VDD
+ VSS OAI221_X1
X_27191_ _03864_ _04172_ _04173_ _04174_ VDD VSS AOI21_X1
X_27192_ _04021_ _03701_ net137 _04175_ VDD VSS AOI21_X1
X_27193_ _04174_ _04175_ _03763_ _04176_ VDD VSS AOI21_X1
X_27194_ _04161_ _04166_ _04170_ _04171_ _04176_ _04177_ VDD
+ VSS AOI221_X1
X_27195_ _04154_ _04177_ _03760_ _00134_ VDD VSS OAI21_X1
X_27196_ _03787_ _04013_ _03722_ _04178_ VDD VSS OAI21_X1
X_27197_ _15203_ _03646_ _04179_ VDD VSS NAND2_X1
X_27198_ _03878_ _04179_ _03894_ _04180_ VDD VSS OAI21_X1
X_27199_ _04178_ _04180_ net662 _04039_ net169 _04181_ VDD
+ VSS AOI221_X2
X_27200_ net660 _03738_ _04039_ _04182_ VDD VSS MUX2_X1
X_27201_ _03853_ _04182_ _15219_ _04183_ VDD VSS OAI21_X1
X_27202_ _03845_ _03941_ _03945_ _04184_ VDD VSS NAND3_X1
X_27203_ _04184_ _04142_ _03845_ net662 _03742_ _04185_ VDD
+ VSS OAI221_X1
X_27204_ _03733_ _04128_ _04186_ VDD VSS NOR2_X1
X_27205_ _04185_ _04186_ _03761_ _04187_ VDD VSS MUX2_X1
X_27206_ _04102_ _04181_ _04183_ _04187_ _03853_ _04188_ VDD
+ VSS OAI221_X1
X_27207_ _03646_ _03691_ _03885_ _03969_ _03787_ _04189_ VDD
+ VSS AOI221_X1
X_27208_ _03700_ _03716_ _03620_ _04190_ VDD VSS MUX2_X1
X_27209_ _03714_ _03932_ _03977_ _04190_ _03894_ _04191_ VDD
+ VSS AOI221_X2
X_27210_ _03853_ _04189_ _04191_ _04192_ VDD VSS OR3_X1
X_27211_ _03674_ _15206_ _03913_ _04193_ VDD VSS MUX2_X1
X_27212_ _15222_ _04193_ _03737_ _04194_ VDD VSS MUX2_X1
X_27213_ _03722_ _03720_ _03688_ _03689_ _04195_ VDD VSS AOI22_X1
X_27214_ _04195_ _03742_ _15208_ _04196_ VDD VSS AOI21_X1
X_27215_ _03819_ _04194_ _03804_ _04196_ _03705_ _04197_ VDD
+ VSS OAI221_X2
X_27216_ _04197_ _04198_ VDD VSS INV_X2
X_27217_ _03698_ _04198_ _04192_ _04199_ VDD VSS AOI21_X2
X_27218_ _15219_ _03633_ _03839_ _03738_ _04200_ VDD VSS AOI22_X2
X_27219_ _03750_ _03742_ _03633_ _04201_ VDD VSS AOI21_X1
X_27220_ _04200_ _04201_ _03797_ _03912_ _03779_ _04202_ VDD
+ VSS OAI221_X1
X_27221_ _03821_ _04049_ _04202_ _04203_ VDD VSS AOI21_X1
X_27222_ net136 _03750_ _03935_ _04204_ VDD VSS OAI21_X1
X_27223_ _03864_ _04036_ _04204_ _04205_ VDD VSS AOI21_X1
X_27224_ _03758_ _03710_ _03718_ _04206_ VDD VSS AOI21_X1
X_27225_ _03826_ _03701_ _15194_ _04207_ VDD VSS AOI21_X1
X_27226_ _15195_ _04206_ _04207_ _03633_ _04208_ VDD VSS OAI22_X1
X_27227_ _03736_ _03761_ _04205_ _04208_ _04209_ VDD VSS OR4_X1
X_27228_ _03674_ _03748_ _03805_ _04210_ VDD VSS AOI21_X1
X_27229_ _04210_ _03750_ _15203_ net134 _03701_ _04211_ VDD
+ VSS AOI221_X2
X_27230_ _04036_ _03805_ _03797_ _04212_ VDD VSS OAI21_X1
X_27231_ _03771_ _03671_ _03773_ _03802_ _15203_ _04213_ VDD
+ VSS OAI221_X2
X_27232_ _03865_ _03820_ _04211_ _04212_ _04213_ _04214_ VDD
+ VSS OAI221_X1
X_27233_ _03787_ _03972_ _03965_ _04215_ VDD VSS OAI21_X1
X_27234_ _03647_ _03846_ _03883_ _04216_ VDD VSS AOI21_X1
X_27235_ _03804_ _04216_ _04217_ VDD VSS NOR2_X1
X_27236_ _03971_ _03758_ _03961_ _03624_ _04218_ VDD VSS AOI22_X1
X_27237_ _04167_ _04218_ _04219_ VDD VSS NAND2_X1
X_27238_ _03864_ _03715_ _04220_ VDD VSS NOR2_X1
X_27239_ _03818_ _04215_ _04217_ _04219_ _04220_ _04221_ VDD
+ VSS AOI221_X2
X_27240_ _04203_ _04209_ _04214_ _04221_ _04222_ VDD VSS AOI22_X1
X_27241_ _04188_ _04199_ _04222_ _00135_ VDD VSS OAI21_X2
X_27242_ _06341_ _04223_ VDD VSS INV_X1
X_27243_ _04223_ _09179_ _04224_ VDD VSS NOR2_X1
X_27244_ _06341_ _09179_ _04225_ VDD VSS NOR2_X1
X_27245_ _12623_ _12510_ _04226_ VDD VSS XNOR2_X2
X_27246_ _09717_ sa01_sr\[1\] _04227_ VDD VSS XNOR2_X2
X_27247_ _04226_ _04227_ _04228_ VDD VSS XNOR2_X2
X_27248_ _04224_ _04225_ _04228_ _04229_ VDD VSS MUX2_X2
X_27249_ _06341_ _09012_ _00479_ _04230_ VDD VSS OR3_X2
X_27250_ _06341_ _09179_ _00479_ _04231_ VDD VSS NAND3_X2
X_27251_ _04230_ _04231_ _04232_ VDD VSS NAND2_X4
X_27252_ _04229_ _04232_ _04233_ VDD VSS NOR2_X4
X_27253_ _04233_ _04234_ VDD VSS INV_X4
X_27254_ _04234_ _04235_ VDD VSS BUF_X8
X_27255_ _04235_ _15232_ VDD VSS BUF_X8
X_27256_ sa01_sr\[0\] net764 _04236_ VDD VSS XNOR2_X1
X_27257_ _09712_ _09799_ _04237_ VDD VSS XOR2_X1
X_27258_ _06326_ _09012_ _04237_ _04238_ VDD VSS NAND3_X1
X_27259_ _06326_ _09015_ _04239_ VDD VSS NOR2_X1
X_27260_ net577 _04239_ _04240_ VDD VSS NAND2_X1
X_27261_ _04236_ _04238_ _04240_ _04241_ VDD VSS AOI21_X1
X_27262_ sa01_sr\[0\] net762 _04242_ VDD VSS XOR2_X1
X_27263_ _04237_ _04239_ _04243_ VDD VSS NAND2_X1
X_27264_ _06326_ _09194_ net577 _04244_ VDD VSS NAND3_X1
X_27265_ _04242_ _04243_ _04244_ _04245_ VDD VSS AOI21_X1
X_27266_ _06326_ _04246_ VDD VSS INV_X1
X_27267_ _04246_ _09727_ _00480_ _04247_ VDD VSS NAND3_X1
X_27268_ _06326_ _09028_ _04248_ VDD VSS NAND2_X1
X_27269_ _04247_ _04248_ _00480_ _04249_ VDD VSS OAI21_X1
X_27270_ _04241_ _04245_ _04249_ _04250_ VDD VSS OR3_X4
X_27271_ _04250_ _04251_ VDD VSS INV_X4
X_27272_ _04251_ _15235_ VDD VSS BUF_X4
X_27273_ _09835_ _09766_ _04252_ VDD VSS XNOR2_X1
X_27274_ _06356_ net829 net933 _04253_ VDD VSS NAND3_X1
X_27275_ _06356_ _08970_ _04254_ VDD VSS NOR2_X1
X_27276_ _12498_ _04254_ _04255_ VDD VSS NAND2_X1
X_27277_ _04252_ _04253_ _04255_ _04256_ VDD VSS AOI21_X2
X_27278_ _09835_ _09764_ _04257_ VDD VSS XNOR2_X1
X_27279_ net933 _04254_ _04258_ VDD VSS NAND2_X1
X_27280_ _06356_ _09009_ _12498_ _04259_ VDD VSS NAND3_X1
X_27281_ _04257_ _04258_ _04259_ _04260_ VDD VSS AOI21_X2
X_27282_ _06356_ _04261_ VDD VSS INV_X1
X_27283_ _04261_ net831 _00481_ _04262_ VDD VSS NAND3_X1
X_27284_ _06356_ net831 _04263_ VDD VSS NAND2_X1
X_27285_ _04262_ _04263_ _00481_ _04264_ VDD VSS OAI21_X2
X_27286_ _04256_ _04260_ _04264_ _04265_ VDD VSS NOR3_X4
X_27287_ _04265_ _04266_ VDD VSS INV_X4
X_27288_ _04266_ _04267_ VDD VSS BUF_X8
X_27289_ _04267_ _04268_ VDD VSS BUF_X4
X_27290_ _04268_ _04269_ VDD VSS BUF_X4
X_27291_ _04269_ _15251_ VDD VSS BUF_X4
X_27292_ _04250_ _04270_ VDD VSS BUF_X4
X_27293_ _04270_ _15226_ VDD VSS BUF_X4
X_27294_ _04265_ _04271_ VDD VSS BUF_X4
X_27295_ _04271_ _04272_ VDD VSS BUF_X4
X_27296_ _04272_ _15244_ VDD VSS BUF_X4
X_27297_ _09798_ _09796_ _04273_ VDD VSS XNOR2_X1
X_27298_ _01658_ _04273_ _04274_ VDD VSS XNOR2_X1
X_27299_ text_in_r\[71\] _04274_ _09803_ _04275_ VDD VSS MUX2_X2
X_27300_ _06440_ _04275_ _04276_ VDD VSS XNOR2_X2
X_27301_ _06418_ _04277_ VDD VSS INV_X1
X_27302_ _09872_ _09789_ _04278_ VDD VSS XNOR2_X1
X_27303_ _04277_ _11938_ _04278_ _04279_ VDD VSS NOR3_X1
X_27304_ _06418_ _11938_ _04278_ _04280_ VDD VSS NOR3_X1
X_27305_ _04279_ _04280_ _09816_ _04281_ VDD VSS MUX2_X2
X_27306_ _09872_ _09789_ _04282_ VDD VSS XOR2_X1
X_27307_ _06418_ _09102_ _04282_ _04283_ VDD VSS NOR3_X1
X_27308_ _04277_ _11841_ _04282_ _04284_ VDD VSS NOR3_X1
X_27309_ _04283_ _04284_ _09816_ _04285_ VDD VSS MUX2_X2
X_27310_ _06418_ _09103_ text_in_r\[69\] _04286_ VDD VSS NAND3_X1
X_27311_ _04277_ _09179_ _04287_ VDD VSS NAND2_X1
X_27312_ _04286_ _04287_ text_in_r\[69\] _04288_ VDD VSS OAI21_X2
X_27313_ _04281_ _04285_ _04288_ _04289_ VDD VSS NOR3_X4
X_27314_ _04289_ _04290_ VDD VSS BUF_X4
X_27315_ _04276_ _04290_ _04291_ VDD VSS NOR2_X1
X_27316_ _09788_ _12614_ _04292_ VDD VSS XNOR2_X1
X_27317_ _09798_ _04292_ _04293_ VDD VSS XNOR2_X1
X_27318_ text_in_r\[70\] _04293_ _10571_ _04294_ VDD VSS MUX2_X2
X_27319_ _06432_ _04294_ _04295_ VDD VSS XNOR2_X2
X_27320_ _04291_ _04295_ _04296_ VDD VSS NAND2_X1
Xclone468 net875 net1081 VDD VSS BUF_X16
X_27322_ _15228_ _04298_ VDD VSS INV_X2
X_27323_ _06387_ _04299_ VDD VSS INV_X1
X_27324_ _09194_ text_in_r\[67\] _04300_ VDD VSS NOR2_X1
X_27325_ _09838_ _01680_ _04301_ VDD VSS XOR2_X2
X_27326_ _04299_ _04300_ _04301_ _09075_ _04302_ VDD VSS AOI211_X2
X_27327_ text_in_r\[67\] _04303_ VDD VSS INV_X1
X_27328_ _09074_ _04303_ _04304_ VDD VSS NOR2_X1
X_27329_ _09838_ _01680_ _04305_ VDD VSS XNOR2_X2
X_27330_ _06387_ _04304_ _04305_ net1004 _04306_ VDD VSS AOI211_X2
X_27331_ _04266_ net476 net475 _04307_ VDD VSS NOR3_X4
X_27332_ _08995_ _04303_ _04308_ VDD VSS NAND2_X1
X_27333_ _06387_ _04308_ _04305_ _08995_ _04309_ VDD VSS OAI211_X4
X_27334_ _04309_ _04310_ VDD VSS BUF_X4
X_27335_ _00991_ text_in_r\[67\] _04311_ VDD VSS NAND2_X1
X_27336_ _04299_ _04311_ _04301_ _00991_ _04312_ VDD VSS OAI211_X4
X_27337_ _04312_ _04313_ VDD VSS BUF_X4
X_27338_ _04251_ _04310_ _04313_ _04314_ VDD VSS NAND3_X4
X_27339_ net476 net475 _04315_ VDD VSS NOR2_X2
X_27340_ _04315_ _04316_ VDD VSS BUF_X4
X_27341_ _04316_ _04317_ VDD VSS BUF_X4
X_27342_ _15230_ _04318_ VDD VSS INV_X2
X_27343_ _04314_ _04317_ _04318_ _04319_ VDD VSS OAI21_X1
X_27344_ _04268_ _04320_ VDD VSS BUF_X4
X_27345_ _04298_ _04307_ _04319_ _04320_ _04321_ VDD VSS AOI22_X2
X_27346_ _09871_ _01668_ _04322_ VDD VSS XNOR2_X1
X_27347_ text_in_r\[68\] _04322_ net1004 _04323_ VDD VSS MUX2_X2
X_27348_ _06404_ _04323_ _04324_ VDD VSS XOR2_X2
Xclone153 _04387_ net153 VDD VSS BUF_X8
X_27350_ _15233_ _04326_ VDD VSS INV_X4
X_27351_ _04251_ _04266_ _04327_ VDD VSS NOR2_X4
X_27352_ _04326_ _04267_ _04327_ _04234_ _04328_ VDD VSS AOI22_X4
X_27353_ _04309_ _04312_ _04329_ VDD VSS NAND2_X4
X_27354_ _04329_ _04330_ VDD VSS BUF_X4
X_27355_ _04324_ _04328_ _04330_ _04331_ VDD VSS AOI21_X2
X_27356_ _04324_ _04332_ VDD VSS BUF_X4
X_27357_ _04332_ _04333_ VDD VSS BUF_X4
X_27358_ _04316_ _04334_ VDD VSS BUF_X4
X_27359_ _04334_ _04335_ VDD VSS BUF_X4
X_27360_ _04265_ _04309_ _04312_ _04336_ VDD VSS AOI21_X4
X_27361_ _15229_ _04337_ VDD VSS BUF_X4
X_27362_ net1047 _04338_ VDD VSS BUF_X16
X_27363_ _15249_ _04335_ _04336_ _04338_ _04339_ VDD VSS AOI22_X2
X_27364_ _04296_ _04321_ _04331_ _04333_ _04339_ _04340_ VDD
+ VSS AOI221_X2
X_27365_ _04290_ _04341_ VDD VSS BUF_X4
X_27366_ _04341_ _04342_ VDD VSS CLKBUF_X3
X_27367_ _06404_ _04323_ _04343_ VDD VSS XNOR2_X2
X_27368_ _04343_ _04344_ VDD VSS BUF_X4
X_27369_ _04344_ _04345_ VDD VSS BUF_X4
X_27370_ _15238_ _04346_ VDD VSS INV_X2
X_27371_ _04346_ _04335_ _04347_ VDD VSS NOR2_X1
X_27372_ _04337_ _04348_ VDD VSS INV_X8
X_27373_ net476 _04349_ VDD VSS BUF_X8
X_27374_ net475 _04350_ VDD VSS BUF_X8
X_27375_ _04348_ _04349_ _04350_ _04351_ VDD VSS NOR3_X4
X_27376_ _15251_ _04345_ _04347_ _04351_ _04352_ VDD VSS NOR4_X1
X_27377_ _06440_ _04275_ _04353_ VDD VSS XOR2_X2
X_27378_ _06432_ _04294_ _04354_ VDD VSS XOR2_X2
X_27379_ _04354_ _04355_ VDD VSS BUF_X4
X_27380_ _04353_ _04355_ _04356_ VDD VSS NAND2_X2
X_27381_ _04342_ _04352_ _04356_ _04357_ VDD VSS NOR3_X1
X_27382_ _04270_ _04310_ _04313_ _04358_ VDD VSS NAND3_X4
X_27383_ _04324_ _04358_ _04359_ VDD VSS NOR2_X2
X_27384_ _04317_ _04360_ VDD VSS BUF_X4
X_27385_ _04360_ _04361_ VDD VSS CLKBUF_X3
X_27386_ _15233_ _04362_ VDD VSS BUF_X4
X_27387_ _15251_ _04361_ _04362_ _04363_ VDD VSS OAI21_X1
X_27388_ _04251_ net966 net481 _04364_ VDD VSS OAI21_X2
X_27389_ _04333_ _04364_ _04361_ _04365_ VDD VSS AOI21_X1
X_27390_ _04359_ _04363_ _04365_ _15251_ _04366_ VDD VSS OAI22_X1
X_27391_ _04340_ _04357_ _04366_ _04367_ VDD VSS AOI21_X1
X_27392_ _04295_ _04344_ _04368_ VDD VSS NAND2_X1
Xclone176 _11308_ net176 VDD VSS BUF_X4
X_27394_ _15236_ _04370_ VDD VSS INV_X4
X_27395_ _04368_ _04336_ _04370_ _04338_ _04307_ _04371_ VDD
+ VSS AOI221_X1
X_27396_ _04265_ _04302_ _04306_ _04372_ VDD VSS NOR3_X4
X_27397_ _04266_ _04309_ _04312_ _04373_ VDD VSS AOI21_X2
X_27398_ _04372_ _04373_ _04374_ VDD VSS NOR2_X2
X_27399_ _15228_ _04375_ VDD VSS CLKBUF_X3
X_27400_ _04371_ _04374_ _04375_ _04376_ VDD VSS OAI21_X1
X_27401_ _04353_ _04377_ VDD VSS BUF_X4
X_27402_ _04377_ _04342_ _04378_ VDD VSS NOR2_X1
X_27403_ _04295_ _04379_ VDD VSS BUF_X4
X_27404_ net481 net966 _04349_ _04350_ _04380_ VDD VSS OAI22_X4
Xclone177 _11376_ net177 VDD VSS BUF_X8
X_27406_ _15242_ _04309_ _04312_ _04382_ VDD VSS NAND3_X4
X_27407_ _15244_ _04380_ _04382_ _04383_ VDD VSS NAND3_X1
X_27408_ _15235_ _04272_ _04384_ VDD VSS NOR2_X2
X_27409_ _04384_ _04361_ _15232_ _04385_ VDD VSS OAI21_X1
X_27410_ _04379_ _04383_ _04385_ _04386_ VDD VSS AOI21_X1
X_27411_ _04233_ _04387_ VDD VSS BUF_X8
X_27412_ _04387_ _04388_ VDD VSS BUF_X16
X_27413_ _04388_ _04320_ _04389_ VDD VSS NAND2_X1
X_27414_ _04348_ _04309_ _04312_ _04390_ VDD VSS AOI21_X4
X_27415_ _04265_ _04391_ VDD VSS CLKBUF_X3
X_27416_ net1047 _04391_ _04392_ VDD VSS NOR2_X1
X_27417_ _04388_ _04330_ _04393_ VDD VSS NAND2_X1
X_27418_ _04355_ _04389_ _04390_ _04392_ _04393_ _04394_ VDD
+ VSS AOI221_X2
X_27419_ _04333_ _04386_ _04394_ _04395_ VDD VSS OAI21_X1
X_27420_ _04373_ _04396_ VDD VSS BUF_X4
X_27421_ _04267_ _04349_ _04350_ _04397_ VDD VSS OAI21_X4
X_27422_ _04251_ _04271_ _04398_ VDD VSS NAND2_X2
X_27423_ _04329_ _04399_ VDD VSS BUF_X4
X_27424_ _04399_ _04400_ VDD VSS CLKBUF_X3
X_27425_ _04397_ _04398_ _04400_ _04401_ VDD VSS OAI21_X1
X_27426_ _04318_ _04396_ _04401_ _15232_ _15226_ _04372_ _04402_
+ VDD VSS AOI222_X2
X_27427_ _04354_ _04344_ _04403_ VDD VSS NAND2_X1
X_27428_ _04402_ _04403_ _04404_ VDD VSS OR2_X1
X_27429_ _04376_ _04378_ _04395_ _04404_ _04405_ VDD VSS NAND4_X1
X_27430_ _04289_ _04343_ _04406_ VDD VSS NAND2_X2
X_27431_ _04377_ _04406_ _04407_ VDD VSS NOR2_X1
X_27432_ _06341_ _09195_ _04408_ VDD VSS NAND2_X1
X_27433_ _04223_ _09195_ _04409_ VDD VSS NAND2_X1
X_27434_ _04408_ _04409_ net909 _04410_ VDD VSS MUX2_X2
X_27435_ _04230_ _04231_ _04411_ VDD VSS AND2_X2
X_27436_ _04410_ _04411_ _04310_ _04313_ _04412_ VDD VSS NAND4_X4
X_27437_ _04379_ _04384_ _04412_ _04307_ _04326_ _04413_ VDD
+ VSS AOI221_X2
X_27438_ _04337_ _04349_ _04350_ _04414_ VDD VSS OAI21_X4
X_27439_ _04370_ _04309_ _04312_ _04415_ VDD VSS NAND3_X2
X_27440_ _15251_ _04414_ _04415_ _04416_ VDD VSS AOI21_X1
X_27441_ _04270_ _04309_ _04312_ _04417_ VDD VSS AOI21_X4
X_27442_ _04272_ _04334_ _04375_ _04417_ _04235_ _04418_ VDD
+ VSS AOI221_X1
X_27443_ _04416_ _04418_ _04419_ VDD VSS NOR2_X1
X_27444_ _04355_ _04419_ _04420_ VDD VSS NOR2_X1
X_27445_ _04407_ _04413_ _04420_ _04421_ VDD VSS OAI21_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
X_27447_ _04270_ _04232_ _04229_ _04423_ VDD VSS OAI21_X4
X_27448_ net1045 _04423_ _04329_ _04424_ VDD VSS MUX2_X1
X_27449_ _04343_ _04336_ _04370_ _04424_ _04391_ _04425_ VDD
+ VSS AOI221_X2
X_27450_ _04281_ _04285_ _04288_ _04426_ VDD VSS OR3_X4
X_27451_ _04276_ _04426_ _04427_ VDD VSS NOR2_X1
X_27452_ _04295_ _04427_ _04428_ VDD VSS NAND2_X1
X_27453_ _15238_ _04429_ VDD VSS BUF_X4
X_27454_ net1045 _04423_ _04315_ _04430_ VDD VSS MUX2_X1
X_27455_ _04324_ _04372_ _04429_ _04430_ _04271_ _04431_ VDD
+ VSS AOI221_X1
X_27456_ _04425_ _04428_ _04431_ _04432_ VDD VSS NOR3_X1
X_27457_ _04324_ _04433_ VDD VSS CLKBUF_X3
X_27458_ _04290_ _04433_ _04434_ VDD VSS NAND2_X1
X_27459_ _04377_ _04434_ _04435_ VDD VSS NOR2_X1
X_27460_ _04251_ _04349_ _04350_ _04436_ VDD VSS OAI21_X4
X_27461_ _04354_ _04436_ _04437_ VDD VSS NAND2_X1
X_27462_ _04382_ _04315_ _04234_ _04438_ VDD VSS OAI21_X2
X_27463_ _04437_ _04438_ _04267_ net1047 _04307_ _04439_ VDD
+ VSS AOI221_X2
X_27464_ _04270_ _04266_ _04440_ VDD VSS NOR2_X4
X_27465_ _04440_ _04270_ _04387_ _04441_ VDD VSS AOI21_X1
X_27466_ _04334_ _04441_ _04442_ VDD VSS XNOR2_X1
X_27467_ _04439_ _04442_ _04379_ _04443_ VDD VSS AOI21_X1
X_27468_ _04426_ _04444_ VDD VSS BUF_X4
X_27469_ _04444_ _04445_ VDD VSS CLKBUF_X3
X_27470_ _04445_ _04356_ _04446_ VDD VSS NOR2_X1
X_27471_ net1078 _04310_ _04313_ _04447_ VDD VSS AOI21_X1
X_27472_ _15233_ _04349_ _04350_ _04448_ VDD VSS NOR3_X4
X_27473_ _04272_ _04447_ _04448_ _04449_ VDD VSS OAI21_X1
X_27474_ _04449_ _04397_ _04298_ _04450_ VDD VSS OAI21_X1
X_27475_ _04271_ _04451_ VDD VSS CLKBUF_X3
X_27476_ net908 _04451_ _04452_ VDD VSS NOR2_X1
X_27477_ _04335_ _04440_ _04452_ _04453_ VDD VSS OAI21_X1
X_27478_ _04267_ _04454_ VDD VSS CLKBUF_X3
X_27479_ _04338_ _04454_ _04310_ _04313_ _04455_ VDD VSS AOI22_X1
X_27480_ _04265_ _04232_ _04229_ _04456_ VDD VSS OAI21_X4
X_27481_ _04332_ _04455_ _04456_ _04457_ VDD VSS AOI21_X2
X_27482_ _04333_ _04450_ _04453_ _04457_ _04458_ VDD VSS AOI22_X2
X_27483_ _04432_ _04435_ _04443_ _04446_ _04458_ _04459_ VDD
+ VSS AOI221_X2
X_27484_ _04367_ _04405_ _04421_ _04459_ _00136_ VDD VSS NAND4_X1
X_27485_ _04444_ _04344_ _04460_ VDD VSS NOR2_X2
X_27486_ _04233_ _04436_ _04461_ VDD VSS NOR2_X1
X_27487_ _04454_ _04462_ VDD VSS CLKBUF_X3
X_27488_ _04461_ _04382_ _04462_ _04463_ VDD VSS AOI21_X1
X_27489_ _04388_ _15227_ VDD VSS BUF_X32
X_27490_ net612 _04307_ _04464_ VDD VSS NAND2_X1
X_27491_ _04460_ _04463_ _04464_ _04465_ VDD VSS AND3_X1
X_27492_ _04270_ _04372_ _04396_ _04466_ VDD VSS OAI21_X1
X_27493_ _15226_ _04349_ _04350_ _04467_ VDD VSS NOR3_X1
X_27494_ net612 _04467_ _04336_ _04338_ _04468_ VDD VSS AOI22_X1
X_27495_ _04345_ _04466_ _04468_ _04469_ VDD VSS NAND3_X1
X_27496_ _04433_ _04470_ VDD VSS CLKBUF_X3
X_27497_ _04391_ _04471_ VDD VSS CLKBUF_X3
X_27498_ _04298_ _04310_ _04313_ _04472_ VDD VSS AOI21_X1
X_27499_ _04471_ _04351_ _04472_ _04473_ VDD VSS OAI21_X1
X_27500_ net674 _04310_ _04313_ _04474_ VDD VSS NAND3_X2
X_27501_ _04462_ _04436_ _04474_ _04475_ VDD VSS NAND3_X1
X_27502_ _04470_ _04473_ _04475_ _04476_ VDD VSS NAND3_X1
X_27503_ _04341_ _04469_ _04476_ _04477_ VDD VSS AOI21_X1
X_27504_ _04360_ _04364_ _04478_ VDD VSS NAND2_X1
X_27505_ _04337_ net476 net475 _04479_ VDD VSS NOR3_X4
X_27506_ _04479_ _04330_ _04362_ _04480_ VDD VSS AOI21_X1
X_27507_ _04478_ _04480_ _04471_ _04481_ VDD VSS MUX2_X1
X_27508_ _04406_ _04481_ _04482_ VDD VSS NOR2_X2
X_27509_ _04477_ _04465_ _04356_ _04482_ _04483_ VDD VSS NOR4_X2
X_27510_ _04353_ _04379_ _04484_ VDD VSS NAND2_X2
X_27511_ _04348_ _04485_ VDD VSS BUF_X16
X_27512_ _04485_ _04391_ _04486_ VDD VSS NOR2_X2
X_27513_ _04486_ _04272_ net181 _04487_ VDD VSS AOI21_X1
X_27514_ _04331_ _04487_ _04400_ _04488_ VDD VSS OAI21_X1
X_27515_ _04362_ _04397_ _04374_ net128 _04489_ VDD VSS OAI22_X1
X_27516_ _04290_ _04332_ _04489_ _04490_ VDD VSS AOI21_X1
X_27517_ _04454_ _04334_ _04433_ _04491_ VDD VSS NAND3_X1
X_27518_ _04491_ _04393_ _04332_ _04492_ VDD VSS OAI21_X1
X_27519_ _04267_ _04316_ _04493_ VDD VSS NAND2_X4
X_27520_ _04320_ _04433_ _04493_ _15235_ _04494_ VDD VSS OAI22_X1
X_27521_ _15226_ _04492_ _04494_ _15232_ _04495_ VDD VSS AOI22_X2
X_27522_ _04399_ _04324_ _04496_ VDD VSS NAND2_X2
X_27523_ _04251_ _04267_ _04497_ VDD VSS NAND2_X1
X_27524_ _04290_ _04496_ _04497_ _04498_ VDD VSS OAI21_X1
X_27525_ _04334_ _04344_ _04485_ _04499_ VDD VSS OAI21_X1
X_27526_ _04499_ _04496_ _04362_ _04500_ VDD VSS OAI21_X1
X_27527_ _04451_ _04501_ VDD VSS BUF_X4
X_27528_ _04498_ _04500_ _04501_ _04502_ VDD VSS AOI21_X1
X_27529_ _04484_ _04488_ _04490_ _04495_ _04502_ _04503_ VDD
+ VSS AOI221_X2
X_27530_ _04454_ _04417_ _04448_ _04504_ VDD VSS OR3_X1
X_27531_ net153 _04400_ _04505_ VDD VSS NOR2_X1
X_27532_ _04375_ _04360_ _04506_ VDD VSS NOR2_X1
X_27533_ _04462_ _04505_ _04506_ _04507_ VDD VSS OAI21_X1
X_27534_ _04406_ _04504_ _04507_ _04508_ VDD VSS AOI21_X1
X_27535_ _04276_ _04354_ _04509_ VDD VSS NAND2_X2
X_27536_ _04426_ _04343_ _04510_ VDD VSS NAND2_X2
X_27537_ _04461_ _04479_ _04511_ VDD VSS OR2_X1
X_27538_ _04510_ _04511_ _04451_ _15226_ _04336_ _04512_ VDD
+ VSS AOI221_X1
X_27539_ _04444_ _04433_ _04513_ VDD VSS NAND2_X2
X_27540_ _04318_ _04399_ _04514_ VDD VSS NAND2_X2
X_27541_ _04250_ _04411_ _04410_ _04515_ VDD VSS AOI21_X4
X_27542_ _04317_ _04515_ _04516_ VDD VSS NAND2_X2
X_27543_ _04471_ _04514_ _04516_ _04517_ VDD VSS AOI21_X1
X_27544_ net1046 _04316_ _04518_ VDD VSS NAND2_X2
X_27545_ _15242_ _04349_ _04350_ _04519_ VDD VSS OAI21_X4
X_27546_ _04451_ _04518_ _04519_ _04520_ VDD VSS AND3_X1
X_27547_ _04351_ _04451_ _04417_ _04521_ VDD VSS NOR3_X2
X_27548_ _04447_ _04317_ _04375_ _04522_ VDD VSS AOI21_X1
X_27549_ _04320_ _04522_ _04523_ VDD VSS NOR2_X1
X_27550_ _04513_ _04517_ _04520_ _04521_ _04523_ _04434_ _04524_
+ VDD VSS OAI33_X1
X_27551_ _04524_ _04509_ _04512_ _04508_ _04525_ VDD VSS NOR4_X1
X_27552_ _04377_ _04355_ _04526_ VDD VSS NOR2_X2
X_27553_ _15252_ _04290_ _04400_ _04527_ VDD VSS NOR3_X1
X_27554_ _04471_ _04515_ _04528_ VDD VSS NAND2_X1
X_27555_ _04370_ _04265_ _04529_ VDD VSS NOR2_X1
X_27556_ _04335_ _04529_ _04530_ VDD VSS NOR2_X1
X_27557_ _04527_ _04528_ _04530_ _04531_ VDD VSS AOI21_X1
X_27558_ _04526_ _04531_ _04333_ _04532_ VDD VSS OAI21_X1
X_27559_ _04270_ _04265_ _04533_ VDD VSS NAND2_X2
X_27560_ _15232_ _04335_ _04533_ _04497_ _04534_ VDD VSS NAND4_X1
X_27561_ _04298_ _04451_ _04535_ VDD VSS NOR2_X1
X_27562_ _04400_ _04327_ _04535_ _04536_ VDD VSS OAI21_X1
X_27563_ _04444_ _04534_ _04536_ _04537_ VDD VSS AOI21_X1
X_27564_ _04269_ _04380_ _04412_ _04538_ VDD VSS NAND3_X1
X_27565_ _04504_ _04538_ _04539_ VDD VSS AND2_X1
X_27566_ _04445_ _04540_ VDD VSS CLKBUF_X3
X_27567_ _04537_ _04539_ _04540_ _04541_ VDD VSS AOI21_X1
X_27568_ _04532_ _04541_ _04333_ _04542_ VDD VSS AOI21_X1
X_27569_ _04525_ _04503_ _04483_ _04542_ _00137_ VDD VSS NOR4_X2
X_27570_ _04344_ _04543_ VDD VSS BUF_X4
X_27571_ _04272_ _04380_ _04415_ _04544_ VDD VSS NAND3_X1
X_27572_ _04320_ _04472_ _04479_ _04545_ VDD VSS OAI21_X1
X_27573_ _04543_ _04544_ _04545_ _04546_ VDD VSS AOI21_X2
X_27574_ _04456_ _04251_ _04234_ _04547_ VDD VSS OAI21_X1
X_27575_ _15252_ _04547_ _04334_ _04548_ VDD VSS MUX2_X1
X_27576_ _04341_ _04546_ _04548_ _04345_ _04549_ VDD VSS AOI211_X2
X_27577_ net1046 _04412_ _04456_ _04550_ VDD VSS NAND3_X2
X_27578_ net153 _04471_ _04358_ _04551_ VDD VSS NAND3_X1
X_27579_ _15232_ _04360_ _04533_ _04552_ VDD VSS NAND3_X1
X_27580_ _04550_ _04470_ _04551_ _04552_ _04553_ VDD VSS AND4_X4
X_27581_ _04330_ _04327_ _04234_ _04454_ net1046 _04554_ VDD
+ VSS AOI221_X2
X_27582_ _04360_ _04555_ VDD VSS BUF_X4
X_27583_ _15249_ _04556_ VDD VSS INV_X1
X_27584_ _04543_ _04555_ _04556_ _04557_ VDD VSS OAI21_X1
X_27585_ _04341_ _04554_ _04557_ _04558_ VDD VSS OAI21_X2
X_27586_ _04355_ _04553_ _04558_ _04559_ VDD VSS OAI21_X4
X_27587_ _04270_ _04451_ _04560_ VDD VSS NOR2_X1
X_27588_ _04235_ _04334_ _04561_ VDD VSS NAND2_X1
X_27589_ _15256_ _04361_ _04560_ _04561_ _04562_ VDD VSS OAI22_X1
X_27590_ _04391_ _04423_ _04563_ VDD VSS NOR2_X1
X_27591_ _04330_ _04564_ VDD VSS CLKBUF_X3
X_27592_ _15247_ _04563_ _04564_ _04565_ VDD VSS MUX2_X1
X_27593_ _04379_ _04513_ _04562_ _04565_ _04510_ _04566_ VDD
+ VSS OAI221_X2
X_27594_ net673 _15233_ _04266_ _04567_ VDD VSS NOR3_X4
X_27595_ _04515_ _04396_ _04567_ _04317_ _04568_ VDD VSS AOI22_X4
X_27596_ _04370_ _04310_ _04313_ _04569_ VDD VSS AOI21_X1
X_27597_ _04569_ _04515_ _04317_ _04570_ VDD VSS AOI21_X1
X_27598_ _04568_ _04570_ _04272_ _04571_ VDD VSS OAI21_X2
X_27599_ _04375_ _04330_ _04572_ VDD VSS NAND2_X1
X_27600_ _04501_ _04572_ _04518_ _04573_ VDD VSS NAND3_X1
X_27601_ _04470_ _04372_ _04362_ _04574_ VDD VSS AOI21_X1
X_27602_ _04445_ _04571_ _04470_ _04573_ _04574_ _04575_ VDD
+ VSS AOI221_X2
X_27603_ _04377_ _04559_ _04549_ _04575_ _04566_ _04576_ VDD
+ VSS OAI221_X2
X_27604_ _04444_ _04433_ _04577_ VDD VSS NOR2_X1
X_27605_ net612 _15244_ _04578_ VDD VSS NOR2_X1
X_27606_ _04358_ _04436_ _04578_ _04579_ VDD VSS NAND3_X1
X_27607_ _15242_ _04580_ VDD VSS INV_X1
X_27608_ _04580_ _04307_ _04581_ VDD VSS NAND2_X1
X_27609_ _04577_ _04526_ _04579_ _04581_ _04582_ VDD VSS NAND4_X1
X_27610_ _04457_ _04328_ _04564_ _04583_ VDD VSS OAI21_X2
X_27611_ _04444_ _04412_ _04584_ VDD VSS NAND2_X1
X_27612_ _04314_ _04519_ _04585_ VDD VSS NAND2_X1
X_27613_ _04584_ _04585_ _04320_ _04362_ _04396_ _04586_ VDD
+ VSS AOI221_X2
X_27614_ _04543_ _04587_ VDD VSS CLKBUF_X3
X_27615_ _04583_ _04342_ _04586_ _04587_ _04588_ VDD VSS OAI22_X2
X_27616_ _04454_ _04314_ _04414_ _04589_ VDD VSS AOI21_X1
X_27617_ _15230_ _04349_ _04350_ _04590_ VDD VSS NOR3_X1
X_27618_ _04454_ _04380_ _04591_ VDD VSS NAND2_X1
X_27619_ _04341_ _04590_ _04591_ _04592_ VDD VSS OAI21_X1
X_27620_ _04589_ _04592_ _04593_ VDD VSS OR2_X1
X_27621_ _04526_ _04593_ _04588_ _04594_ VDD VSS NAND3_X2
X_27622_ _04377_ _04379_ _04595_ VDD VSS NOR2_X1
X_27623_ _04271_ _04399_ _04429_ _04596_ VDD VSS AOI21_X2
X_27624_ _04351_ _04417_ _04597_ VDD VSS NOR2_X1
X_27625_ _04433_ _04518_ _04596_ _04597_ _04272_ _04598_ VDD
+ VSS AOI221_X2
X_27626_ _15242_ _04267_ _04599_ VDD VSS NAND2_X1
X_27627_ _04399_ _04599_ _04600_ VDD VSS AND2_X1
X_27628_ _04346_ _04271_ _04601_ VDD VSS NAND2_X1
X_27629_ _04601_ _04391_ net128 _04602_ VDD VSS OAI21_X1
X_27630_ _04344_ _04398_ _04600_ _04602_ _04360_ _04603_ VDD
+ VSS AOI221_X2
X_27631_ _04540_ _04598_ _04603_ _04604_ VDD VSS OR3_X4
X_27632_ _04429_ _04271_ _04605_ VDD VSS NAND2_X1
X_27633_ _04317_ _04599_ _04605_ _04606_ VDD VSS AOI21_X1
X_27634_ _04606_ _04440_ _04334_ _04362_ _04372_ _04607_ VDD
+ VSS AOI221_X2
X_27635_ _15251_ _04347_ _04505_ _04608_ VDD VSS NOR3_X1
X_27636_ _04345_ _15244_ _04362_ _04609_ VDD VSS OAI21_X1
X_27637_ _04540_ _04587_ _04607_ _04608_ _04609_ _04610_ VDD
+ VSS OAI221_X1
X_27638_ _04595_ _04604_ _04610_ _04611_ VDD VSS NAND3_X4
X_27639_ _04594_ _04576_ _04582_ _04611_ _00138_ VDD VSS NAND4_X4
X_27640_ _04485_ _04429_ _04268_ _04612_ VDD VSS MUX2_X1
X_27641_ _04543_ _04372_ net181 _04612_ _04400_ _04613_ VDD
+ VSS AOI221_X2
X_27642_ _04332_ _04436_ net153 _15235_ _04269_ _04614_ VDD
+ VSS AOI221_X1
X_27643_ _04265_ _04309_ _04312_ _04615_ VDD VSS NAND3_X4
X_27644_ _04540_ _04613_ _04614_ _04615_ net612 _04616_ VDD
+ VSS OAI221_X1
X_27645_ _04360_ _04433_ _04392_ _04617_ VDD VSS NOR3_X1
X_27646_ _04528_ _04617_ _04618_ VDD VSS AND2_X1
X_27647_ _04316_ _04343_ _04619_ VDD VSS NAND2_X1
X_27648_ _04370_ _04320_ _04620_ VDD VSS NOR2_X1
X_27649_ _04619_ _04563_ _04620_ _04621_ VDD VSS NOR3_X1
X_27650_ _04370_ _04451_ _04317_ _04358_ net966 net481 _04622_
+ VDD VSS OAI33_X1
X_27651_ _04543_ _04589_ _04622_ _04623_ VDD VSS NOR3_X1
X_27652_ _04445_ _04618_ _04621_ _04623_ _04624_ VDD VSS OR4_X1
X_27653_ _04377_ _04616_ _04624_ _04625_ VDD VSS NAND3_X1
X_27654_ _04451_ _04334_ _04235_ _04626_ VDD VSS OAI21_X1
X_27655_ _04406_ _04626_ _15235_ _04336_ _15232_ _04627_ VDD
+ VSS AOI221_X1
X_27656_ _04627_ _04615_ _04375_ _04628_ VDD VSS OAI21_X1
X_27657_ _04429_ _04349_ _04350_ _04629_ VDD VSS NOR3_X2
X_27658_ _04454_ _04569_ _04629_ _04630_ VDD VSS OAI21_X1
X_27659_ _04543_ _04568_ _04630_ _04631_ VDD VSS NAND3_X1
X_27660_ _04330_ _04398_ _04599_ _04632_ VDD VSS NAND3_X1
X_27661_ _04290_ _04332_ _04632_ _04633_ VDD VSS AOI21_X2
X_27662_ _15242_ _04309_ _04312_ _04634_ VDD VSS AOI21_X4
X_27663_ _04272_ _04634_ _04635_ VDD VSS NOR2_X1
X_27664_ _15238_ _04310_ _04313_ _04636_ VDD VSS NAND3_X1
X_27665_ _04414_ _04636_ _04637_ VDD VSS NAND2_X4
X_27666_ _04314_ _04635_ _04637_ _04471_ _04638_ VDD VSS AOI22_X2
X_27667_ _04377_ _04631_ _04633_ _04638_ _04460_ _04639_ VDD
+ VSS AOI221_X2
X_27668_ _04379_ _04628_ _04639_ _04640_ VDD VSS AOI21_X1
X_27669_ _04454_ _04382_ _04436_ _04641_ VDD VSS NAND3_X1
X_27670_ _04485_ _04396_ _04567_ _04316_ _04642_ VDD VSS AOI22_X1
X_27671_ _04510_ _04641_ _04642_ _04643_ VDD VSS AOI21_X1
X_27672_ _04324_ _04615_ _04318_ _04644_ VDD VSS OAI21_X1
X_27673_ _04289_ _04315_ _04529_ _04645_ VDD VSS NOR3_X1
X_27674_ _04372_ _04373_ _04289_ _04646_ VDD VSS MUX2_X1
X_27675_ _04644_ _04645_ _04456_ _04348_ _04646_ _04647_ VDD
+ VSS AOI221_X2
X_27676_ _04406_ _04396_ _04251_ _04429_ _04374_ _04648_ VDD
+ VSS AOI221_X1
X_27677_ _04377_ _04643_ _04647_ _04648_ _04649_ VDD VSS NOR4_X1
X_27678_ _04271_ _04417_ _04479_ _04650_ VDD VSS NOR3_X1
X_27679_ _15228_ _15236_ _04329_ _04651_ VDD VSS MUX2_X1
X_27680_ _04650_ _04651_ _04451_ _04652_ VDD VSS AOI21_X1
X_27681_ _04390_ _04316_ _04580_ _04653_ VDD VSS AOI21_X2
X_27682_ _04448_ _04329_ _04233_ _04654_ VDD VSS AOI21_X1
X_27683_ _04653_ _04654_ _04267_ _04655_ VDD VSS MUX2_X1
X_27684_ _04652_ _04655_ _04344_ _04656_ VDD VSS MUX2_X1
X_27685_ _04351_ _04591_ _04657_ VDD VSS NOR2_X1
X_27686_ _04360_ _04533_ _04658_ VDD VSS NOR2_X1
X_27687_ _04338_ _04412_ _04456_ _04659_ VDD VSS AOI21_X1
X_27688_ _04334_ _04423_ _04398_ _04660_ VDD VSS AOI21_X1
X_27689_ _04344_ _04493_ _04235_ _04661_ VDD VSS OAI21_X1
X_27690_ _04345_ _04657_ _04658_ _04659_ _04660_ _04661_ _04662_
+ VDD VSS OAI33_X1
X_27691_ _04649_ _04656_ _04427_ _04662_ _04291_ _04663_ VDD
+ VSS AOI221_X2
X_27692_ _04625_ _04640_ _04379_ _04663_ _00139_ VDD VSS AOI22_X1
X_27693_ _04543_ _04514_ _04471_ _04335_ _04429_ _04664_ VDD
+ VSS AOI221_X1
X_27694_ _04271_ _04316_ _04234_ _04665_ VDD VSS AOI21_X2
X_27695_ _04440_ _04572_ _04665_ _04666_ VDD VSS AOI21_X1
X_27696_ _04664_ _04666_ _04587_ _04667_ VDD VSS AOI21_X1
X_27697_ net153 _04269_ _04332_ _04668_ VDD VSS NOR3_X1
X_27698_ _04501_ _04543_ _04669_ VDD VSS NOR2_X1
X_27699_ _04668_ _04669_ _04375_ _04670_ VDD VSS AOI21_X1
X_27700_ _15226_ _04501_ _04470_ _04671_ VDD VSS OAI21_X1
X_27701_ _04440_ _04671_ _15232_ _04672_ VDD VSS AOI21_X1
X_27702_ _04670_ _04672_ _04564_ _04673_ VDD VSS MUX2_X1
X_27703_ _04462_ _04543_ _04674_ VDD VSS NOR2_X1
X_27704_ net612 _04359_ _04674_ _04675_ VDD VSS OAI21_X1
X_27705_ _04291_ _04355_ _04675_ _04676_ VDD VSS AND3_X1
X_27706_ _04446_ _04667_ _04673_ _04676_ _04677_ VDD VSS AOI22_X1
X_27707_ _04474_ _04555_ _04375_ _04678_ VDD VSS OAI21_X1
X_27708_ _15244_ _04678_ _04679_ VDD VSS NAND2_X1
X_27709_ _04587_ _04538_ _04679_ _04680_ VDD VSS AOI21_X1
X_27710_ _04345_ _04635_ _04658_ _04681_ VDD VSS OAI21_X1
X_27711_ _04540_ _04681_ _04682_ VDD VSS NAND2_X1
X_27712_ _04268_ _04399_ _04326_ _04683_ VDD VSS AOI21_X1
X_27713_ _04314_ _04360_ _04338_ _04684_ VDD VSS OAI21_X1
X_27714_ _04332_ _04516_ _04683_ _04684_ _04269_ _04685_ VDD
+ VSS AOI221_X2
X_27715_ _04514_ _04516_ _04686_ VDD VSS NAND2_X1
X_27716_ _04685_ _04686_ _04669_ _04687_ VDD VSS AOI21_X1
X_27717_ _04595_ _04680_ _04682_ _04687_ _04540_ _04688_ VDD
+ VSS OAI221_X1
X_27718_ _04391_ _04399_ _04689_ VDD VSS NAND2_X1
X_27719_ net672 _04689_ _04690_ VDD VSS NOR2_X1
X_27720_ _04564_ _04423_ _04691_ VDD VSS NOR2_X1
X_27721_ _04501_ _04314_ _04572_ _04692_ VDD VSS AOI21_X1
X_27722_ _04342_ _04690_ _04691_ _04692_ _04693_ VDD VSS NOR4_X1
X_27723_ _15240_ _04486_ _04335_ _04694_ VDD VSS MUX2_X1
X_27724_ _04587_ _04694_ _04540_ _04695_ VDD VSS OAI21_X1
X_27725_ _04444_ _04555_ _04440_ _04696_ VDD VSS NAND3_X1
X_27726_ _04629_ _04564_ _04341_ _04697_ VDD VSS AOI21_X1
X_27727_ _04696_ _04697_ _15244_ _04361_ _04423_ _04698_ VDD
+ VSS OAI221_X1
X_27728_ _04397_ _04615_ _04445_ _04699_ VDD VSS OAI21_X1
X_27729_ _04698_ _04699_ net612 _04700_ VDD VSS AOI21_X1
X_27730_ _04526_ _04695_ _04693_ _04700_ _04587_ _04701_ VDD
+ VSS OAI221_X1
X_27731_ _04484_ _04702_ VDD VSS INV_X1
X_27732_ _04462_ _04634_ _04703_ VDD VSS NOR2_X1
X_27733_ _04329_ _04423_ _04704_ VDD VSS OR2_X2
X_27734_ _15251_ _04637_ _04703_ _04704_ _04705_ VDD VSS AOI22_X1
X_27735_ _04333_ _04705_ _04706_ VDD VSS NOR2_X1
X_27736_ _04462_ _04555_ _04326_ _04707_ VDD VSS OAI21_X1
X_27737_ _04601_ _04707_ _04351_ _04708_ VDD VSS OAI21_X1
X_27738_ _04342_ _04587_ _04708_ _04709_ VDD VSS OAI21_X1
X_27739_ _04519_ _04330_ _04388_ _04710_ VDD VSS OAI21_X1
X_27740_ _04543_ _04704_ _04683_ _04710_ _04269_ _04711_ VDD
+ VSS AOI221_X1
X_27741_ _04375_ _15251_ _04712_ VDD VSS NOR2_X1
X_27742_ _04361_ _04578_ _04712_ _04713_ VDD VSS OAI21_X1
X_27743_ _04711_ _04713_ _04331_ _04714_ VDD VSS AOI21_X1
X_27744_ _04702_ _04706_ _04709_ _04714_ _04342_ _04715_ VDD
+ VSS OAI221_X1
X_27745_ _04677_ _04688_ _04701_ _04715_ _00140_ VDD VSS NAND4_X1
X_27746_ _04519_ _04399_ _15228_ _04716_ VDD VSS OAI21_X1
X_27747_ _04324_ _04485_ _04307_ _04716_ _04268_ _04717_ VDD
+ VSS AOI221_X2
X_27748_ net1047 net1045 _04329_ _04718_ VDD VSS MUX2_X1
X_27749_ _04343_ _04396_ net128 _04718_ _04268_ _04719_ VDD
+ VSS AOI221_X2
X_27750_ _04717_ _04296_ _04719_ _04720_ VDD VSS NOR3_X1
X_27751_ _04265_ _04329_ _04346_ _04721_ VDD VSS AOI21_X2
X_27752_ _04479_ _04399_ _04387_ _04722_ VDD VSS AOI21_X1
X_27753_ _04426_ _04704_ _04721_ _04722_ _04391_ _04723_ VDD
+ VSS AOI221_X2
X_27754_ _04415_ _04519_ _04724_ VDD VSS NAND2_X1
X_27755_ _04289_ _04364_ _04396_ _04724_ _04268_ _04725_ VDD
+ VSS AOI221_X1
X_27756_ _04470_ _04723_ _04725_ _04726_ VDD VSS OAI21_X1
X_27757_ _04289_ _04515_ _04307_ _04336_ _04326_ _04727_ VDD
+ VSS AOI221_X1
X_27758_ _04316_ _04423_ _04396_ _04270_ _04728_ VDD VSS OAI22_X1
X_27759_ _04324_ _04727_ _04466_ _04728_ _04289_ _04729_ VDD
+ VSS AOI221_X1
X_27760_ _04509_ _04729_ _04730_ VDD VSS NOR2_X1
X_27761_ net612 _04555_ _04577_ _04731_ VDD VSS OAI21_X1
X_27762_ _04555_ _04577_ _04462_ _04732_ VDD VSS OAI21_X1
X_27763_ net128 _04316_ _04733_ VDD VSS NOR2_X1
X_27764_ _15226_ _04733_ _04460_ _04734_ VDD VSS AOI21_X1
X_27765_ _04731_ _04732_ _04734_ _04735_ VDD VSS NAND3_X1
X_27766_ _04317_ _04533_ _04493_ _04370_ _04736_ VDD VSS OAI22_X2
X_27767_ _04317_ _04343_ _04529_ _04737_ VDD VSS OAI21_X1
X_27768_ _04689_ _04737_ _04738_ VDD VSS NAND2_X1
X_27769_ _04428_ _04736_ _04433_ _04738_ net153 _04739_ VDD
+ VSS AOI221_X2
X_27770_ _04720_ _04726_ _04730_ _04735_ _04739_ _04740_ VDD
+ VSS AOI221_X2
X_27771_ _04326_ _15244_ _04741_ VDD VSS NOR2_X1
X_27772_ _04333_ _04493_ net181 _04741_ _04361_ _04742_ VDD
+ VSS OAI221_X1
X_27773_ _04361_ _04567_ _04743_ VDD VSS NAND2_X1
X_27774_ _04327_ _04380_ _04560_ _04744_ VDD VSS OR3_X1
X_27775_ _04345_ _04743_ _04744_ _04745_ VDD VSS NAND3_X1
X_27776_ _04540_ _04742_ _04745_ _04746_ VDD VSS AOI21_X1
X_27777_ _04462_ _04390_ _04479_ _04747_ VDD VSS NOR3_X1
X_27778_ _04747_ _04724_ _15251_ _04748_ VDD VSS AOI21_X1
X_27779_ _04513_ _04748_ _04749_ VDD VSS NOR2_X1
X_27780_ _04510_ _04461_ _04471_ net908 _04555_ _04750_ VDD
+ VSS AOI221_X1
X_27781_ _04746_ _04749_ _04750_ _04751_ VDD VSS NOR3_X1
X_27782_ _04276_ _04379_ _04752_ VDD VSS NAND2_X1
X_27783_ _04269_ _04400_ _04362_ _04753_ VDD VSS AOI21_X1
X_27784_ _04445_ _04691_ _04753_ _04754_ VDD VSS OAI21_X1
X_27785_ _04429_ _04471_ _04533_ _04388_ _04755_ VDD VSS OAI22_X1
X_27786_ net1045 _04471_ _04756_ VDD VSS NAND2_X1
X_27787_ _04564_ _04755_ _04756_ _04448_ _04757_ VDD VSS AOI22_X1
X_27788_ _04754_ _04757_ _04445_ _04758_ VDD VSS OAI21_X1
X_27789_ _04449_ _04438_ _04501_ _04759_ VDD VSS OAI21_X1
X_27790_ _15226_ _04493_ _04637_ _04269_ _04760_ VDD VSS OAI22_X1
X_27791_ _04759_ _04760_ _04444_ _04761_ VDD VSS MUX2_X1
X_27792_ _04758_ _04761_ _04587_ _04762_ VDD VSS MUX2_X1
X_27793_ _04740_ _04751_ _04752_ _04356_ _04762_ _00141_ VDD
+ VSS OAI221_X2
X_27794_ _04429_ _04320_ _04310_ _04313_ _04763_ VDD VSS AOI22_X1
X_27795_ _15246_ _04555_ _04456_ _04763_ _04764_ VDD VSS AOI22_X1
X_27796_ _04540_ _04764_ _04765_ VDD VSS NOR2_X1
X_27797_ _04341_ _04564_ _04328_ _04766_ VDD VSS NOR3_X1
X_27798_ _04587_ _04765_ _04766_ _04767_ VDD VSS OAI21_X1
X_27799_ _04382_ _04436_ _04768_ VDD VSS NAND2_X1
X_27800_ _04434_ _04768_ _04320_ _04307_ net1046 _04769_ VDD
+ VSS AOI221_X1
X_27801_ _04513_ _04630_ _04464_ _04770_ VDD VSS AOI21_X1
X_27802_ _04769_ _04770_ _04771_ VDD VSS NOR2_X1
X_27803_ _04752_ _04767_ _04771_ _04772_ VDD VSS AOI21_X1
X_27804_ _04375_ _15235_ _04444_ _04773_ VDD VSS MUX2_X1
X_27805_ _04636_ _04773_ _04555_ _04774_ VDD VSS OAI21_X1
X_27806_ _15244_ _04774_ _04775_ VDD VSS NAND2_X1
X_27807_ _04474_ _04335_ _04338_ _04776_ VDD VSS OAI21_X1
X_27808_ net672 _04361_ _04776_ _04445_ _04777_ VDD VSS AOI22_X1
X_27809_ _04333_ _04775_ _04777_ _15244_ _04778_ VDD VSS OAI211_X2
X_27810_ _04478_ _04501_ _15227_ _04779_ VDD VSS AOI21_X2
X_27811_ _15245_ _15254_ _04780_ VDD VSS OR2_X1
X_27812_ _04341_ _04555_ _04780_ _04781_ VDD VSS OAI21_X1
X_27813_ _04269_ _04590_ _04634_ _04782_ VDD VSS NOR3_X1
X_27814_ _04782_ _04721_ _04516_ _04783_ VDD VSS AOI21_X2
X_27815_ _04587_ _04779_ _04781_ _04783_ _04342_ _04784_ VDD
+ VSS OAI221_X2
X_27816_ _04356_ _04778_ _04784_ _04785_ VDD VSS AOI21_X2
X_27817_ _04330_ _04268_ _04338_ _04786_ VDD VSS OAI21_X1
X_27818_ _04290_ _04563_ _04786_ _04400_ _15247_ _04787_ VDD
+ VSS OAI221_X1
X_27819_ _04387_ _04440_ _04788_ VDD VSS NOR2_X1
X_27820_ _04444_ _04400_ _04788_ _04397_ net908 _04789_ VDD
+ VSS OAI221_X1
X_27821_ _04470_ _04787_ _04789_ _04790_ VDD VSS AND3_X2
X_27822_ _04501_ _04414_ _04412_ _04791_ VDD VSS NAND3_X1
X_27823_ _04462_ _04430_ _04792_ VDD VSS NAND2_X1
X_27824_ _04406_ _04791_ _04792_ _04793_ VDD VSS AOI21_X1
X_27825_ _04391_ _04704_ _04794_ VDD VSS NAND2_X1
X_27826_ _04268_ _04314_ _04414_ _04795_ VDD VSS NAND3_X1
X_27827_ _04510_ _04794_ _04795_ _04567_ _04400_ _04796_ VDD
+ VSS AOI221_X2
X_27828_ _04484_ _04790_ _04793_ _04796_ _04797_ VDD VSS NOR4_X2
X_27829_ _04343_ _04497_ _04634_ _04271_ _04798_ VDD VSS AOI22_X1
X_27830_ _04290_ _04619_ _04398_ _04798_ _04387_ _04799_ VDD
+ VSS OAI221_X1
X_27831_ _04417_ _04327_ net128 _04800_ VDD VSS AOI21_X1
X_27832_ _04497_ _04800_ net181 _04235_ _04358_ _04801_ VDD
+ VSS OAI221_X1
X_27833_ _04799_ _04801_ _04470_ _04802_ VDD VSS AOI21_X2
X_27834_ _04235_ _04344_ _04803_ VDD VSS NOR2_X1
X_27835_ _04320_ _04359_ _04803_ _04804_ VDD VSS OAI21_X1
X_27836_ _04496_ _04637_ _04433_ _04805_ VDD VSS OAI21_X1
X_27837_ _04804_ _04805_ _04269_ _15226_ _04496_ _04806_ VDD
+ VSS OAI221_X2
X_27838_ _04509_ _04802_ _04806_ _04445_ _04807_ VDD VSS AOI211_X2
X_27839_ _04797_ _04785_ _04772_ _04807_ _00142_ VDD VSS NOR4_X2
X_27840_ _04364_ _04397_ _04619_ _04808_ VDD VSS AOI21_X1
X_27841_ _04235_ _04360_ _04332_ _04327_ _04809_ VDD VSS NAND4_X1
X_27842_ _04809_ _04470_ _04501_ net1046 _04689_ _04810_ VDD
+ VSS OAI221_X1
X_27843_ _04355_ _04808_ _04810_ _04811_ VDD VSS NOR3_X1
X_27844_ _04314_ _04519_ _04812_ VDD VSS AND2_X1
X_27845_ _04403_ _04561_ _04596_ _04812_ _04501_ _04813_ VDD
+ VSS AOI221_X2
X_27846_ _04581_ _04397_ _15235_ _04814_ VDD VSS OAI21_X1
X_27847_ _04355_ _04470_ _04815_ VDD VSS NAND2_X1
X_27848_ _04338_ _04374_ _04816_ VDD VSS NOR2_X1
X_27849_ _04814_ _04815_ _04816_ _04817_ VDD VSS NOR3_X1
X_27850_ _04342_ _04811_ _04813_ _04817_ _04818_ VDD VSS NOR4_X1
X_27851_ _04335_ _04423_ _04819_ VDD VSS NOR2_X1
X_27852_ _15232_ _04314_ _04397_ _04820_ VDD VSS AOI21_X1
X_27853_ _04345_ _04819_ _04820_ _04821_ VDD VSS OAI21_X1
X_27854_ _04417_ _04307_ _15226_ _04822_ VDD VSS AOI21_X1
X_27855_ _04372_ _04396_ _15235_ _04823_ VDD VSS AOI21_X1
X_27856_ _04821_ _04822_ _04345_ net612 _04823_ _04824_ VDD
+ VSS OAI221_X1
X_27857_ _04540_ _04355_ _04824_ _04825_ VDD VSS NOR3_X1
X_27858_ _04333_ _04615_ _04298_ _04397_ _15235_ _04826_ VDD
+ VSS OAI221_X1
X_27859_ _04564_ _04372_ _15235_ _04827_ VDD VSS MUX2_X1
X_27860_ _04826_ _04827_ _15232_ _04828_ VDD VSS AOI21_X1
X_27861_ _04345_ _04493_ _04429_ _04710_ _15251_ _04829_ VDD
+ VSS OAI221_X2
X_27862_ _04342_ _04355_ _04829_ _04830_ VDD VSS NAND3_X1
X_27863_ _04276_ _04828_ _04830_ _04831_ VDD VSS OAI21_X1
X_27864_ _04567_ _04462_ _04346_ _04832_ VDD VSS AOI21_X1
X_27865_ _04341_ _04380_ _04384_ _04832_ _04564_ _04833_ VDD
+ VSS OAI221_X1
X_27866_ _04445_ _04361_ _04362_ _04834_ VDD VSS OAI21_X1
X_27867_ _04833_ _04834_ _04779_ _04835_ VDD VSS OAI21_X1
X_27868_ _04377_ _04815_ _04835_ _04836_ VDD VSS OAI21_X1
X_27869_ _04289_ _04514_ _04665_ _04272_ _04298_ _04837_ VDD
+ VSS AOI221_X2
X_27870_ net908 _04335_ _04417_ _04235_ _04838_ VDD VSS AOI22_X1
X_27871_ _04473_ _04838_ _15244_ _04839_ VDD VSS OAI21_X1
X_27872_ _04837_ _04839_ _04342_ _04840_ VDD VSS AOI21_X1
X_27873_ _04403_ _04840_ _04841_ VDD VSS NOR2_X1
X_27874_ net1078 _04267_ _04842_ VDD VSS NAND2_X1
X_27875_ _15240_ _04842_ _04399_ _04843_ VDD VSS MUX2_X1
X_27876_ _04332_ _04843_ _04290_ _04844_ VDD VSS AOI21_X1
X_27877_ _04605_ _04391_ _04338_ _04845_ VDD VSS OAI21_X1
X_27878_ _15254_ _04845_ _04330_ _04846_ VDD VSS MUX2_X1
X_27879_ _04844_ _04846_ _04341_ _04847_ VDD VSS OAI21_X1
X_27880_ _04454_ _04733_ _04479_ _04848_ VDD VSS NOR3_X1
X_27881_ _04521_ _04513_ _04848_ _04849_ VDD VSS OR3_X2
X_27882_ net674 _04235_ _04268_ _04850_ VDD VSS MUX2_X1
X_27883_ _04460_ _04850_ _04564_ _04380_ _04440_ _04851_ VDD
+ VSS OAI221_X1
X_27884_ _04379_ _04847_ _04849_ _04851_ _04852_ VDD VSS AND4_X2
X_27885_ _04818_ _04825_ _04831_ _04852_ _04841_ _04836_ _00143_
+ VDD VSS OAI33_X1
X_27886_ _06346_ _04853_ VDD VSS INV_X1
X_27887_ _04853_ _09730_ _04854_ VDD VSS NOR2_X1
X_27888_ _06346_ _09730_ _04855_ VDD VSS NOR2_X1
X_27889_ _13224_ _13179_ _04856_ VDD VSS XNOR2_X2
X_27890_ net551 _10437_ _04857_ VDD VSS XNOR2_X2
X_27891_ _04857_ _04856_ _04858_ VDD VSS XNOR2_X2
X_27892_ _04854_ _04855_ _04858_ _04859_ VDD VSS MUX2_X2
X_27893_ _06346_ _09856_ _00482_ _04860_ VDD VSS OR3_X4
X_27894_ _06346_ _00991_ _00482_ _04861_ VDD VSS NAND3_X2
X_27895_ _04861_ _04860_ _04862_ VDD VSS NAND2_X4
X_27896_ _04862_ _04859_ _04863_ VDD VSS NOR2_X4
X_27897_ net967 _04864_ VDD VSS INV_X8
X_27898_ _04864_ _04865_ VDD VSS BUF_X16
X_27899_ _04865_ _15264_ VDD VSS BUF_X32
X_27900_ _10439_ net530 _04866_ VDD VSS XNOR2_X1
X_27901_ _10432_ _10506_ _04867_ VDD VSS XOR2_X2
X_27902_ _06330_ _09100_ _04867_ _04868_ VDD VSS NAND3_X4
X_27903_ _06330_ _08993_ _04869_ VDD VSS NOR2_X1
X_27904_ _13224_ _04869_ _04870_ VDD VSS NAND2_X1
X_27905_ _04866_ _04868_ _04870_ _04871_ VDD VSS AOI21_X4
X_27906_ _10439_ net530 _04872_ VDD VSS XOR2_X1
X_27907_ _04867_ _04869_ _04873_ VDD VSS NAND2_X1
X_27908_ _06330_ _09023_ _13224_ _04874_ VDD VSS NAND3_X1
X_27909_ _04872_ _04873_ _04874_ _04875_ VDD VSS AOI21_X1
X_27910_ _06330_ _04876_ VDD VSS INV_X1
X_27911_ _04876_ _09030_ _00483_ _04877_ VDD VSS NAND3_X1
X_27912_ _06330_ _09030_ _04878_ VDD VSS NAND2_X1
X_27913_ _04877_ _04878_ _00483_ _04879_ VDD VSS OAI21_X1
X_27914_ _04875_ _04871_ _04879_ _04880_ VDD VSS OR3_X4
X_27915_ _04880_ _04881_ VDD VSS INV_X16
Xclone13 _07376_ net13 VDD VSS BUF_X4
X_27917_ _04881_ _15267_ VDD VSS BUF_X8
X_27918_ _10550_ _10482_ _04883_ VDD VSS XNOR2_X1
X_27919_ net482 net552 _04884_ VDD VSS XOR2_X2
X_27920_ _06358_ _09194_ _04884_ _04885_ VDD VSS NAND3_X1
X_27921_ _06358_ _09726_ _04886_ VDD VSS NOR2_X1
X_27922_ net561 _04886_ _04887_ VDD VSS NAND2_X1
X_27923_ _04883_ _04885_ _04887_ _04888_ VDD VSS AOI21_X2
X_27924_ _10550_ net1156 _04889_ VDD VSS XNOR2_X1
X_27925_ _04884_ _04886_ _04890_ VDD VSS NAND2_X1
X_27926_ _06358_ _09074_ net561 _04891_ VDD VSS NAND3_X1
X_27927_ _04889_ _04890_ _04891_ _04892_ VDD VSS AOI21_X2
X_27928_ _06365_ _08973_ _00484_ _04893_ VDD VSS NAND3_X1
X_27929_ _06358_ _08973_ _04894_ VDD VSS NAND2_X1
X_27930_ _04893_ _04894_ _00484_ _04895_ VDD VSS OAI21_X2
X_27931_ _04888_ _04892_ _04895_ _04896_ VDD VSS NOR3_X4
X_27932_ _04896_ _04897_ VDD VSS INV_X4
Xclone529 _04972_ net1157 VDD VSS INV_X4
X_27934_ _04897_ _04899_ VDD VSS BUF_X4
X_27935_ _04899_ _04900_ VDD VSS BUF_X4
X_27936_ _04900_ _15283_ VDD VSS BUF_X4
X_27937_ _04880_ _04901_ VDD VSS BUF_X16
X_27938_ _04901_ _15258_ VDD VSS BUF_X16
Xclone530 _04880_ net1158 VDD VSS BUF_X8
X_27940_ net1024 _04903_ VDD VSS BUF_X8
X_27941_ _04903_ _04904_ VDD VSS BUF_X4
X_27942_ _04904_ _04905_ VDD VSS BUF_X4
X_27943_ _04905_ _15276_ VDD VSS BUF_X8
X_27944_ _10503_ _13229_ _04906_ VDD VSS XNOR2_X1
X_27945_ _10458_ _04906_ _04907_ VDD VSS XNOR2_X1
X_27946_ text_in_r\[39\] _04907_ _11207_ _04908_ VDD VSS MUX2_X2
X_27947_ _06442_ _04908_ _04909_ VDD VSS XOR2_X2
X_27948_ _10516_ _10505_ _04910_ VDD VSS XNOR2_X1
X_27949_ _10514_ _04910_ _04911_ VDD VSS XNOR2_X2
X_27950_ _10524_ _04911_ _04912_ VDD VSS XNOR2_X1
X_27951_ text_in_r\[38\] _04912_ _09803_ _04913_ VDD VSS MUX2_X2
X_27952_ _06434_ _04913_ _04914_ VDD VSS XNOR2_X2
X_27953_ _04914_ _04915_ VDD VSS BUF_X4
X_27954_ _04909_ _04915_ _04916_ VDD VSS NOR2_X2
X_27955_ _10527_ _10523_ _04917_ VDD VSS XNOR2_X1
X_27956_ _02320_ _04917_ _04918_ VDD VSS XNOR2_X1
X_27957_ text_in_r\[37\] _04918_ _09076_ _04919_ VDD VSS MUX2_X2
X_27958_ _06420_ _04919_ _04920_ VDD VSS XOR2_X2
X_27959_ _04920_ _04921_ VDD VSS BUF_X4
X_27960_ _06406_ _04922_ VDD VSS INV_X1
X_27961_ _09195_ text_in_r\[36\] _04923_ VDD VSS NOR2_X1
X_27962_ _10538_ _02358_ _04924_ VDD VSS XNOR2_X1
X_27963_ _04922_ _04923_ _11191_ _04924_ _04925_ VDD VSS AOI211_X2
X_27964_ _11841_ text_in_r\[36\] _04926_ VDD VSS AND2_X1
X_27965_ _10538_ _02358_ _04927_ VDD VSS XOR2_X1
X_27966_ _06406_ _04926_ _11191_ _04927_ _04928_ VDD VSS AOI211_X2
X_27967_ _04925_ _04928_ _04929_ VDD VSS OR2_X1
X_27968_ _04929_ _04930_ VDD VSS BUF_X2
X_27969_ _04930_ _04931_ VDD VSS BUF_X4
X_27970_ _04931_ _04932_ VDD VSS BUF_X4
X_27971_ _04921_ _04932_ _04933_ VDD VSS NAND2_X2
Xclone143 net474 net143 VDD VSS INV_X1
X_27973_ net941 _04935_ VDD VSS BUF_X8
X_27974_ _06392_ net830 _04936_ VDD VSS AND2_X1
X_27975_ _06392_ _08994_ _04937_ VDD VSS NOR2_X1
X_27976_ _10553_ _02336_ _04938_ VDD VSS XNOR2_X2
X_27977_ _04936_ _04937_ _04938_ _04939_ VDD VSS MUX2_X1
X_27978_ _04939_ _04940_ VDD VSS BUF_X8
X_27979_ text_in_r\[35\] _04941_ VDD VSS BUF_X2
X_27980_ _06392_ _09075_ _04942_ VDD VSS NOR2_X2
X_27981_ _04941_ _04942_ _04943_ VDD VSS NAND2_X1
X_27982_ _06392_ _09730_ _04944_ VDD VSS NAND2_X1
X_27983_ _04943_ _04944_ _04941_ _04945_ VDD VSS OAI21_X2
X_27984_ _04945_ _04946_ VDD VSS BUF_X8
X_27985_ net1022 _04940_ _04946_ _04947_ VDD VSS OAI21_X4
X_27986_ _04901_ _04897_ _04948_ VDD VSS NAND2_X1
X_27987_ _04936_ _04949_ VDD VSS INV_X1
X_27988_ _04937_ _04950_ VDD VSS INV_X1
X_27989_ _04949_ _04950_ _04938_ _04951_ VDD VSS MUX2_X2
X_27990_ _04951_ _04952_ VDD VSS BUF_X4
X_27991_ _04941_ _04944_ _04953_ VDD VSS NOR2_X1
X_27992_ _04953_ _04942_ _04941_ _04954_ VDD VSS AOI21_X4
X_27993_ _04954_ _04955_ VDD VSS BUF_X4
X_27994_ _04859_ net1074 _04952_ _04955_ _04956_ VDD VSS AOI211_X2
X_27995_ net1028 _04947_ _04948_ _04956_ _04957_ VDD VSS OAI22_X1
X_27996_ _04940_ _04958_ VDD VSS BUF_X4
X_27997_ _04946_ _04959_ VDD VSS BUF_X4
X_27998_ _04901_ _04958_ _04959_ _04960_ VDD VSS NOR3_X4
X_27999_ _06346_ _09138_ _04961_ VDD VSS NAND2_X1
X_28000_ _04853_ _09138_ _04962_ VDD VSS NAND2_X1
X_28001_ _04961_ _04962_ _04858_ _04963_ VDD VSS MUX2_X2
X_28002_ _04860_ _04861_ _04964_ VDD VSS AND2_X1
X_28003_ _04963_ _04964_ _04951_ _04954_ _04965_ VDD VSS NAND4_X2
X_28004_ _04965_ _04966_ VDD VSS BUF_X4
Xsplit87 net1033 net87 VDD VSS BUF_X1
X_28006_ net1033 _04958_ _04959_ _04968_ VDD VSS OAI21_X2
X_28007_ _04966_ _04968_ _04969_ VDD VSS NAND2_X1
X_28008_ _04897_ _04970_ VDD VSS BUF_X4
X_28009_ _04970_ _04971_ VDD VSS CLKBUF_X3
X_28010_ _15261_ _04972_ VDD VSS BUF_X4
X_28011_ _04972_ _04973_ VDD VSS BUF_X8
X_28012_ _04897_ _04952_ _04955_ _04974_ VDD VSS AOI21_X2
X_28013_ _04974_ _04975_ VDD VSS BUF_X4
X_28014_ _04960_ _04969_ _04971_ _04973_ _04975_ _04976_ VDD
+ VSS AOI221_X1
X_28015_ net1164 net1161 _04977_ VDD VSS NOR2_X4
X_28016_ _04920_ _04977_ _04978_ VDD VSS NAND2_X2
X_28017_ _04916_ _04933_ _04957_ _04976_ _04978_ _04979_ VDD
+ VSS OAI221_X1
X_28018_ _04921_ _04980_ VDD VSS BUF_X4
X_28019_ _04977_ _04981_ VDD VSS BUF_X4
X_28020_ _04981_ _04982_ VDD VSS CLKBUF_X3
X_28021_ _04970_ _04983_ VDD VSS CLKBUF_X3
X_28022_ _15258_ _04983_ _04966_ _04984_ VDD VSS NAND3_X1
X_28023_ _04952_ _04955_ _04985_ VDD VSS NAND2_X4
X_28024_ _04985_ _04986_ VDD VSS CLKBUF_X3
X_28025_ _04863_ _04987_ VDD VSS BUF_X8
Xclone480 net946 net945 VDD VSS BUF_X4
X_28027_ _04968_ _04986_ net85 _04989_ VDD VSS OAI21_X1
X_28028_ _04984_ _04989_ _04971_ _04990_ VDD VSS OAI21_X1
X_28029_ _04930_ _04991_ VDD VSS CLKBUF_X3
X_28030_ _04991_ _04992_ VDD VSS CLKBUF_X3
X_28031_ _04881_ net1024 _04993_ VDD VSS NAND2_X4
X_28032_ _04948_ _04993_ _04987_ _04958_ _04959_ _04994_ VDD
+ VSS OAI221_X2
X_28033_ _04992_ _04994_ _04995_ VDD VSS AND2_X1
X_28034_ _04970_ net1075 net527 _04996_ VDD VSS OAI21_X4
X_28035_ _04985_ _04997_ VDD VSS BUF_X4
X_28036_ _04997_ _04998_ VDD VSS BUF_X4
Xsplit32 _14694_ net32 VDD VSS CLKBUF_X2
X_28038_ net939 _05000_ VDD VSS INV_X2
X_28039_ _04998_ _04905_ _05000_ _05001_ VDD VSS AOI21_X1
X_28040_ _04996_ _05001_ _05002_ VDD VSS NAND2_X1
X_28041_ _04980_ _04982_ _04990_ _04995_ _05002_ _05003_ VDD
+ VSS AOI221_X1
X_28042_ _04909_ _05004_ VDD VSS BUF_X4
X_28043_ _06434_ _04913_ _05005_ VDD VSS XOR2_X2
X_28044_ _05004_ _05005_ _05006_ VDD VSS NAND2_X2
Xrebuffer357 _01603_ net822 VDD VSS BUF_X1
X_28046_ _15260_ _05008_ VDD VSS CLKBUF_X3
X_28047_ _05008_ _05009_ VDD VSS INV_X1
X_28048_ _04897_ _04951_ _04954_ _05010_ VDD VSS NAND3_X1
X_28049_ _05010_ _05011_ VDD VSS CLKBUF_X3
X_28050_ _05009_ _05011_ _05012_ VDD VSS OR2_X1
X_28051_ net941 _04952_ _04955_ _05013_ VDD VSS AOI21_X4
X_28052_ net938 _04940_ _04946_ _05014_ VDD VSS NOR3_X4
X_28053_ _04903_ _05013_ _05014_ _05015_ VDD VSS OAI21_X4
X_28054_ _04978_ _05012_ _05015_ _05016_ VDD VSS AOI21_X2
X_28055_ _04940_ _04946_ _05017_ VDD VSS NOR2_X4
X_28056_ _05017_ _05018_ VDD VSS CLKBUF_X3
X_28057_ _05018_ _05019_ VDD VSS CLKBUF_X3
X_28058_ net944 _04897_ _05020_ VDD VSS AND2_X2
X_28059_ _04921_ _05019_ _05020_ _05021_ VDD VSS AOI21_X1
Xclone6 _06216_ net6 VDD VSS BUF_X4
X_28061_ _15270_ _05023_ VDD VSS INV_X4
X_28062_ _05023_ _04897_ _05024_ VDD VSS NOR2_X2
X_28063_ _04973_ _04947_ _05024_ _04997_ _05025_ VDD VSS OAI22_X1
X_28064_ _04994_ _05025_ _04981_ _05026_ VDD VSS MUX2_X1
X_28065_ net586 _04897_ _05027_ VDD VSS NAND2_X4
X_28066_ net1024 net1074 net529 _05028_ VDD VSS OAI21_X4
X_28067_ _05018_ _05027_ _05028_ _05029_ VDD VSS NAND3_X1
X_28068_ _04880_ _04897_ _05030_ VDD VSS NOR2_X4
Xclone141 _04864_ net141 VDD VSS BUF_X4
X_28070_ net142 _04903_ _05032_ VDD VSS NOR2_X1
X_28071_ _04986_ _05030_ _05032_ _05033_ VDD VSS OAI21_X1
X_28072_ _04932_ _05029_ _05033_ _05034_ VDD VSS AND3_X1
X_28073_ _05016_ _05026_ _05021_ _04980_ _05034_ _05035_ VDD
+ VSS AOI221_X2
X_28074_ _04979_ _05003_ _05035_ _05006_ _05036_ VDD VSS OAI22_X1
X_28075_ _05004_ _04915_ _05037_ VDD VSS NAND2_X2
X_28076_ _04981_ _05038_ VDD VSS BUF_X4
X_28077_ _04865_ _05039_ VDD VSS BUF_X4
X_28078_ _04881_ _04897_ _05040_ VDD VSS NOR2_X2
X_28079_ _04952_ _05041_ VDD VSS BUF_X4
X_28080_ _04955_ _05042_ VDD VSS BUF_X4
X_28081_ net941 _05041_ _05042_ _05043_ VDD VSS NAND3_X4
X_28082_ net1025 _04951_ _04954_ _05044_ VDD VSS NAND3_X4
X_28083_ _05039_ _05040_ _05043_ _05044_ _05045_ VDD VSS AOI22_X1
X_28084_ _15260_ _04947_ _05046_ VDD VSS NOR2_X1
X_28085_ _05045_ _05038_ _05046_ _05047_ VDD VSS NOR3_X2
X_28086_ net939 _05041_ _05042_ _05048_ VDD VSS NAND3_X1
X_28087_ _04881_ _04958_ _04959_ _05049_ VDD VSS OAI21_X4
X_28088_ _05048_ _05049_ _05050_ VDD VSS AND2_X1
X_28089_ _04904_ _05051_ VDD VSS CLKBUF_X3
X_28090_ _05047_ _05050_ _05051_ _05052_ VDD VSS OAI21_X1
X_28091_ _04903_ _04985_ _05053_ VDD VSS NOR2_X1
X_28092_ _04931_ _04997_ _15281_ _05053_ _04973_ _05054_ VDD
+ VSS AOI221_X2
X_28093_ _04980_ _05054_ _05055_ VDD VSS NOR2_X1
X_28094_ _04932_ _05056_ VDD VSS BUF_X4
X_28095_ _04901_ net1024 _05057_ VDD VSS NAND2_X1
X_28096_ net84 _05057_ _05058_ VDD VSS NOR2_X2
X_28097_ net604 _04958_ _04959_ _05059_ VDD VSS OAI21_X4
X_28098_ _05000_ _05058_ _04986_ _05060_ VDD VSS MUX2_X1
X_28099_ _04983_ _05061_ VDD VSS CLKBUF_X3
X_28100_ _05056_ _05058_ _05059_ _05060_ _05061_ _05062_ VDD
+ VSS OAI221_X2
X_28101_ _06420_ _04919_ _05063_ VDD VSS XNOR2_X2
X_28102_ _05063_ _05064_ VDD VSS BUF_X4
X_28103_ _05064_ _05065_ VDD VSS BUF_X4
X_28104_ _04986_ _05040_ _05039_ _05066_ VDD VSS AOI21_X1
X_28105_ _05017_ _05067_ VDD VSS CLKBUF_X3
X_28106_ _05067_ _05068_ VDD VSS CLKBUF_X3
X_28107_ _05000_ _05068_ _05069_ VDD VSS NOR2_X1
X_28108_ _05051_ _05066_ _05069_ _05070_ VDD VSS OAI21_X1
X_28109_ _15268_ _05071_ VDD VSS INV_X1
X_28110_ _04992_ _05066_ _05071_ _05072_ VDD VSS AOI21_X1
X_28111_ _05065_ _05070_ _05072_ _05073_ VDD VSS AOI21_X1
X_28112_ _05037_ _05055_ _05052_ _05062_ _05073_ _05074_ VDD
+ VSS AOI221_X2
X_28113_ _04980_ _05075_ VDD VSS BUF_X4
X_28114_ _04997_ _04881_ _04865_ _05076_ VDD VSS AOI21_X2
X_28115_ _05061_ _05019_ _05008_ _05077_ VDD VSS OAI21_X1
X_28116_ _04972_ _04952_ _04955_ _05078_ VDD VSS NAND3_X4
X_28117_ _05019_ _05079_ VDD VSS BUF_X4
X_28118_ _05078_ _05079_ net142 _05080_ VDD VSS OAI21_X1
X_28119_ _05075_ _05076_ _05077_ _05080_ _15283_ _05081_ VDD
+ VSS OAI221_X1
X_28120_ net142 _05011_ _05082_ VDD VSS NOR2_X1
X_28121_ _04897_ _04958_ _04959_ _05083_ VDD VSS OAI21_X4
X_28122_ _05044_ _05083_ _05084_ VDD VSS NAND2_X1
X_28123_ _05082_ _05084_ _05009_ _04975_ _04973_ _05085_ VDD
+ VSS AOI221_X1
X_28124_ _05081_ _05085_ _05075_ _05086_ VDD VSS OAI21_X1
X_28125_ _04992_ _05087_ VDD VSS CLKBUF_X3
X_28126_ _05004_ _05005_ _05088_ VDD VSS NOR2_X1
X_28127_ _05087_ _05088_ _05089_ VDD VSS NAND2_X1
X_28128_ _04982_ _05088_ _05090_ VDD VSS NAND2_X1
X_28129_ _04904_ _04920_ _05091_ VDD VSS NOR2_X1
X_28130_ _04972_ _05092_ VDD VSS INV_X8
X_28131_ _04993_ _04881_ _05039_ _05093_ VDD VSS OAI21_X1
X_28132_ _05068_ _05091_ net1157 _05093_ _04921_ _05094_ VDD
+ VSS AOI221_X1
X_28133_ net1157 _04899_ _04920_ _05095_ VDD VSS NOR3_X1
X_28134_ _04880_ _04896_ _05096_ VDD VSS NOR2_X4
X_28135_ _04904_ _05064_ _04881_ _05097_ VDD VSS OAI21_X1
X_28136_ _05095_ _05096_ _04921_ net1029 _05097_ _05098_ VDD
+ VSS AOI221_X2
X_28137_ _05094_ _05098_ _05079_ _05099_ VDD VSS AOI21_X1
X_28138_ _05086_ _05089_ _05090_ _05099_ _05100_ VDD VSS OAI22_X1
X_28139_ _05036_ _05074_ _05100_ _00144_ VDD VSS NOR3_X2
X_28140_ _05063_ _05101_ VDD VSS BUF_X4
X_28141_ _05039_ _04960_ _05102_ VDD VSS NAND2_X1
X_28142_ _04983_ _04968_ _04975_ net85 _05103_ VDD VSS AOI22_X1
X_28143_ _04982_ _05102_ _05103_ _05104_ VDD VSS NAND3_X1
X_28144_ _04903_ _05105_ VDD VSS BUF_X4
X_28145_ _05092_ _04940_ _04946_ _05106_ VDD VSS OAI21_X4
X_28146_ _05105_ _05043_ _05106_ _05107_ VDD VSS NAND3_X2
X_28147_ _05017_ _04881_ _04865_ _05108_ VDD VSS AOI21_X2
X_28148_ _05107_ net1159 net1162 _04905_ _05108_ _05109_ VDD
+ VSS OAI221_X2
X_28149_ _05101_ _05109_ _05104_ _05110_ VDD VSS AOI21_X2
X_28150_ _04920_ _04977_ _05111_ VDD VSS NOR2_X2
X_28151_ _05111_ _05049_ _05039_ _05092_ _05011_ _05112_ VDD
+ VSS OAI221_X1
X_28152_ _05112_ _05084_ _15258_ _05113_ VDD VSS AOI21_X1
X_28153_ _05064_ _04981_ _05114_ VDD VSS NAND2_X2
X_28154_ net586 _04940_ _04946_ _05115_ VDD VSS OAI21_X4
X_28155_ _15260_ _05041_ _05042_ _05116_ VDD VSS NAND3_X2
X_28156_ _04983_ _05115_ _05116_ _05117_ VDD VSS AOI21_X1
X_28157_ _04960_ _04997_ net943 _05118_ VDD VSS AOI21_X1
X_28158_ _05118_ _04983_ _05119_ VDD VSS AND2_X2
X_28159_ _05114_ _05117_ _05119_ _05120_ VDD VSS NOR3_X4
X_28160_ _05006_ _05110_ _05113_ _05120_ _05121_ VDD VSS NOR4_X2
X_28161_ _04900_ net1067 _05102_ _05122_ VDD VSS AOI21_X1
X_28162_ _05111_ _05011_ _15267_ _05123_ VDD VSS OAI21_X1
X_28163_ _04916_ _05122_ _05123_ _05124_ VDD VSS OAI21_X1
X_28164_ _04987_ net1158 _05067_ _05125_ VDD VSS NOR3_X1
X_28165_ _04905_ _05014_ _05125_ _05126_ VDD VSS OR3_X1
X_28166_ _04998_ _05127_ VDD VSS CLKBUF_X3
X_28167_ _05115_ _05127_ net87 _05128_ VDD VSS OAI21_X1
X_28168_ _05126_ _05128_ _05061_ _05129_ VDD VSS OAI21_X1
X_28169_ _04980_ _05056_ _05130_ VDD VSS NOR2_X1
X_28170_ _05124_ _05129_ _05130_ _05131_ VDD VSS AOI21_X1
X_28171_ _04881_ _05041_ _05042_ _05132_ VDD VSS NAND3_X4
X_28172_ _04904_ _05132_ _05115_ _05133_ VDD VSS AOI21_X2
X_28173_ _05014_ _04998_ _05008_ _05134_ VDD VSS AOI21_X1
X_28174_ _05133_ _05134_ _05051_ _05135_ VDD VSS AOI21_X1
X_28175_ _05135_ _05056_ _05136_ VDD VSS NOR2_X2
X_28176_ _05105_ _04960_ net795 _05137_ VDD VSS OAI21_X2
X_28177_ _05116_ _05068_ _05039_ _05138_ VDD VSS OAI21_X1
X_28178_ _04900_ _05138_ _05139_ VDD VSS NAND2_X1
X_28179_ _04992_ _05137_ _05139_ _05140_ VDD VSS AND3_X2
X_28180_ _05075_ _05136_ _05140_ _05141_ VDD VSS OAI21_X2
X_28181_ _06442_ _04908_ _05142_ VDD VSS XNOR2_X2
X_28182_ _05142_ _05143_ VDD VSS BUF_X4
X_28183_ _04985_ _05030_ _04864_ _04897_ _15268_ _05144_ VDD
+ VSS AOI221_X2
X_28184_ _05008_ _04970_ _05145_ VDD VSS NAND2_X1
X_28185_ _04986_ _05057_ _05145_ _05146_ VDD VSS AOI21_X1
X_28186_ _05040_ _05096_ _05147_ VDD VSS NOR2_X1
X_28187_ net85 _05018_ _05148_ VDD VSS NOR2_X1
X_28188_ _05146_ _05147_ _05148_ _05149_ VDD VSS AOI21_X1
X_28189_ _05144_ _05149_ _05038_ _05150_ VDD VSS MUX2_X1
X_28190_ _15284_ _05068_ _05151_ VDD VSS NOR2_X1
X_28191_ _04982_ _05144_ _05151_ _05152_ VDD VSS NOR3_X1
X_28192_ _04980_ _05152_ _05153_ VDD VSS NOR2_X1
X_28193_ _04940_ _04946_ _04963_ _04964_ _05154_ VDD VSS AOI211_X2
X_28194_ _04900_ _05154_ _04956_ _05155_ VDD VSS OAI21_X1
X_28195_ _05155_ _05137_ _05156_ VDD VSS AND2_X1
X_28196_ _05143_ _05150_ _05153_ _05114_ _05156_ _05157_ VDD
+ VSS OAI221_X2
X_28197_ _04977_ _05067_ _05096_ _05158_ VDD VSS NAND3_X1
X_28198_ _04920_ _04909_ _05158_ _05159_ VDD VSS NAND3_X1
X_28199_ _04977_ _05067_ _05160_ VDD VSS NAND2_X2
X_28200_ net1157 _04930_ _05161_ VDD VSS NOR2_X1
X_28201_ net1028 _05160_ _05161_ _05018_ _05162_ VDD VSS OAI22_X1
X_28202_ _05159_ _05162_ _05105_ _05163_ VDD VSS AOI21_X1
X_28203_ _04897_ _04977_ _05164_ VDD VSS NAND2_X2
X_28204_ _04981_ _04966_ _05164_ _05067_ _05165_ VDD VSS OAI22_X2
X_28205_ _04899_ _04977_ _05083_ _04881_ _05166_ VDD VSS OAI22_X1
X_28206_ _15258_ _05165_ _05166_ _05039_ _05167_ VDD VSS AOI22_X2
X_28207_ _05044_ _05083_ _05168_ VDD VSS AND2_X1
X_28208_ _04981_ _05011_ _04935_ _05168_ net85 _05169_ VDD
+ VSS OAI221_X1
X_28209_ _04899_ _05043_ _05115_ _05170_ VDD VSS NAND3_X4
X_28210_ net141 _05040_ _05171_ VDD VSS NAND2_X1
X_28211_ _05170_ _05171_ _04986_ net87 _04947_ _05172_ VDD
+ VSS OAI221_X2
X_28212_ _05169_ _05172_ _05038_ _05173_ VDD VSS OAI21_X2
X_28213_ _04980_ _05143_ _05174_ VDD VSS NOR2_X1
X_28214_ _05005_ _05163_ _05167_ _05173_ _05174_ _05175_ VDD
+ VSS AOI221_X2
X_28215_ _05121_ _05141_ _05131_ _05157_ _05175_ _00145_ VDD
+ VSS AOI221_X2
X_28216_ _05101_ _05056_ _05176_ VDD VSS NOR2_X1
X_28217_ _15274_ _04940_ _04946_ _05177_ VDD VSS NOR3_X4
X_28218_ _15283_ _05148_ net800 _05178_ VDD VSS OAI21_X1
X_28219_ _15276_ _05132_ _05059_ _05179_ VDD VSS NAND3_X1
X_28220_ _05176_ _05178_ _05179_ _05180_ VDD VSS AND3_X1
X_28221_ _04935_ _05105_ _05181_ VDD VSS OR2_X1
X_28222_ _05111_ _05181_ _05182_ VDD VSS NAND2_X1
X_28223_ _15270_ _05041_ _05042_ _05183_ VDD VSS NAND3_X1
X_28224_ _04987_ _15259_ VDD VSS BUF_X16
X_28225_ _05183_ _05079_ net86 _05184_ VDD VSS OAI21_X1
X_28226_ _15283_ _05184_ _05185_ VDD VSS NOR2_X1
X_28227_ _04916_ _05182_ _05185_ _05186_ VDD VSS OAI21_X1
X_28228_ _05101_ _05038_ _05187_ VDD VSS NOR2_X2
X_28229_ _15283_ net1067 _05183_ _05188_ VDD VSS NAND3_X1
X_28230_ _15276_ _05132_ _05115_ _05189_ VDD VSS NAND3_X1
X_28231_ _05187_ _05188_ _05189_ _05190_ VDD VSS NAND3_X1
X_28232_ _04881_ _04952_ _04955_ _05191_ VDD VSS AOI21_X4
X_28233_ net170 _04958_ _04959_ _05192_ VDD VSS NOR3_X1
X_28234_ _05061_ _05191_ _05192_ _05193_ VDD VSS NOR3_X1
X_28235_ _15276_ net796 net799 _05194_ VDD VSS NOR3_X1
X_28236_ _05130_ _05194_ _05193_ _05195_ VDD VSS OAI21_X1
X_28237_ _05195_ _05190_ _05196_ VDD VSS NAND2_X1
X_28238_ _05196_ _05186_ _05180_ _05197_ VDD VSS NOR3_X2
X_28239_ _05142_ _04915_ _05198_ VDD VSS NAND2_X2
X_28240_ _04897_ _04985_ _05199_ VDD VSS NOR2_X2
X_28241_ net1034 _04952_ _04955_ _05200_ VDD VSS NAND3_X2
X_28242_ _05049_ _05200_ _05201_ VDD VSS NAND2_X1
X_28243_ _04956_ _05199_ _04935_ _05201_ _04971_ _05202_ VDD
+ VSS AOI221_X1
X_28244_ _05079_ _05171_ _05181_ _05203_ VDD VSS AOI21_X2
X_28245_ _05087_ _05029_ _05204_ VDD VSS NAND2_X1
X_28246_ _05065_ _05087_ _05202_ _05203_ _05204_ _05205_ VDD
+ VSS OAI221_X1
X_28247_ _05061_ _05049_ _05078_ _05206_ VDD VSS AOI21_X1
X_28248_ net171 _05041_ _05042_ _05207_ VDD VSS AOI21_X1
X_28249_ _05051_ _05154_ _05207_ _05208_ VDD VSS NOR3_X1
X_28250_ _04978_ _05206_ _05208_ _05209_ VDD VSS NOR3_X1
X_28251_ net87 _15283_ _05079_ _04960_ _04996_ _05191_ _05210_
+ VDD VSS OAI33_X1
X_28252_ _05209_ _05210_ _05187_ _05211_ VDD VSS AOI21_X1
X_28253_ _05198_ _05205_ _05211_ _05212_ VDD VSS AOI21_X1
X_28254_ _15259_ _04932_ _05096_ _05213_ VDD VSS NOR3_X1
X_28255_ _15279_ _04991_ _05214_ VDD VSS AND2_X1
X_28256_ _15288_ _05215_ VDD VSS INV_X1
X_28257_ _05215_ _04986_ _04931_ _05216_ VDD VSS MUX2_X1
X_28258_ _04897_ _04925_ _04928_ _05217_ VDD VSS OAI21_X4
X_28259_ _04881_ _05017_ _05217_ _04964_ _04963_ _05218_ VDD
+ VSS AOI221_X2
X_28260_ net945 _04947_ _05219_ VDD VSS NOR2_X1
X_28261_ _05079_ _05213_ _05214_ _05216_ _05218_ _05219_ _05220_
+ VDD VSS OAI33_X1
X_28262_ _05065_ _05220_ _05221_ VDD VSS AND2_X1
X_28263_ _15265_ _15262_ _05222_ VDD VSS NOR2_X4
X_28264_ _04903_ _05067_ _05222_ _05223_ VDD VSS OAI21_X1
X_28265_ _05071_ _05041_ _05042_ _05224_ VDD VSS NAND3_X1
X_28266_ _04970_ _05224_ _05225_ VDD VSS NAND2_X1
X_28267_ _05076_ _05223_ _05225_ _05108_ _05226_ VDD VSS OAI22_X1
X_28268_ _04905_ net1067 _05116_ _05227_ VDD VSS NAND3_X1
X_28269_ _04903_ _05017_ _05228_ VDD VSS NOR2_X2
X_28270_ _04981_ _05228_ net1028 _05229_ VDD VSS AOI21_X1
X_28271_ _05101_ _05038_ _05226_ _05227_ _05229_ _05230_ VDD
+ VSS AOI221_X2
X_28272_ _15268_ _04958_ _04959_ _05231_ VDD VSS OAI21_X2
X_28273_ _04905_ _04966_ _05231_ _05232_ VDD VSS NAND3_X1
X_28274_ _05106_ _04971_ _05116_ _05233_ VDD VSS NAND3_X2
X_28275_ _05101_ _05232_ _05233_ _05234_ VDD VSS AND3_X4
X_28276_ net945 _05068_ _05040_ _05235_ VDD VSS NOR3_X1
X_28277_ _05039_ _04899_ _05191_ _05236_ VDD VSS NOR3_X1
X_28278_ _04973_ _04966_ _04996_ _05237_ VDD VSS AOI21_X1
X_28279_ _05237_ _05235_ _05236_ _05101_ _05238_ VDD VSS NOR4_X2
X_28280_ _05087_ _05234_ _05238_ _05239_ VDD VSS NOR3_X1
X_28281_ _05028_ _04959_ _04958_ _05039_ _04881_ _05240_ VDD
+ VSS OAI221_X1
X_28282_ _15284_ _05241_ VDD VSS INV_X1
X_28283_ _04920_ _05018_ _05241_ _05242_ VDD VSS AOI21_X1
X_28284_ net586 net1166 _05243_ VDD VSS NOR2_X4
X_28285_ _05018_ _05243_ _05244_ VDD VSS NOR2_X1
X_28286_ _15281_ _05068_ _05244_ _05171_ _05245_ VDD VSS AOI22_X1
X_28287_ _05038_ _05240_ _05242_ _05245_ _04921_ _05246_ VDD
+ VSS AOI221_X1
X_28288_ _05037_ _05221_ _05230_ _05246_ _05006_ _05239_ _05247_
+ VDD VSS OAI33_X1
X_28289_ _05247_ _05212_ _05197_ _00146_ VDD VSS NOR3_X2
X_28290_ net1166 _04977_ _05248_ VDD VSS NAND2_X1
X_28291_ net967 _05092_ _05217_ _05249_ VDD VSS MUX2_X1
X_28292_ _05248_ _05249_ _05250_ VDD VSS NAND2_X1
X_28293_ net84 _05096_ _05251_ VDD VSS NOR2_X1
X_28294_ _04864_ _05017_ _04993_ _05252_ VDD VSS AOI21_X1
X_28295_ _04931_ _05251_ _05252_ _05253_ VDD VSS OAI21_X1
X_28296_ _04987_ _05010_ _05254_ VDD VSS NOR2_X1
X_28297_ _04930_ _05030_ _05254_ _05255_ VDD VSS OR3_X1
X_28298_ _04920_ _04997_ _05250_ _05253_ _05255_ _05256_ VDD
+ VSS AOI221_X2
X_28299_ _04899_ _05132_ _05106_ _05257_ VDD VSS NAND3_X1
X_28300_ _05224_ _05018_ _05008_ _05258_ VDD VSS OAI21_X1
X_28301_ _05257_ _05258_ _04983_ _05259_ VDD VSS OAI21_X1
X_28302_ _05078_ _05067_ net1033 _05260_ VDD VSS OAI21_X1
X_28303_ _04966_ _05067_ _15265_ _05261_ VDD VSS OAI21_X1
X_28304_ _05260_ _05261_ _04970_ _05262_ VDD VSS MUX2_X1
X_28305_ _05259_ _05262_ _04932_ _05263_ VDD VSS MUX2_X1
X_28306_ _05037_ _05256_ _05263_ _05075_ _05264_ VDD VSS AOI211_X2
X_28307_ net586 _05044_ _05265_ VDD VSS NOR2_X1
X_28308_ _04930_ _04881_ _04864_ _05266_ VDD VSS OAI21_X1
X_28309_ _04920_ _05265_ _05266_ _04975_ _04865_ _05267_ VDD
+ VSS AOI221_X2
X_28310_ _04991_ _05192_ _05268_ VDD VSS NOR2_X1
X_28311_ _04940_ _05092_ _04946_ _05269_ VDD VSS NOR3_X4
X_28312_ _05269_ _04956_ _05270_ VDD VSS NOR2_X2
X_28313_ _05268_ _04983_ _05270_ net87 _05083_ _05271_ VDD
+ VSS OAI221_X2
X_28314_ _05039_ _04960_ _05272_ VDD VSS NOR2_X1
X_28315_ _04992_ _05096_ _05272_ _05273_ VDD VSS OAI21_X1
X_28316_ _05267_ _05273_ _05271_ _05274_ VDD VSS AND3_X2
X_28317_ _05071_ _04947_ _05011_ _04973_ _05275_ VDD VSS OAI22_X1
X_28318_ net1158 _04958_ _04959_ _05276_ VDD VSS OAI21_X2
X_28319_ _04998_ _04993_ _05276_ _05105_ _05277_ VDD VSS OAI22_X1
X_28320_ _05275_ _05277_ net1029 _05278_ VDD VSS AOI21_X1
X_28321_ _04933_ _05278_ _05279_ VDD VSS NOR2_X1
X_28322_ _05105_ _05049_ _05224_ _05280_ VDD VSS AOI21_X1
X_28323_ net945 _05276_ _05281_ VDD VSS NOR2_X1
X_28324_ _04978_ _05265_ _05280_ _05281_ _05282_ VDD VSS NOR4_X1
X_28325_ _05274_ _05006_ _05279_ _05282_ _05283_ VDD VSS NOR4_X1
X_28326_ _15268_ _04970_ _05284_ VDD VSS NAND2_X1
X_28327_ _05064_ _05068_ _05028_ _05284_ _05285_ VDD VSS NAND4_X1
X_28328_ _04991_ _04975_ net171 _05286_ VDD VSS AOI21_X1
X_28329_ _05285_ _05286_ _05287_ VDD VSS NAND2_X1
X_28330_ _04983_ _05064_ _04986_ _05288_ VDD VSS NAND3_X1
X_28331_ _05105_ _04921_ _05068_ _05289_ VDD VSS NAND3_X1
X_28332_ _04973_ _05288_ _05289_ _05290_ VDD VSS AOI21_X1
X_28333_ _05127_ _04993_ _05084_ _05023_ _05291_ VDD VSS OAI22_X1
X_28334_ _05088_ _05287_ _05290_ _05291_ _04933_ _05292_ VDD
+ VSS OAI221_X1
X_28335_ _05019_ _05222_ _05051_ _05293_ VDD VSS AOI21_X1
X_28336_ net1033 _05294_ VDD VSS INV_X1
X_28337_ _05294_ _04897_ _05295_ VDD VSS NAND2_X1
X_28338_ _04982_ _05293_ _05295_ _05296_ VDD VSS AOI21_X1
X_28339_ _04973_ _15267_ _04971_ _05297_ VDD VSS MUX2_X1
X_28340_ _04980_ _05079_ _05297_ _05298_ VDD VSS AOI21_X1
X_28341_ _05292_ _05296_ _05298_ _05299_ VDD VSS AOI21_X1
X_28342_ _05143_ _05005_ _05300_ VDD VSS NAND2_X1
X_28343_ net1158 net1024 _04965_ _05301_ VDD VSS AOI21_X1
X_28344_ _04977_ _05046_ _05254_ _05301_ _05302_ VDD VSS OR4_X1
X_28345_ _04901_ _05041_ _05042_ _05303_ VDD VSS AOI21_X2
X_28346_ net1166 _05177_ _05304_ VDD VSS OR2_X1
X_28347_ _05023_ _04952_ _04955_ _05305_ VDD VSS AOI21_X4
X_28348_ _05305_ _05269_ _05306_ VDD VSS NOR2_X1
X_28349_ _04981_ _05303_ _05304_ _05306_ _04899_ _05307_ VDD
+ VSS OAI221_X1
X_28350_ _05064_ _05302_ _05307_ _05308_ VDD VSS AOI21_X1
X_28351_ _05294_ _04904_ _05309_ VDD VSS NOR2_X1
X_28352_ net603 net1023 _05310_ VDD VSS NOR2_X1
X_28353_ _05310_ _04955_ _04952_ net1166 _05222_ _05311_ VDD
+ VSS AOI221_X1
X_28354_ _05030_ _05160_ _05309_ _05311_ _05144_ _04981_ _05312_
+ VDD VSS OAI33_X1
X_28355_ _05300_ _05308_ _05312_ _05101_ _05313_ VDD VSS AOI211_X2
X_28356_ _05283_ _05264_ _05299_ _05313_ _00147_ VDD VSS OR4_X2
X_28357_ _15267_ _05044_ net799 _05051_ _05314_ VDD VSS OAI22_X1
X_28358_ _05004_ _05111_ _05314_ _05315_ VDD VSS AOI21_X1
X_28359_ _05008_ _15276_ _05316_ VDD VSS NAND2_X1
X_28360_ _05155_ _05316_ _05127_ _04947_ net1028 _05317_ VDD
+ VSS OAI221_X1
X_28361_ _05315_ _05317_ _05114_ _05318_ VDD VSS OAI21_X1
X_28362_ _04935_ _04905_ _05319_ VDD VSS AND2_X1
X_28363_ _05079_ _05319_ _05243_ _05320_ VDD VSS OAI21_X1
X_28364_ _05087_ _04994_ _05320_ _05321_ VDD VSS NAND3_X1
X_28365_ _05051_ _05056_ _05322_ VDD VSS NOR2_X1
X_28366_ _05322_ _05125_ _05014_ _05323_ VDD VSS OAI21_X1
X_28367_ _05075_ _05321_ _05323_ _05324_ VDD VSS AND3_X1
X_28368_ _05005_ _05318_ _05324_ _05325_ VDD VSS OAI21_X1
X_28369_ _04971_ _05116_ _05326_ VDD VSS NAND2_X1
X_28370_ _05056_ _05148_ _05326_ _05061_ _15258_ _05327_ VDD
+ VSS OAI221_X1
X_28371_ _05059_ _05014_ _04983_ _05328_ VDD VSS OAI21_X1
X_28372_ _04992_ _05328_ _05329_ VDD VSS NOR2_X1
X_28373_ _05101_ _05329_ _05330_ VDD VSS NOR2_X1
X_28374_ _04932_ _05191_ _05331_ VDD VSS NAND2_X1
X_28375_ net1029 _05248_ _05331_ _05332_ VDD VSS AOI21_X1
X_28376_ net141 _04931_ _05333_ VDD VSS NAND2_X1
X_28377_ _05127_ _05164_ _05009_ _05333_ _04900_ _05334_ VDD
+ VSS OAI221_X1
X_28378_ net84 _15258_ _05217_ _05335_ VDD VSS AOI21_X1
X_28379_ _04998_ _05030_ _05335_ _05336_ VDD VSS OR3_X1
X_28380_ _05332_ _05334_ _05336_ _05337_ VDD VSS AOI21_X1
X_28381_ _05143_ _05327_ _05330_ _05337_ _05065_ _05338_ VDD
+ VSS AOI221_X1
X_28382_ _05170_ _04900_ net170 _05339_ VDD VSS OAI21_X1
X_28383_ _05004_ _05339_ _04978_ _05340_ VDD VSS OAI21_X1
X_28384_ _05047_ _04996_ _05019_ _05341_ VDD VSS OAI21_X1
X_28385_ _04956_ net798 _05342_ VDD VSS NOR2_X1
X_28386_ _04900_ _05342_ _05343_ VDD VSS NAND2_X1
X_28387_ _04864_ net1158 _05344_ VDD VSS NAND2_X1
X_28388_ _04931_ _04975_ _05344_ _05199_ net942 _05345_ VDD
+ VSS AOI221_X2
X_28389_ _04980_ _05343_ _05345_ _05346_ VDD VSS AOI21_X1
X_28390_ _04933_ _05058_ _05127_ _05347_ VDD VSS AOI21_X1
X_28391_ _05051_ _05305_ _05269_ _05348_ VDD VSS NOR3_X1
X_28392_ _05348_ net798 _15276_ _05349_ VDD VSS AOI21_X1
X_28393_ _05340_ _05341_ _05346_ _05347_ _05349_ _05350_ VDD
+ VSS AOI221_X2
X_28394_ _15272_ _05351_ VDD VSS INV_X1
X_28395_ _05351_ _05027_ _04997_ _05352_ VDD VSS MUX2_X1
X_28396_ net85 _04975_ _05059_ _04971_ _05353_ VDD VSS AOI22_X1
X_28397_ _04881_ _04940_ _04946_ _05354_ VDD VSS NOR3_X4
X_28398_ _04932_ _05354_ net1029 _05355_ VDD VSS AOI21_X1
X_28399_ _05101_ _05352_ _04992_ _05353_ _05355_ _05356_ VDD
+ VSS AOI221_X2
X_28400_ _05061_ _04966_ _05276_ _05357_ VDD VSS AOI21_X1
X_28401_ net86 _05132_ _05083_ _05023_ _05358_ VDD VSS OAI22_X1
X_28402_ _04900_ _05048_ _05049_ _05359_ VDD VSS AOI21_X1
X_28403_ _05008_ _05011_ _05276_ net1029 _05360_ VDD VSS OAI22_X1
X_28404_ _05064_ _04992_ _05361_ VDD VSS NAND2_X1
X_28405_ _05114_ _05357_ _05358_ _05359_ _05360_ _05361_ _05362_
+ VDD VSS OAI33_X1
X_28406_ _05143_ _05362_ _05356_ _05363_ VDD VSS OAI21_X1
X_28407_ _05363_ _04915_ _05364_ VDD VSS NAND2_X1
X_28408_ _05325_ _05338_ _05364_ _05350_ _00148_ VDD VSS OAI22_X1
X_28409_ _05051_ _04966_ net1067 _05365_ VDD VSS NAND3_X1
X_28410_ _04971_ _04998_ _15270_ _05276_ net945 _05366_ VDD
+ VSS OAI221_X1
X_28411_ _04982_ _05365_ _05366_ _05367_ VDD VSS NAND3_X1
X_28412_ _15267_ _05154_ _04993_ _04998_ _05368_ VDD VSS OAI22_X1
X_28413_ _05056_ _05368_ _05369_ VDD VSS NAND2_X1
X_28414_ _05004_ _05367_ _05369_ _05370_ VDD VSS AOI21_X1
X_28415_ _05018_ _05058_ _05310_ _05371_ VDD VSS OAI21_X1
X_28416_ net940 _04903_ _05372_ VDD VSS NAND2_X1
X_28417_ _04931_ _05013_ _05372_ _05373_ VDD VSS AOI21_X2
X_28418_ _04970_ _04966_ _04968_ _05374_ VDD VSS NAND3_X1
X_28419_ _05015_ _05374_ _05375_ VDD VSS AND2_X4
X_28420_ _05143_ _05373_ _05371_ _05375_ _04932_ _05376_ VDD
+ VSS AOI221_X2
X_28421_ _05376_ _04915_ _05370_ _05065_ _05377_ VDD VSS NOR4_X2
X_28422_ _05064_ _04909_ _05378_ VDD VSS NAND2_X1
X_28423_ _05043_ _05281_ _04904_ _05379_ VDD VSS OAI21_X1
X_28424_ _05038_ _05379_ _05380_ VDD VSS NAND2_X1
X_28425_ _04881_ _05228_ _05306_ _04903_ _05381_ VDD VSS AOI22_X1
X_28426_ _04915_ _05381_ _04991_ _05382_ VDD VSS AOI21_X1
X_28427_ _04903_ _05048_ _05115_ _05383_ VDD VSS AOI21_X1
X_28428_ _05383_ _05199_ net84 _05384_ VDD VSS AOI21_X1
X_28429_ _04973_ _04947_ _05385_ VDD VSS NOR2_X1
X_28430_ _05200_ _05067_ _15260_ _05386_ VDD VSS OAI21_X1
X_28431_ _05385_ _05386_ _04899_ _05387_ VDD VSS AOI21_X1
X_28432_ _05384_ _05387_ _04991_ _05388_ VDD VSS MUX2_X1
X_28433_ _05378_ _05380_ _05382_ _05388_ _04915_ _05389_ VDD
+ VSS AOI221_X2
X_28434_ _05078_ net1166 net1165 _05390_ VDD VSS AND3_X4
X_28435_ _05177_ _04985_ _15268_ _05391_ VDD VSS AOI21_X1
X_28436_ _05390_ _05391_ _04970_ _05392_ VDD VSS AOI21_X4
X_28437_ _05392_ _04991_ _05393_ VDD VSS OR2_X2
X_28438_ net141 _05017_ _05030_ _05394_ VDD VSS NAND3_X1
X_28439_ _04931_ _05231_ _05394_ _05395_ VDD VSS NAND3_X1
X_28440_ _05064_ _05395_ _05396_ VDD VSS AND2_X1
X_28441_ _04977_ _05154_ _05147_ _05222_ _04974_ _05397_ VDD
+ VSS AOI221_X2
X_28442_ _05020_ _05295_ _04997_ _05398_ VDD VSS MUX2_X1
X_28443_ _05397_ _05038_ _05398_ _05399_ VDD VSS AOI21_X2
X_28444_ _05198_ _05393_ _05396_ _04980_ _05399_ _05400_ VDD
+ VSS AOI221_X2
X_28445_ _05143_ _05005_ _05401_ VDD VSS NOR2_X1
X_28446_ _15267_ _05044_ _05083_ _05071_ _05402_ VDD VSS OAI22_X1
X_28447_ _04982_ _05402_ _05403_ VDD VSS NAND2_X1
X_28448_ _05075_ _05401_ _05403_ _05404_ VDD VSS NAND3_X1
X_28449_ _05038_ _05154_ _04915_ _05405_ VDD VSS AND3_X1
X_28450_ _04986_ _04914_ _04991_ _05406_ VDD VSS AOI21_X1
X_28451_ _04899_ _04991_ _04914_ _05407_ VDD VSS AOI21_X1
X_28452_ net1029 _05406_ _05407_ _05068_ _05408_ VDD VSS OAI22_X1
X_28453_ _04981_ _04915_ _05284_ _05409_ VDD VSS NAND3_X1
X_28454_ _05199_ _05409_ _04998_ _05410_ VDD VSS AOI21_X1
X_28455_ _15258_ _05405_ _05408_ _05410_ net528 net1075 _05411_
+ VDD VSS OAI33_X1
X_28456_ _05019_ _05030_ _05020_ _05412_ VDD VSS OAI21_X1
X_28457_ _04992_ _04994_ _05412_ _05413_ VDD VSS NAND3_X1
X_28458_ _05076_ _05391_ _04971_ _05414_ VDD VSS MUX2_X1
X_28459_ _05413_ _05056_ _05414_ _05415_ VDD VSS OAI21_X1
X_28460_ _05065_ _04916_ _05416_ VDD VSS NAND2_X1
X_28461_ _05404_ _05411_ _05415_ _05416_ _05417_ VDD VSS OAI22_X1
X_28462_ _05400_ _05389_ _05417_ _05377_ _00149_ VDD VSS OR4_X2
X_28463_ _05143_ _05203_ _05075_ net1163 net1160 _05418_ VDD
+ VSS OAI221_X2
X_28464_ _05065_ _05127_ _15278_ _05419_ VDD VSS AOI21_X1
X_28465_ net170 _15283_ _05420_ VDD VSS NAND2_X1
X_28466_ _05079_ _05028_ _05420_ _05421_ VDD VSS NAND3_X1
X_28467_ _05418_ _05419_ _05421_ _05422_ VDD VSS AOI21_X1
X_28468_ _05023_ net142 _05018_ _05423_ VDD VSS MUX2_X1
X_28469_ net86 _04975_ _05423_ _04900_ _05424_ VDD VSS AOI22_X1
X_28470_ _05004_ _05114_ _05424_ _05425_ VDD VSS NOR3_X1
X_28471_ _04905_ _04968_ _05132_ _05426_ VDD VSS AOI21_X1
X_28472_ _04978_ _05004_ _05385_ _05426_ _05427_ VDD VSS NOR4_X1
X_28473_ _05005_ _05425_ _05427_ _05428_ VDD VSS OR3_X1
X_28474_ _05105_ _05344_ _05429_ VDD VSS NOR2_X1
X_28475_ _05018_ _04899_ _04973_ _05430_ VDD VSS OAI21_X1
X_28476_ _04921_ _05429_ _05430_ _05019_ _15279_ _05431_ VDD
+ VSS OAI221_X2
X_28477_ _05067_ _04993_ net141 _05432_ VDD VSS AOI21_X1
X_28478_ _04921_ _05082_ _05432_ _05433_ VDD VSS NOR3_X1
X_28479_ _04992_ _05433_ _05434_ VDD VSS NOR2_X1
X_28480_ _04983_ _04956_ _05269_ _05435_ VDD VSS NOR3_X1
X_28481_ net1166 _05017_ _05000_ _05191_ net141 _05436_ VDD
+ VSS AOI221_X2
X_28482_ _05101_ _05435_ _05436_ _05437_ VDD VSS NOR3_X1
X_28483_ _04897_ _05017_ _05222_ _05191_ _04864_ _05438_ VDD
+ VSS AOI221_X1
X_28484_ _04904_ _05303_ _05269_ _05439_ VDD VSS NOR3_X1
X_28485_ _04921_ _05438_ _05439_ _05440_ VDD VSS NOR3_X1
X_28486_ _05440_ _05437_ _05441_ VDD VSS NOR2_X1
X_28487_ _05143_ _05431_ _05434_ _05441_ _05056_ _05442_ VDD
+ VSS AOI221_X2
X_28488_ _05059_ _04997_ _05008_ _05443_ VDD VSS OAI21_X1
X_28489_ _04904_ _05443_ _05444_ VDD VSS NAND2_X1
X_28490_ _05063_ _05228_ net171 _05445_ VDD VSS AOI21_X1
X_28491_ _05305_ _05354_ _05446_ VDD VSS NOR2_X1
X_28492_ _04972_ _05222_ _04985_ _05447_ VDD VSS MUX2_X1
X_28493_ _05446_ _05447_ _04970_ _05448_ VDD VSS MUX2_X1
X_28494_ _04932_ _05444_ _05445_ _05448_ _05064_ _05449_ VDD
+ VSS AOI221_X2
X_28495_ _04986_ _15258_ _04987_ _05450_ VDD VSS OAI21_X1
X_28496_ _04900_ _05450_ _05183_ _05451_ VDD VSS AND3_X1
X_28497_ _04905_ _05200_ _05452_ VDD VSS NAND2_X1
X_28498_ _05069_ _05452_ _05453_ VDD VSS NOR2_X1
X_28499_ _05361_ _05451_ _05453_ _05454_ VDD VSS NOR3_X1
X_28500_ _05450_ _05051_ net86 _05455_ VDD VSS AOI21_X2
X_28501_ _15277_ _15286_ _04998_ _05456_ VDD VSS NOR3_X1
X_28502_ _04933_ _05455_ _05456_ _05457_ VDD VSS NOR3_X1
X_28503_ _05449_ _05143_ _05454_ _05457_ _05458_ VDD VSS NOR4_X2
X_28504_ _04904_ _04931_ _04997_ _05459_ VDD VSS NAND3_X1
X_28505_ _15267_ _05164_ _05459_ _05460_ VDD VSS NAND3_X1
X_28506_ _05294_ net84 _05461_ VDD VSS NAND2_X1
X_28507_ _05333_ _05461_ _05248_ _05462_ VDD VSS OAI21_X1
X_28508_ _05460_ _05462_ _15267_ _05463_ VDD VSS OAI21_X1
X_28509_ _04864_ _04930_ _05464_ VDD VSS NOR2_X1
X_28510_ _05028_ _04930_ net1158 _05465_ VDD VSS OAI21_X1
X_28511_ _04930_ net797 _05466_ VDD VSS OR2_X1
X_28512_ _05063_ _05191_ _05464_ _05465_ _05466_ _05467_ VDD
+ VSS AOI221_X2
X_28513_ _04931_ _05059_ _05078_ _05468_ VDD VSS NAND3_X1
X_28514_ _05105_ _05160_ _05468_ _05469_ VDD VSS NAND3_X1
X_28515_ _05464_ _05191_ _04991_ _05470_ VDD VSS AOI21_X1
X_28516_ _05469_ _05470_ _04905_ _15258_ _05160_ _05471_ VDD
+ VSS OAI221_X2
X_28517_ _05004_ _05463_ _05467_ _05471_ _05065_ _05472_ VDD
+ VSS AOI221_X2
X_28518_ _05422_ _05428_ _05442_ _05458_ _05472_ _04915_ _00150_
+ VDD VSS OAI33_X1
X_28519_ _05056_ _04975_ _05008_ _05473_ VDD VSS AOI21_X1
X_28520_ _05354_ _05303_ _05061_ _05474_ VDD VSS AOI21_X1
X_28521_ _05473_ _05474_ net86 _15267_ _05011_ _05475_ VDD
+ VSS OAI221_X1
X_28522_ _05087_ _05083_ net170 _05342_ _15283_ _05476_ VDD
+ VSS OAI221_X2
X_28523_ _05075_ _05475_ _05476_ _05477_ VDD VSS NAND3_X1
X_28524_ _15276_ _05049_ _05200_ _05478_ VDD VSS NAND3_X1
X_28525_ _05478_ _05184_ _15276_ _05479_ VDD VSS OAI21_X1
X_28526_ _05027_ _05061_ _05294_ _05480_ VDD VSS OAI21_X1
X_28527_ _05087_ _05127_ _05480_ _05481_ VDD VSS AOI21_X1
X_28528_ _05111_ _05479_ _05481_ _05298_ _05482_ VDD VSS AOI22_X1
X_28529_ _04916_ _05477_ _05482_ _05483_ VDD VSS NAND3_X1
X_28530_ _04966_ _04947_ _05222_ _05484_ VDD VSS OAI21_X1
X_28531_ _05305_ _05354_ _05485_ VDD VSS OR2_X1
X_28532_ _05484_ _05485_ _15283_ _05486_ VDD VSS AOI21_X1
X_28533_ _15276_ _05102_ _05231_ _05487_ VDD VSS AOI21_X1
X_28534_ _04982_ _05117_ _05488_ VDD VSS OR2_X1
X_28535_ _05075_ _05087_ _05486_ _05487_ _05488_ _05489_ VDD
+ VSS OAI221_X1
X_28536_ _05008_ _05061_ _05490_ VDD VSS NOR2_X1
X_28537_ _05014_ _05127_ _15264_ _05491_ VDD VSS AOI21_X1
X_28538_ _05490_ _05491_ _15283_ _05492_ VDD VSS AOI21_X1
X_28539_ _04982_ _05127_ net1028 _05493_ VDD VSS OAI21_X1
X_28540_ _05065_ _04982_ _05492_ _05493_ _05455_ _05494_ VDD
+ VSS OAI221_X2
X_28541_ _05004_ _05005_ _05489_ _05494_ _05495_ VDD VSS NAND4_X1
X_28542_ _04932_ _05068_ _05057_ _05496_ VDD VSS NOR3_X1
X_28543_ _05011_ _05019_ _05038_ _05497_ VDD VSS OAI21_X1
X_28544_ _05496_ _05497_ _15267_ _05498_ VDD VSS AOI21_X1
X_28545_ _05217_ _05498_ net86 _05044_ net1157 _05499_ VDD
+ VSS OAI221_X1
X_28546_ _05075_ _05198_ _05499_ _05500_ VDD VSS OR3_X1
X_28547_ _15264_ _05354_ _05501_ VDD VSS AND2_X1
X_28548_ net1029 _05011_ _05049_ _05502_ VDD VSS AOI21_X1
X_28549_ _05087_ _05501_ _05502_ _05503_ VDD VSS OAI21_X1
X_28550_ _04960_ _04975_ _15258_ _05504_ VDD VSS AOI21_X1
X_28551_ _05228_ _05030_ _05079_ _05505_ VDD VSS AOI21_X1
X_28552_ _05503_ _05504_ _05087_ net86 _05505_ _05506_ VDD
+ VSS OAI221_X2
X_28553_ _05065_ _05198_ _05507_ VDD VSS NOR2_X1
X_28554_ _05105_ _04935_ _05041_ _05042_ _05508_ VDD VSS AOI22_X4
X_28555_ _05154_ _04993_ _05508_ _04996_ _05509_ VDD VSS AOI22_X4
X_28556_ net171 _04971_ _05041_ _05042_ _05510_ VDD VSS NAND4_X1
X_28557_ _05510_ _05019_ _15272_ _05511_ VDD VSS OAI21_X1
X_28558_ _05509_ _05176_ _05511_ _05187_ _05512_ VDD VSS AOI22_X4
X_28559_ _05243_ _05024_ _04998_ _05513_ VDD VSS NOR3_X1
X_28560_ _15286_ _05019_ _05514_ VDD VSS NOR2_X1
X_28561_ _05513_ _05514_ _05515_ VDD VSS OR2_X2
X_28562_ _05106_ _05127_ net86 _05516_ VDD VSS OAI21_X1
X_28563_ _05133_ _05516_ _15276_ _05517_ VDD VSS AOI21_X1
X_28564_ _05512_ _05515_ _05361_ _05114_ _05517_ _05518_ VDD
+ VSS OAI221_X2
X_28565_ _05506_ _05507_ _05518_ _05401_ _05519_ VDD VSS AOI22_X2
X_28566_ _05519_ _05495_ _05500_ _05483_ _00151_ VDD VSS NAND4_X4
X_28567_ net1064 _05520_ VDD VSS INV_X1
X_28568_ _05520_ _09102_ _05521_ VDD VSS NOR2_X1
X_28569_ net1064 _11841_ _05522_ VDD VSS NOR2_X1
X_28570_ _11184_ _11119_ _05523_ VDD VSS XNOR2_X2
X_28571_ _11122_ _05523_ _05524_ VDD VSS XNOR2_X2
X_28572_ _13842_ _11166_ _05525_ VDD VSS XNOR2_X2
X_28573_ _05525_ _05524_ _05526_ VDD VSS XNOR2_X2
X_28574_ _05521_ _05522_ _05526_ _05527_ VDD VSS MUX2_X2
X_28575_ net1064 _09074_ _00405_ _05528_ VDD VSS OR3_X2
X_28576_ net1064 _11938_ _00405_ _05529_ VDD VSS NAND3_X2
X_28577_ _05528_ _05529_ _05530_ VDD VSS NAND2_X4
X_28578_ _05530_ _05527_ _05531_ VDD VSS NOR2_X4
X_28579_ net869 _05532_ VDD VSS INV_X16
Xclone596 net869 net1061 VDD VSS INV_X4
Xrebuffer492 _15306_ net1115 VDD VSS BUF_X2
X_28582_ _05532_ _15296_ VDD VSS BUF_X32
X_28583_ sa03_sr\[0\] net727 _05535_ VDD VSS XNOR2_X1
X_28584_ _09856_ net559 _11144_ _05536_ VDD VSS NAND3_X4
X_28585_ net558 _08973_ _05537_ VDD VSS NOR2_X1
X_28586_ _11137_ _05537_ _05538_ VDD VSS NAND2_X1
X_28587_ _05535_ _05538_ _05536_ _05539_ VDD VSS AOI21_X4
X_28588_ net543 net727 _05540_ VDD VSS XOR2_X1
X_28589_ _11144_ _05537_ _05541_ VDD VSS NAND2_X1
X_28590_ net559 _09100_ _11137_ _05542_ VDD VSS NAND3_X1
X_28591_ _05540_ _05541_ _05542_ _05543_ VDD VSS AOI21_X1
X_28592_ net558 _05544_ VDD VSS INV_X1
X_28593_ _05544_ _09102_ _00406_ _05545_ VDD VSS NAND3_X1
X_28594_ net558 _11841_ _05546_ VDD VSS NAND2_X1
X_28595_ _05545_ _05546_ _00406_ _05547_ VDD VSS OAI21_X1
X_28596_ _05543_ _05539_ _05547_ _05548_ VDD VSS OR3_X4
X_28597_ _05548_ _05549_ VDD VSS INV_X8
Xrebuffer595 _15297_ net1060 VDD VSS BUF_X2
X_28599_ _05549_ _15299_ VDD VSS BUF_X8
X_28600_ _11219_ net928 _05551_ VDD VSS XNOR2_X1
X_28601_ _06354_ _09011_ _11162_ _05552_ VDD VSS NAND3_X1
X_28602_ _06354_ _08992_ _05553_ VDD VSS NOR2_X1
X_28603_ _11160_ _05553_ _05554_ VDD VSS NAND2_X1
X_28604_ _05551_ _05552_ _05554_ _05555_ VDD VSS AOI21_X2
X_28605_ _11219_ _02927_ _05556_ VDD VSS XOR2_X1
X_28606_ _11162_ _05553_ _05557_ VDD VSS NAND2_X1
X_28607_ _06354_ _09022_ _11160_ _05558_ VDD VSS NAND3_X1
X_28608_ _05556_ _05557_ _05558_ _05559_ VDD VSS AOI21_X2
X_28609_ _06367_ _09726_ _00407_ _05560_ VDD VSS NAND3_X1
X_28610_ _06354_ _09726_ _05561_ VDD VSS NAND2_X1
X_28611_ _05560_ _05561_ _00407_ _05562_ VDD VSS OAI21_X2
X_28612_ _05555_ _05559_ _05562_ _05563_ VDD VSS NOR3_X4
X_28613_ _05563_ _05564_ VDD VSS INV_X8
X_28614_ _05564_ _05565_ VDD VSS BUF_X4
X_28615_ _05565_ _05566_ VDD VSS BUF_X4
X_28616_ _05566_ _15315_ VDD VSS BUF_X4
X_28617_ _05548_ _05567_ VDD VSS BUF_X16
X_28618_ _05567_ _15290_ VDD VSS BUF_X32
X_28619_ _05563_ _05568_ VDD VSS BUF_X4
X_28620_ _05568_ _05569_ VDD VSS BUF_X4
X_28621_ _05569_ _05570_ VDD VSS BUF_X4
X_28622_ _05570_ _15308_ VDD VSS BUF_X4
X_28623_ _11202_ _11187_ _05571_ VDD VSS XNOR2_X1
X_28624_ _11200_ _05571_ _05572_ VDD VSS XNOR2_X1
X_28625_ _11262_ _05572_ _05573_ VDD VSS XNOR2_X1
X_28626_ text_in_r\[6\] _05573_ net826 _05574_ VDD VSS MUX2_X2
X_28627_ _06430_ _05574_ _05575_ VDD VSS XNOR2_X1
X_28628_ _05575_ _05576_ VDD VSS BUF_X4
X_28629_ _11121_ _13904_ _05577_ VDD VSS XNOR2_X1
X_28630_ _11183_ _05577_ _05578_ VDD VSS XNOR2_X1
X_28631_ text_in_r\[7\] _05578_ _11207_ _05579_ VDD VSS MUX2_X2
X_28632_ u0.tmp_w\[7\] _05579_ _05580_ VDD VSS XOR2_X2
X_28633_ _05580_ _05581_ VDD VSS CLKBUF_X3
X_28634_ _05576_ _05581_ _05582_ VDD VSS OR2_X2
X_28635_ net1039 text_in_r\[4\] _05583_ VDD VSS OR2_X1
X_28636_ _11248_ _03011_ _05584_ VDD VSS XNOR2_X2
X_28637_ _06407_ _05583_ _05584_ _09824_ _05585_ VDD VSS OAI211_X4
X_28638_ _06407_ _05586_ VDD VSS INV_X1
X_28639_ _09180_ text_in_r\[4\] _05587_ VDD VSS NAND2_X1
X_28640_ _11248_ _03011_ _05588_ VDD VSS XOR2_X2
X_28641_ _05586_ _05587_ _05588_ _09824_ _05589_ VDD VSS OAI211_X4
X_28642_ _05585_ _05589_ _05590_ VDD VSS AND2_X1
X_28643_ _05590_ _05591_ VDD VSS BUF_X4
X_28644_ _05548_ _05564_ _05592_ VDD VSS NOR2_X4
X_28645_ net1061 _05592_ _05593_ VDD VSS NAND2_X1
X_28646_ text_in_r\[3\] _05594_ VDD VSS INV_X1
X_28647_ _09818_ _05594_ _05595_ VDD VSS NAND2_X1
X_28648_ _11222_ _02987_ _05596_ VDD VSS XNOR2_X2
X_28649_ _06393_ _05595_ _05596_ _08996_ _05597_ VDD VSS OAI211_X4
X_28650_ _05597_ _05598_ VDD VSS BUF_X8
X_28651_ _06393_ _05599_ VDD VSS INV_X1
X_28652_ _09818_ text_in_r\[3\] _05600_ VDD VSS NAND2_X1
X_28653_ _11222_ _02987_ _05601_ VDD VSS XOR2_X2
X_28654_ _05599_ _05600_ _05601_ _09135_ _05602_ VDD VSS OAI211_X4
X_28655_ _05602_ _05603_ VDD VSS BUF_X8
X_28656_ _05598_ _05603_ _05604_ VDD VSS NAND2_X2
X_28657_ _05549_ _05568_ _05605_ VDD VSS NOR2_X1
X_28658_ _05604_ _05605_ _05606_ VDD VSS NOR2_X2
X_28659_ _05591_ _05593_ _05606_ _05607_ VDD VSS AOI21_X4
X_28660_ _06416_ _05608_ VDD VSS INV_X1
X_28661_ _11265_ _11261_ _05609_ VDD VSS XNOR2_X1
X_28662_ _05608_ _08975_ _05609_ _05610_ VDD VSS NOR3_X1
X_28663_ _06416_ _08975_ _05609_ _05611_ VDD VSS NOR3_X1
X_28664_ _05610_ _05611_ _03020_ _05612_ VDD VSS MUX2_X2
X_28665_ _11265_ _11261_ _05613_ VDD VSS XOR2_X1
X_28666_ _06416_ _00991_ _05613_ _05614_ VDD VSS NOR3_X1
X_28667_ _05608_ _00991_ _05613_ _05615_ VDD VSS NOR3_X1
X_28668_ _05614_ _05615_ _03020_ _05616_ VDD VSS MUX2_X1
X_28669_ _06416_ _09135_ text_in_r\[5\] _05617_ VDD VSS NAND3_X1
X_28670_ _05608_ _09135_ _05618_ VDD VSS NAND2_X1
X_28671_ _05617_ _05618_ text_in_r\[5\] _05619_ VDD VSS OAI21_X2
X_28672_ _05612_ _05616_ _05619_ _05620_ VDD VSS NOR3_X4
X_28673_ _05620_ _05621_ VDD VSS BUF_X4
X_28674_ _05621_ _05622_ VDD VSS BUF_X4
X_28675_ _05564_ _05623_ VDD VSS BUF_X4
X_28676_ _05623_ _05624_ VDD VSS CLKBUF_X3
X_28677_ _05624_ _05530_ _05527_ _05625_ VDD VSS OAI21_X2
X_28678_ _09194_ text_in_r\[3\] _05626_ VDD VSS NOR2_X1
X_28679_ _05599_ _05626_ _05601_ _09075_ _05627_ VDD VSS AOI211_X4
X_28680_ _09194_ _05594_ _05628_ VDD VSS NOR2_X1
X_28681_ _06393_ _05628_ _05596_ net1004 _05629_ VDD VSS AOI211_X4
X_28682_ _05627_ _05629_ _05630_ VDD VSS NOR2_X2
X_28683_ _05630_ _05631_ VDD VSS BUF_X4
X_28684_ _05631_ _05632_ VDD VSS BUF_X4
X_28685_ _05568_ _05633_ VDD VSS CLKBUF_X3
X_28686_ _15294_ _05634_ VDD VSS BUF_X4
X_28687_ _05634_ _05635_ VDD VSS INV_X1
X_28688_ _05632_ _05633_ _05635_ _05636_ VDD VSS AOI21_X1
X_28689_ _05622_ _05625_ _05636_ _05637_ VDD VSS AOI21_X1
X_28690_ _05612_ _05616_ _05619_ _05638_ VDD VSS OR3_X2
X_28691_ _05638_ _05639_ VDD VSS BUF_X4
X_28692_ _05639_ _05591_ _05640_ VDD VSS NOR2_X2
Xclone96 net101 net96 VDD VSS INV_X4
X_28694_ net1131 _05642_ VDD VSS BUF_X8
X_28695_ _05563_ _05598_ _05603_ _05643_ VDD VSS NAND3_X2
X_28696_ _05643_ _05644_ VDD VSS CLKBUF_X3
X_28697_ _05567_ _05623_ _05645_ VDD VSS NAND2_X1
X_28698_ _05532_ _05604_ _05646_ VDD VSS NOR2_X1
X_28699_ _05642_ _05644_ _05645_ _05646_ _05647_ VDD VSS OAI22_X1
X_28700_ _05582_ _05607_ _05637_ _05640_ _05647_ _05648_ VDD
+ VSS AOI221_X1
X_28701_ _05639_ _05649_ VDD VSS BUF_X4
X_28702_ _05649_ _05650_ VDD VSS CLKBUF_X3
X_28703_ _05532_ _05632_ _05651_ VDD VSS NOR2_X1
Xclone14 _07377_ net14 VDD VSS BUF_X8
X_28705_ _05598_ _05653_ VDD VSS BUF_X4
X_28706_ _05603_ _05654_ VDD VSS BUF_X4
X_28707_ net1115 _05653_ _05654_ _05655_ VDD VSS NAND3_X2
X_28708_ _05627_ _05656_ VDD VSS BUF_X4
X_28709_ _05629_ _05657_ VDD VSS BUF_X4
X_28710_ net575 _05530_ _05656_ _05657_ _05658_ VDD VSS OAI22_X4
X_28711_ _05655_ _05658_ _05659_ VDD VSS NAND2_X1
X_28712_ _05650_ _05651_ _05645_ _05659_ _15315_ _05660_ VDD
+ VSS OAI221_X1
X_28713_ _05567_ _05598_ _05603_ _05661_ VDD VSS AOI21_X4
X_28714_ _05564_ _05627_ _05629_ _05662_ VDD VSS NOR3_X4
X_28715_ _15293_ _05663_ VDD VSS BUF_X4
Xrebuffer440 _05757_ net1062 VDD VSS BUF_X4
X_28717_ _05633_ _05665_ VDD VSS BUF_X4
X_28718_ net747 _05627_ _05629_ _05666_ VDD VSS NOR3_X4
X_28719_ _05665_ _05666_ _05667_ VDD VSS NOR2_X1
X_28720_ _05661_ _05662_ net752 _05658_ _05667_ _05668_ VDD
+ VSS AOI221_X2
X_28721_ _05660_ _05668_ _05650_ _05669_ VDD VSS OAI21_X1
X_28722_ _05585_ _05589_ _05670_ VDD VSS NAND2_X4
X_28723_ _05670_ _05671_ VDD VSS BUF_X4
X_28724_ _05671_ _05672_ VDD VSS BUF_X4
X_28725_ _05672_ _05673_ VDD VSS BUF_X4
X_28726_ _05648_ _05669_ _05673_ _05674_ VDD VSS OAI21_X2
X_28727_ _06430_ _05574_ _05675_ VDD VSS XOR2_X2
X_28728_ _05675_ _05676_ VDD VSS CLKBUF_X3
X_28729_ _05676_ _05581_ _05677_ VDD VSS OR2_X1
Xclone98 net617 net98 VDD VSS BUF_X8
X_28731_ _05563_ _05627_ _05629_ _05679_ VDD VSS NOR3_X4
X_28732_ _05563_ _05627_ _05629_ _05680_ VDD VSS OAI21_X4
X_28733_ _05680_ net832 _05622_ _05681_ VDD VSS AOI21_X4
X_28734_ _15292_ _05679_ _05681_ _05682_ VDD VSS OAI21_X2
X_28735_ _15300_ _05683_ VDD VSS BUF_X4
X_28736_ _05683_ _05684_ VDD VSS INV_X2
X_28737_ _05684_ _05621_ _05685_ VDD VSS NOR2_X1
X_28738_ _05528_ _05529_ _05686_ VDD VSS AND2_X1
X_28739_ net1065 _10571_ _05687_ VDD VSS NAND2_X1
X_28740_ _05520_ _10571_ _05688_ VDD VSS NAND2_X1
X_28741_ _05687_ _05688_ _05526_ _05689_ VDD VSS MUX2_X2
X_28742_ net753 _05686_ _05689_ _05690_ VDD VSS AOI21_X4
X_28743_ _05685_ _05690_ _05622_ _05691_ VDD VSS AOI21_X1
X_28744_ _05623_ _05656_ _05657_ _05692_ VDD VSS OAI21_X4
X_28745_ _05639_ _05693_ VDD VSS BUF_X4
X_28746_ _05683_ _05653_ _05654_ _05694_ VDD VSS NAND3_X2
X_28747_ _05693_ _05694_ _05695_ VDD VSS NOR2_X1
X_28748_ _05631_ _05696_ VDD VSS BUF_X4
X_28749_ _05639_ _05696_ _05697_ VDD VSS XNOR2_X1
X_28750_ _05663_ _05698_ VDD VSS INV_X8
X_28751_ _05695_ _05697_ _05698_ _05699_ VDD VSS AOI21_X1
X_28752_ _05682_ _05691_ _05692_ _15315_ _05699_ _05700_ VDD
+ VSS OAI221_X1
X_28753_ _05696_ _05701_ VDD VSS BUF_X4
X_28754_ _05565_ _05639_ _05702_ VDD VSS NAND2_X1
X_28755_ _05592_ _05703_ VDD VSS BUF_X4
X_28756_ net1053 _05704_ VDD VSS BUF_X4
X_28757_ _05703_ _15290_ _05704_ _05705_ VDD VSS AOI21_X1
X_28758_ _05701_ net752 _05702_ _05705_ _05693_ _05706_ VDD
+ VSS OAI221_X2
X_28759_ net832 _05570_ _05693_ _05707_ VDD VSS NAND3_X1
X_28760_ _05624_ _05622_ _15290_ _05708_ VDD VSS AOI21_X1
Xrebuffer293 _04228_ net909 VDD VSS BUF_X1
Xrebuffer266 _06606_ net731 VDD VSS BUF_X1
X_28763_ _15299_ _05566_ _05710_ VDD VSS NAND2_X1
X_28764_ _05707_ _05708_ net95 _05649_ _05710_ _05711_ VDD
+ VSS OAI221_X1
X_28765_ _05706_ _05711_ _05701_ _05712_ VDD VSS OAI21_X1
X_28766_ _05591_ _05713_ VDD VSS BUF_X4
X_28767_ _05713_ _05714_ VDD VSS BUF_X4
X_28768_ _05714_ _05715_ VDD VSS BUF_X4
X_28769_ _05700_ _05712_ _05715_ _05716_ VDD VSS MUX2_X1
X_28770_ _05591_ _05717_ VDD VSS BUF_X4
X_28771_ _05717_ _05718_ VDD VSS BUF_X4
X_28772_ _05604_ _05719_ VDD VSS CLKBUF_X3
X_28773_ _05719_ _05720_ VDD VSS CLKBUF_X3
X_28774_ _05567_ _05656_ _05657_ _05721_ VDD VSS OAI21_X2
X_28775_ _05665_ _05720_ _05634_ _05721_ _05704_ _05722_ VDD
+ VSS OAI221_X2
X_28776_ _05563_ _05653_ _05654_ _05723_ VDD VSS AOI21_X2
X_28777_ _05723_ _05724_ VDD VSS BUF_X4
X_28778_ _05684_ _05724_ _05725_ VDD VSS NAND2_X1
X_28779_ _05718_ _05722_ _05725_ _05726_ VDD VSS AND3_X1
X_28780_ _15302_ _05727_ VDD VSS BUF_X4
X_28781_ _05727_ _05728_ VDD VSS CLKBUF_X3
X_28782_ _05548_ _05530_ net574 _05729_ VDD VSS OAI21_X4
X_28783_ _05634_ _05729_ _05631_ _05730_ VDD VSS MUX2_X1
X_28784_ _05717_ _05679_ _05728_ _05730_ _05665_ _05731_ VDD
+ VSS AOI221_X1
X_28785_ _05650_ _05726_ _05731_ _05732_ VDD VSS NOR3_X1
X_28786_ _05621_ _05733_ VDD VSS BUF_X4
X_28787_ _05604_ _05734_ VDD VSS BUF_X4
X_28788_ net1131 _05729_ _05568_ _05735_ VDD VSS MUX2_X1
X_28789_ _05713_ _05734_ _05735_ _05736_ VDD VSS AOI21_X4
X_28790_ _15292_ _05643_ _05737_ VDD VSS NOR2_X1
X_28791_ _05549_ _05598_ _05603_ _05738_ VDD VSS NAND3_X4
X_28792_ _05738_ _05632_ _05635_ _05739_ VDD VSS OAI21_X1
X_28793_ _05565_ _05740_ VDD VSS CLKBUF_X3
X_28794_ _05737_ _05739_ _05740_ _05741_ VDD VSS AOI21_X1
X_28795_ _05632_ _05742_ VDD VSS BUF_X4
X_28796_ _15313_ _05742_ _05724_ net752 _05743_ VDD VSS AOI22_X2
X_28797_ _05733_ _05736_ _05741_ _05743_ _05718_ _05744_ VDD
+ VSS AOI221_X2
X_28798_ _05744_ _05732_ _05676_ _05745_ VDD VSS NOR3_X2
X_28799_ _05581_ _05746_ VDD VSS CLKBUF_X3
X_28800_ _05576_ _05649_ _05747_ VDD VSS NOR2_X1
X_28801_ _05719_ _05748_ VDD VSS CLKBUF_X3
X_28802_ _05634_ _05748_ _05749_ VDD VSS NAND2_X1
X_28803_ net1060 _05653_ _05654_ _05750_ VDD VSS NAND3_X4
X_28804_ _15308_ _05749_ _05750_ _05751_ VDD VSS AND3_X1
X_28805_ _15292_ _05752_ VDD VSS INV_X1
X_28806_ _05718_ _05692_ _05752_ _05753_ VDD VSS OAI21_X1
X_28807_ _05567_ _05627_ _05629_ _05754_ VDD VSS NOR3_X4
X_28808_ _05734_ _05755_ VDD VSS BUF_X4
X_28809_ _05754_ _05755_ net1053 _05756_ VDD VSS AOI21_X1
X_28810_ _05663_ _05653_ _05654_ _05757_ VDD VSS AOI21_X4
X_28811_ _05757_ _05742_ _05684_ _05758_ VDD VSS AOI21_X1
X_28812_ _05624_ _05759_ VDD VSS CLKBUF_X3
X_28813_ _05756_ _05758_ _05759_ _05760_ VDD VSS MUX2_X1
X_28814_ _05747_ _05751_ _05753_ _05760_ _05715_ _05761_ VDD
+ VSS OAI221_X2
X_28815_ _05576_ _05733_ _05762_ VDD VSS NOR2_X1
X_28816_ net1058 _05670_ _05763_ VDD VSS NAND2_X1
X_28817_ _05755_ _05763_ _05764_ VDD VSS NOR2_X1
X_28818_ net1060 _05653_ _05654_ _05765_ VDD VSS AOI21_X4
X_28819_ _15308_ _05765_ _05766_ VDD VSS OR2_X1
X_28820_ net92 _05653_ _05654_ _05767_ VDD VSS NAND3_X2
X_28821_ _05728_ _05656_ _05657_ _05768_ VDD VSS OAI21_X1
X_28822_ _05759_ _05767_ _05768_ _05769_ VDD VSS AOI21_X1
X_28823_ _05673_ _05769_ _05770_ VDD VSS NOR2_X1
X_28824_ _05762_ _05764_ _05766_ _05770_ _05607_ _05771_ VDD
+ VSS OAI221_X1
X_28825_ _05761_ _05746_ _05771_ _05772_ VDD VSS NAND3_X2
X_28826_ _05674_ _05677_ _05716_ _05745_ _05772_ _00152_ VDD
+ VSS OAI221_X2
X_28827_ net747 _05627_ _05629_ _05773_ VDD VSS OAI21_X4
X_28828_ _05663_ _05627_ _05629_ _05774_ VDD VSS NOR3_X4
X_28829_ _05565_ _05774_ _05775_ VDD VSS NOR2_X1
X_28830_ _05634_ _05632_ _05738_ net516 _05776_ VDD VSS OAI22_X4
X_28831_ _05671_ _05773_ _05775_ _05776_ _05740_ _05777_ VDD
+ VSS AOI221_X2
X_28832_ _05549_ _05656_ _05657_ _05778_ VDD VSS OAI21_X2
X_28833_ net92 _05719_ _05778_ net90 _05779_ VDD VSS OAI22_X1
X_28834_ _05713_ _05724_ _15290_ _05779_ _05570_ _05780_ VDD
+ VSS AOI221_X2
X_28835_ _05733_ _05777_ _05780_ _05781_ VDD VSS NOR3_X1
X_28836_ _05620_ _05671_ _05782_ VDD VSS NAND2_X4
X_28837_ _15292_ _05656_ _05657_ _05783_ VDD VSS OAI21_X4
X_28838_ _05783_ _05748_ _05532_ _05784_ VDD VSS OAI21_X1
X_28839_ _15308_ _05784_ _05785_ VDD VSS NOR2_X1
X_28840_ _05759_ _05721_ _05750_ _05786_ VDD VSS AOI21_X1
X_28841_ _05621_ _05713_ _05787_ VDD VSS NAND2_X2
X_28842_ _05665_ _05778_ _05767_ _05788_ VDD VSS AOI21_X1
X_28843_ _05752_ _05656_ _05657_ _05789_ VDD VSS NOR3_X2
X_28844_ _05633_ _05632_ _05634_ _05790_ VDD VSS OAI21_X2
X_28845_ _05789_ _05790_ _05791_ VDD VSS NOR2_X1
X_28846_ _05782_ _05785_ _05786_ _05787_ _05788_ _05791_ _05792_
+ VDD VSS OAI33_X1
X_28847_ _05746_ _05781_ _05792_ _05793_ VDD VSS OR3_X1
X_28848_ _05719_ _05690_ _05794_ VDD VSS OR2_X1
X_28849_ net717 _05719_ _05642_ _05795_ VDD VSS AOI21_X1
X_28850_ _05794_ _05795_ _05633_ _05796_ VDD VSS MUX2_X1
X_28851_ _05581_ _05640_ _05797_ VDD VSS NAND2_X1
X_28852_ _05676_ _05796_ _05797_ _05798_ VDD VSS OAI21_X2
X_28853_ _05580_ _05621_ _05799_ VDD VSS AND2_X1
X_28854_ _05714_ _05799_ _05800_ VDD VSS NAND2_X1
X_28855_ _05800_ _05662_ net95 _05801_ VDD VSS AOI21_X1
X_28856_ _05633_ _05802_ VDD VSS CLKBUF_X3
X_28857_ _05532_ _05661_ _05803_ VDD VSS NAND2_X1
X_28858_ _05802_ _05803_ _05804_ VDD VSS NAND2_X1
X_28859_ _05655_ _05804_ _05805_ VDD VSS NAND2_X1
X_28860_ _05633_ _05767_ _05783_ _05806_ VDD VSS NAND3_X1
X_28861_ _05778_ _05750_ _05807_ VDD VSS AND2_X1
X_28862_ _05806_ _05807_ _05570_ _05808_ VDD VSS OAI21_X1
X_28863_ _05698_ _05692_ _05738_ _05532_ _05809_ VDD VSS OAI22_X1
X_28864_ _05564_ _05653_ _05654_ _05810_ VDD VSS NAND3_X4
X_28865_ _05810_ _05680_ _05811_ VDD VSS NAND2_X1
X_28866_ _05809_ _05811_ _15290_ _05812_ VDD VSS AOI21_X1
X_28867_ _05808_ _05812_ _05672_ _05813_ VDD VSS MUX2_X1
X_28868_ _05580_ _05639_ _05814_ VDD VSS NAND2_X2
X_28869_ _05814_ _05815_ VDD VSS INV_X1
X_28870_ _05798_ _05801_ _05805_ _05813_ _05815_ _05816_ VDD
+ VSS AOI221_X2
X_28871_ _05698_ _05569_ _05817_ VDD VSS NOR2_X1
X_28872_ net1115 _05818_ VDD VSS INV_X1
X_28873_ _05818_ _05624_ _05819_ VDD VSS NOR2_X1
X_28874_ _05742_ _05817_ _05819_ _05820_ VDD VSS OAI21_X1
X_28875_ _05564_ _05598_ _05603_ _05821_ VDD VSS AOI21_X4
X_28876_ _05679_ _05821_ _05822_ VDD VSS NOR2_X2
X_28877_ _05642_ _05692_ _05822_ _05704_ _05823_ VDD VSS OAI22_X2
X_28878_ _05814_ _05820_ _05736_ _05823_ _05718_ _05824_ VDD
+ VSS AOI221_X2
X_28879_ net717 _05765_ _05825_ VDD VSS NOR2_X4
X_28880_ _05715_ _05692_ _15290_ _05825_ _15315_ _05826_ VDD
+ VSS OAI221_X1
X_28881_ _05826_ _05662_ _05715_ _05827_ VDD VSS OAI21_X1
X_28882_ _05580_ _05621_ _05828_ VDD VSS NAND2_X1
X_28883_ _05566_ _05717_ _05810_ _05549_ _05829_ VDD VSS OAI22_X1
X_28884_ _05704_ _05720_ _05830_ VDD VSS NAND2_X1
X_28885_ _05740_ _05717_ _05831_ VDD VSS NAND2_X1
X_28886_ _05714_ _05830_ _05831_ _05748_ _05832_ VDD VSS OAI22_X1
X_28887_ _05828_ _05829_ _15296_ _05832_ _15290_ _05833_ VDD
+ VSS AOI221_X1
X_28888_ _05824_ _05827_ _05833_ _05834_ VDD VSS AOI21_X1
X_28889_ _05721_ _05738_ net93 _05835_ VDD VSS OAI21_X1
X_28890_ _05639_ _05724_ _15292_ _05835_ _05570_ _05836_ VDD
+ VSS AOI221_X1
X_28891_ _05621_ _05703_ _05750_ _05724_ _05532_ _05837_ VDD
+ VSS AOI221_X1
X_28892_ _05673_ _05836_ _05837_ _05838_ VDD VSS OR3_X1
X_28893_ net90 _05568_ _05839_ VDD VSS NOR2_X1
X_28894_ _05693_ _05717_ _05840_ VDD VSS NAND2_X1
X_28895_ _05642_ _05841_ VDD VSS INV_X1
X_28896_ _05841_ _05565_ _05842_ VDD VSS NOR2_X2
X_28897_ _05755_ _05839_ _05840_ _05842_ _05843_ VDD VSS NOR4_X2
X_28898_ _05622_ _05742_ _15292_ _05844_ VDD VSS OAI21_X1
X_28899_ _05729_ _05831_ _05844_ _05845_ VDD VSS NOR3_X1
X_28900_ _05630_ _05592_ _05532_ _05564_ _05683_ _05846_ VDD
+ VSS AOI221_X2
X_28901_ _15316_ _05622_ _05720_ _05847_ VDD VSS NOR3_X1
X_28902_ _05718_ _05846_ _05847_ _05848_ VDD VSS NOR3_X1
X_28903_ _05746_ _05843_ _05845_ _05848_ _05849_ VDD VSS NOR4_X1
X_28904_ _05676_ _05838_ _05849_ _05850_ VDD VSS AOI21_X1
X_28905_ _05793_ _05816_ _05834_ _05850_ _00153_ VDD VSS AOI22_X2
X_28906_ _05676_ _05581_ _05851_ VDD VSS NAND2_X1
X_28907_ _05802_ _05694_ _05701_ net1109 _05852_ VDD VSS OAI211_X2
X_28908_ _05783_ _05720_ net832 _05853_ VDD VSS OAI21_X2
X_28909_ _05649_ _05852_ _05853_ _15308_ _05854_ VDD VSS OAI211_X2
X_28910_ _05532_ _05719_ _05703_ _05855_ VDD VSS NOR3_X1
X_28911_ _05658_ _05569_ _05532_ _05856_ VDD VSS OAI21_X1
X_28912_ net90 _05623_ _05857_ VDD VSS NOR2_X2
X_28913_ _05855_ _05856_ net752 _05738_ _05857_ _05858_ VDD
+ VSS AOI221_X2
X_28914_ _05715_ _05854_ _05858_ _05650_ _05859_ VDD VSS OAI211_X2
X_28915_ _15296_ _15299_ _05860_ VDD VSS NOR2_X1
X_28916_ _05755_ _05860_ _05857_ _05861_ VDD VSS NOR3_X1
X_28917_ _05649_ _05701_ _15316_ _05862_ VDD VSS OAI21_X1
X_28918_ net92 _05729_ _05569_ _05863_ VDD VSS MUX2_X1
X_28919_ _15313_ _05863_ _05701_ _05864_ VDD VSS MUX2_X1
X_28920_ _05673_ _05861_ _05862_ _05864_ _05650_ _05865_ VDD
+ VSS OAI221_X1
X_28921_ _05859_ _05865_ _05866_ VDD VSS AND2_X1
X_28922_ _05698_ _05597_ _05602_ _05867_ VDD VSS AOI21_X4
X_28923_ _05569_ _05867_ _05754_ _05868_ VDD VSS OAI21_X4
X_28924_ _05635_ _05653_ _05654_ _05869_ VDD VSS NAND3_X1
X_28925_ _05566_ _05658_ _05869_ _05870_ VDD VSS NAND3_X1
X_28926_ _05672_ _05868_ _05870_ _05871_ VDD VSS AOI21_X4
X_28927_ _05549_ _05627_ _05629_ _05872_ VDD VSS NOR3_X4
X_28928_ _05661_ _05872_ _05873_ VDD VSS NOR2_X1
X_28929_ _05713_ _05839_ _05873_ _05662_ _05818_ _05874_ VDD
+ VSS AOI221_X1
X_28930_ _05746_ _05649_ _05871_ _05874_ _05875_ VDD VSS NOR4_X2
X_28931_ net716 _15294_ _05876_ VDD VSS NOR2_X4
X_28932_ _05876_ _05877_ VDD VSS INV_X1
X_28933_ _05643_ _05877_ _05878_ VDD VSS NOR2_X1
X_28934_ _05878_ _05811_ _05690_ _05683_ _05724_ _05879_ VDD
+ VSS AOI221_X2
X_28935_ _05799_ _05853_ _05759_ _05810_ _05841_ _05880_ VDD
+ VSS OAI221_X1
X_28936_ _05576_ _05800_ _05879_ _05880_ _05715_ _05881_ VDD
+ VSS OAI221_X1
X_28937_ _05875_ _05881_ _05882_ VDD VSS OR2_X2
X_28938_ _05671_ _05883_ VDD VSS BUF_X4
X_28939_ _05883_ _05748_ _05735_ _05884_ VDD VSS OAI21_X2
X_28940_ _05742_ _05817_ _05857_ _05885_ VDD VSS NOR3_X1
X_28941_ _05746_ _05884_ _05885_ _05886_ VDD VSS OR3_X1
X_28942_ _05689_ _05686_ _05549_ _05565_ _05887_ VDD VSS AOI22_X2
X_28943_ _15311_ _05887_ _05713_ _05888_ VDD VSS MUX2_X1
X_28944_ _05755_ _05888_ _05889_ VDD VSS NOR2_X1
X_28945_ _15320_ _05883_ _05890_ VDD VSS NOR2_X1
X_28946_ _05570_ _05717_ _05729_ _05891_ VDD VSS NOR3_X1
X_28947_ _05701_ _05890_ _05891_ _05892_ VDD VSS NOR3_X1
X_28948_ _05746_ _05889_ _05892_ _05893_ VDD VSS OAI21_X1
X_28949_ _05738_ _05773_ _05894_ VDD VSS NAND2_X1
X_28950_ _05646_ _05821_ _05642_ _05894_ _05623_ _05895_ VDD
+ VSS AOI221_X2
X_28951_ _05746_ _05672_ _05895_ _05896_ VDD VSS OR3_X1
X_28952_ _05650_ _05886_ _05893_ _05896_ _05897_ VDD VSS AND4_X2
X_28953_ _05778_ _05767_ _05898_ VDD VSS NAND2_X1
X_28954_ _15315_ _05898_ _05899_ VDD VSS NOR2_X1
X_28955_ _05728_ _05734_ _05900_ VDD VSS AND2_X1
X_28956_ _15308_ _05900_ net718 _05901_ VDD VSS NOR3_X2
X_28957_ _05640_ _05901_ _05899_ _05902_ VDD VSS OAI21_X2
X_28958_ _05759_ _05750_ _05773_ _05903_ VDD VSS NAND3_X1
X_28959_ _05727_ _05598_ _05603_ _05904_ VDD VSS AOI21_X4
X_28960_ _15308_ _05872_ _05904_ _05905_ VDD VSS OAI21_X1
X_28961_ _05715_ _05903_ _05905_ _05906_ VDD VSS NAND3_X1
X_28962_ _05714_ _05759_ _05841_ _05907_ VDD VSS AOI21_X1
X_28963_ _05904_ _05696_ _05704_ _05908_ VDD VSS AOI21_X1
X_28964_ _05907_ _05908_ _15315_ _05909_ VDD VSS OAI21_X1
X_28965_ _05650_ _05906_ _05909_ _05910_ VDD VSS NAND3_X1
X_28966_ _05639_ _05671_ _05911_ VDD VSS NOR2_X2
X_28967_ _05549_ _05598_ _05603_ _05912_ VDD VSS AOI21_X4
X_28968_ _05727_ _05656_ _05657_ _05913_ VDD VSS NOR3_X4
X_28969_ _05759_ _05912_ _05913_ _05914_ VDD VSS NOR3_X1
X_28970_ net747 _05598_ _05603_ _05915_ VDD VSS AOI21_X4
X_28971_ _05915_ _05701_ net1109 _05916_ VDD VSS AOI21_X1
X_28972_ _05914_ _05916_ _15315_ _05917_ VDD VSS AOI21_X1
X_28973_ _05911_ _05917_ _05918_ VDD VSS NAND2_X1
X_28974_ _05918_ _05910_ _05902_ _05919_ VDD VSS NAND3_X1
X_28975_ _05851_ _05866_ _05882_ _05897_ _05582_ _05919_ _00154_
+ VDD VSS OAI222_X2
X_28976_ _05549_ _05563_ _05920_ VDD VSS NAND2_X2
X_28977_ _05670_ _05598_ _05603_ _05564_ net91 _05921_ VDD
+ VSS AOI221_X2
X_28978_ _05727_ _05623_ _05922_ VDD VSS NAND2_X1
X_28979_ _05922_ _05876_ _05623_ _05923_ VDD VSS OAI21_X1
X_28980_ _05632_ _05923_ _05924_ VDD VSS NAND2_X1
X_28981_ _05591_ _05846_ _05925_ VDD VSS NOR2_X1
X_28982_ _05621_ _05920_ _05921_ _05924_ _05925_ _05926_ VDD
+ VSS AOI221_X2
X_28983_ _05570_ _05757_ _05913_ _05927_ VDD VSS OAI21_X1
X_28984_ _05740_ _05754_ _05915_ _05928_ VDD VSS OAI21_X2
X_28985_ _05911_ _05927_ _05928_ _05929_ VDD VSS NAND3_X2
X_28986_ _05568_ _05631_ net1061 _05930_ VDD VSS OAI21_X1
X_28987_ _05737_ _05930_ _05549_ _05723_ net1061 _05931_ VDD
+ VSS AOI221_X2
X_28988_ _05929_ _05931_ _05782_ _05932_ VDD VSS OAI21_X1
X_28989_ _05591_ _05920_ _05729_ _05631_ _05568_ _05933_ VDD
+ VSS AOI221_X2
X_28990_ _05568_ _05666_ _05904_ _05934_ VDD VSS NOR3_X1
X_28991_ _05867_ _05631_ net516 _05935_ VDD VSS AOI21_X2
X_28992_ _05934_ _05935_ _05569_ _05936_ VDD VSS AOI21_X2
X_28993_ _05621_ _05933_ _05936_ _05713_ _05937_ VDD VSS AOI211_X2
X_28994_ _05719_ _05592_ _05679_ net1058 _05938_ VDD VSS AOI22_X1
X_28995_ _05640_ _05938_ net748 _05644_ _05684_ _05939_ VDD
+ VSS OAI221_X1
X_28996_ _05939_ _05724_ _05698_ _05940_ VDD VSS AOI21_X1
X_28997_ _05683_ _05724_ _05941_ VDD VSS NAND2_X1
X_28998_ net93 _05872_ _05942_ VDD VSS NAND2_X1
X_28999_ _05911_ _05868_ _05941_ _05942_ _05943_ VDD VSS NAND4_X4
X_29000_ _05943_ _05581_ _05676_ _05944_ VDD VSS NAND3_X2
X_29001_ _05582_ _05926_ _05932_ _05937_ _05944_ _05940_ _05945_
+ VDD VSS OAI33_X1
X_29002_ _05676_ _05746_ _05946_ VDD VSS NOR2_X1
X_29003_ _05755_ _05703_ _05822_ _05728_ _05947_ VDD VSS AOI22_X1
X_29004_ _05946_ _05947_ _05782_ _05948_ VDD VSS OAI21_X1
X_29005_ _05948_ _05949_ VDD VSS INV_X1
X_29006_ _05569_ _05655_ _05778_ _05950_ VDD VSS AOI21_X1
X_29007_ _05757_ _05876_ _05632_ _05951_ VDD VSS AOI21_X1
X_29008_ _05950_ _05951_ _05570_ _05952_ VDD VSS AOI21_X1
X_29009_ _05733_ _05718_ _05952_ _05953_ VDD VSS NOR3_X1
X_29010_ _05621_ _05656_ _05657_ _05954_ VDD VSS OAI21_X1
X_29011_ _05740_ _05954_ _05702_ _05734_ _05955_ VDD VSS OAI22_X1
X_29012_ _05696_ _05702_ _05956_ VDD VSS NOR2_X1
X_29013_ _05698_ _05955_ _05956_ _05684_ _05957_ VDD VSS AOI22_X1
X_29014_ _05634_ _05696_ _05958_ VDD VSS NAND2_X1
X_29015_ net93 _05639_ _05720_ _05959_ VDD VSS NAND3_X1
X_29016_ _05958_ _05959_ _05960_ VDD VSS AND2_X1
X_29017_ _05957_ _05960_ _05759_ _05961_ VDD VSS OAI21_X1
X_29018_ _05953_ _05961_ _05715_ _05962_ VDD VSS AOI21_X2
X_29019_ net1109 _05717_ _05703_ _05963_ VDD VSS NOR3_X1
X_29020_ _05625_ _05883_ _15290_ _05964_ VDD VSS AOI21_X1
X_29021_ _05755_ _05963_ _05964_ _05965_ VDD VSS OAI21_X1
X_29022_ _05740_ _05883_ _05966_ VDD VSS NAND2_X1
X_29023_ _05633_ _05713_ _05967_ VDD VSS XNOR2_X1
X_29024_ _05701_ _05966_ net1109 _05967_ net752 _05968_ VDD
+ VSS OAI221_X2
X_29025_ _15299_ _15308_ _05718_ _05969_ VDD VSS NAND3_X1
X_29026_ _05649_ _05965_ _05968_ _05969_ _05970_ VDD VSS NAND4_X2
X_29027_ _05789_ _05748_ _05683_ _05971_ VDD VSS AOI21_X1
X_29028_ _05661_ net717 _05972_ VDD VSS OR2_X1
X_29029_ _05971_ _05972_ _05566_ _05973_ VDD VSS MUX2_X1
X_29030_ _05566_ _05666_ _05867_ _05974_ VDD VSS NOR3_X1
X_29031_ _05665_ _05658_ _05750_ _05975_ VDD VSS AOI21_X1
X_29032_ _05974_ _05975_ _05976_ VDD VSS OR2_X1
X_29033_ _05970_ _05973_ _05787_ _05782_ _05976_ _05977_ VDD
+ VSS OAI221_X2
X_29034_ _05575_ _05581_ _05978_ VDD VSS AND2_X1
X_29035_ _05945_ _05949_ _05962_ _05977_ _05978_ _00155_ VDD
+ VSS AOI221_X2
X_29036_ net1062 _05633_ _05913_ _05979_ VDD VSS NOR3_X4
X_29037_ _05740_ _05915_ _05980_ VDD VSS NOR2_X1
X_29038_ net1061 _05872_ _05981_ VDD VSS NAND2_X4
X_29039_ _05979_ _05980_ _05981_ _05982_ VDD VSS AOI21_X2
X_29040_ _05727_ _05633_ _05983_ VDD VSS AND2_X1
X_29041_ _05983_ _05825_ _05566_ _05984_ VDD VSS AOI21_X2
X_29042_ _05978_ _05782_ _05982_ _05787_ _05984_ _05985_ VDD
+ VSS OAI221_X2
X_29043_ _05623_ _05765_ _05986_ VDD VSS NOR2_X1
X_29044_ _05915_ _05631_ net90 _05987_ VDD VSS AOI21_X2
X_29045_ _05671_ _05981_ _05986_ _05987_ _05624_ _05988_ VDD
+ VSS AOI221_X2
X_29046_ _05625_ _05566_ _15292_ _05989_ VDD VSS OAI21_X1
X_29047_ _05701_ _05989_ _05990_ VDD VSS NAND2_X1
X_29048_ _05988_ _05990_ _05736_ _05991_ VDD VSS AOI21_X1
X_29049_ _05985_ _05991_ _05650_ _05992_ VDD VSS AOI21_X2
X_29050_ net1058 _05620_ _05993_ VDD VSS NOR2_X1
X_29051_ _05670_ _05662_ _05993_ _05912_ _05532_ _05994_ VDD
+ VSS AOI221_X2
X_29052_ _05913_ _05720_ _05622_ _05995_ VDD VSS AOI21_X1
X_29053_ _05994_ _05995_ _05802_ _05996_ VDD VSS OAI21_X1
X_29054_ _05692_ _05644_ _05693_ _05997_ VDD VSS OAI21_X1
X_29055_ _05996_ _05997_ net95 _05998_ VDD VSS AOI21_X1
X_29056_ _05677_ _05998_ _05999_ VDD VSS NOR2_X1
X_29057_ _15304_ _05817_ _05696_ _06000_ VDD VSS MUX2_X1
X_29058_ _05733_ _06000_ _06001_ VDD VSS NAND2_X1
X_29059_ _05981_ _05680_ _05634_ _06002_ VDD VSS OAI21_X1
X_29060_ _05665_ _05738_ _05783_ _06003_ VDD VSS AOI21_X1
X_29061_ _05649_ _06002_ _06003_ _06004_ VDD VSS OAI21_X1
X_29062_ _05673_ _06001_ _06004_ _06005_ VDD VSS NAND3_X1
X_29063_ net90 _05623_ _05591_ _06006_ VDD VSS NOR3_X1
X_29064_ _05568_ _05670_ _06007_ VDD VSS NOR2_X1
X_29065_ _06006_ _06007_ _15292_ _06008_ VDD VSS AOI21_X1
X_29066_ net1058 _05568_ _05591_ _06009_ VDD VSS OAI21_X1
X_29067_ _05592_ _06009_ net1061 _06010_ VDD VSS AOI21_X1
X_29068_ _06008_ _06010_ _05719_ _06011_ VDD VSS MUX2_X1
X_29069_ _05624_ _05671_ _05719_ _05763_ _06012_ VDD VSS OAI22_X1
X_29070_ _05814_ _06012_ _05704_ _06013_ VDD VSS AOI21_X1
X_29071_ _05663_ _05563_ _06014_ VDD VSS NOR2_X1
X_29072_ _05734_ _05842_ _06014_ _06015_ VDD VSS OAI21_X1
X_29073_ _05776_ _06007_ _06015_ _05607_ _06016_ VDD VSS AOI22_X2
X_29074_ _05581_ _05693_ _06017_ VDD VSS NOR2_X2
X_29075_ _05576_ _06011_ _06013_ _06016_ _06017_ _06018_ VDD
+ VSS AOI221_X2
X_29076_ _05569_ _05631_ _05532_ _06019_ VDD VSS AOI21_X1
X_29077_ _05592_ _05783_ _06019_ _06020_ VDD VSS AOI21_X1
X_29078_ _05671_ _05696_ _05728_ _06021_ VDD VSS AOI21_X1
X_29079_ _05828_ _06020_ _05883_ _06021_ _05790_ _06022_ VDD
+ VSS AOI221_X2
X_29080_ _05750_ _05632_ _15292_ _06023_ VDD VSS OAI21_X2
X_29081_ _05532_ _05631_ _06024_ VDD VSS XNOR2_X1
X_29082_ _06023_ _06024_ _05624_ _06025_ VDD VSS MUX2_X1
X_29083_ _15299_ _05680_ _05915_ _05570_ _06026_ VDD VSS OAI22_X1
X_29084_ _06025_ _06026_ _05672_ _06027_ VDD VSS MUX2_X1
X_29085_ _05581_ _05622_ _06028_ VDD VSS NOR2_X1
X_29086_ _06022_ _06027_ _06028_ _06029_ VDD VSS AOI21_X2
X_29087_ _05992_ _05999_ _06005_ _06018_ _06029_ _00156_ VDD
+ VSS AOI221_X2
X_29088_ _05633_ _05904_ _06030_ VDD VSS NOR2_X1
X_29089_ net726 _05748_ _05704_ _06031_ VDD VSS AOI21_X1
X_29090_ _05883_ _05981_ _06030_ _06031_ _05802_ _06032_ VDD
+ VSS AOI221_X2
X_29091_ _05714_ _05680_ _05549_ _05912_ net1109 _06033_ VDD
+ VSS AOI221_X1
X_29092_ _05576_ _06032_ _06033_ _06034_ VDD VSS NOR3_X1
X_29093_ _05605_ _05703_ _06035_ VDD VSS NOR2_X1
X_29094_ _05673_ _05644_ _05877_ _06035_ _05658_ _06036_ VDD
+ VSS OAI221_X1
X_29095_ _05642_ _05565_ _06037_ VDD VSS NAND2_X1
X_29096_ _05672_ _05755_ _06037_ _06038_ VDD VSS AOI21_X1
X_29097_ _06038_ _05810_ net91 _06039_ VDD VSS OAI21_X1
X_29098_ _05676_ _06036_ _06039_ _06040_ VDD VSS AOI21_X1
X_29099_ _06017_ _06034_ _06040_ _06041_ VDD VSS OAI21_X1
X_29100_ _05734_ _05690_ _05692_ net93 _06042_ VDD VSS AOI22_X2
X_29101_ _05671_ _05679_ _05683_ _05821_ net1058 _06043_ VDD
+ VSS AOI221_X2
X_29102_ net93 _05644_ _06044_ VDD VSS NOR2_X1
X_29103_ _15299_ _05651_ _06044_ _06045_ VDD VSS OAI21_X1
X_29104_ _05675_ _05883_ _06042_ _06043_ _06045_ _06046_ VDD
+ VSS AOI221_X2
X_29105_ _05900_ _05729_ _05759_ _06047_ VDD VSS OAI21_X1
X_29106_ _05576_ _05672_ _06048_ VDD VSS NOR2_X1
X_29107_ _05722_ _05750_ _06047_ _06048_ _06049_ VDD VSS AND4_X1
X_29108_ _05676_ _05673_ _06050_ VDD VSS NAND2_X1
X_29109_ _05658_ _05755_ net91 _06051_ VDD VSS OAI21_X1
X_29110_ _05642_ _05748_ _06052_ VDD VSS NOR2_X1
X_29111_ _15308_ _06051_ _06052_ _05790_ _06053_ VDD VSS OAI22_X1
X_29112_ _05799_ _06050_ _06053_ _06054_ VDD VSS OAI21_X1
X_29113_ _06046_ _06049_ _06054_ _06055_ VDD VSS OR3_X1
X_29114_ _05642_ _05755_ _05981_ _15315_ _06056_ VDD VSS AOI22_X2
X_29115_ _05576_ _05581_ _06057_ VDD VSS NAND2_X1
X_29116_ _05802_ _05789_ _05915_ _06058_ VDD VSS NOR3_X1
X_29117_ net832 _05644_ _06059_ VDD VSS NOR2_X1
X_29118_ _06058_ _06057_ _05715_ _06059_ _06060_ VDD VSS NOR4_X2
X_29119_ _05714_ _05679_ _15299_ _06061_ VDD VSS AOI21_X1
X_29120_ _05851_ _05927_ _06061_ _06062_ VDD VSS AOI21_X1
X_29121_ _05673_ _06056_ _06060_ _06062_ _06063_ VDD VSS OAI22_X2
X_29122_ _05802_ _05749_ _05767_ _06064_ VDD VSS AOI21_X1
X_29123_ net1109 _05680_ _06065_ VDD VSS NOR2_X1
X_29124_ _06057_ _06064_ _06065_ _06066_ VDD VSS OR3_X1
X_29125_ _05683_ _05632_ _05690_ _05821_ _06067_ VDD VSS AOI22_X1
X_29126_ _05675_ _05717_ _06067_ _06068_ VDD VSS NOR3_X1
X_29127_ _05867_ _05675_ _05774_ _05564_ _06069_ VDD VSS NOR4_X4
X_29128_ _05690_ _05680_ _06070_ VDD VSS NOR2_X1
X_29129_ _05773_ _05604_ _05683_ _06071_ VDD VSS OAI21_X1
X_29130_ _06069_ _06070_ _05675_ _06071_ _05565_ _06072_ VDD
+ VSS AOI221_X2
X_29131_ _05696_ _05920_ _06037_ _06073_ VDD VSS AOI21_X1
X_29132_ _05576_ _06073_ _06074_ VDD VSS NOR2_X1
X_29133_ _06068_ _05714_ _06072_ _05607_ _06074_ _06075_ VDD
+ VSS AOI221_X2
X_29134_ _06063_ _06066_ _05673_ _06075_ _05746_ _06076_ VDD
+ VSS OAI221_X2
X_29135_ _06041_ _06055_ _06076_ _05733_ _00157_ VDD VSS OAI211_X2
X_29136_ _05883_ net1052 _06077_ VDD VSS NAND2_X1
X_29137_ _05696_ _05713_ _05728_ _06078_ VDD VSS OAI21_X1
X_29138_ _05665_ _06077_ _06078_ _06079_ VDD VSS NAND3_X1
X_29139_ _05740_ _05720_ _05763_ _05883_ _05532_ _06080_ VDD
+ VSS OAI221_X1
X_29140_ _05622_ _05714_ _05661_ _06079_ _06080_ _06081_ VDD
+ VSS AOI221_X1
X_29141_ net748 _05549_ _05591_ _06082_ VDD VSS NOR3_X1
X_29142_ _05915_ _05670_ _06083_ VDD VSS OR2_X4
X_29143_ _05713_ _05734_ _06084_ VDD VSS NOR2_X1
X_29144_ _06082_ _06083_ _05857_ _05703_ _06084_ _06085_ VDD
+ VSS AOI221_X2
X_29145_ _05527_ _05530_ _05549_ _05565_ _06086_ VDD VSS NOR4_X1
X_29146_ _05818_ _05661_ _06086_ _06087_ VDD VSS OAI21_X1
X_29147_ _05710_ _05942_ _06087_ _06088_ VDD VSS AND3_X1
X_29148_ _05650_ _06085_ _06088_ _05787_ _06089_ VDD VSS OAI22_X1
X_29149_ _06089_ _06081_ _05582_ _06090_ VDD VSS NOR3_X1
X_29150_ _05913_ _05720_ _05683_ _06091_ VDD VSS AOI21_X1
X_29151_ _05714_ _05644_ _05532_ _06091_ _05665_ _06092_ VDD
+ VSS OAI221_X1
X_29152_ _05649_ _05884_ _06092_ _06093_ VDD VSS AND3_X2
X_29153_ _15310_ _05742_ _06094_ VDD VSS NAND2_X1
X_29154_ _05922_ _05657_ _05656_ _05704_ _05740_ _06095_ VDD
+ VSS OAI221_X1
X_29155_ _05782_ _06094_ _06095_ _06096_ VDD VSS AOI21_X1
X_29156_ _05787_ _05950_ _06059_ _06097_ VDD VSS NOR3_X1
X_29157_ _06096_ _06097_ _06098_ VDD VSS OR2_X1
X_29158_ _05867_ _05754_ _05665_ _06099_ VDD VSS NOR3_X2
X_29159_ _05565_ _05604_ _05876_ _05872_ net1061 _06100_ VDD
+ VSS AOI221_X1
X_29160_ _06099_ _06100_ _05718_ _05733_ _06101_ VDD VSS NOR4_X2
X_29161_ _15294_ _05631_ _06102_ VDD VSS NOR2_X1
X_29162_ _05569_ _06102_ _06103_ VDD VSS NOR2_X1
X_29163_ _05782_ _05981_ _06103_ _05935_ _05570_ _06104_ VDD
+ VSS AOI221_X2
X_29164_ _05734_ _05645_ net748 _05624_ net92 _06105_ VDD
+ VSS OAI221_X1
X_29165_ _06105_ _05748_ _15311_ _06106_ VDD VSS OAI21_X1
X_29166_ _05696_ _05703_ _05704_ _06107_ VDD VSS OAI21_X1
X_29167_ _05725_ _06107_ _06108_ VDD VSS NAND2_X1
X_29168_ _05978_ _06106_ _05787_ _06108_ _05840_ _06109_ VDD
+ VSS OAI221_X1
X_29169_ _05677_ _06093_ _06098_ _06104_ _06101_ _06109_ _06110_
+ VDD VSS OAI33_X1
X_29170_ _05759_ _05958_ _05773_ _06111_ VDD VSS AOI21_X1
X_29171_ _05728_ _05742_ _05738_ _05704_ _06112_ VDD VSS OAI22_X1
X_29172_ _05672_ _06112_ _05802_ _06113_ VDD VSS OAI21_X1
X_29173_ _05912_ _05742_ _05728_ _06114_ VDD VSS AOI21_X1
X_29174_ _15315_ _06114_ _06115_ VDD VSS NOR2_X1
X_29175_ _05718_ _05810_ _05841_ _06116_ VDD VSS OAI21_X1
X_29176_ _05650_ _06111_ _06113_ _06115_ _06116_ _06117_ VDD
+ VSS OAI221_X1
X_29177_ _05802_ _05733_ _06118_ VDD VSS NAND2_X1
X_29178_ _05783_ _05748_ _05728_ _06119_ VDD VSS OAI21_X1
X_29179_ _05634_ _05742_ net1062 _05693_ _06120_ VDD VSS AOI22_X2
X_29180_ _06118_ _06119_ _06120_ _15308_ _06121_ VDD VSS OAI22_X1
X_29181_ _05532_ _05740_ _06122_ VDD VSS NOR2_X1
X_29182_ _05794_ _06122_ _06123_ VDD VSS OR2_X1
X_29183_ _15309_ _15318_ _05742_ _06124_ VDD VSS NOR3_X1
X_29184_ _05782_ _06124_ _06125_ VDD VSS NOR2_X1
X_29185_ _05715_ _06121_ _06123_ _06125_ _06126_ VDD VSS AOI22_X1
X_29186_ _05851_ _06117_ _06126_ _06127_ VDD VSS AOI21_X1
X_29187_ _06110_ _06127_ _06090_ _00158_ VDD VSS OR3_X2
X_29188_ _05883_ _05662_ _15292_ _05724_ _15290_ _06128_ VDD
+ VSS AOI221_X2
X_29189_ _05912_ _05679_ _15299_ _06129_ VDD VSS AOI21_X1
X_29190_ _06128_ _06129_ net95 _06130_ VDD VSS OAI21_X1
X_29191_ _05673_ _05810_ _05728_ _05987_ _15315_ _06131_ VDD
+ VSS OAI221_X1
X_29192_ _05747_ _06130_ _06131_ _06132_ VDD VSS AND3_X1
X_29193_ net91 _05644_ _05692_ _15299_ _05822_ net832 _06133_
+ VDD VSS OAI222_X2
X_29194_ _05665_ _05738_ _05773_ _06134_ VDD VSS NAND3_X1
X_29195_ _06134_ _05908_ _05802_ _06135_ VDD VSS OAI21_X1
X_29196_ _06133_ _06135_ _05672_ _06136_ VDD VSS MUX2_X1
X_29197_ _05762_ _06136_ _06137_ VDD VSS AND2_X1
X_29198_ net1109 _05912_ _06138_ VDD VSS NAND2_X1
X_29199_ net95 _05724_ _05754_ _06139_ VDD VSS OAI21_X1
X_29200_ _05718_ _06138_ _06139_ _06140_ VDD VSS AOI21_X1
X_29201_ _05679_ _05703_ _05748_ _06141_ VDD VSS AOI21_X1
X_29202_ _05661_ _05662_ _15290_ _06142_ VDD VSS AOI21_X1
X_29203_ net95 _06141_ _06142_ _05672_ _06143_ VDD VSS OAI22_X1
X_29204_ _06017_ _06140_ _06143_ _06144_ VDD VSS OAI21_X1
X_29205_ _05966_ _06028_ _06145_ VDD VSS AND2_X1
X_29206_ _05549_ _05671_ _05644_ _06146_ VDD VSS NOR3_X1
X_29207_ _05692_ _05720_ _05717_ _06147_ VDD VSS OAI21_X1
X_29208_ _06146_ _06147_ _15299_ _06148_ VDD VSS AOI21_X1
X_29209_ _06145_ _06148_ net95 _05698_ _05680_ _06149_ VDD
+ VSS OAI221_X1
X_29210_ _05582_ _06144_ _06149_ _06150_ VDD VSS AND3_X1
X_29211_ _15318_ _05720_ _06151_ VDD VSS NOR2_X1
X_29212_ _06014_ _05654_ _05653_ _05727_ _05569_ _06152_ VDD
+ VSS AOI221_X2
X_29213_ _05693_ _06151_ _06152_ _06153_ VDD VSS OAI21_X1
X_29214_ _05634_ _05623_ _06154_ VDD VSS NAND2_X1
X_29215_ _15304_ _06154_ _05719_ _06155_ VDD VSS MUX2_X1
X_29216_ _05717_ _06155_ _05622_ _06156_ VDD VSS AOI21_X2
X_29217_ _05698_ _05642_ _05620_ _06157_ VDD VSS MUX2_X1
X_29218_ _05693_ _05658_ _05703_ _06157_ _05734_ _05624_ _06158_
+ VDD VSS OAI33_X1
X_29219_ _05714_ _05702_ _05898_ _06159_ VDD VSS OAI21_X1
X_29220_ _06158_ _06159_ _06160_ VDD VSS NOR2_X1
X_29221_ _05679_ _05821_ _05639_ _06161_ VDD VSS MUX2_X1
X_29222_ net95 _06161_ _06162_ VDD VSS NAND2_X1
X_29223_ _05676_ _06153_ _06156_ _06160_ _06162_ _06163_ VDD
+ VSS AOI221_X2
X_29224_ _05830_ _05644_ _05876_ _06114_ _05802_ _06164_ VDD
+ VSS OAI221_X1
X_29225_ _05733_ _06164_ _06165_ VDD VSS AND2_X1
X_29226_ _05649_ _05794_ _06122_ _05701_ _05642_ _06166_ VDD
+ VSS OAI221_X1
X_29227_ _06048_ _06166_ _06167_ VDD VSS NAND2_X1
X_29228_ _05746_ _06165_ _06167_ _06168_ VDD VSS OAI21_X1
X_29229_ _05566_ _05694_ _05803_ _06169_ VDD VSS NAND3_X1
X_29230_ _05733_ _05806_ _06169_ _06170_ VDD VSS NAND3_X1
X_29231_ _05624_ _05734_ net748 _06171_ VDD VSS OAI21_X1
X_29232_ _05693_ _06102_ _06171_ _05566_ _15292_ _06172_ VDD
+ VSS OAI221_X2
X_29233_ _05576_ _05585_ _05589_ _06170_ _06172_ _06173_ VDD
+ VSS AOI221_X2
X_29234_ _06132_ _06137_ _06150_ _06163_ _06168_ _06173_ _00159_
+ VDD VSS OAI33_X1
X_29235_ dcnt\[0\] _06174_ VDD VSS BUF_X1
X_29236_ dcnt\[2\] _06175_ VDD VSS BUF_X1
X_29237_ dcnt\[1\] dcnt\[3\] _06175_ _06176_ VDD VSS NOR3_X1
X_29238_ _06797_ _06174_ _06176_ _00160_ VDD VSS AND3_X1
X_29239_ _06598_ sa00_sr\[0\] _00185_ VDD VSS XOR2_X2
X_29240_ _06614_ net570 _00186_ VDD VSS XOR2_X2
X_29241_ _06630_ _09088_ _00187_ VDD VSS XOR2_X2
X_29242_ _06649_ _09186_ _00188_ VDD VSS XOR2_X2
X_29243_ _06666_ _09162_ _00189_ VDD VSS XOR2_X2
X_29244_ _06683_ _09065_ _00190_ VDD VSS XOR2_X2
X_29245_ _06701_ _09154_ _00191_ VDD VSS XOR2_X2
X_29246_ _06706_ _08978_ _00192_ VDD VSS XOR2_X2
X_29247_ net883 net894 _00281_ VDD VSS XOR2_X1
X_29248_ net1184 sa01_sr\[1\] _00282_ VDD VSS XOR2_X1
X_29249_ _06638_ _09835_ _00283_ VDD VSS XOR2_X1
X_29250_ _06657_ _09868_ _00284_ VDD VSS XOR2_X1
X_29251_ _06673_ _09813_ _00285_ VDD VSS XOR2_X1
X_29252_ _06688_ _09789_ _00286_ VDD VSS XOR2_X2
X_29253_ _06697_ _09798_ _00287_ VDD VSS XOR2_X1
X_29254_ _06711_ _09712_ _00288_ VDD VSS XOR2_X1
X_29255_ net733 _10439_ _00241_ VDD VSS XOR2_X2
X_29256_ net738 net553 _00242_ VDD VSS XOR2_X2
X_29257_ _06637_ _10550_ _00243_ VDD VSS XOR2_X2
X_29258_ _06656_ _10535_ _00244_ VDD VSS XOR2_X2
X_29259_ _06672_ _10527_ _00245_ VDD VSS XOR2_X1
X_29260_ _06687_ _10516_ _00246_ VDD VSS XOR2_X1
X_29261_ _06696_ _10505_ _00247_ VDD VSS XOR2_X2
X_29262_ _06710_ _10432_ _00248_ VDD VSS XOR2_X2
X_29263_ net737 sa03_sr\[0\] _00209_ VDD VSS XOR2_X2
X_29264_ _06619_ _11165_ _00210_ VDD VSS XOR2_X2
X_29265_ _06635_ _11219_ _00211_ VDD VSS XOR2_X2
X_29266_ _06654_ _11245_ _00212_ VDD VSS XOR2_X2
X_29267_ _06670_ _11265_ _00213_ VDD VSS XOR2_X2
X_29268_ _06685_ _11202_ _00214_ VDD VSS XOR2_X2
X_29269_ _06699_ _11187_ _00215_ VDD VSS XOR2_X2
X_29270_ _06708_ _11119_ _00216_ VDD VSS XOR2_X2
X_29271_ _06241_ _08986_ _00177_ VDD VSS XOR2_X2
X_29272_ _06255_ net537 _00178_ VDD VSS XOR2_X2
X_29273_ _06296_ _09040_ _00179_ VDD VSS XOR2_X2
X_29274_ _06221_ _09092_ _00180_ VDD VSS XOR2_X2
X_29275_ _06281_ _09161_ _00181_ VDD VSS XOR2_X2
X_29276_ _06269_ _09070_ _00182_ VDD VSS XOR2_X2
X_29277_ _06575_ _09066_ _00183_ VDD VSS XOR2_X2
X_29278_ _06587_ _08979_ _00184_ VDD VSS XOR2_X2
X_29279_ _06242_ _09720_ _00273_ VDD VSS XOR2_X2
X_29280_ _06256_ sa11_sr\[1\] _00274_ VDD VSS XOR2_X1
X_29281_ _06297_ _09762_ _00275_ VDD VSS XOR2_X2
X_29282_ _06222_ _09839_ _00276_ VDD VSS XOR2_X2
X_29283_ _06282_ _09808_ _00277_ VDD VSS XOR2_X2
X_29284_ _06270_ _09785_ _00278_ VDD VSS XOR2_X2
X_29285_ _06576_ _09786_ _00279_ VDD VSS XOR2_X2
X_29286_ _06588_ net562 _00280_ VDD VSS XOR2_X2
X_29287_ _06247_ net488 _00233_ VDD VSS XOR2_X2
X_29288_ _06260_ net788 _00234_ VDD VSS XOR2_X2
X_29289_ _06299_ _10478_ _00235_ VDD VSS XOR2_X2
X_29290_ _06228_ _10539_ _00236_ VDD VSS XOR2_X2
X_29291_ _06284_ _10526_ _00237_ VDD VSS XOR2_X2
X_29292_ _06272_ _10515_ _00238_ VDD VSS XOR2_X2
X_29293_ _06578_ _10502_ _00239_ VDD VSS XOR2_X2
X_29294_ _06590_ net611 _00240_ VDD VSS XOR2_X2
X_29295_ net785 net544 _00201_ VDD VSS XOR2_X2
X_29296_ net779 sa10_sub\[1\] _00202_ VDD VSS XOR2_X2
X_29297_ _06295_ _11158_ _00203_ VDD VSS XOR2_X2
X_29298_ _06229_ _11223_ _00204_ VDD VSS XOR2_X2
X_29299_ _06285_ _11249_ _00205_ VDD VSS XOR2_X2
X_29300_ _06268_ _11201_ _00206_ VDD VSS XOR2_X2
X_29301_ _06574_ _11186_ _00207_ VDD VSS XOR2_X2
X_29302_ _06586_ _11120_ _00208_ VDD VSS XOR2_X2
X_29303_ _06450_ _09006_ _00169_ VDD VSS XOR2_X2
X_29304_ _06465_ net641 _00170_ VDD VSS XOR2_X2
X_29305_ _06480_ _09041_ _00171_ VDD VSS XOR2_X2
X_29306_ _06510_ _09089_ _00172_ VDD VSS XOR2_X2
X_29307_ _06527_ _09187_ _00173_ VDD VSS XOR2_X2
X_29308_ _06542_ _09165_ _00174_ VDD VSS XOR2_X2
X_29309_ _06555_ _09067_ _00175_ VDD VSS XOR2_X2
X_29310_ _06564_ _09151_ _00176_ VDD VSS XOR2_X2
X_29311_ _06451_ net767 _00257_ VDD VSS XOR2_X2
X_29312_ _06466_ sa21_sr\[1\] _00258_ VDD VSS XOR2_X2
X_29313_ _06483_ _09763_ _00259_ VDD VSS XOR2_X2
X_29314_ _06511_ _09836_ _00260_ VDD VSS XOR2_X2
X_29315_ _06528_ _09869_ _00261_ VDD VSS XOR2_X2
X_29316_ _06543_ _09814_ _00262_ VDD VSS XOR2_X2
X_29317_ _06556_ _09787_ _00263_ VDD VSS XOR2_X2
X_29318_ _06565_ _09796_ _00264_ VDD VSS XOR2_X2
X_29319_ _06456_ net679 _00225_ VDD VSS XOR2_X2
X_29320_ _06470_ net791 _00226_ VDD VSS XOR2_X2
X_29321_ _06482_ _10479_ _00227_ VDD VSS XOR2_X2
X_29322_ _06516_ _10551_ _00228_ VDD VSS XOR2_X2
X_29323_ _06532_ _10536_ _00229_ VDD VSS XOR2_X2
X_29324_ _06545_ _10523_ _00230_ VDD VSS XOR2_X2
X_29325_ _06558_ _10513_ _00231_ VDD VSS XOR2_X2
X_29326_ _06567_ _10503_ _00232_ VDD VSS XOR2_X2
X_29327_ _06457_ _11136_ _00193_ VDD VSS XOR2_X2
X_29328_ _06471_ net904 _00194_ VDD VSS XOR2_X2
X_29329_ _06479_ _11159_ _00195_ VDD VSS XOR2_X2
X_29330_ _06517_ _11220_ _00196_ VDD VSS XOR2_X2
X_29331_ _06533_ _11246_ _00197_ VDD VSS XOR2_X2
X_29332_ _06546_ _11261_ _00198_ VDD VSS XOR2_X2
X_29333_ _06554_ _11199_ _00199_ VDD VSS XOR2_X2
X_29334_ _06563_ _11183_ _00200_ VDD VSS XOR2_X2
X_29335_ _06325_ net634 _00161_ VDD VSS XOR2_X2
X_29336_ _06340_ _08987_ _00162_ VDD VSS XOR2_X2
X_29337_ _06355_ _09037_ _00163_ VDD VSS XOR2_X2
X_29338_ _06386_ _09094_ _00164_ VDD VSS XOR2_X2
X_29339_ _06403_ _09190_ _00165_ VDD VSS XOR2_X2
X_29340_ _06417_ _09166_ _00166_ VDD VSS XOR2_X2
X_29341_ _06431_ _09071_ _00167_ VDD VSS XOR2_X2
X_29342_ _06439_ _09152_ _00168_ VDD VSS XOR2_X2
X_29343_ _06326_ net507 _00249_ VDD VSS XOR2_X2
X_29344_ _06341_ net607 _00250_ VDD VSS XOR2_X2
X_29345_ _06356_ _09759_ _00251_ VDD VSS XOR2_X2
X_29346_ _06387_ _09841_ _00252_ VDD VSS XOR2_X2
X_29347_ _06404_ _09872_ _00253_ VDD VSS XOR2_X2
X_29348_ _06418_ _09809_ _00254_ VDD VSS XOR2_X2
X_29349_ _06432_ _09790_ _00255_ VDD VSS XOR2_X2
X_29350_ _06440_ _09799_ _00256_ VDD VSS XOR2_X2
X_29351_ _06330_ _10453_ _00217_ VDD VSS XOR2_X2
X_29352_ _06346_ sa31_sub\[1\] _00218_ VDD VSS XOR2_X2
X_29353_ _06358_ _10475_ _00219_ VDD VSS XOR2_X2
X_29354_ _06392_ _10554_ _00220_ VDD VSS XOR2_X2
X_29355_ _06406_ _10541_ _00221_ VDD VSS XOR2_X2
X_29356_ _06420_ _10524_ _00222_ VDD VSS XOR2_X2
X_29357_ _06434_ _10512_ _00223_ VDD VSS XOR2_X2
X_29358_ _06442_ _10506_ _00224_ VDD VSS XOR2_X2
X_29359_ net560 sa32_sub\[0\] _00265_ VDD VSS XOR2_X2
X_29360_ net1064 net906 _00266_ VDD VSS XOR2_X2
X_29361_ _06354_ _11164_ _00267_ VDD VSS XOR2_X2
X_29362_ _06393_ _11225_ _00268_ VDD VSS XOR2_X2
X_29363_ _06407_ _11250_ _00269_ VDD VSS XOR2_X2
X_29364_ _06416_ _11262_ _00270_ VDD VSS XOR2_X2
X_29365_ _06430_ _11198_ _00271_ VDD VSS XOR2_X2
X_29366_ u0.tmp_w\[7\] _11184_ _00272_ VDD VSS XOR2_X2
X_29367_ text_in_r\[0\] net217 _06776_ _00489_ VDD VSS MUX2_X1
X_29368_ text_in_r\[100\] net218 _06776_ _00490_ VDD VSS MUX2_X1
X_29369_ text_in_r\[101\] net219 _06776_ _00491_ VDD VSS MUX2_X1
X_29370_ text_in_r\[102\] net220 _06776_ _00492_ VDD VSS MUX2_X1
X_29371_ _06771_ _06177_ VDD VSS BUF_X4
X_29372_ text_in_r\[103\] net221 _06177_ _00493_ VDD VSS MUX2_X1
X_29373_ text_in_r\[104\] net222 _06177_ _00494_ VDD VSS MUX2_X1
X_29374_ text_in_r\[105\] net223 _06177_ _00495_ VDD VSS MUX2_X1
X_29375_ text_in_r\[106\] net224 _06177_ _00496_ VDD VSS MUX2_X1
X_29376_ text_in_r\[107\] net225 _06177_ _00497_ VDD VSS MUX2_X1
X_29377_ text_in_r\[108\] net226 _06177_ _00498_ VDD VSS MUX2_X1
X_29378_ text_in_r\[109\] net227 _06177_ _00499_ VDD VSS MUX2_X1
X_29379_ text_in_r\[10\] net228 _06177_ _00500_ VDD VSS MUX2_X1
X_29380_ text_in_r\[110\] net229 _06177_ _00501_ VDD VSS MUX2_X1
X_29381_ text_in_r\[111\] net230 _06177_ _00502_ VDD VSS MUX2_X1
X_29382_ _06771_ _06178_ VDD VSS BUF_X4
X_29383_ text_in_r\[112\] net231 _06178_ _00503_ VDD VSS MUX2_X1
X_29384_ text_in_r\[113\] net232 _06178_ _00504_ VDD VSS MUX2_X1
X_29385_ text_in_r\[114\] net233 _06178_ _00505_ VDD VSS MUX2_X1
X_29386_ text_in_r\[115\] net234 _06178_ _00506_ VDD VSS MUX2_X1
X_29387_ text_in_r\[116\] net235 _06178_ _00507_ VDD VSS MUX2_X1
X_29388_ text_in_r\[117\] net236 _06178_ _00508_ VDD VSS MUX2_X1
X_29389_ text_in_r\[118\] net237 _06178_ _00509_ VDD VSS MUX2_X1
X_29390_ text_in_r\[119\] net238 _06178_ _00510_ VDD VSS MUX2_X1
X_29391_ text_in_r\[11\] net239 _06178_ _00511_ VDD VSS MUX2_X1
X_29392_ text_in_r\[120\] net240 _06178_ _00512_ VDD VSS MUX2_X1
X_29393_ _06401_ _06179_ VDD VSS BUF_X4
X_29394_ _06179_ _06180_ VDD VSS BUF_X4
X_29395_ text_in_r\[121\] net241 _06180_ _00513_ VDD VSS MUX2_X1
X_29396_ text_in_r\[122\] net242 _06180_ _00514_ VDD VSS MUX2_X1
X_29397_ text_in_r\[123\] net243 _06180_ _00515_ VDD VSS MUX2_X1
X_29398_ text_in_r\[124\] net244 _06180_ _00516_ VDD VSS MUX2_X1
X_29399_ text_in_r\[125\] net245 _06180_ _00517_ VDD VSS MUX2_X1
X_29400_ text_in_r\[126\] net246 _06180_ _00518_ VDD VSS MUX2_X1
X_29401_ text_in_r\[127\] net247 _06180_ _00519_ VDD VSS MUX2_X1
X_29402_ text_in_r\[12\] net248 _06180_ _00520_ VDD VSS MUX2_X1
X_29403_ text_in_r\[13\] net249 _06180_ _00521_ VDD VSS MUX2_X1
X_29404_ text_in_r\[14\] net250 _06180_ _00522_ VDD VSS MUX2_X1
X_29405_ _06179_ _06181_ VDD VSS CLKBUF_X3
X_29406_ text_in_r\[15\] net251 _06181_ _00523_ VDD VSS MUX2_X1
X_29407_ text_in_r\[16\] net252 _06181_ _00524_ VDD VSS MUX2_X1
X_29408_ text_in_r\[17\] net253 _06181_ _00525_ VDD VSS MUX2_X1
X_29409_ text_in_r\[18\] net254 _06181_ _00526_ VDD VSS MUX2_X1
X_29410_ _13936_ net255 _06181_ _00527_ VDD VSS MUX2_X1
X_29411_ text_in_r\[1\] net256 _06181_ _00528_ VDD VSS MUX2_X1
X_29412_ text_in_r\[20\] net257 _06181_ _00529_ VDD VSS MUX2_X1
X_29413_ text_in_r\[21\] net258 _06181_ _00530_ VDD VSS MUX2_X1
X_29414_ text_in_r\[22\] net259 _06181_ _00531_ VDD VSS MUX2_X1
X_29415_ text_in_r\[23\] net260 _06181_ _00532_ VDD VSS MUX2_X1
X_29416_ _06179_ _06182_ VDD VSS BUF_X4
X_29417_ text_in_r\[24\] net261 _06182_ _00533_ VDD VSS MUX2_X1
X_29418_ text_in_r\[25\] net262 _06182_ _00534_ VDD VSS MUX2_X1
X_29419_ text_in_r\[26\] net263 _06182_ _00535_ VDD VSS MUX2_X1
X_29420_ text_in_r\[27\] net264 _06182_ _00536_ VDD VSS MUX2_X1
X_29421_ text_in_r\[28\] net265 _06182_ _00537_ VDD VSS MUX2_X1
X_29422_ text_in_r\[29\] net266 _06182_ _00538_ VDD VSS MUX2_X1
X_29423_ text_in_r\[2\] net267 _06182_ _00539_ VDD VSS MUX2_X1
X_29424_ text_in_r\[30\] net268 _06182_ _00540_ VDD VSS MUX2_X1
X_29425_ text_in_r\[31\] net269 _06182_ _00541_ VDD VSS MUX2_X1
X_29426_ text_in_r\[32\] net270 _06182_ _00542_ VDD VSS MUX2_X1
X_29427_ _06179_ _06183_ VDD VSS BUF_X4
X_29428_ text_in_r\[33\] net271 _06183_ _00543_ VDD VSS MUX2_X1
X_29429_ text_in_r\[34\] net272 _06183_ _00544_ VDD VSS MUX2_X1
X_29430_ _04941_ net273 _06183_ _00545_ VDD VSS MUX2_X1
X_29431_ text_in_r\[36\] net274 _06183_ _00546_ VDD VSS MUX2_X1
X_29432_ text_in_r\[37\] net275 _06183_ _00547_ VDD VSS MUX2_X1
X_29433_ text_in_r\[38\] net276 _06183_ _00548_ VDD VSS MUX2_X1
X_29434_ text_in_r\[39\] net277 _06183_ _00549_ VDD VSS MUX2_X1
X_29435_ text_in_r\[3\] net278 _06183_ _00550_ VDD VSS MUX2_X1
X_29436_ text_in_r\[40\] net279 _06183_ _00551_ VDD VSS MUX2_X1
X_29437_ text_in_r\[41\] net280 _06183_ _00552_ VDD VSS MUX2_X1
X_29438_ _06179_ _06184_ VDD VSS BUF_X4
X_29439_ text_in_r\[42\] net281 _06184_ _00553_ VDD VSS MUX2_X1
X_29440_ _02333_ net282 _06184_ _00554_ VDD VSS MUX2_X1
X_29441_ text_in_r\[44\] net283 _06184_ _00555_ VDD VSS MUX2_X1
X_29442_ text_in_r\[45\] net284 _06184_ _00556_ VDD VSS MUX2_X1
X_29443_ text_in_r\[46\] net285 _06184_ _00557_ VDD VSS MUX2_X1
X_29444_ text_in_r\[47\] net286 _06184_ _00558_ VDD VSS MUX2_X1
X_29445_ text_in_r\[48\] net287 _06184_ _00559_ VDD VSS MUX2_X1
X_29446_ text_in_r\[49\] net288 _06184_ _00560_ VDD VSS MUX2_X1
X_29447_ text_in_r\[4\] net289 _06184_ _00561_ VDD VSS MUX2_X1
X_29448_ text_in_r\[50\] net290 _06184_ _00562_ VDD VSS MUX2_X1
X_29449_ _06179_ _06185_ VDD VSS BUF_X4
X_29450_ text_in_r\[51\] net291 _06185_ _00563_ VDD VSS MUX2_X1
X_29451_ text_in_r\[52\] net292 _06185_ _00564_ VDD VSS MUX2_X1
X_29452_ text_in_r\[53\] net293 _06185_ _00565_ VDD VSS MUX2_X1
X_29453_ text_in_r\[54\] net294 _06185_ _00566_ VDD VSS MUX2_X1
X_29454_ text_in_r\[55\] net295 _06185_ _00567_ VDD VSS MUX2_X1
X_29455_ text_in_r\[56\] net296 _06185_ _00568_ VDD VSS MUX2_X1
X_29456_ text_in_r\[57\] net297 _06185_ _00569_ VDD VSS MUX2_X1
X_29457_ text_in_r\[58\] net298 _06185_ _00570_ VDD VSS MUX2_X1
X_29458_ text_in_r\[59\] net299 _06185_ _00571_ VDD VSS MUX2_X1
X_29459_ text_in_r\[5\] net300 _06185_ _00572_ VDD VSS MUX2_X1
X_29460_ _06179_ _06186_ VDD VSS BUF_X4
X_29461_ text_in_r\[60\] net301 _06186_ _00573_ VDD VSS MUX2_X1
X_29462_ text_in_r\[61\] net302 _06186_ _00574_ VDD VSS MUX2_X1
X_29463_ text_in_r\[62\] net303 _06186_ _00575_ VDD VSS MUX2_X1
X_29464_ text_in_r\[63\] net304 _06186_ _00576_ VDD VSS MUX2_X1
X_29465_ text_in_r\[64\] net305 _06186_ _00577_ VDD VSS MUX2_X1
X_29466_ text_in_r\[65\] net306 _06186_ _00578_ VDD VSS MUX2_X1
X_29467_ text_in_r\[66\] net307 _06186_ _00579_ VDD VSS MUX2_X1
X_29468_ text_in_r\[67\] net308 _06186_ _00580_ VDD VSS MUX2_X1
X_29469_ text_in_r\[68\] net309 _06186_ _00581_ VDD VSS MUX2_X1
X_29470_ text_in_r\[69\] net310 _06186_ _00582_ VDD VSS MUX2_X1
X_29471_ _06179_ _06187_ VDD VSS BUF_X4
X_29472_ text_in_r\[6\] net311 _06187_ _00583_ VDD VSS MUX2_X1
X_29473_ text_in_r\[70\] net312 _06187_ _00584_ VDD VSS MUX2_X1
X_29474_ text_in_r\[71\] net313 _06187_ _00585_ VDD VSS MUX2_X1
X_29475_ text_in_r\[72\] net314 _06187_ _00586_ VDD VSS MUX2_X1
X_29476_ text_in_r\[73\] net315 _06187_ _00587_ VDD VSS MUX2_X1
X_29477_ text_in_r\[74\] net316 _06187_ _00588_ VDD VSS MUX2_X1
X_29478_ text_in_r\[75\] net317 _06187_ _00589_ VDD VSS MUX2_X1
X_29479_ text_in_r\[76\] net318 _06187_ _00590_ VDD VSS MUX2_X1
X_29480_ text_in_r\[77\] net319 _06187_ _00591_ VDD VSS MUX2_X1
X_29481_ text_in_r\[78\] net320 _06187_ _00592_ VDD VSS MUX2_X1
X_29482_ _06179_ _06188_ VDD VSS BUF_X4
X_29483_ text_in_r\[79\] net321 _06188_ _00593_ VDD VSS MUX2_X1
X_29484_ text_in_r\[7\] net322 _06188_ _00594_ VDD VSS MUX2_X1
X_29485_ text_in_r\[80\] net323 _06188_ _00595_ VDD VSS MUX2_X1
X_29486_ text_in_r\[81\] net324 _06188_ _00596_ VDD VSS MUX2_X1
X_29487_ text_in_r\[82\] net325 _06188_ _00597_ VDD VSS MUX2_X1
X_29488_ text_in_r\[83\] net326 _06188_ _00598_ VDD VSS MUX2_X1
X_29489_ text_in_r\[84\] net327 _06188_ _00599_ VDD VSS MUX2_X1
X_29490_ text_in_r\[85\] net328 _06188_ _00600_ VDD VSS MUX2_X1
X_29491_ text_in_r\[86\] net329 _06188_ _00601_ VDD VSS MUX2_X1
X_29492_ text_in_r\[87\] net330 _06188_ _00602_ VDD VSS MUX2_X1
X_29493_ _06179_ _06189_ VDD VSS BUF_X4
X_29494_ text_in_r\[88\] net331 _06189_ _00603_ VDD VSS MUX2_X1
X_29495_ text_in_r\[89\] net332 _06189_ _00604_ VDD VSS MUX2_X1
X_29496_ text_in_r\[8\] net333 _06189_ _00605_ VDD VSS MUX2_X1
X_29497_ text_in_r\[90\] net334 _06189_ _00606_ VDD VSS MUX2_X1
X_29498_ text_in_r\[91\] net335 _06189_ _00607_ VDD VSS MUX2_X1
X_29499_ text_in_r\[92\] net336 _06189_ _00608_ VDD VSS MUX2_X1
X_29500_ text_in_r\[93\] net337 _06189_ _00609_ VDD VSS MUX2_X1
X_29501_ text_in_r\[94\] net338 _06189_ _00610_ VDD VSS MUX2_X1
X_29502_ text_in_r\[95\] net339 _06189_ _00611_ VDD VSS MUX2_X1
X_29503_ text_in_r\[96\] net340 _06189_ _00612_ VDD VSS MUX2_X1
X_29504_ text_in_r\[97\] net341 _06771_ _00613_ VDD VSS MUX2_X1
X_29505_ text_in_r\[98\] net342 _06771_ _00614_ VDD VSS MUX2_X1
X_29506_ _03651_ net343 _06771_ _00615_ VDD VSS MUX2_X1
X_29507_ text_in_r\[9\] net344 _06771_ _00616_ VDD VSS MUX2_X1
X_29508_ net216 _06190_ VDD VSS INV_X1
X_29509_ dcnt\[3\] _06191_ VDD VSS INV_X1
X_29510_ dcnt\[1\] _06174_ _06192_ VDD VSS OR2_X1
X_29511_ _06191_ _06175_ _06192_ _06193_ VDD VSS NOR3_X1
X_29512_ _06193_ _06192_ _06175_ _06194_ VDD VSS AOI21_X1
X_29513_ _06772_ _06190_ _06194_ _00487_ VDD VSS NOR3_X1
X_29514_ u0.r0.rcnt\[2\] _15330_ _06195_ VDD VSS XNOR2_X1
X_29515_ _06776_ _15328_ _06195_ _06196_ VDD VSS AOI21_X1
X_29516_ _06196_ _00617_ VDD VSS INV_X1
X_29517_ u0.r0.rcnt\[2\] _15330_ _06197_ VDD VSS XOR2_X2
X_29518_ _06771_ _06197_ _06198_ VDD VSS NOR2_X1
X_29519_ u0.r0.rcnt\[2\] u0.r0.rcnt\[1\] u0.r0.rcnt\[0\] _06199_
+ VDD VSS NAND3_X1
X_29520_ u0.r0.rcnt\[3\] _06199_ _06200_ VDD VSS XOR2_X2
X_29521_ _15323_ _06200_ _06201_ VDD VSS NAND2_X1
X_29522_ _06201_ _06200_ u0.r0.rcnt_next\[1\] _06202_ VDD
+ VSS OAI21_X1
X_29523_ _06198_ _06202_ _00618_ VDD VSS AND2_X1
X_29524_ _15323_ _15326_ _06200_ _06203_ VDD VSS MUX2_X1
X_29525_ _06198_ _06203_ _00619_ VDD VSS AND2_X1
X_29526_ _15328_ _15324_ _06200_ _06204_ VDD VSS MUX2_X1
X_29527_ _06198_ _06204_ _00620_ VDD VSS AND2_X1
X_29528_ u0.r0.rcnt_next\[1\] _06197_ _06200_ _06205_ VDD
+ VSS OR3_X1
X_29529_ _15328_ _06197_ _06200_ _06206_ VDD VSS NAND3_X1
X_29530_ _06772_ _06205_ _06206_ _00621_ VDD VSS AOI21_X1
X_29531_ _06197_ _06200_ _06207_ VDD VSS XNOR2_X1
X_29532_ _06797_ _15323_ _06207_ _00622_ VDD VSS AND3_X1
X_29533_ _06401_ _06195_ _00627_ VDD VSS NOR2_X1
X_29534_ _06200_ _00627_ _06208_ VDD VSS AND2_X1
X_29535_ _15326_ _06208_ _00623_ VDD VSS AND2_X1
X_29536_ _15324_ _06208_ _00624_ VDD VSS AND2_X1
X_29537_ _06797_ u0.r0.rcnt_next\[0\] _00625_ VDD VSS AND2_X1
X_29538_ _06797_ u0.r0.rcnt_next\[1\] _00626_ VDD VSS AND2_X1
X_29539_ _06772_ _06200_ _00628_ VDD VSS NOR2_X1
X_29540_ _06721_ _06174_ _06176_ _06209_ VDD VSS OAI21_X1
X_29541_ net216 _06209_ _06210_ VDD VSS NAND2_X1
X_29542_ _06210_ _00485_ VDD VSS INV_X1
X_29543_ _06771_ dcnt\[1\] _06174_ _06211_ VDD VSS AOI21_X1
X_29544_ dcnt\[3\] _06175_ _06212_ VDD VSS NOR2_X1
X_29545_ _06211_ _06212_ _06192_ _06213_ VDD VSS OAI21_X1
X_29546_ net216 _06213_ _00486_ VDD VSS AND2_X1
X_29547_ dcnt\[1\] _06174_ _06175_ _06214_ VDD VSS NOR3_X1
X_29548_ _06721_ _06191_ _06214_ _06215_ VDD VSS OAI21_X1
X_29549_ net216 _06215_ _00488_ VDD VSS AND2_X1
X_29550_ _14658_ _14659_ _14660_ _14661_ VDD VSS HA_X1
X_29551_ _14658_ _14659_ _14662_ _14663_ VDD VSS HA_X1
X_29552_ _14658_ _14664_ _14665_ _14666_ VDD VSS HA_X1
X_29553_ _14658_ _14664_ _14667_ _14668_ VDD VSS HA_X1
X_29554_ _14669_ _14659_ _14670_ _14671_ VDD VSS HA_X1
X_29555_ _14669_ _14659_ _14672_ _14673_ VDD VSS HA_X1
X_29556_ _14669_ _14664_ _14674_ _14675_ VDD VSS HA_X1
X_29557_ _14669_ _14664_ _14676_ _14677_ VDD VSS HA_X1
X_29558_ net783 _14678_ _14679_ _14680_ VDD VSS HA_X1
X_29559_ _14678_ net783 _14681_ _14682_ VDD VSS HA_X1
X_29560_ net783 _14683_ _14684_ _14685_ VDD VSS HA_X1
X_29561_ _14683_ _14658_ _14686_ _14687_ VDD VSS HA_X1
X_29562_ _14669_ _14678_ _14688_ _14689_ VDD VSS HA_X1
X_29563_ _14669_ _14678_ _14690_ _14691_ VDD VSS HA_X1
X_29564_ _14693_ _14692_ _14694_ _14695_ VDD VSS HA_X1
X_29565_ _14692_ _14693_ _14696_ _14697_ VDD VSS HA_X1
X_29566_ _14692_ _14698_ _14699_ _14700_ VDD VSS HA_X1
X_29567_ _14698_ _14692_ _14701_ _14702_ VDD VSS HA_X1
X_29568_ _14703_ _14693_ _14704_ _14705_ VDD VSS HA_X1
X_29569_ _14703_ _14693_ _14706_ _14707_ VDD VSS HA_X1
X_29570_ _14703_ _14698_ _14708_ _14709_ VDD VSS HA_X1
X_29571_ _14703_ _14698_ _14710_ _14711_ VDD VSS HA_X1
X_29572_ net15 _14712_ _14713_ _14714_ VDD VSS HA_X1
X_29573_ net15 _14712_ _14715_ _14716_ VDD VSS HA_X1
X_29574_ net15 _14717_ _14718_ _14719_ VDD VSS HA_X1
X_29575_ _14692_ _14717_ _14720_ _14721_ VDD VSS HA_X1
X_29576_ _14703_ _14712_ _14722_ _14723_ VDD VSS HA_X1
X_29577_ _14703_ _14712_ _14724_ _14725_ VDD VSS HA_X1
X_29578_ _14726_ _14727_ _14728_ _14729_ VDD VSS HA_X1
X_29579_ _14727_ _14726_ _14730_ _14731_ VDD VSS HA_X1
X_29580_ _14732_ _14726_ _14733_ _14734_ VDD VSS HA_X1
X_29581_ _14732_ _14726_ _14735_ _14736_ VDD VSS HA_X1
X_29582_ _14727_ _14737_ _14738_ _14739_ VDD VSS HA_X1
X_29583_ _14727_ _14737_ _14740_ _14741_ VDD VSS HA_X1
X_29584_ _14737_ _14732_ _14742_ _14743_ VDD VSS HA_X1
X_29585_ _14737_ _14732_ _14744_ _14745_ VDD VSS HA_X1
X_29586_ net29 _14746_ _14747_ _14748_ VDD VSS HA_X1
X_29587_ _14746_ _14726_ _14749_ _14750_ VDD VSS HA_X1
X_29588_ net29 _14751_ _14752_ _14753_ VDD VSS HA_X1
X_29589_ net29 _14751_ _14754_ _14755_ VDD VSS HA_X1
X_29590_ _14737_ _14746_ _14756_ _14757_ VDD VSS HA_X1
X_29591_ _14737_ _14746_ _14758_ _14759_ VDD VSS HA_X1
X_29592_ _14761_ _14760_ _14762_ _14763_ VDD VSS HA_X1
X_29593_ _14760_ _14761_ _14764_ _14765_ VDD VSS HA_X1
X_29594_ _14760_ _14766_ _14767_ _14768_ VDD VSS HA_X1
X_29595_ _14760_ _14766_ _14769_ _14770_ VDD VSS HA_X1
X_29596_ _14771_ _14761_ _14772_ _14773_ VDD VSS HA_X1
X_29597_ _14771_ _14761_ _14774_ _14775_ VDD VSS HA_X1
X_29598_ _14771_ _14766_ _14776_ _14777_ VDD VSS HA_X1
X_29599_ _14771_ _14766_ _14778_ _14779_ VDD VSS HA_X1
X_29600_ _14780_ _14760_ _14781_ _14782_ VDD VSS HA_X1
X_29601_ _14780_ _14760_ _14783_ _14784_ VDD VSS HA_X1
X_29602_ _14785_ _14760_ _14786_ _14787_ VDD VSS HA_X1
X_29603_ _14785_ _14760_ _14788_ _14789_ VDD VSS HA_X1
X_29604_ _14785_ _14771_ _14790_ _14791_ VDD VSS HA_X1
X_29605_ _14785_ _14771_ _14792_ _14793_ VDD VSS HA_X1
X_29606_ _14794_ _14795_ _14796_ _14797_ VDD VSS HA_X1
X_29607_ _14794_ _14795_ _14798_ _14799_ VDD VSS HA_X1
X_29608_ _14794_ _14800_ _14801_ _14802_ VDD VSS HA_X1
X_29609_ _14803_ _14795_ _14804_ _14805_ VDD VSS HA_X1
X_29610_ _14803_ _14795_ _14806_ _14807_ VDD VSS HA_X1
X_29611_ _14803_ _14800_ _14808_ _14809_ VDD VSS HA_X1
X_29612_ _14800_ _14803_ _14810_ _14811_ VDD VSS HA_X1
X_29613_ _14812_ _14795_ _14813_ _14814_ VDD VSS HA_X1
X_29614_ _14812_ _14800_ _14815_ _14816_ VDD VSS HA_X1
X_29615_ _14812_ _14800_ _14817_ _14818_ VDD VSS HA_X1
X_29616_ _14819_ _14795_ _14820_ _14821_ VDD VSS HA_X1
X_29617_ _14819_ _14795_ _14822_ _14823_ VDD VSS HA_X1
X_29618_ _14819_ net860 _14824_ _14825_ VDD VSS HA_X1
X_29619_ _14826_ _10003_ _14828_ _14829_ VDD VSS HA_X1
X_29620_ _14826_ _10003_ _14830_ _14831_ VDD VSS HA_X1
X_29621_ _14826_ _09736_ _14833_ _14834_ VDD VSS HA_X1
X_29622_ _14835_ _10003_ _14836_ _14837_ VDD VSS HA_X1
X_29623_ _10003_ _14835_ _14838_ _14839_ VDD VSS HA_X1
X_29624_ _14835_ _09736_ _14840_ _14841_ VDD VSS HA_X1
X_29625_ _14835_ _09736_ _14842_ _14843_ VDD VSS HA_X1
X_29626_ _14844_ _10003_ _14845_ _14846_ VDD VSS HA_X1
X_29627_ _14844_ net1050 _14847_ _14848_ VDD VSS HA_X1
X_29628_ _14844_ _09736_ _14849_ _14850_ VDD VSS HA_X1
X_29629_ _14851_ net617 _14852_ _14853_ VDD VSS HA_X1
X_29630_ _14851_ _10003_ _14854_ _14855_ VDD VSS HA_X1
X_29631_ _14851_ net1050 _14856_ _14857_ VDD VSS HA_X1
X_29632_ _14858_ _14859_ _14860_ _14861_ VDD VSS HA_X1
X_29633_ _14858_ _14859_ _14862_ _14863_ VDD VSS HA_X1
X_29634_ _14858_ _14864_ _14865_ _14866_ VDD VSS HA_X1
X_29635_ _14867_ _14859_ _14868_ _14869_ VDD VSS HA_X1
X_29636_ _14867_ _14859_ _14870_ _14871_ VDD VSS HA_X1
X_29637_ _14867_ _14864_ _14872_ _14873_ VDD VSS HA_X1
X_29638_ _14867_ _14864_ _14874_ _14875_ VDD VSS HA_X1
X_29639_ _14876_ _14859_ _14877_ _14878_ VDD VSS HA_X1
X_29640_ _14876_ _14864_ _14879_ _14880_ VDD VSS HA_X1
X_29641_ _14876_ _14864_ _14881_ _14882_ VDD VSS HA_X1
X_29642_ _14883_ _14859_ _14884_ _14885_ VDD VSS HA_X1
X_29643_ _14883_ _14859_ _14886_ _14887_ VDD VSS HA_X1
X_29644_ _14883_ _14864_ _14888_ _14889_ VDD VSS HA_X1
X_29645_ _14890_ _14891_ _14892_ _14893_ VDD VSS HA_X1
X_29646_ _14890_ _14891_ _14894_ _14895_ VDD VSS HA_X1
X_29647_ _14890_ _11131_ _14897_ _14898_ VDD VSS HA_X1
X_29648_ _14899_ _14891_ _14900_ _14901_ VDD VSS HA_X1
X_29649_ _14899_ _14891_ _14902_ _14903_ VDD VSS HA_X1
X_29650_ _14899_ _11131_ _14904_ _14905_ VDD VSS HA_X1
X_29651_ _11131_ _14899_ _14906_ _14907_ VDD VSS HA_X1
X_29652_ _14908_ _14891_ _14909_ _14910_ VDD VSS HA_X1
X_29653_ _14908_ net843 _14911_ _14912_ VDD VSS HA_X1
X_29654_ _14908_ net843 _14913_ _14914_ VDD VSS HA_X1
X_29655_ _14915_ _14891_ _14916_ _14917_ VDD VSS HA_X1
X_29656_ _14915_ _14891_ _14918_ _14919_ VDD VSS HA_X1
X_29657_ _14915_ net925 _14920_ _14921_ VDD VSS HA_X1
X_29658_ _14922_ _14923_ _14924_ _14925_ VDD VSS HA_X1
X_29659_ _14922_ _14923_ _14926_ _14927_ VDD VSS HA_X1
X_29660_ _14922_ _14928_ _14929_ _14930_ VDD VSS HA_X1
X_29661_ _14931_ _14923_ _14932_ _14933_ VDD VSS HA_X1
X_29662_ _14931_ _14923_ _14934_ _14935_ VDD VSS HA_X1
X_29663_ _14931_ _14928_ _14936_ _14937_ VDD VSS HA_X1
X_29664_ _14931_ _14928_ _14938_ _14939_ VDD VSS HA_X1
X_29665_ _14940_ _14923_ _14941_ _14942_ VDD VSS HA_X1
X_29666_ _14940_ _14928_ _14943_ _14944_ VDD VSS HA_X1
X_29667_ _14940_ _14928_ _14945_ _14946_ VDD VSS HA_X1
X_29668_ _14947_ _14923_ _14948_ _14949_ VDD VSS HA_X1
X_29669_ _14947_ _14923_ _14950_ _14951_ VDD VSS HA_X1
X_29670_ _14947_ net991 _14952_ _14953_ VDD VSS HA_X1
X_29671_ _14954_ _14955_ _14956_ _14957_ VDD VSS HA_X1
X_29672_ _14954_ _14955_ _14958_ _14959_ VDD VSS HA_X1
X_29673_ _12508_ _14954_ _14961_ _14962_ VDD VSS HA_X1
X_29674_ _14963_ _14955_ _14964_ _14965_ VDD VSS HA_X1
X_29675_ _14963_ _14955_ _14966_ _14967_ VDD VSS HA_X1
X_29676_ _14963_ _12508_ _14968_ _14969_ VDD VSS HA_X1
X_29677_ _14963_ _12508_ _14970_ _14971_ VDD VSS HA_X1
X_29678_ _14972_ _14955_ _14973_ _14974_ VDD VSS HA_X1
X_29679_ _14972_ _12508_ _14975_ _14976_ VDD VSS HA_X1
X_29680_ _14972_ _12508_ _14977_ _14978_ VDD VSS HA_X1
X_29681_ _14979_ _14955_ _14980_ _14981_ VDD VSS HA_X1
X_29682_ _14979_ _14955_ _14982_ _14983_ VDD VSS HA_X1
X_29683_ _14979_ _12508_ _14984_ _14985_ VDD VSS HA_X1
X_29684_ _14986_ _14987_ _14988_ _14989_ VDD VSS HA_X1
X_29685_ _14986_ _14987_ _14990_ _14991_ VDD VSS HA_X1
X_29686_ _14986_ _14992_ _14993_ _14994_ VDD VSS HA_X1
X_29687_ _14995_ _14987_ _14996_ _14997_ VDD VSS HA_X1
X_29688_ _14995_ _14987_ _14998_ _14999_ VDD VSS HA_X1
X_29689_ _14995_ _14992_ _15000_ _15001_ VDD VSS HA_X1
X_29690_ _14995_ _14992_ _15002_ _15003_ VDD VSS HA_X1
X_29691_ _15004_ _14987_ _15005_ _15006_ VDD VSS HA_X1
X_29692_ _15004_ _14992_ _15007_ _15008_ VDD VSS HA_X1
X_29693_ _15004_ _14992_ _15009_ _15010_ VDD VSS HA_X1
X_29694_ _15011_ _14987_ _15012_ _15013_ VDD VSS HA_X1
X_29695_ _15011_ net623 _15014_ _15015_ VDD VSS HA_X1
X_29696_ _15011_ _14992_ _15016_ _15017_ VDD VSS HA_X1
X_29697_ _15018_ _15019_ _15020_ _15021_ VDD VSS HA_X1
X_29698_ _15018_ _15019_ _15022_ _15023_ VDD VSS HA_X1
X_29699_ _15018_ _15024_ _15025_ _15026_ VDD VSS HA_X1
X_29700_ _15027_ _15019_ _15028_ _15029_ VDD VSS HA_X1
X_29701_ _15027_ _15019_ _15030_ _15031_ VDD VSS HA_X1
X_29702_ _15027_ _15024_ _15032_ _15033_ VDD VSS HA_X1
X_29703_ _15027_ _15024_ _15034_ _15035_ VDD VSS HA_X1
X_29704_ _15036_ _15019_ _15037_ _15038_ VDD VSS HA_X1
X_29705_ _15036_ _15024_ _15039_ _15040_ VDD VSS HA_X1
X_29706_ _15036_ _15024_ _15041_ _15042_ VDD VSS HA_X1
X_29707_ _15043_ _15019_ _15044_ _15045_ VDD VSS HA_X1
X_29708_ _15043_ _15019_ _15046_ _15047_ VDD VSS HA_X1
X_29709_ _15043_ _15024_ _15048_ _15049_ VDD VSS HA_X1
X_29710_ _15051_ _15050_ _15052_ _15053_ VDD VSS HA_X1
X_29711_ _15050_ _15051_ _15054_ _15055_ VDD VSS HA_X1
X_29712_ _15050_ _00946_ _15057_ _15058_ VDD VSS HA_X1
X_29713_ _15050_ _00946_ _15059_ _15060_ VDD VSS HA_X1
X_29714_ _15061_ _15051_ _15062_ _15063_ VDD VSS HA_X1
X_29715_ _15061_ _15051_ _15064_ _15065_ VDD VSS HA_X1
X_29716_ _00946_ _15061_ _15066_ _15067_ VDD VSS HA_X1
X_29717_ _15061_ _00946_ _15068_ _15069_ VDD VSS HA_X1
X_29718_ _15070_ _15051_ _15071_ _15072_ VDD VSS HA_X1
X_29719_ _15070_ net886 _15073_ _15074_ VDD VSS HA_X1
X_29720_ _15070_ _00946_ _15075_ _15076_ VDD VSS HA_X1
X_29721_ _15077_ _15051_ _15078_ _15079_ VDD VSS HA_X1
X_29722_ _15077_ _15051_ _15080_ _15081_ VDD VSS HA_X1
X_29723_ _15077_ net886 _15082_ _15083_ VDD VSS HA_X1
X_29724_ _15077_ net886 _15084_ _15085_ VDD VSS HA_X1
X_29725_ _15087_ _15086_ _15088_ _15089_ VDD VSS HA_X1
X_29726_ _15086_ _15087_ _15090_ _15091_ VDD VSS HA_X1
X_29727_ _15092_ _15086_ _15093_ _15094_ VDD VSS HA_X1
X_29728_ _15086_ _15092_ _15095_ _15096_ VDD VSS HA_X1
X_29729_ _15097_ _15087_ _15098_ _15099_ VDD VSS HA_X1
X_29730_ _15097_ _15087_ _15100_ _15101_ VDD VSS HA_X1
X_29731_ _15097_ _15092_ _15102_ _15103_ VDD VSS HA_X1
X_29732_ _15097_ _15092_ _15104_ _15105_ VDD VSS HA_X1
X_29733_ _15106_ _15087_ _15107_ _15108_ VDD VSS HA_X1
X_29734_ _15106_ net1072 _15109_ _15110_ VDD VSS HA_X1
X_29735_ _15106_ net1072 _15111_ _15112_ VDD VSS HA_X1
X_29736_ _15113_ _15087_ _15114_ _15115_ VDD VSS HA_X1
X_29737_ _15113_ _15087_ _15116_ _15117_ VDD VSS HA_X1
X_29738_ _15113_ _15092_ _15118_ _15119_ VDD VSS HA_X1
X_29739_ _15113_ net1072 _15120_ _15121_ VDD VSS HA_X1
X_29740_ _15122_ _15123_ _15124_ _15125_ VDD VSS HA_X1
X_29741_ _15122_ _15123_ _15126_ _15127_ VDD VSS HA_X1
X_29742_ _15122_ _15128_ _15129_ _15130_ VDD VSS HA_X1
X_29743_ _15122_ _15128_ _15131_ _15132_ VDD VSS HA_X1
X_29744_ _15133_ _15123_ _15134_ _15135_ VDD VSS HA_X1
X_29745_ _15133_ _15123_ _15136_ _15137_ VDD VSS HA_X1
X_29746_ _15133_ _15128_ _15138_ _15139_ VDD VSS HA_X1
X_29747_ _15133_ _15128_ _15140_ _15141_ VDD VSS HA_X1
X_29748_ _15142_ _15123_ _15143_ _15144_ VDD VSS HA_X1
X_29749_ _15142_ _15128_ _15145_ _15146_ VDD VSS HA_X1
X_29750_ _15142_ _15128_ _15147_ _15148_ VDD VSS HA_X1
X_29751_ _15149_ net127 _15150_ _15151_ VDD VSS HA_X1
X_29752_ _15149_ _15123_ _15152_ _15153_ VDD VSS HA_X1
X_29753_ _15149_ _15128_ _15154_ _15155_ VDD VSS HA_X1
X_29754_ _15149_ _15128_ _15156_ _15157_ VDD VSS HA_X1
X_29755_ _02972_ _15158_ _15160_ _15161_ VDD VSS HA_X1
X_29756_ _15158_ _02972_ _15162_ _15163_ VDD VSS HA_X1
X_29757_ _15164_ _15158_ _15165_ _15166_ VDD VSS HA_X1
X_29758_ _15158_ _15164_ _15167_ _15168_ VDD VSS HA_X1
X_29759_ _15169_ _02972_ _15170_ _15171_ VDD VSS HA_X1
X_29760_ _02972_ _15169_ _15172_ _15173_ VDD VSS HA_X1
X_29761_ _15164_ _15169_ _15174_ _15175_ VDD VSS HA_X1
X_29762_ _15169_ _15164_ _15176_ _15177_ VDD VSS HA_X1
X_29763_ _15178_ _02972_ _15179_ _15180_ VDD VSS HA_X1
X_29764_ _15178_ _15164_ _15181_ _15182_ VDD VSS HA_X1
X_29765_ _15178_ _15164_ _15183_ _15184_ VDD VSS HA_X1
X_29766_ _15185_ _02972_ _15186_ _15187_ VDD VSS HA_X1
X_29767_ _15185_ _02972_ _15188_ _15189_ VDD VSS HA_X1
X_29768_ _15185_ _15164_ _15190_ _15191_ VDD VSS HA_X1
X_29769_ _15185_ _15164_ _15192_ _15193_ VDD VSS HA_X1
X_29770_ _15194_ _15195_ _15196_ _15197_ VDD VSS HA_X1
X_29771_ _15194_ _15195_ _15198_ _15199_ VDD VSS HA_X1
X_29772_ _15194_ _03588_ _15201_ _15202_ VDD VSS HA_X1
X_29773_ _15203_ _15195_ _15204_ _15205_ VDD VSS HA_X1
X_29774_ _15195_ _15203_ _15206_ _15207_ VDD VSS HA_X1
X_29775_ _15203_ _03588_ _15208_ _15209_ VDD VSS HA_X1
X_29776_ _15203_ _03588_ _15210_ _15211_ VDD VSS HA_X1
X_29777_ _15212_ net136 _15213_ _15214_ VDD VSS HA_X1
X_29778_ _15212_ _03588_ _15215_ _15216_ VDD VSS HA_X1
X_29779_ _15212_ _03588_ _15217_ _15218_ VDD VSS HA_X1
X_29780_ _15219_ _15195_ _15220_ _15221_ VDD VSS HA_X1
X_29781_ _15219_ _15195_ _15222_ _15223_ VDD VSS HA_X1
X_29782_ _15219_ _03588_ _15224_ _15225_ VDD VSS HA_X1
X_29783_ _15226_ _15227_ _15228_ _15229_ VDD VSS HA_X1
X_29784_ _15226_ _15227_ _15230_ _15231_ VDD VSS HA_X1
X_29785_ _15226_ _15232_ _15233_ _15234_ VDD VSS HA_X1
X_29786_ _15235_ _15227_ _15236_ _15237_ VDD VSS HA_X1
X_29787_ _15235_ _15227_ _15238_ _15239_ VDD VSS HA_X1
X_29788_ _15235_ _15232_ _15240_ _15241_ VDD VSS HA_X1
X_29789_ _15235_ _15232_ _15242_ _15243_ VDD VSS HA_X1
X_29790_ _15244_ _15227_ _15245_ _15246_ VDD VSS HA_X1
X_29791_ _15244_ _15232_ _15247_ _15248_ VDD VSS HA_X1
X_29792_ _15244_ _15232_ _15249_ _15250_ VDD VSS HA_X1
X_29793_ _15251_ _15227_ _15252_ _15253_ VDD VSS HA_X1
X_29794_ _15251_ _15227_ _15254_ _15255_ VDD VSS HA_X1
X_29795_ _15251_ _15232_ _15256_ _15257_ VDD VSS HA_X1
X_29796_ _15258_ _15259_ _15260_ _15261_ VDD VSS HA_X1
X_29797_ _15258_ _15259_ _15262_ _15263_ VDD VSS HA_X1
X_29798_ _15258_ _15264_ _15265_ _15266_ VDD VSS HA_X1
X_29799_ _15259_ _15267_ _15268_ _15269_ VDD VSS HA_X1
X_29800_ _15267_ _15259_ _15270_ _15271_ VDD VSS HA_X1
X_29801_ _15267_ _15264_ _15272_ _15273_ VDD VSS HA_X1
X_29802_ _15267_ _15264_ _15274_ _15275_ VDD VSS HA_X1
X_29803_ _15276_ _15259_ _15277_ _15278_ VDD VSS HA_X1
X_29804_ _15276_ _15264_ _15279_ _15280_ VDD VSS HA_X1
X_29805_ _15276_ _15264_ _15281_ _15282_ VDD VSS HA_X1
X_29806_ _15283_ _15259_ _15284_ _15285_ VDD VSS HA_X1
X_29807_ _15283_ _15259_ _15286_ _15287_ VDD VSS HA_X1
X_29808_ _15283_ _15264_ _15288_ _15289_ VDD VSS HA_X1
X_29809_ _15290_ net749 _15292_ _15293_ VDD VSS HA_X1
X_29810_ _15290_ net749 _15294_ _15295_ VDD VSS HA_X1
X_29811_ _15290_ _15296_ _15297_ _15298_ VDD VSS HA_X1
X_29812_ _15299_ net749 _15300_ _15301_ VDD VSS HA_X1
X_29813_ _15299_ net749 _15302_ _15303_ VDD VSS HA_X1
X_29814_ _15299_ _15296_ _15304_ _15305_ VDD VSS HA_X1
X_29815_ _15299_ _15296_ _15306_ _15307_ VDD VSS HA_X1
X_29816_ _15308_ net1053 _15309_ _15310_ VDD VSS HA_X1
X_29817_ _15308_ _15296_ _15311_ _15312_ VDD VSS HA_X1
X_29818_ _15308_ _15296_ _15313_ _15314_ VDD VSS HA_X1
X_29819_ _15315_ net1053 _15316_ _15317_ VDD VSS HA_X1
X_29820_ _15315_ net748 _15318_ _15319_ VDD VSS HA_X1
X_29821_ _15315_ _15296_ _15320_ _15321_ VDD VSS HA_X1
X_29822_ u0.r0.rcnt_next\[0\] _15322_ _15323_ u0.r0.rcnt_next\[1\]
+ VDD VSS HA_X1
X_29823_ u0.r0.rcnt_next\[0\] u0.r0.rcnt\[1\] _15324_ _15325_
+ VDD VSS HA_X1
X_29824_ u0.r0.rcnt\[0\] _15322_ _15326_ _15327_ VDD VSS HA_X1
X_29825_ u0.r0.rcnt\[0\] u0.r0.rcnt\[1\] _15328_ _15329_ VDD
+ VSS HA_X1
X_29826_ u0.r0.rcnt\[0\] u0.r0.rcnt\[1\] _15330_ _15331_ VDD
+ VSS HA_X1
Xdcnt\[0\]$_SDFFE_PN0P_ _00485_ clknet_leaf_35_clk dcnt\[0\]
+ _14264_ VDD VSS DFF_X1
Xdcnt\[1\]$_SDFFE_PN0P_ _00486_ clknet_leaf_35_clk dcnt\[1\]
+ _14263_ VDD VSS DFF_X1
Xdcnt\[2\]$_SDFFE_PP0P_ _00487_ clknet_leaf_35_clk dcnt\[2\]
+ _14262_ VDD VSS DFF_X1
Xdcnt\[3\]$_SDFFE_PN0P_ _00488_ clknet_leaf_36_clk dcnt\[3\]
+ _14265_ VDD VSS DFF_X1
Xdone$_DFF_P_ _00160_ clknet_leaf_23_clk net345 _14266_ VDD
+ VSS DFF_X1
Xld_r$_DFF_P_ net1144 clknet_leaf_7_clk ld_r _14267_ VDD VSS
+ DFF_X1
Xsa00_sr\[0\]$_DFF_P_ _00032_ clknet_leaf_79_clk sa00_sr\[0\]
+ _14268_ VDD VSS DFF_X2
Xsa00_sr\[1\]$_DFF_P_ _00033_ clknet_leaf_76_clk sa00_sr\[1\]
+ _14269_ VDD VSS DFF_X2
Xsa00_sr\[2\]$_DFF_P_ _00034_ clknet_leaf_77_clk sa00_sr\[2\]
+ _14270_ VDD VSS DFF_X1
Xsa00_sr\[3\]$_DFF_P_ _00035_ clknet_leaf_76_clk sa00_sr\[3\]
+ _14271_ VDD VSS DFF_X1
Xsa00_sr\[4\]$_DFF_P_ _00036_ clknet_leaf_77_clk sa00_sr\[4\]
+ _14272_ VDD VSS DFF_X1
Xsa00_sr\[5\]$_DFF_P_ _00037_ clknet_leaf_77_clk sa00_sr\[5\]
+ _14273_ VDD VSS DFF_X1
Xsa00_sr\[6\]$_DFF_P_ _00038_ clknet_leaf_76_clk sa00_sr\[6\]
+ _14274_ VDD VSS DFF_X1
Xsa00_sr\[7\]$_DFF_P_ _00039_ clknet_leaf_76_clk sa00_sr\[7\]
+ _14275_ VDD VSS DFF_X1
Xsa01_sr\[0\]$_DFF_P_ _00040_ clknet_leaf_49_clk sa01_sr\[0\]
+ _14276_ VDD VSS DFF_X2
Xsa01_sr\[1\]$_DFF_P_ _00041_ clknet_leaf_42_clk sa01_sr\[1\]
+ _14277_ VDD VSS DFF_X2
Xsa01_sr\[2\]$_DFF_P_ _00042_ clknet_leaf_43_clk sa01_sr\[2\]
+ _14278_ VDD VSS DFF_X1
Xsa01_sr\[3\]$_DFF_P_ _00043_ clknet_leaf_43_clk sa01_sr\[3\]
+ _14279_ VDD VSS DFF_X1
Xsa01_sr\[4\]$_DFF_P_ _00044_ clknet_leaf_49_clk sa01_sr\[4\]
+ _14280_ VDD VSS DFF_X1
Xsa01_sr\[5\]$_DFF_P_ _00045_ clknet_leaf_49_clk sa01_sr\[5\]
+ _14281_ VDD VSS DFF_X1
Xsa01_sr\[6\]$_DFF_P_ _00046_ clknet_leaf_49_clk sa01_sr\[6\]
+ _14282_ VDD VSS DFF_X1
Xsa01_sr\[7\]$_DFF_P_ _00047_ clknet_leaf_43_clk sa01_sr\[7\]
+ _14283_ VDD VSS DFF_X1
Xsa02_sr\[0\]$_DFF_P_ _00048_ clknet_leaf_61_clk sa02_sr\[0\]
+ _14284_ VDD VSS DFF_X1
Xsa02_sr\[1\]$_DFF_P_ _00049_ clknet_leaf_62_clk sa02_sr\[1\]
+ _14285_ VDD VSS DFF_X2
Xsa02_sr\[2\]$_DFF_P_ _00050_ clknet_leaf_62_clk sa02_sr\[2\]
+ _14286_ VDD VSS DFF_X1
Xsa02_sr\[3\]$_DFF_P_ _00051_ clknet_leaf_60_clk sa02_sr\[3\]
+ _14287_ VDD VSS DFF_X1
Xsa02_sr\[4\]$_DFF_P_ _00052_ clknet_leaf_66_clk sa02_sr\[4\]
+ _14288_ VDD VSS DFF_X1
Xsa02_sr\[5\]$_DFF_P_ _00053_ clknet_leaf_68_clk sa02_sr\[5\]
+ _14289_ VDD VSS DFF_X1
Xsa02_sr\[6\]$_DFF_P_ _00054_ clknet_leaf_63_clk sa02_sr\[6\]
+ _14290_ VDD VSS DFF_X1
Xsa02_sr\[7\]$_DFF_P_ _00055_ clknet_leaf_63_clk sa02_sr\[7\]
+ _14291_ VDD VSS DFF_X1
Xsa03_sr\[0\]$_DFF_P_ _00056_ clknet_leaf_13_clk sa03_sr\[0\]
+ _14292_ VDD VSS DFF_X2
Xsa03_sr\[1\]$_DFF_P_ _00057_ clknet_leaf_17_clk sa03_sr\[1\]
+ _14293_ VDD VSS DFF_X1
Xsa03_sr\[2\]$_DFF_P_ _00058_ clknet_leaf_22_clk sa03_sr\[2\]
+ _14294_ VDD VSS DFF_X1
Xsa03_sr\[3\]$_DFF_P_ _00059_ clknet_leaf_14_clk sa03_sr\[3\]
+ _14295_ VDD VSS DFF_X1
Xsa03_sr\[4\]$_DFF_P_ _00060_ clknet_leaf_15_clk sa03_sr\[4\]
+ _14296_ VDD VSS DFF_X1
Xsa03_sr\[5\]$_DFF_P_ _00061_ clknet_leaf_15_clk sa03_sr\[5\]
+ _14297_ VDD VSS DFF_X1
Xsa03_sr\[6\]$_DFF_P_ _00062_ clknet_leaf_15_clk sa03_sr\[6\]
+ _14298_ VDD VSS DFF_X1
Xsa03_sr\[7\]$_DFF_P_ _00063_ clknet_leaf_15_clk sa03_sr\[7\]
+ _14299_ VDD VSS DFF_X1
Xsa10_sr\[0\]$_DFF_P_ _00072_ clknet_leaf_81_clk sa10_sr\[0\]
+ _14300_ VDD VSS DFF_X1
Xsa10_sr\[1\]$_DFF_P_ _00073_ clknet_leaf_81_clk sa10_sr\[1\]
+ _14301_ VDD VSS DFF_X2
Xsa10_sr\[2\]$_DFF_P_ _00074_ clknet_leaf_81_clk sa10_sr\[2\]
+ _14302_ VDD VSS DFF_X1
Xsa10_sr\[3\]$_DFF_P_ _00075_ clknet_leaf_78_clk sa10_sr\[3\]
+ _14303_ VDD VSS DFF_X1
Xsa10_sr\[4\]$_DFF_P_ _00076_ clknet_leaf_78_clk sa10_sr\[4\]
+ _14304_ VDD VSS DFF_X1
Xsa10_sr\[5\]$_DFF_P_ _00077_ clknet_leaf_78_clk sa10_sr\[5\]
+ _14305_ VDD VSS DFF_X1
Xsa10_sr\[6\]$_DFF_P_ _00078_ clknet_leaf_78_clk sa10_sr\[6\]
+ _14306_ VDD VSS DFF_X1
Xsa10_sr\[7\]$_DFF_P_ _00079_ clknet_leaf_81_clk sa10_sr\[7\]
+ _14307_ VDD VSS DFF_X1
Xsa11_sr\[0\]$_DFF_P_ _00080_ clknet_leaf_48_clk sa11_sr\[0\]
+ _14308_ VDD VSS DFF_X1
Xsa11_sr\[1\]$_DFF_P_ _00081_ clknet_leaf_47_clk sa11_sr\[1\]
+ _14309_ VDD VSS DFF_X2
Xsa11_sr\[2\]$_DFF_P_ _00082_ clknet_leaf_67_clk sa11_sr\[2\]
+ _14310_ VDD VSS DFF_X1
Xsa11_sr\[3\]$_DFF_P_ _00083_ clknet_leaf_69_clk sa11_sr\[3\]
+ _14311_ VDD VSS DFF_X1
Xsa11_sr\[4\]$_DFF_P_ _00084_ clknet_leaf_68_clk sa11_sr\[4\]
+ _14312_ VDD VSS DFF_X1
Xsa11_sr\[5\]$_DFF_P_ _00085_ clknet_leaf_69_clk sa11_sr\[5\]
+ _14313_ VDD VSS DFF_X1
Xsa11_sr\[6\]$_DFF_P_ _00086_ clknet_leaf_67_clk sa11_sr\[6\]
+ _14314_ VDD VSS DFF_X1
Xsa11_sr\[7\]$_DFF_P_ _00087_ clknet_leaf_67_clk sa11_sr\[7\]
+ _14315_ VDD VSS DFF_X2
Xsa12_sr\[0\]$_DFF_P_ _00088_ clknet_leaf_83_clk sa12_sr\[0\]
+ _14316_ VDD VSS DFF_X2
Xsa12_sr\[1\]$_DFF_P_ _00089_ clknet_leaf_85_clk sa12_sr\[1\]
+ _14317_ VDD VSS DFF_X2
Xsa12_sr\[2\]$_DFF_P_ _00090_ clknet_leaf_89_clk sa12_sr\[2\]
+ _14318_ VDD VSS DFF_X2
Xsa12_sr\[3\]$_DFF_P_ _00091_ clknet_leaf_85_clk sa12_sr\[3\]
+ _14319_ VDD VSS DFF_X2
Xsa12_sr\[4\]$_DFF_P_ _00092_ clknet_leaf_84_clk sa12_sr\[4\]
+ _14320_ VDD VSS DFF_X1
Xsa12_sr\[5\]$_DFF_P_ _00093_ clknet_leaf_84_clk sa12_sr\[5\]
+ _14321_ VDD VSS DFF_X1
Xsa12_sr\[6\]$_DFF_P_ _00094_ clknet_leaf_88_clk sa12_sr\[6\]
+ _14322_ VDD VSS DFF_X1
Xsa12_sr\[7\]$_DFF_P_ _00095_ clknet_leaf_58_clk sa12_sr\[7\]
+ _14323_ VDD VSS DFF_X1
Xsa13_sr\[0\]$_DFF_P_ _00064_ clknet_leaf_6_clk sa10_sub\[0\]
+ _14324_ VDD VSS DFF_X2
Xsa13_sr\[1\]$_DFF_P_ _00065_ clknet_leaf_89_clk sa10_sub\[1\]
+ _14325_ VDD VSS DFF_X2
Xsa13_sr\[2\]$_DFF_P_ _00066_ clknet_leaf_5_clk sa10_sub\[2\]
+ _14326_ VDD VSS DFF_X1
Xsa13_sr\[3\]$_DFF_P_ _00067_ clknet_leaf_5_clk sa10_sub\[3\]
+ _14327_ VDD VSS DFF_X1
Xsa13_sr\[4\]$_DFF_P_ _00068_ clknet_leaf_5_clk sa10_sub\[4\]
+ _14328_ VDD VSS DFF_X1
Xsa13_sr\[5\]$_DFF_P_ _00069_ clknet_leaf_4_clk sa10_sub\[5\]
+ _14329_ VDD VSS DFF_X1
Xsa13_sr\[6\]$_DFF_P_ _00070_ clknet_leaf_96_clk sa10_sub\[6\]
+ _14330_ VDD VSS DFF_X1
Xsa13_sr\[7\]$_DFF_P_ _00071_ clknet_leaf_6_clk sa10_sub\[7\]
+ _14331_ VDD VSS DFF_X1
Xsa20_sr\[0\]$_DFF_P_ _00112_ clknet_leaf_79_clk sa20_sr\[0\]
+ _14332_ VDD VSS DFF_X1
Xsa20_sr\[1\]$_DFF_P_ _00113_ clknet_leaf_80_clk sa20_sr\[1\]
+ _14333_ VDD VSS DFF_X2
Xsa20_sr\[2\]$_DFF_P_ _00114_ clknet_leaf_58_clk sa20_sr\[2\]
+ _14334_ VDD VSS DFF_X1
Xsa20_sr\[3\]$_DFF_P_ _00115_ clknet_leaf_77_clk sa20_sr\[3\]
+ _14335_ VDD VSS DFF_X1
Xsa20_sr\[4\]$_DFF_P_ _00116_ clknet_leaf_71_clk sa20_sr\[4\]
+ _14336_ VDD VSS DFF_X1
Xsa20_sr\[5\]$_DFF_P_ _00117_ clknet_leaf_70_clk sa20_sr\[5\]
+ _14337_ VDD VSS DFF_X1
Xsa20_sr\[6\]$_DFF_P_ _00118_ clknet_leaf_71_clk sa20_sr\[6\]
+ _14338_ VDD VSS DFF_X1
Xsa20_sr\[7\]$_DFF_P_ _00119_ clknet_leaf_77_clk sa20_sr\[7\]
+ _14339_ VDD VSS DFF_X1
Xsa21_sr\[0\]$_DFF_P_ _00120_ clknet_leaf_9_clk sa21_sr\[0\]
+ _14340_ VDD VSS DFF_X2
Xsa21_sr\[1\]$_DFF_P_ _00121_ clknet_leaf_9_clk sa21_sr\[1\]
+ _14341_ VDD VSS DFF_X2
Xsa21_sr\[2\]$_DFF_P_ _00122_ clknet_leaf_16_clk sa21_sr\[2\]
+ _14342_ VDD VSS DFF_X1
Xsa21_sr\[3\]$_DFF_P_ _00123_ clknet_leaf_16_clk sa21_sr\[3\]
+ _14343_ VDD VSS DFF_X1
Xsa21_sr\[4\]$_DFF_P_ _00124_ clknet_leaf_3_clk sa21_sr\[4\]
+ _14344_ VDD VSS DFF_X1
Xsa21_sr\[5\]$_DFF_P_ _00125_ clknet_leaf_16_clk sa21_sr\[5\]
+ _14345_ VDD VSS DFF_X1
Xsa21_sr\[6\]$_DFF_P_ _00126_ clknet_leaf_16_clk sa21_sr\[6\]
+ _14346_ VDD VSS DFF_X1
Xsa21_sr\[7\]$_DFF_P_ _00127_ clknet_leaf_9_clk sa21_sr\[7\]
+ _14347_ VDD VSS DFF_X1
Xsa22_sr\[0\]$_DFF_P_ _00096_ clknet_leaf_58_clk sa20_sub\[0\]
+ _14348_ VDD VSS DFF_X2
Xsa22_sr\[1\]$_DFF_P_ _00097_ clknet_leaf_58_clk sa20_sub\[1\]
+ _14349_ VDD VSS DFF_X2
Xsa22_sr\[2\]$_DFF_P_ _00098_ clknet_leaf_59_clk sa20_sub\[2\]
+ _14350_ VDD VSS DFF_X1
Xsa22_sr\[3\]$_DFF_P_ _00099_ clknet_leaf_69_clk sa20_sub\[3\]
+ _14351_ VDD VSS DFF_X1
Xsa22_sr\[4\]$_DFF_P_ _00100_ clknet_leaf_59_clk sa20_sub\[4\]
+ _14352_ VDD VSS DFF_X1
Xsa22_sr\[5\]$_DFF_P_ _00101_ clknet_leaf_59_clk sa20_sub\[5\]
+ _14353_ VDD VSS DFF_X1
Xsa22_sr\[6\]$_DFF_P_ _00102_ clknet_leaf_69_clk sa20_sub\[6\]
+ _14354_ VDD VSS DFF_X1
Xsa22_sr\[7\]$_DFF_P_ _00103_ clknet_leaf_69_clk sa20_sub\[7\]
+ _14355_ VDD VSS DFF_X1
Xsa23_sr\[0\]$_DFF_P_ _00104_ clknet_leaf_12_clk sa21_sub\[0\]
+ _14356_ VDD VSS DFF_X1
Xsa23_sr\[1\]$_DFF_P_ _00105_ clknet_leaf_10_clk sa21_sub\[1\]
+ _14357_ VDD VSS DFF_X1
Xsa23_sr\[2\]$_DFF_P_ _00106_ clknet_leaf_10_clk sa21_sub\[2\]
+ _14358_ VDD VSS DFF_X1
Xsa23_sr\[3\]$_DFF_P_ _00107_ clknet_leaf_28_clk sa21_sub\[3\]
+ _14359_ VDD VSS DFF_X1
Xsa23_sr\[4\]$_DFF_P_ _00108_ clknet_leaf_10_clk sa21_sub\[4\]
+ _14360_ VDD VSS DFF_X1
Xsa23_sr\[5\]$_DFF_P_ _00109_ clknet_leaf_11_clk sa21_sub\[5\]
+ _14361_ VDD VSS DFF_X1
Xsa23_sr\[6\]$_DFF_P_ _00110_ clknet_leaf_10_clk sa21_sub\[6\]
+ _14362_ VDD VSS DFF_X1
Xsa23_sr\[7\]$_DFF_P_ _00111_ clknet_leaf_28_clk sa21_sub\[7\]
+ _14363_ VDD VSS DFF_X1
Xsa30_sr\[0\]$_DFF_P_ _00152_ clknet_leaf_30_clk sa30_sr\[0\]
+ _14364_ VDD VSS DFF_X2
Xsa30_sr\[1\]$_DFF_P_ _00153_ clknet_leaf_24_clk sa30_sr\[1\]
+ _14365_ VDD VSS DFF_X1
Xsa30_sr\[2\]$_DFF_P_ _00154_ clknet_leaf_26_clk sa30_sr\[2\]
+ _14366_ VDD VSS DFF_X1
Xsa30_sr\[3\]$_DFF_P_ _00155_ clknet_leaf_26_clk sa30_sr\[3\]
+ _14367_ VDD VSS DFF_X1
Xsa30_sr\[4\]$_DFF_P_ _00156_ clknet_leaf_26_clk sa30_sr\[4\]
+ _14368_ VDD VSS DFF_X1
Xsa30_sr\[5\]$_DFF_P_ _00157_ clknet_leaf_25_clk sa30_sr\[5\]
+ _14369_ VDD VSS DFF_X1
Xsa30_sr\[6\]$_DFF_P_ _00158_ clknet_leaf_26_clk sa30_sr\[6\]
+ _14370_ VDD VSS DFF_X1
Xsa30_sr\[7\]$_DFF_P_ _00159_ clknet_leaf_26_clk sa30_sr\[7\]
+ _14371_ VDD VSS DFF_X1
Xsa31_sr\[0\]$_DFF_P_ _00128_ clknet_leaf_53_clk sa30_sub\[0\]
+ _14372_ VDD VSS DFF_X2
Xsa31_sr\[1\]$_DFF_P_ _00129_ clknet_leaf_32_clk sa30_sub\[1\]
+ _14373_ VDD VSS DFF_X2
Xsa31_sr\[2\]$_DFF_P_ _00130_ clknet_leaf_32_clk sa30_sub\[2\]
+ _14374_ VDD VSS DFF_X1
Xsa31_sr\[3\]$_DFF_P_ _00131_ clknet_leaf_32_clk sa30_sub\[3\]
+ _14375_ VDD VSS DFF_X1
Xsa31_sr\[4\]$_DFF_P_ _00132_ clknet_leaf_38_clk sa30_sub\[4\]
+ _14376_ VDD VSS DFF_X1
Xsa31_sr\[5\]$_DFF_P_ _00133_ clknet_leaf_39_clk sa30_sub\[5\]
+ _14377_ VDD VSS DFF_X1
Xsa31_sr\[6\]$_DFF_P_ _00134_ clknet_leaf_38_clk sa30_sub\[6\]
+ _14378_ VDD VSS DFF_X1
Xsa31_sr\[7\]$_DFF_P_ _00135_ clknet_leaf_38_clk sa30_sub\[7\]
+ _14379_ VDD VSS DFF_X1
Xsa32_sr\[0\]$_DFF_P_ _00136_ clknet_leaf_40_clk sa31_sub\[0\]
+ _14380_ VDD VSS DFF_X1
Xsa32_sr\[1\]$_DFF_P_ _00137_ clknet_leaf_39_clk sa31_sub\[1\]
+ _14381_ VDD VSS DFF_X2
Xsa32_sr\[2\]$_DFF_P_ _00138_ clknet_leaf_39_clk sa31_sub\[2\]
+ _14382_ VDD VSS DFF_X1
Xsa32_sr\[3\]$_DFF_P_ _00139_ clknet_leaf_40_clk sa31_sub\[3\]
+ _14383_ VDD VSS DFF_X1
Xsa32_sr\[4\]$_DFF_P_ _00140_ clknet_leaf_39_clk sa31_sub\[4\]
+ _14384_ VDD VSS DFF_X1
Xsa32_sr\[5\]$_DFF_P_ _00141_ clknet_leaf_40_clk sa31_sub\[5\]
+ _14385_ VDD VSS DFF_X1
Xsa32_sr\[6\]$_DFF_P_ _00142_ clknet_leaf_40_clk sa31_sub\[6\]
+ _14386_ VDD VSS DFF_X1
Xsa32_sr\[7\]$_DFF_P_ _00143_ clknet_leaf_40_clk sa31_sub\[7\]
+ _14387_ VDD VSS DFF_X1
Xsa33_sr\[0\]$_DFF_P_ _00144_ clknet_leaf_55_clk sa32_sub\[0\]
+ _14388_ VDD VSS DFF_X2
Xsa33_sr\[1\]$_DFF_P_ _00145_ clknet_leaf_12_clk sa32_sub\[1\]
+ _14389_ VDD VSS DFF_X2
Xsa33_sr\[2\]$_DFF_P_ _00146_ clknet_leaf_31_clk sa32_sub\[2\]
+ _14390_ VDD VSS DFF_X2
Xsa33_sr\[3\]$_DFF_P_ _00147_ clknet_leaf_53_clk sa32_sub\[3\]
+ _14391_ VDD VSS DFF_X2
Xsa33_sr\[4\]$_DFF_P_ _00148_ clknet_leaf_31_clk sa32_sub\[4\]
+ _14392_ VDD VSS DFF_X1
Xsa33_sr\[5\]$_DFF_P_ _00149_ clknet_leaf_53_clk sa32_sub\[5\]
+ _14393_ VDD VSS DFF_X1
Xsa33_sr\[6\]$_DFF_P_ _00150_ clknet_leaf_31_clk sa32_sub\[6\]
+ _14394_ VDD VSS DFF_X1
Xsa33_sr\[7\]$_DFF_P_ _00151_ clknet_leaf_11_clk sa32_sub\[7\]
+ _14261_ VDD VSS DFF_X1
Xtext_in_r\[0\]$_DFFE_PP_ _00489_ clknet_leaf_12_clk text_in_r\[0\]
+ _00406_ VDD VSS DFF_X1
Xtext_in_r\[100\]$_DFFE_PP_ _00490_ clknet_leaf_52_clk text_in_r\[100\]
+ _14260_ VDD VSS DFF_X1
Xtext_in_r\[101\]$_DFFE_PP_ _00491_ clknet_leaf_55_clk text_in_r\[101\]
+ _14259_ VDD VSS DFF_X1
Xtext_in_r\[102\]$_DFFE_PP_ _00492_ clknet_leaf_50_clk text_in_r\[102\]
+ _14258_ VDD VSS DFF_X1
Xtext_in_r\[103\]$_DFFE_PP_ _00493_ clknet_leaf_57_clk text_in_r\[103\]
+ _14257_ VDD VSS DFF_X1
Xtext_in_r\[104\]$_DFFE_PP_ _00494_ clknet_leaf_93_clk text_in_r\[104\]
+ _00465_ VDD VSS DFF_X2
Xtext_in_r\[105\]$_DFFE_PP_ _00495_ clknet_leaf_73_clk text_in_r\[105\]
+ _00464_ VDD VSS DFF_X1
Xtext_in_r\[106\]$_DFFE_PP_ _00496_ clknet_leaf_56_clk text_in_r\[106\]
+ _00466_ VDD VSS DFF_X1
Xtext_in_r\[107\]$_DFFE_PP_ _00497_ clknet_leaf_72_clk text_in_r\[107\]
+ _14256_ VDD VSS DFF_X2
Xtext_in_r\[108\]$_DFFE_PP_ _00498_ clknet_leaf_72_clk text_in_r\[108\]
+ _14255_ VDD VSS DFF_X2
Xtext_in_r\[109\]$_DFFE_PP_ _00499_ clknet_leaf_93_clk text_in_r\[109\]
+ _14254_ VDD VSS DFF_X2
Xtext_in_r\[10\]$_DFFE_PP_ _00500_ clknet_leaf_6_clk text_in_r\[10\]
+ _00475_ VDD VSS DFF_X1
Xtext_in_r\[110\]$_DFFE_PP_ _00501_ clknet_leaf_93_clk text_in_r\[110\]
+ _14253_ VDD VSS DFF_X1
Xtext_in_r\[111\]$_DFFE_PP_ _00502_ clknet_leaf_75_clk text_in_r\[111\]
+ _14252_ VDD VSS DFF_X1
Xtext_in_r\[112\]$_DFFE_PP_ _00503_ clknet_leaf_95_clk text_in_r\[112\]
+ _00453_ VDD VSS DFF_X2
Xtext_in_r\[113\]$_DFFE_PP_ _00504_ clknet_leaf_95_clk text_in_r\[113\]
+ _00452_ VDD VSS DFF_X2
Xtext_in_r\[114\]$_DFFE_PP_ _00505_ clknet_leaf_74_clk text_in_r\[114\]
+ _00454_ VDD VSS DFF_X2
Xtext_in_r\[115\]$_DFFE_PP_ _00506_ clknet_leaf_96_clk text_in_r\[115\]
+ _14251_ VDD VSS DFF_X2
Xtext_in_r\[116\]$_DFFE_PP_ _00507_ clknet_leaf_93_clk text_in_r\[116\]
+ _14250_ VDD VSS DFF_X1
Xtext_in_r\[117\]$_DFFE_PP_ _00508_ clknet_leaf_95_clk text_in_r\[117\]
+ _14249_ VDD VSS DFF_X2
Xtext_in_r\[118\]$_DFFE_PP_ _00509_ clknet_leaf_95_clk text_in_r\[118\]
+ _14248_ VDD VSS DFF_X1
Xtext_in_r\[119\]$_DFFE_PP_ _00510_ clknet_leaf_74_clk text_in_r\[119\]
+ _14247_ VDD VSS DFF_X1
Xtext_in_r\[11\]$_DFFE_PP_ _00511_ clknet_leaf_3_clk text_in_r\[11\]
+ _14246_ VDD VSS DFF_X1
Xtext_in_r\[120\]$_DFFE_PP_ _00512_ clknet_leaf_74_clk text_in_r\[120\]
+ _00441_ VDD VSS DFF_X2
Xtext_in_r\[121\]$_DFFE_PP_ _00513_ clknet_leaf_76_clk text_in_r\[121\]
+ _00440_ VDD VSS DFF_X1
Xtext_in_r\[122\]$_DFFE_PP_ _00514_ clknet_leaf_72_clk text_in_r\[122\]
+ _00442_ VDD VSS DFF_X2
Xtext_in_r\[123\]$_DFFE_PP_ _00515_ clknet_leaf_71_clk text_in_r\[123\]
+ _14245_ VDD VSS DFF_X2
Xtext_in_r\[124\]$_DFFE_PP_ _00516_ clknet_leaf_71_clk text_in_r\[124\]
+ _14244_ VDD VSS DFF_X1
Xtext_in_r\[125\]$_DFFE_PP_ _00517_ clknet_leaf_72_clk text_in_r\[125\]
+ _14243_ VDD VSS DFF_X2
Xtext_in_r\[126\]$_DFFE_PP_ _00518_ clknet_leaf_75_clk text_in_r\[126\]
+ _14242_ VDD VSS DFF_X1
Xtext_in_r\[127\]$_DFFE_PP_ _00519_ clknet_leaf_72_clk text_in_r\[127\]
+ _14241_ VDD VSS DFF_X1
Xtext_in_r\[12\]$_DFFE_PP_ _00520_ clknet_leaf_16_clk text_in_r\[12\]
+ _14240_ VDD VSS DFF_X1
Xtext_in_r\[13\]$_DFFE_PP_ _00521_ clknet_leaf_13_clk text_in_r\[13\]
+ _14239_ VDD VSS DFF_X2
Xtext_in_r\[14\]$_DFFE_PP_ _00522_ clknet_leaf_16_clk text_in_r\[14\]
+ _14238_ VDD VSS DFF_X1
Xtext_in_r\[15\]$_DFFE_PP_ _00523_ clknet_leaf_18_clk text_in_r\[15\]
+ _14237_ VDD VSS DFF_X1
Xtext_in_r\[16\]$_DFFE_PP_ _00524_ clknet_leaf_1_clk text_in_r\[16\]
+ _00462_ VDD VSS DFF_X2
Xtext_in_r\[17\]$_DFFE_PP_ _00525_ clknet_leaf_1_clk text_in_r\[17\]
+ _00461_ VDD VSS DFF_X2
Xtext_in_r\[18\]$_DFFE_PP_ _00526_ clknet_leaf_1_clk text_in_r\[18\]
+ _00463_ VDD VSS DFF_X2
Xtext_in_r\[19\]$_DFFE_PP_ _00527_ clknet_leaf_1_clk text_in_r\[19\]
+ _14236_ VDD VSS DFF_X1
Xtext_in_r\[1\]$_DFFE_PP_ _00528_ clknet_leaf_18_clk text_in_r\[1\]
+ _00405_ VDD VSS DFF_X2
Xtext_in_r\[20\]$_DFFE_PP_ _00529_ clknet_leaf_1_clk text_in_r\[20\]
+ _14235_ VDD VSS DFF_X2
Xtext_in_r\[21\]$_DFFE_PP_ _00530_ clknet_leaf_1_clk text_in_r\[21\]
+ _14234_ VDD VSS DFF_X2
Xtext_in_r\[22\]$_DFFE_PP_ _00531_ clknet_leaf_2_clk text_in_r\[22\]
+ _14233_ VDD VSS DFF_X1
Xtext_in_r\[23\]$_DFFE_PP_ _00532_ clknet_leaf_2_clk text_in_r\[23\]
+ _14232_ VDD VSS DFF_X1
Xtext_in_r\[24\]$_DFFE_PP_ _00533_ clknet_leaf_20_clk text_in_r\[24\]
+ _00450_ VDD VSS DFF_X2
Xtext_in_r\[25\]$_DFFE_PP_ _00534_ clknet_leaf_21_clk text_in_r\[25\]
+ _00449_ VDD VSS DFF_X2
Xtext_in_r\[26\]$_DFFE_PP_ _00535_ clknet_leaf_17_clk text_in_r\[26\]
+ _00451_ VDD VSS DFF_X2
Xtext_in_r\[27\]$_DFFE_PP_ _00536_ clknet_leaf_19_clk text_in_r\[27\]
+ _14231_ VDD VSS DFF_X2
Xtext_in_r\[28\]$_DFFE_PP_ _00537_ clknet_leaf_20_clk text_in_r\[28\]
+ _14230_ VDD VSS DFF_X2
Xtext_in_r\[29\]$_DFFE_PP_ _00538_ clknet_leaf_17_clk text_in_r\[29\]
+ _14229_ VDD VSS DFF_X1
Xtext_in_r\[2\]$_DFFE_PP_ _00539_ clknet_leaf_17_clk text_in_r\[2\]
+ _00407_ VDD VSS DFF_X2
Xtext_in_r\[30\]$_DFFE_PP_ _00540_ clknet_leaf_20_clk text_in_r\[30\]
+ _14228_ VDD VSS DFF_X2
Xtext_in_r\[31\]$_DFFE_PP_ _00541_ clknet_leaf_20_clk text_in_r\[31\]
+ _14227_ VDD VSS DFF_X1
Xtext_in_r\[32\]$_DFFE_PP_ _00542_ clknet_leaf_57_clk text_in_r\[32\]
+ _00483_ VDD VSS DFF_X1
Xtext_in_r\[33\]$_DFFE_PP_ _00543_ clknet_leaf_61_clk text_in_r\[33\]
+ _00482_ VDD VSS DFF_X1
Xtext_in_r\[34\]$_DFFE_PP_ _00544_ clknet_leaf_56_clk text_in_r\[34\]
+ _00484_ VDD VSS DFF_X1
Xtext_in_r\[35\]$_DFFE_PP_ _00545_ clknet_leaf_52_clk text_in_r\[35\]
+ _14226_ VDD VSS DFF_X1
Xtext_in_r\[36\]$_DFFE_PP_ _00546_ clknet_leaf_52_clk text_in_r\[36\]
+ _14225_ VDD VSS DFF_X1
Xtext_in_r\[37\]$_DFFE_PP_ _00547_ clknet_leaf_62_clk text_in_r\[37\]
+ _14224_ VDD VSS DFF_X1
Xtext_in_r\[38\]$_DFFE_PP_ _00548_ clknet_leaf_53_clk text_in_r\[38\]
+ _14223_ VDD VSS DFF_X1
Xtext_in_r\[39\]$_DFFE_PP_ _00549_ clknet_leaf_51_clk text_in_r\[39\]
+ _14222_ VDD VSS DFF_X1
Xtext_in_r\[3\]$_DFFE_PP_ _00550_ clknet_leaf_13_clk text_in_r\[3\]
+ _14221_ VDD VSS DFF_X1
Xtext_in_r\[40\]$_DFFE_PP_ _00551_ clknet_leaf_58_clk text_in_r\[40\]
+ _00471_ VDD VSS DFF_X1
Xtext_in_r\[41\]$_DFFE_PP_ _00552_ clknet_leaf_61_clk text_in_r\[41\]
+ _00470_ VDD VSS DFF_X1
Xtext_in_r\[42\]$_DFFE_PP_ _00553_ clknet_leaf_61_clk text_in_r\[42\]
+ _00472_ VDD VSS DFF_X1
Xtext_in_r\[43\]$_DFFE_PP_ _00554_ clknet_leaf_69_clk text_in_r\[43\]
+ _14220_ VDD VSS DFF_X1
Xtext_in_r\[44\]$_DFFE_PP_ _00555_ clknet_leaf_68_clk text_in_r\[44\]
+ _14219_ VDD VSS DFF_X1
Xtext_in_r\[45\]$_DFFE_PP_ _00556_ clknet_leaf_59_clk text_in_r\[45\]
+ _14218_ VDD VSS DFF_X1
Xtext_in_r\[46\]$_DFFE_PP_ _00557_ clknet_leaf_69_clk text_in_r\[46\]
+ _14217_ VDD VSS DFF_X1
Xtext_in_r\[47\]$_DFFE_PP_ _00558_ clknet_leaf_59_clk text_in_r\[47\]
+ _14216_ VDD VSS DFF_X1
Xtext_in_r\[48\]$_DFFE_PP_ _00559_ clknet_leaf_58_clk text_in_r\[48\]
+ _00459_ VDD VSS DFF_X1
Xtext_in_r\[49\]$_DFFE_PP_ _00560_ clknet_leaf_68_clk text_in_r\[49\]
+ _00458_ VDD VSS DFF_X1
Xtext_in_r\[4\]$_DFFE_PP_ _00561_ clknet_leaf_12_clk text_in_r\[4\]
+ _14215_ VDD VSS DFF_X1
Xtext_in_r\[50\]$_DFFE_PP_ _00562_ clknet_leaf_61_clk text_in_r\[50\]
+ _00460_ VDD VSS DFF_X1
Xtext_in_r\[51\]$_DFFE_PP_ _00563_ clknet_leaf_68_clk text_in_r\[51\]
+ _14214_ VDD VSS DFF_X1
Xtext_in_r\[52\]$_DFFE_PP_ _00564_ clknet_leaf_68_clk text_in_r\[52\]
+ _14213_ VDD VSS DFF_X1
Xtext_in_r\[53\]$_DFFE_PP_ _00565_ clknet_leaf_68_clk text_in_r\[53\]
+ _14212_ VDD VSS DFF_X1
Xtext_in_r\[54\]$_DFFE_PP_ _00566_ clknet_leaf_68_clk text_in_r\[54\]
+ _14211_ VDD VSS DFF_X1
Xtext_in_r\[55\]$_DFFE_PP_ _00567_ clknet_leaf_60_clk text_in_r\[55\]
+ _14210_ VDD VSS DFF_X1
Xtext_in_r\[56\]$_DFFE_PP_ _00568_ clknet_leaf_61_clk text_in_r\[56\]
+ _00447_ VDD VSS DFF_X1
Xtext_in_r\[57\]$_DFFE_PP_ _00569_ clknet_leaf_60_clk text_in_r\[57\]
+ _00446_ VDD VSS DFF_X2
Xtext_in_r\[58\]$_DFFE_PP_ _00570_ clknet_leaf_60_clk text_in_r\[58\]
+ _00448_ VDD VSS DFF_X1
Xtext_in_r\[59\]$_DFFE_PP_ _00571_ clknet_leaf_60_clk text_in_r\[59\]
+ _14209_ VDD VSS DFF_X1
Xtext_in_r\[5\]$_DFFE_PP_ _00572_ clknet_leaf_13_clk text_in_r\[5\]
+ _14208_ VDD VSS DFF_X1
Xtext_in_r\[60\]$_DFFE_PP_ _00573_ clknet_leaf_65_clk text_in_r\[60\]
+ _14207_ VDD VSS DFF_X1
Xtext_in_r\[61\]$_DFFE_PP_ _00574_ clknet_leaf_66_clk text_in_r\[61\]
+ _14206_ VDD VSS DFF_X1
Xtext_in_r\[62\]$_DFFE_PP_ _00575_ clknet_leaf_66_clk text_in_r\[62\]
+ _14205_ VDD VSS DFF_X1
Xtext_in_r\[63\]$_DFFE_PP_ _00576_ clknet_leaf_66_clk text_in_r\[63\]
+ _14204_ VDD VSS DFF_X1
Xtext_in_r\[64\]$_DFFE_PP_ _00577_ clknet_leaf_52_clk text_in_r\[64\]
+ _00480_ VDD VSS DFF_X1
Xtext_in_r\[65\]$_DFFE_PP_ _00578_ clknet_leaf_38_clk text_in_r\[65\]
+ _00479_ VDD VSS DFF_X1
Xtext_in_r\[66\]$_DFFE_PP_ _00579_ clknet_leaf_41_clk text_in_r\[66\]
+ _00481_ VDD VSS DFF_X2
Xtext_in_r\[67\]$_DFFE_PP_ _00580_ clknet_leaf_42_clk text_in_r\[67\]
+ _14203_ VDD VSS DFF_X2
Xtext_in_r\[68\]$_DFFE_PP_ _00581_ clknet_leaf_52_clk text_in_r\[68\]
+ _14202_ VDD VSS DFF_X1
Xtext_in_r\[69\]$_DFFE_PP_ _00582_ clknet_leaf_45_clk text_in_r\[69\]
+ _14201_ VDD VSS DFF_X2
Xtext_in_r\[6\]$_DFFE_PP_ _00583_ clknet_leaf_11_clk text_in_r\[6\]
+ _14200_ VDD VSS DFF_X1
Xtext_in_r\[70\]$_DFFE_PP_ _00584_ clknet_leaf_48_clk text_in_r\[70\]
+ _14199_ VDD VSS DFF_X1
Xtext_in_r\[71\]$_DFFE_PP_ _00585_ clknet_leaf_50_clk text_in_r\[71\]
+ _14198_ VDD VSS DFF_X1
Xtext_in_r\[72\]$_DFFE_PP_ _00586_ clknet_leaf_55_clk text_in_r\[72\]
+ _00468_ VDD VSS DFF_X1
Xtext_in_r\[73\]$_DFFE_PP_ _00587_ clknet_leaf_9_clk text_in_r\[73\]
+ _00467_ VDD VSS DFF_X1
Xtext_in_r\[74\]$_DFFE_PP_ _00588_ clknet_leaf_54_clk text_in_r\[74\]
+ _00469_ VDD VSS DFF_X1
Xtext_in_r\[75\]$_DFFE_PP_ _00589_ clknet_leaf_49_clk text_in_r\[75\]
+ _14197_ VDD VSS DFF_X2
Xtext_in_r\[76\]$_DFFE_PP_ _00590_ clknet_leaf_56_clk text_in_r\[76\]
+ _14196_ VDD VSS DFF_X1
Xtext_in_r\[77\]$_DFFE_PP_ _00591_ clknet_leaf_29_clk text_in_r\[77\]
+ _14195_ VDD VSS DFF_X2
Xtext_in_r\[78\]$_DFFE_PP_ _00592_ clknet_leaf_9_clk text_in_r\[78\]
+ _14194_ VDD VSS DFF_X1
Xtext_in_r\[79\]$_DFFE_PP_ _00593_ clknet_leaf_48_clk text_in_r\[79\]
+ _14193_ VDD VSS DFF_X1
Xtext_in_r\[7\]$_DFFE_PP_ _00594_ clknet_leaf_12_clk text_in_r\[7\]
+ _14192_ VDD VSS DFF_X1
Xtext_in_r\[80\]$_DFFE_PP_ _00595_ clknet_leaf_47_clk text_in_r\[80\]
+ _00456_ VDD VSS DFF_X1
Xtext_in_r\[81\]$_DFFE_PP_ _00596_ clknet_leaf_47_clk text_in_r\[81\]
+ _00455_ VDD VSS DFF_X2
Xtext_in_r\[82\]$_DFFE_PP_ _00597_ clknet_leaf_49_clk text_in_r\[82\]
+ _00457_ VDD VSS DFF_X2
Xtext_in_r\[83\]$_DFFE_PP_ _00598_ clknet_leaf_51_clk text_in_r\[83\]
+ _14191_ VDD VSS DFF_X1
Xtext_in_r\[84\]$_DFFE_PP_ _00599_ clknet_leaf_48_clk text_in_r\[84\]
+ _14190_ VDD VSS DFF_X2
Xtext_in_r\[85\]$_DFFE_PP_ _00600_ clknet_leaf_51_clk text_in_r\[85\]
+ _14189_ VDD VSS DFF_X1
Xtext_in_r\[86\]$_DFFE_PP_ _00601_ clknet_leaf_54_clk text_in_r\[86\]
+ _14188_ VDD VSS DFF_X1
Xtext_in_r\[87\]$_DFFE_PP_ _00602_ clknet_leaf_47_clk text_in_r\[87\]
+ _14187_ VDD VSS DFF_X1
Xtext_in_r\[88\]$_DFFE_PP_ _00603_ clknet_leaf_45_clk text_in_r\[88\]
+ _00444_ VDD VSS DFF_X1
Xtext_in_r\[89\]$_DFFE_PP_ _00604_ clknet_leaf_49_clk text_in_r\[89\]
+ _00443_ VDD VSS DFF_X2
Xtext_in_r\[8\]$_DFFE_PP_ _00605_ clknet_leaf_12_clk text_in_r\[8\]
+ _00474_ VDD VSS DFF_X1
Xtext_in_r\[90\]$_DFFE_PP_ _00606_ clknet_leaf_53_clk text_in_r\[90\]
+ _00445_ VDD VSS DFF_X1
Xtext_in_r\[91\]$_DFFE_PP_ _00607_ clknet_leaf_43_clk text_in_r\[91\]
+ _14186_ VDD VSS DFF_X2
Xtext_in_r\[92\]$_DFFE_PP_ _00608_ clknet_leaf_43_clk text_in_r\[92\]
+ _14185_ VDD VSS DFF_X2
Xtext_in_r\[93\]$_DFFE_PP_ _00609_ clknet_leaf_45_clk text_in_r\[93\]
+ _14184_ VDD VSS DFF_X1
Xtext_in_r\[94\]$_DFFE_PP_ _00610_ clknet_leaf_47_clk text_in_r\[94\]
+ _14183_ VDD VSS DFF_X1
Xtext_in_r\[95\]$_DFFE_PP_ _00611_ clknet_leaf_45_clk text_in_r\[95\]
+ _14182_ VDD VSS DFF_X1
Xtext_in_r\[96\]$_DFFE_PP_ _00612_ clknet_leaf_56_clk text_in_r\[96\]
+ _00477_ VDD VSS DFF_X1
Xtext_in_r\[97\]$_DFFE_PP_ _00613_ clknet_leaf_37_clk text_in_r\[97\]
+ _00476_ VDD VSS DFF_X2
Xtext_in_r\[98\]$_DFFE_PP_ _00614_ clknet_leaf_36_clk text_in_r\[98\]
+ _00478_ VDD VSS DFF_X2
Xtext_in_r\[99\]$_DFFE_PP_ _00615_ clknet_leaf_36_clk text_in_r\[99\]
+ _14181_ VDD VSS DFF_X1
Xtext_in_r\[9\]$_DFFE_PP_ _00616_ clknet_leaf_3_clk text_in_r\[9\]
+ _00473_ VDD VSS DFF_X1
Xtext_out\[0\]$_DFF_P_ _00265_ clknet_leaf_18_clk net346 _14395_
+ VDD VSS DFF_X1
Xtext_out\[100\]$_DFF_P_ _00165_ clknet_leaf_36_clk net347
+ _14396_ VDD VSS DFF_X1
Xtext_out\[101\]$_DFF_P_ _00166_ clknet_leaf_44_clk net348
+ _14397_ VDD VSS DFF_X1
Xtext_out\[102\]$_DFF_P_ _00167_ clknet_leaf_41_clk net349
+ _14398_ VDD VSS DFF_X1
Xtext_out\[103\]$_DFF_P_ _00168_ clknet_leaf_37_clk net350
+ _14399_ VDD VSS DFF_X1
Xtext_out\[104\]$_DFF_P_ _00169_ clknet_leaf_73_clk net351
+ _14400_ VDD VSS DFF_X1
Xtext_out\[105\]$_DFF_P_ _00170_ clknet_leaf_35_clk net352
+ _14401_ VDD VSS DFF_X1
Xtext_out\[106\]$_DFF_P_ _00171_ clknet_leaf_64_clk net353
+ _14402_ VDD VSS DFF_X1
Xtext_out\[107\]$_DFF_P_ _00172_ clknet_leaf_73_clk net354
+ _14403_ VDD VSS DFF_X1
Xtext_out\[108\]$_DFF_P_ _00173_ clknet_leaf_73_clk net355
+ _14404_ VDD VSS DFF_X1
Xtext_out\[109\]$_DFF_P_ _00174_ clknet_leaf_94_clk net356
+ _14405_ VDD VSS DFF_X1
Xtext_out\[10\]$_DFF_P_ _00195_ clknet_leaf_18_clk net357
+ _14406_ VDD VSS DFF_X1
Xtext_out\[110\]$_DFF_P_ _00175_ clknet_leaf_74_clk net358
+ _14407_ VDD VSS DFF_X1
Xtext_out\[111\]$_DFF_P_ _00176_ clknet_leaf_73_clk net359
+ _14408_ VDD VSS DFF_X1
Xtext_out\[112\]$_DFF_P_ _00177_ clknet_leaf_94_clk net360
+ _14409_ VDD VSS DFF_X1
Xtext_out\[113\]$_DFF_P_ _00178_ clknet_leaf_94_clk net361
+ _14410_ VDD VSS DFF_X1
Xtext_out\[114\]$_DFF_P_ _00179_ clknet_leaf_73_clk net362
+ _14411_ VDD VSS DFF_X1
Xtext_out\[115\]$_DFF_P_ _00180_ clknet_leaf_74_clk net363
+ _14412_ VDD VSS DFF_X1
Xtext_out\[116\]$_DFF_P_ _00181_ clknet_leaf_93_clk net364
+ _14413_ VDD VSS DFF_X1
Xtext_out\[117\]$_DFF_P_ _00182_ clknet_leaf_94_clk net365
+ _14414_ VDD VSS DFF_X1
Xtext_out\[118\]$_DFF_P_ _00183_ clknet_leaf_94_clk net366
+ _14415_ VDD VSS DFF_X1
Xtext_out\[119\]$_DFF_P_ _00184_ clknet_leaf_74_clk net367
+ _14416_ VDD VSS DFF_X1
Xtext_out\[11\]$_DFF_P_ _00196_ clknet_leaf_1_clk net368 _14417_
+ VDD VSS DFF_X1
Xtext_out\[120\]$_DFF_P_ _00185_ clknet_leaf_72_clk net369
+ _14418_ VDD VSS DFF_X1
Xtext_out\[121\]$_DFF_P_ _00186_ clknet_leaf_71_clk net370
+ _14419_ VDD VSS DFF_X1
Xtext_out\[122\]$_DFF_P_ _00187_ clknet_leaf_73_clk net371
+ _14420_ VDD VSS DFF_X1
Xtext_out\[123\]$_DFF_P_ _00188_ clknet_leaf_71_clk net372
+ _14421_ VDD VSS DFF_X1
Xtext_out\[124\]$_DFF_P_ _00189_ clknet_leaf_72_clk net373
+ _14422_ VDD VSS DFF_X1
Xtext_out\[125\]$_DFF_P_ _00190_ clknet_leaf_72_clk net374
+ _14423_ VDD VSS DFF_X1
Xtext_out\[126\]$_DFF_P_ _00191_ clknet_leaf_67_clk net375
+ _14424_ VDD VSS DFF_X1
Xtext_out\[127\]$_DFF_P_ _00192_ clknet_leaf_67_clk net376
+ _14425_ VDD VSS DFF_X1
Xtext_out\[12\]$_DFF_P_ _00197_ clknet_leaf_2_clk net377 _14426_
+ VDD VSS DFF_X1
Xtext_out\[13\]$_DFF_P_ _00198_ clknet_leaf_2_clk net378 _14427_
+ VDD VSS DFF_X1
Xtext_out\[14\]$_DFF_P_ _00199_ clknet_leaf_2_clk net379 _14428_
+ VDD VSS DFF_X1
Xtext_out\[15\]$_DFF_P_ _00200_ clknet_leaf_2_clk net380 _14429_
+ VDD VSS DFF_X1
Xtext_out\[16\]$_DFF_P_ _00201_ clknet_leaf_0_clk net381 _14430_
+ VDD VSS DFF_X1
Xtext_out\[17\]$_DFF_P_ _00202_ clknet_leaf_0_clk net382 _14431_
+ VDD VSS DFF_X1
Xtext_out\[18\]$_DFF_P_ _00203_ clknet_leaf_1_clk net383 _14432_
+ VDD VSS DFF_X1
Xtext_out\[19\]$_DFF_P_ _00204_ clknet_leaf_0_clk net384 _14433_
+ VDD VSS DFF_X1
Xtext_out\[1\]$_DFF_P_ _00266_ clknet_leaf_19_clk net385 _14434_
+ VDD VSS DFF_X1
Xtext_out\[20\]$_DFF_P_ _00205_ clknet_leaf_0_clk net386 _14435_
+ VDD VSS DFF_X1
Xtext_out\[21\]$_DFF_P_ _00206_ clknet_leaf_0_clk net387 _14436_
+ VDD VSS DFF_X1
Xtext_out\[22\]$_DFF_P_ _00207_ clknet_leaf_0_clk net388 _14437_
+ VDD VSS DFF_X1
Xtext_out\[23\]$_DFF_P_ _00208_ clknet_leaf_0_clk net389 _14438_
+ VDD VSS DFF_X1
Xtext_out\[24\]$_DFF_P_ _00209_ clknet_leaf_20_clk net390
+ _14439_ VDD VSS DFF_X1
Xtext_out\[25\]$_DFF_P_ _00210_ clknet_leaf_19_clk net391
+ _14440_ VDD VSS DFF_X1
Xtext_out\[26\]$_DFF_P_ _00211_ clknet_leaf_21_clk net392
+ _14441_ VDD VSS DFF_X1
Xtext_out\[27\]$_DFF_P_ _00212_ clknet_leaf_17_clk net393
+ _14442_ VDD VSS DFF_X1
Xtext_out\[28\]$_DFF_P_ _00213_ clknet_leaf_21_clk net394
+ _14443_ VDD VSS DFF_X1
Xtext_out\[29\]$_DFF_P_ _00214_ clknet_leaf_18_clk net395
+ _14444_ VDD VSS DFF_X1
Xtext_out\[2\]$_DFF_P_ _00267_ clknet_leaf_19_clk net396 _14445_
+ VDD VSS DFF_X1
Xtext_out\[30\]$_DFF_P_ _00215_ clknet_leaf_20_clk net397
+ _14446_ VDD VSS DFF_X1
Xtext_out\[31\]$_DFF_P_ _00216_ clknet_leaf_19_clk net398
+ _14447_ VDD VSS DFF_X1
Xtext_out\[32\]$_DFF_P_ _00217_ clknet_leaf_46_clk net399
+ _14448_ VDD VSS DFF_X1
Xtext_out\[33\]$_DFF_P_ _00218_ clknet_leaf_44_clk net400
+ _14449_ VDD VSS DFF_X1
Xtext_out\[34\]$_DFF_P_ _00219_ clknet_leaf_38_clk net401
+ _14450_ VDD VSS DFF_X1
Xtext_out\[35\]$_DFF_P_ _00220_ clknet_leaf_45_clk net402
+ _14451_ VDD VSS DFF_X1
Xtext_out\[36\]$_DFF_P_ _00221_ clknet_leaf_43_clk net403
+ _14452_ VDD VSS DFF_X1
Xtext_out\[37\]$_DFF_P_ _00222_ clknet_leaf_46_clk net404
+ _14453_ VDD VSS DFF_X1
Xtext_out\[38\]$_DFF_P_ _00223_ clknet_leaf_45_clk net405
+ _14454_ VDD VSS DFF_X1
Xtext_out\[39\]$_DFF_P_ _00224_ clknet_leaf_45_clk net406
+ _14455_ VDD VSS DFF_X1
Xtext_out\[3\]$_DFF_P_ _00268_ clknet_leaf_18_clk net407 _14456_
+ VDD VSS DFF_X1
Xtext_out\[40\]$_DFF_P_ _00225_ clknet_leaf_70_clk net408
+ _14457_ VDD VSS DFF_X1
Xtext_out\[41\]$_DFF_P_ _00226_ clknet_leaf_70_clk net409
+ _14458_ VDD VSS DFF_X1
Xtext_out\[42\]$_DFF_P_ _00227_ clknet_leaf_64_clk net410
+ _14459_ VDD VSS DFF_X1
Xtext_out\[43\]$_DFF_P_ _00228_ clknet_leaf_65_clk net411
+ _14460_ VDD VSS DFF_X1
Xtext_out\[44\]$_DFF_P_ _00229_ clknet_leaf_65_clk net412
+ _14461_ VDD VSS DFF_X1
Xtext_out\[45\]$_DFF_P_ _00230_ clknet_leaf_66_clk net413
+ _14462_ VDD VSS DFF_X1
Xtext_out\[46\]$_DFF_P_ _00231_ clknet_leaf_70_clk net414
+ _14463_ VDD VSS DFF_X1
Xtext_out\[47\]$_DFF_P_ _00232_ clknet_leaf_70_clk net415
+ _14464_ VDD VSS DFF_X1
Xtext_out\[48\]$_DFF_P_ _00233_ clknet_leaf_74_clk net416
+ _14465_ VDD VSS DFF_X1
Xtext_out\[49\]$_DFF_P_ _00234_ clknet_leaf_94_clk net417
+ _14466_ VDD VSS DFF_X1
Xtext_out\[4\]$_DFF_P_ _00269_ clknet_leaf_23_clk net418 _14467_
+ VDD VSS DFF_X1
Xtext_out\[50\]$_DFF_P_ _00235_ clknet_leaf_64_clk net419
+ _14468_ VDD VSS DFF_X1
Xtext_out\[51\]$_DFF_P_ _00236_ clknet_leaf_65_clk net420
+ _14469_ VDD VSS DFF_X1
Xtext_out\[52\]$_DFF_P_ _00237_ clknet_leaf_75_clk net421
+ _14470_ VDD VSS DFF_X1
Xtext_out\[53\]$_DFF_P_ _00238_ clknet_leaf_94_clk net422
+ _14471_ VDD VSS DFF_X1
Xtext_out\[54\]$_DFF_P_ _00239_ clknet_leaf_95_clk net423
+ _14472_ VDD VSS DFF_X1
Xtext_out\[55\]$_DFF_P_ _00240_ clknet_leaf_65_clk net424
+ _14473_ VDD VSS DFF_X1
Xtext_out\[56\]$_DFF_P_ _00241_ clknet_leaf_65_clk net425
+ _14474_ VDD VSS DFF_X1
Xtext_out\[57\]$_DFF_P_ _00242_ clknet_leaf_64_clk net426
+ _14475_ VDD VSS DFF_X1
Xtext_out\[58\]$_DFF_P_ _00243_ clknet_leaf_64_clk net427
+ _14476_ VDD VSS DFF_X1
Xtext_out\[59\]$_DFF_P_ _00244_ clknet_leaf_65_clk net428
+ _14477_ VDD VSS DFF_X1
Xtext_out\[5\]$_DFF_P_ _00270_ clknet_leaf_21_clk net429 _14478_
+ VDD VSS DFF_X1
Xtext_out\[60\]$_DFF_P_ _00245_ clknet_leaf_66_clk net430
+ _14479_ VDD VSS DFF_X1
Xtext_out\[61\]$_DFF_P_ _00246_ clknet_leaf_65_clk net431
+ _14480_ VDD VSS DFF_X1
Xtext_out\[62\]$_DFF_P_ _00247_ clknet_leaf_66_clk net432
+ _14481_ VDD VSS DFF_X1
Xtext_out\[63\]$_DFF_P_ _00248_ clknet_leaf_66_clk net433
+ _14482_ VDD VSS DFF_X1
Xtext_out\[64\]$_DFF_P_ _00249_ clknet_leaf_42_clk net434
+ _14483_ VDD VSS DFF_X1
Xtext_out\[65\]$_DFF_P_ _00250_ clknet_leaf_37_clk net435
+ _14484_ VDD VSS DFF_X1
Xtext_out\[66\]$_DFF_P_ _00251_ clknet_leaf_37_clk net436
+ _14485_ VDD VSS DFF_X1
Xtext_out\[67\]$_DFF_P_ _00252_ clknet_leaf_41_clk net437
+ _14486_ VDD VSS DFF_X1
Xtext_out\[68\]$_DFF_P_ _00253_ clknet_leaf_41_clk net438
+ _14487_ VDD VSS DFF_X1
Xtext_out\[69\]$_DFF_P_ _00254_ clknet_leaf_46_clk net439
+ _14488_ VDD VSS DFF_X1
Xtext_out\[6\]$_DFF_P_ _00271_ clknet_leaf_22_clk net440 _14489_
+ VDD VSS DFF_X1
Xtext_out\[70\]$_DFF_P_ _00255_ clknet_leaf_41_clk net441
+ _14490_ VDD VSS DFF_X1
Xtext_out\[71\]$_DFF_P_ _00256_ clknet_leaf_44_clk net442
+ _14491_ VDD VSS DFF_X1
Xtext_out\[72\]$_DFF_P_ _00257_ clknet_leaf_35_clk net443
+ _14492_ VDD VSS DFF_X1
Xtext_out\[73\]$_DFF_P_ _00258_ clknet_leaf_23_clk net444
+ _14493_ VDD VSS DFF_X1
Xtext_out\[74\]$_DFF_P_ _00259_ clknet_leaf_35_clk net445
+ _14494_ VDD VSS DFF_X1
Xtext_out\[75\]$_DFF_P_ _00260_ clknet_leaf_23_clk net446
+ _14495_ VDD VSS DFF_X1
Xtext_out\[76\]$_DFF_P_ _00261_ clknet_leaf_35_clk net447
+ _14496_ VDD VSS DFF_X1
Xtext_out\[77\]$_DFF_P_ _00262_ clknet_leaf_23_clk net448
+ _14497_ VDD VSS DFF_X1
Xtext_out\[78\]$_DFF_P_ _00263_ clknet_leaf_95_clk net449
+ _14498_ VDD VSS DFF_X1
Xtext_out\[79\]$_DFF_P_ _00264_ clknet_leaf_23_clk net450
+ _14499_ VDD VSS DFF_X1
Xtext_out\[7\]$_DFF_P_ _00272_ clknet_leaf_19_clk net451 _14500_
+ VDD VSS DFF_X1
Xtext_out\[80\]$_DFF_P_ _00273_ clknet_leaf_42_clk net452
+ _14501_ VDD VSS DFF_X1
Xtext_out\[81\]$_DFF_P_ _00274_ clknet_leaf_43_clk net453
+ _14502_ VDD VSS DFF_X1
Xtext_out\[82\]$_DFF_P_ _00275_ clknet_leaf_41_clk net454
+ _14503_ VDD VSS DFF_X1
Xtext_out\[83\]$_DFF_P_ _00276_ clknet_leaf_64_clk net455
+ _14504_ VDD VSS DFF_X1
Xtext_out\[84\]$_DFF_P_ _00277_ clknet_leaf_44_clk net456
+ _14505_ VDD VSS DFF_X1
Xtext_out\[85\]$_DFF_P_ _00278_ clknet_leaf_46_clk net457
+ _14506_ VDD VSS DFF_X1
Xtext_out\[86\]$_DFF_P_ _00279_ clknet_leaf_46_clk net458
+ _14507_ VDD VSS DFF_X1
Xtext_out\[87\]$_DFF_P_ _00280_ clknet_leaf_47_clk net459
+ _14508_ VDD VSS DFF_X1
Xtext_out\[88\]$_DFF_P_ _00281_ clknet_leaf_44_clk net460
+ _14509_ VDD VSS DFF_X1
Xtext_out\[89\]$_DFF_P_ _00282_ clknet_leaf_44_clk net461
+ _14510_ VDD VSS DFF_X1
Xtext_out\[8\]$_DFF_P_ _00193_ clknet_leaf_18_clk net462 _14511_
+ VDD VSS DFF_X1
Xtext_out\[90\]$_DFF_P_ _00283_ clknet_leaf_44_clk net463
+ _14512_ VDD VSS DFF_X1
Xtext_out\[91\]$_DFF_P_ _00284_ clknet_leaf_43_clk net464
+ _14513_ VDD VSS DFF_X1
Xtext_out\[92\]$_DFF_P_ _00285_ clknet_leaf_44_clk net465
+ _14514_ VDD VSS DFF_X1
Xtext_out\[93\]$_DFF_P_ _00286_ clknet_leaf_46_clk net466
+ _14515_ VDD VSS DFF_X1
Xtext_out\[94\]$_DFF_P_ _00287_ clknet_leaf_46_clk net467
+ _14516_ VDD VSS DFF_X1
Xtext_out\[95\]$_DFF_P_ _00288_ clknet_leaf_45_clk net468
+ _14517_ VDD VSS DFF_X1
Xtext_out\[96\]$_DFF_P_ _00161_ clknet_leaf_36_clk net469
+ _14518_ VDD VSS DFF_X1
Xtext_out\[97\]$_DFF_P_ _00162_ clknet_leaf_37_clk net470
+ _14519_ VDD VSS DFF_X1
Xtext_out\[98\]$_DFF_P_ _00163_ clknet_leaf_36_clk net471
+ _14520_ VDD VSS DFF_X1
Xtext_out\[99\]$_DFF_P_ _00164_ clknet_leaf_36_clk net472
+ _14521_ VDD VSS DFF_X1
Xtext_out\[9\]$_DFF_P_ _00194_ clknet_leaf_1_clk net473 _14180_
+ VDD VSS DFF_X1
Xu0.r0.out\[24\]$_SDFF_PP1_ _00617_ clknet_leaf_9_clk u0.r0.out\[24\]
+ _00432_ VDD VSS DFF_X1
Xu0.r0.out\[25\]$_SDFF_PP0_ _00618_ clknet_leaf_10_clk u0.r0.out\[25\]
+ _00433_ VDD VSS DFF_X1
Xu0.r0.out\[26\]$_SDFF_PP0_ _00619_ clknet_leaf_8_clk u0.r0.out\[26\]
+ _00434_ VDD VSS DFF_X1
Xu0.r0.out\[27\]$_SDFF_PP0_ _00620_ clknet_leaf_7_clk u0.r0.out\[27\]
+ _00435_ VDD VSS DFF_X1
Xu0.r0.out\[28\]$_SDFF_PP0_ _00621_ clknet_leaf_10_clk u0.r0.out\[28\]
+ _00436_ VDD VSS DFF_X1
Xu0.r0.out\[29\]$_SDFF_PP0_ _00622_ clknet_leaf_8_clk u0.r0.out\[29\]
+ _00437_ VDD VSS DFF_X1
Xu0.r0.out\[30\]$_SDFF_PP0_ _00623_ clknet_leaf_8_clk u0.r0.out\[30\]
+ _00438_ VDD VSS DFF_X1
Xu0.r0.out\[31\]$_SDFF_PP0_ _00624_ clknet_leaf_8_clk u0.r0.out\[31\]
+ _00439_ VDD VSS DFF_X1
Xu0.r0.rcnt\[0\]$_SDFF_PP0_ _00625_ clknet_leaf_6_clk u0.r0.rcnt\[0\]
+ u0.r0.rcnt_next\[0\] VDD VSS DFF_X2
Xu0.r0.rcnt\[1\]$_SDFF_PP0_ _00626_ clknet_leaf_6_clk u0.r0.rcnt\[1\]
+ _15322_ VDD VSS DFF_X2
Xu0.r0.rcnt\[2\]$_SDFF_PP0_ _00627_ clknet_leaf_6_clk u0.r0.rcnt\[2\]
+ _14179_ VDD VSS DFF_X2
Xu0.r0.rcnt\[3\]$_SDFF_PP0_ _00628_ clknet_leaf_7_clk u0.r0.rcnt\[3\]
+ _14522_ VDD VSS DFF_X1
Xu0.u0.d\[0\]$_DFF_P_ _00000_ clknet_leaf_87_clk u0.subword\[24\]
+ _14523_ VDD VSS DFF_X1
Xu0.u0.d\[1\]$_DFF_P_ _00001_ clknet_leaf_91_clk u0.subword\[25\]
+ _14524_ VDD VSS DFF_X2
Xu0.u0.d\[2\]$_DFF_P_ _00002_ clknet_leaf_91_clk u0.subword\[26\]
+ _14525_ VDD VSS DFF_X2
Xu0.u0.d\[3\]$_DFF_P_ _00003_ clknet_leaf_90_clk u0.subword\[27\]
+ _14526_ VDD VSS DFF_X2
Xu0.u0.d\[4\]$_DFF_P_ _00004_ clknet_leaf_91_clk u0.subword\[28\]
+ _14527_ VDD VSS DFF_X1
Xu0.u0.d\[5\]$_DFF_P_ _00005_ clknet_leaf_90_clk u0.subword\[29\]
+ _14528_ VDD VSS DFF_X1
Xu0.u0.d\[6\]$_DFF_P_ _00006_ clknet_leaf_93_clk u0.subword\[30\]
+ _14529_ VDD VSS DFF_X1
Xu0.u0.d\[7\]$_DFF_P_ _00007_ clknet_leaf_90_clk u0.subword\[31\]
+ _14530_ VDD VSS DFF_X1
Xu0.u1.d\[0\]$_DFF_P_ _00008_ clknet_leaf_7_clk u0.subword\[16\]
+ _00425_ VDD VSS DFF_X1
Xu0.u1.d\[1\]$_DFF_P_ _00009_ clknet_leaf_88_clk u0.subword\[17\]
+ _00426_ VDD VSS DFF_X1
Xu0.u1.d\[2\]$_DFF_P_ _00010_ clknet_leaf_85_clk u0.subword\[18\]
+ _00408_ VDD VSS DFF_X1
Xu0.u1.d\[3\]$_DFF_P_ _00011_ clknet_leaf_85_clk u0.subword\[19\]
+ _00427_ VDD VSS DFF_X1
Xu0.u1.d\[4\]$_DFF_P_ _00012_ clknet_leaf_88_clk u0.subword\[20\]
+ _00428_ VDD VSS DFF_X1
Xu0.u1.d\[5\]$_DFF_P_ _00013_ clknet_leaf_91_clk u0.subword\[21\]
+ _00429_ VDD VSS DFF_X1
Xu0.u1.d\[6\]$_DFF_P_ _00014_ clknet_leaf_88_clk u0.subword\[22\]
+ _00430_ VDD VSS DFF_X1
Xu0.u1.d\[7\]$_DFF_P_ _00015_ clknet_leaf_86_clk u0.subword\[23\]
+ _00431_ VDD VSS DFF_X1
Xu0.u2.d\[0\]$_DFF_P_ _00016_ clknet_leaf_27_clk u0.subword\[8\]
+ _00418_ VDD VSS DFF_X2
Xu0.u2.d\[1\]$_DFF_P_ _00017_ clknet_leaf_83_clk u0.subword\[9\]
+ _00419_ VDD VSS DFF_X1
Xu0.u2.d\[2\]$_DFF_P_ _00018_ clknet_leaf_24_clk u0.subword\[10\]
+ _00410_ VDD VSS DFF_X2
Xu0.u2.d\[3\]$_DFF_P_ _00019_ clknet_leaf_84_clk u0.subword\[11\]
+ _00420_ VDD VSS DFF_X1
Xu0.u2.d\[4\]$_DFF_P_ _00020_ clknet_leaf_82_clk u0.subword\[12\]
+ _00421_ VDD VSS DFF_X1
Xu0.u2.d\[5\]$_DFF_P_ _00021_ clknet_leaf_84_clk u0.subword\[13\]
+ _00422_ VDD VSS DFF_X1
Xu0.u2.d\[6\]$_DFF_P_ _00022_ clknet_leaf_8_clk u0.subword\[14\]
+ _00423_ VDD VSS DFF_X1
Xu0.u2.d\[7\]$_DFF_P_ _00023_ clknet_leaf_87_clk u0.subword\[15\]
+ _00424_ VDD VSS DFF_X1
Xu0.u3.d\[0\]$_DFF_P_ _00024_ clknet_leaf_30_clk u0.subword\[0\]
+ _00411_ VDD VSS DFF_X2
Xu0.u3.d\[1\]$_DFF_P_ _00025_ clknet_leaf_24_clk u0.subword\[1\]
+ _00412_ VDD VSS DFF_X1
Xu0.u3.d\[2\]$_DFF_P_ _00026_ clknet_leaf_27_clk u0.subword\[2\]
+ _00409_ VDD VSS DFF_X1
Xu0.u3.d\[3\]$_DFF_P_ _00027_ clknet_leaf_30_clk u0.subword\[3\]
+ _00413_ VDD VSS DFF_X1
Xu0.u3.d\[4\]$_DFF_P_ _00028_ clknet_leaf_33_clk u0.subword\[4\]
+ _00414_ VDD VSS DFF_X1
Xu0.u3.d\[5\]$_DFF_P_ _00029_ clknet_leaf_31_clk u0.subword\[5\]
+ _00415_ VDD VSS DFF_X1
Xu0.u3.d\[6\]$_DFF_P_ _00030_ clknet_leaf_34_clk u0.subword\[6\]
+ _00416_ VDD VSS DFF_X1
Xu0.u3.d\[7\]$_DFF_P_ _00031_ clknet_leaf_30_clk u0.subword\[7\]
+ _00417_ VDD VSS DFF_X1
Xu0.w\[0\]\[0\]$_DFF_P_ _00289_ clknet_leaf_30_clk u0.w\[0\]\[0\]
+ _14531_ VDD VSS DFF_X1
Xu0.w\[0\]\[10\]$_DFF_P_ _00290_ clknet_leaf_24_clk u0.w\[0\]\[10\]
+ _14532_ VDD VSS DFF_X1
Xu0.w\[0\]\[11\]$_DFF_P_ _00291_ clknet_leaf_85_clk u0.w\[0\]\[11\]
+ _14533_ VDD VSS DFF_X1
Xu0.w\[0\]\[12\]$_DFF_P_ _00292_ clknet_leaf_57_clk u0.w\[0\]\[12\]
+ _14534_ VDD VSS DFF_X1
Xu0.w\[0\]\[13\]$_DFF_P_ _00293_ clknet_leaf_85_clk u0.w\[0\]\[13\]
+ _14535_ VDD VSS DFF_X1
Xu0.w\[0\]\[14\]$_DFF_P_ _00294_ clknet_leaf_8_clk u0.w\[0\]\[14\]
+ _14536_ VDD VSS DFF_X1
Xu0.w\[0\]\[15\]$_DFF_P_ _00295_ clknet_leaf_87_clk u0.w\[0\]\[15\]
+ _14537_ VDD VSS DFF_X1
Xu0.w\[0\]\[16\]$_DFF_P_ _00296_ clknet_leaf_7_clk u0.w\[0\]\[16\]
+ _14538_ VDD VSS DFF_X1
Xu0.w\[0\]\[17\]$_DFF_P_ _00297_ clknet_leaf_87_clk u0.w\[0\]\[17\]
+ _14539_ VDD VSS DFF_X1
Xu0.w\[0\]\[18\]$_DFF_P_ _00298_ clknet_leaf_86_clk u0.w\[0\]\[18\]
+ _14540_ VDD VSS DFF_X1
Xu0.w\[0\]\[19\]$_DFF_P_ _00299_ clknet_leaf_86_clk u0.w\[0\]\[19\]
+ _14541_ VDD VSS DFF_X1
Xu0.w\[0\]\[1\]$_DFF_P_ _00300_ clknet_leaf_32_clk u0.w\[0\]\[1\]
+ _14542_ VDD VSS DFF_X1
Xu0.w\[0\]\[20\]$_DFF_P_ _00301_ clknet_leaf_91_clk u0.w\[0\]\[20\]
+ _14543_ VDD VSS DFF_X1
Xu0.w\[0\]\[21\]$_DFF_P_ _00302_ clknet_leaf_92_clk u0.w\[0\]\[21\]
+ _14544_ VDD VSS DFF_X1
Xu0.w\[0\]\[22\]$_DFF_P_ _00303_ clknet_leaf_88_clk u0.w\[0\]\[22\]
+ _14545_ VDD VSS DFF_X1
Xu0.w\[0\]\[23\]$_DFF_P_ _00304_ clknet_leaf_87_clk u0.w\[0\]\[23\]
+ _14546_ VDD VSS DFF_X1
Xu0.w\[0\]\[24\]$_DFF_P_ _00305_ clknet_leaf_79_clk u0.w\[0\]\[24\]
+ _14547_ VDD VSS DFF_X1
Xu0.w\[0\]\[25\]$_DFF_P_ _00306_ clknet_leaf_80_clk u0.w\[0\]\[25\]
+ _14548_ VDD VSS DFF_X1
Xu0.w\[0\]\[26\]$_DFF_P_ _00307_ clknet_leaf_79_clk u0.w\[0\]\[26\]
+ _14549_ VDD VSS DFF_X1
Xu0.w\[0\]\[27\]$_DFF_P_ _00308_ clknet_leaf_78_clk u0.w\[0\]\[27\]
+ _14550_ VDD VSS DFF_X1
Xu0.w\[0\]\[28\]$_DFF_P_ _00309_ clknet_leaf_76_clk u0.w\[0\]\[28\]
+ _14551_ VDD VSS DFF_X1
Xu0.w\[0\]\[29\]$_DFF_P_ _00310_ clknet_leaf_76_clk u0.w\[0\]\[29\]
+ _14552_ VDD VSS DFF_X1
Xu0.w\[0\]\[2\]$_DFF_P_ _00311_ clknet_leaf_30_clk u0.w\[0\]\[2\]
+ _14553_ VDD VSS DFF_X1
Xu0.w\[0\]\[30\]$_DFF_P_ _00312_ clknet_leaf_79_clk u0.w\[0\]\[30\]
+ _14554_ VDD VSS DFF_X1
Xu0.w\[0\]\[31\]$_DFF_P_ _00313_ clknet_leaf_80_clk u0.w\[0\]\[31\]
+ _14555_ VDD VSS DFF_X1
Xu0.w\[0\]\[3\]$_DFF_P_ _00314_ clknet_leaf_33_clk u0.w\[0\]\[3\]
+ _14556_ VDD VSS DFF_X1
Xu0.w\[0\]\[4\]$_DFF_P_ _00315_ clknet_leaf_33_clk u0.w\[0\]\[4\]
+ _14557_ VDD VSS DFF_X1
Xu0.w\[0\]\[5\]$_DFF_P_ _00316_ clknet_leaf_31_clk u0.w\[0\]\[5\]
+ _14558_ VDD VSS DFF_X1
Xu0.w\[0\]\[6\]$_DFF_P_ _00317_ clknet_leaf_33_clk u0.w\[0\]\[6\]
+ _14559_ VDD VSS DFF_X1
Xu0.w\[0\]\[7\]$_DFF_P_ _00318_ clknet_leaf_31_clk u0.w\[0\]\[7\]
+ _14560_ VDD VSS DFF_X1
Xu0.w\[0\]\[8\]$_DFF_P_ _00319_ clknet_leaf_27_clk u0.w\[0\]\[8\]
+ _14561_ VDD VSS DFF_X1
Xu0.w\[0\]\[9\]$_DFF_P_ _00320_ clknet_leaf_82_clk u0.w\[0\]\[9\]
+ _14562_ VDD VSS DFF_X1
Xu0.w\[1\]\[0\]$_DFF_P_ _00321_ clknet_leaf_29_clk u0.w\[1\]\[0\]
+ _14563_ VDD VSS DFF_X1
Xu0.w\[1\]\[10\]$_DFF_P_ _00322_ clknet_leaf_56_clk u0.w\[1\]\[10\]
+ _14564_ VDD VSS DFF_X1
Xu0.w\[1\]\[11\]$_DFF_P_ _00323_ clknet_leaf_83_clk u0.w\[1\]\[11\]
+ _14565_ VDD VSS DFF_X1
Xu0.w\[1\]\[12\]$_DFF_P_ _00324_ clknet_leaf_82_clk u0.w\[1\]\[12\]
+ _14566_ VDD VSS DFF_X1
Xu0.w\[1\]\[13\]$_DFF_P_ _00325_ clknet_leaf_84_clk u0.w\[1\]\[13\]
+ _14567_ VDD VSS DFF_X1
Xu0.w\[1\]\[14\]$_DFF_P_ _00326_ clknet_leaf_9_clk u0.w\[1\]\[14\]
+ _14568_ VDD VSS DFF_X1
Xu0.w\[1\]\[15\]$_DFF_P_ _00327_ clknet_leaf_87_clk u0.w\[1\]\[15\]
+ _14569_ VDD VSS DFF_X1
Xu0.w\[1\]\[16\]$_DFF_P_ _00328_ clknet_leaf_7_clk u0.w\[1\]\[16\]
+ _14570_ VDD VSS DFF_X1
Xu0.w\[1\]\[17\]$_DFF_P_ _00329_ clknet_leaf_86_clk u0.w\[1\]\[17\]
+ _14571_ VDD VSS DFF_X1
Xu0.w\[1\]\[18\]$_DFF_P_ _00330_ clknet_leaf_82_clk u0.w\[1\]\[18\]
+ _14572_ VDD VSS DFF_X1
Xu0.w\[1\]\[19\]$_DFF_P_ _00331_ clknet_leaf_83_clk u0.w\[1\]\[19\]
+ _14573_ VDD VSS DFF_X1
Xu0.w\[1\]\[1\]$_DFF_P_ _00332_ clknet_leaf_32_clk u0.w\[1\]\[1\]
+ _14574_ VDD VSS DFF_X1
Xu0.w\[1\]\[20\]$_DFF_P_ _00333_ clknet_leaf_92_clk u0.w\[1\]\[20\]
+ _14575_ VDD VSS DFF_X1
Xu0.w\[1\]\[21\]$_DFF_P_ _00334_ clknet_leaf_92_clk u0.w\[1\]\[21\]
+ _14576_ VDD VSS DFF_X1
Xu0.w\[1\]\[22\]$_DFF_P_ _00335_ clknet_leaf_87_clk u0.w\[1\]\[22\]
+ _14577_ VDD VSS DFF_X1
Xu0.w\[1\]\[23\]$_DFF_P_ _00336_ clknet_leaf_80_clk u0.w\[1\]\[23\]
+ _14578_ VDD VSS DFF_X1
Xu0.w\[1\]\[24\]$_DFF_P_ _00337_ clknet_leaf_50_clk u0.w\[1\]\[24\]
+ _14579_ VDD VSS DFF_X1
Xu0.w\[1\]\[25\]$_DFF_P_ _00338_ clknet_leaf_48_clk u0.w\[1\]\[25\]
+ _14580_ VDD VSS DFF_X1
Xu0.w\[1\]\[26\]$_DFF_P_ _00339_ clknet_leaf_62_clk u0.w\[1\]\[26\]
+ _14581_ VDD VSS DFF_X1
Xu0.w\[1\]\[27\]$_DFF_P_ _00340_ clknet_leaf_63_clk u0.w\[1\]\[27\]
+ _14582_ VDD VSS DFF_X1
Xu0.w\[1\]\[28\]$_DFF_P_ _00341_ clknet_leaf_48_clk u0.w\[1\]\[28\]
+ _14583_ VDD VSS DFF_X1
Xu0.w\[1\]\[29\]$_DFF_P_ _00342_ clknet_leaf_63_clk u0.w\[1\]\[29\]
+ _14584_ VDD VSS DFF_X1
Xu0.w\[1\]\[2\]$_DFF_P_ _00343_ clknet_leaf_34_clk u0.w\[1\]\[2\]
+ _14585_ VDD VSS DFF_X1
Xu0.w\[1\]\[30\]$_DFF_P_ _00344_ clknet_leaf_63_clk u0.w\[1\]\[30\]
+ _14586_ VDD VSS DFF_X1
Xu0.w\[1\]\[31\]$_DFF_P_ _00345_ clknet_leaf_50_clk u0.w\[1\]\[31\]
+ _14587_ VDD VSS DFF_X1
Xu0.w\[1\]\[3\]$_DFF_P_ _00346_ clknet_leaf_31_clk u0.w\[1\]\[3\]
+ _14588_ VDD VSS DFF_X1
Xu0.w\[1\]\[4\]$_DFF_P_ _00347_ clknet_leaf_33_clk u0.w\[1\]\[4\]
+ _14589_ VDD VSS DFF_X1
Xu0.w\[1\]\[5\]$_DFF_P_ _00348_ clknet_leaf_54_clk u0.w\[1\]\[5\]
+ _14590_ VDD VSS DFF_X1
Xu0.w\[1\]\[6\]$_DFF_P_ _00349_ clknet_leaf_34_clk u0.w\[1\]\[6\]
+ _14591_ VDD VSS DFF_X1
Xu0.w\[1\]\[7\]$_DFF_P_ _00350_ clknet_leaf_55_clk u0.w\[1\]\[7\]
+ _14592_ VDD VSS DFF_X1
Xu0.w\[1\]\[8\]$_DFF_P_ _00351_ clknet_leaf_29_clk u0.w\[1\]\[8\]
+ _14593_ VDD VSS DFF_X1
Xu0.w\[1\]\[9\]$_DFF_P_ _00352_ clknet_leaf_83_clk u0.w\[1\]\[9\]
+ _14594_ VDD VSS DFF_X1
Xu0.w\[2\]\[0\]$_DFF_P_ _00353_ clknet_leaf_55_clk u0.w\[2\]\[0\]
+ _14595_ VDD VSS DFF_X1
Xu0.w\[2\]\[10\]$_DFF_P_ _00354_ clknet_leaf_56_clk u0.w\[2\]\[10\]
+ _14596_ VDD VSS DFF_X1
Xu0.w\[2\]\[11\]$_DFF_P_ _00355_ clknet_leaf_86_clk u0.w\[2\]\[11\]
+ _14597_ VDD VSS DFF_X1
Xu0.w\[2\]\[12\]$_DFF_P_ _00356_ clknet_leaf_82_clk u0.w\[2\]\[12\]
+ _14598_ VDD VSS DFF_X1
Xu0.w\[2\]\[13\]$_DFF_P_ _00357_ clknet_leaf_85_clk u0.w\[2\]\[13\]
+ _14599_ VDD VSS DFF_X1
Xu0.w\[2\]\[14\]$_DFF_P_ _00358_ clknet_leaf_84_clk u0.w\[2\]\[14\]
+ _14600_ VDD VSS DFF_X1
Xu0.w\[2\]\[15\]$_DFF_P_ _00359_ clknet_leaf_91_clk u0.w\[2\]\[15\]
+ _14601_ VDD VSS DFF_X1
Xu0.w\[2\]\[16\]$_DFF_P_ _00360_ clknet_leaf_84_clk u0.w\[2\]\[16\]
+ _14602_ VDD VSS DFF_X1
Xu0.w\[2\]\[17\]$_DFF_P_ _00361_ clknet_leaf_86_clk u0.w\[2\]\[17\]
+ _14603_ VDD VSS DFF_X1
Xu0.w\[2\]\[18\]$_DFF_P_ _00362_ clknet_leaf_82_clk u0.w\[2\]\[18\]
+ _14604_ VDD VSS DFF_X1
Xu0.w\[2\]\[19\]$_DFF_P_ _00363_ clknet_leaf_81_clk u0.w\[2\]\[19\]
+ _14605_ VDD VSS DFF_X1
Xu0.w\[2\]\[1\]$_DFF_P_ _00364_ clknet_leaf_32_clk u0.w\[2\]\[1\]
+ _14606_ VDD VSS DFF_X1
Xu0.w\[2\]\[20\]$_DFF_P_ _00365_ clknet_leaf_92_clk u0.w\[2\]\[20\]
+ _14607_ VDD VSS DFF_X1
Xu0.w\[2\]\[21\]$_DFF_P_ _00366_ clknet_leaf_91_clk u0.w\[2\]\[21\]
+ _14608_ VDD VSS DFF_X1
Xu0.w\[2\]\[22\]$_DFF_P_ _00367_ clknet_leaf_88_clk u0.w\[2\]\[22\]
+ _14609_ VDD VSS DFF_X1
Xu0.w\[2\]\[23\]$_DFF_P_ _00368_ clknet_leaf_58_clk u0.w\[2\]\[23\]
+ _14610_ VDD VSS DFF_X1
Xu0.w\[2\]\[24\]$_DFF_P_ _00369_ clknet_leaf_51_clk u0.w\[2\]\[24\]
+ _14611_ VDD VSS DFF_X1
Xu0.w\[2\]\[25\]$_DFF_P_ _00370_ clknet_leaf_50_clk u0.w\[2\]\[25\]
+ _14612_ VDD VSS DFF_X1
Xu0.w\[2\]\[26\]$_DFF_P_ _00371_ clknet_leaf_61_clk u0.w\[2\]\[26\]
+ _14613_ VDD VSS DFF_X1
Xu0.w\[2\]\[27\]$_DFF_P_ _00372_ clknet_leaf_62_clk u0.w\[2\]\[27\]
+ _14614_ VDD VSS DFF_X1
Xu0.w\[2\]\[28\]$_DFF_P_ _00373_ clknet_leaf_50_clk u0.w\[2\]\[28\]
+ _14615_ VDD VSS DFF_X1
Xu0.w\[2\]\[29\]$_DFF_P_ _00374_ clknet_leaf_62_clk u0.w\[2\]\[29\]
+ _14616_ VDD VSS DFF_X1
Xu0.w\[2\]\[2\]$_DFF_P_ _00375_ clknet_leaf_30_clk u0.w\[2\]\[2\]
+ _14617_ VDD VSS DFF_X2
Xu0.w\[2\]\[30\]$_DFF_P_ _00376_ clknet_leaf_62_clk u0.w\[2\]\[30\]
+ _14618_ VDD VSS DFF_X1
Xu0.w\[2\]\[31\]$_DFF_P_ _00377_ clknet_leaf_50_clk u0.w\[2\]\[31\]
+ _14619_ VDD VSS DFF_X1
Xu0.w\[2\]\[3\]$_DFF_P_ _00378_ clknet_leaf_31_clk u0.w\[2\]\[3\]
+ _14620_ VDD VSS DFF_X1
Xu0.w\[2\]\[4\]$_DFF_P_ _00379_ clknet_leaf_33_clk u0.w\[2\]\[4\]
+ _14621_ VDD VSS DFF_X1
Xu0.w\[2\]\[5\]$_DFF_P_ _00380_ clknet_leaf_54_clk u0.w\[2\]\[5\]
+ _14622_ VDD VSS DFF_X1
Xu0.w\[2\]\[6\]$_DFF_P_ _00381_ clknet_leaf_33_clk u0.w\[2\]\[6\]
+ _14623_ VDD VSS DFF_X1
Xu0.w\[2\]\[7\]$_DFF_P_ _00382_ clknet_leaf_54_clk u0.w\[2\]\[7\]
+ _14624_ VDD VSS DFF_X1
Xu0.w\[2\]\[8\]$_DFF_P_ _00383_ clknet_leaf_80_clk u0.w\[2\]\[8\]
+ _14625_ VDD VSS DFF_X1
Xu0.w\[2\]\[9\]$_DFF_P_ _00384_ clknet_leaf_83_clk u0.w\[2\]\[9\]
+ _14626_ VDD VSS DFF_X1
Xu0.w\[3\]\[0\]$_DFF_P_ net49 clknet_leaf_27_clk u0.tmp_w\[0\]
+ _14627_ VDD VSS DFF_X1
Xu0.w\[3\]\[10\]$_DFF_P_ _14717_ clknet_leaf_3_clk u0.tmp_w\[10\]
+ _14628_ VDD VSS DFF_X1
Xu0.w\[3\]\[11\]$_DFF_P_ _00385_ clknet_leaf_4_clk u0.tmp_w\[11\]
+ _14629_ VDD VSS DFF_X1
Xu0.w\[3\]\[12\]$_DFF_P_ _00386_ clknet_leaf_4_clk u0.tmp_w\[12\]
+ _14630_ VDD VSS DFF_X1
Xu0.w\[3\]\[13\]$_DFF_P_ _00387_ clknet_leaf_4_clk u0.tmp_w\[13\]
+ _14631_ VDD VSS DFF_X1
Xu0.w\[3\]\[14\]$_DFF_P_ _00388_ clknet_leaf_3_clk u0.tmp_w\[14\]
+ _14632_ VDD VSS DFF_X1
Xu0.w\[3\]\[15\]$_DFF_P_ _00389_ clknet_leaf_4_clk u0.tmp_w\[15\]
+ _14633_ VDD VSS DFF_X1
Xu0.w\[3\]\[16\]$_DFF_P_ net587 clknet_leaf_89_clk u0.tmp_w\[16\]
+ _14634_ VDD VSS DFF_X1
Xu0.w\[3\]\[17\]$_DFF_P_ net782 clknet_leaf_89_clk u0.tmp_w\[17\]
+ _14635_ VDD VSS DFF_X1
Xu0.w\[3\]\[18\]$_DFF_P_ _14683_ clknet_leaf_90_clk u0.tmp_w\[18\]
+ _14636_ VDD VSS DFF_X1
Xu0.w\[3\]\[19\]$_DFF_P_ _00390_ clknet_leaf_90_clk u0.tmp_w\[19\]
+ _14637_ VDD VSS DFF_X1
Xu0.w\[3\]\[1\]$_DFF_P_ net27 clknet_leaf_24_clk u0.tmp_w\[1\]
+ _14638_ VDD VSS DFF_X1
Xu0.w\[3\]\[20\]$_DFF_P_ _00391_ clknet_leaf_89_clk u0.tmp_w\[20\]
+ _14639_ VDD VSS DFF_X1
Xu0.w\[3\]\[21\]$_DFF_P_ _00392_ clknet_leaf_90_clk u0.tmp_w\[21\]
+ _14640_ VDD VSS DFF_X1
Xu0.w\[3\]\[22\]$_DFF_P_ _00393_ clknet_leaf_90_clk u0.tmp_w\[22\]
+ _14641_ VDD VSS DFF_X1
Xu0.w\[3\]\[23\]$_DFF_P_ _00394_ clknet_leaf_90_clk u0.tmp_w\[23\]
+ _14642_ VDD VSS DFF_X1
Xu0.w\[3\]\[24\]$_DFF_P_ _14761_ clknet_leaf_11_clk u0.tmp_w\[24\]
+ _14643_ VDD VSS DFF_X1
Xu0.w\[3\]\[25\]$_DFF_P_ _14760_ clknet_leaf_14_clk u0.tmp_w\[25\]
+ _14644_ VDD VSS DFF_X1
Xu0.w\[3\]\[26\]$_DFF_P_ _14780_ clknet_leaf_14_clk u0.tmp_w\[26\]
+ _14645_ VDD VSS DFF_X1
Xu0.w\[3\]\[27\]$_DFF_P_ _00395_ clknet_leaf_14_clk u0.tmp_w\[27\]
+ _14646_ VDD VSS DFF_X1
Xu0.w\[3\]\[28\]$_DFF_P_ _00396_ clknet_leaf_28_clk u0.tmp_w\[28\]
+ _14647_ VDD VSS DFF_X1
Xu0.w\[3\]\[29\]$_DFF_P_ _00397_ clknet_leaf_11_clk u0.tmp_w\[29\]
+ _14648_ VDD VSS DFF_X1
Xu0.w\[3\]\[2\]$_DFF_P_ _14751_ clknet_leaf_24_clk u0.tmp_w\[2\]
+ _14649_ VDD VSS DFF_X1
Xu0.w\[3\]\[30\]$_DFF_P_ _00398_ clknet_leaf_9_clk u0.tmp_w\[30\]
+ _14650_ VDD VSS DFF_X1
Xu0.w\[3\]\[31\]$_DFF_P_ _00399_ clknet_leaf_14_clk u0.tmp_w\[31\]
+ _14651_ VDD VSS DFF_X1
Xu0.w\[3\]\[3\]$_DFF_P_ _00400_ clknet_leaf_27_clk u0.tmp_w\[3\]
+ _14652_ VDD VSS DFF_X1
Xu0.w\[3\]\[4\]$_DFF_P_ _00401_ clknet_leaf_25_clk u0.tmp_w\[4\]
+ _14653_ VDD VSS DFF_X1
Xu0.w\[3\]\[5\]$_DFF_P_ _00402_ clknet_leaf_25_clk u0.tmp_w\[5\]
+ _14654_ VDD VSS DFF_X1
Xu0.w\[3\]\[6\]$_DFF_P_ _00403_ clknet_leaf_25_clk u0.tmp_w\[6\]
+ _14655_ VDD VSS DFF_X1
Xu0.w\[3\]\[7\]$_DFF_P_ _00404_ clknet_leaf_25_clk u0.tmp_w\[7\]
+ _14656_ VDD VSS DFF_X2
Xu0.w\[3\]\[8\]$_DFF_P_ net709 clknet_leaf_4_clk u0.tmp_w\[8\]
+ _14657_ VDD VSS DFF_X1
Xu0.w\[3\]\[9\]$_DFF_P_ net14 clknet_leaf_3_clk u0.tmp_w\[9\]
+ _14178_ VDD VSS DFF_X1
Xclone102 _09734_ net102 VDD VSS BUF_X4
Xclone103 _09735_ net103 VDD VSS BUF_X8
Xclone104 net1050 net104 VDD VSS BUF_X8
Xclone107 _09001_ net493 net107 VDD VSS NOR2_X4
Xclone108 _01602_ _01599_ net108 VDD VSS NOR2_X2
Xclone157 _15002_ net157 VDD VSS BUF_X2
Xclone158 _13176_ net158 VDD VSS BUF_X4
Xclone159 _13177_ net159 VDD VSS BUF_X4
Xclone160 _13178_ net160 VDD VSS BUF_X8
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Right_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Right_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Right_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Right_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Right_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Right_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Right_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Right_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Right_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Right_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Right_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Right_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Right_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Right_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Right_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Right_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Right_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Right_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Right_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Right_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Right_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Right_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Right_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Right_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Right_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Right_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Right_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Right_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Right_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Right_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Right_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Right_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Right_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Right_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Right_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Right_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Right_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Right_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Right_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Right_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Right_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Right_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Right_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Right_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Right_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Right_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Right_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Right_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Right_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Right_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Right_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Right_103 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Right_104 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Right_105 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Right_106 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Right_107 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Right_108 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Right_109 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Right_110 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Right_111 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Right_112 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Right_113 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Right_114 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Right_115 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Right_116 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Right_117 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Right_118 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Right_119 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Right_120 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Right_121 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Right_122 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Right_123 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Right_124 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Right_125 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Right_126 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Right_127 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Right_128 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Right_129 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Right_130 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Right_131 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Right_132 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Right_133 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Right_134 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Right_135 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Right_136 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Right_137 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Right_138 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Right_139 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Right_140 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Right_141 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Right_142 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Right_143 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Right_144 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Right_145 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Right_146 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Right_147 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Right_148 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Right_149 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Right_150 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Right_151 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Right_152 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Right_153 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Right_154 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Right_155 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Right_156 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Right_157 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Right_158 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Right_159 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Right_160 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Right_161 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Right_162 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Right_163 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_164 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_165 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_166 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_167 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_168 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_169 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_170 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_171 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_172 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_173 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_174 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_175 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_176 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_177 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_178 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_179 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_180 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_181 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_182 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_183 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_184 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_185 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_186 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_187 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_188 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_189 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_190 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_191 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_192 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_193 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_194 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_195 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_196 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_197 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_198 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_199 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_200 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_201 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_202 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_203 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_204 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_205 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_206 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_207 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_208 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_209 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_210 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_211 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_212 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_213 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_214 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_215 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Left_216 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Left_217 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Left_218 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Left_219 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Left_220 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Left_221 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Left_222 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Left_223 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Left_224 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Left_225 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Left_226 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Left_227 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Left_228 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Left_229 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Left_230 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Left_231 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Left_232 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Left_233 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Left_234 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Left_235 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Left_236 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Left_237 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Left_238 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Left_239 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Left_240 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Left_241 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Left_242 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Left_243 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Left_244 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Left_245 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Left_246 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Left_247 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Left_248 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Left_249 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Left_250 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Left_251 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Left_252 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Left_253 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Left_254 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Left_255 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Left_256 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Left_257 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Left_258 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Left_259 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Left_260 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Left_261 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Left_262 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Left_263 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Left_264 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Left_265 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Left_266 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Left_267 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Left_268 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Left_269 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Left_270 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Left_271 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Left_272 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Left_273 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Left_274 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Left_275 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Left_276 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Left_277 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Left_278 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Left_279 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Left_280 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_117_Left_281 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_118_Left_282 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_119_Left_283 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_120_Left_284 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_121_Left_285 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_122_Left_286 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_123_Left_287 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_124_Left_288 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_125_Left_289 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_126_Left_290 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_127_Left_291 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_128_Left_292 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_129_Left_293 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_130_Left_294 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_131_Left_295 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_132_Left_296 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_133_Left_297 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_134_Left_298 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_135_Left_299 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_136_Left_300 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_137_Left_301 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_138_Left_302 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_139_Left_303 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_140_Left_304 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_141_Left_305 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_142_Left_306 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_143_Left_307 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_144_Left_308 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_145_Left_309 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_146_Left_310 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_147_Left_311 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_148_Left_312 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_149_Left_313 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_150_Left_314 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_151_Left_315 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_152_Left_316 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_153_Left_317 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_154_Left_318 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_155_Left_319 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_156_Left_320 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_157_Left_321 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_158_Left_322 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_159_Left_323 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_160_Left_324 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_161_Left_325 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_162_Left_326 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_163_Left_327 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_328 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_2_329 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_4_330 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_6_331 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_8_332 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_10_333 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_12_334 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_14_335 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_16_336 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_18_337 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_20_338 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_22_339 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_24_340 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_26_341 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_28_342 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_30_343 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_32_344 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_34_345 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_36_346 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_38_347 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_40_348 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_42_349 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_44_350 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_46_351 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_48_352 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_50_353 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_52_354 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_54_355 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_56_356 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_58_357 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_60_358 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_62_359 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_64_360 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_66_361 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_68_362 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_70_363 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_72_364 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_74_365 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_76_366 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_78_367 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_80_368 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_82_369 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_84_370 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_86_371 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_88_372 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_90_373 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_92_374 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_94_375 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_96_376 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_98_377 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_100_378 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_102_379 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_104_380 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_106_381 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_108_382 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_110_383 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_112_384 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_114_385 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_116_386 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_118_387 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_120_388 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_122_389 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_124_390 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_126_391 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_128_392 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_130_393 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_132_394 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_134_395 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_136_396 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_138_397 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_140_398 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_142_399 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_144_400 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_146_401 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_148_402 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_150_403 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_152_404 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_154_405 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_156_406 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_158_407 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_160_408 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_162_409 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_163_410 VDD VSS TAPCELL_X1
Xinput1 key[0] net9 VDD VSS BUF_X2
Xinput2 key[100] net10 VDD VSS BUF_X1
Xinput3 key[101] net11 VDD VSS BUF_X1
Xinput4 key[102] net17 VDD VSS BUF_X1
Xinput5 key[103] net19 VDD VSS BUF_X1
Xinput6 key[104] net20 VDD VSS BUF_X1
Xinput7 key[105] net21 VDD VSS BUF_X2
Xinput8 key[106] net22 VDD VSS BUF_X1
Xinput9 key[107] net23 VDD VSS BUF_X1
Xinput10 key[108] net24 VDD VSS CLKBUF_X2
Xinput11 key[109] net25 VDD VSS BUF_X1
Xinput12 key[10] net26 VDD VSS CLKBUF_X2
Xinput13 key[110] net30 VDD VSS CLKBUF_X2
Xinput14 key[111] net31 VDD VSS BUF_X1
Xinput15 key[112] net33 VDD VSS BUF_X1
Xinput16 key[113] net34 VDD VSS BUF_X1
Xinput17 key[114] net35 VDD VSS BUF_X1
Xinput18 key[115] net38 VDD VSS BUF_X1
Xinput19 key[116] net40 VDD VSS BUF_X1
Xinput20 key[117] net41 VDD VSS BUF_X1
Xinput21 key[118] net44 VDD VSS CLKBUF_X2
Xinput22 key[119] net45 VDD VSS BUF_X1
Xinput23 key[11] net46 VDD VSS BUF_X2
Xinput24 key[120] net47 VDD VSS BUF_X1
Xinput25 key[121] net48 VDD VSS CLKBUF_X2
Xinput26 key[122] net52 VDD VSS BUF_X1
Xinput27 key[123] net53 VDD VSS BUF_X1
Xinput28 key[124] net54 VDD VSS BUF_X1
Xinput29 key[125] net55 VDD VSS BUF_X1
Xinput30 key[126] net59 VDD VSS BUF_X1
Xinput31 key[127] net60 VDD VSS BUF_X1
Xinput32 key[12] net61 VDD VSS BUF_X1
Xinput33 key[13] net62 VDD VSS BUF_X1
Xinput34 key[14] net63 VDD VSS BUF_X1
Xinput35 key[15] net64 VDD VSS BUF_X2
Xinput36 key[16] net65 VDD VSS BUF_X1
Xinput37 key[17] net66 VDD VSS BUF_X1
Xinput38 key[18] net67 VDD VSS BUF_X1
Xinput39 key[19] net69 VDD VSS BUF_X1
Xinput40 key[1] net70 VDD VSS BUF_X2
Xinput41 key[20] net71 VDD VSS BUF_X1
Xinput42 key[21] net72 VDD VSS CLKBUF_X2
Xinput43 key[22] net73 VDD VSS BUF_X1
Xinput44 key[23] net74 VDD VSS BUF_X1
Xinput45 key[24] net75 VDD VSS BUF_X1
Xinput46 key[25] net76 VDD VSS BUF_X2
Xinput47 key[26] net77 VDD VSS BUF_X2
Xinput48 key[28] net78 VDD VSS BUF_X1
Xinput49 key[29] net79 VDD VSS BUF_X1
Xinput50 key[2] net80 VDD VSS CLKBUF_X2
Xinput51 key[30] net81 VDD VSS BUF_X1
Xinput52 key[31] net82 VDD VSS BUF_X2
Xinput53 key[32] net89 VDD VSS BUF_X1
Xinput54 key[33] net94 VDD VSS BUF_X1
Xinput55 key[34] net105 VDD VSS BUF_X1
Xinput56 key[35] net110 VDD VSS BUF_X1
Xinput57 key[36] net111 VDD VSS BUF_X1
Xinput58 key[37] net112 VDD VSS BUF_X1
Xinput59 key[38] net113 VDD VSS BUF_X1
Xinput60 key[39] net114 VDD VSS BUF_X1
Xinput61 key[3] net116 VDD VSS BUF_X2
Xinput62 key[40] net117 VDD VSS BUF_X1
Xinput63 key[41] net118 VDD VSS BUF_X1
Xinput64 key[42] net119 VDD VSS CLKBUF_X2
Xinput65 key[43] net120 VDD VSS BUF_X1
Xinput66 key[44] net121 VDD VSS BUF_X1
Xinput67 key[45] net122 VDD VSS BUF_X1
Xinput68 key[46] net124 VDD VSS BUF_X1
Xinput69 key[47] net129 VDD VSS BUF_X1
Xinput70 key[48] net130 VDD VSS BUF_X1
Xinput71 key[49] net132 VDD VSS BUF_X1
Xinput72 key[4] net133 VDD VSS BUF_X1
Xinput73 key[50] net140 VDD VSS CLKBUF_X2
Xinput74 key[51] net145 VDD VSS CLKBUF_X2
Xinput75 key[52] net146 VDD VSS BUF_X1
Xinput76 key[53] net149 VDD VSS BUF_X1
Xinput77 key[54] net150 VDD VSS BUF_X1
Xinput78 key[55] net151 VDD VSS BUF_X1
Xinput79 key[56] net152 VDD VSS BUF_X1
Xinput80 key[57] net154 VDD VSS BUF_X1
Xinput81 key[58] net161 VDD VSS BUF_X1
Xinput82 key[59] net162 VDD VSS BUF_X1
Xinput83 key[5] net163 VDD VSS BUF_X1
Xinput84 key[60] net164 VDD VSS BUF_X1
Xinput85 key[61] net165 VDD VSS BUF_X1
Xinput86 key[62] net166 VDD VSS BUF_X1
Xinput87 key[63] net167 VDD VSS BUF_X1
Xinput88 key[64] net172 VDD VSS BUF_X1
Xinput89 key[65] net173 VDD VSS BUF_X1
Xinput90 key[66] net174 VDD VSS BUF_X1
Xinput91 key[67] net175 VDD VSS BUF_X1
Xinput92 key[68] net178 VDD VSS BUF_X1
Xinput93 key[69] net179 VDD VSS BUF_X1
Xinput94 key[6] net180 VDD VSS BUF_X1
Xinput95 key[70] net182 VDD VSS BUF_X1
Xinput96 key[71] net183 VDD VSS BUF_X1
Xinput97 key[72] net184 VDD VSS CLKBUF_X2
Xinput98 key[73] net185 VDD VSS BUF_X1
Xinput99 key[74] net186 VDD VSS CLKBUF_X2
Xinput100 key[75] net187 VDD VSS BUF_X1
Xinput101 key[76] net188 VDD VSS BUF_X2
Xinput102 key[77] net189 VDD VSS BUF_X2
Xinput103 key[78] net190 VDD VSS CLKBUF_X2
Xinput104 key[79] net191 VDD VSS BUF_X1
Xinput105 key[7] net192 VDD VSS BUF_X2
Xinput106 key[80] net193 VDD VSS CLKBUF_X2
Xinput107 key[81] net194 VDD VSS BUF_X1
Xinput108 key[82] net195 VDD VSS CLKBUF_X2
Xinput109 key[83] net196 VDD VSS BUF_X2
Xinput110 key[84] net197 VDD VSS BUF_X1
Xinput111 key[85] net198 VDD VSS BUF_X1
Xinput112 key[86] net199 VDD VSS CLKBUF_X2
Xinput113 key[87] net200 VDD VSS CLKBUF_X2
Xinput114 key[88] net201 VDD VSS BUF_X1
Xinput115 key[89] net202 VDD VSS BUF_X1
Xinput116 key[8] net203 VDD VSS CLKBUF_X3
Xinput117 key[90] net204 VDD VSS BUF_X1
Xinput118 key[91] net205 VDD VSS BUF_X1
Xinput119 key[92] net206 VDD VSS BUF_X1
Xinput120 key[93] net207 VDD VSS BUF_X1
Xinput121 key[94] net208 VDD VSS BUF_X1
Xinput122 key[95] net209 VDD VSS BUF_X1
Xinput123 key[96] net210 VDD VSS BUF_X1
Xinput124 key[97] net211 VDD VSS BUF_X1
Xinput125 key[98] net212 VDD VSS BUF_X1
Xinput126 key[99] net213 VDD VSS BUF_X1
Xinput127 key[9] net214 VDD VSS BUF_X1
Xinput128 ld net215 VDD VSS BUF_X4
Xinput129 rst net216 VDD VSS BUF_X1
Xinput130 text_in[0] net217 VDD VSS BUF_X1
Xinput131 text_in[100] net218 VDD VSS BUF_X1
Xinput132 text_in[101] net219 VDD VSS CLKBUF_X2
Xinput133 text_in[102] net220 VDD VSS BUF_X1
Xinput134 text_in[103] net221 VDD VSS CLKBUF_X2
Xinput135 text_in[104] net222 VDD VSS BUF_X1
Xinput136 text_in[105] net223 VDD VSS BUF_X1
Xinput137 text_in[106] net224 VDD VSS CLKBUF_X2
Xinput138 text_in[107] net225 VDD VSS BUF_X1
Xinput139 text_in[108] net226 VDD VSS BUF_X1
Xinput140 text_in[109] net227 VDD VSS BUF_X1
Xinput141 text_in[10] net228 VDD VSS BUF_X1
Xinput142 text_in[110] net229 VDD VSS BUF_X1
Xinput143 text_in[111] net230 VDD VSS BUF_X1
Xinput144 text_in[112] net231 VDD VSS BUF_X1
Xinput145 text_in[113] net232 VDD VSS BUF_X1
Xinput146 text_in[114] net233 VDD VSS BUF_X1
Xinput147 text_in[115] net234 VDD VSS BUF_X1
Xinput148 text_in[116] net235 VDD VSS BUF_X1
Xinput149 text_in[117] net236 VDD VSS BUF_X1
Xinput150 text_in[118] net237 VDD VSS BUF_X1
Xinput151 text_in[119] net238 VDD VSS BUF_X1
Xinput152 text_in[11] net239 VDD VSS BUF_X1
Xinput153 text_in[120] net240 VDD VSS BUF_X1
Xinput154 text_in[121] net241 VDD VSS CLKBUF_X2
Xinput155 text_in[122] net242 VDD VSS BUF_X1
Xinput156 text_in[123] net243 VDD VSS BUF_X1
Xinput157 text_in[124] net244 VDD VSS BUF_X1
Xinput158 text_in[125] net245 VDD VSS BUF_X1
Xinput159 text_in[126] net246 VDD VSS BUF_X1
Xinput160 text_in[127] net247 VDD VSS BUF_X1
Xinput161 text_in[12] net248 VDD VSS BUF_X1
Xinput162 text_in[13] net249 VDD VSS BUF_X1
Xinput163 text_in[14] net250 VDD VSS BUF_X1
Xinput164 text_in[15] net251 VDD VSS BUF_X1
Xinput165 text_in[16] net252 VDD VSS BUF_X1
Xinput166 text_in[17] net253 VDD VSS BUF_X1
Xinput167 text_in[18] net254 VDD VSS BUF_X1
Xinput168 text_in[19] net255 VDD VSS BUF_X1
Xinput169 text_in[1] net256 VDD VSS BUF_X1
Xinput170 text_in[20] net257 VDD VSS BUF_X1
Xinput171 text_in[21] net258 VDD VSS BUF_X1
Xinput172 text_in[22] net259 VDD VSS BUF_X1
Xinput173 text_in[23] net260 VDD VSS BUF_X1
Xinput174 text_in[24] net261 VDD VSS BUF_X1
Xinput175 text_in[25] net262 VDD VSS BUF_X1
Xinput176 text_in[26] net263 VDD VSS BUF_X1
Xinput177 text_in[27] net264 VDD VSS BUF_X1
Xinput178 text_in[28] net265 VDD VSS BUF_X1
Xinput179 text_in[29] net266 VDD VSS BUF_X1
Xinput180 text_in[2] net267 VDD VSS BUF_X1
Xinput181 text_in[30] net268 VDD VSS BUF_X1
Xinput182 text_in[31] net269 VDD VSS BUF_X1
Xinput183 text_in[32] net270 VDD VSS BUF_X1
Xinput184 text_in[33] net271 VDD VSS BUF_X1
Xinput185 text_in[34] net272 VDD VSS CLKBUF_X2
Xinput186 text_in[35] net273 VDD VSS BUF_X1
Xinput187 text_in[36] net274 VDD VSS BUF_X1
Xinput188 text_in[37] net275 VDD VSS BUF_X1
Xinput189 text_in[38] net276 VDD VSS CLKBUF_X2
Xinput190 text_in[39] net277 VDD VSS BUF_X1
Xinput191 text_in[3] net278 VDD VSS BUF_X1
Xinput192 text_in[40] net279 VDD VSS BUF_X1
Xinput193 text_in[41] net280 VDD VSS BUF_X1
Xinput194 text_in[42] net281 VDD VSS BUF_X1
Xinput195 text_in[43] net282 VDD VSS BUF_X1
Xinput196 text_in[44] net283 VDD VSS BUF_X1
Xinput197 text_in[45] net284 VDD VSS CLKBUF_X2
Xinput198 text_in[46] net285 VDD VSS BUF_X1
Xinput199 text_in[47] net286 VDD VSS BUF_X1
Xinput200 text_in[48] net287 VDD VSS BUF_X1
Xinput201 text_in[49] net288 VDD VSS BUF_X1
Xinput202 text_in[4] net289 VDD VSS BUF_X1
Xinput203 text_in[50] net290 VDD VSS BUF_X1
Xinput204 text_in[51] net291 VDD VSS BUF_X1
Xinput205 text_in[52] net292 VDD VSS BUF_X1
Xinput206 text_in[53] net293 VDD VSS BUF_X1
Xinput207 text_in[54] net294 VDD VSS BUF_X1
Xinput208 text_in[55] net295 VDD VSS BUF_X1
Xinput209 text_in[56] net296 VDD VSS BUF_X1
Xinput210 text_in[57] net297 VDD VSS BUF_X1
Xinput211 text_in[58] net298 VDD VSS BUF_X1
Xinput212 text_in[59] net299 VDD VSS BUF_X1
Xinput213 text_in[5] net300 VDD VSS BUF_X1
Xinput214 text_in[60] net301 VDD VSS BUF_X1
Xinput215 text_in[61] net302 VDD VSS BUF_X1
Xinput216 text_in[62] net303 VDD VSS BUF_X1
Xinput217 text_in[63] net304 VDD VSS BUF_X1
Xinput218 text_in[64] net305 VDD VSS BUF_X1
Xinput219 text_in[65] net306 VDD VSS BUF_X1
Xinput220 text_in[66] net307 VDD VSS BUF_X1
Xinput221 text_in[67] net308 VDD VSS BUF_X1
Xinput222 text_in[68] net309 VDD VSS BUF_X1
Xinput223 text_in[69] net310 VDD VSS BUF_X1
Xinput224 text_in[6] net311 VDD VSS BUF_X1
Xinput225 text_in[70] net312 VDD VSS BUF_X1
Xinput226 text_in[71] net313 VDD VSS BUF_X1
Xinput227 text_in[72] net314 VDD VSS BUF_X1
Xinput228 text_in[73] net315 VDD VSS CLKBUF_X2
Xinput229 text_in[74] net316 VDD VSS BUF_X1
Xinput230 text_in[75] net317 VDD VSS BUF_X1
Xinput231 text_in[76] net318 VDD VSS CLKBUF_X2
Xinput232 text_in[77] net319 VDD VSS CLKBUF_X2
Xinput233 text_in[78] net320 VDD VSS BUF_X1
Xinput234 text_in[79] net321 VDD VSS BUF_X1
Xinput235 text_in[7] net322 VDD VSS BUF_X1
Xinput236 text_in[80] net323 VDD VSS BUF_X1
Xinput237 text_in[81] net324 VDD VSS BUF_X1
Xinput238 text_in[82] net325 VDD VSS BUF_X1
Xinput239 text_in[83] net326 VDD VSS BUF_X1
Xinput240 text_in[84] net327 VDD VSS BUF_X1
Xinput241 text_in[85] net328 VDD VSS BUF_X1
Xinput242 text_in[86] net329 VDD VSS BUF_X1
Xinput243 text_in[87] net330 VDD VSS BUF_X1
Xinput244 text_in[88] net331 VDD VSS BUF_X1
Xinput245 text_in[89] net332 VDD VSS BUF_X1
Xinput246 text_in[8] net333 VDD VSS BUF_X1
Xinput247 text_in[90] net334 VDD VSS BUF_X1
Xinput248 text_in[91] net335 VDD VSS BUF_X1
Xinput249 text_in[92] net336 VDD VSS BUF_X1
Xinput250 text_in[93] net337 VDD VSS BUF_X1
Xinput251 text_in[94] net338 VDD VSS BUF_X1
Xinput252 text_in[95] net339 VDD VSS BUF_X1
Xinput253 text_in[96] net340 VDD VSS CLKBUF_X2
Xinput254 text_in[97] net341 VDD VSS BUF_X1
Xinput255 text_in[98] net342 VDD VSS BUF_X1
Xinput256 text_in[99] net343 VDD VSS BUF_X1
Xinput257 text_in[9] net344 VDD VSS BUF_X1
Xoutput258 net345 done VDD VSS BUF_X1
Xoutput259 net346 text_out[0] VDD VSS BUF_X1
Xoutput260 net347 text_out[100] VDD VSS BUF_X1
Xoutput261 net348 text_out[101] VDD VSS BUF_X1
Xoutput262 net349 text_out[102] VDD VSS BUF_X1
Xoutput263 net350 text_out[103] VDD VSS BUF_X1
Xoutput264 net351 text_out[104] VDD VSS BUF_X1
Xoutput265 net352 text_out[105] VDD VSS BUF_X1
Xoutput266 net353 text_out[106] VDD VSS BUF_X1
Xoutput267 net354 text_out[107] VDD VSS BUF_X1
Xoutput268 net355 text_out[108] VDD VSS BUF_X1
Xoutput269 net356 text_out[109] VDD VSS BUF_X1
Xoutput270 net357 text_out[10] VDD VSS BUF_X1
Xoutput271 net358 text_out[110] VDD VSS BUF_X1
Xoutput272 net359 text_out[111] VDD VSS BUF_X1
Xoutput273 net360 text_out[112] VDD VSS BUF_X1
Xoutput274 net361 text_out[113] VDD VSS BUF_X1
Xoutput275 net362 text_out[114] VDD VSS BUF_X1
Xoutput276 net363 text_out[115] VDD VSS BUF_X1
Xoutput277 net364 text_out[116] VDD VSS BUF_X1
Xoutput278 net365 text_out[117] VDD VSS BUF_X1
Xoutput279 net366 text_out[118] VDD VSS BUF_X1
Xoutput280 net367 text_out[119] VDD VSS BUF_X1
Xoutput281 net368 text_out[11] VDD VSS BUF_X1
Xoutput282 net369 text_out[120] VDD VSS BUF_X1
Xoutput283 net370 text_out[121] VDD VSS BUF_X1
Xoutput284 net371 text_out[122] VDD VSS BUF_X1
Xoutput285 net372 text_out[123] VDD VSS BUF_X1
Xoutput286 net373 text_out[124] VDD VSS BUF_X1
Xoutput287 net374 text_out[125] VDD VSS BUF_X1
Xoutput288 net375 text_out[126] VDD VSS BUF_X1
Xoutput289 net376 text_out[127] VDD VSS BUF_X1
Xoutput290 net377 text_out[12] VDD VSS BUF_X1
Xoutput291 net378 text_out[13] VDD VSS BUF_X1
Xoutput292 net379 text_out[14] VDD VSS BUF_X1
Xoutput293 net380 text_out[15] VDD VSS BUF_X1
Xoutput294 net381 text_out[16] VDD VSS BUF_X1
Xoutput295 net382 text_out[17] VDD VSS BUF_X1
Xoutput296 net383 text_out[18] VDD VSS BUF_X1
Xoutput297 net384 text_out[19] VDD VSS BUF_X1
Xoutput298 net385 text_out[1] VDD VSS BUF_X1
Xoutput299 net386 text_out[20] VDD VSS BUF_X1
Xoutput300 net387 text_out[21] VDD VSS BUF_X1
Xoutput301 net388 text_out[22] VDD VSS BUF_X1
Xoutput302 net389 text_out[23] VDD VSS BUF_X1
Xoutput303 net390 text_out[24] VDD VSS BUF_X1
Xoutput304 net391 text_out[25] VDD VSS BUF_X1
Xoutput305 net392 text_out[26] VDD VSS BUF_X1
Xoutput306 net393 text_out[27] VDD VSS BUF_X1
Xoutput307 net394 text_out[28] VDD VSS BUF_X1
Xoutput308 net395 text_out[29] VDD VSS BUF_X1
Xoutput309 net396 text_out[2] VDD VSS BUF_X1
Xoutput310 net397 text_out[30] VDD VSS BUF_X1
Xoutput311 net398 text_out[31] VDD VSS BUF_X1
Xoutput312 net399 text_out[32] VDD VSS BUF_X1
Xoutput313 net400 text_out[33] VDD VSS BUF_X1
Xoutput314 net401 text_out[34] VDD VSS BUF_X1
Xoutput315 net402 text_out[35] VDD VSS BUF_X1
Xoutput316 net403 text_out[36] VDD VSS BUF_X1
Xoutput317 net404 text_out[37] VDD VSS BUF_X1
Xoutput318 net405 text_out[38] VDD VSS BUF_X1
Xoutput319 net406 text_out[39] VDD VSS BUF_X1
Xoutput320 net407 text_out[3] VDD VSS BUF_X1
Xoutput321 net408 text_out[40] VDD VSS BUF_X1
Xoutput322 net409 text_out[41] VDD VSS BUF_X1
Xoutput323 net410 text_out[42] VDD VSS BUF_X1
Xoutput324 net411 text_out[43] VDD VSS BUF_X1
Xoutput325 net412 text_out[44] VDD VSS BUF_X1
Xoutput326 net413 text_out[45] VDD VSS BUF_X1
Xoutput327 net414 text_out[46] VDD VSS BUF_X1
Xoutput328 net415 text_out[47] VDD VSS BUF_X1
Xoutput329 net416 text_out[48] VDD VSS BUF_X1
Xoutput330 net417 text_out[49] VDD VSS BUF_X1
Xoutput331 net418 text_out[4] VDD VSS BUF_X1
Xoutput332 net419 text_out[50] VDD VSS BUF_X1
Xoutput333 net420 text_out[51] VDD VSS BUF_X1
Xoutput334 net421 text_out[52] VDD VSS BUF_X1
Xoutput335 net422 text_out[53] VDD VSS BUF_X1
Xoutput336 net423 text_out[54] VDD VSS BUF_X1
Xoutput337 net424 text_out[55] VDD VSS BUF_X1
Xoutput338 net425 text_out[56] VDD VSS BUF_X1
Xoutput339 net426 text_out[57] VDD VSS BUF_X1
Xoutput340 net427 text_out[58] VDD VSS BUF_X1
Xoutput341 net428 text_out[59] VDD VSS BUF_X1
Xoutput342 net429 text_out[5] VDD VSS BUF_X1
Xoutput343 net430 text_out[60] VDD VSS BUF_X1
Xoutput344 net431 text_out[61] VDD VSS BUF_X1
Xoutput345 net432 text_out[62] VDD VSS BUF_X1
Xoutput346 net433 text_out[63] VDD VSS BUF_X1
Xoutput347 net434 text_out[64] VDD VSS BUF_X1
Xoutput348 net435 text_out[65] VDD VSS BUF_X1
Xoutput349 net436 text_out[66] VDD VSS BUF_X1
Xoutput350 net437 text_out[67] VDD VSS BUF_X1
Xoutput351 net438 text_out[68] VDD VSS BUF_X1
Xoutput352 net439 text_out[69] VDD VSS BUF_X1
Xoutput353 net440 text_out[6] VDD VSS BUF_X1
Xoutput354 net441 text_out[70] VDD VSS BUF_X1
Xoutput355 net442 text_out[71] VDD VSS BUF_X1
Xoutput356 net443 text_out[72] VDD VSS BUF_X1
Xoutput357 net444 text_out[73] VDD VSS BUF_X1
Xoutput358 net445 text_out[74] VDD VSS BUF_X1
Xoutput359 net446 text_out[75] VDD VSS BUF_X1
Xoutput360 net447 text_out[76] VDD VSS BUF_X1
Xoutput361 net448 text_out[77] VDD VSS BUF_X1
Xoutput362 net449 text_out[78] VDD VSS BUF_X1
Xoutput363 net450 text_out[79] VDD VSS BUF_X1
Xoutput364 net451 text_out[7] VDD VSS BUF_X1
Xoutput365 net452 text_out[80] VDD VSS BUF_X1
Xoutput366 net453 text_out[81] VDD VSS BUF_X1
Xoutput367 net454 text_out[82] VDD VSS BUF_X1
Xoutput368 net455 text_out[83] VDD VSS BUF_X1
Xoutput369 net456 text_out[84] VDD VSS BUF_X1
Xoutput370 net457 text_out[85] VDD VSS BUF_X1
Xoutput371 net458 text_out[86] VDD VSS BUF_X1
Xoutput372 net459 text_out[87] VDD VSS BUF_X1
Xoutput373 net460 text_out[88] VDD VSS BUF_X1
Xoutput374 net461 text_out[89] VDD VSS BUF_X1
Xoutput375 net462 text_out[8] VDD VSS BUF_X1
Xoutput376 net463 text_out[90] VDD VSS BUF_X1
Xoutput377 net464 text_out[91] VDD VSS BUF_X1
Xoutput378 net465 text_out[92] VDD VSS BUF_X1
Xoutput379 net466 text_out[93] VDD VSS BUF_X1
Xoutput380 net467 text_out[94] VDD VSS BUF_X1
Xoutput381 net468 text_out[95] VDD VSS BUF_X1
Xoutput382 net469 text_out[96] VDD VSS BUF_X1
Xoutput383 net470 text_out[97] VDD VSS BUF_X1
Xoutput384 net471 text_out[98] VDD VSS BUF_X1
Xoutput385 net472 text_out[99] VDD VSS BUF_X1
Xoutput386 net473 text_out[9] VDD VSS BUF_X1
Xmax_cap387 net924 net474 VDD VSS BUF_X8
Xmax_cap388 _04306_ net475 VDD VSS BUF_X4
Xmax_cap389 _04302_ net476 VDD VSS BUF_X4
Xclkbuf_leaf_0_clk clknet_3_2__leaf_clk clknet_leaf_0_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_1_clk clknet_3_2__leaf_clk clknet_leaf_1_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_2_clk clknet_3_2__leaf_clk clknet_leaf_2_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_3_clk clknet_3_2__leaf_clk clknet_leaf_3_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_4_clk clknet_3_2__leaf_clk clknet_leaf_4_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_5_clk clknet_3_0__leaf_clk clknet_leaf_5_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_6_clk clknet_3_3__leaf_clk clknet_leaf_6_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_7_clk clknet_3_0__leaf_clk clknet_leaf_7_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_8_clk clknet_3_0__leaf_clk clknet_leaf_8_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_9_clk clknet_3_3__leaf_clk clknet_leaf_9_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_10_clk clknet_3_3__leaf_clk clknet_leaf_10_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_11_clk clknet_3_3__leaf_clk clknet_leaf_11_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_12_clk clknet_3_3__leaf_clk clknet_leaf_12_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_13_clk clknet_3_3__leaf_clk clknet_leaf_13_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_14_clk clknet_3_3__leaf_clk clknet_leaf_14_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_15_clk clknet_3_3__leaf_clk clknet_leaf_15_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_16_clk clknet_3_2__leaf_clk clknet_leaf_16_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_17_clk clknet_3_2__leaf_clk clknet_leaf_17_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_18_clk clknet_3_2__leaf_clk clknet_leaf_18_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_19_clk clknet_3_2__leaf_clk clknet_leaf_19_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_20_clk clknet_3_2__leaf_clk clknet_leaf_20_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_21_clk clknet_3_2__leaf_clk clknet_leaf_21_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_22_clk clknet_3_3__leaf_clk clknet_leaf_22_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_23_clk clknet_3_3__leaf_clk clknet_leaf_23_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_24_clk clknet_3_6__leaf_clk clknet_leaf_24_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_25_clk clknet_3_3__leaf_clk clknet_leaf_25_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_26_clk clknet_3_3__leaf_clk clknet_leaf_26_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_27_clk clknet_3_3__leaf_clk clknet_leaf_27_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_28_clk clknet_3_3__leaf_clk clknet_leaf_28_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_29_clk clknet_3_6__leaf_clk clknet_leaf_29_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_30_clk clknet_3_6__leaf_clk clknet_leaf_30_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_31_clk clknet_3_7__leaf_clk clknet_leaf_31_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_32_clk clknet_3_6__leaf_clk clknet_leaf_32_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_33_clk clknet_3_6__leaf_clk clknet_leaf_33_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_34_clk clknet_3_6__leaf_clk clknet_leaf_34_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_35_clk clknet_3_6__leaf_clk clknet_leaf_35_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_36_clk clknet_3_6__leaf_clk clknet_leaf_36_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_37_clk clknet_3_6__leaf_clk clknet_leaf_37_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_38_clk clknet_3_7__leaf_clk clknet_leaf_38_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_39_clk clknet_3_7__leaf_clk clknet_leaf_39_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_40_clk clknet_3_7__leaf_clk clknet_leaf_40_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_41_clk clknet_3_7__leaf_clk clknet_leaf_41_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_42_clk clknet_3_5__leaf_clk clknet_leaf_42_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_43_clk clknet_3_5__leaf_clk clknet_leaf_43_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_44_clk clknet_3_5__leaf_clk clknet_leaf_44_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_45_clk clknet_3_5__leaf_clk clknet_leaf_45_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_46_clk clknet_3_5__leaf_clk clknet_leaf_46_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_47_clk clknet_3_5__leaf_clk clknet_leaf_47_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_48_clk clknet_3_5__leaf_clk clknet_leaf_48_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_49_clk clknet_3_5__leaf_clk clknet_leaf_49_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_50_clk clknet_3_5__leaf_clk clknet_leaf_50_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_51_clk clknet_3_4__leaf_clk clknet_leaf_51_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_52_clk clknet_3_7__leaf_clk clknet_leaf_52_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_53_clk clknet_3_7__leaf_clk clknet_leaf_53_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_54_clk clknet_3_7__leaf_clk clknet_leaf_54_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_55_clk clknet_3_6__leaf_clk clknet_leaf_55_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_56_clk clknet_3_6__leaf_clk clknet_leaf_56_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_57_clk clknet_3_6__leaf_clk clknet_leaf_57_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_58_clk clknet_3_4__leaf_clk clknet_leaf_58_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_59_clk clknet_3_4__leaf_clk clknet_leaf_59_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_60_clk clknet_3_4__leaf_clk clknet_leaf_60_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_61_clk clknet_3_4__leaf_clk clknet_leaf_61_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_62_clk clknet_3_5__leaf_clk clknet_leaf_62_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_63_clk clknet_3_5__leaf_clk clknet_leaf_63_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_64_clk clknet_3_5__leaf_clk clknet_leaf_64_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_65_clk clknet_3_5__leaf_clk clknet_leaf_65_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_66_clk clknet_3_5__leaf_clk clknet_leaf_66_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_67_clk clknet_3_5__leaf_clk clknet_leaf_67_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_68_clk clknet_3_4__leaf_clk clknet_leaf_68_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_69_clk clknet_3_4__leaf_clk clknet_leaf_69_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_70_clk clknet_3_4__leaf_clk clknet_leaf_70_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_71_clk clknet_3_4__leaf_clk clknet_leaf_71_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_72_clk clknet_3_1__leaf_clk clknet_leaf_72_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_73_clk clknet_3_1__leaf_clk clknet_leaf_73_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_74_clk clknet_3_1__leaf_clk clknet_leaf_74_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_75_clk clknet_3_1__leaf_clk clknet_leaf_75_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_76_clk clknet_3_1__leaf_clk clknet_leaf_76_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_77_clk clknet_3_4__leaf_clk clknet_leaf_77_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_78_clk clknet_3_4__leaf_clk clknet_leaf_78_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_79_clk clknet_3_0__leaf_clk clknet_leaf_79_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_80_clk clknet_3_0__leaf_clk clknet_leaf_80_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_81_clk clknet_3_0__leaf_clk clknet_leaf_81_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_82_clk clknet_3_0__leaf_clk clknet_leaf_82_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_83_clk clknet_3_0__leaf_clk clknet_leaf_83_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_84_clk clknet_3_0__leaf_clk clknet_leaf_84_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_85_clk clknet_3_0__leaf_clk clknet_leaf_85_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_86_clk clknet_3_0__leaf_clk clknet_leaf_86_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_87_clk clknet_3_0__leaf_clk clknet_leaf_87_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_88_clk clknet_3_0__leaf_clk clknet_leaf_88_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_89_clk clknet_3_1__leaf_clk clknet_leaf_89_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_90_clk clknet_3_1__leaf_clk clknet_leaf_90_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_91_clk clknet_3_1__leaf_clk clknet_leaf_91_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_92_clk clknet_3_1__leaf_clk clknet_leaf_92_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_93_clk clknet_3_1__leaf_clk clknet_leaf_93_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_94_clk clknet_3_1__leaf_clk clknet_leaf_94_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_95_clk clknet_3_1__leaf_clk clknet_leaf_95_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_leaf_96_clk clknet_3_1__leaf_clk clknet_leaf_96_clk
+ VDD VSS CLKBUF_X3
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_3_0__f_clk clknet_0_clk clknet_3_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_1__f_clk clknet_0_clk clknet_3_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_2__f_clk clknet_0_clk clknet_3_2__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_3__f_clk clknet_0_clk clknet_3_3__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_4__f_clk clknet_0_clk clknet_3_4__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_5__f_clk clknet_0_clk clknet_3_5__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_6__f_clk clknet_0_clk clknet_3_6__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_3_7__f_clk clknet_0_clk clknet_3_7__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_3_0__leaf_clk _unconnected_0 VDD VSS INV_X2
Xclkload1 clknet_3_1__leaf_clk _unconnected_1 VDD VSS INV_X2
Xclkload2 clknet_3_2__leaf_clk _unconnected_2 VDD VSS INV_X4
Xclkload3 clknet_3_3__leaf_clk _unconnected_3 VDD VSS CLKBUF_X3
Xclkload4 clknet_3_4__leaf_clk _unconnected_4 VDD VSS INV_X4
Xclkload5 clknet_3_6__leaf_clk _unconnected_5 VDD VSS INV_X2
Xclkload6 clknet_3_7__leaf_clk _unconnected_6 VDD VSS INV_X8
Xclkload7 clknet_leaf_5_clk _unconnected_7 VDD VSS INV_X2
Xclkload8 clknet_leaf_7_clk _unconnected_8 VDD VSS CLKBUF_X1
Xclkload9 clknet_leaf_8_clk _unconnected_9 VDD VSS CLKBUF_X1
Xclkload10 clknet_leaf_79_clk _unconnected_10 VDD VSS INV_X1
Xclkload11 clknet_leaf_80_clk _unconnected_11 VDD VSS INV_X1
Xclkload12 clknet_leaf_81_clk _unconnected_12 VDD VSS INV_X1
Xclkload13 clknet_leaf_82_clk _unconnected_13 VDD VSS CLKBUF_X1
Xclkload14 clknet_leaf_83_clk _unconnected_14 VDD VSS CLKBUF_X1
Xclkload15 clknet_leaf_85_clk _unconnected_15 VDD VSS CLKBUF_X1
Xclkload16 clknet_leaf_86_clk _unconnected_16 VDD VSS CLKBUF_X1
Xclkload17 clknet_leaf_88_clk _unconnected_17 VDD VSS CLKBUF_X1
Xclkload18 clknet_leaf_72_clk _unconnected_18 VDD VSS CLKBUF_X1
Xclkload19 clknet_leaf_73_clk _unconnected_19 VDD VSS CLKBUF_X1
Xclkload20 clknet_leaf_74_clk _unconnected_20 VDD VSS CLKBUF_X1
Xclkload21 clknet_leaf_75_clk _unconnected_21 VDD VSS INV_X2
Xclkload22 clknet_leaf_76_clk _unconnected_22 VDD VSS CLKBUF_X1
Xclkload23 clknet_leaf_89_clk _unconnected_23 VDD VSS INV_X2
Xclkload24 clknet_leaf_91_clk _unconnected_24 VDD VSS CLKBUF_X1
Xclkload25 clknet_leaf_92_clk _unconnected_25 VDD VSS INV_X2
Xclkload26 clknet_leaf_93_clk _unconnected_26 VDD VSS INV_X1
Xclkload27 clknet_leaf_94_clk _unconnected_27 VDD VSS CLKBUF_X1
Xclkload28 clknet_leaf_95_clk _unconnected_28 VDD VSS INV_X1
Xclkload29 clknet_leaf_96_clk _unconnected_29 VDD VSS INV_X4
Xclkload30 clknet_leaf_0_clk _unconnected_30 VDD VSS INV_X1
Xclkload31 clknet_leaf_2_clk _unconnected_31 VDD VSS INV_X2
Xclkload32 clknet_leaf_3_clk _unconnected_32 VDD VSS INV_X2
Xclkload33 clknet_leaf_4_clk _unconnected_33 VDD VSS INV_X2
Xclkload34 clknet_leaf_16_clk _unconnected_34 VDD VSS INV_X2
Xclkload35 clknet_leaf_17_clk _unconnected_35 VDD VSS INV_X2
Xclkload36 clknet_leaf_18_clk _unconnected_36 VDD VSS INV_X1
Xclkload37 clknet_leaf_19_clk _unconnected_37 VDD VSS INV_X2
Xclkload38 clknet_leaf_20_clk _unconnected_38 VDD VSS INV_X2
Xclkload39 clknet_leaf_21_clk _unconnected_39 VDD VSS INV_X2
Xclkload40 clknet_leaf_6_clk _unconnected_40 VDD VSS INV_X1
Xclkload41 clknet_leaf_10_clk _unconnected_41 VDD VSS INV_X1
Xclkload42 clknet_leaf_11_clk _unconnected_42 VDD VSS INV_X2
Xclkload43 clknet_leaf_12_clk _unconnected_43 VDD VSS INV_X1
Xclkload44 clknet_leaf_13_clk _unconnected_44 VDD VSS INV_X2
Xclkload45 clknet_leaf_14_clk _unconnected_45 VDD VSS INV_X2
Xclkload46 clknet_leaf_15_clk _unconnected_46 VDD VSS INV_X2
Xclkload47 clknet_leaf_22_clk _unconnected_47 VDD VSS INV_X4
Xclkload48 clknet_leaf_23_clk _unconnected_48 VDD VSS INV_X1
Xclkload49 clknet_leaf_25_clk _unconnected_49 VDD VSS INV_X2
Xclkload50 clknet_leaf_26_clk _unconnected_50 VDD VSS INV_X2
Xclkload51 clknet_leaf_27_clk _unconnected_51 VDD VSS INV_X2
Xclkload52 clknet_leaf_28_clk _unconnected_52 VDD VSS INV_X2
Xclkload53 clknet_leaf_51_clk _unconnected_53 VDD VSS INV_X2
Xclkload54 clknet_leaf_58_clk _unconnected_54 VDD VSS CLKBUF_X1
Xclkload55 clknet_leaf_59_clk _unconnected_55 VDD VSS INV_X2
Xclkload56 clknet_leaf_60_clk _unconnected_56 VDD VSS INV_X2
Xclkload57 clknet_leaf_61_clk _unconnected_57 VDD VSS CLKBUF_X1
Xclkload58 clknet_leaf_69_clk _unconnected_58 VDD VSS CLKBUF_X1
Xclkload59 clknet_leaf_70_clk _unconnected_59 VDD VSS INV_X2
Xclkload60 clknet_leaf_71_clk _unconnected_60 VDD VSS INV_X1
Xclkload61 clknet_leaf_77_clk _unconnected_61 VDD VSS INV_X2
Xclkload62 clknet_leaf_78_clk _unconnected_62 VDD VSS INV_X2
Xclkload63 clknet_leaf_42_clk _unconnected_63 VDD VSS INV_X2
Xclkload64 clknet_leaf_43_clk _unconnected_64 VDD VSS CLKBUF_X1
Xclkload65 clknet_leaf_45_clk _unconnected_65 VDD VSS CLKBUF_X1
Xclkload66 clknet_leaf_46_clk _unconnected_66 VDD VSS CLKBUF_X1
Xclkload67 clknet_leaf_47_clk _unconnected_67 VDD VSS INV_X1
Xclkload68 clknet_leaf_48_clk _unconnected_68 VDD VSS INV_X1
Xclkload69 clknet_leaf_49_clk _unconnected_69 VDD VSS CLKBUF_X1
Xclkload70 clknet_leaf_50_clk _unconnected_70 VDD VSS CLKBUF_X1
Xclkload71 clknet_leaf_62_clk _unconnected_71 VDD VSS CLKBUF_X1
Xclkload72 clknet_leaf_63_clk _unconnected_72 VDD VSS INV_X2
Xclkload73 clknet_leaf_64_clk _unconnected_73 VDD VSS INV_X1
Xclkload74 clknet_leaf_67_clk _unconnected_74 VDD VSS INV_X2
Xclkload75 clknet_leaf_24_clk _unconnected_75 VDD VSS CLKBUF_X1
Xclkload76 clknet_leaf_29_clk _unconnected_76 VDD VSS INV_X2
Xclkload77 clknet_leaf_30_clk _unconnected_77 VDD VSS CLKBUF_X1
Xclkload78 clknet_leaf_32_clk _unconnected_78 VDD VSS CLKBUF_X1
Xclkload79 clknet_leaf_34_clk _unconnected_79 VDD VSS INV_X2
Xclkload80 clknet_leaf_36_clk _unconnected_80 VDD VSS CLKBUF_X1
Xclkload81 clknet_leaf_37_clk _unconnected_81 VDD VSS INV_X1
Xclkload82 clknet_leaf_55_clk _unconnected_82 VDD VSS INV_X1
Xclkload83 clknet_leaf_56_clk _unconnected_83 VDD VSS CLKBUF_X1
Xclkload84 clknet_leaf_57_clk _unconnected_84 VDD VSS INV_X2
Xclkload85 clknet_leaf_38_clk _unconnected_85 VDD VSS INV_X2
Xclkload86 clknet_leaf_39_clk _unconnected_86 VDD VSS INV_X2
Xclkload87 clknet_leaf_40_clk _unconnected_87 VDD VSS INV_X2
Xclkload88 clknet_leaf_41_clk _unconnected_88 VDD VSS INV_X1
Xclkload89 clknet_leaf_52_clk _unconnected_89 VDD VSS INV_X2
Xclkload90 clknet_leaf_53_clk _unconnected_90 VDD VSS INV_X2
Xclkload91 clknet_leaf_54_clk _unconnected_91 VDD VSS INV_X2
Xrebuffer1 _14829_ net477 VDD VSS BUF_X2
Xrebuffer2 _14829_ net478 VDD VSS BUF_X2
Xrebuffer3 _14829_ net479 VDD VSS BUF_X1
Xrebuffer4 _14829_ net480 VDD VSS BUF_X4
Xrebuffer5 _04229_ net481 VDD VSS BUF_X1
Xrebuffer6 sa31_sub\[1\] net482 VDD VSS BUF_X1
Xrebuffer7 sa31_sub\[1\] net483 VDD VSS BUF_X2
Xrebuffer8 net483 net484 VDD VSS BUF_X1
Xclone251 net861 net860 VDD VSS BUF_X16
Xrebuffer10 _15053_ net486 VDD VSS BUF_X4
Xrebuffer11 net486 net487 VDD VSS BUF_X4
Xrebuffer12 sa12_sr\[0\] net488 VDD VSS BUF_X1
Xrebuffer13 sa12_sr\[0\] net489 VDD VSS BUF_X1
Xrebuffer14 sa12_sr\[0\] net490 VDD VSS BUF_X1
Xrebuffer15 net658 net491 VDD VSS BUF_X4
Xrebuffer16 net658 net492 VDD VSS BUF_X2
Xrebuffer17 _08991_ net493 VDD VSS BUF_X1
Xrebuffer18 net664 net494 VDD VSS BUF_X1
Xrebuffer19 _03585_ net495 VDD VSS BUF_X1
Xrebuffer20 sa21_sr\[1\] net496 VDD VSS BUF_X1
Xrebuffer21 sa21_sr\[1\] net497 VDD VSS BUF_X1
Xrebuffer22 _06460_ net498 VDD VSS BUF_X1
Xrebuffer23 net498 net499 VDD VSS BUF_X1
Xrebuffer24 _13175_ net500 VDD VSS BUF_X1
Xrebuffer25 _13175_ net501 VDD VSS BUF_X4
Xrebuffer26 _14993_ net502 VDD VSS BUF_X4
Xrebuffer27 _15125_ net503 VDD VSS BUF_X2
Xrebuffer28 _06460_ net504 VDD VSS BUF_X1
Xrebuffer29 sa30_sub\[0\] net505 VDD VSS BUF_X4
Xrebuffer30 net505 net506 VDD VSS BUF_X1
Xrebuffer31 sa30_sub\[0\] net507 VDD VSS BUF_X1
Xrebuffer32 _14862_ net508 VDD VSS BUF_X4
Xrebuffer33 net644 net509 VDD VSS BUF_X4
Xrebuffer34 _14776_ net510 VDD VSS BUF_X1
Xrebuffer35 _14776_ net511 VDD VSS BUF_X2
Xrebuffer36 net511 net512 VDD VSS BUF_X1
Xrebuffer37 _13174_ net513 VDD VSS BUF_X1
Xrebuffer38 _14956_ net514 VDD VSS BUF_X1
Xrebuffer39 _14956_ net515 VDD VSS BUF_X1
Xrebuffer40 net1053 net516 VDD VSS BUF_X1
Xrebuffer41 _14767_ net517 VDD VSS BUF_X1
Xrebuffer42 _12502_ net518 VDD VSS BUF_X1
Xrebuffer43 net518 net519 VDD VSS BUF_X1
Xrebuffer44 net519 net520 VDD VSS BUF_X1
Xrebuffer45 net680 net521 VDD VSS BUF_X2
Xrebuffer46 _15140_ net522 VDD VSS BUF_X1
Xrebuffer47 _11852_ net523 VDD VSS BUF_X8
Xrebuffer48 _06265_ net524 VDD VSS BUF_X1
Xrebuffer49 _06334_ net525 VDD VSS BUF_X1
Xrebuffer50 _14842_ net526 VDD VSS BUF_X4
Xrebuffer51 _04859_ net527 VDD VSS BUF_X1
Xrebuffer52 net527 net528 VDD VSS BUF_X1
Xrebuffer53 _04859_ net529 VDD VSS BUF_X1
Xrebuffer54 _10455_ net530 VDD VSS BUF_X2
Xrebuffer55 _06335_ net531 VDD VSS BUF_X4
Xrebuffer56 _03581_ net532 VDD VSS BUF_X1
Xrebuffer57 net532 net533 VDD VSS BUF_X1
Xrebuffer58 net533 net534 VDD VSS BUF_X1
Xrebuffer59 sa10_sr\[1\] net535 VDD VSS BUF_X1
Xrebuffer60 sa10_sr\[1\] net536 VDD VSS BUF_X1
Xrebuffer61 net536 net537 VDD VSS BUF_X1
Xrebuffer62 _09717_ net538 VDD VSS BUF_X1
Xrebuffer63 net538 net539 VDD VSS BUF_X1
Xrebuffer64 net708 net540 VDD VSS BUF_X1
Xrebuffer65 _14865_ net541 VDD VSS BUF_X1
Xrebuffer66 _14865_ net542 VDD VSS BUF_X1
Xrebuffer67 sa03_sr\[0\] net543 VDD VSS BUF_X1
Xrebuffer68 sa10_sub\[0\] net544 VDD VSS BUF_X1
Xrebuffer69 _06264_ net545 VDD VSS BUF_X1
Xrebuffer70 _10504_ net546 VDD VSS BUF_X1
Xrebuffer71 _10504_ net547 VDD VSS BUF_X1
Xrebuffer72 _06608_ net548 VDD VSS BUF_X1
Xrebuffer73 net548 net549 VDD VSS BUF_X1
Xrebuffer74 _11848_ net550 VDD VSS BUF_X1
Xrebuffer75 sa02_sr\[1\] net551 VDD VSS BUF_X1
Xrebuffer76 sa02_sr\[1\] net552 VDD VSS BUF_X1
Xrebuffer77 sa02_sr\[1\] net553 VDD VSS BUF_X1
Xrebuffer78 net694 net554 VDD VSS BUF_X1
Xrebuffer79 _00945_ net555 VDD VSS BUF_X1
Xrebuffer80 net1051 net556 VDD VSS BUF_X1
Xrebuffer81 net556 net557 VDD VSS BUF_X2
Xrebuffer82 u0.tmp_w\[0\] net558 VDD VSS BUF_X1
Xrebuffer83 net558 net559 VDD VSS BUF_X2
Xrebuffer84 net559 net560 VDD VSS BUF_X1
Xrebuffer85 _13167_ net561 VDD VSS BUF_X1
Xrebuffer87 sa11_sr\[7\] net563 VDD VSS BUF_X1
Xrebuffer88 net563 net564 VDD VSS BUF_X1
Xrebuffer89 sa11_sr\[7\] net565 VDD VSS BUF_X1
Xrebuffer91 _15165_ net567 VDD VSS BUF_X4
Xrebuffer92 net567 net568 VDD VSS BUF_X8
Xrebuffer93 _02463_ net569 VDD VSS BUF_X2
Xrebuffer94 sa00_sr\[1\] net570 VDD VSS BUF_X1
Xrebuffer95 sa00_sr\[1\] net571 VDD VSS BUF_X2
Xrebuffer96 sa00_sr\[1\] net572 VDD VSS BUF_X1
Xrebuffer97 net572 net573 VDD VSS BUF_X2
Xrebuffer98 _05527_ net574 VDD VSS BUF_X1
Xrebuffer99 _05527_ net575 VDD VSS BUF_X1
Xrebuffer100 _12623_ net576 VDD VSS BUF_X1
Xrebuffer101 _12623_ net577 VDD VSS BUF_X1
Xrebuffer102 _15020_ net578 VDD VSS BUF_X1
Xrebuffer103 _15020_ net579 VDD VSS BUF_X1
Xrebuffer104 net579 net580 VDD VSS BUF_X1
Xrebuffer105 net580 net581 VDD VSS BUF_X1
Xrebuffer106 _09153_ net582 VDD VSS BUF_X2
Xrebuffer107 _09153_ net583 VDD VSS BUF_X1
Xrebuffer108 net666 net584 VDD VSS BUF_X1
Xrebuffer109 _14906_ net585 VDD VSS BUF_X4
Xrebuffer110 _04972_ net586 VDD VSS BUF_X8
Xclone111 net588 net587 VDD VSS BUF_X4
Xrebuffer112 net778 net588 VDD VSS BUF_X1
Xclone113 net590 net589 VDD VSS INV_X4
Xclone114 net591 net590 VDD VSS BUF_X4
Xrebuffer115 _14989_ net591 VDD VSS BUF_X1
Xrebuffer116 _15131_ net592 VDD VSS BUF_X1
Xrebuffer117 net592 net593 VDD VSS BUF_X2
Xrebuffer118 net592 net594 VDD VSS BUF_X1
Xrebuffer119 _12510_ net595 VDD VSS BUF_X1
Xrebuffer120 net595 net596 VDD VSS BUF_X1
Xrebuffer121 u0.subword\[0\] net597 VDD VSS BUF_X1
Xrebuffer122 _14838_ net598 VDD VSS BUF_X2
Xrebuffer123 net598 net599 VDD VSS BUF_X1
Xclone129 _13388_ net623 VDD VSS BUF_X16
Xrebuffer220 _11627_ net836 VDD VSS BUF_X8
Xrebuffer126 _11121_ net602 VDD VSS BUF_X1
Xrebuffer127 _15270_ net603 VDD VSS BUF_X2
Xrebuffer128 _15270_ net604 VDD VSS BUF_X2
Xrebuffer130 _09714_ net606 VDD VSS BUF_X1
Xrebuffer132 sa30_sub\[1\] net608 VDD VSS BUF_X1
Xrebuffer133 sa11_sr\[7\] net609 VDD VSS BUF_X1
Xrebuffer134 sa30_sub\[1\] net610 VDD VSS BUF_X1
Xclone140 _04388_ net612 VDD VSS BUF_X16
Xrebuffer141 _09732_ net613 VDD VSS BUF_X1
Xrebuffer143 _09002_ net615 VDD VSS BUF_X1
Xclone146 net619 net617 VDD VSS BUF_X4
Xrebuffer147 _09733_ net618 VDD VSS BUF_X8
Xrebuffer148 net618 net619 VDD VSS BUF_X1
Xrebuffer149 net618 net620 VDD VSS BUF_X1
Xrebuffer155 _00939_ net625 VDD VSS BUF_X1
Xrebuffer167 _03585_ net632 VDD VSS BUF_X4
Xrebuffer168 sa30_sr\[0\] net633 VDD VSS BUF_X4
Xrebuffer169 sa30_sr\[0\] net634 VDD VSS BUF_X1
Xrebuffer170 _03672_ net635 VDD VSS BUF_X8
Xrebuffer171 _15210_ net636 VDD VSS BUF_X2
Xrebuffer172 _03580_ net637 VDD VSS BUF_X1
Xrebuffer173 _15210_ net638 VDD VSS BUF_X1
Xrebuffer174 net638 net639 VDD VSS BUF_X1
Xrebuffer175 sa20_sr\[1\] net640 VDD VSS BUF_X1
Xrebuffer176 net640 net641 VDD VSS BUF_X1
Xrebuffer177 _11856_ net642 VDD VSS BUF_X1
Xrebuffer178 _14897_ net643 VDD VSS BUF_X2
Xrebuffer179 _14897_ net644 VDD VSS BUF_X2
Xrebuffer181 _11117_ net646 VDD VSS BUF_X1
Xclone182 net648 net647 VDD VSS INV_X4
Xrebuffer183 _11130_ net648 VDD VSS BUF_X1
Xclone184 _11131_ net649 VDD VSS BUF_X8
Xclone185 net474 net650 VDD VSS BUF_X4
Xclone186 net838 net651 VDD VSS BUF_X16
Xrebuffer190 sa30_sub\[1\] net655 VDD VSS BUF_X4
Xclone191 net526 _09859_ _09861_ net656 VDD VSS NAND3_X2
Xrebuffer192 net842 net657 VDD VSS BUF_X16
Xrebuffer193 _14893_ net658 VDD VSS BUF_X2
Xrebuffer194 _15196_ net659 VDD VSS BUF_X1
Xrebuffer195 net659 net660 VDD VSS BUF_X1
Xrebuffer196 _15196_ net661 VDD VSS BUF_X1
Xclone197 net1108 net662 VDD VSS BUF_X16
Xsplit201 _14906_ net666 VDD VSS CLKBUF_X2
Xrebuffer203 u0.subword\[8\] net668 VDD VSS BUF_X1
Xrebuffer207 net1045 net672 VDD VSS BUF_X1
Xrebuffer208 _15230_ net673 VDD VSS BUF_X4
Xrebuffer209 _15233_ net674 VDD VSS BUF_X1
Xrebuffer212 net1041 net677 VDD VSS BUF_X4
Xrebuffer213 _02314_ net678 VDD VSS BUF_X1
Xrebuffer214 sa20_sub\[0\] net679 VDD VSS BUF_X1
Xrebuffer215 _15140_ net680 VDD VSS BUF_X4
Xrebuffer216 net680 net681 VDD VSS BUF_X1
Xrebuffer221 _00977_ net686 VDD VSS BUF_X8
Xrebuffer222 net686 net687 VDD VSS BUF_X1
Xrebuffer223 net686 net688 VDD VSS BUF_X1
Xrebuffer224 net686 net689 VDD VSS BUF_X1
Xrebuffer225 net686 net690 VDD VSS BUF_X1
Xrebuffer226 net686 net691 VDD VSS BUF_X1
Xrebuffer227 _15064_ net692 VDD VSS BUF_X2
Xclone228 net695 net693 VDD VSS BUF_X4
Xrebuffer229 net1134 net694 VDD VSS BUF_X1
Xrebuffer230 net694 net695 VDD VSS BUF_X1
Xrebuffer231 _15057_ net696 VDD VSS BUF_X4
Xrebuffer232 _15057_ net697 VDD VSS BUF_X4
Xrebuffer233 net697 net698 VDD VSS BUF_X4
Xrebuffer234 _00944_ net699 VDD VSS BUF_X1
Xrebuffer235 _00960_ net700 VDD VSS BUF_X8
Xrebuffer236 net700 net701 VDD VSS BUF_X1
Xrebuffer237 sa30_sr\[0\] net702 VDD VSS BUF_X1
Xclone238 net704 net703 VDD VSS BUF_X4
Xrebuffer239 net1137 net704 VDD VSS BUF_X1
Xclone240 _00946_ net705 VDD VSS BUF_X4
Xclone241 net486 net706 VDD VSS BUF_X8
Xrebuffer246 _14838_ net711 VDD VSS BUF_X1
Xrebuffer247 net711 net712 VDD VSS BUF_X1
Xrebuffer512 _15059_ net1137 VDD VSS BUF_X4
Xrebuffer251 _15297_ net716 VDD VSS BUF_X2
Xrebuffer253 net717 net718 VDD VSS BUF_X4
Xrebuffer255 sa10_sub\[1\] net720 VDD VSS BUF_X1
Xrebuffer256 sa32_sub\[0\] net721 VDD VSS BUF_X1
Xrebuffer257 net721 net722 VDD VSS BUF_X2
Xrebuffer258 _11166_ net723 VDD VSS BUF_X1
Xrebuffer259 _13842_ net724 VDD VSS BUF_X2
Xrebuffer260 _05774_ net725 VDD VSS BUF_X4
Xrebuffer261 net725 net726 VDD VSS BUF_X1
Xrebuffer262 _05523_ net727 VDD VSS BUF_X1
Xrebuffer267 u0.w\[2\]\[24\] net732 VDD VSS BUF_X1
Xrebuffer268 net732 net733 VDD VSS BUF_X1
Xrebuffer269 _06625_ net734 VDD VSS BUF_X1
Xrebuffer270 u0.w\[1\]\[24\] net735 VDD VSS BUF_X1
Xrebuffer271 _06602_ net736 VDD VSS BUF_X1
Xrebuffer272 net736 net737 VDD VSS BUF_X1
Xrebuffer274 net738 net739 VDD VSS BUF_X4
Xrebuffer275 net739 net740 VDD VSS BUF_X1
Xrebuffer277 _06608_ net742 VDD VSS BUF_X1
Xclone278 _06611_ net743 VDD VSS BUF_X16
Xclone279 net745 net744 VDD VSS INV_X8
Xrebuffer280 _06609_ net745 VDD VSS BUF_X1
Xclone281 _06611_ net746 VDD VSS BUF_X16
Xrebuffer282 _15306_ net747 VDD VSS BUF_X4
Xclone283 net750 net748 VDD VSS BUF_X4
Xrebuffer284 _05531_ net749 VDD VSS BUF_X8
Xrebuffer285 net749 net750 VDD VSS BUF_X1
Xrebuffer443 _06349_ net1063 VDD VSS BUF_X1
Xrebuffer287 _05663_ net752 VDD VSS BUF_X4
Xrebuffer288 _05548_ net753 VDD VSS BUF_X1
Xrebuffer289 _11843_ net754 VDD VSS BUF_X1
Xrebuffer298 net762 net763 VDD VSS BUF_X2
Xrebuffer299 net762 net764 VDD VSS BUF_X1
Xrebuffer300 _12732_ net765 VDD VSS BUF_X4
Xrebuffer301 net765 net766 VDD VSS BUF_X4
Xrebuffer302 sa21_sr\[0\] net767 VDD VSS BUF_X1
Xrebuffer303 sa21_sr\[0\] net768 VDD VSS BUF_X1
Xrebuffer304 _09797_ net769 VDD VSS BUF_X1
Xrebuffer305 sa01_sr\[1\] net770 VDD VSS BUF_X1
Xrebuffer306 sa01_sr\[1\] net771 VDD VSS BUF_X4
Xclone308 _12526_ net773 VDD VSS BUF_X8
Xclone309 net889 net774 VDD VSS BUF_X4
Xclone313 _06240_ _06251_ net778 VDD VSS NOR2_X2
Xrebuffer314 u0.tmp_w\[17\] net779 VDD VSS BUF_X1
Xrebuffer315 u0.tmp_w\[17\] net780 VDD VSS BUF_X1
Xrebuffer316 net857 net781 VDD VSS BUF_X1
Xclone317 _06868_ net782 VDD VSS BUF_X8
Xclone318 _06868_ net783 VDD VSS BUF_X8
Xrebuffer319 u0.tmp_w\[16\] net784 VDD VSS BUF_X1
Xrebuffer320 net784 net785 VDD VSS BUF_X1
Xrebuffer321 net784 net786 VDD VSS BUF_X1
Xrebuffer323 sa12_sr\[1\] net788 VDD VSS BUF_X1
Xrebuffer324 sa12_sr\[1\] net789 VDD VSS BUF_X1
Xrebuffer325 sa12_sr\[1\] net790 VDD VSS BUF_X1
Xrebuffer326 sa20_sub\[1\] net791 VDD VSS BUF_X1
Xrebuffer327 net1026 net792 VDD VSS BUF_X1
Xrebuffer328 sa20_sub\[1\] net793 VDD VSS BUF_X4
Xrebuffer329 _13224_ net794 VDD VSS BUF_X1
Xrebuffer330 _05013_ net795 VDD VSS BUF_X4
Xrebuffer331 net795 net796 VDD VSS BUF_X1
Xrebuffer332 _05177_ net797 VDD VSS BUF_X4
Xrebuffer333 _05177_ net798 VDD VSS BUF_X1
Xrebuffer334 net798 net799 VDD VSS BUF_X2
Xrebuffer335 net799 net800 VDD VSS BUF_X1
Xrebuffer338 _15206_ net803 VDD VSS BUF_X1
Xrebuffer339 _15206_ net804 VDD VSS BUF_X1
Xrebuffer340 _03584_ net805 VDD VSS BUF_X4
Xrebuffer341 net805 net806 VDD VSS BUF_X1
Xrebuffer342 _15167_ net807 VDD VSS BUF_X1
Xclone469 _08971_ net1083 VDD VSS BUF_X16
Xrebuffer344 _15161_ net809 VDD VSS BUF_X2
Xrebuffer346 _15162_ net811 VDD VSS BUF_X1
Xrebuffer347 _02967_ net812 VDD VSS BUF_X1
Xrebuffer348 net1038 net813 VDD VSS BUF_X16
Xrebuffer349 net813 net814 VDD VSS BUF_X1
Xrebuffer350 _11185_ net815 VDD VSS BUF_X1
Xrebuffer351 _11185_ net816 VDD VSS BUF_X1
Xrebuffer352 _02967_ net817 VDD VSS BUF_X1
Xrebuffer353 _02990_ net818 VDD VSS BUF_X2
Xrebuffer354 net818 net819 VDD VSS BUF_X1
Xrebuffer355 net818 net820 VDD VSS BUF_X1
Xrebuffer358 _01706_ net823 VDD VSS BUF_X8
Xclone360 net854 net825 VDD VSS BUF_X8
Xclone361 net830 net826 VDD VSS BUF_X8
Xclone362 net824 net827 VDD VSS INV_X4
Xclone363 net829 net828 VDD VSS BUF_X16
Xclone364 _09009_ net829 VDD VSS BUF_X16
Xclone365 _09011_ net830 VDD VSS BUF_X16
Xclone366 _08970_ net831 VDD VSS BUF_X8
Xrebuffer367 _05663_ net832 VDD VSS BUF_X8
Xrebuffer368 _14810_ net833 VDD VSS BUF_X2
Xrebuffer369 _09249_ net834 VDD VSS BUF_X8
Xclone376 _09129_ net841 VDD VSS BUF_X4
Xrebuffer379 _14772_ net844 VDD VSS BUF_X4
Xrebuffer380 net844 net845 VDD VSS BUF_X1
Xrebuffer381 _14772_ net846 VDD VSS BUF_X1
Xrebuffer382 _14776_ net847 VDD VSS BUF_X2
Xrebuffer383 net922 net848 VDD VSS BUF_X2
Xclone394 _00946_ net859 VDD VSS BUF_X8
Xrebuffer400 _14798_ net865 VDD VSS BUF_X1
Xrebuffer401 _14798_ net866 VDD VSS BUF_X1
Xrebuffer402 _09001_ net867 VDD VSS BUF_X1
Xclone405 _15129_ net870 VDD VSS BUF_X2
Xclone406 _09099_ net871 VDD VSS BUF_X16
Xrebuffer410 _11852_ net875 VDD VSS BUF_X16
Xclone411 _14929_ net876 VDD VSS BUF_X4
Xclone412 net875 net877 VDD VSS BUF_X8
Xrebuffer420 _01086_ net885 VDD VSS BUF_X4
Xclone421 _00946_ net886 VDD VSS BUF_X16
Xrebuffer422 _14961_ net887 VDD VSS BUF_X4
Xrebuffer423 _12506_ net888 VDD VSS BUF_X16
Xrebuffer424 net888 net889 VDD VSS BUF_X1
Xclone425 _14961_ net890 VDD VSS BUF_X2
Xrebuffer426 _12517_ net891 VDD VSS BUF_X2
Xrebuffer427 net891 net892 VDD VSS BUF_X1
Xrebuffer428 sa01_sr\[0\] net893 VDD VSS BUF_X2
Xrebuffer429 sa01_sr\[0\] net894 VDD VSS BUF_X1
Xrebuffer430 _13835_ net895 VDD VSS BUF_X1
Xrebuffer431 _13875_ net896 VDD VSS BUF_X8
Xrebuffer432 net896 net897 VDD VSS BUF_X1
Xrebuffer433 net896 net898 VDD VSS BUF_X1
Xrebuffer434 net896 net899 VDD VSS BUF_X1
Xrebuffer435 _11123_ net900 VDD VSS BUF_X4
Xrebuffer436 net900 net901 VDD VSS BUF_X1
Xclone437 _13839_ net902 VDD VSS BUF_X4
Xclone389 _02953_ net999 VDD VSS BUF_X8
Xrebuffer439 _11122_ net904 VDD VSS BUF_X1
Xclone440 _15025_ net905 VDD VSS BUF_X2
Xrebuffer441 sa32_sub\[1\] net906 VDD VSS BUF_X1
Xrebuffer442 _15025_ net907 VDD VSS BUF_X4
Xrebuffer447 _14730_ net912 VDD VSS BUF_X1
Xrebuffer448 _14730_ net913 VDD VSS BUF_X2
Xrebuffer449 net913 net914 VDD VSS BUF_X1
Xrebuffer450 net914 net915 VDD VSS BUF_X1
Xrebuffer451 _14733_ net916 VDD VSS BUF_X4
Xrebuffer452 net916 net917 VDD VSS BUF_X8
Xrebuffer453 net916 net918 VDD VSS BUF_X2
Xrebuffer458 net982 net923 VDD VSS BUF_X4
Xrebuffer459 _14893_ net924 VDD VSS BUF_X2
Xclone460 net839 net925 VDD VSS BUF_X16
Xrebuffer461 net1 net926 VDD VSS BUF_X4
Xclone462 _02936_ net927 VDD VSS BUF_X4
Xrebuffer463 _02927_ net928 VDD VSS BUF_X1
Xrebuffer473 _15262_ net938 VDD VSS BUF_X4
Xrebuffer474 net938 net939 VDD VSS BUF_X2
Xrebuffer475 net939 net940 VDD VSS BUF_X1
Xrebuffer476 _15265_ net941 VDD VSS BUF_X8
Xrebuffer477 net941 net942 VDD VSS BUF_X1
Xrebuffer478 net941 net943 VDD VSS BUF_X1
Xrebuffer479 net941 net944 VDD VSS BUF_X1
Xrebuffer481 net967 net946 VDD VSS BUF_X1
Xrebuffer482 _02389_ net947 VDD VSS BUF_X2
Xrebuffer483 _01272_ net948 VDD VSS BUF_X2
Xrebuffer486 _03577_ net951 VDD VSS BUF_X2
Xrebuffer487 _03777_ net952 VDD VSS BUF_X4
Xrebuffer489 _02310_ net954 VDD VSS BUF_X1
Xrebuffer490 net954 net955 VDD VSS BUF_X1
Xrebuffer491 net955 net956 VDD VSS BUF_X2
Xrebuffer493 _11363_ net958 VDD VSS BUF_X4
Xrebuffer494 net958 net959 VDD VSS BUF_X4
Xrebuffer495 _12017_ net960 VDD VSS BUF_X4
Xrebuffer496 net960 net961 VDD VSS BUF_X1
Xrebuffer497 _14926_ net962 VDD VSS BUF_X2
Xclone503 _11969_ _11925_ _11930_ net968 VDD VSS AOI21_X4
Xrebuffer506 _14796_ net971 VDD VSS BUF_X2
Xrebuffer507 net971 net972 VDD VSS BUF_X1
Xrebuffer529 _13167_ net994 VDD VSS BUF_X2
Xrebuffer536 net1097 net1001 VDD VSS BUF_X4
Xrebuffer537 _13926_ net1002 VDD VSS BUF_X8
Xrebuffer541 _15093_ net1006 VDD VSS BUF_X4
Xclone542 net888 net1007 VDD VSS INV_X8
Xclone543 net888 net1008 VDD VSS INV_X8
Xclone544 _12508_ net1009 VDD VSS BUF_X16
Xrebuffer545 _06350_ net1010 VDD VSS BUF_X1
Xrebuffer546 _06350_ net1011 VDD VSS BUF_X1
Xrebuffer547 net1011 net1012 VDD VSS BUF_X1
Xrebuffer548 _08004_ net1013 VDD VSS BUF_X1
Xrebuffer549 net1013 net1014 VDD VSS BUF_X1
Xrebuffer554 net1181 net1019 VDD VSS BUF_X2
Xrebuffer556 sa12_sr\[1\] net1021 VDD VSS BUF_X1
Xrebuffer557 net1167 net1022 VDD VSS BUF_X1
Xrebuffer558 net1022 net1023 VDD VSS BUF_X1
Xrebuffer559 _04896_ net1024 VDD VSS BUF_X8
Xrebuffer560 net1024 net1025 VDD VSS BUF_X1
Xrebuffer561 net1027 net1026 VDD VSS BUF_X2
Xrebuffer562 net853 net1027 VDD VSS BUF_X4
Xclone563 net941 net1028 VDD VSS BUF_X4
Xclone564 _04865_ net1029 VDD VSS BUF_X16
Xrebuffer565 _14738_ net1030 VDD VSS BUF_X4
Xrebuffer566 net1030 net1031 VDD VSS BUF_X1
Xsplit580 _15230_ net1045 VDD VSS CLKBUF_X2
Xclone581 _04348_ net1046 VDD VSS BUF_X8
Xrebuffer582 _04337_ net1047 VDD VSS BUF_X8
Xrebuffer590 _12683_ net1055 VDD VSS BUF_X4
Xrebuffer594 sa32_sub\[0\] net1059 VDD VSS BUF_X4
Xrebuffer601 _10480_ net1066 VDD VSS BUF_X2
Xclone602 _05092_ _04940_ _04946_ net1067 VDD VSS OAI21_X2
Xrebuffer603 _06623_ net1068 VDD VSS BUF_X1
Xrebuffer604 _14776_ net1069 VDD VSS BUF_X4
Xrebuffer617 net1149 net1082 VDD VSS BUF_X16
Xrebuffer632 _13996_ net1097 VDD VSS BUF_X8
Xrebuffer633 sa32_sub\[1\] net1098 VDD VSS BUF_X4
Xclone634 net1100 net1099 VDD VSS BUF_X4
Xrebuffer635 _15034_ net1100 VDD VSS BUF_X1
Xclone636 _14152_ net1101 VDD VSS BUF_X8
Xrebuffer639 _14661_ net1104 VDD VSS BUF_X1
Xrebuffer640 _14661_ net1105 VDD VSS BUF_X2
Xclone641 _13840_ net1106 VDD VSS BUF_X8
Xclone642 net1002 net1107 VDD VSS BUF_X8
Xrebuffer645 _08498_ net1110 VDD VSS BUF_X1
Xrebuffer646 _08498_ net1111 VDD VSS BUF_X1
Xclone647 net1113 net1112 VDD VSS INV_X4
Xrebuffer648 _13926_ net1113 VDD VSS BUF_X4
Xclone649 _02972_ net1114 VDD VSS BUF_X8
Xrebuffer652 net1116 net1117 VDD VSS BUF_X1
Xrebuffer653 net1117 net1118 VDD VSS BUF_X1
Xrebuffer654 _14665_ net1119 VDD VSS BUF_X2
Xrebuffer655 net1119 net1120 VDD VSS BUF_X1
Xclone665 net524 net1130 VDD VSS INV_X2
Xrebuffer671 _14735_ net1136 VDD VSS BUF_X2
Xrebuffer676 net1 net1141 VDD VSS BUF_X2
Xsplit678 _14701_ net1143 VDD VSS CLKBUF_X2
Xhold679 net215 net1144 VDD VSS CLKBUF_X1
Xrebuffer111 _14993_ net1 VDD VSS BUF_X4
Xrebuffer113 _10433_ net605 VDD VSS BUF_X4
Xrebuffer114 net605 net611 VDD VSS BUF_X1
Xrebuffer135 _09151_ net624 VDD VSS BUF_X8
Xrebuffer146 _11852_ net627 VDD VSS BUF_X1
Xrebuffer150 _10450_ net630 VDD VSS BUF_X1
Xrebuffer162 _09002_ net663 VDD VSS BUF_X8
Xrebuffer163 _08991_ net664 VDD VSS BUF_X1
Xclone187 net683 net682 VDD VSS BUF_X4
Xrebuffer188 _14870_ net683 VDD VSS BUF_X1
Xrebuffer197 _06475_ net708 VDD VSS BUF_X1
Xclone198 _07381_ net709 VDD VSS BUF_X8
Xclone199 _07426_ net710 VDD VSS INV_X4
Xrebuffer219 _15002_ net835 VDD VSS BUF_X2
Xrebuffer228 net836 net837 VDD VSS BUF_X1
Xrebuffer240 net657 net849 VDD VSS BUF_X4
Xrebuffer242 _10437_ net852 VDD VSS BUF_X1
Xrebuffer243 sa20_sub\[1\] net853 VDD VSS BUF_X4
Xrebuffer244 _01619_ net854 VDD VSS BUF_X1
Xrebuffer249 net856 net857 VDD VSS BUF_X1
Xclone252 net663 net861 VDD VSS INV_X8
Xrebuffer263 _13213_ net862 VDD VSS BUF_X8
Xrebuffer264 net862 net863 VDD VSS BUF_X2
Xrebuffer283 _11856_ net880 VDD VSS BUF_X1
Xrebuffer294 _09725_ net910 VDD VSS BUF_X1
Xrebuffer295 _10153_ net911 VDD VSS BUF_X4
Xrebuffer308 _14662_ net921 VDD VSS BUF_X1
Xrebuffer309 _14833_ net922 VDD VSS BUF_X4
Xrebuffer317 _01593_ net933 VDD VSS BUF_X1
Xrebuffer322 _14926_ net935 VDD VSS BUF_X4
Xrebuffer336 _14894_ net957 VDD VSS BUF_X2
Xclone337 net964 net963 VDD VSS BUF_X2
Xrebuffer343 _14894_ net964 VDD VSS BUF_X1
Xclone344 net474 _11231_ _11235_ net965 VDD VSS OAI21_X4
Xrebuffer345 _04232_ net966 VDD VSS BUF_X1
Xrebuffer356 _04863_ net967 VDD VSS BUF_X4
Xrebuffer371 _11344_ net982 VDD VSS BUF_X8
Xclone381 _11855_ net991 VDD VSS BUF_X16
Xclone382 _11853_ net992 VDD VSS BUF_X16
Xclone385 net997 net995 VDD VSS BUF_X4
Xclone386 net813 net996 VDD VSS INV_X4
Xrebuffer387 _15174_ net997 VDD VSS BUF_X2
Xclone388 _02937_ net998 VDD VSS BUF_X8
Xclone390 _09010_ net1000 VDD VSS BUF_X16
Xclone391 _03036_ net1003 VDD VSS BUF_X8
Xclone392 _09099_ net1004 VDD VSS BUF_X16
Xrebuffer396 _11513_ net1016 VDD VSS BUF_X4
Xrebuffer403 _15274_ net1033 VDD VSS BUF_X2
Xrebuffer405 net1033 net1034 VDD VSS BUF_X2
Xrebuffer409 _02936_ net1038 VDD VSS BUF_X4
Xclone410 _09856_ net1039 VDD VSS BUF_X16
Xrebuffer414 _02278_ net1041 VDD VSS BUF_X1
Xrebuffer415 _01140_ net1042 VDD VSS BUF_X4
Xrebuffer419 _14842_ net1049 VDD VSS BUF_X1
Xclone420 _09735_ net1050 VDD VSS BUF_X16
Xrebuffer421 _15172_ net1051 VDD VSS BUF_X4
Xclone426 _05531_ net1053 VDD VSS BUF_X4
Xrebuffer437 _03145_ net1057 VDD VSS BUF_X4
Xclone438 _05548_ net1058 VDD VSS BUF_X8
Xrebuffer444 _06347_ net1064 VDD VSS BUF_X2
Xrebuffer445 net1064 net1065 VDD VSS BUF_X1
Xrebuffer454 _15104_ net1071 VDD VSS BUF_X1
Xclone455 _01604_ net1072 VDD VSS BUF_X16
Xrebuffer457 _04862_ net1074 VDD VSS BUF_X1
Xrebuffer460 net1074 net1075 VDD VSS BUF_X1
Xrebuffer465 _15230_ net1078 VDD VSS BUF_X2
Xclone470 net1086 net1084 VDD VSS BUF_X16
Xclone471 _08974_ net1085 VDD VSS BUF_X16
Xclone472 _08972_ net1086 VDD VSS BUF_X16
Xclone476 net1091 net1090 VDD VSS BUF_X8
Xclone477 net1092 net1091 VDD VSS BUF_X8
Xrebuffer480 _14957_ net1092 VDD VSS BUF_X2
Xclone481 _12548_ net1093 VDD VSS BUF_X16
Xrebuffer485 _03942_ net1102 VDD VSS BUF_X2
Xrebuffer488 net1102 net1103 VDD VSS BUF_X1
Xclone490 _05532_ net1109 VDD VSS BUF_X16
Xclone494 _12549_ net1122 VDD VSS BUF_X16
Xrebuffer498 _14966_ net1123 VDD VSS BUF_X2
Xrebuffer499 net1123 net1124 VDD VSS BUF_X1
Xrebuffer500 _01086_ net1125 VDD VSS BUF_X2
Xclone516 net1145 net1142 VDD VSS BUF_X4
Xrebuffer517 _15064_ net1145 VDD VSS BUF_X1
Xrebuffer522 _08010_ net1150 VDD VSS BUF_X2
Xclone526 net1155 net1154 VDD VSS BUF_X2
Xrebuffer527 _08466_ net1155 VDD VSS BUF_X4
Xrebuffer528 _10480_ net1156 VDD VSS BUF_X1
Xrebuffer531 _04928_ net1159 VDD VSS BUF_X1
Xrebuffer532 net1159 net1160 VDD VSS BUF_X1
Xrebuffer533 _04928_ net1161 VDD VSS BUF_X1
Xrebuffer534 _04925_ net1162 VDD VSS BUF_X1
Xrebuffer535 net1162 net1163 VDD VSS BUF_X1
Xrebuffer538 _04925_ net1164 VDD VSS BUF_X1
Xrebuffer539 _05106_ net1165 VDD VSS BUF_X4
Xclone540 net1168 net1166 VDD VSS BUF_X4
Xrebuffer542 _04896_ net1167 VDD VSS BUF_X4
Xrebuffer543 net1167 net1168 VDD VSS BUF_X1
Xrebuffer550 _03145_ net1174 VDD VSS BUF_X2
Xrebuffer551 _13975_ net1175 VDD VSS BUF_X1
Xrebuffer555 _07012_ net1178 VDD VSS BUF_X2
Xrebuffer567 _04083_ net1181 VDD VSS BUF_X2
Xclone569 net700 net1183 VDD VSS BUF_X8
Xrebuffer571 u0.w\[1\]\[25\] net1185 VDD VSS BUF_X1
Xclone572 _06627_ net1186 VDD VSS BUF_X4
.ENDS aes_cipher_top
*
* ******************************************************************************
* *                                                                            *
* *                   Copyright (C) 2004-2010, Nangate Inc.                    *
* *                           All rights reserved.                             *
* *                                                                            *
* * Nangate and the Nangate logo are trademarks of Nangate Inc.                *
* *                                                                            *
* * All trademarks, logos, software marks, and trade names (collectively the   *
* * "Marks") in this program are proprietary to Nangate or other respective    *
* * owners that have granted Nangate the right and license to use such Marks.  *
* * You are not permitted to use the Marks without the prior written consent   *
* * of Nangate or such third party that may own the Marks.                     *
* *                                                                            *
* * This file has been provided pursuant to a License Agreement containing     *
* * restrictions on its use. This file contains valuable trade secrets and     *
* * proprietary information of Nangate Inc., and is protected by U.S. and      *
* * international laws and/or treaties.                                        *
* *                                                                            *
* * The copyright notice(s) in this file does not indicate actual or intended  *
* * publication of this file.                                                  *
* *                                                                            *
* *     NGLibraryCreator, v2010.08-HR32-SP3-2010-08-05 - build 1009061800      *
* *                                                                            *
* ******************************************************************************
*
*
* Running on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr).
* Local time is now Fri, 3 Dec 2010, 19:32:12.
* Main process id is 27821.
*
********************************************************************************
*                                                                              *
* Cellname:   AND2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:24:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 * A2)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 VSS A2 net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_neg A1 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_5 VDD A2 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:31 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 * A2)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND2_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:29 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 * A2)
M_i_3__m0_m2__m0 net_0__m0_0__m0_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m0 ZN_neg A1 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0_0__m1 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m1 VSS A2 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0_x2__m1 ZN_neg A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m0 VDD A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m1 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m0 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_0 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:35 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 * A2) * A3)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 VSS A3 net_1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VDD A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_6 ZN_neg A2 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD A3 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:26 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 * A2) * A3)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS A3 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VDD A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN_neg A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A3 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:25 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 * A2) * A3)
M_i_4__m0_m2__m0 net_1__m0_0__m0_0 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m0 net_0__m0_0__m0_0 A2 net_1__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m0 ZN_neg A1 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0_0__m1 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m1 net_1__m0_0__m1 A2 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0_m2__m1 VSS A3 net_1__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0_x2__m0 ZN_neg A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0_x2__m0 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m0 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m1 VDD A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0_x2__m1 ZN_neg A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0_x2__m1 VDD A3 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:41 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 * A2) * A3) * A4)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 net_2 A3 net_1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 VSS A4 net_2 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 ZN_neg A1 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD A2 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 ZN_neg A3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_9 VDD A4 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 * A2) * A3) * A4)
M_i_2 net_0 A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_2 A3 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS A4 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 ZN_neg A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A2 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 ZN_neg A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD A4 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 * A2) * A3) * A4)
M_i_5__m0 net_2__m0_0 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 net_1__m0_0 A3 net_2__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 net_0__m0_0 A2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 x1 A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0__m1 A1 x1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_2__m1 A3 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m1 VSS A4 net_2__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN x1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS x1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN x1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS x1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9__m0 x1 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 VDD A3 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 x1 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 VDD A1 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 x1 A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A2 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 x1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD A4 x1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN x1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD x1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN x1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD x1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ANTENNA_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:30:15 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ANTENNA_X1 A VDD VSS
*.PININFO A:I VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:12 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X1 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + B) + A)
M_i_1 net_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 ZN C2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:11 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X2 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + B) + A)
M_i_2__m0 ZN B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN C1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS C2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 net_2__m0_0 B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD A net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2__m1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_1 B net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN C2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN C1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_1 C2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:03 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X4 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((C1 * C2) + B) + A)))
M_i_0 net_0 C1 ZN_3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN_3 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A ZN_3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_8_0 ZN_4 ZN_3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_8_1 VSS ZN_3 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0 ZN ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_1 VSS ZN_4 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_2 ZN ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_3 VSS ZN_4 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_3 C1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_1 C2 ZN_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9_0 ZN_4 ZN_3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9_1 VDD ZN_3 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_0 ZN ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1 VDD ZN_4 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_2 ZN ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_3 VDD ZN_4 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:18:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X1 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A + (B1 * B2))
M_i_1 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X2 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A + (B1 * B2))
M_i_2_0_x2_1 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0_x2_0 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m1 net_0__m0_0__m1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m1 ZN B1 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m0 net_0__m0_0__m0_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m0 VSS B2 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0_x2_0 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_0_x2_1 net_1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m0 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m1 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m0 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m1 net_1 B2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X4 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A + (B1 * B2))
M_i_2_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN B1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS B2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 net_0__m2 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 ZN B1 net_0__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 net_0__m3 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 VSS B2 net_0__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1 net_1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_2 VDD A net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_3 net_1 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_1 B2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 ZN B2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m2 net_1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m3 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 net_1 B2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:07:32 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X1 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + A) + (B1 * B2))
M_i_4 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN C2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_2 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:07:38 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X2 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 * C2) + A) + (B1 * B2))
M_i_2_1 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 net_1__m0_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 VSS B2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_1__m1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 ZN B1 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN C1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS C2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7_1 net_3 A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 VDD B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_3 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 net_3 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_0 net_2 A net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN C2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2 C2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:07:31 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X4 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((C1 * C2) + A) + (B1 * B2))))
M_i_0 net_0 C1 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN_4 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B1 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_0 ZN_5 ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_1 VSS ZN_4 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_0 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_1 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_2 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_3 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 ZN_4 C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 C2 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_3 A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 VDD B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_1 ZN_5 ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_0 VDD ZN_4 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_0 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_1 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_2 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x4_3 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X1 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) + (B1 * B2)) + (C1 * C2))
M_i_5 net_2 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN C1 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_4 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 VDD C1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_4 B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_3 B2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN A2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_3 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X2 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) + (B1 * B2)) + (C1 * C2))
M_i_5__m1 net_2__m1 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 ZN C1 net_2__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 net_2__m0_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0 VSS C2 net_2__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 ZN B1 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_1__m0_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11__m0 VDD C2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10__m0 net_4 C1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10__m1 VDD C1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11__m1 net_4 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 net_3 B2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 net_4 B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_3 B1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_4 B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 ZN A1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_3 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 ZN A2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 net_3 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((A1 * A2) + (B1 * B2)) + (C1 * C2))))
M_i_0 net_0 A1 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN_5 B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_2 C1 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS C2 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x2_0 ZN_6 ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x2_1 VSS ZN_5 ZN_6 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_0 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_1 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_2 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_3 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 ZN_5 A1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_3 A2 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_4 B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 net_4 C1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11 VDD C2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_0 ZN_6 ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_1 VDD ZN_5 ZN_6 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_3 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_2 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_1 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_0 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X1 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) + (B1 * B2))
M_i_3 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:12:55 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X2 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) + (B1 * B2))
M_i_3__m0 net_1__m0_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 ZN B1 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_1__m1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS B2 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:13:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X4 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) + (B1 * B2))
M_i_3__m0 net_1__m0_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 ZN B1 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_1__m1 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS B2 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m2 net_1__m2 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 ZN B1 net_1__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 net_1__m3 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m3 VSS B2 net_1__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 net_0__m2 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 ZN A1 net_0__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 net_0__m3 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 VSS A2 net_0__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m2 VDD B2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m2 net_2 B1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m3 VDD B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m3 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 ZN A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 net_2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 net_2 A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X1 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X16.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X16 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_4 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_5 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_6 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_7 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_4 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_5 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_6 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_7 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X2 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x2_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x2_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X32.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:31:57 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X32 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_4 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_5 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_6 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_7 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_8 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_9 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_10 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_11 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_12 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_13 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_14 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_15 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_16 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_17 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_18 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_19 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_20 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_21 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_22 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_23 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_24 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_25 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_26 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_27 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_28 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_29 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_30 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_31 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_4 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_5 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_6 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_7 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_8 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_9 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_10 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_11 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_12 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_13 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_14 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_15 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_16 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_17 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_18 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_19 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_20 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_21 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_22 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_23 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_24 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_25 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_26 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_27 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_28 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_29 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_30 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_31 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:29:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X4 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X8.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:28:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X8 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_0 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 Z_neg A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 VSS A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 Z_neg A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X1 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.095000U L=0.050000U
M_i_0 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:41 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X2 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2 VSS A Z_neg VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_3 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X3.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:23 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X3 A Z VDD VSS
*.PININFO A:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_2_1 VSS A Z_neg VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_0_2 Z Z_neg VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_3_1 VDD A Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X1.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:04:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X1 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_52 net_008 CK net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_57 VSS net_002 net_008 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X2.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:03:58 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X2 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_57 VSS net_002 net_008 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52 net_008 CK net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X4.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:03:50 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X4 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_52 net_008 CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57 net_007 net_002 net_008 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_77 net_007 net_002 net_008b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_76 net_008b CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_15 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_29 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_69 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_72 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_11 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_28 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X8.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:04:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X8 CK E SE GCK VDD VSS
*.PININFO CK:I E:I SE:I GCK:O VDD:P VSS:G
M_i_0 net_000 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS E net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_006 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_001 net_000 VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_002 net_006 net_001 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_23 net_003 net_005 net_002 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 VSS net_004 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_33_93 net_004 net_002 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_33 net_004 net_002 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_46 net_006 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_52 net_008 CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57 net_007 net_002 net_008 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_77 net_007 net_002 net_008b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_76 net_008b CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_150 net_008c CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_123 net_007 net_002 net_008c VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_57_77_169 net_007 net_002 net_008d VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_52_76_137 net_008d CK VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_63 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_15 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_29 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_12 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_55 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_15_27 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_63_13_29_4 GCK net_007 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_69 net_009 SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_107 VDD net_006 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_80 net_010 net_000 VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_85 net_002 net_005 net_010 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_91 net_011 net_006 net_002 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_95 VDD net_004 net_011 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_101_94 net_004 net_002 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_101 net_004 net_002 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_114 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_120 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_69 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_72 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_163 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_158 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_127_69_164 VDD net_002 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_120_72_145 net_007 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_11 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_28 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_38 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_20 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_11_14 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_133_10_28_7 GCK net_007 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:03:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X1 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 VSS net_000 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_007 CK net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X2.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:02:42 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X2 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_007 CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45 VSS net_000 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X4.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:02:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X4 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 VSS net_000 net_007b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40 net_007b CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_75 net_007 CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_66 VSS net_000 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_10 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_25 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_71 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_74 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_24 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_19 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X8.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:02:20 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X8 CK E GCK VDD VSS
*.PININFO CK:I E:I GCK:O VDD:P VSS:G
M_i_27 net_004 net_005 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS E net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_003 net_005 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_11 net_002 net_004 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_0 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_174 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_33 VSS CK net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 VSS net_000 net_007b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40 net_007b CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_75 net_007 CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_66 VSS net_000 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_63 VSS net_000 net_007c VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_71 net_007c CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_40_75_82 net_007d CK net_006 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_45_66_78 VSS net_000 net_007d VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_51 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_10 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_25 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_40 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_58 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_10_28 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_51_7_25_30 GCK net_006 VSS VSS NMOS_VTL W=0.195000U L=0.050000U
M_i_84 net_004 net_005 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_78 VDD E net_009 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_74 net_009 net_004 net_002 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_68 net_002 net_005 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_57 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_57_165 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_90 VDD CK net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_71 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_74 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_72 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_99 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_97_71_87 net_006 CK VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_103_74_97 VDD net_000 net_006 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_24 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_19 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_53 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_22 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_24_52 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_109_4_19_36 GCK net_006 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFRS_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:01:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFRS_X1 D RN SN CK Q QN VDD VSS
*.PININFO D:I RN:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_MN81 QN z99 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN91_0_0 VSS z56 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_transistor_0 z99 z56 nn99 VSS NMOS_VTL W=0.210000U L=0.050000U
M_transistor_1 nn99 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN51 VSS z41 nn5 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN52 nn5 RN z56 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN63 VSS SN nn62 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN62 nn62 z56 nn61 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN61 nn61 ckn_i z41 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN41 z41 ck_i nn4 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN42 nn4 z37 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_0 VSS z37 nn2 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_1 nn2 SN z51 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN101 VSS ckn_i ck_i VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN33 VSS RN nn32 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN32 nn32 z51 nn31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN31 nn31 ck_i z37 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z37 ckn_i nn1 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN12 nn1 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN91 ckn_i CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP81_0 QN z99 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_1 VDD z56 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_transistor_2 VDD z56 z99 VDD PMOS_VTL W=0.315000U L=0.050000U
M_transistor_3 z99 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP51 z56 z41 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP52 VDD RN z56 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP63 VDD SN np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP61 VDD z56 np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP62 np61 ck_i z41 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP41 np4 ckn_i z41 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP42 VDD z37 np4 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP21 VDD z37 z51 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP22 z51 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP101 ck_i ckn_i VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP33 VDD RN np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP31 VDD z51 np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP34 np32 ckn_i z37 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP12 np1 ck_i z37 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP11 VDD D np1 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP91 ckn_i CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFRS_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:01:53 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFRS_X2 D RN SN CK Q QN VDD VSS
*.PININFO D:I RN:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_MN81_53 QN z99 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN81 QN z99 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN91_0_0 VSS z56 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN91_0_0_58 VSS z56 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_transistor_0 z99 z56 nn99 VSS NMOS_VTL W=0.310000U L=0.050000U
M_transistor_1 nn99 SN VSS VSS NMOS_VTL W=0.310000U L=0.050000U
M_MN51 VSS RN nn5 VSS NMOS_VTL W=0.310000U L=0.050000U
M_MN52 nn5 z41 z56 VSS NMOS_VTL W=0.310000U L=0.050000U
M_MN63 VSS SN nn62 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN62 nn62 z56 nn61 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN61 nn61 ckn_i z41 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN41 z41 ck_i nn4 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN42 nn4 z37 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_0 VSS z37 nn2 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP91_1 nn2 SN z51 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN101 VSS ckn_i ck_i VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN33 VSS RN nn32 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN32 nn32 z51 nn31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN31 nn31 ck_i z37 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z37 ckn_i nn1 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN12 nn1 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN91 ckn_i CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MP81_0_51 QN z99 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_0 QN z99 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_1 VDD z56 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP81_1_55 VDD z56 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_transistor_2 VDD z56 z99 VDD PMOS_VTL W=0.485000U L=0.050000U
M_transistor_3 z99 SN VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_MP52 VDD RN z56 VDD PMOS_VTL W=0.485000U L=0.050000U
M_MP51 z56 z41 VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_MP63 VDD SN np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP61 VDD z56 np61 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP62 np61 ck_i z41 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP41 np4 ckn_i z41 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP42 VDD z37 np4 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP21 VDD z37 z51 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP22 z51 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP101 ck_i ckn_i VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP33 VDD RN np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP31 VDD z51 np32 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP34 np32 ckn_i z37 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP12 np1 ck_i z37 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP11 VDD D np1 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP91 ckn_i CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFR_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:01:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFR_X1 D RN CK Q QN VDD VSS
*.PININFO D:I RN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 net_005 net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_32 VSS RN net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_38 VSS net_003 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_003 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_49 net_008 net_001 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 net_009 net_000 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 VSS net_011 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_65 net_010 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_70 net_011 net_008 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_76 VSS net_008 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_83 Q net_011 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_89 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_96 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_108 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_114 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_119 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_125 net_013 RN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_136 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 net_015 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_147 net_008 net_000 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_153 net_016 net_001 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_159 VDD net_011 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 net_011 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_172 VDD net_008 net_011 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_180 VDD net_008 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_187 Q net_011 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFR_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:00:47 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFR_X2 D RN CK Q QN VDD VSS
*.PININFO D:I RN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 net_005 net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_32 VSS RN net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_38 VSS net_003 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_003 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_49 net_008 net_001 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 net_009 net_000 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 VSS net_011 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_65 net_010 RN VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_70 net_011 net_008 net_010 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_76_4 VSS net_008 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_76 VSS net_008 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_83 Q net_011 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_83_49 Q net_011 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_89 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_96 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_103 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_108 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_114 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_119 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_125 net_013 RN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_136 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 net_015 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_147 net_008 net_000 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_153 net_016 net_001 net_008 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_159 VDD net_011 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 net_011 RN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_172 VDD net_008 net_011 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_180_3 VDD net_008 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_180 VDD net_008 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_187 Q net_011 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_187_39 Q net_011 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFS_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:00:41 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFS_X1 D SN CK Q QN VDD VSS
*.PININFO D:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_15 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_19 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_25 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 VSS net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_36 net_005 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_003 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_73 VSS net_003 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 net_011 net_001 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_63 net_010 net_000 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 net_009 net_007 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_53 net_008 SN VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_46 VSS net_010 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_86 QN net_010 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_79 VSS net_007 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_99 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_106 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_111 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_118 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_122 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_128 net_006 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_134 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_92 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_171 net_016 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 net_010 net_000 net_016 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_015 net_001 net_010 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 VDD net_007 net_015 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_149 net_015 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_142 VDD net_010 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_189 QN net_010 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_182 VDD net_007 Q VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFS_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:00:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFS_X2 D SN CK Q QN VDD VSS
*.PININFO D:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_15 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_19 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_25 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 VSS net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_36 net_005 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_003 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 VSS CK net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_73 VSS net_003 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 net_011 net_001 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_63 net_010 net_000 net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_59 net_009 net_007 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_53 net_008 SN VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_79_29 VSS net_007 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_79 VSS net_007 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_86 QN net_010 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_86_15 QN net_010 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_46 VSS net_010 net_007 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_99 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_106 net_012 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_111 net_003 net_001 net_012 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_118 net_013 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_122 VDD net_006 net_013 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_128 net_006 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_134 VDD net_003 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_92 VDD CK net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_171 net_016 net_003 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 net_010 net_000 net_016 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_015 net_001 net_010 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_165 VDD net_007 net_015 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_149 net_015 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_182_20 VDD net_007 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_182 VDD net_007 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_189 QN net_010 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_189_10 QN net_010 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_142 VDD net_010 net_007 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFF_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:59:45 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFF_X1 D CK Q QN VDD VSS
*.PININFO D:I CK:I Q:O QN:O VDD:P VSS:G
M_MN2 ci cni VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN6 VSS z4 z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN7 z3 ci z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN4 z2 cni z3 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN3 z2 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN5 z4 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN1 VSS CK cni VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN8 z12 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN9 z9 ci z12 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN12 z9 cni z8 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z8 z10 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN10 VSS z9 z10 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN14 QN z9 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN13 VSS z10 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MP2 ci cni VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP6 VDD z4 z1 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP7 z1 cni z3 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP4 z3 ci z5 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP3 z5 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP5 z4 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP1 VDD CK cni VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP8 z7 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP9 z9 cni z7 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP12 z9 ci z11 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP11 z11 z10 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP10 VDD z9 z10 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP14 QN z9 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP13 VDD z10 Q VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFF_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:59:42 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFF_X2 D CK Q QN VDD VSS
*.PININFO D:I CK:I Q:O QN:O VDD:P VSS:G
M_MN2 ci cni VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN6 VSS z4 z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN7 z3 ci z6 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN4 z2 cni z3 VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN3 z2 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_MN5 z4 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN1 VSS CK cni VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN8 z12 z3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN9 z9 ci z12 VSS NMOS_VTL W=0.210000U L=0.050000U
M_MN12 z9 cni z8 VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN11 z8 z10 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_MN10 VSS z9 z10 VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN14_8 QN z9 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN14 QN z9 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN13 VSS z10 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MN13_38 VSS z10 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_MP2 ci cni VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP6 VDD z4 z1 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP7 z1 cni z3 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP4 z3 ci z5 VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP3 z5 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_MP5 z4 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP1 VDD CK cni VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP8 z7 z3 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP9 z9 cni z7 VDD PMOS_VTL W=0.315000U L=0.050000U
M_MP12 z9 ci z11 VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP11 z11 z10 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_MP10 VDD z9 z10 VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP14_5 QN z9 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP14 QN z9 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP13 VDD z10 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_MP13_26 VDD z10 Q VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLH_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:59:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLH_X1 D G Q VDD VSS
*.PININFO D:I G:I Q:O VDD:P VSS:G
M_i_0 VSS G net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41_11 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_001 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24 net_004 net_000 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_34 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_48 VDD G net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_89_4 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_55 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_61 net_006 D VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_66 net_003 net_000 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_72 net_007 net_001 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_76 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_82 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLH_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:52 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLH_X2 D G Q VDD VSS
*.PININFO D:I G:I Q:O VDD:P VSS:G
M_i_0 VSS G net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_41_11 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_001 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_000 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_34 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_48 VDD G net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_89 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_89_4 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_55 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_61 net_006 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_66 net_003 net_000 net_006 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_72 net_007 net_001 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_76 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_82 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLL_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLL_X1 D GN Q VDD VSS
*.PININFO D:I GN:I Q:O VDD:P VSS:G
M_i_7 VSS net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_29 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_35 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_42 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_000 GN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 VDD net_000 net_001 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_62 net_006 D VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_67 net_003 net_001 net_006 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_73 net_007 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_79 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_85 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_92 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_000 GN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLL_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:19 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLL_X2 D GN Q VDD VSS
*.PININFO D:I GN:I Q:O VDD:P VSS:G
M_i_7 VSS net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_001 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_29 VSS net_005 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_35 VSS net_003 net_005 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_42_3 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_42 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_000 GN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_55 VDD net_000 net_001 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_62 net_006 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_67 net_003 net_001 net_006 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_73 net_007 net_000 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_79 VDD net_005 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_85 VDD net_003 net_005 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_92_11 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_92 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_000 GN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FA_X1.                                                           *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:24 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FA_X1 A B CI CO S VDD VSS
*.PININFO A:I B:I CI:I CO:O S:O VDD:P VSS:G
*.EQN CO=((A * B) + (CI * (A + B)));S=(CI ^ (A ^ B))
M_instance_159 CO net_001 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_instance_166 VSS B net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_170 net_000 A net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_176 net_001 CI net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_188 net_002 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_182 VSS B net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_227 net_006 B VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_215 VSS CI net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_221 net_006 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_209 net_005 net_001 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_203 net_004 CI net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_199 net_003 B net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_194 VSS A net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_instance_233 S net_005 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_instance_239 CO net_001 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_instance_246 VDD B net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_251 net_007 A net_001 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_257 net_001 CI net_008 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_269 net_008 A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_263 VDD B net_008 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_309 net_011 B VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_297 VDD CI net_011 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_303 net_011 A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_290 net_005 net_001 net_011 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_284 net_010 CI net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_280 net_009 B net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_275 VDD A net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_instance_315 S net_005 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X1.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X1 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TAPCELL_X1.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TAPCELL_X1 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X16.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:23 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X16 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X2.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:27:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X2 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X32.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:13 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X32 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X4.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:50 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X4 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X8.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X8 VDD VSS
*.PININFO VDD:P VSS:G
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HA_X1.                                                           *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:27 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT HA_X1 A B CO S VDD VSS
*.PININFO A:I B:I CO:O S:O VDD:P VSS:G
*.EQN CO=(A * B);S=(A ^ B)
M_i_1 net_0 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 S A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS x1 S VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 x1 B VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_6 VSS A x1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_12 net_3 A CO_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 VSS B net_3 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_10 CO CO_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 S B net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 net_1 A S VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD x1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_2 B VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 x1 A net_2 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_14 CO_neg A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_15 VDD B CO_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_11 CO CO_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:52 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X1 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X16.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:12 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X16 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X2 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0_x2_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0_x2_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x2_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X32.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:26:38 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X32 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_4 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_5 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_6 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_7 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_8 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_9 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_11 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_12 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_13 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_16 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_17 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_18 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_19 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_20 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_21 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_22 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_23 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_24 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_25 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_26 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_27 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_28 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_29 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_30 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_31 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_4 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_6 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_8 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_9 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_10 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_11 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_12 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_13 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_14 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_15 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_16 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_17 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_18 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_19 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_20 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_21 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_22 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_23 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_24 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_25 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_26 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_27 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_28 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_29 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_30 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_31 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:25:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X4 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0_x4_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0_x4_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X8.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:24:46 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X8 A ZN VDD VSS
*.PININFO A:I ZN:O VDD:P VSS:G
*.EQN ZN=!A
M_i_0_0_x8_0 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_1 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_2 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_3 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_4 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_5 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_6 ZN A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x8_7 VSS A ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_0_x8_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_4 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_6 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x8_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LOGIC0_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:24:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LOGIC0_X1 Z VDD VSS
*.PININFO Z:O VDD:P VSS:G
M_n_tran_1 VSS A Z VSS NMOS_VTL W=0.090000U L=0.050000U
M_transistor_0 VDD A A VDD PMOS_VTL W=0.090000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LOGIC1_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:23:59 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LOGIC1_X1 Z VDD VSS
*.PININFO Z:O VDD:P VSS:G
M_n_tran_1 VSS A A VSS NMOS_VTL W=0.090000U L=0.050000U
M_p_tran_2 VDD A Z VDD PMOS_VTL W=0.135000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   MUX2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:17:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT MUX2_X1 A B S Z VDD VSS
*.PININFO A:I B:I S:I Z:O VDD:P VSS:G
*.EQN Z=((S * B) + (A * !S))
M_i_10 VSS S x1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 net_1 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 Z_neg x1 net_1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_2 Z_neg S net_0 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 net_0 B VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 VDD S x1 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 VDD A net_2 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_6 net_2 S Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_9 net_3 x1 Z_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD B net_3 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   MUX2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:57 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT MUX2_X2 A B S Z VDD VSS
*.PININFO A:I B:I S:I Z:O VDD:P VSS:G
*.EQN Z=((S * B) + (A * !S))
M_i_4 net_1 A Z_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS x1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 Z_neg S net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS Z_neg Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 Z Z_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10 VSS S x1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_8 VDD A net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_2 x1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 Z_neg B net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 S Z_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 VDD Z_neg Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 Z Z_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11 VDD S x1 VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 * A2)
M_i_1 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:47 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 * A2)
M_i_1__m0_m2__m0 net_0__m0__m0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m0 ZN A1 net_0__m0__m0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m1 net_0__m0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m1 VSS A2 net_0__m0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_x2__m0 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_x2__m0 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_x2__m1 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m1 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:44 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 * A2)
M_i_1_0 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_1 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_2 VSS A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_3 net_0 A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_0 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_2 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_3 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_0 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_1 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_2 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2_3 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:24 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) * A3)
M_i_2 net_1 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:17 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) * A3)
M_i_2__m0_m2__m0 net_1__m0_0__m0_0 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m0 net_0__m0_0__m0_0 A2 net_1__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m0 ZN A1 net_0__m0_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_m2__m1 net_0__m0_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_m2__m1 net_1__m0_0__m1 A2 net_0__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_m2__m1 VSS A3 net_1__m0_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0_x2__m0 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m0 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m0 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_x2__m1 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_x2__m1 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_x2__m1 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:16:27 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 * A2) * A3)
M_i_2__m0 net_1__m0_0 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_1__m1 A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS A3 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 net_1__m2 A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 net_0__m2 A2 net_1__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 ZN A1 net_0__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 net_0__m3 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_1__m3 A2 net_0__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 VSS A3 net_1__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m2 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m3 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:11:28 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) * A3) * A4)
M_i_3 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:11:18 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) * A3) * A4)
M_i_3__m0 net_2__m0_0 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_1__m0_0 A3 net_2__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 net_0__m0_0 A2 net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0__m1 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_1__m1 A2 net_0__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_2__m1 A3 net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS A4 net_2__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 ZN A1 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A2 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 ZN A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A4 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:11:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 * A2) * A3) * A4)
M_i_0_187 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_85 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_34 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_177 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_24 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_75 net_0 A2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_196 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_94 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_43 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A3 net_2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_170 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_68 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_17 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_2 A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4_168 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_66 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_15 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 VDD A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_189 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_36 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_87 ZN A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_202 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_100 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_49 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD A3 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_154 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_52 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:22 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 + A2)
M_i_1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:11 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 + A2)
M_i_1__m0_x2__m0 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m1 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m0 net_0__m0__m0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m0 ZN A1 net_0__m0__m0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m1 VDD A2 net_0__m0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:22:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A1 + A2)
M_i_1__m0_x2__m0_16 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m0_35 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m1_57 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m1_23 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m0 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0_x2__m1 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0_x2__m1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_m2__m0_38 net_0__m0__m3 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m0_52 ZN A1 net_0__m0__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m1_45 net_0__m0__m2 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m1_58 VDD A2 net_0__m0__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m0 net_0__m0__m0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m0 ZN A1 net_0__m0__m0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_2__m0_m2__m1 net_0__m0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0_m2__m1 VDD A2 net_0__m0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:39 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) + A3)
M_i_2 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:33 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) + A3)
M_i_2_0_x2__m0 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_1_x2__m0 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2__m0 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x2__m1 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_1_x2__m1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0_x2__m1 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_1_m2__m0 net_1_0__m0_0 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_0_m2__m0 net_0_0__m0_0 A2 net_1_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1_m2__m0 ZN A1 net_0_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_1_m2__m1 net_0_0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_0_m2__m1 net_1_0__m1 A2 net_0_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1_m2__m1 VDD A3 net_1_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) + A3)
M_i_0_28 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_19 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_31 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_40 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_49 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_58 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_67 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_85 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_24 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_15 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3_6 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_34 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_43 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_52 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_56 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_65 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_83 net_1 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:10:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) + A4)
M_i_3 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:10:31 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) + A4)
M_i_3__m0 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 VSS A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 ZN A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS A4 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_2__m0_0 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_1__m0_0 A3 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_0__m0_0 A2 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN A1 net_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_0__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_1__m1 A2 net_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2__m1 A3 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A4 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:10:50 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) + A4)
M_i_0_22 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_22_71 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_77 VSS A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_13 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_13_89 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1_79 ZN A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_29 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_52 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_29_45 VSS A3 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_8 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_109 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3_8_108 ZN A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4_6 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_6_75 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4_68 ZN A1 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_24 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_24_95 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_88 net_0 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_34 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_56 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6_34_44 net_1 A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_102 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1_96 net_2 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X1 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * B)
M_i_1 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS B net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_2 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 ZN C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:59 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X2 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * B)
M_i_2__m0 net_1__m0_0 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0 A net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD B ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_2__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN C1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_2__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD C2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:10 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X4 A B C1 C2 ZN VDD VSS
*.PININFO A:I B:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * B)
M_i_2__m0 net_1__m0_0 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B net_1__m0_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1__m1 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0 A net_1__m1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 net_1__m2 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m2 VSS B net_1__m2 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m3 net_1__m3 B VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 net_0 A net_1__m3 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD B ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m2 VDD B ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m3 ZN B VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_2__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN C1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_2__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD C2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 net_2__m2 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 ZN C1 net_2__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 net_2__m3 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 VDD C2 net_2__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X1 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A * (B1 + B2))
M_i_1 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_1 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3 ZN B1 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:55 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X2 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A * (B1 + B2))
M_i_2_0 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 net_0 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 B2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_1__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 ZN B1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 net_1__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 VDD B2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:15:03 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X4 A B1 B2 ZN VDD VSS
*.PININFO A:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A * (B1 + B2))
M_i_2_0 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 net_0 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_2 VSS A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_3 net_0 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 B2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 ZN B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 net_0 B1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 ZN B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_0 B2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_2 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5_3 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 net_1__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m0 ZN B1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m1 net_1__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 VDD B2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 net_1__m2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m2 ZN B1 net_1__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_3__m3 net_1__m3 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 VDD B2 net_1__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:54 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X1 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * (B1 + B2))
M_i_4 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_0 A net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9 net_3 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 ZN B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_2 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 ZN C1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:53 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X2 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((C1 + C2) * A) * (B1 + B2))
M_i_1__m0 ZN C2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 C1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 C2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_1 net_1 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_1 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_1 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2_0 net_0 A net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6__m0 net_2__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN C1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_2__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 VDD C2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_0 ZN A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_3__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD B2 net_3__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_3__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 ZN B1 net_3__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7_1 VDD A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:06:43 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X4 A B1 B2 C1 C2 ZN VDD VSS
*.PININFO A:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((C1 + C2) * A) * (B1 + B2))))
M_i_0 ZN_4 C1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 C2 ZN_4 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 A net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_0 ZN_5 ZN_4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10_0_x2_1 VSS ZN_4 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_0 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_1 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_2 ZN ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_0_x4_3 VSS ZN_5 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_2 C1 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 VDD C2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 ZN_4 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 ZN_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_1 ZN_5 ZN_4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11_1_x2_0 VDD ZN_4 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_3 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_2 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_1 ZN ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_3_x4_0 VDD ZN_5 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X1 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) * (B1 + B2)) * (C1 + C2))
M_i_5 net_1 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS C1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_1 B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_4 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 ZN C1 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_3 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD B2 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN A1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:02 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X2 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) * (B1 + B2)) * (C1 + C2))
M_i_4__m0 VSS C1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m1 net_1 C2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0 VSS C2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 net_1 C1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 net_0 B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 net_1 B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_0 B2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_1 B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_10__m1 net_4__m1 C1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11__m1 VDD C2 net_4__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11__m0 net_4__m0_0 C2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10__m0 ZN C1 net_4__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_3__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD B2 net_3__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m0 net_3__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 ZN B1 net_3__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_2__m0_0 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 VDD A2 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_2__m1 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 ZN A1 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:04:48 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I C1:I C2:I ZN:O VDD:P VSS:G
*.EQN ZN=!(!(!(((A1 + A2) * (B1 + B2)) * (C1 + C2))))
M_i_0 ZN_5 A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 ZN_5 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_1 B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_0 B1 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_1 C1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS C2 net_1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_1_x2_1 ZN_6 ZN_5 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_12_1_x2_0 VSS ZN_5 ZN_6 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_0 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_2 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_1 ZN ZN_6 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_14_0_x4_3 VSS ZN_6 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 net_2 A1 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A2 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 net_3 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 ZN_5 B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 net_4 C1 ZN_5 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_11 VDD C2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_0 ZN_6 ZN_5 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_13_0_x2_1 VDD ZN_5 ZN_6 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_3 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_2 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_0 ZN ZN_6 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_15_3_x4_1 VDD ZN_6 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X1 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) * (B1 + B2))
M_i_3 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 net_2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 ZN B1 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4 net_1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:44 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X2 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) * (B1 + B2))
M_i_3__m0 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_2__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN B1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD B2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_1__m0_0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN A1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_1__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:09:56 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X4 A1 A2 B1 B2 ZN VDD VSS
*.PININFO A1:I A2:I B1:I B2:I ZN:O VDD:P VSS:G
*.EQN ZN=!((A1 + A2) * (B1 + B2))
M_i_3__m0 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m2 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m2 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m3 VSS B1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m3 net_0 B2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m0 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m0 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m1 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m2 ZN A2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m2 net_0 A1 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0__m3 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1__m3 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_2__m0_0 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN B1 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_2__m1 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD B2 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m2 net_2__m2 B2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m2 ZN B1 net_2__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m3 net_2__m3 B1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m3 VDD B2 net_2__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 net_1__m0_0 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0 ZN A1 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m1 net_1__m1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 VDD A2 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m2 net_1__m2 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m2 ZN A1 net_1__m2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m3 net_1__m3 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m3 VDD A2 net_1__m3 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI33_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:05:27 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI33_X1 A1 A2 A3 B1 B2 B3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I B1:I B2:I B3:I ZN:O VDD:P VSS:G
*.EQN ZN=!(((A1 + A2) + A3) * ((B1 + B2) + B3))
M_i_5 net_0 B3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS B2 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 net_0 B1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 ZN A1 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_1 net_0 A2 ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2 ZN A3 net_0 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_4 B3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_10 net_3 B2 net_4 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 ZN B1 net_3 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A1 ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_2 A2 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 VDD A3 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:49 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X1 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 + A2)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_0 A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_5 VDD A2 net_0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X2 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 + A2)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 net_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5 VDD A2 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X4 A1 A2 ZN VDD VSS
*.PININFO A1:I A2:I ZN:O VDD:P VSS:G
*.EQN ZN=(A1 + A2)
M_i_3__m0_x2__m1 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_x2__m1 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0_x2__m0 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0_x2__m0 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_2 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_3 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0_x4_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m0_m2__m1 net_0__m0_0__m1 A2 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_m2__m1 ZN_neg A1 net_0__m0_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_4__m0_m2__m0 net_0__m0_0__m0_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0_m2__m0 VDD A2 net_0__m0_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_2 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_3 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0_x4_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:16 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X1 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 + A2) + A3)
M_i_2 VSS A1 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 ZN_neg A2 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 VSS A3 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_0 A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_6 net_1 A2 net_0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 VDD A3 net_1 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:13 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X2 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 + A2) + A3)
M_i_2 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 VSS A3 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 net_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6 net_1 A2 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 VDD A3 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:14:20 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X4 A1 A2 A3 ZN VDD VSS
*.PININFO A1:I A2:I A3:I ZN:O VDD:P VSS:G
*.EQN ZN=((A1 + A2) + A3)
M_i_4__m0 ZN_neg A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 VSS A3 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7__m0 net_1__m0_0 A3 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 net_0__m0_0 A2 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m0 ZN_neg A1 net_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_5__m1 net_0__m1 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_1__m1 A2 net_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 VDD A3 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:17 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X1 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 + A2) + A3) + A4)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_4 ZN_neg A3 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 VSS A4 ZN_neg VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 net_0 A1 ZN_neg VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_7 net_1 A2 net_0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_8 net_2 A3 net_1 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_9 VDD A4 net_2 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_1 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:10 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X2 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 + A2) + A3) + A4)
M_i_2 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4 ZN_neg A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS A4 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_6 net_0 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7 net_1 A2 net_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8 net_2 A3 net_1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9 VDD A4 net_2 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:08:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X4 A1 A2 A3 A4 ZN VDD VSS
*.PININFO A1:I A2:I A3:I A4:I ZN:O VDD:P VSS:G
*.EQN ZN=(((A1 + A2) + A3) + A4)
M_i_5__m0 ZN_neg A4 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m0 VSS A3 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m0 ZN_neg A2 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m0 VSS A1 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_2__m1 ZN_neg A1 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_3__m1 VSS A2 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_4__m1 ZN_neg A3 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5__m1 VSS A4 ZN_neg VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_0 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_1 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_2 ZN ZN_neg VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_3 VSS ZN_neg ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_9__m0 net_2__m0_0 A4 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m0 net_1__m0_0 A3 net_2__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m0 net_0__m0_0 A2 net_1__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m0 ZN_neg A1 net_0__m0_0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_6__m1 net_0__m1 A1 ZN_neg VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_7__m1 net_1__m1 A2 net_0__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_8__m1 net_2__m1 A3 net_1__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_9__m1 VDD A4 net_2__m1 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_0 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_1 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_2 ZN ZN_neg VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_1_3 VDD ZN_neg ZN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFRS_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:05 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFRS_X1 D RN SE SI SN CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_132 Q net_019 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_125 VSS net_017 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_119 net_019 net_017 net_018 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_114 net_018 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_101 net_016 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_106 net_017 net_013 net_016 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_28 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_95 VSS RN net_015 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_91 net_015 net_017 net_014 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 net_014 net_004 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_81 net_013 net_005 net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_71 VSS net_007 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_66 net_011 RN net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_52 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_46 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_12 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_22 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_290 Q net_019 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_277 VDD net_017 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_284 VDD net_017 net_019 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_270 net_019 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_255 net_017 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_262 VDD net_013 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_165 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_248 VDD RN net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_234 net_026 net_017 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_238 net_013 net_005 net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_223 net_025 net_004 net_013 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_228 VDD net_007 net_025 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_217 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_211 net_010 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_172 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD SN net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 net_023 net_010 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_007 net_004 net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_022 net_005 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_183 VDD net_002 net_022 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_159 VDD SI net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 net_021 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_002 SE net_020 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_145 net_020 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_138 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFRS_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:58:01 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFRS_X2 D RN SE SI SN CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_132_2 Q net_019 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_132 Q net_019 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_125 VSS net_017 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_125_68 VSS net_017 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_114 net_018 net_017 VSS VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_119 net_019 RN net_018 VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_106 net_017 SN net_016 VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_101 net_016 net_013 VSS VSS NMOS_VTL W=0.310000U L=0.050000U
M_i_28 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_95 VSS RN net_015 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_91 net_015 net_017 net_014 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 net_014 net_004 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_81 net_013 net_005 net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_71 VSS net_007 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_66 net_011 RN net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_52 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_46 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_41 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_12 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_18 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_22 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_290_11 Q net_019 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_290 Q net_019 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_277 VDD net_017 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_277_67 VDD net_017 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_284 VDD net_017 net_019 VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_270 net_019 RN VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_255 net_017 SN VDD VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_262 VDD net_013 net_017 VDD PMOS_VTL W=0.485000U L=0.050000U
M_i_165 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_248 VDD RN net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_234 net_026 net_017 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_238 net_013 net_005 net_026 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_223 net_025 net_004 net_013 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_228 VDD net_007 net_025 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_217 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_211 net_010 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_172 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD SN net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 net_023 net_010 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_007 net_004 net_023 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_022 net_005 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_183 VDD net_002 net_022 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_159 VDD SI net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 net_021 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_002 SE net_020 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_145 net_020 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_138 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFR_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:57:35 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFR_X1 D RN SE SI CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS net_000 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13 VSS net_003 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 net_001 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_25 net_002 net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_29 net_003 net_011 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_004 net_005 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_009 net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_011 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_005 net_011 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_62 net_008 net_006 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_009 net_005 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_72 net_010 net_011 net_009 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 VSS net_013 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_007 net_009 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 VSS RN net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_104 VSS SI net_014 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_100 net_014 SE net_013 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_94 net_013 net_015 net_012 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_89 net_012 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_110 net_015 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_116 VDD net_000 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_123 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_129 VDD net_003 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_136 net_017 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_151 VDD net_000 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_146 net_017 net_005 net_003 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_003 net_011 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_209 net_011 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_167 VDD net_011 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_188 net_019 net_006 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_009 net_011 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_199 net_020 net_005 net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD net_013 net_020 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_174 net_006 net_009 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_181 VDD RN net_006 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_215 net_021 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_220 net_013 net_015 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_226 net_022 SE net_013 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_230 VDD D net_022 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_236 net_015 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFR_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:56:45 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFR_X2 D RN SE SI CK Q QN VDD VSS
*.PININFO D:I RN:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_13 VSS net_003 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7_145 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 Q net_003 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS net_000 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_10 VSS net_000 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_21 net_001 RN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_25 net_002 net_000 net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_29 net_003 net_011 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_35 net_004 net_005 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_39 VSS net_009 net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_011 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_005 net_011 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_62 net_008 net_006 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_009 net_005 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_72 net_010 net_011 net_009 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 VSS net_013 net_010 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_007 net_009 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 VSS RN net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_104 VSS SI net_014 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_100 net_014 SE net_013 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_94 net_013 net_015 net_012 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_89 net_012 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_110 net_015 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_129 VDD net_003 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_123_146 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_123 Q net_003 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_116 VDD net_000 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_116_1 VDD net_000 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_136 net_017 RN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_151 VDD net_000 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_146 net_017 net_005 net_003 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_161 net_003 net_011 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_209 net_011 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_167 VDD net_011 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_188 net_019 net_006 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_193 net_009 net_011 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_199 net_020 net_005 net_009 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_203 VDD net_013 net_020 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_174 net_006 net_009 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_181 VDD RN net_006 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_215 net_021 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_220 net_013 net_015 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_226 net_022 SE net_013 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_230 VDD D net_022 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_236 net_015 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFS_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:56:36 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFS_X1 D SE SI SN CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_11 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_27 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_010 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_73 net_011 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_005 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_013 net_004 net_012 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 VSS net_015 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_93 net_014 SN VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_97 net_015 net_012 net_014 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_110 Q net_012 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_103 VSS net_015 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_116 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_123 net_016 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_127 net_002 SE net_016 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_133 net_017 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_137 VDD SI net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_150 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_007 net_005 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_168 net_019 net_004 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 VDD net_010 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_019 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_197 net_021 net_007 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_201 net_012 net_004 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_208 net_022 net_005 net_012 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_212 VDD net_015 net_022 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_218 net_015 SN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_224 VDD net_012 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_237 Q net_012 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_230 VDD net_015 QN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFS_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:56:22 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFS_X2 D SE SI SN CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I SN:I CK:I Q:O QN:O VDD:P VSS:G
M_i_0 VSS SE net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_21 VSS D net_003 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_17 net_003 net_000 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_11 net_002 SE net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 SI VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_27 VSS CK net_004 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 net_005 net_004 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_006 net_002 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_45 net_007 net_004 net_006 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_51 net_008 net_005 net_007 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_56 net_009 net_010 net_008 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_60 VSS SN net_009 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_73 net_011 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_77 net_012 net_005 net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_83 net_013 net_004 net_012 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_87 VSS net_015 net_013 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_66 net_010 net_007 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_93 net_014 SN net_015 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_97 VSS net_012 net_014 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_110_2 Q net_012 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_110 Q net_012 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_103 VSS net_015 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_103_26 VSS net_015 QN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_116 VDD SE net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_123 net_016 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_127 net_002 SE net_016 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_133 net_017 net_000 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_137 VDD SI net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD CK net_004 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_150 net_005 net_004 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_157 net_018 net_002 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_007 net_005 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_168 net_019 net_004 net_007 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 VDD net_010 net_019 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_178 net_019 SN VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_197 net_021 net_007 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_201 net_012 net_004 net_021 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_208 net_022 net_005 net_012 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_212 VDD net_015 net_022 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_189 VDD net_007 net_010 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_218 net_015 SN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_224 VDD net_012 net_015 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_237_1 Q net_012 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_237 Q net_012 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_230 VDD net_015 QN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_230_17 VDD net_015 QN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFF_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:55:24 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFF_X1 D SE SI CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_7 QN net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS net_002 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13 VSS net_002 net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_20 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_24 net_002 net_009 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 net_003 net_004 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 VSS net_007 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_004 net_009 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_75 net_009 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_54 net_006 net_005 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_58 net_007 net_004 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_009 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 VSS net_011 net_008 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_47 VSS net_007 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_96 VSS SI net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_92 net_012 SE net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_86 net_011 net_013 net_010 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_81 net_010 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_102 net_013 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_115 QN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_108 VDD net_002 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_121 VDD net_002 net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_128 net_014 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_132 net_002 net_004 net_014 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_138 net_015 net_009 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD net_007 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_004 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_182 net_009 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_016 net_005 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_166 net_007 net_009 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 net_017 net_004 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 VDD net_011 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 VDD net_007 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_189 net_018 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_194 net_011 net_013 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_200 net_019 SE net_011 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_204 VDD D net_019 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_210 net_013 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFF_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:55:29 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFF_X2 D SE SI CK Q QN VDD VSS
*.PININFO D:I SE:I SI:I CK:I Q:O QN:O VDD:P VSS:G
M_i_13 VSS net_002 net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_50 VSS net_002 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 VSS net_002 Q VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 QN net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7_4 QN net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_20 net_001 net_000 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_24 net_002 net_009 net_001 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_30 net_003 net_004 net_002 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_34 VSS net_007 net_003 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_40 net_004 net_009 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_75 net_009 CK VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_54 net_006 net_005 VSS VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_58 net_007 net_004 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_64 net_008 net_009 net_007 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_69 VSS net_011 net_008 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_47 VSS net_007 net_005 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_96 VSS SI net_012 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_92 net_012 SE net_011 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_86 net_011 net_013 net_010 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_81 net_010 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_102 net_013 SE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_121 VDD net_002 net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_108_51 VDD net_002 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_108 VDD net_002 Q VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_115 QN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_115_2 QN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_128 net_014 net_000 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_132 net_002 net_004 net_014 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_138 net_015 net_009 net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_143 VDD net_007 net_015 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_149 net_004 net_009 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_182 net_009 CK VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_162 net_016 net_005 VDD VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_166 net_007 net_009 net_016 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_172 net_017 net_004 net_007 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_176 VDD net_011 net_017 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_155 VDD net_007 net_005 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_189 net_018 SI VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_194 net_011 net_013 net_018 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_200 net_019 SE net_011 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_204 VDD D net_019 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_210 net_013 SE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:14 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X1 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_15_63 dummy1 A y VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24_0 VDD A dummy0 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24_1 dummy0 EN x VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X16.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:20:34 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X16 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6_6_40_125 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_45_122 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_37_112 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_42_108 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6_43 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_120 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_106 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_116 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6_40 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_45 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_37 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_42 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1a VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1a A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63_69 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_47_77 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_113 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_129 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24_3_19_50_12 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_39_66 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_18_103 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_9_17 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19_51 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_42 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_83 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_10 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19_50 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_39 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_18 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_9 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64_92 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_48_94 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_114 dummy0a EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_130 x A dummy0a VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 x A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1 dummy0 EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:21:00 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X2 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1 dummy0 EN x VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 VDD A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:20:21 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X4 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_24_3_19 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 x A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1 dummy0 EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.315000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X8.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:20:37 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X8 A EN Z VDD VSS
*.PININFO A:I EN:I Z:O VDD:P VSS:G
*.EQN Z=A
M_i_0_6_6_40 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13_45 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_37 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_42 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_13 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_6 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0 VSS x Z VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_0_14_47 VSS NEN dummy1a VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63 dummy1a A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_63_69 dummy1 A y VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_47_77 VSS NEN dummy1 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14_113 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15_129 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_15 VSS A x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0_14 VSS EN x VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 VSS EN NEN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24_3_19_50 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8_39 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_18 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_9 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3_19 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_8 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_3 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24 VDD y Z VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_24_1_48 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_64_92 VDD A y VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_48_94 y NEN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1_114 dummy0a EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0_130 x A dummy0a VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_0 x A dummy0 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_24_1 dummy0 EN VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 VDD EN NEN VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TINV_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TINV_X1 EN I ZN VDD VSS
*.PININFO EN:I I:I ZN:O VDD:P VSS:G
*.EQN ZN=!I
M_i_0 VSS EN net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 I VSS VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_11 ZN net_000 net_001 VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_17 VDD EN net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_24 net_002 I VDD VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_29 ZN EN net_002 VDD PMOS_VTL W=0.540000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TLAT_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 18:55:08 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT TLAT_X1 D G OE Q VDD VSS
*.PININFO D:I G:I OE:I Q:O VDD:P VSS:G
M_i_0 VSS G net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 net_001 net_000 VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 net_002 D VSS VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_18 net_003 net_001 net_002 VSS NMOS_VTL W=0.275000U L=0.050000U
M_i_24 net_004 net_000 net_003 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_28 VSS net_006 net_004 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_40 VSS net_003 net_006 VSS NMOS_VTL W=0.090000U L=0.050000U
M_i_34 net_005 OE VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_47 net_007 net_003 VSS VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_51 Q OE net_007 VSS NMOS_VTL W=0.355000U L=0.050000U
M_i_57 VDD G net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_64 net_001 net_000 VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_70 net_008 D VDD VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_75 net_003 net_000 net_008 VDD PMOS_VTL W=0.420000U L=0.050000U
M_i_81 net_009 net_001 net_003 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_85 VDD net_006 net_009 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_99 VDD net_003 net_006 VDD PMOS_VTL W=0.090000U L=0.050000U
M_i_91 net_005 OE VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_106 net_010 net_003 VDD VDD PMOS_VTL W=0.540000U L=0.050000U
M_i_111 Q net_005 net_010 VDD PMOS_VTL W=0.540000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XNOR2_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:40 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XNOR2_X1 A B ZN VDD VSS
*.PININFO A:I B:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A ^ B)
M_i_0 net_001 A net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_5 VSS B net_001 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_11 net_002 net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 ZN A net_002 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_23 net_002 B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_29 net_000 A VDD VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_36 VDD B net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_42 ZN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_003 A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 VDD B net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XNOR2_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:17 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XNOR2_X2 A B ZN VDD VSS
*.PININFO A:I B:I ZN:O VDD:P VSS:G
*.EQN ZN=!(A ^ B)
M_i_11_23 net_002 net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_11 net_002 net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_5 VSS B net_001 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_0 net_001 A net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17_20 ZN A net_002 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_17 ZN A net_002 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_23_12 net_002 B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_23 net_002 B ZN VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_42_14 ZN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_42 ZN net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_36 VDD B net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_29 net_000 A VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48 net_003 A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_48_8 net_003b A ZN VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53_25 VDD B net_003b VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 VDD B net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XOR2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:03 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XOR2_X1 A B Z VDD VSS
*.PININFO A:I B:I Z:O VDD:P VSS:G
*.EQN Z=(A ^ B)
M_i_0 net_000 A VSS VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_7 VSS B net_000 VSS NMOS_VTL W=0.210000U L=0.050000U
M_i_13 Z net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_19 net_001 A Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24 VSS B net_001 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_30 net_002 A net_000 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_35 VDD B net_002 VDD PMOS_VTL W=0.315000U L=0.050000U
M_i_41 net_003 net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_47 Z A net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 net_003 B Z VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XOR2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:19:07 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT XOR2_X2 A B Z VDD VSS
*.PININFO A:I B:I Z:O VDD:P VSS:G
*.EQN Z=(A ^ B)
M_i_0 net_000 A VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_7 VSS B net_000 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13 Z net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_19 net_001 A Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24 VSS B net_001 VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_24_4 VSS B net_001b VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_19_23 net_001b A Z VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_13_35 Z net_000 VSS VSS NMOS_VTL W=0.415000U L=0.050000U
M_i_30 net_002 A net_000 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_35 VDD B net_002 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_41 net_003 net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_47 Z A net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53 net_003 B Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_53_18 net_003 B Z VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_47_27 Z A net_003 VDD PMOS_VTL W=0.630000U L=0.050000U
M_i_41_29 net_003 net_000 VDD VDD PMOS_VTL W=0.630000U L=0.050000U
.ENDS

********************************************************************************
*
* END
*
********************************************************************************
