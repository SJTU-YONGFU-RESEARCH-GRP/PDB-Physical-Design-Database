* cell ahb_lite_master
* pin trans_burst[2]
* pin trans_burst[1]
* pin trans_burst[0]
* pin trans_size[2]
* pin trans_size[0]
* pin trans_size[1]
* pin hsize[0]
* pin hsize[1]
* pin hsize[2]
* pin hburst[1]
* pin hburst[2]
* pin hburst[0]
* pin haddr[0]
* pin haddr[2]
* pin trans_addr[0]
* pin trans_addr[3]
* pin trans_addr[2]
* pin haddr[3]
* pin haddr[1]
* pin trans_addr[1]
* pin haddr[5]
* pin haddr[7]
* pin trans_addr[4]
* pin trans_addr[7]
* pin trans_addr[5]
* pin haddr[4]
* pin trans_addr[6]
* pin trans_addr[11]
* pin haddr[6]
* pin haddr[11]
* pin haddr[8]
* pin trans_addr[8]
* pin hreset
* pin haddr[10]
* pin trans_addr[9]
* pin haddr[9]
* pin haddr[12]
* pin haddr[14]
* pin trans_addr[14]
* pin trans_addr[12]
* pin trans_addr[10]
* pin haddr[15]
* pin haddr[13]
* pin trans_addr[15]
* pin haddr[30]
* pin trans_addr[16]
* pin haddr[16]
* pin trans_addr[30]
* pin trans_addr[19]
* pin haddr[29]
* pin trans_addr[13]
* pin haddr[19]
* pin trans_addr[29]
* pin haddr[17]
* pin trans_addr[17]
* pin trans_addr[31]
* pin haddr[31]
* pin hwdata[14]
* pin haddr[18]
* pin haddr[27]
* pin trans_addr[18]
* pin start_trans
* pin trans_addr[21]
* pin trans_addr[27]
* pin hbusreq
* pin haddr[21]
* pin haddr[20]
* pin trans_resp[0]
* pin hready
* pin hresp[0]
* pin hresp[1]
* pin trans_resp[1]
* pin trans_done
* pin write_data[14]
* pin haddr[22]
* pin hwdata[13]
* pin write_data[10]
* pin hwdata[10]
* pin write_data[13]
* pin hgrant
* pin trans_addr[20]
* pin trans_addr[22]
* pin htrans[1]
* pin htrans[0]
* pin write_data[0]
* pin hwdata[0]
* pin write_data[12]
* pin hwdata[12]
* pin read_data[13]
* pin hrdata[11]
* pin trans_write
* pin hwrite
* pin hwdata[16]
* pin read_data[6]
* pin hwdata[15]
* pin write_data[15]
* pin write_data[16]
* pin hrdata[31]
* pin hrdata[18]
* pin write_data[11]
* pin hwdata[11]
* pin hrdata[5]
* pin read_data[29]
* pin write_data[18]
* pin hwdata[18]
* pin write_data[17]
* pin hrdata[2]
* pin hrdata[6]
* pin read_data[5]
* pin hwdata[17]
* pin hrdata[16]
* pin read_data[4]
* pin write_data[7]
* pin write_data[28]
* pin hrdata[29]
* pin hwdata[28]
* pin read_data[27]
* pin read_data[31]
* pin hrdata[10]
* pin hrdata[15]
* pin hrdata[12]
* pin read_data[18]
* pin read_data[16]
* pin read_data[28]
* pin hrdata[25]
* pin hrdata[3]
* pin read_data[3]
* pin read_data[10]
* pin hrdata[13]
* pin read_data[15]
* pin read_data[2]
* pin read_data[12]
* pin read_data[11]
* pin hrdata[4]
* pin hwdata[2]
* pin write_data[6]
* pin hwdata[29]
* pin write_data[4]
* pin write_data[24]
* pin read_data[19]
* pin hrdata[24]
* pin write_data[3]
* pin hwdata[6]
* pin write_data[19]
* pin hrdata[0]
* pin trans_addr[28]
* pin write_data[30]
* pin write_data[27]
* pin write_data[1]
* pin hrdata[21]
* pin trans_addr[23]
* pin read_data[14]
* pin write_data[8]
* pin write_data[2]
* pin hwdata[9]
* pin write_data[9]
* pin write_data[31]
* pin hrdata[30]
* pin hwdata[23]
* pin hrdata[22]
* pin haddr[26]
* pin read_data[30]
* pin hrdata[17]
* pin hrdata[20]
* pin hwdata[22]
* pin hclk
* pin hwdata[19]
* pin hrdata[28]
* pin hrdata[7]
* pin write_data[26]
* pin hrdata[19]
* pin trans_addr[24]
* pin read_data[7]
* pin write_data[20]
* pin write_data[21]
* pin write_data[23]
* pin hrdata[27]
* pin hrdata[9]
* pin hwdata[21]
* pin read_data[8]
* pin read_data[26]
* pin trans_addr[25]
* pin read_data[1]
* pin read_data[24]
* pin read_data[20]
* pin hrdata[14]
* pin write_data[5]
* pin hwdata[3]
* pin hwdata[4]
* pin write_data[29]
* pin hwdata[7]
* pin hwdata[31]
* pin hrdata[1]
* pin write_data[22]
* pin read_data[22]
* pin hwdata[8]
* pin write_data[25]
* pin hwdata[25]
* pin hwdata[24]
* pin hwdata[20]
* pin haddr[24]
* pin hrdata[26]
* pin haddr[28]
* pin hwdata[26]
* pin read_data[9]
* pin read_data[23]
* pin hwdata[27]
* pin hrdata[8]
* pin trans_addr[26]
* pin hwdata[1]
* pin hrdata[23]
* pin hwdata[5]
* pin hwdata[30]
* pin read_data[21]
* pin haddr[25]
* pin read_data[25]
* pin haddr[23]
* pin read_data[17]
* pin read_data[0]
* pin NWELL
* pin PWELL,gf180mcu_gnd
.SUBCKT ahb_lite_master 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 74 200 214 228 239 242 254 256 265 287 324
+ 340 358 371 382 383 397 407 408 420 422 437 446 458 459 463 474 483 484 489
+ 497 505 513 523 524 533 534 535 536 552 553 554 560 570 571 572 573 580 589
+ 590 598 599 607 608 626 627 639 641 644 645 646 656 663 664 665 670 672 675
+ 676 684 687 690 691 692 698 700 701 705 711 715 719 721 725 731 742 747 749
+ 751 752 753 754 759 771 773 775 778 779 781 782 783 784 787 789 796 802 810
+ 815 818 819 825 828 829 831 834 836 843 845 846 848 850 856 857 858 859 861
+ 862 865 866 867 875 881 882 883 886 893 903 904 911 914 916 923 925 927 928
+ 929 931 932 934 935 936 937 938 939 940 942 943 944 945 946 947 948 949 950
+ 951 952 953 954 955 956 957 958 959 960 961 962 963 964 965 966 967 968 969
+ 970 971 972 973 974 975 976
* net 1 trans_burst[2]
* net 2 trans_burst[1]
* net 3 trans_burst[0]
* net 4 trans_size[2]
* net 5 trans_size[0]
* net 6 trans_size[1]
* net 7 hsize[0]
* net 8 hsize[1]
* net 9 hsize[2]
* net 10 hburst[1]
* net 11 hburst[2]
* net 12 hburst[0]
* net 13 haddr[0]
* net 14 haddr[2]
* net 15 trans_addr[0]
* net 16 trans_addr[3]
* net 17 trans_addr[2]
* net 18 haddr[3]
* net 19 haddr[1]
* net 20 trans_addr[1]
* net 21 haddr[5]
* net 22 haddr[7]
* net 23 trans_addr[4]
* net 24 trans_addr[7]
* net 25 trans_addr[5]
* net 26 haddr[4]
* net 27 trans_addr[6]
* net 28 trans_addr[11]
* net 29 haddr[6]
* net 30 haddr[11]
* net 31 haddr[8]
* net 32 trans_addr[8]
* net 74 hreset
* net 200 haddr[10]
* net 214 trans_addr[9]
* net 228 haddr[9]
* net 239 haddr[12]
* net 242 haddr[14]
* net 254 trans_addr[14]
* net 256 trans_addr[12]
* net 265 trans_addr[10]
* net 287 haddr[15]
* net 324 haddr[13]
* net 340 trans_addr[15]
* net 358 haddr[30]
* net 371 trans_addr[16]
* net 382 haddr[16]
* net 383 trans_addr[30]
* net 397 trans_addr[19]
* net 407 haddr[29]
* net 408 trans_addr[13]
* net 420 haddr[19]
* net 422 trans_addr[29]
* net 437 haddr[17]
* net 446 trans_addr[17]
* net 458 trans_addr[31]
* net 459 haddr[31]
* net 463 hwdata[14]
* net 474 haddr[18]
* net 483 haddr[27]
* net 484 trans_addr[18]
* net 489 start_trans
* net 497 trans_addr[21]
* net 505 trans_addr[27]
* net 513 hbusreq
* net 523 haddr[21]
* net 524 haddr[20]
* net 533 trans_resp[0]
* net 534 hready
* net 535 hresp[0]
* net 536 hresp[1]
* net 552 trans_resp[1]
* net 553 trans_done
* net 554 write_data[14]
* net 560 haddr[22]
* net 570 hwdata[13]
* net 571 write_data[10]
* net 572 hwdata[10]
* net 573 write_data[13]
* net 580 hgrant
* net 589 trans_addr[20]
* net 590 trans_addr[22]
* net 598 htrans[1]
* net 599 htrans[0]
* net 607 write_data[0]
* net 608 hwdata[0]
* net 626 write_data[12]
* net 627 hwdata[12]
* net 639 read_data[13]
* net 641 hrdata[11]
* net 644 trans_write
* net 645 hwrite
* net 646 hwdata[16]
* net 656 read_data[6]
* net 663 hwdata[15]
* net 664 write_data[15]
* net 665 write_data[16]
* net 670 hrdata[31]
* net 672 hrdata[18]
* net 675 write_data[11]
* net 676 hwdata[11]
* net 684 hrdata[5]
* net 687 read_data[29]
* net 690 write_data[18]
* net 691 hwdata[18]
* net 692 write_data[17]
* net 698 hrdata[2]
* net 700 hrdata[6]
* net 701 read_data[5]
* net 705 hwdata[17]
* net 711 hrdata[16]
* net 715 read_data[4]
* net 719 write_data[7]
* net 721 write_data[28]
* net 725 hrdata[29]
* net 731 hwdata[28]
* net 742 read_data[27]
* net 747 read_data[31]
* net 749 hrdata[10]
* net 751 hrdata[15]
* net 752 hrdata[12]
* net 753 read_data[18]
* net 754 read_data[16]
* net 759 read_data[28]
* net 771 hrdata[25]
* net 773 hrdata[3]
* net 775 read_data[3]
* net 778 read_data[10]
* net 779 hrdata[13]
* net 781 read_data[15]
* net 782 read_data[2]
* net 783 read_data[12]
* net 784 read_data[11]
* net 787 hrdata[4]
* net 789 hwdata[2]
* net 796 write_data[6]
* net 802 hwdata[29]
* net 810 write_data[4]
* net 815 write_data[24]
* net 818 read_data[19]
* net 819 hrdata[24]
* net 825 write_data[3]
* net 828 hwdata[6]
* net 829 write_data[19]
* net 831 hrdata[0]
* net 834 trans_addr[28]
* net 836 write_data[30]
* net 843 write_data[27]
* net 845 write_data[1]
* net 846 hrdata[21]
* net 848 trans_addr[23]
* net 850 read_data[14]
* net 856 write_data[8]
* net 857 write_data[2]
* net 858 hwdata[9]
* net 859 write_data[9]
* net 861 write_data[31]
* net 862 hrdata[30]
* net 865 hwdata[23]
* net 866 hrdata[22]
* net 867 haddr[26]
* net 875 read_data[30]
* net 881 hrdata[17]
* net 882 hrdata[20]
* net 883 hwdata[22]
* net 886 hclk
* net 893 hwdata[19]
* net 903 hrdata[28]
* net 904 hrdata[7]
* net 911 write_data[26]
* net 914 hrdata[19]
* net 916 trans_addr[24]
* net 923 read_data[7]
* net 925 write_data[20]
* net 927 write_data[21]
* net 928 write_data[23]
* net 929 hrdata[27]
* net 931 hrdata[9]
* net 932 hwdata[21]
* net 934 read_data[8]
* net 935 read_data[26]
* net 936 trans_addr[25]
* net 937 read_data[1]
* net 938 read_data[24]
* net 939 read_data[20]
* net 940 hrdata[14]
* net 942 write_data[5]
* net 943 hwdata[3]
* net 944 hwdata[4]
* net 945 write_data[29]
* net 946 hwdata[7]
* net 947 hwdata[31]
* net 948 hrdata[1]
* net 949 write_data[22]
* net 950 read_data[22]
* net 951 hwdata[8]
* net 952 write_data[25]
* net 953 hwdata[25]
* net 954 hwdata[24]
* net 955 hwdata[20]
* net 956 haddr[24]
* net 957 hrdata[26]
* net 958 haddr[28]
* net 959 hwdata[26]
* net 960 read_data[9]
* net 961 read_data[23]
* net 962 hwdata[27]
* net 963 hrdata[8]
* net 964 trans_addr[26]
* net 965 hwdata[1]
* net 966 hrdata[23]
* net 967 hwdata[5]
* net 968 hwdata[30]
* net 969 read_data[21]
* net 970 haddr[25]
* net 971 read_data[25]
* net 972 haddr[23]
* net 973 read_data[17]
* net 974 read_data[0]
* net 975 NWELL
* net 976 PWELL,gf180mcu_gnd
* cell instance $4 m0 *1 59.36,15.12
X$4 1 975 976 50 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $7 r0 *1 70,5.04
X$7 2 975 976 34 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $12 r0 *1 58.8,5.04
X$12 3 975 976 33 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15 r0 *1 92.4,15.12
X$15 4 975 976 90 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $20 m0 *1 86.24,35.28
X$20 5 975 976 67 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $24 m0 *1 94.64,35.28
X$24 6 975 976 69 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $28 r0 *1 92.4,5.04
X$28 37 975 976 7 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $31 r0 *1 103.04,25.2
X$31 53 975 976 8 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $35 r0 *1 84,5.04
X$35 36 975 976 9 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $40 m0 *1 67.76,15.12
X$40 51 975 976 10 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $44 r0 *1 75.6,5.04
X$44 35 975 976 11 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $48 m0 *1 76.16,15.12
X$48 65 975 976 12 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $51 m0 *1 106.96,25.2
X$51 78 975 976 13 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $56 r0 *1 104.72,5.04
X$56 38 975 976 14 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $60 r0 *1 113.12,5.04
X$60 15 975 976 47 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64 m0 *1 127.68,25.2
X$64 16 975 976 81 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68 m0 *1 118.72,15.12
X$68 17 975 976 130 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $72 r0 *1 129.92,5.04
X$72 40 975 976 18 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $75 r0 *1 121.52,5.04
X$75 39 975 976 19 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $80 r0 *1 138.32,5.04
X$80 20 975 976 41 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $84 r0 *1 173.6,5.04
X$84 44 975 976 21 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $87 m0 *1 173.04,15.12
X$87 57 975 976 22 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $92 r0 *1 147.84,5.04
X$92 23 975 976 48 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $96 r0 *1 182.56,5.04
X$96 24 975 976 115 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99 r0 *1 169.12,15.12
X$99 25 975 976 86 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $103 r0 *1 164.64,5.04
X$103 45 975 976 26 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $108 r0 *1 224.56,5.04
X$108 27 975 976 46 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $112 r0 *1 216.16,5.04
X$112 28 975 976 100 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $115 m0 *1 221.2,15.12
X$115 60 975 976 29 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $119 r0 *1 221.2,15.12
X$119 85 975 976 30 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $123 m0 *1 229.6,15.12
X$123 73 975 976 31 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $128 r0 *1 238,5.04
X$128 32 975 976 147 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $130 r0 *1 59.36,35.28
X$130 976 975 33 137 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $134 m0 *1 61.04,25.2
X$134 976 975 91 33 52 65 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $137 r0 *1 51.52,35.28
X$137 50 33 34 119 975 976 118 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $140 m0 *1 49.28,45.36
X$140 976 975 34 138 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $143 m0 *1 68.88,45.36
X$143 975 50 34 976 149 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $150 r0 *1 45.36,15.12
X$150 976 975 77 34 52 51 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $154 m0 *1 59.92,35.28
X$154 976 975 114 50 52 35 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $161 r0 *1 54.32,15.12
X$161 976 63 35 71 114 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $163 m0 *1 68.32,35.28
X$163 35 976 51 65 975 127 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $165 m0 *1 75.04,35.28
X$165 976 975 87 35 51 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $167 m0 *1 128.8,35.28
X$167 109 975 37 36 976 111 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $169 r0 *1 128.8,25.2
X$169 53 975 37 36 976 105 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $171 m0 *1 73.92,25.2
X$171 976 975 64 90 52 36 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $174 r0 *1 117.6,35.28
X$174 129 975 976 37 109 36 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $176 m0 *1 112.56,35.28
X$176 976 975 36 108 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $179 m0 *1 115.92,35.28
X$179 975 36 93 976 117 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $190 r0 *1 73.36,15.12
X$190 976 63 36 71 64 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $193 m0 *1 84.56,15.12
X$193 976 975 66 67 52 37 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $196 r0 *1 121.52,25.2
X$196 976 975 37 94 108 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $199 m0 *1 120.96,35.28
X$199 125 975 976 37 109 108 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $206 m0 *1 106.96,35.28
X$206 976 975 93 53 37 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $214 r0 *1 81.76,25.2
X$214 976 63 37 71 66 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $217 r0 *1 106.96,45.36
X$217 976 975 164 167 49 38 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $219 m0 *1 118.72,55.44
X$219 976 178 177 38 129 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $226 m0 *1 98,55.44
X$226 976 63 38 71 164 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $229 r0 *1 125.44,75.6
X$229 976 975 39 262 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $231 m0 *1 114.8,65.52
X$231 976 224 208 39 222 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $238 r0 *1 117.6,85.68
X$238 976 63 39 71 296 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $241 m0 *1 128.24,15.12
X$241 976 975 55 72 49 40 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $246 m0 *1 136.08,45.36
X$246 976 156 141 40 131 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $248 r0 *1 126,15.12
X$248 976 63 40 71 55 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $256 r0 *1 141.68,75.6
X$256 976 247 975 253 104 62 273 41 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $258 m0 *1 151.76,15.12
X$258 976 63 44 71 42 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $260 r0 *1 156.24,5.04
X$260 976 975 42 43 49 44 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $262 m0 *1 158.48,25.2
X$262 976 975 106 43 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $265 m0 *1 156.24,35.28
X$265 976 128 120 44 111 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $273 m0 *1 150.08,25.2
X$273 976 975 89 96 49 45 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $275 r0 *1 154.56,35.28
X$275 976 133 134 45 117 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $280 r0 *1 148.4,15.12
X$280 976 63 45 71 89 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $285 m0 *1 215.6,15.12
X$285 976 975 46 61 56 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $288 m0 *1 109.76,15.12
X$288 976 76 975 79 54 62 47 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $295 m0 *1 146.72,15.12
X$295 976 975 48 95 56 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $300 m0 *1 189.84,95.76
X$300 975 49 318 976 319 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $302 m0 *1 208.88,115.92
X$302 975 49 365 976 400 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $304 r0 *1 210.56,75.6
X$304 975 49 258 976 264 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $322 m0 *1 207.2,15.12
X$322 976 975 58 59 49 60 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $324 m0 *1 101.36,15.12
X$324 976 975 75 70 49 78 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $326 m0 *1 99.12,115.92
X$326 975 976 391 49 390 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $330 m0 *1 53.2,45.36
X$330 976 50 975 160 138 137 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $338 m0 *1 61.6,55.44
X$338 975 50 138 976 139 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $346 m0 *1 42,25.2
X$346 976 63 51 71 77 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $353 m0 *1 86.24,126
X$353 976 52 975 391 426 220 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $355 m0 *1 86.8,166.32
X$355 976 566 52 975 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $365 m0 *1 53.2,196.56
X$365 976 975 666 667 52 668 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $371 m0 *1 92.96,15.12
X$371 976 975 68 69 52 53 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $378 r0 *1 114.24,35.28
X$378 976 975 53 109 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $390 m0 *1 87.92,25.2
X$390 976 63 53 71 68 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $394 m0 *1 121.52,45.36
X$394 976 53 94 975 223 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $396 r0 *1 111.44,25.2
X$396 976 975 54 70 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $401 m0 *1 215.04,95.76
X$401 976 56 304 975 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $403 r0 *1 77.84,115.92
X$403 976 329 56 301 352 416 975 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $405 r0 *1 154,85.68
X$405 976 975 80 56 302 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $408 m0 *1 136.08,126
X$408 976 56 62 975 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $411 m0 *1 136.64,15.12
X$411 976 975 81 82 56 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $414 r0 *1 214.48,45.36
X$414 976 975 56 144 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $428 m0 *1 76.72,136.08
X$428 975 976 430 56 440 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $432 m0 *1 147.84,85.68
X$432 976 80 56 975 88 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $434 m0 *1 188.16,15.12
X$434 976 975 57 102 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $440 r0 *1 180.32,15.12
X$440 976 63 57 71 103 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $442 r0 *1 168.56,25.2
X$442 976 112 113 57 105 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $444 r0 *1 202.16,15.12
X$444 976 63 60 71 58 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $447 m0 *1 208.32,25.2
X$447 975 61 976 99 59 88 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $457 m0 *1 188.72,35.28
X$457 976 136 122 60 125 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $463 m0 *1 170.8,166.32
X$463 976 568 975 456 549 62 606 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $465 r0 *1 54.32,156.24
X$465 976 975 476 539 62 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $469 r0 *1 115.36,45.36
X$469 976 165 975 79 168 62 130 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $471 r0 *1 182,115.92
X$471 976 429 975 428 393 62 372 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $475 m0 *1 162.96,25.2
X$475 976 116 975 79 106 62 86 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $477 m0 *1 147.84,196.56
X$477 975 737 62 976 658 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $496 m0 *1 160.72,186.48
X$496 976 597 975 364 584 62 613 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $499 r0 *1 180.32,25.2
X$499 976 101 975 79 104 62 97 115 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $503 m0 *1 32.48,146.16
X$503 976 63 467 71 466 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $506 m0 *1 70,176.4
X$506 976 63 492 71 583 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $508 m0 *1 246.96,236.88
X$508 976 63 777 71 803 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $510 r0 *1 240.8,15.12
X$510 976 74 63 975 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $623 m0 *1 224,267.12
X$623 976 63 745 71 876 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $625 r0 *1 215.04,216.72
X$625 976 63 724 71 732 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $628 r0 *1 239.68,246.96
X$628 976 63 688 71 877 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $631 r0 *1 244.72,257.04
X$631 976 63 683 71 682 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $633 r0 *1 223.44,257.04
X$633 976 63 905 71 908 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $635 m0 *1 244.72,257.04
X$635 976 63 655 71 653 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $637 m0 *1 230.16,246.96
X$637 976 63 712 71 824 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $639 r0 *1 247.52,236.88
X$639 976 63 640 71 860 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $641 r0 *1 201.04,226.8
X$641 976 63 776 71 809 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $643 m0 *1 234.08,45.36
X$643 976 63 73 71 146 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $645 m0 *1 219.52,236.88
X$645 976 63 758 71 746 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $647 r0 *1 217.28,35.28
X$647 976 63 85 71 124 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $649 m0 *1 244.72,267.12
X$649 976 63 697 71 696 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $651 r0 *1 196,216.72
X$651 976 63 733 71 743 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $655 m0 *1 201.6,257.04
X$655 976 63 852 71 880 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $658 r0 *1 224,136.08
X$658 976 63 418 71 435 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $660 r0 *1 49.84,176.4
X$660 976 63 601 71 565 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $662 m0 *1 4.48,206.64
X$662 976 63 677 71 800 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $664 m0 *1 254.8,115.92
X$664 976 63 306 71 370 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $666 r0 *1 21.84,196.56
X$666 976 63 678 71 689 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $668 r0 *1 52.08,196.56
X$668 976 63 668 71 666 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $670 m0 *1 51.52,186.48
X$670 976 63 611 71 621 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $672 m0 *1 22.4,196.56
X$672 976 63 648 71 628 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $674 m0 *1 3.92,146.16
X$674 976 63 477 71 506 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $677 r0 *1 11.76,146.16
X$677 976 63 490 71 507 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $679 r0 *1 7.28,176.4
X$679 976 63 600 71 617 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $681 m0 *1 4.48,186.48
X$681 976 63 609 71 657 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $683 r0 *1 246.4,126
X$683 976 63 404 71 438 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $685 r0 *1 7.28,166.32
X$685 976 63 462 71 555 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $687 m0 *1 19.04,176.4
X$687 976 63 582 71 581 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $690 r0 *1 19.04,226.8
X$690 976 63 761 71 786 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $692 m0 *1 246.4,95.76
X$692 976 63 286 71 323 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $694 m0 *1 3.92,216.72
X$694 976 63 716 71 785 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $696 r0 *1 254.8,75.6
X$696 976 63 240 71 255 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $698 m0 *1 3.92,267.12
X$698 976 63 722 71 757 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $700 r0 *1 51.52,246.96
X$700 976 63 868 71 922 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $702 m0 *1 5.6,246.96
X$702 976 63 734 71 853 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $704 r0 *1 8.96,246.96
X$704 976 63 835 71 854 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $706 m0 *1 12.32,257.04
X$706 976 63 887 71 919 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $709 m0 *1 216.16,85.68
X$709 976 63 252 71 293 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $711 r0 *1 28.56,216.72
X$711 976 63 720 71 728 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $713 r0 *1 20.72,206.64
X$713 976 63 695 71 693 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $715 m0 *1 215.6,105.84
X$715 976 63 366 71 355 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $717 r0 *1 38.08,226.8
X$717 976 63 765 71 762 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $719 m0 *1 35.84,226.8
X$719 976 63 735 71 756 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $725 m0 *1 92.4,105.84
X$725 976 63 300 71 377 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $727 r0 *1 101.92,95.76
X$727 976 63 279 71 349 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $729 r0 *1 38.64,55.44
X$729 976 63 189 71 202 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $732 m0 *1 34.72,55.44
X$732 976 63 152 71 174 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $734 r0 *1 29.68,75.6
X$734 976 63 259 71 268 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $736 r0 *1 7.28,105.84
X$736 976 63 332 71 398 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $739 r0 *1 15.68,136.08
X$739 976 63 464 71 475 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $741 m0 *1 51.52,115.92
X$741 976 63 333 71 384 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $744 r0 *1 34.72,115.92
X$744 976 63 351 71 388 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $746 m0 *1 18.48,85.68
X$746 976 63 274 71 267 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $749 m0 *1 3.36,95.76
X$749 976 63 299 71 325 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $753 r0 *1 34.16,166.32
X$753 976 63 557 71 564 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $756 r0 *1 103.6,15.12
X$756 976 63 78 71 75 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $760 r0 *1 61.04,25.2
X$760 976 63 65 71 91 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $762 m0 *1 87.92,146.16
X$762 976 63 440 71 468 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $764 r0 *1 58.8,45.36
X$764 976 63 140 71 162 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $766 m0 *1 75.6,55.44
X$766 976 63 176 71 155 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $771 r0 *1 150.64,196.56
X$771 976 63 680 71 612 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $776 r0 *1 176.4,206.64
X$776 976 63 669 71 650 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $778 r0 *1 193.76,196.56
X$778 976 63 649 71 651 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $780 r0 *1 192.08,166.32
X$780 976 63 498 71 569 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $783 m0 *1 148.96,156.24
X$783 976 63 495 71 532 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $785 r0 *1 151.76,176.4
X$785 976 63 551 71 595 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $787 m0 *1 178.08,257.04
X$787 976 63 833 71 821 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $790 m0 *1 248.08,65.52
X$790 976 63 227 71 199 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $793 r0 *1 191.52,257.04
X$793 976 63 744 71 799 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $795 r0 *1 256.48,206.64
X$795 976 63 702 71 713 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $798 m0 *1 248.64,226.8
X$798 976 63 726 71 750 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $801 m0 *1 256.48,216.72
X$801 976 63 714 71 727 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $803 r0 *1 171.36,257.04
X$803 976 63 918 71 933 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $805 r0 *1 165.2,246.96
X$805 976 63 820 71 807 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $808 r0 *1 145.6,216.72
X$808 976 63 723 71 738 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $810 m0 *1 141.68,226.8
X$810 976 63 739 71 736 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $812 r0 *1 174.16,236.88
X$812 976 63 823 71 832 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $816 m0 *1 159.04,257.04
X$816 976 63 740 71 847 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $818 m0 *1 140,257.04
X$818 976 63 900 71 899 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $820 r0 *1 141.68,257.04
X$820 976 63 902 71 874 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $822 r0 *1 141.12,246.96
X$822 976 63 901 71 884 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $825 r0 *1 155.12,226.8
X$825 976 63 741 71 791 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $827 m0 *1 55.44,257.04
X$827 976 63 838 71 889 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $830 m0 *1 78.96,246.96
X$830 976 63 816 71 840 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $832 m0 *1 75.04,257.04
X$832 976 63 891 71 909 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $835 r0 *1 59.36,257.04
X$835 976 63 842 71 907 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $837 r0 *1 81.76,246.96
X$837 976 63 870 71 839 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $839 r0 *1 122.08,246.96
X$839 976 63 898 71 912 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $842 r0 *1 111.44,257.04
X$842 976 63 885 71 910 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $844 m0 *1 120.96,257.04
X$844 976 63 913 71 895 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $846 r0 *1 101.92,246.96
X$846 976 63 872 71 871 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $849 r0 *1 110.32,216.72
X$849 976 63 708 71 707 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $851 m0 *1 119.84,226.8
X$851 976 63 760 71 793 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $854 r0 *1 174.72,136.08
X$854 976 63 369 71 441 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $856 m0 *1 35.84,257.04
X$856 976 63 813 71 811 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $859 r0 *1 28,246.96
X$859 976 63 763 71 795 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $861 r0 *1 77.28,226.8
X$861 976 63 768 71 767 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $864 r0 *1 101.92,226.8
X$864 976 63 792 71 805 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $867 r0 *1 190.96,115.92
X$867 976 63 357 71 395 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $869 m0 *1 218.96,196.56
X$869 976 63 567 71 615 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $871 m0 *1 252,186.48
X$871 976 63 545 71 618 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $873 r0 *1 189.84,75.6
X$873 976 63 186 71 263 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $876 m0 *1 252.56,206.64
X$876 976 63 686 71 685 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $878 m0 *1 243.04,176.4
X$878 976 63 546 71 578 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $881 m0 *1 254.8,156.24
X$881 976 63 457 71 482 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $883 r0 *1 216.16,156.24
X$883 976 63 472 71 504 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $885 r0 *1 39.2,257.04
X$885 976 63 888 71 920 975 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $894 m0 *1 82.32,25.2
X$894 976 975 80 65 87 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $967 r0 *1 3.36,257.04
X$967 976 886 71 975 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $1209 m0 *1 138.88,25.2
X$1209 975 82 976 83 72 88 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1214 r0 *1 253.12,65.52
X$1214 975 73 227 976 241 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1217 m0 *1 241.36,65.52
X$1217 976 975 73 229 183 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1219 r0 *1 238.56,65.52
X$1219 73 213 238 196 976 975 230 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1227 r0 *1 227.36,45.36
X$1227 976 975 158 73 88 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1229 r0 *1 227.92,55.44
X$1229 975 73 976 206 185 198 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1241 m0 *1 115.92,25.2
X$1241 976 92 76 78 107 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $1252 m0 *1 194.88,95.76
X$1252 975 295 79 976 320 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1255 m0 *1 170.8,105.84
X$1255 976 79 363 975 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1262 m0 *1 210.56,55.44
X$1262 187 79 183 184 976 975 173 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1277 m0 *1 207.2,75.6
X$1277 975 236 258 172 237 79 976 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1279 m0 *1 162.96,105.84
X$1279 976 975 302 79 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1282 r0 *1 206.08,105.84
X$1282 975 79 976 380 365 336 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1284 m0 *1 182,95.76
X$1284 975 79 976 336 318 283 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1300 m0 *1 141.12,55.44
X$1300 975 141 215 976 83 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1307 r0 *1 246.4,166.32
X$1307 975 976 559 562 577 84 578 561 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $1309 m0 *1 188.16,166.32
X$1309 975 976 541 503 550 84 569 542 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $1311 m0 *1 131.6,85.68
X$1311 976 273 975 296 84 262 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1314 m0 *1 249.2,126
X$1314 975 976 419 423 424 84 438 421 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $1317 m0 *1 254.24,85.68
X$1317 975 976 290 270 269 84 255 308 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $1319 r0 *1 154.56,95.76
X$1319 976 104 84 975 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1322 m0 *1 185.36,25.2
X$1322 976 97 975 103 84 102 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1336 m0 *1 233.52,55.44
X$1336 975 185 976 159 146 84 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1338 m0 *1 220.08,45.36
X$1338 975 145 976 148 124 84 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1341 r0 *1 253.12,105.84
X$1341 975 368 976 376 406 370 84 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1346 m0 *1 217.84,156.24
X$1346 975 478 976 520 508 504 84 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $1348 r0 *1 233.52,75.6
X$1348 186 975 85 252 976 257 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1350 m0 *1 206.08,65.52
X$1350 976 236 212 85 186 975 197 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $1352 r0 *1 209.44,45.36
X$1352 976 975 85 187 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1354 r0 *1 207.2,65.52
X$1354 976 237 212 85 186 975 211 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $1366 r0 *1 216.16,55.44
X$1366 975 85 976 182 145 198 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1380 r0 *1 170.8,105.84
X$1380 234 975 379 364 976 88 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $1383 m0 *1 217.84,55.44
X$1383 976 88 975 182 184 183 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1385 r0 *1 204.4,55.44
X$1385 197 123 88 206 211 975 976 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1397 r0 *1 230.72,115.92
X$1397 412 975 976 404 381 88 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $1401 r0 *1 148.4,25.2
X$1401 975 95 976 110 96 88 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1411 r0 *1 127.68,65.52
X$1411 976 975 92 233 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1413 r0 *1 119.84,55.44
X$1413 976 169 208 92 224 178 975 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $1415 m0 *1 126.56,65.52
X$1415 976 224 975 210 208 92 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1429 r0 *1 116.48,25.2
X$1429 975 108 93 976 107 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1431 r0 *1 125.44,35.28
X$1431 976 975 131 109 94 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1443 r0 *1 192.08,25.2
X$1443 113 976 98 975 101 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1446 r0 *1 185.92,35.28
X$1446 121 975 135 126 976 98 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1450 r0 *1 201.04,35.28
X$1450 975 122 123 976 99 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1455 m0 *1 212.8,45.36
X$1455 976 173 975 148 144 100 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1470 r0 *1 235.76,146.16
X$1470 976 104 975 487 479 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1473 m0 *1 217.28,166.32
X$1473 976 104 975 520 544 253 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1475 r0 *1 241.92,105.84
X$1475 976 104 975 376 386 253 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1478 r0 *1 140.56,115.92
X$1478 976 392 104 975 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $1482 m0 *1 188.16,126
X$1482 976 104 975 394 427 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1487 r0 *1 170.8,176.4
X$1487 976 104 975 579 596 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1489 r0 *1 170.24,186.48
X$1489 976 104 975 623 624 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1491 r0 *1 245.84,65.52
X$1491 976 104 975 203 229 253 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1539 r0 *1 145.04,35.28
X$1539 134 976 132 975 110 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1546 m0 *1 184.24,45.36
X$1546 976 112 975 143 136 113 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1548 r0 *1 179.76,95.76
X$1548 976 379 157 112 354 241 975 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $1555 m0 *1 182.56,85.68
X$1555 975 241 976 157 283 112 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1558 m0 *1 191.52,45.36
X$1558 976 150 120 975 122 113 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1563 m0 *1 201.6,55.44
X$1563 975 122 113 976 197 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1565 r0 *1 194.88,55.44
X$1565 976 975 122 171 113 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1573 r0 *1 187.6,45.36
X$1573 975 113 121 976 157 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1586 m0 *1 161.84,45.36
X$1586 120 976 142 975 116 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1593 m0 *1 53.76,55.44
X$1593 975 118 976 153 202 166 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1595 r0 *1 22.4,75.6
X$1595 975 119 289 976 267 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1598 m0 *1 53.2,136.08
X$1598 976 975 454 119 430 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1600 m0 *1 22.4,95.76
X$1600 975 119 313 976 325 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1602 m0 *1 14.56,115.92
X$1602 975 119 374 976 398 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1604 r0 *1 43.68,85.68
X$1604 975 259 119 976 275 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1615 m0 *1 154.56,55.44
X$1615 976 128 975 179 133 120 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1626 r0 *1 179.2,35.28
X$1626 120 976 128 136 975 126 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1628 r0 *1 167.44,55.44
X$1628 976 181 134 975 120 194 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1630 m0 *1 168.56,65.52
X$1630 134 975 120 194 976 226 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1636 r0 *1 193.2,35.28
X$1636 976 122 136 975 121 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1652 m0 *1 161.84,55.44
X$1652 975 179 976 180 123 181 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1667 m0 *1 78.96,126
X$1667 413 425 430 127 976 975 426 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1670 r0 *1 77.84,126
X$1670 976 399 430 425 413 975 127 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $1672 r0 *1 68.32,126
X$1672 411 975 414 127 976 431 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1681 m0 *1 196,55.44
X$1681 976 975 128 175 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1690 r0 *1 192.64,45.36
X$1690 976 975 163 128 136 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1704 r0 *1 140,45.36
X$1704 976 156 975 132 193 141 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1706 r0 *1 154.56,45.36
X$1706 976 133 975 151 156 134 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1722 r0 *1 149.52,55.44
X$1722 976 170 178 177 134 141 975 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $1728 r0 *1 178.08,45.36
X$1728 975 169 135 170 163 151 976 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $1747 m0 *1 60.48,45.36
X$1747 976 975 162 139 153 140 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1750 m0 *1 61.6,65.52
X$1750 975 140 204 976 216 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1753 r0 *1 57.68,55.44
X$1753 152 975 189 217 976 140 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $1760 m0 *1 72.8,65.52
X$1760 140 976 176 190 975 260 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1768 m0 *1 161.28,65.52
X$1768 976 141 156 975 194 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1773 r0 *1 161.84,45.36
X$1773 975 151 976 169 142 170 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1775 r0 *1 185.92,55.44
X$1775 976 975 143 211 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1777 m0 *1 183.68,55.44
X$1777 975 976 150 151 143 175 195 171 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $1782 r0 *1 198.24,45.36
X$1782 975 143 976 171 161 172 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1784 m0 *1 227.92,156.24
X$1784 976 496 975 364 508 144 485 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1786 r0 *1 250.32,156.24
X$1786 976 522 975 410 561 144 526 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1788 m0 *1 248.08,146.16
X$1788 976 488 975 480 144 486 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1790 r0 *1 256.48,115.92
X$1790 976 368 975 410 406 144 409 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1793 m0 *1 251.44,136.08
X$1793 976 412 975 456 421 144 448 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1796 r0 *1 252,85.68
X$1796 976 310 975 284 308 144 266 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1798 r0 *1 248.64,95.76
X$1798 976 344 975 337 144 343 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1800 r0 *1 232.96,45.36
X$1800 976 158 975 161 159 144 147 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $1806 r0 *1 240.8,55.44
X$1806 976 230 975 205 144 201 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1830 r0 *1 78.4,45.36
X$1830 976 975 155 149 153 176 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1834 m0 *1 175.84,55.44
X$1834 188 975 976 170 150 169 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $1850 r0 *1 45.92,45.36
X$1850 976 975 174 160 153 152 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1853 r0 *1 54.32,45.36
X$1853 976 975 152 154 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1860 r0 *1 86.24,95.76
X$1860 976 153 975 349 348 317 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1862 m0 *1 47.6,85.68
X$1862 976 975 291 259 153 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1866 r0 *1 64.4,115.92
X$1866 976 330 220 415 153 975 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $1869 r0 *1 84,105.84
X$1869 976 153 975 377 385 362 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1871 m0 *1 53.76,146.16
X$1871 430 476 453 976 975 153 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $1888 m0 *1 50.96,65.52
X$1888 204 976 975 166 154 292 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1896 r0 *1 158.48,65.52
X$1896 976 975 156 248 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1898 m0 *1 150.64,65.52
X$1898 177 231 178 180 156 975 976 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1941 m0 *1 130.48,55.44
X$1941 975 192 177 976 165 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1945 r0 *1 54.88,65.52
X$1945 976 975 189 166 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1947 r0 *1 116.48,55.44
X$1947 976 975 168 167 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1975 r0 *1 168.56,65.52
X$1975 976 172 226 225 235 975 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $1982 m0 *1 216.72,75.6
X$1982 975 237 976 236 251 172 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1998 m0 *1 81.2,65.52
X$1998 976 975 176 218 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2005 m0 *1 136.08,65.52
X$2005 976 975 177 191 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2016 m0 *1 147.28,65.52
X$2016 976 975 178 209 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2027 r0 *1 162.4,65.52
X$2027 976 975 179 235 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2042 m0 *1 240.8,146.16
X$2042 481 238 183 473 976 975 488 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2044 m0 *1 234.64,146.16
X$2044 976 975 183 479 473 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2046 r0 *1 202.16,136.08
X$2046 976 469 354 183 212 975 433 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $2048 r0 *1 241.36,95.76
X$2048 322 238 183 339 976 975 344 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2050 r0 *1 236.32,95.76
X$2050 976 975 183 338 339 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2052 m0 *1 208.32,136.08
X$2052 976 443 354 183 212 975 455 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $2055 m0 *1 224,65.52
X$2055 976 975 196 183 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2075 r0 *1 234.64,105.84
X$2075 976 386 212 975 183 257 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2082 m0 *1 218.96,65.52
X$2082 975 186 212 976 184 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2086 m0 *1 202.72,85.68
X$2086 976 975 186 295 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2096 m0 *1 256.48,55.44
X$2096 186 975 976 200 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2104 r0 *1 189.28,55.44
X$2104 976 195 188 975 196 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2108 m0 *1 52.08,95.76
X$2108 326 976 975 351 189 334 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2114 r0 *1 61.04,95.76
X$2114 975 334 976 333 346 189 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2119 r0 *1 72.8,55.44
X$2119 976 975 204 190 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2123 r0 *1 140.56,65.52
X$2123 976 225 191 192 209 248 975 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $2126 r0 *1 140,55.44
X$2126 975 209 976 191 193 192 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2128 m0 *1 139.44,65.52
X$2128 975 209 976 210 215 191 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2130 r0 *1 137.2,65.52
X$2130 976 975 192 231 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2133 m0 *1 117.6,75.6
X$2133 976 262 247 223 233 192 975 gf180mcu_fd_sc_mcu9t5v0__addf_4
* cell instance $2150 r0 *1 193.76,136.08
X$2150 212 196 354 433 976 975 519 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2153 r0 *1 238.56,115.92
X$2153 302 212 196 257 976 975 410 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2155 r0 *1 239.12,126
X$2155 212 196 257 356 976 975 456 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2157 r0 *1 215.04,136.08
X$2157 212 196 354 455 976 975 445 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2174 r0 *1 250.32,146.16
X$2174 975 198 976 480 487 482 481 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2176 m0 *1 244.16,126
X$2176 976 975 404 424 198 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2178 m0 *1 249.76,75.6
X$2178 976 975 240 269 198 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2180 m0 *1 148.4,115.92
X$2180 976 392 198 975 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2184 m0 *1 184.8,115.92
X$2184 975 198 976 393 394 395 396 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2186 r0 *1 248.08,55.44
X$2186 975 198 976 205 203 199 213 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2189 r0 *1 153.44,156.24
X$2189 975 976 549 198 548 531 532 494 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $2204 r0 *1 155.68,186.48
X$2204 975 198 976 632 623 612 633 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2206 m0 *1 161.28,176.4
X$2206 975 198 976 584 579 595 575 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2213 r0 *1 258.72,55.44
X$2213 214 975 976 201 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2241 m0 *1 80.64,75.6
X$2241 976 243 207 282 249 975 245 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $2243 m0 *1 85.68,65.52
X$2243 976 219 975 281 207 221 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2246 r0 *1 73.92,75.6
X$2246 219 976 975 259 232 207 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2272 m0 *1 164.08,75.6
X$2272 976 234 225 226 235 211 975 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $2293 r0 *1 198.24,105.84
X$2293 976 975 241 212 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $2297 r0 *1 258.16,65.52
X$2297 976 975 227 213 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2309 m0 *1 64.96,85.68
X$2309 277 976 975 299 216 307 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2313 r0 *1 81.76,65.52
X$2313 976 975 218 244 217 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2316 r0 *1 76.72,65.52
X$2316 976 975 218 232 217 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2321 r0 *1 86.8,65.52
X$2321 976 220 246 218 217 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2337 m0 *1 75.6,126
X$2337 976 975 220 402 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2346 m0 *1 92.4,75.6
X$2346 221 976 975 274 246 245 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2350 r0 *1 122.64,65.52
X$2350 976 975 223 222 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2377 m0 *1 267.12,65.52
X$2377 227 975 976 228 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2399 m0 *1 185.36,105.84
X$2399 976 975 234 336 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2401 m0 *1 190.4,85.68
X$2401 976 975 284 283 234 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2410 r0 *1 174.16,115.92
X$2410 417 234 380 403 975 976 427 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2429 r0 *1 187.6,156.24
X$2429 518 975 238 517 976 530 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2431 m0 *1 241.92,186.48
X$2431 975 616 238 976 604 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2433 m0 *1 195.44,126
X$2433 975 396 238 976 429 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2436 r0 *1 210.56,85.68
X$2436 975 285 238 976 311 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2438 r0 *1 226.24,126
X$2438 975 436 238 976 449 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2440 r0 *1 184.8,126
X$2440 417 238 433 432 976 975 434 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2463 m0 *1 206.64,105.84
X$2463 976 975 302 238 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $2465 r0 *1 200.48,186.48
X$2465 975 614 238 976 643 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2468 m0 *1 241.36,75.6
X$2468 252 975 976 239 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2472 m0 *1 248.64,85.68
X$2472 976 975 240 270 253 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2474 r0 *1 244.72,85.68
X$2474 306 240 241 257 976 975 339 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2476 m0 *1 238,85.68
X$2476 976 975 240 305 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2479 r0 *1 258.72,95.76
X$2479 306 975 240 286 976 356 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2487 r0 *1 267.12,65.52
X$2487 240 975 976 242 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2492 m0 *1 201.6,115.92
X$2492 369 975 357 241 976 470 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2512 m0 *1 61.6,95.76
X$2512 976 352 346 347 327 243 309 975 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $2514 m0 *1 92.4,85.68
X$2514 250 976 975 300 244 282 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2535 r0 *1 86.24,75.6
X$2535 976 272 975 280 250 249 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2537 m0 *1 87.36,85.68
X$2537 976 975 249 261 282 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2543 m0 *1 75.6,85.68
X$2543 976 272 249 279 260 975 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $2548 r0 *1 217.84,85.68
X$2548 976 311 975 251 294 304 288 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2552 r0 *1 230.16,85.68
X$2552 976 975 252 285 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2560 m0 *1 188.16,156.24
X$2560 976 975 498 503 253 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2563 r0 *1 173.6,146.16
X$2563 976 302 253 975 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2568 m0 *1 236.88,126
X$2568 976 975 404 423 253 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2571 r0 *1 169.68,136.08
X$2571 976 975 369 460 253 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2573 r0 *1 161.84,146.16
X$2573 976 975 495 494 253 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2594 m0 *1 246.96,166.32
X$2594 976 975 546 562 253 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2598 m0 *1 254.8,75.6
X$2598 254 975 976 266 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2605 m0 *1 263.2,75.6
X$2605 256 975 976 288 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2607 m0 *1 241.92,85.68
X$2607 306 975 284 257 976 290 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2611 m0 *1 242.48,105.84
X$2611 975 257 356 976 354 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2621 r0 *1 237.44,85.68
X$2621 306 305 302 257 976 975 310 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2629 r0 *1 68.32,85.68
X$2629 976 316 299 259 300 975 315 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $2631 r0 *1 70.56,95.76
X$2631 976 975 259 353 345 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2646 r0 *1 84.56,85.68
X$2646 975 280 976 281 301 261 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2655 r0 *1 185.92,85.68
X$2655 975 303 976 312 319 263 295 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2657 m0 *1 206.08,85.68
X$2657 975 303 976 294 264 293 285 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2661 r0 *1 241.92,75.6
X$2661 265 975 976 271 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2673 m0 *1 39.2,85.68
X$2673 976 975 268 291 276 275 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2684 r0 *1 196,85.68
X$2684 976 320 975 284 312 304 271 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2697 r0 *1 50.4,95.76
X$2697 274 332 361 299 976 975 345 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2700 r0 *1 34.72,85.68
X$2700 976 975 274 297 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2708 m0 *1 43.12,95.76
X$2708 299 975 314 315 976 276 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2711 r0 *1 77.28,85.68
X$2711 976 975 277 347 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2717 r0 *1 51.52,85.68
X$2717 327 975 976 298 277 326 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $2719 m0 *1 55.44,85.68
X$2719 298 976 975 332 292 278 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $2721 r0 *1 60.48,85.68
X$2721 975 307 976 298 309 278 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2727 m0 *1 84,95.76
X$2727 975 279 976 316 317 335 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2729 r0 *1 79.52,95.76
X$2729 279 976 335 316 975 348 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2763 r0 *1 260.96,85.68
X$2763 976 975 286 322 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2768 m0 *1 267.12,85.68
X$2768 286 975 976 287 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2780 r0 *1 19.04,85.68
X$2780 975 297 342 976 289 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2816 m0 *1 36.4,95.76
X$2816 976 975 315 297 331 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2825 r0 *1 12.32,95.76
X$2825 976 975 299 328 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2841 m0 *1 84.56,105.84
X$2841 975 300 976 353 362 335 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2844 m0 *1 77.84,105.84
X$2844 300 976 335 353 975 385 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2854 m0 *1 84.56,115.92
X$2854 352 976 301 399 975 390 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2856 m0 *1 75.6,115.92
X$2856 975 402 976 301 411 352 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2865 m0 *1 168,156.24
X$2865 512 302 433 516 976 975 568 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2875 r0 *1 216.16,126
X$2875 975 303 976 444 439 435 436 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2877 r0 *1 213.92,105.84
X$2877 975 303 976 387 400 355 381 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2879 m0 *1 177.52,136.08
X$2879 975 976 442 460 450 303 441 461 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $2882 m0 *1 162.96,115.92
X$2882 976 392 303 975 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2885 m0 *1 180.32,196.56
X$2885 975 303 976 662 661 650 659 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2899 m0 *1 236.32,95.76
X$2899 975 303 976 337 321 323 322 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2901 m0 *1 190.4,196.56
X$2901 975 303 976 634 585 651 614 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2903 r0 *1 215.6,186.48
X$2903 975 303 976 642 635 615 586 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2909 r0 *1 240.24,186.48
X$2909 975 303 976 637 620 618 616 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $2912 r0 *1 193.76,156.24
X$2912 976 530 975 519 542 304 547 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2914 r0 *1 239.12,176.4
X$2914 976 604 975 593 637 304 591 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2917 m0 *1 222.88,186.48
X$2917 976 588 975 364 642 304 619 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2920 m0 *1 189.84,136.08
X$2920 976 434 975 456 461 304 447 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2923 r0 *1 224,105.84
X$2923 976 381 975 364 387 304 375 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2927 m0 *1 220.08,136.08
X$2927 976 449 975 445 444 304 405 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2930 r0 *1 184.8,196.56
X$2930 976 704 975 364 662 304 822 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2932 r0 *1 191.52,186.48
X$2932 976 643 975 519 634 304 849 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $2950 r0 *1 249.76,105.84
X$2950 976 975 306 368 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2964 r0 *1 267.12,85.68
X$2964 306 975 976 324 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2991 r0 *1 15.68,95.76
X$2991 975 328 341 976 313 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2993 m0 *1 41.44,115.92
X$2993 976 975 388 389 314 351 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2995 m0 *1 42,105.84
X$2995 976 975 329 314 330 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3019 m0 *1 235.2,105.84
X$3019 976 367 975 321 338 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3050 m0 *1 20.16,115.92
X$3050 359 976 360 328 975 350 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3053 m0 *1 65.52,105.84
X$3053 975 329 330 976 335 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3062 r0 *1 32.48,95.76
X$3062 976 331 975 341 330 329 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3064 m0 *1 25.2,105.84
X$3064 976 360 975 373 330 329 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3066 r0 *1 25.2,95.76
X$3066 976 350 975 342 330 329 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3082 r0 *1 41.44,95.76
X$3082 976 331 332 975 333 351 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $3088 r0 *1 26.32,105.84
X$3088 976 975 332 359 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3098 r0 *1 44.24,105.84
X$3098 361 976 975 333 351 401 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $3107 r0 *1 62.72,105.84
X$3107 976 975 384 335 333 378 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3124 m0 *1 178.08,126
X$3124 976 428 403 975 380 417 336 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $3126 m0 *1 192.64,186.48
X$3126 614 336 380 602 975 976 625 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $3137 m0 *1 175.84,186.48
X$3137 336 380 602 622 975 976 624 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $3139 r0 *1 179.2,176.4
X$3139 336 380 602 576 975 976 596 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $3143 r0 *1 222.88,176.4
X$3143 336 976 380 587 975 605 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3146 r0 *1 230.72,176.4
X$3146 593 975 976 380 336 603 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $3149 m0 *1 232.4,186.48
X$3149 336 976 380 603 975 636 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3151 r0 *1 218.96,146.16
X$3151 336 976 380 471 975 544 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3166 m0 *1 265.44,95.76
X$3166 340 975 976 343 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3221 m0 *1 202.72,146.16
X$3221 354 543 432 470 976 975 473 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3239 r0 *1 243.04,156.24
X$3239 545 527 356 521 976 975 522 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3249 m0 *1 197.12,115.92
X$3249 976 975 357 396 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3255 r0 *1 267.12,95.76
X$3255 357 975 976 358 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3264 m0 *1 15.12,105.84
X$3264 975 359 373 976 374 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3273 r0 *1 40.88,105.84
X$3273 976 975 361 360 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3284 r0 *1 232.4,186.48
X$3284 976 367 975 620 636 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3289 r0 *1 208.88,126
X$3289 976 367 975 439 443 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3291 r0 *1 184.24,186.48
X$3291 976 367 975 661 625 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3311 r0 *1 199.36,176.4
X$3311 976 367 975 585 469 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3314 m0 *1 215.6,186.48
X$3314 976 367 975 635 605 363 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3324 m0 *1 154.56,196.56
X$3324 976 658 975 632 660 364 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3339 m0 *1 229.6,146.16
X$3339 976 975 366 471 404 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3341 r0 *1 244.16,136.08
X$3341 366 404 472 418 976 975 521 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3343 m0 *1 246.4,136.08
X$3343 975 366 456 976 419 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3345 m0 *1 232.4,115.92
X$3345 976 975 366 381 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3353 m0 *1 247.52,105.84
X$3353 366 975 976 382 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3355 m0 *1 183.12,166.32
X$3355 976 975 498 550 367 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3358 r0 *1 238,166.32
X$3358 976 975 546 577 367 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3366 r0 *1 161.84,115.92
X$3366 976 975 392 367 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3368 m0 *1 172.48,136.08
X$3368 976 975 369 450 367 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3371 m0 *1 157.36,166.32
X$3371 976 975 495 548 367 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3398 m0 *1 174.72,126
X$3398 976 975 369 417 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3409 m0 *1 257.04,105.84
X$3409 369 975 976 407 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3416 m0 *1 266.56,105.84
X$3416 371 975 976 375 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3422 r0 *1 267.12,105.84
X$3422 383 975 976 372 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3447 m0 *1 69.44,126
X$3447 975 411 415 976 378 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3451 r0 *1 185.36,105.84
X$3451 976 975 379 380 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3515 r0 *1 53.76,115.92
X$3515 975 401 414 976 389 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3518 m0 *1 108.08,115.92
X$3518 975 390 391 976 392 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3554 m0 *1 246.4,115.92
X$3554 397 975 976 405 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3572 r0 *1 179.2,126
X$3572 976 975 433 403 432 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3589 m0 *1 267.12,126
X$3589 404 975 976 437 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3600 r0 *1 267.12,115.92
X$3600 408 975 976 409 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3620 r0 *1 66.64,136.08
X$3620 976 975 411 493 451 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $3626 m0 *1 59.36,126
X$3626 975 413 430 976 414 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3629 r0 *1 44.24,136.08
X$3629 425 413 454 452 467 975 976 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3631 r0 *1 31.92,146.16
X$3631 975 413 976 500 451 499 464 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $3634 r0 *1 83.44,136.08
X$3634 976 975 440 413 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3637 m0 *1 55.44,156.24
X$3637 976 558 509 413 431 492 975 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $3639 r0 *1 76.16,146.16
X$3639 976 975 413 502 416 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3654 r0 *1 35.84,156.24
X$3654 976 975 514 425 413 537 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3656 r0 *1 81.2,156.24
X$3656 975 492 413 976 511 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3658 r0 *1 47.6,156.24
X$3658 492 976 491 413 975 538 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3669 r0 *1 71.12,196.56
X$3669 975 668 415 976 674 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3672 m0 *1 70,146.16
X$3672 440 975 425 430 976 415 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3678 r0 *1 67.76,146.16
X$3678 492 491 453 416 975 976 493 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $3681 m0 *1 78.96,146.16
X$3681 976 975 425 416 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3690 r0 *1 235.76,126
X$3690 976 975 418 436 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3697 r0 *1 246.96,115.92
X$3697 418 975 976 420 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3706 r0 *1 260.4,136.08
X$3706 422 975 976 447 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3722 r0 *1 58.8,146.16
X$3722 976 975 491 509 425 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3732 r0 *1 26.32,156.24
X$3732 976 975 534 425 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $3757 r0 *1 81.2,146.16
X$3757 976 975 467 492 430 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $3759 r0 *1 66.64,156.24
X$3759 976 529 975 528 430 502 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3780 m0 *1 176.96,146.16
X$3780 456 975 433 432 976 442 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3782 r0 *1 174.16,156.24
X$3782 498 975 551 517 976 432 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3789 m0 *1 161.84,196.56
X$3789 495 633 433 516 976 975 660 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3791 m0 *1 171.36,176.4
X$3791 498 575 433 517 976 975 597 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3793 m0 *1 182,206.64
X$3793 649 975 659 433 976 704 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3811 m0 *1 203.28,166.32
X$3811 543 975 976 433 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $3813 r0 *1 167.44,156.24
X$3813 456 975 433 516 976 531 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3839 r0 *1 76.72,136.08
X$3839 976 975 440 453 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $3861 r0 *1 265.44,126
X$3861 446 975 976 448 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3884 m0 *1 8.96,156.24
X$3884 976 975 506 525 451 477 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3887 m0 *1 17.36,156.24
X$3887 976 975 507 501 451 490 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3890 r0 *1 36.4,136.08
X$3890 976 451 465 975 466 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3895 m0 *1 39.76,156.24
X$3895 514 467 452 465 492 975 976 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3901 m0 *1 77.28,166.32
X$3901 540 467 453 537 976 975 566 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3904 m0 *1 71.12,166.32
X$3904 540 975 453 537 976 529 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3911 r0 *1 53.76,136.08
X$3911 975 453 476 976 454 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3913 r0 *1 73.92,156.24
X$3913 976 515 467 975 453 537 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $3921 m0 *1 219.52,146.16
X$3921 976 975 455 478 471 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3928 m0 *1 240.8,166.32
X$3928 545 975 456 521 976 559 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3952 m0 *1 263.76,146.16
X$3952 976 975 457 481 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3955 m0 *1 267.12,136.08
X$3955 457 975 976 459 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3960 r0 *1 251.44,136.08
X$3960 458 975 976 486 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3972 m0 *1 10.64,166.32
X$3972 976 975 555 556 610 462 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3978 r0 *1 2.24,136.08
X$3978 462 975 976 463 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3984 m0 *1 19.04,166.32
X$3984 464 975 976 553 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3997 r0 *1 42,146.16
X$3997 492 976 467 975 500 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $4000 m0 *1 84,156.24
X$4000 975 467 976 511 510 468 492 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $4003 m0 *1 50.4,156.24
X$4003 976 975 467 491 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4025 r0 *1 230.16,146.16
X$4025 976 975 496 472 471 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4031 r0 *1 225.68,146.16
X$4031 976 975 472 478 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4039 m0 *1 267.12,146.16
X$4039 472 975 976 474 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4055 m0 *1 29.12,146.16
X$4055 976 975 499 475 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4063 r0 *1 5.6,146.16
X$4063 489 975 976 476 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $4071 r0 *1 4.48,156.24
X$4071 477 975 976 533 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4091 r0 *1 267.12,146.16
X$4091 498 975 976 483 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4094 m0 *1 255.36,146.16
X$4094 484 975 976 485 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4117 r0 *1 8.4,186.48
X$4117 490 975 976 552 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4134 m0 *1 67.76,166.32
X$4134 976 975 492 540 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4149 r0 *1 71.68,176.4
X$4149 976 975 493 583 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4157 m0 *1 72.24,206.64
X$4157 976 668 493 975 679 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4166 r0 *1 166.88,146.16
X$4166 976 975 495 512 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4169 m0 *1 169.68,186.48
X$4169 976 975 495 622 516 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4176 m0 *1 170.24,206.64
X$4176 649 669 495 680 976 975 517 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4179 r0 *1 172.48,267.12
X$4179 495 975 976 970 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4184 r0 *1 259.28,156.24
X$4184 497 975 976 526 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4187 r0 *1 184.24,156.24
X$4187 976 975 498 518 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4193 m0 *1 180.88,176.4
X$4193 976 975 498 576 517 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4213 r0 *1 14.56,156.24
X$4213 536 975 976 501 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4216 m0 *1 77.28,156.24
X$4216 975 502 515 976 510 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4229 m0 *1 252,166.32
X$4229 505 975 976 547 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4256 m0 *1 27.44,166.32
X$4256 557 975 976 513 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4268 r0 *1 169.68,196.56
X$4268 975 649 669 976 516 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4271 r0 *1 187.04,166.32
X$4271 975 519 517 976 541 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4298 r0 *1 234.64,166.32
X$4298 976 975 521 603 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4302 m0 *1 233.52,166.32
X$4302 545 546 567 521 976 975 543 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4312 m0 *1 231.84,176.4
X$4312 976 587 545 975 546 521 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4317 r0 *1 267.12,166.32
X$4317 546 975 976 523 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4320 m0 *1 265.44,166.32
X$4320 545 975 976 524 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4325 m0 *1 2.24,166.32
X$4325 535 975 976 525 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4334 r0 *1 239.68,156.24
X$4334 976 975 546 527 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4336 m0 *1 54.32,176.4
X$4336 976 594 975 558 621 528 631 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4338 r0 *1 54.88,166.32
X$4338 976 538 975 558 565 528 574 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $4379 m0 *1 2.24,176.4
X$4379 580 975 976 537 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $4381 m0 *1 48.72,176.4
X$4381 976 537 538 975 594 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4383 m0 *1 52.64,166.32
X$4383 976 975 538 563 539 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4409 m0 *1 248.64,186.48
X$4409 976 975 545 616 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4452 r0 *1 168.56,166.32
X$4452 976 975 551 575 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4461 m0 *1 161.28,226.8
X$4461 551 975 976 958 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4468 m0 *1 2.24,196.56
X$4468 554 975 976 556 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4474 m0 *1 44.24,166.32
X$4474 976 975 564 563 558 557 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4491 m0 *1 262.08,176.4
X$4491 567 975 976 560 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4513 m0 *1 222.88,176.4
X$4513 976 975 567 586 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4524 m0 *1 226.24,176.4
X$4524 976 975 588 567 587 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4532 r0 *1 37.52,176.4
X$4532 582 975 976 570 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4535 r0 *1 3.36,196.56
X$4535 571 975 976 647 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4538 r0 *1 11.76,196.56
X$4538 609 975 976 572 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4541 m0 *1 10.64,176.4
X$4541 573 975 976 592 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4544 m0 *1 63.28,176.4
X$4544 976 975 601 574 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4570 r0 *1 26.32,176.4
X$4570 976 975 581 592 610 582 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4589 r0 *1 217.28,176.4
X$4589 976 586 587 975 602 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4603 r0 *1 250.32,176.4
X$4603 589 975 976 591 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4606 r0 *1 250.32,186.48
X$4606 590 975 976 619 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4637 m0 *1 43.68,196.56
X$4637 601 975 976 598 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4639 m0 *1 43.12,186.48
X$4639 611 975 976 599 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4645 m0 *1 25.76,186.48
X$4645 600 975 976 608 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4648 r0 *1 26.32,186.48
X$4648 976 975 617 630 610 600 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4678 m0 *1 171.36,267.12
X$4678 936 975 976 606 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4681 r0 *1 2.8,216.72
X$4681 607 975 976 630 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4685 m0 *1 10.64,196.56
X$4685 976 975 657 647 610 609 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4695 m0 *1 50.4,206.64
X$4695 976 975 674 610 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4704 m0 *1 30.24,206.64
X$4704 976 975 689 694 610 678 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4709 r0 *1 16.8,186.48
X$4709 976 975 628 629 610 648 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4712 m0 *1 20.72,236.88
X$4712 976 975 785 718 610 716 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4715 m0 *1 19.04,226.8
X$4715 976 975 693 755 610 695 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4717 m0 *1 10.64,236.88
X$4717 976 975 800 794 610 677 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4720 m0 *1 39.76,216.72
X$4720 976 975 728 717 610 720 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4722 r0 *1 59.92,186.48
X$4722 976 975 611 631 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4734 r0 *1 165.76,236.88
X$4734 834 975 976 613 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4736 m0 *1 201.6,196.56
X$4736 976 975 649 614 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4791 r0 *1 3.36,206.64
X$4791 626 975 976 629 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4794 m0 *1 2.24,226.8
X$4794 648 975 976 627 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4813 m0 *1 160.16,206.64
X$4813 976 975 680 633 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4826 r0 *1 251.44,226.8
X$4826 976 975 750 726 710 638 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4830 r0 *1 258.72,186.48
X$4830 641 975 976 638 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4833 r0 *1 267.12,186.48
X$4833 640 975 976 639 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4840 m0 *1 249.2,246.96
X$4840 976 975 860 640 710 788 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4858 r0 *1 42,206.64
X$4858 644 975 976 667 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4863 r0 *1 10.64,226.8
X$4863 668 975 976 645 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4866 m0 *1 38.64,206.64
X$4866 678 975 976 646 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4886 r0 *1 218.4,267.12
X$4886 649 975 976 972 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4897 m0 *1 241.92,196.56
X$4897 670 975 976 652 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4899 r0 *1 243.6,196.56
X$4899 976 975 682 683 671 652 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4902 m0 *1 250.32,196.56
X$4902 976 975 653 655 671 654 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4906 r0 *1 243.6,206.64
X$4906 700 975 976 654 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4914 m0 *1 267.12,196.56
X$4914 655 975 976 656 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4929 r0 *1 181.44,196.56
X$4929 976 975 669 659 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4946 r0 *1 2.24,226.8
X$4946 695 975 976 663 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4949 m0 *1 10.64,226.8
X$4949 664 975 976 755 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4952 r0 *1 2.24,236.88
X$4952 665 975 976 694 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4978 r0 *1 189.28,267.12
X$4978 669 975 976 956 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4982 m0 *1 229.04,257.04
X$4982 976 975 908 905 671 906 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4984 r0 *1 235.2,206.64
X$4984 976 975 696 697 671 681 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4986 m0 *1 192.64,226.8
X$4986 976 975 679 671 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5000 r0 *1 252,267.12
X$5000 976 975 877 688 671 941 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5003 m0 *1 219.52,226.8
X$5003 976 975 746 758 671 703 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5005 r0 *1 226.24,246.96
X$5005 976 975 876 745 671 878 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5007 r0 *1 230.72,236.88
X$5007 976 975 824 712 671 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5009 r0 *1 209.44,246.96
X$5009 976 975 880 852 671 851 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5011 m0 *1 192.08,236.88
X$5011 976 975 799 744 671 774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5019 m0 *1 258.72,196.56
X$5019 672 975 976 699 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5021 r0 *1 252,196.56
X$5021 976 975 685 686 710 673 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5027 m0 *1 258.72,246.96
X$5027 751 975 976 673 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5029 m0 *1 65.52,226.8
X$5029 976 975 674 764 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5032 m0 *1 86.8,236.88
X$5032 976 975 674 797 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5047 m0 *1 47.6,267.12
X$5047 976 975 922 921 674 868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5049 m0 *1 57.68,267.12
X$5049 976 975 889 924 674 838 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5052 m0 *1 2.24,236.88
X$5052 675 975 976 794 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5055 r0 *1 12.32,206.64
X$5055 677 975 976 676 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5066 m0 *1 192.64,216.72
X$5066 976 975 679 710 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5070 m0 *1 184.8,226.8
X$5070 976 975 679 770 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5078 m0 *1 117.04,216.72
X$5078 976 975 707 708 679 709 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5080 r0 *1 126.56,226.8
X$5080 976 975 793 760 679 896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5090 m0 *1 147.28,236.88
X$5090 680 975 976 867 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5092 m0 *1 235.76,206.64
X$5092 684 975 976 681 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5107 m0 *1 226.8,216.72
X$5107 683 975 976 747 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5121 r0 *1 237.44,216.72
X$5121 686 975 976 781 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5126 r0 *1 267.12,196.56
X$5126 688 975 976 687 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5143 r0 *1 19.6,216.72
X$5143 690 975 976 717 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5146 r0 *1 11.2,216.72
X$5146 720 975 976 691 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5149 m0 *1 22.96,216.72
X$5149 692 975 976 718 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5180 m0 *1 244.16,206.64
X$5180 697 975 976 701 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5185 r0 *1 226.8,206.64
X$5185 698 975 976 703 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5187 r0 *1 260.4,216.72
X$5187 976 975 713 702 710 699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5200 r0 *1 267.12,236.88
X$5200 702 975 976 753 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5215 r0 *1 10.64,236.88
X$5215 716 975 976 705 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5217 m0 *1 31.36,216.72
X$5217 719 975 976 706 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5219 m0 *1 35.28,267.12
X$5219 976 975 920 706 764 888 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5228 r0 *1 113.68,267.12
X$5228 708 975 976 960 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5233 m0 *1 112,267.12
X$5233 931 975 976 709 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5249 m0 *1 228.48,226.8
X$5249 976 975 732 724 710 729 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5251 m0 *1 238.56,236.88
X$5251 976 975 803 777 710 748 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5253 m0 *1 202.16,236.88
X$5253 976 975 743 733 710 804 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5256 m0 *1 211.12,236.88
X$5256 976 975 809 776 710 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5260 m0 *1 267.12,236.88
X$5260 976 975 727 714 710 780 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5263 r0 *1 193.2,236.88
X$5263 976 975 832 823 710 863 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5267 m0 *1 235.2,216.72
X$5267 711 975 976 729 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5272 m0 *1 243.6,216.72
X$5272 712 975 976 715 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5281 m0 *1 267.12,246.96
X$5281 714 975 976 783 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5317 r0 *1 47.6,216.72
X$5317 721 975 976 730 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5319 m0 *1 57.12,226.8
X$5319 976 975 757 730 764 722 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5326 r0 *1 56,216.72
X$5326 722 975 976 731 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5329 m0 *1 164.08,236.88
X$5329 723 975 976 938 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5332 m0 *1 155.68,236.88
X$5332 976 975 738 723 770 798 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5340 r0 *1 267.12,246.96
X$5340 724 975 976 754 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5345 r0 *1 249.2,216.72
X$5345 725 975 976 941 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5348 m0 *1 267.12,257.04
X$5348 726 975 976 784 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5381 m0 *1 201.6,246.96
X$5381 733 975 976 850 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5384 r0 *1 48.72,236.88
X$5384 976 975 853 837 764 734 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5391 m0 *1 27.44,226.8
X$5391 734 975 976 967 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5394 r0 *1 31.92,236.88
X$5394 976 975 756 826 764 735 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5400 m0 *1 3.92,257.04
X$5400 735 975 976 943 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5404 r0 *1 146.72,226.8
X$5404 976 975 736 739 770 769 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5407 r0 *1 138.88,267.12
X$5407 964 975 976 737 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5416 r0 *1 148.4,236.88
X$5416 739 975 976 818 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5423 m0 *1 170.8,226.8
X$5423 740 975 976 742 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5425 m0 *1 168.56,246.96
X$5425 976 975 847 740 770 864 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5429 r0 *1 182.56,226.8
X$5429 976 975 791 741 770 790 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5431 m0 *1 160.16,246.96
X$5431 741 975 976 937 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5445 m0 *1 201.6,226.8
X$5445 744 975 976 775 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5454 m0 *1 210,226.8
X$5454 745 975 976 759 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5461 m0 *1 238.56,226.8
X$5461 749 975 976 748 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5472 r0 *1 267.12,226.8
X$5472 752 975 976 780 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5493 r0 *1 267.12,257.04
X$5493 758 975 976 782 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5503 m0 *1 128.8,267.12
X$5503 760 975 976 934 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5507 m0 *1 30.24,236.88
X$5507 976 975 786 801 764 761 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5513 r0 *1 19.6,267.12
X$5513 761 975 976 944 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5517 m0 *1 39.2,236.88
X$5517 976 975 762 827 764 765 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5519 r0 *1 57.12,226.8
X$5519 976 975 795 766 764 763 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5523 r0 *1 66.64,226.8
X$5523 763 975 976 789 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5541 m0 *1 24.64,267.12
X$5541 976 975 919 879 764 887 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5544 m0 *1 25.76,246.96
X$5544 976 975 854 855 764 835 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5551 r0 *1 65.52,236.88
X$5551 976 975 811 812 764 813 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5557 m0 *1 57.68,236.88
X$5557 765 975 976 802 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5561 r0 *1 57.12,236.88
X$5561 857 975 976 766 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5563 m0 *1 76.16,236.88
X$5563 976 975 767 814 797 768 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5570 r0 *1 84,267.12
X$5570 768 975 976 955 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5576 r0 *1 160.72,257.04
X$5576 914 975 976 769 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5589 m0 *1 174.16,236.88
X$5589 976 975 807 820 770 772 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5591 m0 *1 183.68,236.88
X$5591 976 975 821 833 770 808 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5593 m0 *1 154.56,267.12
X$5593 976 975 884 901 770 873 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5595 m0 *1 188.16,267.12
X$5595 976 975 933 918 770 930 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5599 m0 *1 179.76,267.12
X$5599 976 975 874 902 770 917 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5602 m0 *1 146.16,267.12
X$5602 976 975 899 900 770 915 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5609 r0 *1 174.16,226.8
X$5609 771 975 976 772 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5615 r0 *1 192.64,226.8
X$5615 773 975 976 774 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5627 r0 *1 260.4,267.12
X$5627 776 975 976 974 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5632 r0 *1 232.96,226.8
X$5632 777 975 976 778 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5643 r0 *1 243.04,226.8
X$5643 779 975 976 788 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5668 r0 *1 223.44,226.8
X$5668 787 975 976 806 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5680 r0 *1 210,267.12
X$5680 948 975 976 790 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5686 m0 *1 103.6,236.88
X$5686 976 975 805 817 797 792 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5689 m0 *1 112,246.96
X$5689 792 975 976 865 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5705 m0 *1 66.64,236.88
X$5705 796 975 976 812 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5720 r0 *1 131.6,257.04
X$5720 976 975 912 897 797 898 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5723 m0 *1 78.4,267.12
X$5723 976 975 840 926 797 816 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5725 m0 *1 95.76,257.04
X$5725 976 975 909 841 797 891 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5728 r0 *1 92.4,257.04
X$5728 976 975 910 892 797 885 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5731 r0 *1 73.36,246.96
X$5731 976 975 839 869 797 870 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5733 m0 *1 120.4,267.12
X$5733 976 975 895 844 797 913 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5735 m0 *1 107.52,257.04
X$5735 976 975 871 894 797 872 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5738 r0 *1 82.32,257.04
X$5738 976 975 907 890 797 842 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5742 r0 *1 156.8,236.88
X$5742 819 975 976 798 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5751 m0 *1 48.16,236.88
X$5751 810 975 976 801 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5768 r0 *1 243.6,267.12
X$5768 940 975 976 804 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5783 m0 *1 176.96,246.96
X$5783 866 975 976 808 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5802 r0 *1 75.04,236.88
X$5802 813 975 976 828 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5805 m0 *1 70,267.12
X$5805 925 975 976 814 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5810 r0 *1 92.4,236.88
X$5810 815 975 976 841 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5817 r0 *1 103.6,236.88
X$5817 816 975 976 883 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5819 m0 *1 95.2,267.12
X$5819 928 975 976 817 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5835 r0 *1 226.8,267.12
X$5835 820 975 976 971 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5846 m0 *1 210,267.12
X$5846 916 975 976 822 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5851 r0 *1 235.2,267.12
X$5851 823 975 976 973 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5861 r0 *1 23.52,236.88
X$5861 825 975 976 826 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5870 r0 *1 28,267.12
X$5870 945 975 976 827 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5876 r0 *1 83.44,236.88
X$5876 829 975 976 890 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5881 r0 *1 207.2,236.88
X$5881 831 975 976 830 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5897 r0 *1 192.64,246.96
X$5897 833 975 976 950 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5911 m0 *1 34.16,246.96
X$5911 835 975 976 947 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5916 m0 *1 42.56,246.96
X$5916 836 975 976 879 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5920 r0 *1 2.24,267.12
X$5920 942 975 976 837 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5926 m0 *1 51.52,246.96
X$5926 838 975 976 858 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5941 m0 *1 98,246.96
X$5941 842 975 976 893 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5947 m0 *1 122.64,246.96
X$5947 843 975 976 844 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5955 m0 *1 131.04,246.96
X$5955 845 975 976 897 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5959 m0 *1 151.76,246.96
X$5959 846 975 976 873 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5967 m0 *1 192.08,246.96
X$5967 848 975 976 849 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5975 m0 *1 210,246.96
X$5975 862 975 976 851 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5981 m0 *1 218.4,246.96
X$5981 852 975 976 875 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5993 m0 *1 69.44,246.96
X$5993 861 975 976 855 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5998 r0 *1 40.32,236.88
X$5998 856 975 976 921 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6008 m0 *1 59.92,246.96
X$6008 859 975 976 924 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6020 r0 *1 201.04,246.96
X$6020 881 975 976 863 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6026 m0 *1 201.6,267.12
X$6026 929 975 976 864 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6046 r0 *1 47.04,267.12
X$6046 868 975 976 951 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6048 r0 *1 67.2,267.12
X$6048 952 975 976 869 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6054 r0 *1 75.6,267.12
X$6054 870 975 976 953 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6064 r0 *1 105.28,267.12
X$6064 872 975 976 959 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6084 r0 *1 217.84,246.96
X$6084 903 975 976 878 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6100 r0 *1 184.24,246.96
X$6100 882 975 976 930 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6115 m0 *1 103.6,267.12
X$6115 885 975 976 932 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6123 r0 *1 11.2,267.12
X$6123 887 975 976 968 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6131 r0 *1 36.4,267.12
X$6131 888 975 976 946 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6139 r0 *1 92.4,267.12
X$6139 891 975 976 954 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6143 m0 *1 86.8,267.12
X$6143 927 975 976 892 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6150 r0 *1 103.04,257.04
X$6150 911 975 976 894 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6157 r0 *1 130.48,267.12
X$6157 963 975 976 896 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6162 m0 *1 137.2,267.12
X$6162 898 975 976 965 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6168 r0 *1 155.68,267.12
X$6168 900 975 976 961 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6175 r0 *1 164.08,267.12
X$6175 901 975 976 969 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6180 m0 *1 162.96,267.12
X$6180 902 975 976 935 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6191 m0 *1 220.64,257.04
X$6191 904 975 976 906 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6198 r0 *1 213.36,257.04
X$6198 905 975 976 923 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6234 r0 *1 122.08,267.12
X$6234 913 975 976 962 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6240 r0 *1 147.28,267.12
X$6240 966 975 976 915 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6247 r0 *1 180.88,267.12
X$6247 957 975 976 917 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6254 r0 *1 201.6,267.12
X$6254 918 975 976 939 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9131 r0 *1 57.12,267.12
X$9131 949 975 976 926 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS ahb_lite_master

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_4 1 3 4 5 6 7 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 ZN
* net 4 A2
* net 5 A1
* net 6 B
* net 7 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 13 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 3 5 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 14 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 12 4 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 15 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 3 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 16 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 12 4 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $9 r0 *1 9.91,3.965 pmos_5p0
M$9 3 6 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.7238P AD=1.7812P PS=8.47U PD=9.74U
* device instance $10 r0 *1 10.93,3.965 pmos_5p0
M$10 12 7 3 12 pmos_5p0 L=0.5U W=5.84U AS=1.5184P AD=1.5184P PS=7.92U PD=7.92U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 3 4 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3926P PS=9.04U PD=7.39U
* device instance $18 r0 *1 2.04,1.005 nmos_5p0
M$18 2 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $25 r0 *1 9.91,1.005 nmos_5p0
M$25 10 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $26 r0 *1 10.88,1.005 nmos_5p0
M$26 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 12,1.005 nmos_5p0
M$27 11 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.92,1.005 nmos_5p0
M$28 2 6 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 14.04,1.005 nmos_5p0
M$29 9 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.96,1.005 nmos_5p0
M$30 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 16.08,1.005 nmos_5p0
M$31 8 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 17,1.005 nmos_5p0
M$32 2 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin C
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_2 1 3 4 5 6 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 NWELL,VDD
* net 5 B1
* net 6 C
* net 8 A2
* net 9 ZN
* net 10 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 2 6 7 4 pmos_5p0 L=0.5U W=3.66U AS=1.4457P AD=0.983625P PS=7.07U PD=4.735U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.1163P PS=4.7U PD=4.88U
* device instance $3 r0 *1 3.01,3.78 pmos_5p0
M$3 2 5 4 4 pmos_5p0 L=0.5U W=3.66U AS=0.9699P AD=0.9699P PS=4.72U PD=4.72U
* device instance $7 r0 *1 7.325,3.78 pmos_5p0
M$7 9 10 7 4 pmos_5p0 L=0.5U W=3.66U AS=0.983625P AD=1.281P PS=4.735U PD=6.89U
* device instance $8 r0 *1 8.345,3.78 pmos_5p0
M$8 7 8 9 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $11 r0 *1 6.32,0.875 nmos_5p0
M$11 9 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.711P AD=0.709025P PS=3.77U PD=4.36U
* device instance $13 r0 *1 2.22,1.072 nmos_5p0
M$13 14 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1422P PS=1.885U PD=1.425U
* device instance $14 r0 *1 3.06,1.072 nmos_5p0
M$14 9 5 14 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 4.18,1.072 nmos_5p0
M$15 12 5 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 5.02,1.072 nmos_5p0
M$16 1 3 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
* device instance $17 r0 *1 7.635,1.072 nmos_5p0
M$17 13 10 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.361425P AD=0.1422P PS=1.9U
+ PD=1.425U
* device instance $18 r0 *1 8.475,1.072 nmos_5p0
M$18 1 8 13 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $19 r0 *1 9.595,1.072 nmos_5p0
M$19 11 8 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $20 r0 *1 10.435,1.072 nmos_5p0
M$20 9 10 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.5214P PS=1.425U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 2 4 4 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 6 3 8 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 7 3 6 4 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 4 2 7 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.7869P PS=2.4U PD=2.69U
* device instance $5 r0 *1 5.59,3.78 pmos_5p0
M$5 5 6 4 4 pmos_5p0 L=0.5U W=7.32U AS=2.3973P AD=2.4156P PS=9.94U PD=11.79U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 6 2 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7788P PS=5.36U PD=3.82U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 1 3 6 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.54,1.005 nmos_5p0
M$13 5 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4652P AD=1.6104P PS=7.5U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A4
* pin NWELL,VDD
* pin A3
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A4
* net 4 NWELL,VDD
* net 5 A3
* net 6 A1
* net 7 A2
* device instance $1 r0 *1 0.975,3.78 pmos_5p0
M$1 13 5 8 4 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.045,3.78 pmos_5p0
M$2 4 3 13 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.165,3.78 pmos_5p0
M$3 12 3 4 4 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.465,3.78 pmos_5p0
M$4 11 5 12 4 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.77775P PS=2.63U PD=2.68U
* device instance $5 r0 *1 5.815,3.78 pmos_5p0
M$5 10 7 11 4 pmos_5p0 L=0.5U W=1.83U AS=0.77775P AD=0.52155P PS=2.68U PD=2.4U
* device instance $6 r0 *1 6.885,3.78 pmos_5p0
M$6 2 6 10 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 8.055,3.78 pmos_5p0
M$7 9 6 2 4 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $8 r0 *1 9.075,3.78 pmos_5p0
M$8 8 7 9 4 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 4.465,0.695 nmos_5p0
M$9 1 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.52165P AD=0.40285P PS=3.565U PD=2.545U
* device instance $11 r0 *1 2.045,0.7 nmos_5p0
M$11 1 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.40285P AD=0.3432P PS=2.545U PD=2.36U
* device instance $13 r0 *1 5.765,0.7 nmos_5p0
M$13 2 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.40285P AD=0.462P PS=2.545U PD=3.38U
* device instance $14 r0 *1 6.885,0.7 nmos_5p0
M$14 1 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=2.36U PD=2.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor4_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_2
* pin NWELL,VDD
* pin A2
* pin ZN
* pin A1
* pin B
* pin C
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 A2
* net 3 ZN
* net 4 A1
* net 5 B
* net 6 C
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $5 r0 *1 5.43,3.965 pmos_5p0
M$5 3 5 1 1 pmos_5p0 L=0.5U W=2.92U AS=0.9646P AD=1.022P PS=4.51U PD=5.78U
* device instance $6 r0 *1 6.45,3.965 pmos_5p0
M$6 1 6 3 1 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7062P PS=5.36U PD=3.71U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 7 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.43,1.005 nmos_5p0
M$13 11 5 8 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $14 r0 *1 6.4,1.005 nmos_5p0
M$14 7 6 11 7 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $15 r0 *1 7.52,1.005 nmos_5p0
M$15 12 6 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 8.44,1.005 nmos_5p0
M$16 8 5 12 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.2993P PS=6.99U PD=5.08U
* device instance $3 r0 *1 3.29,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.5071P PS=9.98U PD=11.89U
* device instance $7 r0 *1 0.92,1.23 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.4593P PS=3.59U PD=2.75U
* device instance $9 r0 *1 3.34,1.265 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.8935P AD=0.976P PS=5.46U PD=6.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4

* cell gf180mcu_fd_sc_mcu9t5v0__or4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_4 1 3 4 5 6 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 Z
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 4 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 5 11 8 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 6 10 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 7 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 12 7 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 13 6 12 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 14 5 13 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 8 4 14 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.77775P PS=2.45U PD=2.68U
* device instance $9 r0 *1 10.11,3.78 pmos_5p0
M$9 3 2 8 8 pmos_5p0 L=0.5U W=7.32U AS=2.38815P AD=2.4156P PS=9.93U PD=11.79U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 2 4 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.5879P PS=3.77U PD=3.33U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 1 5 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $15 r0 *1 3.16,0.74 nmos_5p0
M$15 2 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $16 r0 *1 4.28,0.74 nmos_5p0
M$16 1 7 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $21 r0 *1 10.06,1.005 nmos_5p0
M$21 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4121P AD=1.6104P PS=7.54U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_4 1 2 3 4 5
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 ZN
* net 5 A1
* device instance $1 r0 *1 0.87,3.687 pmos_5p0
M$1 4 3 1 1 pmos_5p0 L=0.5U W=6.58U AS=2.0069P AD=2.0069P PS=10.665U PD=10.665U
* device instance $2 r0 *1 1.89,3.687 pmos_5p0
M$2 1 5 4 1 pmos_5p0 L=0.5U W=6.58U AS=1.7108P AD=1.7108P PS=8.66U PD=8.66U
* device instance $9 r0 *1 1,1.005 nmos_5p0
M$9 9 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 5 9 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3729P PS=1.56U PD=1.885U
* device instance $11 r0 *1 3.005,1.005 nmos_5p0
M$11 8 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3729P AD=0.1584P PS=1.885U PD=1.56U
* device instance $12 r0 *1 3.845,1.005 nmos_5p0
M$12 2 3 8 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3663P PS=1.56U PD=1.875U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 7 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.2112P PS=1.875U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 4 5 7 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 6 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 2 3 6 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_4
* pin A2
* pin NWELL,VDD
* pin A3
* pin ZN
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_4 1 2 3 4 5 6
* net 1 A2
* net 2 NWELL,VDD
* net 3 A3
* net 4 ZN
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 12 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 2 3 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 11 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 7 1 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 9 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 3 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.59,3.78 pmos_5p0
M$7 8 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 10 1 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.83,3.78 pmos_5p0
M$9 4 6 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 7 6 4 2 pmos_5p0 L=0.5U W=5.49U AS=1.7019P AD=1.9398P PS=7.35U PD=9.44U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 4 1 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.9638P AD=0.8216P PS=6.39U PD=5.24U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 5 3 4 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.8216P PS=5.24U PD=5.24U
* device instance $21 r0 *1 9.88,0.74 nmos_5p0
M$21 4 6 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.9638P PS=5.24U PD=6.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_4

* cell gf180mcu_fd_sc_mcu9t5v0__addh_1
* pin CO
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A
* pin B
* pin S
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_1 1 2 3 4 5 9
* net 1 CO
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 NWELL,VDD
* net 4 A
* net 5 B
* net 9 S
* device instance $1 r0 *1 5.01,3.912 pmos_5p0
M$1 10 5 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 6.03,3.912 pmos_5p0
M$2 8 4 10 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.3294P PS=1.435U PD=1.635U
* device instance $3 r0 *1 7.25,3.912 pmos_5p0
M$3 8 6 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.50325P AD=0.3294P PS=2.53U PD=1.635U
* device instance $4 r0 *1 8.45,3.78 pmos_5p0
M$4 9 8 3 3 pmos_5p0 L=0.5U W=1.83U AS=0.50325P AD=0.8052P PS=2.53U PD=4.54U
* device instance $5 r0 *1 2.23,3.912 pmos_5p0
M$5 6 4 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.5307P AD=0.2379P PS=2.59U PD=1.435U
* device instance $6 r0 *1 3.25,3.912 pmos_5p0
M$6 3 5 6 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $7 r0 *1 0.97,3.78 pmos_5p0
M$7 3 6 1 3 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5307P PS=4.54U PD=2.59U
* device instance $8 r0 *1 4.96,1.335 nmos_5p0
M$8 8 5 7 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $9 r0 *1 6.08,1.335 nmos_5p0
M$9 7 4 8 2 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1716P PS=1.18U PD=1.18U
* device instance $10 r0 *1 7.2,1.335 nmos_5p0
M$10 7 6 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $11 r0 *1 8.5,1.005 nmos_5p0
M$11 9 8 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.5808P PS=2.02U PD=3.52U
* device instance $12 r0 *1 0.92,1.005 nmos_5p0
M$12 2 6 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3828P PS=3.52U PD=2.08U
* device instance $13 r0 *1 2.28,1.335 nmos_5p0
M$13 11 4 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.3828P AD=0.0792P PS=2.08U PD=0.9U
* device instance $14 r0 *1 3.12,1.335 nmos_5p0
M$14 6 5 11 2 nmos_5p0 L=0.6U W=0.66U AS=0.0792P AD=0.2904P PS=0.9U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_1

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin A2
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_4 1 2 3 4 5 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 A2
* net 5 B
* net 11 NWELL,VDD
* device instance $1 r0 *1 1.07,3.785 pmos_5p0
M$1 2 4 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1594P PS=11.59U PD=9.68U
* device instance $2 r0 *1 2.09,3.785 pmos_5p0
M$2 10 3 2 11 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.51,3.785 pmos_5p0
M$9 11 5 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $13 r0 *1 1.14,1 nmos_5p0
M$13 7 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $14 r0 *1 1.98,1 nmos_5p0
M$14 2 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $15 r0 *1 3.1,1 nmos_5p0
M$15 6 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $16 r0 *1 3.94,1 nmos_5p0
M$16 1 4 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 5.06,1 nmos_5p0
M$17 8 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $18 r0 *1 5.9,1 nmos_5p0
M$18 2 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $19 r0 *1 7.02,1 nmos_5p0
M$19 9 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $20 r0 *1 7.86,1 nmos_5p0
M$20 1 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.402P PS=1.56U PD=2.02U
* device instance $21 r0 *1 9.16,1.2 nmos_5p0
M$21 2 5 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1196P AD=1.1224P PS=6.34U PD=7.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin B1
* pin A1
* pin B2
* pin C
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_4 1 2 3 4 13 14 15 16
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 B1
* net 4 A1
* net 13 B2
* net 14 C
* net 15 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 9.8,3.78 pmos_5p0
M$1 17 14 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.27835P AD=2.20515P PS=11.64U
+ PD=9.73U
* device instance $5 r0 *1 14.21,3.78 pmos_5p0
M$5 2 4 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $6 r0 *1 15.23,3.78 pmos_5p0
M$6 18 15 2 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $13 r0 *1 0.92,3.78 pmos_5p0
M$13 17 3 16 16 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U
+ PD=11.59U
* device instance $14 r0 *1 1.94,3.78 pmos_5p0
M$14 16 13 17 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $21 r0 *1 9.6,0.74 nmos_5p0
M$21 1 14 2 1 nmos_5p0 L=0.6U W=3.16U AS=1.04675P AD=0.9717P PS=6.005U PD=5.815U
* device instance $25 r0 *1 0.92,0.937 nmos_5p0
M$25 5 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.219225P PS=3.25U PD=1.555U
* device instance $26 r0 *1 1.89,0.937 nmos_5p0
M$26 1 13 5 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.01,0.937 nmos_5p0
M$27 7 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 3.93,0.937 nmos_5p0
M$28 2 3 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.05,0.937 nmos_5p0
M$29 9 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 5.97,0.937 nmos_5p0
M$30 1 13 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.09,0.937 nmos_5p0
M$31 8 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.24885P PS=1.705U
+ PD=1.605U
* device instance $32 r0 *1 8.11,0.937 nmos_5p0
M$32 2 3 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.24885P AD=0.43055P PS=1.605U
+ PD=2.075U
* device instance $33 r0 *1 14.26,0.937 nmos_5p0
M$33 12 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1896P PS=1.885U PD=1.505U
* device instance $34 r0 *1 15.18,0.937 nmos_5p0
M$34 1 15 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $35 r0 *1 16.3,0.937 nmos_5p0
M$35 11 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U
+ PD=1.505U
* device instance $36 r0 *1 17.22,0.937 nmos_5p0
M$36 2 4 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $37 r0 *1 18.34,0.937 nmos_5p0
M$37 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $38 r0 *1 19.26,0.937 nmos_5p0
M$38 1 15 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $39 r0 *1 20.38,0.937 nmos_5p0
M$39 6 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $40 r0 *1 21.3,0.937 nmos_5p0
M$40 2 4 6 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.5214P PS=1.505U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_4

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__xor2_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xor2_2 1 2 6 7 8
* net 1 A1
* net 2 PWELL,VSS,gf180mcu_gnd
* net 6 A2
* net 7 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.87,3.947 pmos_5p0
M$1 3 6 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 1.89,3.947 pmos_5p0
M$2 3 1 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.526125P AD=0.2379P PS=2.58U PD=1.435U
* device instance $3 r0 *1 3.14,3.785 pmos_5p0
M$3 5 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.526125P AD=0.61305P PS=2.58U PD=2.5U
* device instance $4 r0 *1 4.31,3.785 pmos_5p0
M$4 9 1 5 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $5 r0 *1 5.33,3.785 pmos_5p0
M$5 7 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.27,3.78 pmos_5p0
M$6 8 5 7 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 5 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,1.16 nmos_5p0
M$10 10 6 3 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1056P PS=2.2U PD=0.98U
* device instance $11 r0 *1 1.84,1.16 nmos_5p0
M$11 10 1 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1056P PS=2.02U PD=0.98U
* device instance $12 r0 *1 3.14,1.005 nmos_5p0
M$12 4 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.26,1.005 nmos_5p0
M$13 5 1 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 4 6 5 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_4 1 3 4 5 6 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 RN
* net 4 Q
* net 5 CLK
* net 6 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 16.975,3.78 pmos_5p0
M$1 4 13 17 17 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U PD=11.59U
* device instance $5 r0 *1 9.55,3.71 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.285P PS=2.88U PD=1.57U
* device instance $6 r0 *1 10.62,3.71 pmos_5p0
M$6 11 2 10 17 pmos_5p0 L=0.5U W=1U AS=0.285P AD=0.26P PS=1.57U PD=1.52U
* device instance $7 r0 *1 11.64,3.71 pmos_5p0
M$7 12 8 11 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2875P PS=1.52U PD=1.575U
* device instance $8 r0 *1 12.715,3.71 pmos_5p0
M$8 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.5457P AD=0.2875P PS=2.57U PD=1.575U
* device instance $9 r0 *1 13.955,3.78 pmos_5p0
M$9 13 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5457P AD=0.4758P PS=2.57U PD=2.35U
* device instance $10 r0 *1 14.975,3.78 pmos_5p0
M$10 17 11 13 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $11 r0 *1 3.73,3.41 pmos_5p0
M$11 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $12 r0 *1 4.75,3.41 pmos_5p0
M$12 9 8 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 5.77,3.41 pmos_5p0
M$13 18 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $14 r0 *1 6.79,3.41 pmos_5p0
M$14 17 10 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $15 r0 *1 7.81,3.41 pmos_5p0
M$15 18 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $16 r0 *1 0.97,3.555 pmos_5p0
M$16 17 5 2 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $17 r0 *1 1.99,3.555 pmos_5p0
M$17 8 2 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $18 r0 *1 16.925,1.005 nmos_5p0
M$18 4 13 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $22 r0 *1 3.9,1.315 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $23 r0 *1 5.02,1.315 nmos_5p0
M$23 9 2 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $24 r0 *1 6.14,1.315 nmos_5p0
M$24 15 8 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $25 r0 *1 6.98,1.315 nmos_5p0
M$25 14 10 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0826P PS=0.83U PD=0.87U
* device instance $26 r0 *1 7.86,1.315 nmos_5p0
M$26 1 3 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.0826P AD=0.2124P PS=0.87U PD=1.31U
* device instance $27 r0 *1 9.18,1.315 nmos_5p0
M$27 10 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2124P AD=0.190275P PS=1.31U PD=1.235U
* device instance $28 r0 *1 10.425,1.315 nmos_5p0
M$28 11 8 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.190275P AD=0.1534P PS=1.235U
+ PD=1.11U
* device instance $29 r0 *1 11.545,1.315 nmos_5p0
M$29 12 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $30 r0 *1 12.665,1.315 nmos_5p0
M$30 1 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 13.785,1.315 nmos_5p0
M$31 1 3 16 1 nmos_5p0 L=0.6U W=0.59U AS=0.3525P AD=0.1534P PS=2.02U PD=1.11U
* device instance $32 r0 *1 15.085,1.005 nmos_5p0
M$32 13 11 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3525P AD=0.5808P PS=2.02U PD=3.52U
* device instance $33 r0 *1 0.92,1.27 nmos_5p0
M$33 1 5 2 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $34 r0 *1 2.04,1.27 nmos_5p0
M$34 8 2 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_3 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.552 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=2.75U AS=1.03125P AD=0.97625P PS=5.625U PD=4.17U
* device instance $3 r0 *1 3.29,3.552 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=5.5U AS=1.82875P AD=1.88375P PS=8.16U PD=9.615U
* device instance $7 r0 *1 0.92,1.34 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.1U AS=0.385P AD=0.3455P PS=3.05U PD=2.37U
* device instance $9 r0 *1 3.34,1.365 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=2.4U AS=0.6705P AD=0.732P PS=4.66U PD=5.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.732P PS=4.54U PD=2.63U
* device instance $2 r0 *1 2.17,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.2993P AD=1.3725P PS=5.08U PD=6.99U
* device instance $4 r0 *1 0.92,1.23 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=0.73U AS=0.3212P AD=0.2695P PS=2.34U PD=1.5U
* device instance $5 r0 *1 2.22,1.265 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=1.6U AS=0.4775P AD=0.56P PS=2.82U PD=3.8U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.673P PS=26.59U PD=24.5U
* device instance $11 r0 *1 12.07,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.346P AD=11.5839P PS=49U PD=51.09U
* device instance $31 r0 *1 0.92,1.005 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=13.2U AS=3.6696P AD=3.432P PS=20.08U PD=18.4U
* device instance $41 r0 *1 12.12,1.005 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=6.864P AD=7.1016P PS=36.8U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_20

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_2
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_2 1 2 3 4 5 6
* net 1 ZN
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A1
* net 6 A3
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 6 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 9 4 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 1 5 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 8 5 1 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 4 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 6 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 3 6 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.553P PS=3.77U PD=3.77U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 1 4 3 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 3 5 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_2 1 2 3 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 NWELL,VDD
* net 5 A2
* net 6 A3
* device instance $1 r0 *1 0.87,3.85 pmos_5p0
M$1 2 6 4 4 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.022P PS=5.78U PD=5.78U
* device instance $2 r0 *1 1.89,3.85 pmos_5p0
M$2 4 5 2 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.85 pmos_5p0
M$3 2 3 4 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 1.06,1 nmos_5p0
M$7 10 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1848P PS=3.52U PD=1.6U
* device instance $8 r0 *1 1.94,1 nmos_5p0
M$8 9 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1848P AD=0.2112P PS=1.6U PD=1.64U
* device instance $9 r0 *1 2.86,1 nmos_5p0
M$9 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $10 r0 *1 3.98,1 nmos_5p0
M$10 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $11 r0 *1 4.9,1 nmos_5p0
M$11 7 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $12 r0 *1 5.92,1 nmos_5p0
M$12 1 6 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.5808P PS=1.74U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai221_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin B2
* pin C
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai221_2 1 3 4 5 6 8 9 10
* net 1 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 B2
* net 6 C
* net 8 A1
* net 9 ZN
* net 10 A2
* device instance $1 r0 *1 0.92,3.965 pmos_5p0
M$1 9 6 1 1 pmos_5p0 L=0.5U W=2.92U AS=1.17P AD=1.2274P PS=5.06U PD=6.33U
* device instance $2 r0 *1 2.12,3.78 pmos_5p0
M$2 14 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.4758P PS=2.53U PD=2.35U
* device instance $3 r0 *1 3.14,3.78 pmos_5p0
M$3 9 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $4 r0 *1 4.31,3.78 pmos_5p0
M$4 13 4 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $5 r0 *1 5.38,3.78 pmos_5p0
M$5 1 5 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $7 r0 *1 7.78,3.78 pmos_5p0
M$7 12 8 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.52155P PS=2.53U PD=2.4U
* device instance $8 r0 *1 8.85,3.78 pmos_5p0
M$8 1 10 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.97,3.78 pmos_5p0
M$9 11 10 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 11.04,3.78 pmos_5p0
M$10 9 8 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 6 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7458P PS=5.36U PD=3.77U
* device instance $12 r0 *1 2.07,1.005 nmos_5p0
M$12 3 5 2 3 nmos_5p0 L=0.6U W=2.64U AS=0.7062P AD=0.6864P PS=3.71U PD=3.68U
* device instance $13 r0 *1 3.19,1.005 nmos_5p0
M$13 2 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.73,1.005 nmos_5p0
M$17 9 8 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.726P AD=0.924P PS=3.74U PD=5.36U
* device instance $18 r0 *1 8.85,1.005 nmos_5p0
M$18 7 10 9 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai221_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_2
* pin NWELL,VDD
* pin B2
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B2
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.4758P PS=4.54U PD=2.35U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 6 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $5 r0 *1 5.45,3.78 pmos_5p0
M$5 11 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 6 7 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 10 7 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 6 5 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $14 r0 *1 6.52,1.005 nmos_5p0
M$14 8 7 6 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_3
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_3 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.74115P PS=4.54U PD=2.64U
* device instance $2 r0 *1 2.18,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.87575P AD=1.9398P PS=7.54U PD=9.44U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 1 4 3 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.4686P PS=3.52U PD=2.03U
* device instance $6 r0 *1 2.23,1.005 nmos_5p0
M$6 5 4 3 3 nmos_5p0 L=0.6U W=3.96U AS=1.155P AD=1.2672P PS=5.71U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_3

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 8 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 8 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 9 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 9 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 10 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 10 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__addh_2
* pin PWELL,VSS,gf180mcu_gnd
* pin CO
* pin S
* pin A
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_2 1 2 6 7 8 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 CO
* net 6 S
* net 7 A
* net 8 B
* net 10 NWELL,VDD
* device instance $1 r0 *1 5.99,3.78 pmos_5p0
M$1 11 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 7.06,3.78 pmos_5p0
M$2 5 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.52155P PS=2.4U PD=2.4U
* device instance $3 r0 *1 8.13,3.78 pmos_5p0
M$3 10 3 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8784P PS=2.4U PD=2.79U
* device instance $4 r0 *1 9.59,3.78 pmos_5p0
M$4 6 5 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.32675P PS=5.19U PD=6.94U
* device instance $6 r0 *1 0.94,3.78 pmos_5p0
M$6 2 3 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.08885P PS=6.99U PD=4.85U
* device instance $8 r0 *1 3.13,3.78 pmos_5p0
M$8 3 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.4758P PS=2.4U PD=2.35U
* device instance $9 r0 *1 4.15,3.78 pmos_5p0
M$9 10 8 3 10 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 5.94,1.005 nmos_5p0
M$10 5 8 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $11 r0 *1 7.06,1.005 nmos_5p0
M$11 4 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $12 r0 *1 8.18,1.005 nmos_5p0
M$12 1 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5016P PS=1.84U PD=2.08U
* device instance $13 r0 *1 9.54,1.005 nmos_5p0
M$13 6 5 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.8448P AD=0.924P PS=3.92U PD=5.36U
* device instance $15 r0 *1 0.94,1.005 nmos_5p0
M$15 2 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $17 r0 *1 3.18,1.005 nmos_5p0
M$17 9 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 4.1,1.005 nmos_5p0
M$18 3 8 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_2

* cell gf180mcu_fd_sc_mcu9t5v0__addf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A
* pin S
* pin B
* pin CI
* pin CO
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addf_4 1 3 4 5 6 10 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A
* net 4 S
* net 5 B
* net 6 CI
* net 10 CO
* net 14 NWELL,VDD
* device instance $1 r0 *1 13.75,3.56 pmos_5p0
M$1 14 5 16 14 pmos_5p0 L=0.5U W=1.39U AS=0.6116P AD=0.3614P PS=3.66U PD=1.91U
* device instance $2 r0 *1 14.77,3.56 pmos_5p0
M$2 16 3 14 14 pmos_5p0 L=0.5U W=1.39U AS=0.3614P AD=0.4309P PS=1.91U PD=2.01U
* device instance $3 r0 *1 15.89,3.56 pmos_5p0
M$3 9 6 16 14 pmos_5p0 L=0.5U W=1.39U AS=0.4309P AD=0.4309P PS=2.01U PD=2.01U
* device instance $4 r0 *1 17.01,3.56 pmos_5p0
M$4 19 5 9 14 pmos_5p0 L=0.5U W=1.39U AS=0.4309P AD=0.2363P PS=2.01U PD=1.73U
* device instance $5 r0 *1 17.85,3.56 pmos_5p0
M$5 14 3 19 14 pmos_5p0 L=0.5U W=1.39U AS=0.2363P AD=0.7026P PS=1.73U PD=2.67U
* device instance $6 r0 *1 19.19,3.78 pmos_5p0
M$6 10 9 14 14 pmos_5p0 L=0.5U W=7.32U AS=2.4045P AD=2.6901P PS=10.02U PD=12.09U
* device instance $10 r0 *1 5.75,3.56 pmos_5p0
M$10 18 3 14 14 pmos_5p0 L=0.5U W=1.39U AS=0.7026P AD=0.2363P PS=2.67U PD=1.73U
* device instance $11 r0 *1 6.59,3.56 pmos_5p0
M$11 17 5 18 14 pmos_5p0 L=0.5U W=1.39U AS=0.2363P AD=0.2363P PS=1.73U PD=1.73U
* device instance $12 r0 *1 7.43,3.56 pmos_5p0
M$12 2 6 17 14 pmos_5p0 L=0.5U W=1.39U AS=0.2363P AD=0.4309P PS=1.73U PD=2.01U
* device instance $13 r0 *1 8.55,3.56 pmos_5p0
M$13 15 9 2 14 pmos_5p0 L=0.5U W=1.39U AS=0.4309P AD=0.4309P PS=2.01U PD=2.01U
* device instance $14 r0 *1 9.67,3.56 pmos_5p0
M$14 14 3 15 14 pmos_5p0 L=0.5U W=1.39U AS=0.4309P AD=0.3614P PS=2.01U PD=1.91U
* device instance $15 r0 *1 10.69,3.56 pmos_5p0
M$15 15 5 14 14 pmos_5p0 L=0.5U W=1.39U AS=0.3614P AD=0.4309P PS=1.91U PD=2.01U
* device instance $16 r0 *1 11.81,3.56 pmos_5p0
M$16 14 6 15 14 pmos_5p0 L=0.5U W=1.39U AS=0.4309P AD=0.6116P PS=2.01U PD=3.66U
* device instance $17 r0 *1 0.95,3.78 pmos_5p0
M$17 4 2 14 14 pmos_5p0 L=0.5U W=7.32U AS=2.5986P AD=2.496P PS=11.99U PD=10.12U
* device instance $21 r0 *1 13.7,1.265 nmos_5p0
M$21 1 5 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.208P PS=2.48U PD=1.32U
* device instance $22 r0 *1 14.82,1.265 nmos_5p0
M$22 8 3 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $23 r0 *1 15.94,1.265 nmos_5p0
M$23 9 6 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $24 r0 *1 17.06,1.265 nmos_5p0
M$24 13 5 9 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.096P PS=1.32U PD=1.04U
* device instance $25 r0 *1 17.9,1.265 nmos_5p0
M$25 13 3 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.4104P AD=0.096P PS=2.06U PD=1.04U
* device instance $26 r0 *1 19.24,1.005 nmos_5p0
M$26 10 9 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.44P AD=1.6104P PS=7.58U PD=9.04U
* device instance $30 r0 *1 1,1.005 nmos_5p0
M$30 4 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.44P PS=9.04U PD=7.58U
* device instance $34 r0 *1 5.7,1.265 nmos_5p0
M$34 12 3 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.4104P AD=0.096P PS=2.06U PD=1.04U
* device instance $35 r0 *1 6.54,1.265 nmos_5p0
M$35 11 5 12 1 nmos_5p0 L=0.6U W=0.8U AS=0.096P AD=0.096P PS=1.04U PD=1.04U
* device instance $36 r0 *1 7.38,1.265 nmos_5p0
M$36 2 6 11 1 nmos_5p0 L=0.6U W=0.8U AS=0.096P AD=0.208P PS=1.04U PD=1.32U
* device instance $37 r0 *1 8.5,1.265 nmos_5p0
M$37 7 9 2 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $38 r0 *1 9.62,1.265 nmos_5p0
M$38 1 3 7 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $39 r0 *1 10.74,1.265 nmos_5p0
M$39 7 5 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $40 r0 *1 11.86,1.265 nmos_5p0
M$40 1 6 7 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addf_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_4 1 2 3 4 5 6 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A2
* net 4 A1
* net 5 B
* net 6 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 1.54,3.78 pmos_5p0
M$1 2 3 11 12 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1411P PS=11.59U PD=9.66U
* device instance $2 r0 *1 2.56,3.78 pmos_5p0
M$2 11 4 2 12 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.96,3.78 pmos_5p0
M$9 13 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.5673P PS=2.61U PD=2.45U
* device instance $10 r0 *1 11.08,3.78 pmos_5p0
M$10 12 6 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $11 r0 *1 12.62,3.78 pmos_5p0
M$11 14 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $12 r0 *1 13.74,3.78 pmos_5p0
M$12 11 5 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $13 r0 *1 15.28,3.78 pmos_5p0
M$13 16 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $14 r0 *1 16.4,3.78 pmos_5p0
M$14 12 6 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $15 r0 *1 17.94,3.78 pmos_5p0
M$15 15 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $16 r0 *1 19.06,3.78 pmos_5p0
M$16 11 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $17 r0 *1 9.96,1.08 nmos_5p0
M$17 2 5 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.33065P AD=0.9638P PS=6.745U PD=6.39U
* device instance $18 r0 *1 11.08,1.08 nmos_5p0
M$18 2 6 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.5056P AD=0.8216P PS=7.04U PD=5.24U
* device instance $25 r0 *1 1.54,0.937 nmos_5p0
M$25 7 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.74655P AD=0.219225P PS=3.63U
+ PD=1.555U
* device instance $26 r0 *1 2.51,0.937 nmos_5p0
M$26 2 4 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.63,0.937 nmos_5p0
M$27 9 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 4.55,0.937 nmos_5p0
M$28 1 3 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.67,0.937 nmos_5p0
M$29 8 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 6.59,0.937 nmos_5p0
M$30 2 4 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.71,0.937 nmos_5p0
M$31 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $32 r0 *1 8.63,0.937 nmos_5p0
M$32 1 3 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.37245P PS=1.505U
+ PD=1.915U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__and4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_2 1 2 3 4 5 6 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.925,4.055 pmos_5p0
M$1 7 1 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $2 r0 *1 1.945,4.055 pmos_5p0
M$2 6 2 7 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $3 r0 *1 2.965,4.055 pmos_5p0
M$3 7 3 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $4 r0 *1 3.985,4.055 pmos_5p0
M$4 7 4 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.558P AD=0.3328P PS=2.53U PD=1.8U
* device instance $5 r0 *1 5.185,3.78 pmos_5p0
M$5 8 7 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.0338P AD=1.281P PS=4.88U PD=6.89U
* device instance $7 r0 *1 0.975,1.005 nmos_5p0
M$7 11 1 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $8 r0 *1 1.895,1.005 nmos_5p0
M$8 10 2 11 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $9 r0 *1 2.915,1.005 nmos_5p0
M$9 9 3 10 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $10 r0 *1 3.935,1.005 nmos_5p0
M$10 5 4 9 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $11 r0 *1 5.055,1.005 nmos_5p0
M$11 8 7 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* pin A2
* pin A1
* pin B
* pin ZN
* pin C
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_2 1 2 4 5 6 7 8
* net 1 A2
* net 2 A1
* net 4 B
* net 5 ZN
* net 6 C
* net 7 NWELL,VDD
* net 8 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 5 1 3 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.3359P PS=6.89U PD=5.12U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 3 2 5 7 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.37,3.78 pmos_5p0
M$5 10 4 3 7 pmos_5p0 L=0.5U W=1.83U AS=0.8601P AD=0.2196P PS=2.77U PD=2.07U
* device instance $6 r0 *1 6.11,3.78 pmos_5p0
M$6 7 6 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.549P PS=2.07U PD=2.43U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 9 6 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.549P AD=0.4392P PS=2.43U PD=2.31U
* device instance $8 r0 *1 8.19,3.78 pmos_5p0
M$8 3 4 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.4392P AD=0.8052P PS=2.31U PD=4.54U
* device instance $9 r0 *1 5.02,0.745 nmos_5p0
M$9 5 4 8 8 nmos_5p0 L=0.6U W=1.58U AS=0.5609P AD=0.553P PS=3.195U PD=3.77U
* device instance $10 r0 *1 6.14,0.745 nmos_5p0
M$10 8 6 5 8 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $13 r0 *1 0.92,0.942 nmos_5p0
M$13 12 1 8 8 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.1422P PS=3.25U PD=1.425U
* device instance $14 r0 *1 1.76,0.942 nmos_5p0
M$14 5 2 12 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 2.88,0.942 nmos_5p0
M$15 11 2 5 8 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 3.72,0.942 nmos_5p0
M$16 8 1 11 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_2

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 10 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 9 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 11 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A2
* pin A1
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A2
* net 4 A1
* net 5 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.61305P PS=4.54U PD=2.5U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 5 4 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 3 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 5 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 6 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 2 3 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $9 r0 *1 0.92,1.04 nmos_5p0
M$9 5 3 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1224P AD=1.1224P PS=7.04U PD=7.04U
* device instance $10 r0 *1 2.04,1.04 nmos_5p0
M$10 1 4 5 1 nmos_5p0 L=0.6U W=3.68U AS=0.9568P AD=0.9568P PS=5.76U PD=5.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin A4
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 A4
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 6 7 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.896P PS=5.24U PD=5.24U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 2 3 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.91,4.055 pmos_5p0
M$3 6 4 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.93,4.055 pmos_5p0
M$4 2 5 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 13 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2442P PS=3.52U PD=1.69U
* device instance $10 r0 *1 1.89,1.005 nmos_5p0
M$10 12 3 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2442P PS=1.69U PD=1.69U
* device instance $11 r0 *1 2.86,1.005 nmos_5p0
M$11 11 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 9 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $14 r0 *1 5.97,1.005 nmos_5p0
M$14 8 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $15 r0 *1 6.99,1.005 nmos_5p0
M$15 10 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.5808P PS=1.69U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_2 1 5 6 7 8
* net 1 NWELL,VDD
* net 5 A1
* net 6 A2
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 ZN
* device instance $1 r0 *1 0.97,3.327 pmos_5p0
M$1 9 6 2 1 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.260775P PS=2.71U PD=1.485U
* device instance $2 r0 *1 2.04,3.327 pmos_5p0
M$2 1 5 9 1 pmos_5p0 L=0.5U W=0.915U AS=0.260775P AD=0.571875P PS=1.485U
+ PD=2.68U
* device instance $3 r0 *1 3.39,3.785 pmos_5p0
M$3 4 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.4758P PS=2.68U PD=2.35U
* device instance $4 r0 *1 4.41,3.785 pmos_5p0
M$4 3 5 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.4758P PS=2.35U PD=2.35U
* device instance $5 r0 *1 5.43,3.785 pmos_5p0
M$5 4 6 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.17,3.78 pmos_5p0
M$6 8 3 1 1 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 3 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,0.675 nmos_5p0
M$10 2 6 7 7 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $11 r0 *1 2.04,0.675 nmos_5p0
M$11 7 5 2 7 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.363P PS=1.18U PD=2.02U
* device instance $12 r0 *1 3.34,1.005 nmos_5p0
M$12 3 2 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.46,1.005 nmos_5p0
M$13 10 5 3 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 7 6 10 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
