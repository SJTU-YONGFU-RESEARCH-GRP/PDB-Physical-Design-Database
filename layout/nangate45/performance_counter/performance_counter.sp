* cell performance_counter
* pin all_counts[39]
* pin all_counts[40]
* pin all_counts[42]
* pin all_counts[41]
* pin all_counts[45]
* pin all_counts[44]
* pin all_counts[47]
* pin all_counts[48]
* pin all_counts[46]
* pin all_counts[15]
* pin all_counts[49]
* pin all_counts[17]
* pin all_counts[31]
* pin all_counts[61]
* pin all_counts[63]
* pin all_counts[57]
* pin all_counts[30]
* pin all_counts[60]
* pin all_counts[27]
* pin all_counts[62]
* pin all_counts[58]
* pin all_counts[56]
* pin all_counts[26]
* pin all_counts[59]
* pin all_counts[22]
* pin all_counts[55]
* pin all_counts[23]
* pin all_counts[141]
* pin all_counts[24]
* pin all_counts[12]
* pin all_counts[135]
* pin all_counts[54]
* pin all_counts[138]
* pin all_counts[50]
* pin all_counts[136]
* pin all_counts[142]
* pin all_counts[14]
* pin all_counts[19]
* pin all_counts[25]
* pin all_counts[13]
* pin all_counts[20]
* pin all_counts[53]
* pin all_counts[147]
* pin all_counts[52]
* pin all_counts[148]
* pin all_counts[51]
* pin all_counts[16]
* pin all_counts[18]
* pin all_counts[21]
* pin all_counts[143]
* pin all_counts[144]
* pin all_counts[163]
* pin all_counts[167]
* pin all_counts[164]
* pin all_counts[165]
* pin all_counts[166]
* pin all_counts[168]
* pin all_counts[162]
* pin event_inc[5]
* pin all_counts[170]
* pin all_counts[173]
* pin all_counts[175]
* pin all_counts[172]
* pin PWELL
* pin NWELL
* pin all_counts[35]
* pin all_counts[36]
* pin all_counts[178]
* pin all_counts[183]
* pin all_counts[184]
* pin all_counts[169]
* pin all_counts[171]
* pin all_counts[177]
* pin all_counts[186]
* pin all_counts[139]
* pin all_counts[174]
* pin all_counts[37]
* pin all_counts[38]
* pin all_counts[149]
* pin all_counts[233]
* pin all_counts[43]
* pin all_counts[182]
* pin all_counts[185]
* pin all_counts[188]
* pin counter_sel[1]
* pin all_counts[3]
* pin all_counts[4]
* pin all_counts[176]
* pin all_counts[245]
* pin count_value[13]
* pin count_value[12]
* pin all_counts[187]
* pin all_counts[34]
* pin all_counts[180]
* pin event_inc[1]
* pin all_counts[191]
* pin all_counts[190]
* pin all_counts[181]
* pin all_counts[161]
* pin all_counts[160]
* pin all_counts[33]
* pin all_counts[5]
* pin all_counts[2]
* pin all_counts[189]
* pin all_counts[145]
* pin all_counts[239]
* pin event_inc[0]
* pin all_counts[179]
* pin all_counts[32]
* pin all_counts[28]
* pin count_value[18]
* pin all_counts[240]
* pin all_counts[29]
* pin all_counts[0]
* pin all_counts[242]
* pin count_value[14]
* pin all_counts[1]
* pin all_counts[11]
* pin all_counts[146]
* pin counter_sel[0]
* pin all_counts[10]
* pin all_counts[241]
* pin all_counts[238]
* pin count_value[16]
* pin all_counts[8]
* pin all_counts[9]
* pin enable
* pin count_value[17]
* pin counter_sel[5]
* pin all_counts[114]
* pin count_value[15]
* pin all_counts[6]
* pin all_counts[7]
* pin all_counts[140]
* pin all_counts[243]
* pin all_counts[112]
* pin all_counts[116]
* pin count_value[19]
* pin all_counts[236]
* pin count_value[20]
* pin counter_sel[2]
* pin all_counts[111]
* pin all_counts[244]
* pin all_counts[237]
* pin all_counts[235]
* pin all_counts[105]
* pin all_counts[115]
* pin all_counts[246]
* pin count_value[11]
* pin all_counts[107]
* pin all_counts[108]
* pin all_counts[113]
* pin count_value[21]
* pin all_counts[106]
* pin count_value[22]
* pin all_counts[104]
* pin count_value[10]
* pin all_counts[137]
* pin all_counts[110]
* pin all_counts[118]
* pin all_counts[134]
* pin count_value[8]
* pin count_value[9]
* pin clk
* pin counter_sel[4]
* pin all_counts[103]
* pin all_counts[117]
* pin all_counts[232]
* pin count_value[0]
* pin all_counts[234]
* pin all_counts[109]
* pin all_counts[102]
* pin all_counts[249]
* pin all_counts[150]
* pin all_counts[228]
* pin count_value[6]
* pin count_value[7]
* pin all_counts[121]
* pin event_inc[3]
* pin event_inc[7]
* pin all_counts[248]
* pin all_counts[100]
* pin all_counts[96]
* pin count_value[5]
* pin count_value[4]
* pin all_counts[101]
* pin all_counts[97]
* pin all_counts[119]
* pin count_value[25]
* pin all_counts[231]
* pin count_value[23]
* pin all_counts[98]
* pin count_value[24]
* pin all_counts[99]
* pin count_value[1]
* pin all_counts[247]
* pin all_counts[229]
* pin event_inc[4]
* pin all_counts[67]
* pin all_counts[224]
* pin all_counts[227]
* pin counter_sel[3]
* pin all_counts[230]
* pin all_counts[124]
* pin all_counts[64]
* pin count_value[27]
* pin count_value[30]
* pin all_counts[252]
* pin all_counts[254]
* pin all_counts[66]
* pin all_counts[69]
* pin all_counts[250]
* pin event_inc[2]
* pin all_counts[65]
* pin all_counts[68]
* pin counter_sel[7]
* pin all_counts[251]
* pin all_counts[255]
* pin counter_sel[6]
* pin all_counts[253]
* pin all_counts[225]
* pin all_counts[226]
* pin count_value[29]
* pin count_value[31]
* pin all_counts[71]
* pin all_counts[73]
* pin all_counts[222]
* pin all_counts[217]
* pin all_counts[218]
* pin count_value[28]
* pin all_counts[221]
* pin all_counts[74]
* pin all_counts[208]
* pin all_counts[72]
* pin all_counts[223]
* pin all_counts[220]
* pin all_counts[207]
* pin all_counts[70]
* pin all_counts[209]
* pin count_value[26]
* pin all_counts[219]
* pin all_counts[215]
* pin all_counts[213]
* pin all_counts[133]
* pin all_counts[216]
* pin all_counts[93]
* pin clear
* pin all_counts[128]
* pin all_counts[158]
* pin all_counts[153]
* pin all_counts[156]
* pin all_counts[154]
* pin all_counts[194]
* pin all_counts[202]
* pin all_counts[214]
* pin all_counts[212]
* pin all_counts[210]
* pin all_counts[76]
* pin all_counts[77]
* pin all_counts[211]
* pin all_counts[75]
* pin all_counts[78]
* pin all_counts[205]
* pin all_counts[81]
* pin all_counts[206]
* pin all_counts[79]
* pin all_counts[193]
* pin all_counts[204]
* pin all_counts[203]
* pin all_counts[80]
* pin all_counts[192]
* pin all_counts[201]
* pin all_counts[86]
* pin all_counts[200]
* pin all_counts[85]
* pin all_counts[199]
* pin all_counts[83]
* pin count_value[2]
* pin all_counts[84]
* pin all_counts[125]
* pin all_counts[198]
* pin all_counts[196]
* pin all_counts[120]
* pin all_counts[126]
* pin all_counts[197]
* pin all_counts[88]
* pin all_counts[195]
* pin all_counts[94]
* pin all_counts[132]
* pin all_counts[131]
* pin all_counts[155]
* pin all_counts[151]
* pin all_counts[123]
* pin all_counts[157]
* pin all_counts[90]
* pin all_counts[152]
* pin all_counts[127]
* pin all_counts[159]
* pin all_counts[95]
* pin all_counts[129]
* pin all_counts[91]
* pin all_counts[92]
* pin all_counts[82]
* pin all_counts[87]
* pin all_counts[89]
* pin all_counts[122]
* pin rst_n
* pin all_counts[130]
* pin event_inc[6]
* pin count_value[3]
.SUBCKT performance_counter 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20
+ 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46
+ 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 85 109 265 266 279 280 282
+ 311 312 314 341 347 349 365 408 425 426 427 429 460 462 475 476 477 499 500
+ 545 546 547 573 595 610 624 625 626 628 629 635 636 682 698 699 702 712 728
+ 760 761 779 780 797 798 815 816 830 831 848 877 878 900 901 902 920 921 922
+ 943 944 967 982 991 992 1007 1008 1034 1035 1059 1060 1061 1076 1077 1090
+ 1092 1093 1111 1112 1140 1141 1157 1158 1159 1189 1190 1194 1217 1232 1249
+ 1250 1251 1279 1280 1281 1310 1313 1314 1315 1339 1340 1341 1361 1362 1382
+ 1383 1384 1432 1433 1447 1448 1462 1466 1488 1489 1511 1512 1535 1536 1537
+ 1554 1555 1556 1575 1595 1609 1633 1634 1635 1647 1651 1664 1665 1666 1696
+ 1710 1711 1733 1734 1735 1739 1757 1758 1783 1787 1808 1809 1833 1834 1835
+ 1873 1874 1908 1909 1942 1943 1953 1954 1969 1970 2006 2007 2008 2019 2040
+ 2060 2072 2073 2074 2084 2097 2101 2132 2157 2158 2172 2193 2270 2271 2272
+ 2273 2275 2276 2277 2278 2279 2280 2281 2282 2283 2284 2285 2286 2287 2288
+ 2289 2290 2291 2292 2293 2294 2295 2296 2297 2298 2299 2300 2301 2302 2303
+ 2304 2305 2306 2307 2308 2309 2310 2311 2312 2313 2314 2315 2316 2317 2318
+ 2319 2320 2321 2322 2323 2324 2325 2326 2327 2328 2329 2330 2331 2332 2333
+ 2334 2335
* net 1 all_counts[39]
* net 2 all_counts[40]
* net 3 all_counts[42]
* net 4 all_counts[41]
* net 5 all_counts[45]
* net 6 all_counts[44]
* net 7 all_counts[47]
* net 8 all_counts[48]
* net 9 all_counts[46]
* net 10 all_counts[15]
* net 11 all_counts[49]
* net 12 all_counts[17]
* net 13 all_counts[31]
* net 14 all_counts[61]
* net 15 all_counts[63]
* net 16 all_counts[57]
* net 17 all_counts[30]
* net 18 all_counts[60]
* net 19 all_counts[27]
* net 20 all_counts[62]
* net 21 all_counts[58]
* net 22 all_counts[56]
* net 23 all_counts[26]
* net 24 all_counts[59]
* net 25 all_counts[22]
* net 26 all_counts[55]
* net 27 all_counts[23]
* net 28 all_counts[141]
* net 29 all_counts[24]
* net 30 all_counts[12]
* net 31 all_counts[135]
* net 32 all_counts[54]
* net 33 all_counts[138]
* net 34 all_counts[50]
* net 35 all_counts[136]
* net 36 all_counts[142]
* net 37 all_counts[14]
* net 38 all_counts[19]
* net 39 all_counts[25]
* net 40 all_counts[13]
* net 41 all_counts[20]
* net 42 all_counts[53]
* net 43 all_counts[147]
* net 44 all_counts[52]
* net 45 all_counts[148]
* net 46 all_counts[51]
* net 47 all_counts[16]
* net 48 all_counts[18]
* net 49 all_counts[21]
* net 50 all_counts[143]
* net 51 all_counts[144]
* net 52 all_counts[163]
* net 53 all_counts[167]
* net 54 all_counts[164]
* net 55 all_counts[165]
* net 56 all_counts[166]
* net 57 all_counts[168]
* net 58 all_counts[162]
* net 59 event_inc[5]
* net 60 all_counts[170]
* net 61 all_counts[173]
* net 62 all_counts[175]
* net 63 all_counts[172]
* net 85 PWELL
* net 109 NWELL
* net 265 all_counts[35]
* net 266 all_counts[36]
* net 279 all_counts[178]
* net 280 all_counts[183]
* net 282 all_counts[184]
* net 311 all_counts[169]
* net 312 all_counts[171]
* net 314 all_counts[177]
* net 341 all_counts[186]
* net 347 all_counts[139]
* net 349 all_counts[174]
* net 365 all_counts[37]
* net 408 all_counts[38]
* net 425 all_counts[149]
* net 426 all_counts[233]
* net 427 all_counts[43]
* net 429 all_counts[182]
* net 460 all_counts[185]
* net 462 all_counts[188]
* net 475 counter_sel[1]
* net 476 all_counts[3]
* net 477 all_counts[4]
* net 499 all_counts[176]
* net 500 all_counts[245]
* net 545 count_value[13]
* net 546 count_value[12]
* net 547 all_counts[187]
* net 573 all_counts[34]
* net 595 all_counts[180]
* net 610 event_inc[1]
* net 624 all_counts[191]
* net 625 all_counts[190]
* net 626 all_counts[181]
* net 628 all_counts[161]
* net 629 all_counts[160]
* net 635 all_counts[33]
* net 636 all_counts[5]
* net 682 all_counts[2]
* net 698 all_counts[189]
* net 699 all_counts[145]
* net 702 all_counts[239]
* net 712 event_inc[0]
* net 728 all_counts[179]
* net 760 all_counts[32]
* net 761 all_counts[28]
* net 779 count_value[18]
* net 780 all_counts[240]
* net 797 all_counts[29]
* net 798 all_counts[0]
* net 815 all_counts[242]
* net 816 count_value[14]
* net 830 all_counts[1]
* net 831 all_counts[11]
* net 848 all_counts[146]
* net 877 counter_sel[0]
* net 878 all_counts[10]
* net 900 all_counts[241]
* net 901 all_counts[238]
* net 902 count_value[16]
* net 920 all_counts[8]
* net 921 all_counts[9]
* net 922 enable
* net 943 count_value[17]
* net 944 counter_sel[5]
* net 967 all_counts[114]
* net 982 count_value[15]
* net 991 all_counts[6]
* net 992 all_counts[7]
* net 1007 all_counts[140]
* net 1008 all_counts[243]
* net 1034 all_counts[112]
* net 1035 all_counts[116]
* net 1059 count_value[19]
* net 1060 all_counts[236]
* net 1061 count_value[20]
* net 1076 counter_sel[2]
* net 1077 all_counts[111]
* net 1090 all_counts[244]
* net 1092 all_counts[237]
* net 1093 all_counts[235]
* net 1111 all_counts[105]
* net 1112 all_counts[115]
* net 1140 all_counts[246]
* net 1141 count_value[11]
* net 1157 all_counts[107]
* net 1158 all_counts[108]
* net 1159 all_counts[113]
* net 1189 count_value[21]
* net 1190 all_counts[106]
* net 1194 count_value[22]
* net 1217 all_counts[104]
* net 1232 count_value[10]
* net 1249 all_counts[137]
* net 1250 all_counts[110]
* net 1251 all_counts[118]
* net 1279 all_counts[134]
* net 1280 count_value[8]
* net 1281 count_value[9]
* net 1310 clk
* net 1313 counter_sel[4]
* net 1314 all_counts[103]
* net 1315 all_counts[117]
* net 1339 all_counts[232]
* net 1340 count_value[0]
* net 1341 all_counts[234]
* net 1361 all_counts[109]
* net 1362 all_counts[102]
* net 1382 all_counts[249]
* net 1383 all_counts[150]
* net 1384 all_counts[228]
* net 1432 count_value[6]
* net 1433 count_value[7]
* net 1447 all_counts[121]
* net 1448 event_inc[3]
* net 1462 event_inc[7]
* net 1466 all_counts[248]
* net 1488 all_counts[100]
* net 1489 all_counts[96]
* net 1511 count_value[5]
* net 1512 count_value[4]
* net 1535 all_counts[101]
* net 1536 all_counts[97]
* net 1537 all_counts[119]
* net 1554 count_value[25]
* net 1555 all_counts[231]
* net 1556 count_value[23]
* net 1575 all_counts[98]
* net 1595 count_value[24]
* net 1609 all_counts[99]
* net 1633 count_value[1]
* net 1634 all_counts[247]
* net 1635 all_counts[229]
* net 1647 event_inc[4]
* net 1651 all_counts[67]
* net 1664 all_counts[224]
* net 1665 all_counts[227]
* net 1666 counter_sel[3]
* net 1696 all_counts[230]
* net 1710 all_counts[124]
* net 1711 all_counts[64]
* net 1733 count_value[27]
* net 1734 count_value[30]
* net 1735 all_counts[252]
* net 1739 all_counts[254]
* net 1757 all_counts[66]
* net 1758 all_counts[69]
* net 1783 all_counts[250]
* net 1787 event_inc[2]
* net 1808 all_counts[65]
* net 1809 all_counts[68]
* net 1833 counter_sel[7]
* net 1834 all_counts[251]
* net 1835 all_counts[255]
* net 1873 counter_sel[6]
* net 1874 all_counts[253]
* net 1908 all_counts[225]
* net 1909 all_counts[226]
* net 1942 count_value[29]
* net 1943 count_value[31]
* net 1953 all_counts[71]
* net 1954 all_counts[73]
* net 1969 all_counts[222]
* net 1970 all_counts[217]
* net 2006 all_counts[218]
* net 2007 count_value[28]
* net 2008 all_counts[221]
* net 2019 all_counts[74]
* net 2040 all_counts[208]
* net 2060 all_counts[72]
* net 2072 all_counts[223]
* net 2073 all_counts[220]
* net 2074 all_counts[207]
* net 2084 all_counts[70]
* net 2097 all_counts[209]
* net 2101 count_value[26]
* net 2132 all_counts[219]
* net 2157 all_counts[215]
* net 2158 all_counts[213]
* net 2172 all_counts[133]
* net 2193 all_counts[216]
* net 2270 all_counts[93]
* net 2271 clear
* net 2272 all_counts[128]
* net 2273 all_counts[158]
* net 2275 all_counts[153]
* net 2276 all_counts[156]
* net 2277 all_counts[154]
* net 2278 all_counts[194]
* net 2279 all_counts[202]
* net 2280 all_counts[214]
* net 2281 all_counts[212]
* net 2282 all_counts[210]
* net 2283 all_counts[76]
* net 2284 all_counts[77]
* net 2285 all_counts[211]
* net 2286 all_counts[75]
* net 2287 all_counts[78]
* net 2288 all_counts[205]
* net 2289 all_counts[81]
* net 2290 all_counts[206]
* net 2291 all_counts[79]
* net 2292 all_counts[193]
* net 2293 all_counts[204]
* net 2294 all_counts[203]
* net 2295 all_counts[80]
* net 2296 all_counts[192]
* net 2297 all_counts[201]
* net 2298 all_counts[86]
* net 2299 all_counts[200]
* net 2300 all_counts[85]
* net 2301 all_counts[199]
* net 2302 all_counts[83]
* net 2303 count_value[2]
* net 2304 all_counts[84]
* net 2305 all_counts[125]
* net 2306 all_counts[198]
* net 2307 all_counts[196]
* net 2308 all_counts[120]
* net 2309 all_counts[126]
* net 2310 all_counts[197]
* net 2311 all_counts[88]
* net 2312 all_counts[195]
* net 2313 all_counts[94]
* net 2314 all_counts[132]
* net 2315 all_counts[131]
* net 2316 all_counts[155]
* net 2317 all_counts[151]
* net 2318 all_counts[123]
* net 2319 all_counts[157]
* net 2320 all_counts[90]
* net 2321 all_counts[152]
* net 2322 all_counts[127]
* net 2323 all_counts[159]
* net 2324 all_counts[95]
* net 2325 all_counts[129]
* net 2326 all_counts[91]
* net 2327 all_counts[92]
* net 2328 all_counts[82]
* net 2329 all_counts[87]
* net 2330 all_counts[89]
* net 2331 all_counts[122]
* net 2332 rst_n
* net 2333 all_counts[130]
* net 2334 event_inc[6]
* net 2335 count_value[3]
* cell instance $2 r0 *1 12.92,1.4
X$2 65 85 109 1 BUF_X1
* cell instance $8 r0 *1 11.97,1.4
X$8 64 85 109 2 BUF_X1
* cell instance $14 r0 *1 14.63,1.4
X$14 89 85 109 3 BUF_X1
* cell instance $20 r0 *1 15.2,1.4
X$20 133 85 109 4 BUF_X1
* cell instance $26 r0 *1 18.24,1.4
X$26 66 85 109 5 BUF_X1
* cell instance $32 r0 *1 19.38,1.4
X$32 91 85 109 6 BUF_X1
* cell instance $38 r0 *1 21.09,1.4
X$38 111 85 109 7 BUF_X1
* cell instance $44 r0 *1 21.66,1.4
X$44 137 85 109 8 BUF_X1
* cell instance $50 r0 *1 22.42,1.4
X$50 68 85 109 9 BUF_X1
* cell instance $56 r0 *1 23.18,1.4
X$56 112 85 109 10 BUF_X1
* cell instance $62 r0 *1 23.94,1.4
X$62 69 85 109 11 BUF_X1
* cell instance $68 r0 *1 25.46,1.4
X$68 114 85 109 12 BUF_X1
* cell instance $74 r0 *1 26.03,1.4
X$74 70 85 109 13 BUF_X1
* cell instance $80 r0 *1 26.6,1.4
X$80 71 85 109 14 BUF_X1
* cell instance $86 r0 *1 27.36,1.4
X$86 116 85 109 15 BUF_X1
* cell instance $92 r0 *1 28.12,1.4
X$92 93 85 109 16 BUF_X1
* cell instance $98 r0 *1 28.88,1.4
X$98 117 85 109 17 BUF_X1
* cell instance $104 m0 *1 29.45,4.2
X$104 184 85 109 18 BUF_X1
* cell instance $110 r0 *1 29.64,1.4
X$110 94 85 109 19 BUF_X1
* cell instance $116 r0 *1 30.21,1.4
X$116 72 85 109 20 BUF_X1
* cell instance $122 r0 *1 32.11,1.4
X$122 86 85 109 21 BUF_X1
* cell instance $128 r0 *1 31.54,1.4
X$128 73 85 109 22 BUF_X1
* cell instance $138 r0 *1 33.25,1.4
X$138 119 85 109 23 BUF_X1
* cell instance $140 r0 *1 32.68,1.4
X$140 96 85 109 24 BUF_X1
* cell instance $146 r0 *1 34.39,1.4
X$146 87 85 109 25 BUF_X1
* cell instance $152 r0 *1 33.82,1.4
X$152 98 85 109 26 BUF_X1
* cell instance $158 r0 *1 35.72,1.4
X$158 120 85 109 27 BUF_X1
* cell instance $164 r0 *1 37.43,1.4
X$164 123 85 109 28 BUF_X1
* cell instance $170 r0 *1 36.86,1.4
X$170 159 85 109 29 BUF_X1
* cell instance $176 r0 *1 38,1.4
X$176 160 85 109 30 BUF_X1
* cell instance $182 r0 *1 39.14,1.4
X$182 88 85 109 31 BUF_X1
* cell instance $188 r0 *1 36.29,1.4
X$188 100 85 109 32 BUF_X1
* cell instance $194 r0 *1 41.04,1.4
X$194 125 85 109 33 BUF_X1
* cell instance $200 r0 *1 40.47,1.4
X$200 102 85 109 34 BUF_X1
* cell instance $206 r0 *1 42.18,1.4
X$206 127 85 109 35 BUF_X1
* cell instance $212 r0 *1 44.46,1.4
X$212 128 85 109 36 BUF_X1
* cell instance $218 r0 *1 42.75,1.4
X$218 126 85 109 37 BUF_X1
* cell instance $224 m0 *1 44.84,4.2
X$224 105 85 109 38 BUF_X1
* cell instance $230 r0 *1 43.32,1.4
X$230 149 85 109 39 BUF_X1
* cell instance $236 r0 *1 43.89,1.4
X$236 104 85 109 40 BUF_X1
* cell instance $242 r0 *1 45.6,1.4
X$242 75 85 109 41 BUF_X1
* cell instance $248 r0 *1 45.03,1.4
X$248 129 85 109 42 BUF_X1
* cell instance $254 r0 *1 46.17,1.4
X$254 76 85 109 43 BUF_X1
* cell instance $260 r0 *1 47.88,1.4
X$260 145 85 109 44 BUF_X1
* cell instance $266 r0 *1 46.74,1.4
X$266 194 85 109 45 BUF_X1
* cell instance $272 r0 *1 47.31,1.4
X$272 106 85 109 46 BUF_X1
* cell instance $278 r0 *1 48.45,1.4
X$278 77 85 109 47 BUF_X1
* cell instance $284 r0 *1 49.4,1.4
X$284 107 85 109 48 BUF_X1
* cell instance $290 r0 *1 49.97,1.4
X$290 78 85 109 49 BUF_X1
* cell instance $296 r0 *1 50.92,1.4
X$296 122 85 109 50 BUF_X1
* cell instance $302 r0 *1 51.87,1.4
X$302 79 85 109 51 BUF_X1
* cell instance $308 r0 *1 53.39,1.4
X$308 80 85 109 52 BUF_X1
* cell instance $316 m0 *1 53.39,4.2
X$316 164 85 109 53 BUF_X1
* cell instance $320 r0 *1 53.96,1.4
X$320 296 85 109 54 BUF_X1
* cell instance $326 m0 *1 54.53,4.2
X$326 186 85 109 55 BUF_X1
* cell instance $332 r0 *1 56.05,1.4
X$332 165 85 109 56 BUF_X1
* cell instance $338 m0 *1 57,4.2
X$338 216 85 109 57 BUF_X1
* cell instance $344 r0 *1 57.76,1.4
X$344 81 85 109 58 BUF_X1
* cell instance $350 r0 *1 58.71,1.4
X$350 59 85 109 108 BUF_X1
* cell instance $356 r0 *1 61.37,1.4
X$356 82 85 109 60 BUF_X1
* cell instance $362 r0 *1 65.17,1.4
X$362 83 85 109 61 BUF_X1
* cell instance $368 r0 *1 66.31,1.4
X$368 84 85 109 62 BUF_X1
* cell instance $374 r0 *1 68.97,1.4
X$374 222 85 109 63 BUF_X1
* cell instance $381 m0 *1 9.12,7
X$381 85 64 167 236 109 DFF_X1
* cell instance $383 m0 *1 12.35,7
X$383 64 85 109 177 BUF_X2
* cell instance $386 r0 *1 10.07,9.8
X$386 85 65 269 200 109 DFF_X1
* cell instance $388 r0 *1 13.3,9.8
X$388 65 85 109 199 BUF_X2
* cell instance $394 m0 *1 20.14,21
X$394 443 442 66 85 558 109 AOI21_X1
* cell instance $396 m0 *1 19.19,18.2
X$396 85 66 468 200 109 DFF_X1
* cell instance $399 r0 *1 18.62,12.6
X$399 66 300 85 109 331 NAND2_X1
* cell instance $402 r0 *1 18.62,15.4
X$402 66 433 109 85 369 XNOR2_X1
* cell instance $414 r0 *1 20.14,7
X$414 226 67 85 109 171 NOR2_X1
* cell instance $416 m0 *1 7.79,18.2
X$416 502 67 85 109 461 NOR2_X1
* cell instance $418 m0 *1 14.82,15.4
X$418 328 67 85 109 392 NOR2_X1
* cell instance $420 m0 *1 17.1,12.6
X$420 286 67 85 109 270 NOR2_X1
* cell instance $422 r0 *1 18.81,1.4
X$422 110 67 85 109 90 NOR2_X1
* cell instance $424 r0 *1 11.02,4.2
X$424 176 67 85 109 167 NOR2_X1
* cell instance $426 m0 *1 13.3,7
X$426 192 67 85 109 148 NOR2_X1
* cell instance $429 m0 *1 15.96,7
X$429 181 67 85 109 182 NOR2_X1
* cell instance $432 r0 *1 21.66,4.2
X$432 136 67 85 109 92 NOR2_X1
* cell instance $434 r0 *1 19.76,15.4
X$434 369 67 85 109 468 NOR2_X1
* cell instance $437 m0 *1 18.24,18.2
X$437 411 85 109 67 CLKBUF_X3
* cell instance $440 r0 *1 22.23,4.2
X$440 68 85 109 138 BUF_X2
* cell instance $443 m0 *1 21.28,4.2
X$443 85 68 92 115 109 DFF_X1
* cell instance $450 r0 *1 21.47,12.6
X$450 85 321 115 2397 69 109 DFF_X2
* cell instance $453 m0 *1 22.8,7
X$453 138 111 137 69 109 85 158 AND4_X2
* cell instance $455 r0 *1 23.37,9.8
X$455 69 290 109 85 289 XNOR2_X1
* cell instance $458 r0 *1 23.56,21
X$458 537 584 69 85 581 109 AOI21_X1
* cell instance $461 m0 *1 27.93,32.2
X$461 70 786 85 109 869 NAND2_X1
* cell instance $465 m0 *1 24.89,18.2
X$465 85 70 412 115 109 DFF_X1
* cell instance $469 r0 *1 26.03,18.2
X$469 70 511 85 109 371 XOR2_X1
* cell instance $478 r0 *1 26.98,12.6
X$478 71 355 109 85 322 XNOR2_X1
* cell instance $480 m0 *1 25.08,15.4
X$480 85 301 115 2344 71 109 DFF_X2
* cell instance $483 m0 *1 29.26,12.6
X$483 242 184 71 109 85 271 AND3_X1
* cell instance $487 r0 *1 30.4,26.6
X$487 714 763 71 85 719 109 AOI21_X1
* cell instance $492 r0 *1 29.07,15.4
X$492 85 398 413 2391 72 109 DFF_X2
* cell instance $494 m0 *1 30.21,15.4
X$494 72 332 109 85 360 XNOR2_X1
* cell instance $497 m0 *1 30.21,12.6
X$497 271 244 72 85 109 293 NAND3_X1
* cell instance $501 r0 *1 30.78,29.4
X$501 714 763 72 85 913 109 AOI21_X1
* cell instance $510 r0 *1 30.78,1.4
X$510 73 85 109 95 CLKBUF_X2
* cell instance $513 m0 *1 30.21,4.2
X$513 85 73 118 97 109 DFF_X1
* cell instance $526 m0 *1 23.18,12.6
X$526 289 74 85 109 321 NOR2_X1
* cell instance $529 r0 *1 9.12,18.2
X$529 504 74 85 109 501 NOR2_X1
* cell instance $531 m0 *1 24.7,4.2
X$531 152 74 85 109 113 NOR2_X1
* cell instance $533 r0 *1 33.06,4.2
X$533 157 74 85 109 118 NOR2_X1
* cell instance $535 r0 *1 34.96,1.4
X$535 99 74 85 109 121 NOR2_X1
* cell instance $537 r0 *1 38.57,1.4
X$537 101 74 85 109 124 NOR2_X1
* cell instance $539 r0 *1 41.61,1.4
X$539 150 74 85 109 103 NOR2_X1
* cell instance $541 m0 *1 45.6,4.2
X$541 147 74 85 109 130 NOR2_X1
* cell instance $543 m0 *1 45.22,9.8
X$543 211 74 85 109 264 NOR2_X1
* cell instance $545 r0 *1 44.27,7
X$545 234 74 85 109 231 NOR2_X1
* cell instance $547 m0 *1 17.29,18.2
X$547 411 85 109 74 CLKBUF_X3
* cell instance $561 r0 *1 43.7,23.8
X$561 85 649 617 2432 75 109 DFF_X2
* cell instance $563 r0 *1 45.6,21
X$563 75 85 109 538 INV_X1
* cell instance $566 r0 *1 40.28,21
X$566 87 570 75 85 109 632 NAND3_X2
* cell instance $570 r0 *1 37.81,23.8
X$570 75 646 85 109 676 NAND2_X1
* cell instance $576 r0 *1 46.17,35
X$576 76 976 85 109 1046 NOR2_X1
* cell instance $578 r0 *1 46.17,29.4
X$578 76 931 109 85 871 XNOR2_X1
* cell instance $580 m0 *1 46.93,32.2
X$580 76 930 109 85 885 AND2_X1
* cell instance $582 m0 *1 46.93,35
X$582 76 194 930 109 85 1032 AND3_X2
* cell instance $584 m0 *1 43.7,29.4
X$584 85 840 617 2357 76 109 DFF_X2
* cell instance $588 m0 *1 47.69,12.6
X$588 85 77 324 132 109 DFF_X1
* cell instance $591 m0 *1 46.93,12.6
X$591 77 85 109 336 BUF_X2
* cell instance $597 m0 *1 48.64,21
X$597 78 85 109 570 CLKBUF_X2
* cell instance $600 r0 *1 49.21,21
X$600 85 78 605 335 109 DFF_X1
* cell instance $604 m0 *1 49.97,26.6
X$604 85 79 722 617 109 DFF_X1
* cell instance $607 r0 *1 52.06,26.6
X$607 79 85 109 773 BUF_X1
* cell instance $611 m0 *1 53.77,9.8
X$611 80 85 109 212 CLKBUF_X2
* cell instance $614 r0 *1 51.11,9.8
X$614 85 80 261 132 109 DFF_X1
* cell instance $618 r0 *1 57.57,12.6
X$618 81 85 109 295 CLKBUF_X2
* cell instance $622 m0 *1 55.29,15.4
X$622 85 81 405 169 109 DFF_X1
* cell instance $628 r0 *1 59.85,7
X$628 85 82 224 146 109 DFF_X1
* cell instance $630 m0 *1 61.56,9.8
X$630 82 85 109 250 BUF_X1
* cell instance $632 m0 *1 66.88,9.8
X$632 83 85 109 217 BUF_X2
* cell instance $635 r0 *1 63.08,7
X$635 85 83 189 146 109 DFF_X1
* cell instance $638 r0 *1 64.03,4.2
X$638 85 84 168 146 109 DFF_X1
* cell instance $640 m0 *1 66.31,7
X$640 84 85 109 190 BUF_X2
* cell instance $641 m0 *1 46.17,60.2
X$641 1858 1819 1691 109 1925 85 OAI21_X1
* cell instance $644 m0 *1 48.45,60.2
X$644 659 1859 85 109 1850 NAND2_X1
* cell instance $645 m0 *1 49.02,60.2
X$645 85 1890 1692 2341 1859 109 DFF_X2
* cell instance $646 m0 *1 52.63,60.2
X$646 1463 85 109 1692 CLKBUF_X3
* cell instance $648 m0 *1 53.77,60.2
X$648 1821 1861 1822 85 109 1775 NOR3_X1
* cell instance $649 m0 *1 54.53,60.2
X$649 1821 1862 1822 85 109 1504 NOR3_X1
* cell instance $651 m0 *1 56.05,60.2
X$651 1821 85 109 1823 BUF_X2
* cell instance $653 r0 *1 45.98,60.2
X$653 790 1923 1925 85 1934 109 AOI21_X1
* cell instance $656 r0 *1 50.54,60.2
X$656 1901 85 109 1951 INV_X1
* cell instance $660 r0 *1 53.01,60.2
X$660 1820 1901 85 109 1860 NAND2_X1
* cell instance $661 r0 *1 53.58,60.2
X$661 1862 1861 1891 1902 85 1949 109 NAND4_X2
* cell instance $663 r0 *1 55.67,60.2
X$663 85 1924 1692 1948 1919 109 DFF_X2
* cell instance $664 m0 *1 58.52,60.2
X$664 1821 1864 1822 109 1355 85 NOR3_X2
* cell instance $665 m0 *1 57.19,60.2
X$665 1821 1863 1822 109 1422 85 NOR3_X2
* cell instance $666 m0 *1 59.85,60.2
X$666 1821 1865 1866 109 1303 85 NOR3_X2
* cell instance $667 m0 *1 61.18,60.2
X$667 1296 1866 1919 109 1352 85 NOR3_X2
* cell instance $668 m0 *1 62.51,60.2
X$668 1866 85 109 1822 CLKBUF_X3
* cell instance $669 m0 *1 63.46,60.2
X$669 1296 1867 1727 109 1020 85 NOR3_X2
* cell instance $670 m0 *1 64.79,60.2
X$670 1866 109 1727 85 BUF_X4
* cell instance $671 m0 *1 66.12,60.2
X$671 1821 109 1745 85 BUF_X4
* cell instance $673 m0 *1 67.64,60.2
X$673 1745 1889 1826 85 109 1695 NOR3_X1
* cell instance $674 m0 *1 68.4,60.2
X$674 1866 85 109 1826 BUF_X2
* cell instance $679 r0 *1 59.28,60.2
X$679 85 1922 1670 2435 1889 109 DFF_X2
* cell instance $684 r0 *1 65.74,60.2
X$684 1903 109 1821 85 BUF_X4
* cell instance $687 r0 *1 68.02,60.2
X$687 1904 1903 85 109 1227 OR2_X1
* cell instance $688 r0 *1 68.78,60.2
X$688 1904 85 109 1866 INV_X2
* cell instance $690 m0 *1 70.87,60.2
X$690 1745 1883 1826 85 109 1206 NOR3_X1
* cell instance $691 m0 *1 69.54,60.2
X$691 1745 1887 1727 109 1148 85 NOR3_X2
* cell instance $694 r0 *1 71.63,60.2
X$694 1823 1905 1826 85 109 1728 NOR3_X1
* cell instance $695 m0 *1 72.77,60.2
X$695 1823 1881 1826 85 109 1743 NOR3_X1
* cell instance $696 m0 *1 72.01,60.2
X$696 1823 1906 1826 85 109 1623 NOR3_X1
* cell instance $698 r0 *1 72.39,60.2
X$698 1823 1966 1826 85 109 1521 NOR3_X1
* cell instance $699 r0 *1 73.15,60.2
X$699 1823 1882 1826 85 109 1625 NOR3_X1
* cell instance $700 m0 *1 74.1,60.2
X$700 1843 735 1869 1421 1841 85 109 1870 AOI221_X1
* cell instance $702 m0 *1 75.24,60.2
X$702 1668 85 109 1841 INV_X1
* cell instance $703 m0 *1 75.62,60.2
X$703 1840 732 1871 1421 1872 85 109 1876 AOI221_X1
* cell instance $704 m0 *1 76.76,60.2
X$704 928 1830 1832 85 1878 109 AOI21_X1
* cell instance $705 m0 *1 77.52,60.2
X$705 85 1831 1878 1670 109 DFF_X1
* cell instance $707 r0 *1 73.91,60.2
X$707 1823 1940 1826 85 109 1868 NOR3_X1
* cell instance $708 r0 *1 74.67,60.2
X$708 1823 1941 1822 85 109 1869 NOR3_X1
* cell instance $709 r0 *1 75.43,60.2
X$709 1823 1967 1822 85 109 1829 NOR3_X1
* cell instance $710 r0 *1 76.19,60.2
X$710 1823 1907 1822 85 109 1871 NOR3_X1
* cell instance $711 r0 *1 76.95,60.2
X$711 1833 85 109 1903 BUF_X1
* cell instance $712 r0 *1 77.52,60.2
X$712 1662 85 109 1834 BUF_X1
* cell instance $713 r0 *1 78.09,60.2
X$713 1726 85 109 1908 BUF_X1
* cell instance $714 r0 *1 78.66,60.2
X$714 1873 85 109 1904 BUF_X1
* cell instance $715 r0 *1 79.23,60.2
X$715 1694 85 109 1909 BUF_X1
* cell instance $716 r0 *1 79.8,60.2
X$716 1552 85 109 1783 BUF_X1
* cell instance $719 m0 *1 62.7,9.8
X$719 217 258 85 109 257 XOR2_X1
* cell instance $721 m0 *1 63.84,9.8
X$721 257 166 85 109 189 NOR2_X1
* cell instance $722 m0 *1 64.41,9.8
X$722 146 85 109 2438 INV_X1
* cell instance $723 m0 *1 64.79,9.8
X$723 190 287 85 109 218 XOR2_X1
* cell instance $724 m0 *1 65.93,9.8
X$724 263 85 109 146 CLKBUF_X3
* cell instance $726 r0 *1 62.51,9.8
X$726 291 251 252 219 85 109 258 NAND4_X1
* cell instance $729 r0 *1 65.36,9.8
X$729 306 255 251 252 85 109 287 NAND4_X1
* cell instance $732 r0 *1 67.26,9.8
X$732 291 109 255 85 BUF_X4
* cell instance $733 m0 *1 69.16,9.8
X$733 255 214 85 109 220 NAND2_X1
* cell instance $734 m0 *1 68.02,9.8
X$734 219 220 85 109 256 XOR2_X1
* cell instance $735 m0 *1 69.73,9.8
X$735 256 166 85 109 221 NOR2_X1
* cell instance $741 r0 *1 68.78,9.8
X$741 253 308 85 109 285 XOR2_X1
* cell instance $742 r0 *1 69.92,9.8
X$742 285 166 85 109 276 NOR2_X1
* cell instance $743 r0 *1 70.49,9.8
X$743 85 254 276 310 109 DFF_X1
* cell instance $744 r0 *1 73.72,9.8
X$744 254 85 109 253 BUF_X2
* cell instance $748 r0 *1 78.09,9.8
X$748 283 85 109 282 BUF_X1
* cell instance $750 r0 *1 78.85,9.8
X$750 254 85 109 279 BUF_X1
* cell instance $752 r0 *1 80.18,9.8
X$752 278 85 109 280 BUF_X1
* cell instance $756 m0 *1 60.8,54.6
X$756 1463 85 109 1620 CLKBUF_X3
* cell instance $758 m0 *1 61.75,54.6
X$758 1620 85 109 2439 INV_X1
* cell instance $759 m0 *1 62.13,54.6
X$759 1660 85 109 1270 INV_X1
* cell instance $762 m0 *1 65.74,54.6
X$762 85 1661 1671 1670 109 DFF_X1
* cell instance $764 m0 *1 69.16,54.6
X$764 85 1621 1670 2371 1662 109 DFF_X2
* cell instance $765 m0 *1 72.77,54.6
X$765 1662 85 109 1624 INV_X1
* cell instance $767 m0 *1 73.91,54.6
X$767 1472 1662 85 109 1626 NAND2_X1
* cell instance $769 r0 *1 60.61,54.6
X$769 1660 1726 1798 109 85 1706 HA_X1
* cell instance $770 r0 *1 62.51,54.6
X$770 85 1746 1620 2415 1726 109 DFF_X2
* cell instance $774 r0 *1 67.45,54.6
X$774 1296 109 1134 85 BUF_X4
* cell instance $776 r0 *1 68.97,54.6
X$776 1726 85 109 1704 INV_X1
* cell instance $777 r0 *1 69.35,54.6
X$777 1744 448 85 109 1671 NOR2_X1
* cell instance $778 r0 *1 69.92,54.6
X$778 1661 1669 109 85 1744 XNOR2_X1
* cell instance $781 r0 *1 71.63,54.6
X$781 742 1702 1743 1134 1624 1740 109 85 AOI221_X2
* cell instance $783 r0 *1 74.1,54.6
X$783 1424 85 109 1696 BUF_X1
* cell instance $784 r0 *1 74.67,54.6
X$784 1660 85 109 1664 BUF_X1
* cell instance $785 m0 *1 75.05,54.6
X$785 1472 1668 1628 1662 85 109 1639 NAND4_X1
* cell instance $787 m0 *1 76,54.6
X$787 1472 1628 1662 85 109 1630 NAND3_X1
* cell instance $789 m0 *1 76.95,54.6
X$789 1630 1377 1668 109 1663 85 OAI21_X1
* cell instance $792 r0 *1 75.24,54.6
X$792 1628 85 109 1729 INV_X1
* cell instance $794 r0 *1 76.38,54.6
X$794 1668 1377 1630 85 109 1731 OR3_X1
* cell instance $796 r0 *1 77.52,54.6
X$796 85 1668 1732 1670 109 DFF_X1
* cell instance $798 m0 *1 78.85,54.6
X$798 1632 85 109 1628 BUF_X1
* cell instance $799 m0 *1 79.61,54.6
X$799 1515 85 109 1595 BUF_X1
* cell instance $800 m0 *1 80.18,54.6
X$800 1378 85 109 1634 BUF_X1
* cell instance $803 m0 *1 12.16,43.4
X$803 1258 1163 85 109 1292 NAND2_X1
* cell instance $804 m0 *1 11.4,43.4
X$804 1258 1319 1320 85 109 1289 NAND3_X1
* cell instance $805 m0 *1 12.73,43.4
X$805 1292 1321 1323 85 109 1290 NOR3_X1
* cell instance $806 m0 *1 13.49,43.4
X$806 1099 1290 109 85 1286 XNOR2_X1
* cell instance $810 m0 *1 9.69,43.4
X$810 1255 1253 1254 1193 109 85 1258 AND4_X2
* cell instance $811 r0 *1 9.69,43.4
X$811 1313 85 109 1291 CLKBUF_X3
* cell instance $814 r0 *1 12.54,43.4
X$814 1367 443 1343 85 1324 109 AOI21_X1
* cell instance $815 r0 *1 13.3,43.4
X$815 822 1368 1291 1221 1253 1344 109 85 AOI221_X2
* cell instance $816 r0 *1 15.39,43.4
X$816 1258 1319 85 1078 109 NAND2_X4
* cell instance $817 m0 *1 15.96,43.4
X$817 1319 1258 109 85 1260 AND2_X1
* cell instance $820 r0 *1 17.1,43.4
X$820 1397 1252 85 109 1345 NOR2_X1
* cell instance $821 m0 *1 17.29,43.4
X$821 1081 1078 1259 85 109 1164 NOR3_X1
* cell instance $823 m0 *1 18.05,43.4
X$823 999 85 109 1259 INV_X1
* cell instance $825 r0 *1 17.67,43.4
X$825 1259 1123 109 85 1397 XNOR2_X1
* cell instance $826 m0 *1 19.57,43.4
X$826 1221 1119 1347 85 1117 109 AOI21_X1
* cell instance $827 m0 *1 18.81,43.4
X$827 1221 1119 1346 85 1295 109 AOI21_X1
* cell instance $828 m0 *1 20.33,43.4
X$828 1221 1119 1348 85 1165 109 AOI21_X1
* cell instance $831 r0 *1 19,43.4
X$831 1325 85 109 999 CLKBUF_X2
* cell instance $833 r0 *1 19.95,43.4
X$833 1367 85 109 1166 CLKBUF_X3
* cell instance $835 r0 *1 21.09,43.4
X$835 1291 109 998 85 BUF_X4
* cell instance $837 m0 *1 21.47,43.4
X$837 1221 1371 1119 85 1349 109 AOI21_X1
* cell instance $839 m0 *1 22.8,43.4
X$839 826 1349 998 1372 1000 1311 109 85 AOI221_X2
* cell instance $842 m0 *1 25.08,43.4
X$842 1351 1260 1220 85 109 1302 NAND3_X1
* cell instance $844 m0 *1 26.03,43.4
X$844 1261 1302 85 109 1350 XOR2_X1
* cell instance $845 m0 *1 27.17,43.4
X$845 85 1080 1222 1261 1264 1453 109 NAND4_X4
* cell instance $849 r0 *1 23.75,43.4
X$849 1291 109 1169 85 BUF_X4
* cell instance $852 r0 *1 26.22,43.4
X$852 1373 85 109 1261 BUF_X2
* cell instance $853 r0 *1 26.98,43.4
X$853 1350 971 85 109 1326 NOR2_X1
* cell instance $857 r0 *1 30.02,43.4
X$857 1262 1081 1078 85 109 1356 NOR3_X1
* cell instance $858 r0 *1 30.78,43.4
X$858 1263 971 85 109 1358 NOR2_X1
* cell instance $859 m0 *1 31.92,43.4
X$859 85 1358 1043 2370 1264 109 DFF_X2
* cell instance $860 m0 *1 30.97,43.4
X$860 1354 85 109 1043 CLKBUF_X3
* cell instance $866 r0 *1 31.54,43.4
X$866 1043 85 109 CLKBUF_X1
* cell instance $869 m0 *1 42.18,43.4
X$869 1224 1266 85 109 1312 NOR2_X1
* cell instance $870 m0 *1 41.23,43.4
X$870 978 1311 1312 85 109 1301 OR3_X1
* cell instance $871 m0 *1 42.75,43.4
X$871 1224 85 109 1327 CLKBUF_X3
* cell instance $873 m0 *1 43.89,43.4
X$873 1173 1327 85 109 1308 NOR2_X1
* cell instance $875 m0 *1 44.65,43.4
X$875 808 1344 1308 85 109 1353 OR3_X1
* cell instance $879 r0 *1 43.13,43.4
X$879 873 1327 85 109 1407 NOR2_X1
* cell instance $882 r0 *1 45.6,43.4
X$882 85 1032 1267 1328 842 1406 109 NAND4_X4
* cell instance $884 m0 *1 45.98,43.4
X$884 85 1032 1267 1247 842 1819 109 NAND4_X4
* cell instance $885 m0 *1 49.59,43.4
X$885 1271 1174 1330 1246 109 85 1267 AND4_X2
* cell instance $888 r0 *1 49.21,43.4
X$888 1330 1129 85 109 1268 NOR2_X1
* cell instance $889 r0 *1 49.78,43.4
X$889 1271 85 109 844 CLKBUF_X3
* cell instance $890 r0 *1 50.73,43.4
X$890 844 1327 85 109 1405 NOR2_X1
* cell instance $891 m0 *1 52.44,43.4
X$891 1269 487 85 109 1359 NOR2_X1
* cell instance $892 m0 *1 51.3,43.4
X$892 844 841 109 85 1269 XNOR2_X1
* cell instance $894 m0 *1 53.2,43.4
X$894 85 1271 1359 1177 109 DFF_X1
* cell instance $895 m0 *1 56.43,43.4
X$895 1463 85 109 1177 CLKBUF_X3
* cell instance $896 m0 *1 57.38,43.4
X$896 1177 85 109 CLKBUF_X1
* cell instance $899 r0 *1 51.3,43.4
X$899 1032 842 841 844 85 109 1404 NAND4_X1
* cell instance $902 r0 *1 52.82,43.4
X$902 1329 1404 1330 109 1360 85 OAI21_X1
* cell instance $904 r0 *1 53.77,43.4
X$904 85 1402 1177 2405 1330 109 DFF_X2
* cell instance $909 m0 *1 59.28,43.4
X$909 1132 1353 1355 1296 1331 1287 109 85 AOI221_X2
* cell instance $911 m0 *1 61.37,43.4
X$911 810 1301 1352 979 1270 1338 109 85 AOI221_X2
* cell instance $913 m0 *1 63.65,43.4
X$913 1332 390 1272 85 109 1333 NAND3_X2
* cell instance $915 m0 *1 65.17,43.4
X$915 1333 1376 1273 85 109 1274 NOR3_X1
* cell instance $920 r0 *1 60.99,43.4
X$920 1272 85 109 1331 INV_X1
* cell instance $924 r0 *1 63.84,43.4
X$924 1272 1375 109 85 1398 XNOR2_X1
* cell instance $925 r0 *1 64.98,43.4
X$925 85 1335 1334 1277 109 DFF_X1
* cell instance $927 m0 *1 67.83,43.4
X$927 1203 1275 109 85 1336 XNOR2_X1
* cell instance $928 r0 *1 68.21,43.4
X$928 1335 85 109 1272 CLKBUF_X2
* cell instance $929 r0 *1 68.97,43.4
X$929 1336 721 85 109 1337 NOR2_X1
* cell instance $930 m0 *1 72.58,43.4
X$930 1278 85 109 1203 BUF_X2
* cell instance $931 m0 *1 69.35,43.4
X$931 85 1278 1337 1277 109 DFF_X1
* cell instance $937 r0 *1 73.53,43.4
X$937 1229 935 891 85 109 1377 NAND3_X2
* cell instance $938 m0 *1 74.67,43.4
X$938 1287 85 109 1280 BUF_X1
* cell instance $943 r0 *1 75.05,43.4
X$943 85 1381 1342 1277 109 DFF_X1
* cell instance $944 m0 *1 76.57,43.4
X$944 1278 85 109 1341 BUF_X1
* cell instance $946 m0 *1 77.14,43.4
X$946 1271 85 109 1279 BUF_X1
* cell instance $950 m0 *1 80.18,43.4
X$950 1285 85 109 1281 BUF_X1
* cell instance $951 m0 *1 79.61,43.4
X$951 1338 85 109 1340 BUF_X1
* cell instance $956 m0 *1 13.68,9.8
X$956 177 199 85 109 238 NAND2_X1
* cell instance $958 m0 *1 14.25,9.8
X$958 238 179 144 85 109 223 NOR3_X1
* cell instance $959 m0 *1 15.01,9.8
X$959 238 179 203 202 85 109 201 NOR4_X1
* cell instance $960 m0 *1 15.96,9.8
X$960 193 85 109 202 INV_X1
* cell instance $963 m0 *1 17.29,9.8
X$963 206 85 109 200 CLKBUF_X3
* cell instance $964 m0 *1 18.24,9.8
X$964 200 85 109 CLKBUF_X1
* cell instance $968 m0 *1 21.28,9.8
X$968 203 85 109 143 CLKBUF_X3
* cell instance $971 m0 *1 23.18,9.8
X$971 204 210 239 205 85 109 290 NOR4_X1
* cell instance $973 m0 *1 25.65,9.8
X$973 206 85 109 115 CLKBUF_X3
* cell instance $975 m0 *1 28.12,9.8
X$975 262 156 210 143 85 109 230 NOR4_X1
* cell instance $976 m0 *1 29.07,9.8
X$976 244 242 85 109 262 NAND2_X1
* cell instance $977 m0 *1 29.64,9.8
X$977 242 207 109 85 208 XNOR2_X1
* cell instance $978 m0 *1 30.78,9.8
X$978 208 183 85 109 209 NOR2_X1
* cell instance $979 m0 *1 31.35,9.8
X$979 96 85 109 242 CLKBUF_X2
* cell instance $981 m0 *1 32.87,9.8
X$981 154 95 140 85 109 245 NAND3_X1
* cell instance $982 m0 *1 33.63,9.8
X$982 85 139 109 210 BUF_X8
* cell instance $983 m0 *1 36.1,9.8
X$983 97 85 109 CLKBUF_X1
* cell instance $985 m0 *1 36.86,9.8
X$985 142 210 203 246 85 109 235 NOR4_X1
* cell instance $986 m0 *1 37.81,9.8
X$986 131 85 109 246 INV_X1
* cell instance $988 m0 *1 38.95,9.8
X$988 161 235 109 85 234 XNOR2_X1
* cell instance $1002 r0 *1 3.42,9.8
X$1002 237 85 109 265 BUF_X1
* cell instance $1005 r0 *1 5.89,9.8
X$1005 85 237 267 236 109 DFF_X1
* cell instance $1006 r0 *1 9.12,9.8
X$1006 237 85 109 326 BUF_X2
* cell instance $1009 m0 *1 10.83,9.8
X$1009 179 144 85 109 198 NOR2_X1
* cell instance $1010 m0 *1 11.59,9.8
X$1010 199 198 109 85 316 XNOR2_X1
* cell instance $1011 m0 *1 12.73,9.8
X$1011 199 85 109 180 INV_X1
* cell instance $1017 r0 *1 16.91,9.8
X$1017 85 91 270 200 109 DFF_X1
* cell instance $1021 r0 *1 24.7,9.8
X$1021 85 116 241 115 109 DFF_X1
* cell instance $1022 r0 *1 27.93,9.8
X$1022 116 294 109 85 240 XNOR2_X1
* cell instance $1023 r0 *1 29.07,9.8
X$1023 240 183 85 109 241 NOR2_X1
* cell instance $1024 r0 *1 29.64,9.8
X$1024 244 85 109 243 INV_X1
* cell instance $1025 r0 *1 30.02,9.8
X$1025 243 156 210 239 85 109 207 NOR4_X1
* cell instance $1027 r0 *1 31.73,9.8
X$1027 140 95 154 86 109 85 244 AND4_X1
* cell instance $1028 r0 *1 32.87,9.8
X$1028 245 156 139 143 85 109 273 NOR4_X1
* cell instance $1031 r0 *1 41.42,9.8
X$1031 85 264 132 2413 129 109 DFF_X2
* cell instance $1032 m0 *1 42.18,9.8
X$1032 161 131 85 109 247 NAND2_X1
* cell instance $1034 m0 *1 42.75,9.8
X$1034 247 142 139 144 85 109 233 NOR4_X1
* cell instance $1036 m0 *1 44.08,9.8
X$1036 129 233 109 85 211 XNOR2_X1
* cell instance $1039 m0 *1 46.74,9.8
X$1039 263 85 109 132 CLKBUF_X3
* cell instance $1040 m0 *1 47.69,9.8
X$1040 132 85 109 CLKBUF_X1
* cell instance $1045 m0 *1 54.53,9.8
X$1045 260 213 85 109 229 NOR2_X1
* cell instance $1047 m0 *1 55.29,9.8
X$1047 187 259 85 109 260 XOR2_X1
* cell instance $1049 m0 *1 56.62,9.8
X$1049 214 187 215 85 109 227 NAND3_X1
* cell instance $1051 m0 *1 60.42,9.8
X$1051 249 166 85 109 224 NOR2_X1
* cell instance $1054 r0 *1 54.34,9.8
X$1054 248 213 85 109 261 NOR2_X1
* cell instance $1055 r0 *1 54.91,9.8
X$1055 212 274 85 109 248 XOR2_X1
* cell instance $1057 r0 *1 56.43,9.8
X$1057 251 252 215 85 109 259 NAND3_X1
* cell instance $1062 r0 *1 60.23,9.8
X$1062 250 292 85 109 249 XOR2_X1
* cell instance $1067 m0 *1 4.56,18.2
X$1067 85 440 461 236 109 DFF_X1
* cell instance $1068 m0 *1 3.99,18.2
X$1068 368 85 109 427 BUF_X1
* cell instance $1069 m0 *1 8.36,18.2
X$1069 85 428 463 236 109 DFF_X1
* cell instance $1070 m0 *1 11.59,18.2
X$1070 464 268 85 109 463 NOR2_X1
* cell instance $1072 m0 *1 15.2,18.2
X$1072 409 268 85 109 410 NOR2_X1
* cell instance $1086 r0 *1 1.33,18.2
X$1086 440 85 109 476 BUF_X1
* cell instance $1088 r0 *1 2.09,18.2
X$1088 439 85 109 477 BUF_X1
* cell instance $1090 r0 *1 2.85,18.2
X$1090 85 439 501 236 109 DFF_X1
* cell instance $1095 r0 *1 6.27,18.2
X$1095 440 85 109 478 BUF_X2
* cell instance $1097 r0 *1 7.22,18.2
X$1097 439 85 109 527 BUF_X2
* cell instance $1102 r0 *1 10.26,18.2
X$1102 428 109 367 85 BUF_X4
* cell instance $1106 r0 *1 14.25,18.2
X$1106 85 410 441 2426 529 109 DFF_X2
* cell instance $1108 r0 *1 18.24,18.2
X$1108 411 85 109 268 CLKBUF_X3
* cell instance $1110 r0 *1 19.95,18.2
X$1110 443 442 300 85 469 109 AOI21_X1
* cell instance $1112 r0 *1 21.47,18.2
X$1112 443 442 111 85 481 109 AOI21_X1
* cell instance $1113 r0 *1 22.23,18.2
X$1113 443 442 138 85 444 109 AOI21_X1
* cell instance $1114 r0 *1 22.99,18.2
X$1114 443 442 137 85 470 109 AOI21_X1
* cell instance $1115 r0 *1 23.75,18.2
X$1115 112 482 85 109 445 NAND2_X1
* cell instance $1118 r0 *1 24.89,18.2
X$1118 415 482 85 109 446 NAND2_X1
* cell instance $1119 r0 *1 25.46,18.2
X$1119 336 482 85 109 510 NAND2_X1
* cell instance $1122 r0 *1 28.31,18.2
X$1122 473 447 414 373 85 109 511 NAND4_X1
* cell instance $1124 r0 *1 29.45,18.2
X$1124 483 484 513 85 109 473 NOR3_X1
* cell instance $1126 r0 *1 30.4,18.2
X$1126 85 517 413 2390 119 109 DFF_X2
* cell instance $1127 m0 *1 34.96,18.2
X$1127 85 159 449 413 109 DFF_X1
* cell instance $1128 m0 *1 33.82,18.2
X$1128 119 518 85 109 516 XOR2_X1
* cell instance $1132 r0 *1 34.39,18.2
X$1132 516 448 85 109 517 NOR2_X1
* cell instance $1134 r0 *1 35.72,18.2
X$1134 486 448 85 109 449 NOR2_X1
* cell instance $1136 r0 *1 36.67,18.2
X$1136 159 85 109 485 BUF_X1
* cell instance $1139 r0 *1 38.38,18.2
X$1139 149 85 109 489 BUF_X1
* cell instance $1140 r0 *1 38.95,18.2
X$1140 85 149 522 413 109 DFF_X1
* cell instance $1141 m0 *1 40.28,18.2
X$1141 415 523 85 109 474 XOR2_X1
* cell instance $1143 m0 *1 41.42,18.2
X$1143 474 375 85 109 333 NOR2_X1
* cell instance $1144 m0 *1 41.99,18.2
X$1144 414 109 377 85 BUF_X4
* cell instance $1145 m0 *1 43.32,18.2
X$1145 372 376 415 112 109 85 450 AND4_X1
* cell instance $1148 m0 *1 46.17,18.2
X$1148 450 414 373 336 85 109 416 NAND4_X1
* cell instance $1150 m0 *1 47.31,18.2
X$1150 378 85 109 213 CLKBUF_X3
* cell instance $1152 r0 *1 42.18,18.2
X$1152 85 415 112 372 376 587 109 NAND4_X4
* cell instance $1153 r0 *1 45.6,18.2
X$1153 336 114 450 109 85 490 AND3_X1
* cell instance $1156 r0 *1 47.12,18.2
X$1156 490 377 437 85 109 520 NAND3_X1
* cell instance $1157 r0 *1 47.88,18.2
X$1157 452 520 85 109 451 XOR2_X1
* cell instance $1158 m0 *1 51.87,18.2
X$1158 335 85 109 CLKBUF_X1
* cell instance $1159 m0 *1 48.64,18.2
X$1159 85 107 417 335 109 DFF_X1
* cell instance $1161 r0 *1 49.02,18.2
X$1161 451 382 85 109 417 NOR2_X1
* cell instance $1162 r0 *1 49.59,18.2
X$1162 378 85 109 375 CLKBUF_X3
* cell instance $1163 r0 *1 50.54,18.2
X$1163 378 109 448 85 BUF_X4
* cell instance $1165 m0 *1 56.43,18.2
X$1165 295 454 85 109 419 XOR2_X1
* cell instance $1166 m0 *1 52.82,18.2
X$1166 85 418 335 2365 296 109 DFF_X2
* cell instance $1169 r0 *1 53.77,18.2
X$1169 515 213 85 109 418 NOR2_X1
* cell instance $1170 r0 *1 54.34,18.2
X$1170 296 514 109 85 515 XNOR2_X1
* cell instance $1171 r0 *1 55.48,18.2
X$1171 212 295 85 109 453 NAND2_X1
* cell instance $1172 r0 *1 56.05,18.2
X$1172 453 454 85 109 514 NOR2_X1
* cell instance $1174 r0 *1 57.38,18.2
X$1174 215 187 216 109 85 455 AND3_X1
* cell instance $1175 m0 *1 58.14,18.2
X$1175 85 420 169 2355 317 109 DFF_X2
* cell instance $1178 m0 *1 62.51,18.2
X$1178 472 166 85 109 512 NOR2_X1
* cell instance $1180 r0 *1 58.33,18.2
X$1180 455 251 252 85 109 456 NAND3_X1
* cell instance $1188 r0 *1 61.94,18.2
X$1188 85 467 512 169 109 DFF_X1
* cell instance $1189 m0 *1 63.65,18.2
X$1189 85 305 190 219 217 509 109 NAND4_X4
* cell instance $1191 m0 *1 67.07,18.2
X$1191 457 434 109 85 472 XNOR2_X1
* cell instance $1194 r0 *1 65.17,18.2
X$1194 509 457 85 109 354 NOR2_X2
* cell instance $1195 r0 *1 66.12,18.2
X$1195 85 457 509 493 459 397 109 NOR4_X4
* cell instance $1196 m0 *1 69.92,18.2
X$1196 421 85 109 458 INV_X1
* cell instance $1197 m0 *1 69.35,18.2
X$1197 493 458 85 109 471 NOR2_X1
* cell instance $1199 r0 *1 69.54,18.2
X$1199 471 354 255 214 85 109 508 NAND4_X1
* cell instance $1200 r0 *1 70.49,18.2
X$1200 423 508 85 109 422 XOR2_X1
* cell instance $1201 m0 *1 70.87,18.2
X$1201 422 382 85 109 380 NOR2_X1
* cell instance $1206 r0 *1 73.15,18.2
X$1206 653 397 255 214 85 109 507 NAND4_X1
* cell instance $1208 m0 *1 73.53,18.2
X$1208 389 352 432 85 109 431 OR3_X1
* cell instance $1209 m0 *1 74.48,18.2
X$1209 432 352 389 109 466 85 OAI21_X1
* cell instance $1210 m0 *1 75.24,18.2
X$1210 495 431 466 85 465 109 AOI21_X1
* cell instance $1211 m0 *1 76,18.2
X$1211 85 384 465 310 109 DFF_X1
* cell instance $1212 m0 *1 79.23,18.2
X$1212 384 85 109 460 BUF_X1
* cell instance $1214 r0 *1 74.1,18.2
X$1214 622 397 255 214 85 109 506 NAND4_X1
* cell instance $1217 r0 *1 75.62,18.2
X$1217 467 85 109 499 BUF_X1
* cell instance $1218 r0 *1 76.19,18.2
X$1218 424 85 109 551 BUF_X1
* cell instance $1219 r0 *1 76.76,18.2
X$1219 85 424 496 310 109 DFF_X1
* cell instance $1221 r0 *1 80.18,18.2
X$1221 505 85 109 500 BUF_X1
* cell instance $1223 m0 *1 80.18,18.2
X$1223 424 85 109 462 BUF_X1
* cell instance $1225 m0 *1 69.16,79.8
X$1225 85 2268 2267 2096 109 DFF_X1
* cell instance $1227 m0 *1 72.39,79.8
X$1227 2268 85 109 2280 BUF_X1
* cell instance $1245 m0 *1 35.34,79.8
X$1245 2065 85 109 2324 BUF_X1
* cell instance $1246 m0 *1 36.1,79.8
X$1246 2263 85 109 2327 BUF_X1
* cell instance $1249 m0 *1 37.62,79.8
X$1249 2152 85 109 2326 BUF_X1
* cell instance $1251 m0 *1 38.95,79.8
X$1251 2332 85 109 1816 CLKBUF_X2
* cell instance $1252 m0 *1 39.71,79.8
X$1252 1499 85 109 2325 BUF_X1
* cell instance $1254 m0 *1 40.47,79.8
X$1254 1857 85 109 2323 BUF_X1
* cell instance $1257 m0 *1 60.04,79.8
X$1257 1779 85 109 2293 BUF_X1
* cell instance $1258 m0 *1 60.8,79.8
X$1258 1889 85 109 2292 BUF_X1
* cell instance $1261 m0 *1 48.45,79.8
X$1261 1548 85 109 2315 BUF_X1
* cell instance $1262 m0 *1 49.21,79.8
X$1262 2334 85 109 1901 BUF_X1
* cell instance $1263 m0 *1 49.78,79.8
X$1263 1862 85 109 2310 BUF_X1
* cell instance $1264 m0 *1 50.35,79.8
X$1264 1861 85 109 2312 BUF_X1
* cell instance $1265 m0 *1 50.92,79.8
X$1265 2213 85 109 2307 BUF_X1
* cell instance $1267 m0 *1 52.25,79.8
X$1267 1902 85 109 2306 BUF_X1
* cell instance $1268 m0 *1 52.82,79.8
X$1268 1807 85 109 2335 BUF_X1
* cell instance $1271 m0 *1 3.42,57.4
X$1271 1736 183 85 109 1759 NOR2_X1
* cell instance $1272 m0 *1 4.18,57.4
X$1272 1713 1737 109 85 1736 XNOR2_X1
* cell instance $1274 m0 *1 5.51,57.4
X$1274 1712 85 109 1713 INV_X1
* cell instance $1275 m0 *1 5.89,57.4
X$1275 1761 1713 85 109 1738 NOR2_X1
* cell instance $1276 m0 *1 6.46,57.4
X$1276 85 1760 1714 1712 1680 1893 109 NAND4_X4
* cell instance $1279 m0 *1 10.83,57.4
X$1279 1714 85 109 1742 INV_X1
* cell instance $1280 m0 *1 11.21,57.4
X$1280 1787 85 109 1763 BUF_X2
* cell instance $1283 m0 *1 1.33,57.4
X$1283 1679 85 109 1651 BUF_X1
* cell instance $1285 m0 *1 1.9,57.4
X$1285 1717 85 109 1711 BUF_X1
* cell instance $1286 m0 *1 2.47,57.4
X$1286 1784 85 109 1710 BUF_X1
* cell instance $1289 r0 *1 1.33,57.4
X$1289 85 1759 1716 2433 1712 109 DFF_X2
* cell instance $1293 r0 *1 4.94,57.4
X$1293 1760 1837 109 85 1875 XNOR2_X1
* cell instance $1294 r0 *1 6.08,57.4
X$1294 1810 1737 85 109 1837 NOR2_X1
* cell instance $1295 r0 *1 6.65,57.4
X$1295 1680 1712 85 109 1810 NAND2_X1
* cell instance $1297 r0 *1 7.41,57.4
X$1297 1760 85 109 1578 INV_X1
* cell instance $1300 r0 *1 8.36,57.4
X$1300 85 1839 1716 2436 1714 109 DFF_X2
* cell instance $1301 r0 *1 11.97,57.4
X$1301 1763 1811 567 1762 85 1737 109 NAND4_X2
* cell instance $1303 m0 *1 13.11,57.4
X$1303 1717 1766 1788 109 85 1762 HA_X1
* cell instance $1304 r0 *1 13.68,57.4
X$1304 85 1763 1764 565 1811 1761 109 NAND4_X4
* cell instance $1306 m0 *1 15.39,57.4
X$1306 1717 1766 109 85 1764 AND2_X1
* cell instance $1307 m0 *1 16.72,57.4
X$1307 85 1715 1716 1790 1717 109 DFF_X2
* cell instance $1310 r0 *1 17.1,57.4
X$1310 1788 1765 1766 85 109 1842 MUX2_X1
* cell instance $1313 r0 *1 19,57.4
X$1313 803 1842 109 85 1812 AND2_X1
* cell instance $1315 m0 *1 20.9,57.4
X$1315 85 1784 1748 1370 109 DFF_X1
* cell instance $1317 m0 *1 24.13,57.4
X$1317 1766 85 109 1487 INV_X1
* cell instance $1318 m0 *1 24.51,57.4
X$1318 1718 803 109 85 1791 AND2_X1
* cell instance $1319 m0 *1 25.27,57.4
X$1319 1719 1749 1791 85 109 1748 MUX2_X1
* cell instance $1321 m0 *1 26.79,57.4
X$1321 1768 1583 1769 1718 85 109 1792 NAND4_X1
* cell instance $1323 m0 *1 27.93,57.4
X$1323 1720 803 109 85 1793 AND2_X1
* cell instance $1325 m0 *1 29.45,57.4
X$1325 1615 1486 1794 85 1770 109 AOI21_X1
* cell instance $1327 m0 *1 30.4,57.4
X$1327 915 1795 1390 1393 1720 1756 109 85 AOI221_X2
* cell instance $1328 m0 *1 32.49,57.4
X$1328 1615 1486 1796 85 1755 109 AOI21_X1
* cell instance $1332 r0 *1 22.99,57.4
X$1332 1767 85 109 1200 INV_X1
* cell instance $1333 r0 *1 23.37,57.4
X$1333 803 85 109 724 CLKBUF_X3
* cell instance $1336 r0 *1 25.46,57.4
X$1336 1815 85 109 803 BUF_X2
* cell instance $1338 r0 *1 26.41,57.4
X$1338 1844 1792 1793 85 109 1880 MUX2_X1
* cell instance $1339 r0 *1 27.74,57.4
X$1339 1682 1720 85 109 1844 NOR2_X1
* cell instance $1341 r0 *1 28.5,57.4
X$1341 1768 1720 1769 1718 85 109 1846 NAND4_X1
* cell instance $1342 r0 *1 29.45,57.4
X$1342 918 1770 1390 1393 1769 1771 109 85 AOI221_X2
* cell instance $1343 r0 *1 31.54,57.4
X$1343 1615 1486 1961 85 1795 109 AOI21_X1
* cell instance $1345 r0 *1 32.68,57.4
X$1345 1615 1486 1990 85 1797 109 AOI21_X1
* cell instance $1346 r0 *1 33.44,57.4
X$1346 876 1797 1390 1393 1814 1802 109 85 AOI221_X2
* cell instance $1347 m0 *1 35.72,57.4
X$1347 1772 1686 85 109 1800 NOR2_X1
* cell instance $1348 m0 *1 34.39,57.4
X$1348 1799 1687 1800 85 109 1721 MUX2_X1
* cell instance $1352 m0 *1 38.76,57.4
X$1352 839 85 109 1682 CLKBUF_X3
* cell instance $1353 m0 *1 39.71,57.4
X$1353 839 85 109 1772 CLKBUF_X3
* cell instance $1355 m0 *1 40.85,57.4
X$1355 839 109 928 85 BUF_X4
* cell instance $1357 m0 *1 42.37,57.4
X$1357 1457 1756 1773 85 109 1789 OR3_X1
* cell instance $1360 m0 *1 45.03,57.4
X$1360 1803 213 85 109 1754 NOR2_X1
* cell instance $1362 m0 *1 45.79,57.4
X$1362 1457 1708 1722 85 109 1778 OR3_X1
* cell instance $1363 m0 *1 46.74,57.4
X$1363 1723 1129 85 109 1722 NOR2_X1
* cell instance $1364 m0 *1 47.31,57.4
X$1364 1982 1129 85 109 1752 NOR2_X1
* cell instance $1367 m0 *1 48.83,57.4
X$1367 1724 1129 85 109 1751 NOR2_X1
* cell instance $1369 m0 *1 50.92,57.4
X$1369 565 109 567 85 BUF_X4
* cell instance $1370 m0 *1 52.25,57.4
X$1370 758 1750 1775 1421 1672 1807 109 85 AOI221_X2
* cell instance $1372 r0 *1 35.53,57.4
X$1372 1814 1815 109 85 1885 AND2_X1
* cell instance $1377 r0 *1 39.14,57.4
X$1377 1816 552 85 109 839 NAND2_X2
* cell instance $1378 r0 *1 40.09,57.4
X$1378 1816 85 109 612 INV_X4
* cell instance $1381 r0 *1 41.61,57.4
X$1381 1457 1802 1817 85 109 1840 OR3_X1
* cell instance $1382 r0 *1 42.56,57.4
X$1382 1457 1771 1848 85 109 1843 OR3_X1
* cell instance $1385 r0 *1 44.08,57.4
X$1385 1818 1819 109 85 1803 XNOR2_X1
* cell instance $1389 r0 *1 49.21,57.4
X$1389 552 1901 85 109 1774 NAND2_X1
* cell instance $1390 r0 *1 49.78,57.4
X$1390 612 1774 1850 85 1890 109 AOI21_X1
* cell instance $1394 r0 *1 51.87,57.4
X$1394 1692 85 109 CLKBUF_X1
* cell instance $1397 r0 *1 54.34,57.4
X$1397 1821 1820 1822 85 109 1459 NOR3_X1
* cell instance $1398 m0 *1 56.81,57.4
X$1398 1776 1725 109 85 1801 XNOR2_X1
* cell instance $1399 m0 *1 54.72,57.4
X$1399 862 1806 1805 1421 1776 1804 109 85 AOI221_X2
* cell instance $1400 m0 *1 57.95,57.4
X$1400 1694 85 109 1776 INV_X1
* cell instance $1402 r0 *1 55.1,57.4
X$1402 1823 1891 1822 85 109 1805 NOR3_X1
* cell instance $1405 r0 *1 56.43,57.4
X$1405 1821 1902 1822 109 1477 85 NOR3_X2
* cell instance $1406 r0 *1 57.76,57.4
X$1406 85 1777 1620 2412 1694 109 DFF_X2
* cell instance $1407 m0 *1 59.28,57.4
X$1407 1726 1591 1798 85 109 1747 MUX2_X1
* cell instance $1408 m0 *1 58.71,57.4
X$1408 1801 589 85 109 1777 NOR2_X1
* cell instance $1410 m0 *1 60.8,57.4
X$1410 724 1747 109 85 1746 AND2_X1
* cell instance $1413 m0 *1 62.51,57.4
X$1413 1296 1779 1727 109 1021 85 NOR3_X2
* cell instance $1415 m0 *1 64.03,57.4
X$1415 1745 1849 1727 109 963 85 NOR3_X2
* cell instance $1418 m0 *1 66.31,57.4
X$1418 1745 1780 1727 109 1226 85 NOR3_X2
* cell instance $1425 r0 *1 61.56,57.4
X$1425 1296 1824 1727 109 1299 85 NOR3_X2
* cell instance $1426 r0 *1 62.89,57.4
X$1426 1296 1918 1727 109 1298 85 NOR3_X2
* cell instance $1427 r0 *1 64.22,57.4
X$1427 1821 109 1296 85 BUF_X4
* cell instance $1429 r0 *1 65.74,57.4
X$1429 1296 109 1421 85 BUF_X4
* cell instance $1431 r0 *1 67.26,57.4
X$1431 1745 1825 1727 109 959 85 NOR3_X2
* cell instance $1432 r0 *1 68.59,57.4
X$1432 1745 1827 1727 109 1276 85 NOR3_X2
* cell instance $1433 m0 *1 69.73,57.4
X$1433 1745 1781 1727 109 958 85 NOR3_X2
* cell instance $1436 r0 *1 69.92,57.4
X$1436 1745 1828 1826 85 109 1179 NOR3_X1
* cell instance $1439 r0 *1 71.25,57.4
X$1439 1745 1845 1826 85 109 1294 NOR3_X1
* cell instance $1440 m0 *1 71.63,57.4
X$1440 1670 85 109 2437 INV_X1
* cell instance $1442 m0 *1 72.01,57.4
X$1442 853 1703 1728 1134 1741 1785 109 85 AOI221_X2
* cell instance $1443 m0 *1 74.1,57.4
X$1443 1789 737 1829 1421 1730 85 109 1786 AOI221_X1
* cell instance $1444 m0 *1 75.24,57.4
X$1444 1552 85 109 1741 INV_X1
* cell instance $1445 m0 *1 75.62,57.4
X$1445 1661 85 109 1730 INV_X1
* cell instance $1446 m0 *1 76,57.4
X$1446 1730 1639 85 109 1782 OR2_X1
* cell instance $1448 m0 *1 76.95,57.4
X$1448 928 1731 1663 85 1732 109 AOI21_X1
* cell instance $1449 m0 *1 77.71,57.4
X$1449 1740 85 109 1733 BUF_X1
* cell instance $1450 m0 *1 78.28,57.4
X$1450 1661 85 109 1739 BUF_X1
* cell instance $1451 m0 *1 78.85,57.4
X$1451 1786 85 109 1734 BUF_X1
* cell instance $1452 m0 *1 79.42,57.4
X$1452 1693 85 109 1665 BUF_X1
* cell instance $1454 m0 *1 80.18,57.4
X$1454 1632 85 109 1735 BUF_X1
* cell instance $1458 r0 *1 72.58,57.4
X$1458 1463 85 109 1670 CLKBUF_X3
* cell instance $1459 r0 *1 73.53,57.4
X$1459 819 1778 1868 1421 1729 1836 109 85 AOI221_X2
* cell instance $1461 r0 *1 75.81,57.4
X$1461 1831 1377 1782 85 109 1830 OR3_X1
* cell instance $1462 r0 *1 76.76,57.4
X$1462 1831 85 109 1872 INV_X1
* cell instance $1463 r0 *1 77.14,57.4
X$1463 1782 1377 1831 109 1832 85 OAI21_X1
* cell instance $1470 m0 *1 2.28,29.4
X$1470 789 85 109 797 BUF_X1
* cell instance $1471 m0 *1 3.04,29.4
X$1471 765 85 109 830 BUF_X1
* cell instance $1474 m0 *1 4.56,29.4
X$1474 818 525 762 85 109 849 MUX2_X1
* cell instance $1475 m0 *1 5.89,29.4
X$1475 85 833 726 2349 765 109 DFF_X2
* cell instance $1476 m0 *1 9.5,29.4
X$1476 478 786 85 109 854 NAND2_X1
* cell instance $1477 m0 *1 10.07,29.4
X$1477 577 786 85 109 850 NAND2_X1
* cell instance $1478 m0 *1 10.64,29.4
X$1478 714 763 366 85 834 109 AOI21_X1
* cell instance $1479 m0 *1 11.4,29.4
X$1479 714 763 298 85 799 109 AOI21_X1
* cell instance $1482 m0 *1 13.11,29.4
X$1482 800 801 85 109 821 NAND2_X1
* cell instance $1483 m0 *1 13.68,29.4
X$1483 442 821 820 109 822 85 OAI21_X1
* cell instance $1486 m0 *1 16.15,29.4
X$1486 576 786 85 109 837 NAND2_X1
* cell instance $1487 m0 *1 16.72,29.4
X$1487 714 763 529 85 802 109 AOI21_X1
* cell instance $1489 m0 *1 19,29.4
X$1489 801 85 109 482 BUF_X2
* cell instance $1490 m0 *1 19.76,29.4
X$1490 762 482 85 109 804 NAND2_X1
* cell instance $1491 m0 *1 20.33,29.4
X$1491 532 804 715 109 826 85 OAI21_X1
* cell instance $1492 m0 *1 21.09,29.4
X$1492 532 861 767 109 823 85 OAI21_X1
* cell instance $1493 m0 *1 21.85,29.4
X$1493 801 85 109 646 BUF_X2
* cell instance $1494 m0 *1 22.61,29.4
X$1494 765 646 85 109 824 NAND2_X1
* cell instance $1496 m0 *1 23.37,29.4
X$1496 688 824 644 109 825 85 OAI21_X1
* cell instance $1498 m0 *1 25.65,29.4
X$1498 859 85 109 414 CLKBUF_X3
* cell instance $1499 m0 *1 26.6,29.4
X$1499 789 768 788 85 109 916 OR3_X1
* cell instance $1500 m0 *1 27.55,29.4
X$1500 788 768 789 109 867 85 OAI21_X1
* cell instance $1502 m0 *1 28.5,29.4
X$1502 714 763 116 85 805 109 AOI21_X1
* cell instance $1503 m0 *1 29.26,29.4
X$1503 117 786 85 109 919 NAND2_X1
* cell instance $1505 m0 *1 30.02,29.4
X$1505 714 763 184 85 917 109 AOI21_X1
* cell instance $1507 m0 *1 30.97,29.4
X$1507 714 763 242 85 872 109 AOI21_X1
* cell instance $1508 m0 *1 31.73,29.4
X$1508 94 646 85 109 874 NAND2_X1
* cell instance $1510 m0 *1 32.49,29.4
X$1510 688 770 645 109 827 85 OAI21_X1
* cell instance $1513 m0 *1 1.33,29.4
X$1513 762 85 109 798 BUF_X1
* cell instance $1520 r0 *1 2.66,29.4
X$1520 884 85 109 831 BUF_X1
* cell instance $1525 r0 *1 3.99,29.4
X$1525 724 849 109 85 817 AND2_X1
* cell instance $1526 r0 *1 4.75,29.4
X$1526 713 525 765 85 109 832 MUX2_X1
* cell instance $1527 r0 *1 6.08,29.4
X$1527 724 832 109 85 833 AND2_X1
* cell instance $1529 r0 *1 7.22,29.4
X$1529 877 85 109 801 BUF_X1
* cell instance $1532 r0 *1 9.5,29.4
X$1532 527 786 85 109 852 NAND2_X1
* cell instance $1533 r0 *1 10.07,29.4
X$1533 836 850 834 109 851 85 OAI21_X1
* cell instance $1534 r0 *1 10.83,29.4
X$1534 836 852 799 109 906 85 OAI21_X1
* cell instance $1536 r0 *1 11.78,29.4
X$1536 836 854 784 109 835 85 OAI21_X1
* cell instance $1537 r0 *1 12.54,29.4
X$1537 880 801 85 109 855 NAND2_X1
* cell instance $1538 r0 *1 13.11,29.4
X$1538 442 855 764 109 882 85 OAI21_X1
* cell instance $1542 r0 *1 16.34,29.4
X$1542 836 837 802 109 858 85 OAI21_X1
* cell instance $1544 r0 *1 17.29,29.4
X$1544 801 85 109 786 BUF_X2
* cell instance $1545 r0 *1 18.05,29.4
X$1545 838 884 883 109 85 859 AND3_X1
* cell instance $1546 r0 *1 19,29.4
X$1546 866 109 373 85 BUF_X4
* cell instance $1547 r0 *1 20.33,29.4
X$1547 838 482 85 109 861 NAND2_X1
* cell instance $1549 r0 *1 21.09,29.4
X$1549 884 482 85 109 766 NAND2_X1
* cell instance $1553 r0 *1 25.27,29.4
X$1553 85 914 666 2381 789 109 DFF_X2
* cell instance $1555 r0 *1 29.07,29.4
X$1555 805 836 869 109 85 876 OAI21_X2
* cell instance $1557 r0 *1 31.54,29.4
X$1557 688 874 872 109 974 85 OAI21_X1
* cell instance $1559 m0 *1 38.38,29.4
X$1559 85 88 806 829 109 DFF_X1
* cell instance $1560 m0 *1 35.15,29.4
X$1560 85 120 828 829 109 DFF_X1
* cell instance $1561 m0 *1 41.61,29.4
X$1561 88 85 109 873 CLKBUF_X2
* cell instance $1565 r0 *1 39.14,29.4
X$1565 875 487 85 109 806 NOR2_X1
* cell instance $1566 r0 *1 39.71,29.4
X$1566 839 109 411 85 BUF_X4
* cell instance $1567 r0 *1 41.04,29.4
X$1567 873 933 85 109 875 XOR2_X1
* cell instance $1570 m0 *1 47.31,29.4
X$1570 194 870 85 109 759 XOR2_X1
* cell instance $1571 m0 *1 48.45,29.4
X$1571 85 122 807 617 109 DFF_X1
* cell instance $1572 m0 *1 51.68,29.4
X$1572 122 85 109 843 BUF_X2
* cell instance $1576 m0 *1 54.91,29.4
X$1576 757 723 295 85 862 109 AOI21_X2
* cell instance $1579 m0 *1 57.19,29.4
X$1579 757 723 187 85 1175 109 AOI21_X2
* cell instance $1581 m0 *1 59.28,29.4
X$1581 808 109 723 85 BUF_X4
* cell instance $1582 m0 *1 60.61,29.4
X$1582 809 109 757 85 BUF_X4
* cell instance $1583 m0 *1 61.94,29.4
X$1583 775 619 725 85 810 109 AOI21_X1
* cell instance $1584 m0 *1 62.7,29.4
X$1584 775 725 250 85 857 109 AOI21_X1
* cell instance $1585 m0 *1 63.46,29.4
X$1585 775 725 277 85 812 109 AOI21_X1
* cell instance $1587 m0 *1 64.41,29.4
X$1587 775 725 217 85 813 109 AOI21_X1
* cell instance $1588 m0 *1 65.17,29.4
X$1588 808 85 109 725 BUF_X2
* cell instance $1589 m0 *1 65.93,29.4
X$1589 809 85 109 775 BUF_X2
* cell instance $1592 m0 *1 67.64,29.4
X$1592 775 725 253 85 847 109 AOI21_X1
* cell instance $1594 m0 *1 68.59,29.4
X$1594 809 85 109 695 CLKBUF_X3
* cell instance $1596 r0 *1 45.22,29.4
X$1596 871 375 85 109 840 NOR2_X1
* cell instance $1598 r0 *1 47.31,29.4
X$1598 885 842 841 844 85 109 870 NAND4_X1
* cell instance $1601 r0 *1 49.21,29.4
X$1601 842 841 843 844 85 109 868 NAND4_X1
* cell instance $1603 r0 *1 50.54,29.4
X$1603 843 773 651 109 85 865 AND3_X1
* cell instance $1604 r0 *1 51.49,29.4
X$1604 865 842 841 844 85 109 864 NAND4_X1
* cell instance $1606 r0 *1 53.2,29.4
X$1606 845 864 85 109 863 XOR2_X1
* cell instance $1607 r0 *1 54.34,29.4
X$1607 863 375 85 109 860 NOR2_X1
* cell instance $1609 r0 *1 55.67,29.4
X$1609 85 860 774 2411 845 109 DFF_X2
* cell instance $1614 r0 *1 59.47,29.4
X$1614 411 85 109 790 CLKBUF_X3
* cell instance $1617 r0 *1 61.56,29.4
X$1617 85 909 774 2402 890 109 DFF_X2
* cell instance $1620 r0 *1 66.12,29.4
X$1620 85 856 592 2387 700 109 DFF_X2
* cell instance $1621 r0 *1 69.73,29.4
X$1621 85 893 620 2384 894 109 DFF_X2
* cell instance $1622 m0 *1 70.11,29.4
X$1622 808 85 109 694 CLKBUF_X3
* cell instance $1624 m0 *1 71.06,29.4
X$1624 695 694 423 85 907 109 AOI21_X1
* cell instance $1625 m0 *1 71.82,29.4
X$1625 695 694 346 85 853 109 AOI21_X2
* cell instance $1626 m0 *1 73.15,29.4
X$1626 1015 85 109 779 BUF_X1
* cell instance $1628 m0 *1 73.91,29.4
X$1628 620 85 109 CLKBUF_X1
* cell instance $1629 m0 *1 74.48,29.4
X$1629 757 723 551 85 819 109 AOI21_X2
* cell instance $1630 m0 *1 75.81,29.4
X$1630 263 85 109 620 CLKBUF_X3
* cell instance $1633 r0 *1 73.72,29.4
X$1633 85 897 895 620 109 DFF_X1
* cell instance $1634 r0 *1 76.95,29.4
X$1634 845 85 109 848 BUF_X1
* cell instance $1636 m0 *1 77.14,29.4
X$1636 85 623 730 620 109 DFF_X1
* cell instance $1645 r0 *1 1.33,26.6
X$1645 717 85 109 761 BUF_X1
* cell instance $1646 r0 *1 1.9,26.6
X$1646 85 817 726 818 762 109 DFF_X2
* cell instance $1647 m0 *1 3.23,26.6
X$1647 85 683 726 2362 577 109 DFF_X2
* cell instance $1648 m0 *1 2.47,26.6
X$1648 712 85 109 480 BUF_X2
* cell instance $1653 r0 *1 5.51,26.6
X$1653 762 765 713 109 85 684 HA_X1
* cell instance $1654 m0 *1 7.41,26.6
X$1654 684 85 109 637 INV_X1
* cell instance $1656 m0 *1 7.79,26.6
X$1656 638 85 109 685 INV_X1
* cell instance $1657 m0 *1 8.17,26.6
X$1657 85 638 701 639 524 866 109 NOR4_X4
* cell instance $1659 m0 *1 11.78,26.6
X$1659 716 479 199 85 731 109 AOI21_X1
* cell instance $1662 r0 *1 7.41,26.6
X$1662 643 85 109 760 BUF_X1
* cell instance $1666 r0 *1 10.07,26.6
X$1666 765 762 85 109 524 NAND2_X2
* cell instance $1667 r0 *1 11.02,26.6
X$1667 716 479 367 85 729 109 AOI21_X1
* cell instance $1668 r0 *1 11.78,26.6
X$1668 714 763 326 85 784 109 AOI21_X1
* cell instance $1670 r0 *1 13.3,26.6
X$1670 716 479 193 85 764 109 AOI21_X1
* cell instance $1671 m0 *1 13.87,26.6
X$1671 716 479 177 85 820 109 AOI21_X1
* cell instance $1676 r0 *1 14.82,26.6
X$1676 85 785 441 734 643 109 DFF_X2
* cell instance $1677 m0 *1 16.72,26.6
X$1677 734 642 643 85 109 736 MUX2_X1
* cell instance $1681 r0 *1 18.43,26.6
X$1681 724 736 109 85 785 AND2_X1
* cell instance $1683 m0 *1 19.95,26.6
X$1683 443 442 368 85 738 109 AOI21_X1
* cell instance $1684 m0 *1 19.19,26.6
X$1684 443 442 89 85 767 109 AOI21_X1
* cell instance $1689 r0 *1 20.14,26.6
X$1689 443 643 442 85 715 109 AOI21_X1
* cell instance $1691 r0 *1 21.09,26.6
X$1691 532 766 738 109 787 85 OAI21_X1
* cell instance $1692 r0 *1 21.85,26.6
X$1692 479 85 109 836 CLKBUF_X3
* cell instance $1693 r0 *1 22.8,26.6
X$1693 716 85 109 714 CLKBUF_X3
* cell instance $1694 m0 *1 24.13,26.6
X$1694 85 717 707 413 109 DFF_X1
* cell instance $1695 m0 *1 23.37,26.6
X$1695 716 85 109 537 BUF_X2
* cell instance $1696 m0 *1 27.36,26.6
X$1696 769 686 85 109 706 XOR2_X1
* cell instance $1697 m0 *1 28.5,26.6
X$1697 718 447 414 437 85 109 686 NAND4_X1
* cell instance $1698 m0 *1 29.45,26.6
X$1698 94 687 109 85 718 AND2_X1
* cell instance $1700 m0 *1 30.4,26.6
X$1700 687 447 414 373 85 109 709 NAND4_X1
* cell instance $1705 r0 *1 24.32,26.6
X$1705 479 85 109 763 CLKBUF_X3
* cell instance $1707 r0 *1 26.79,26.6
X$1707 447 414 866 85 109 768 NAND3_X1
* cell instance $1708 r0 *1 27.55,26.6
X$1708 717 85 109 769 BUF_X1
* cell instance $1709 r0 *1 28.12,26.6
X$1709 718 769 85 109 788 NAND2_X1
* cell instance $1711 r0 *1 29.07,26.6
X$1711 789 769 94 85 109 483 NAND3_X1
* cell instance $1715 r0 *1 31.35,26.6
X$1715 714 763 86 85 748 109 AOI21_X1
* cell instance $1718 r0 *1 32.68,26.6
X$1718 583 646 85 109 770 NAND2_X1
* cell instance $1720 m0 *1 33.25,26.6
X$1720 119 646 85 109 792 NAND2_X1
* cell instance $1721 m0 *1 34.01,26.6
X$1721 688 720 751 109 749 85 OAI21_X1
* cell instance $1723 r0 *1 33.25,26.6
X$1723 688 792 748 109 791 85 OAI21_X1
* cell instance $1724 r0 *1 34.01,26.6
X$1724 583 768 85 109 793 XOR2_X1
* cell instance $1726 m0 *1 35.34,26.6
X$1726 120 85 109 583 BUF_X1
* cell instance $1728 m0 *1 35.91,26.6
X$1728 688 689 647 109 752 85 OAI21_X1
* cell instance $1730 r0 *1 35.53,26.6
X$1730 793 772 85 109 828 NOR2_X1
* cell instance $1732 m0 *1 37.24,26.6
X$1732 688 690 585 109 754 85 OAI21_X1
* cell instance $1736 m0 *1 39.71,26.6
X$1736 85 756 617 2363 87 109 DFF_X2
* cell instance $1737 m0 *1 43.32,26.6
X$1737 691 721 85 109 756 NOR2_X1
* cell instance $1738 m0 *1 43.89,26.6
X$1738 378 85 109 721 CLKBUF_X3
* cell instance $1745 r0 *1 41.23,26.6
X$1745 839 85 109 378 CLKBUF_X3
* cell instance $1747 r0 *1 42.56,26.6
X$1747 378 85 109 772 CLKBUF_X3
* cell instance $1750 r0 *1 44.65,26.6
X$1750 85 795 617 2383 194 109 DFF_X2
* cell instance $1752 m0 *1 47.69,26.6
X$1752 659 85 109 552 INV_X4
* cell instance $1753 m0 *1 48.64,26.6
X$1753 378 109 679 85 BUF_X4
* cell instance $1756 m0 *1 54.91,26.6
X$1756 757 723 186 85 755 109 AOI21_X2
* cell instance $1757 m0 *1 56.24,26.6
X$1757 85 753 774 708 619 109 DFF_X2
* cell instance $1758 m0 *1 59.85,26.6
X$1758 724 750 109 85 753 AND2_X1
* cell instance $1761 r0 *1 48.26,26.6
X$1761 263 85 109 617 CLKBUF_X3
* cell instance $1762 r0 *1 49.21,26.6
X$1762 773 868 85 109 796 XOR2_X1
* cell instance $1763 r0 *1 50.35,26.6
X$1763 759 375 85 109 795 NOR2_X1
* cell instance $1764 r0 *1 50.92,26.6
X$1764 796 375 85 109 722 NOR2_X1
* cell instance $1768 r0 *1 54.15,26.6
X$1768 757 723 212 85 758 109 AOI21_X2
* cell instance $1769 r0 *1 55.48,26.6
X$1769 757 723 296 85 1050 109 AOI21_X2
* cell instance $1770 r0 *1 56.81,26.6
X$1770 757 723 215 85 794 109 AOI21_X2
* cell instance $1778 r0 *1 62.51,26.6
X$1778 775 725 219 85 811 109 AOI21_X1
* cell instance $1781 r0 *1 63.84,26.6
X$1781 775 725 305 85 776 109 AOI21_X1
* cell instance $1782 m0 *1 64.79,26.6
X$1782 85 693 747 592 109 DFF_X1
* cell instance $1783 m0 *1 64.03,26.6
X$1783 790 746 704 85 747 109 AOI21_X1
* cell instance $1787 r0 *1 66.5,26.6
X$1787 775 725 190 85 846 109 AOI21_X1
* cell instance $1789 r0 *1 67.45,26.6
X$1789 775 725 307 85 777 109 AOI21_X1
* cell instance $1790 r0 *1 68.21,26.6
X$1790 775 725 467 85 744 109 AOI21_X1
* cell instance $1792 m0 *1 68.4,26.6
X$1792 693 85 109 561 CLKBUF_X2
* cell instance $1793 r0 *1 68.97,26.6
X$1793 695 694 650 85 745 109 AOI21_X2
* cell instance $1794 m0 *1 69.73,26.6
X$1794 695 694 561 85 814 109 AOI21_X1
* cell instance $1797 r0 *1 70.3,26.6
X$1797 695 694 541 85 778 109 AOI21_X1
* cell instance $1799 m0 *1 70.87,26.6
X$1799 695 694 421 85 743 109 AOI21_X1
* cell instance $1801 r0 *1 71.44,26.6
X$1801 695 694 498 85 742 109 AOI21_X2
* cell instance $1803 m0 *1 72.01,26.6
X$1803 695 694 381 85 741 109 AOI21_X1
* cell instance $1804 m0 *1 72.96,26.6
X$1804 695 694 389 85 740 109 AOI21_X1
* cell instance $1806 r0 *1 72.77,26.6
X$1806 695 694 339 85 739 109 AOI21_X1
* cell instance $1808 r0 *1 73.91,26.6
X$1808 757 723 494 85 737 109 AOI21_X1
* cell instance $1809 m0 *1 74.67,26.6
X$1809 594 551 498 85 109 696 NAND3_X1
* cell instance $1810 m0 *1 74.1,26.6
X$1810 693 85 109 728 BUF_X1
* cell instance $1811 m0 *1 75.43,26.6
X$1811 653 494 85 109 733 NAND2_X1
* cell instance $1813 r0 *1 74.67,26.6
X$1813 757 723 594 85 735 109 AOI21_X1
* cell instance $1816 r0 *1 76,26.6
X$1816 623 352 733 85 109 783 OR3_X1
* cell instance $1818 m0 *1 76.38,26.6
X$1818 594 352 697 85 109 703 OR3_X1
* cell instance $1819 m0 *1 77.52,26.6
X$1819 85 594 655 620 109 DFF_X1
* cell instance $1821 r0 *1 76.95,26.6
X$1821 757 723 623 85 732 109 AOI21_X1
* cell instance $1822 r0 *1 77.71,26.6
X$1822 733 352 623 109 781 85 OAI21_X1
* cell instance $1823 r0 *1 78.47,26.6
X$1823 495 783 781 85 730 109 AOI21_X1
* cell instance $1824 r0 *1 79.23,26.6
X$1824 782 85 109 816 BUF_X1
* cell instance $1825 r0 *1 79.8,26.6
X$1825 894 85 109 780 BUF_X1
* cell instance $1831 m0 *1 2.28,49
X$1831 1456 85 109 1447 BUF_X1
* cell instance $1835 r0 *1 1.71,49
X$1835 85 1557 1467 1316 109 DFF_X1
* cell instance $1839 m0 *1 3.8,49
X$1839 1468 1252 85 109 1467 NOR2_X1
* cell instance $1840 m0 *1 3.23,49
X$1840 1372 85 109 1489 BUF_X1
* cell instance $1841 m0 *1 4.37,49
X$1841 1557 85 109 1413 BUF_X2
* cell instance $1843 r0 *1 4.94,49
X$1843 1354 85 109 1316 CLKBUF_X3
* cell instance $1844 m0 *1 5.7,49
X$1844 1413 1449 85 109 1468 XOR2_X1
* cell instance $1846 m0 *1 6.84,49
X$1846 1320 1363 1412 85 109 1449 NAND3_X1
* cell instance $1849 r0 *1 5.89,49
X$1849 1513 1252 85 109 1558 NOR2_X1
* cell instance $1850 r0 *1 6.46,49
X$1850 1363 1559 109 85 1513 XNOR2_X1
* cell instance $1851 r0 *1 7.6,49
X$1851 1576 85 109 1363 BUF_X2
* cell instance $1852 r0 *1 8.36,49
X$1852 1323 1539 85 109 1559 NOR2_X1
* cell instance $1853 r0 *1 8.93,49
X$1853 1412 85 109 1539 INV_X1
* cell instance $1855 m0 *1 9.69,49
X$1855 1367 1486 1450 85 1364 109 AOI21_X1
* cell instance $1857 m0 *1 10.45,49
X$1857 851 1490 1390 1393 1413 1517 109 85 AOI221_X2
* cell instance $1859 r0 *1 9.69,49
X$1859 1367 1486 1540 85 1366 109 AOI21_X1
* cell instance $1860 r0 *1 10.45,49
X$1860 906 1541 1390 1393 1363 1516 109 85 AOI221_X2
* cell instance $1861 r0 *1 12.54,49
X$1861 85 1491 1543 565 1451 1323 109 NAND4_X4
* cell instance $1862 m0 *1 16.34,49
X$1862 1491 1451 618 85 109 1414 NAND3_X1
* cell instance $1863 m0 *1 12.92,49
X$1863 85 1491 1562 565 1451 1081 109 NAND4_X4
* cell instance $1864 m0 *1 17.1,49
X$1864 1493 1372 85 109 1437 NAND2_X1
* cell instance $1866 m0 *1 17.86,49
X$1866 1163 1479 1493 1099 85 1492 109 NAND4_X2
* cell instance $1868 m0 *1 20.33,49
X$1868 85 1452 1370 1415 1372 109 DFF_X2
* cell instance $1871 r0 *1 16.72,49
X$1871 85 674 1563 1564 1492 1220 109 NOR4_X4
* cell instance $1872 r0 *1 20.14,49
X$1872 1566 1414 1493 85 109 1544 MUX2_X1
* cell instance $1875 m0 *1 24.32,49
X$1875 825 1520 1169 1127 1493 1519 109 85 AOI221_X2
* cell instance $1878 r0 *1 26.22,49
X$1878 1453 1081 1078 109 1583 85 NOR3_X2
* cell instance $1879 m0 *1 27.55,49
X$1879 1495 1454 1485 85 109 1417 MUX2_X1
* cell instance $1880 m0 *1 26.79,49
X$1880 1455 803 109 85 1495 AND2_X1
* cell instance $1881 m0 *1 28.88,49
X$1881 411 1455 85 109 1485 NOR2_X1
* cell instance $1884 r0 *1 27.55,49
X$1884 1494 1545 85 109 1496 NAND2_X1
* cell instance $1885 r0 *1 28.12,49
X$1885 1496 1453 1123 85 109 1454 NOR3_X1
* cell instance $1887 r0 *1 29.64,49
X$1887 1455 1494 1545 85 109 1524 NAND3_X1
* cell instance $1888 r0 *1 30.4,49
X$1888 1524 1453 1081 1078 85 109 1571 NOR4_X1
* cell instance $1889 m0 *1 30.78,49
X$1889 1456 85 109 1455 CLKBUF_X2
* cell instance $1894 r0 *1 31.73,49
X$1894 1497 1571 109 85 1484 XNOR2_X1
* cell instance $1896 m0 *1 32.68,49
X$1896 85 1525 1547 2375 1497 109 DFF_X2
* cell instance $1898 r0 *1 32.87,49
X$1898 749 1569 1169 1127 1494 1528 109 85 AOI221_X2
* cell instance $1900 m0 *1 37.62,49
X$1900 411 109 945 85 BUF_X4
* cell instance $1902 m0 *1 38.95,49
X$1902 552 1498 85 109 1483 NAND2_X1
* cell instance $1907 r0 *1 38.95,49
X$1907 1527 1526 1499 85 109 1546 MUX2_X1
* cell instance $1908 r0 *1 40.28,49
X$1908 1266 1499 1527 109 85 1500 HA_X1
* cell instance $1909 m0 *1 40.85,49
X$1909 1498 1445 567 85 109 1526 NAND3_X1
* cell instance $1911 m0 *1 41.61,49
X$1911 1498 1445 618 1501 85 955 109 NAND4_X2
* cell instance $1912 m0 *1 43.32,49
X$1912 618 1445 1498 1501 109 85 1247 AND4_X2
* cell instance $1914 r0 *1 42.18,49
X$1914 1498 1500 109 85 1419 AND2_X1
* cell instance $1915 r0 *1 42.94,49
X$1915 1266 1499 109 85 1501 AND2_X1
* cell instance $1917 r0 *1 43.89,49
X$1917 1499 1129 85 109 1573 NOR2_X1
* cell instance $1918 r0 *1 44.46,49
X$1918 1029 1519 1573 85 109 1568 OR3_X1
* cell instance $1919 m0 *1 45.22,49
X$1919 1529 487 85 109 1482 NOR2_X1
* cell instance $1921 m0 *1 45.79,49
X$1921 85 1482 1547 2347 1420 109 DFF_X2
* cell instance $1922 m0 *1 49.4,49
X$1922 1457 1516 1531 85 109 1533 OR3_X1
* cell instance $1923 m0 *1 50.35,49
X$1923 1457 1517 1503 85 109 1534 OR3_X1
* cell instance $1925 r0 *1 45.41,49
X$1925 1502 1328 109 85 1607 XNOR2_X1
* cell instance $1928 r0 *1 48.45,49
X$1928 1548 1502 85 109 1444 NAND2_X1
* cell instance $1929 r0 *1 49.02,49
X$1929 1247 1502 85 109 1574 NAND2_X1
* cell instance $1930 r0 *1 49.59,49
X$1930 1502 1548 1420 1458 109 85 1246 AND4_X1
* cell instance $1931 r0 *1 50.73,49
X$1931 1458 1327 85 109 1503 NOR2_X1
* cell instance $1934 m0 *1 51.68,49
X$1934 85 1532 1177 2378 1458 109 DFF_X2
* cell instance $1937 r0 *1 53.58,49
X$1937 1570 612 85 109 1604 NOR2_X1
* cell instance $1940 r0 *1 55.1,49
X$1940 755 1534 1504 1421 1507 1518 109 85 AOI221_X2
* cell instance $1941 m0 *1 56.62,49
X$1941 794 1401 1477 1421 1461 1514 109 85 AOI221_X2
* cell instance $1943 m0 *1 58.71,49
X$1943 1476 721 85 109 1399 NOR2_X1
* cell instance $1944 m0 *1 59.28,49
X$1944 1460 1475 109 85 1476 XNOR2_X1
* cell instance $1945 m0 *1 60.42,49
X$1945 1424 85 109 1461 INV_X1
* cell instance $1948 r0 *1 57.57,49
X$1948 618 1505 1506 1602 109 85 1423 AND4_X1
* cell instance $1949 r0 *1 58.71,49
X$1949 618 1505 1506 1549 109 85 1530 AND4_X1
* cell instance $1953 r0 *1 59.85,49
X$1953 1549 1506 1505 567 85 109 1376 NAND4_X1
* cell instance $1954 r0 *1 60.8,49
X$1954 1530 85 109 891 CLKBUF_X3
* cell instance $1955 m0 *1 62.13,49
X$1955 889 1427 1426 85 109 1474 NAND3_X1
* cell instance $1956 m0 *1 61.18,49
X$1956 891 1424 1427 1426 85 109 1475 NAND4_X1
* cell instance $1958 m0 *1 63.65,49
X$1958 1426 85 109 1440 INV_X1
* cell instance $1960 m0 *1 64.22,49
X$1960 1440 1376 1427 109 1508 85 OAI21_X1
* cell instance $1961 m0 *1 64.98,49
X$1961 1462 85 109 1506 CLKBUF_X2
* cell instance $1964 r0 *1 61.75,49
X$1964 1461 1474 109 85 1601 XNOR2_X1
* cell instance $1965 r0 *1 62.89,49
X$1965 1427 85 109 1507 INV_X1
* cell instance $1966 r0 *1 63.27,49
X$1966 891 1507 1426 85 109 1523 NAND3_X1
* cell instance $1967 r0 *1 64.03,49
X$1967 495 1523 1508 85 1592 109 AOI21_X1
* cell instance $1968 r0 *1 64.79,49
X$1968 1593 85 109 1427 BUF_X2
* cell instance $1971 m0 *1 66.88,49
X$1971 85 1429 1522 1277 109 DFF_X1
* cell instance $1976 r0 *1 72.2,49
X$1976 1567 739 1521 1134 1550 85 109 1515 AOI221_X1
* cell instance $1977 m0 *1 73.91,49
X$1977 1238 1333 1396 1464 85 109 1471 NOR4_X1
* cell instance $1978 m0 *1 72.77,49
X$1978 1464 1377 109 85 1473 XNOR2_X1
* cell instance $1979 m0 *1 74.86,49
X$1979 1378 85 109 1464 INV_X1
* cell instance $1980 m0 *1 75.24,49
X$1980 85 1510 1465 1277 109 DFF_X1
* cell instance $1981 m0 *1 78.47,49
X$1981 1510 85 109 1436 BUF_X1
* cell instance $1985 r0 *1 73.34,49
X$1985 1436 85 109 1550 INV_X1
* cell instance $1986 r0 *1 73.72,49
X$1986 1380 85 109 1598 INV_X1
* cell instance $1987 r0 *1 74.1,49
X$1987 1380 1436 1378 85 109 1551 NAND3_X1
* cell instance $1989 r0 *1 75.05,49
X$1989 1378 1436 1380 1552 109 85 1472 AND4_X1
* cell instance $1990 r0 *1 76.19,49
X$1990 85 1552 1553 1277 109 DFF_X1
* cell instance $1991 r0 *1 79.42,49
X$1991 1469 85 109 1512 BUF_X1
* cell instance $1993 r0 *1 80.18,49
X$1993 1514 85 109 1432 BUF_X1
* cell instance $1996 m0 *1 46.74,79.8
X$1996 1420 85 109 2314 BUF_X1
* cell instance $2004 m0 *1 53.77,79.8
X$2004 1804 85 109 2303 BUF_X1
* cell instance $2013 m0 *1 2.28,63
X$2013 85 1927 1944 1926 109 DFF_X1
* cell instance $2014 m0 *1 1.71,63
X$2014 1927 85 109 1953 BUF_X1
* cell instance $2016 r0 *1 2.85,63
X$2016 1957 85 109 1954 BUF_X1
* cell instance $2026 r0 *1 5.51,63
X$2026 85 1957 1955 1926 109 DFF_X1
* cell instance $2027 m0 *1 6.08,63
X$2027 1927 85 109 1928 BUF_X1
* cell instance $2030 m0 *1 7.41,63
X$2030 1945 1036 85 109 1944 NOR2_X1
* cell instance $2031 m0 *1 7.98,63
X$2031 1928 1929 109 85 1945 XNOR2_X1
* cell instance $2032 m0 *1 9.12,63
X$2032 1893 1761 1450 85 109 1929 NOR3_X1
* cell instance $2033 m0 *1 9.88,63
X$2033 1928 85 109 1540 INV_X1
* cell instance $2034 m0 *1 10.26,63
X$2034 1984 85 109 1450 INV_X1
* cell instance $2037 r0 *1 8.74,63
X$2037 1956 1928 1984 85 109 1983 NAND3_X1
* cell instance $2038 r0 *1 9.5,63
X$2038 1971 1928 1984 85 109 2011 NAND3_X1
* cell instance $2039 r0 *1 10.26,63
X$2039 1984 1928 1956 1957 109 85 2020 AND4_X1
* cell instance $2040 r0 *1 11.4,63
X$2040 1542 2011 109 85 2043 XNOR2_X1
* cell instance $2041 m0 *1 12.92,63
X$2041 85 674 1892 1895 1893 1971 109 NOR4_X4
* cell instance $2042 m0 *1 12.54,63
X$2042 1957 85 109 1343 INV_X1
* cell instance $2043 m0 *1 16.34,63
X$2043 674 1892 1895 1893 109 1946 85 OR4_X2
* cell instance $2044 m0 *1 17.67,63
X$2044 85 1958 109 1946 BUF_X8
* cell instance $2047 m0 *1 21.09,63
X$2047 928 2016 1931 85 1930 109 AOI21_X1
* cell instance $2048 m0 *1 21.85,63
X$2048 1767 1974 109 85 1896 XNOR2_X1
* cell instance $2051 m0 *1 26.22,63
X$2051 85 1897 1912 1652 109 DFF_X1
* cell instance $2053 m0 *1 29.64,63
X$2053 1354 85 109 1652 CLKBUF_X3
* cell instance $2054 m0 *1 30.59,63
X$2054 1914 1898 1950 85 109 1975 MUX2_X1
* cell instance $2055 m0 *1 31.92,63
X$2055 1682 1685 85 109 1914 NOR2_X1
* cell instance $2056 m0 *1 32.49,63
X$2056 1952 85 109 1685 INV_X1
* cell instance $2058 m0 *1 33.63,63
X$2058 85 1962 1932 2336 1913 109 DFF_X2
* cell instance $2060 r0 *1 12.54,63
X$2060 1956 85 109 1542 INV_X1
* cell instance $2066 r0 *1 18.81,63
X$2066 85 1988 1930 2014 109 DFF_X1
* cell instance $2067 r0 *1 22.04,63
X$2067 1987 2022 1958 1198 85 109 1974 NOR4_X1
* cell instance $2068 r0 *1 22.99,63
X$2068 1988 85 109 1198 INV_X1
* cell instance $2072 r0 *1 24.7,63
X$2072 85 1959 1652 2409 2023 109 DFF_X2
* cell instance $2075 r0 *1 30.02,63
X$2075 85 1975 1652 2399 1952 109 DFF_X2
* cell instance $2076 r0 *1 33.63,63
X$2076 1913 1960 1991 85 109 1977 OR3_X1
* cell instance $2077 r0 *1 34.58,63
X$2077 928 1977 1992 85 1962 109 AOI21_X1
* cell instance $2080 m0 *1 37.62,63
X$2080 85 1857 1917 1932 109 DFF_X1
* cell instance $2084 r0 *1 41.04,63
X$2084 1888 85 109 1995 INV_X1
* cell instance $2086 m0 *1 41.23,63
X$2086 85 1933 1921 1935 109 DFF_X1
* cell instance $2089 r0 *1 42.37,63
X$2089 1963 85 109 1996 INV_X1
* cell instance $2093 r0 *1 44.08,63
X$2093 1933 85 109 1690 BUF_X1
* cell instance $2094 r0 *1 44.65,63
X$2094 1691 1690 1753 85 109 1998 NAND3_X1
* cell instance $2095 m0 *1 45.03,63
X$2095 85 1934 1935 2351 1691 109 DFF_X2
* cell instance $2097 m0 *1 48.64,63
X$2097 85 674 1859 1951 1936 109 NOR3_X4
* cell instance $2098 m0 *1 51.3,63
X$2098 85 674 1859 1860 1949 2017 109 NOR4_X4
* cell instance $2101 m0 *1 57,63
X$2101 724 1947 109 85 1924 AND2_X1
* cell instance $2102 m0 *1 57.76,63
X$2102 1919 1936 1948 85 109 1947 MUX2_X1
* cell instance $2106 r0 *1 46.36,63
X$2106 85 2018 1935 2418 1724 109 DFF_X2
* cell instance $2108 r0 *1 51.49,63
X$2108 85 1981 1692 2416 1861 109 DFF_X2
* cell instance $2112 r0 *1 58.71,63
X$2112 1889 1936 2029 85 109 1980 MUX2_X1
* cell instance $2119 m0 *1 59.66,63
X$2119 724 1980 109 85 1922 AND2_X1
* cell instance $2123 m0 *1 62.7,63
X$2123 2015 679 85 109 1979 NOR2_X1
* cell instance $2125 m0 *1 64.79,63
X$2125 85 1964 1937 2345 1781 109 DFF_X2
* cell instance $2126 m0 *1 68.4,63
X$2126 85 1976 1937 2346 1905 109 DFF_X2
* cell instance $2127 m0 *1 72.01,63
X$2127 2004 589 85 109 1938 NOR2_X1
* cell instance $2131 r0 *1 61.94,63
X$2131 85 1979 1937 2389 1780 109 DFF_X2
* cell instance $2132 r0 *1 65.55,63
X$2132 1781 2013 85 109 1978 XOR2_X1
* cell instance $2133 r0 *1 66.69,63
X$2133 1978 679 85 109 1964 NOR2_X1
* cell instance $2136 r0 *1 69.16,63
X$2136 1965 589 85 109 1976 NOR2_X1
* cell instance $2138 r0 *1 69.92,63
X$2138 1463 85 109 1937 CLKBUF_X3
* cell instance $2139 r0 *1 70.87,63
X$2139 85 1967 1938 1937 109 DFF_X1
* cell instance $2140 m0 *1 76.19,63
X$2140 1967 1941 1940 1881 85 109 1968 NAND4_X1
* cell instance $2141 m0 *1 72.96,63
X$2141 85 1907 1939 1937 109 DFF_X1
* cell instance $2144 m0 *1 78.85,63
X$2144 1870 85 109 1942 BUF_X1
* cell instance $2146 m0 *1 79.61,63
X$2146 1831 85 109 1835 BUF_X1
* cell instance $2147 m0 *1 80.18,63
X$2147 1668 85 109 1874 BUF_X1
* cell instance $2150 r0 *1 74.86,63
X$2150 495 1973 1972 85 1939 109 AOI21_X1
* cell instance $2151 r0 *1 75.62,63
X$2151 1907 2005 1968 85 109 1973 OR3_X1
* cell instance $2152 r0 *1 76.57,63
X$2152 1968 2005 1907 109 1972 85 OAI21_X1
* cell instance $2155 r0 *1 77.9,63
X$2155 1967 85 109 1969 BUF_X1
* cell instance $2158 r0 *1 79.61,63
X$2158 1876 85 109 1943 BUF_X1
* cell instance $2159 r0 *1 80.18,63
X$2159 1882 85 109 1970 BUF_X1
* cell instance $2163 m0 *1 1.33,23.8
X$2163 610 85 109 530 BUF_X1
* cell instance $2165 m0 *1 1.9,23.8
X$2165 613 85 109 635 BUF_X1
* cell instance $2166 m0 *1 2.47,23.8
X$2166 85 656 441 2348 576 109 DFF_X2
* cell instance $2167 m0 *1 6.08,23.8
X$2167 575 611 109 85 627 XNOR2_X1
* cell instance $2168 m0 *1 7.22,23.8
X$2168 565 480 685 85 109 525 NAND3_X2
* cell instance $2171 m0 *1 9.5,23.8
X$2171 618 480 85 109 701 NAND2_X2
* cell instance $2175 r0 *1 2.09,23.8
X$2175 577 85 109 636 BUF_X1
* cell instance $2176 r0 *1 2.66,23.8
X$2176 576 85 109 682 BUF_X1
* cell instance $2182 r0 *1 3.8,23.8
X$2182 657 183 85 109 683 NOR2_X1
* cell instance $2184 r0 *1 4.56,23.8
X$2184 577 574 109 85 657 XNOR2_X1
* cell instance $2186 r0 *1 5.89,23.8
X$2186 627 268 85 109 656 NOR2_X1
* cell instance $2187 r0 *1 6.46,23.8
X$2187 567 480 685 684 85 611 109 NAND4_X2
* cell instance $2188 r0 *1 8.17,23.8
X$2188 85 638 637 701 639 572 109 NOR4_X4
* cell instance $2189 m0 *1 11.4,23.8
X$2189 552 530 85 109 660 NAND2_X1
* cell instance $2190 m0 *1 10.83,23.8
X$2190 441 85 109 CLKBUF_X1
* cell instance $2191 m0 *1 11.97,23.8
X$2191 659 578 85 109 661 NAND2_X1
* cell instance $2192 m0 *1 12.54,23.8
X$2192 612 528 641 85 640 109 AOI21_X1
* cell instance $2193 m0 *1 13.3,23.8
X$2193 206 85 109 441 CLKBUF_X3
* cell instance $2194 m0 *1 14.25,23.8
X$2194 612 660 661 85 598 109 AOI21_X1
* cell instance $2196 m0 *1 15.2,23.8
X$2196 530 531 567 85 109 642 NAND3_X1
* cell instance $2197 m0 *1 15.96,23.8
X$2197 643 613 662 109 85 579 HA_X1
* cell instance $2199 m0 *1 18.05,23.8
X$2199 85 580 665 618 531 239 109 NAND4_X4
* cell instance $2200 m0 *1 21.47,23.8
X$2200 643 613 109 85 665 AND2_X1
* cell instance $2202 m0 *1 22.99,23.8
X$2202 479 85 109 532 BUF_X2
* cell instance $2203 m0 *1 23.75,23.8
X$2203 532 633 581 109 634 85 OAI21_X1
* cell instance $2208 r0 *1 11.59,23.8
X$2208 85 640 441 2422 638 109 DFF_X2
* cell instance $2209 r0 *1 15.2,23.8
X$2209 659 638 85 109 641 NAND2_X1
* cell instance $2211 r0 *1 15.96,23.8
X$2211 662 642 613 85 109 663 MUX2_X1
* cell instance $2213 r0 *1 18.81,23.8
X$2213 803 663 109 85 664 AND2_X1
* cell instance $2214 r0 *1 19.57,23.8
X$2214 85 664 666 2386 613 109 DFF_X2
* cell instance $2216 r0 *1 23.56,23.8
X$2216 537 584 613 85 644 109 AOI21_X1
* cell instance $2217 r0 *1 24.32,23.8
X$2217 479 85 109 688 BUF_X2
* cell instance $2219 r0 *1 25.46,23.8
X$2219 706 268 85 109 707 NOR2_X1
* cell instance $2222 r0 *1 29.26,23.8
X$2222 85 670 413 2382 94 109 DFF_X2
* cell instance $2223 m0 *1 31.35,23.8
X$2223 672 448 85 109 670 NOR2_X1
* cell instance $2224 m0 *1 30.21,23.8
X$2224 94 709 85 109 672 XOR2_X1
* cell instance $2226 m0 *1 32.11,23.8
X$2226 537 584 140 85 645 109 AOI21_X1
* cell instance $2227 m0 *1 32.87,23.8
X$2227 583 485 489 119 109 85 687 AND4_X1
* cell instance $2229 m0 *1 34.2,23.8
X$2229 537 584 95 85 751 109 AOI21_X1
* cell instance $2233 r0 *1 33.06,23.8
X$2233 688 675 535 109 710 85 OAI21_X1
* cell instance $2235 r0 *1 34.01,23.8
X$2235 489 646 85 109 675 NAND2_X1
* cell instance $2237 r0 *1 34.77,23.8
X$2237 485 646 85 109 720 NAND2_X1
* cell instance $2239 r0 *1 35.72,23.8
X$2239 87 646 85 109 689 NAND2_X1
* cell instance $2240 m0 *1 36.29,23.8
X$2240 537 584 100 85 647 109 AOI21_X1
* cell instance $2242 m0 *1 37.05,23.8
X$2242 537 584 161 85 648 109 AOI21_X1
* cell instance $2243 m0 *1 37.81,23.8
X$2243 537 584 129 85 677 109 AOI21_X1
* cell instance $2246 r0 *1 36.29,23.8
X$2246 688 676 648 109 771 85 OAI21_X1
* cell instance $2247 r0 *1 37.05,23.8
X$2247 688 678 677 109 711 85 OAI21_X1
* cell instance $2248 r0 *1 38.38,23.8
X$2248 105 646 85 109 690 NAND2_X1
* cell instance $2250 r0 *1 39.14,23.8
X$2250 570 646 85 109 678 NAND2_X1
* cell instance $2254 m0 *1 41.99,23.8
X$2254 615 414 572 570 85 109 680 NAND4_X1
* cell instance $2255 m0 *1 43.7,23.8
X$2255 538 631 109 85 614 XNOR2_X1
* cell instance $2256 m0 *1 44.84,23.8
X$2256 614 679 85 109 649 NOR2_X1
* cell instance $2257 m0 *1 45.41,23.8
X$2257 681 377 437 85 109 631 NAND3_X1
* cell instance $2259 m0 *1 46.93,23.8
X$2259 85 616 617 2361 105 109 DFF_X2
* cell instance $2262 r0 *1 41.99,23.8
X$2262 87 680 85 109 691 XOR2_X1
* cell instance $2266 r0 *1 48.07,23.8
X$2266 588 692 85 109 616 NOR2_X1
* cell instance $2269 r0 *1 49.21,23.8
X$2269 378 85 109 589 CLKBUF_X3
* cell instance $2270 r0 *1 50.16,23.8
X$2270 378 85 109 692 CLKBUF_X3
* cell instance $2272 m0 *1 51.87,23.8
X$2272 85 565 109 618 BUF_X8
* cell instance $2275 m0 *1 54.53,23.8
X$2275 568 612 85 109 630 NOR2_X1
* cell instance $2276 m0 *1 55.1,23.8
X$2276 85 674 604 590 673 252 109 NOR4_X4
* cell instance $2277 m0 *1 58.52,23.8
X$2277 650 619 85 109 673 NAND2_X1
* cell instance $2278 m0 *1 59.09,23.8
X$2278 619 650 671 109 85 668 HA_X1
* cell instance $2282 m0 *1 68.78,23.8
X$2282 85 621 600 620 109 DFF_X1
* cell instance $2283 m0 *1 72.01,23.8
X$2283 621 85 109 421 BUF_X1
* cell instance $2286 m0 *1 73.53,23.8
X$2286 650 85 109 628 BUF_X1
* cell instance $2287 m0 *1 74.1,23.8
X$2287 498 85 109 654 INV_X1
* cell instance $2288 m0 *1 74.48,23.8
X$2288 593 654 85 109 622 NOR2_X1
* cell instance $2289 m0 *1 75.05,23.8
X$2289 498 352 593 85 109 543 OR3_X1
* cell instance $2290 m0 *1 76,23.8
X$2290 619 85 109 629 BUF_X1
* cell instance $2292 m0 *1 76.76,23.8
X$2292 85 497 544 620 109 DFF_X1
* cell instance $2293 m0 *1 79.99,23.8
X$2293 623 85 109 624 BUF_X1
* cell instance $2296 r0 *1 54.15,23.8
X$2296 618 85 109 674 INV_X8
* cell instance $2299 r0 *1 57.57,23.8
X$2299 671 591 650 85 109 669 MUX2_X1
* cell instance $2300 r0 *1 58.9,23.8
X$2300 708 591 619 85 109 750 MUX2_X1
* cell instance $2305 r0 *1 60.61,23.8
X$2305 724 669 109 85 667 AND2_X1
* cell instance $2307 r0 *1 61.56,23.8
X$2307 85 667 592 2385 650 109 DFF_X2
* cell instance $2308 r0 *1 65.17,23.8
X$2308 652 353 561 109 704 85 OAI21_X1
* cell instance $2309 r0 *1 65.93,23.8
X$2309 561 353 652 85 109 746 OR3_X1
* cell instance $2312 r0 *1 67.83,23.8
X$2312 263 85 109 592 CLKBUF_X3
* cell instance $2313 r0 *1 68.78,23.8
X$2313 253 307 85 109 652 NAND2_X1
* cell instance $2314 r0 *1 69.35,23.8
X$2314 592 85 109 2445 INV_X1
* cell instance $2318 r0 *1 73.91,23.8
X$2318 696 593 85 109 653 NOR2_X1
* cell instance $2319 r0 *1 74.48,23.8
X$2319 389 339 381 346 85 593 109 NAND4_X2
* cell instance $2320 r0 *1 76.19,23.8
X$2320 622 551 85 109 697 NAND2_X1
* cell instance $2322 r0 *1 76.95,23.8
X$2322 697 352 594 109 658 85 OAI21_X1
* cell instance $2323 r0 *1 77.71,23.8
X$2323 495 703 658 85 655 109 AOI21_X1
* cell instance $2324 r0 *1 78.47,23.8
X$2324 651 85 109 699 BUF_X1
* cell instance $2325 r0 *1 79.04,23.8
X$2325 700 85 109 702 BUF_X1
* cell instance $2327 r0 *1 79.99,23.8
X$2327 727 85 109 815 BUF_X1
* cell instance $2330 m0 *1 4.18,65.8
X$2330 1985 85 109 2019 BUF_X1
* cell instance $2333 m0 *1 6.27,65.8
X$2333 2009 1036 85 109 1955 NOR2_X1
* cell instance $2334 m0 *1 6.84,65.8
X$2334 1957 2010 109 85 2009 XNOR2_X1
* cell instance $2335 m0 *1 7.98,65.8
X$2335 1983 1893 1761 85 109 2010 NOR3_X1
* cell instance $2336 m0 *1 8.74,65.8
X$2336 1984 1971 109 85 2041 XNOR2_X1
* cell instance $2338 m0 *1 10.07,65.8
X$2338 2043 1036 85 109 2042 NOR2_X1
* cell instance $2340 m0 *1 12.16,65.8
X$2340 2020 1971 85 109 2045 NAND2_X1
* cell instance $2341 m0 *1 12.73,65.8
X$2341 2012 1036 85 109 2044 NOR2_X1
* cell instance $2342 m0 *1 13.3,65.8
X$2342 1346 2045 109 85 2012 XNOR2_X1
* cell instance $2343 m0 *1 14.44,65.8
X$2343 1985 85 109 1346 INV_X1
* cell instance $2346 r0 *1 4.18,65.8
X$2346 1956 85 109 2060 BUF_X1
* cell instance $2348 r0 *1 6.27,65.8
X$2348 2041 1036 85 109 2085 NOR2_X1
* cell instance $2350 r0 *1 7.03,65.8
X$2350 1926 85 109 CLKBUF_X1
* cell instance $2351 r0 *1 7.6,65.8
X$2351 1354 85 109 1926 CLKBUF_X3
* cell instance $2352 r0 *1 8.55,65.8
X$2352 85 1956 2042 1926 109 DFF_X1
* cell instance $2354 r0 *1 12.16,65.8
X$2354 85 1985 2044 1716 109 DFF_X1
* cell instance $2355 m0 *1 15.77,65.8
X$2355 2020 1764 1985 85 109 2145 NAND3_X1
* cell instance $2356 m0 *1 15.2,65.8
X$2356 2020 1985 85 109 2021 NAND2_X1
* cell instance $2360 m0 *1 18.05,65.8
X$2360 2021 85 109 2022 CLKBUF_X3
* cell instance $2361 m0 *1 16.91,65.8
X$2361 1761 1893 2021 85 109 1986 OR3_X2
* cell instance $2364 r0 *1 17.29,65.8
X$2364 1348 1986 109 85 2061 XNOR2_X1
* cell instance $2367 r0 *1 19.57,65.8
X$2367 2062 85 109 1347 INV_X1
* cell instance $2368 r0 *1 19.95,65.8
X$2368 2134 85 109 1196 INV_X1
* cell instance $2369 m0 *1 20.33,65.8
X$2369 1988 1986 1987 85 109 2016 OR3_X1
* cell instance $2371 m0 *1 21.28,65.8
X$2371 1987 1986 1988 109 1931 85 OAI21_X1
* cell instance $2378 r0 *1 22.99,65.8
X$2378 85 2063 2047 1910 109 DFF_X1
* cell instance $2379 m0 *1 26.03,65.8
X$2379 1772 2023 85 109 1989 NOR2_X1
* cell instance $2380 m0 *1 24.7,65.8
X$2380 2048 2088 1989 85 109 1959 MUX2_X1
* cell instance $2381 m0 *1 26.6,65.8
X$2381 1682 1441 85 109 2048 NOR2_X1
* cell instance $2383 m0 *1 27.36,65.8
X$2383 2023 85 109 1441 INV_X1
* cell instance $2386 m0 *1 31.54,65.8
X$2386 1772 1952 85 109 1950 NOR2_X1
* cell instance $2387 m0 *1 32.11,65.8
X$2387 1682 1990 85 109 2024 NOR2_X1
* cell instance $2388 m0 *1 32.68,65.8
X$2388 1772 2065 85 109 2025 NOR2_X1
* cell instance $2390 m0 *1 34.01,65.8
X$2390 1991 1960 1913 109 1992 85 OAI21_X1
* cell instance $2394 m0 *1 38.76,65.8
X$2394 1682 1995 85 109 1993 NOR2_X1
* cell instance $2395 m0 *1 39.33,65.8
X$2395 1993 2053 1994 85 109 2051 MUX2_X1
* cell instance $2396 m0 *1 40.66,65.8
X$2396 1772 1888 85 109 1994 NOR2_X1
* cell instance $2397 m0 *1 41.23,65.8
X$2397 2026 1819 1995 1996 85 109 1916 NOR4_X1
* cell instance $2398 m0 *1 42.18,65.8
X$2398 2026 1406 1996 85 109 2053 NOR3_X1
* cell instance $2400 m0 *1 44.46,65.8
X$2400 1998 1997 85 109 2027 NOR2_X1
* cell instance $2401 m0 *1 45.03,65.8
X$2401 1997 1998 85 109 2117 OR2_X1
* cell instance $2402 m0 *1 45.79,65.8
X$2402 1724 85 109 1997 INV_X1
* cell instance $2403 m0 *1 46.17,65.8
X$2403 1724 1406 1998 85 109 1999 OR3_X1
* cell instance $2404 m0 *1 47.12,65.8
X$2404 790 1999 2000 85 2018 109 AOI21_X1
* cell instance $2405 m0 *1 47.88,65.8
X$2405 1998 1406 1724 109 2000 85 OAI21_X1
* cell instance $2409 m0 *1 52.63,65.8
X$2409 2028 382 85 109 2056 NOR2_X1
* cell instance $2410 m0 *1 53.2,65.8
X$2410 2057 692 85 109 1981 NOR2_X1
* cell instance $2411 m0 *1 53.77,65.8
X$2411 1861 2068 85 109 2057 XOR2_X1
* cell instance $2415 r0 *1 26.22,65.8
X$2415 1772 2063 85 109 2108 NOR2_X1
* cell instance $2419 r0 *1 29.26,65.8
X$2419 1684 1960 109 85 2078 XNOR2_X1
* cell instance $2423 r0 *1 31.73,65.8
X$2423 2024 2064 2025 85 109 2050 MUX2_X1
* cell instance $2424 r0 *1 33.06,65.8
X$2424 85 2065 2050 1652 109 DFF_X1
* cell instance $2428 r0 *1 38.38,65.8
X$2428 85 1888 2051 1932 109 DFF_X1
* cell instance $2429 r0 *1 41.61,65.8
X$2429 1963 1819 2026 85 109 2091 OR3_X1
* cell instance $2431 r0 *1 42.94,65.8
X$2431 2026 1819 1963 109 2115 85 OAI21_X1
* cell instance $2433 r0 *1 44.08,65.8
X$2433 1935 85 109 2444 INV_X1
* cell instance $2434 r0 *1 44.46,65.8
X$2434 2027 1723 1982 85 109 2026 NAND3_X2
* cell instance $2435 r0 *1 45.79,65.8
X$2435 1463 85 109 1935 CLKBUF_X3
* cell instance $2437 r0 *1 46.93,65.8
X$2437 1723 1406 2066 85 109 2082 OR3_X1
* cell instance $2438 r0 *1 47.88,65.8
X$2438 2027 1982 85 109 2066 NAND2_X1
* cell instance $2440 r0 *1 49.21,65.8
X$2440 85 2067 2056 1692 109 DFF_X1
* cell instance $2441 r0 *1 52.44,65.8
X$2441 1891 2083 85 109 2028 XOR2_X1
* cell instance $2442 r0 *1 53.58,65.8
X$2442 1936 2069 85 109 2083 NAND2_X1
* cell instance $2444 r0 *1 54.91,65.8
X$2444 2059 1936 1891 85 109 2068 NAND3_X1
* cell instance $2447 m0 *1 57.76,65.8
X$2447 1863 1864 1865 1824 109 85 2030 AND4_X1
* cell instance $2450 m0 *1 59.09,65.8
X$2450 1919 1889 2029 109 85 2032 HA_X1
* cell instance $2453 m0 *1 61.94,65.8
X$2453 1918 1779 1867 1849 109 85 2002 AND4_X1
* cell instance $2454 m0 *1 63.08,65.8
X$2454 1780 2001 85 109 2015 XOR2_X1
* cell instance $2455 m0 *1 64.22,65.8
X$2455 1780 2002 109 85 2055 AND2_X1
* cell instance $2458 m0 *1 65.93,65.8
X$2458 1780 1781 109 85 2033 AND2_X1
* cell instance $2459 m0 *1 66.69,65.8
X$2459 2002 2033 109 85 2034 AND2_X1
* cell instance $2462 m0 *1 68.4,65.8
X$2462 1905 2003 85 109 1965 XOR2_X1
* cell instance $2464 m0 *1 71.06,65.8
X$2464 1937 85 109 2441 INV_X1
* cell instance $2467 r0 *1 58.14,65.8
X$2467 2017 109 2036 85 BUF_X4
* cell instance $2471 r0 *1 59.47,65.8
X$2471 2030 109 2031 85 BUF_X4
* cell instance $2472 r0 *1 60.8,65.8
X$2472 2017 85 109 2058 CLKBUF_X3
* cell instance $2475 r0 *1 63.46,65.8
X$2475 2002 2031 2058 2059 85 109 2001 NAND4_X1
* cell instance $2477 r0 *1 64.79,65.8
X$2477 2055 2031 2058 2069 85 109 2013 NAND4_X1
* cell instance $2479 r0 *1 65.93,65.8
X$2479 1825 2031 2002 2033 109 85 2081 AND4_X1
* cell instance $2480 r0 *1 67.07,65.8
X$2480 2054 2034 2017 2070 85 2005 109 NAND4_X2
* cell instance $2482 r0 *1 68.97,65.8
X$2482 2054 2035 2036 2069 85 109 2003 NAND4_X1
* cell instance $2485 r0 *1 71.06,65.8
X$2485 1881 1905 85 109 2111 NAND2_X1
* cell instance $2486 r0 *1 71.63,65.8
X$2486 2079 2035 2036 2069 85 109 2052 NAND4_X1
* cell instance $2487 m0 *1 72.96,65.8
X$2487 1905 85 109 2006 BUF_X1
* cell instance $2488 m0 *1 71.82,65.8
X$2488 1967 2052 85 109 2004 XOR2_X1
* cell instance $2491 r0 *1 72.58,65.8
X$2491 1966 1906 1845 1882 85 2071 109 NAND4_X2
* cell instance $2492 r0 *1 74.29,65.8
X$2492 1941 1940 85 109 2076 NAND2_X1
* cell instance $2493 m0 *1 74.86,65.8
X$2493 1781 85 109 2040 BUF_X1
* cell instance $2497 m0 *1 76.38,65.8
X$2497 1940 1881 85 109 2037 NAND2_X1
* cell instance $2498 m0 *1 76.95,65.8
X$2498 2037 2005 1941 109 2038 85 OAI21_X1
* cell instance $2499 m0 *1 77.71,65.8
X$2499 2039 85 109 1941 BUF_X1
* cell instance $2504 r0 *1 75.81,65.8
X$2504 1941 2005 2037 85 109 2049 OR3_X1
* cell instance $2505 r0 *1 76.76,65.8
X$2505 495 2049 2038 85 2046 109 AOI21_X1
* cell instance $2506 r0 *1 77.52,65.8
X$2506 85 2039 2046 1937 109 DFF_X1
* cell instance $2508 m0 *1 80.18,65.8
X$2508 2039 85 109 2008 BUF_X1
* cell instance $2510 m0 *1 28.69,79.8
X$2510 1897 85 109 2305 BUF_X1
* cell instance $2512 m0 *1 29.26,79.8
X$2512 1683 85 109 2308 BUF_X1
* cell instance $2513 m0 *1 29.83,79.8
X$2513 1720 85 109 2309 BUF_X1
* cell instance $2514 m0 *1 30.4,79.8
X$2514 2138 85 109 2311 BUF_X1
* cell instance $2515 m0 *1 30.97,79.8
X$2515 2180 85 109 2313 BUF_X1
* cell instance $2516 m0 *1 31.54,79.8
X$2516 2124 85 109 2329 BUF_X1
* cell instance $2517 m0 *1 32.11,79.8
X$2517 1952 85 109 2330 BUF_X1
* cell instance $2518 m0 *1 32.68,79.8
X$2518 1497 85 109 2331 BUF_X1
* cell instance $2519 m0 *1 33.25,79.8
X$2519 2125 85 109 2320 BUF_X1
* cell instance $2520 m0 *1 33.82,79.8
X$2520 1686 85 109 2318 BUF_X1
* cell instance $2521 m0 *1 34.39,79.8
X$2521 1814 85 109 2322 BUF_X1
* cell instance $2523 m0 *1 1.33,51.8
X$2523 1557 85 109 1535 BUF_X1
* cell instance $2525 m0 *1 1.9,51.8
X$2525 1576 85 109 1488 BUF_X1
* cell instance $2528 r0 *1 1.33,51.8
X$2528 1611 85 109 1575 BUF_X1
* cell instance $2530 m0 *1 3.04,51.8
X$2530 85 1576 1558 1316 109 DFF_X1
* cell instance $2532 m0 *1 6.27,51.8
X$2532 1538 85 109 1536 BUF_X1
* cell instance $2533 m0 *1 6.84,51.8
X$2533 1412 1320 109 85 1637 XNOR2_X1
* cell instance $2539 r0 *1 3.8,51.8
X$2539 1610 85 109 1609 BUF_X1
* cell instance $2540 r0 *1 4.37,51.8
X$2540 85 1610 1636 1316 109 DFF_X1
* cell instance $2541 r0 *1 7.6,51.8
X$2541 1637 945 85 109 1636 NOR2_X1
* cell instance $2542 r0 *1 8.17,51.8
X$2542 1610 85 109 1412 BUF_X2
* cell instance $2544 m0 *1 8.36,51.8
X$2544 1582 85 109 1537 BUF_X1
* cell instance $2545 m0 *1 9.69,51.8
X$2545 1561 945 85 109 1577 NOR2_X1
* cell instance $2547 m0 *1 10.45,51.8
X$2547 1367 1486 1578 85 1541 109 AOI21_X1
* cell instance $2549 r0 *1 8.93,51.8
X$2549 85 1611 1577 1316 109 DFF_X1
* cell instance $2550 m0 *1 11.78,51.8
X$2550 1479 1579 85 109 1561 XOR2_X1
* cell instance $2553 m0 *1 13.11,51.8
X$2553 1479 1580 109 85 1543 AND2_X1
* cell instance $2554 m0 *1 13.87,51.8
X$2554 1479 1163 1099 1580 109 85 1562 AND4_X1
* cell instance $2555 m0 *1 15.01,51.8
X$2555 85 674 1563 1638 1564 1320 109 NOR4_X4
* cell instance $2557 r0 *1 12.16,51.8
X$2557 1611 85 109 1479 BUF_X2
* cell instance $2559 r0 *1 13.3,51.8
X$2559 1580 1491 1451 567 85 109 1579 NAND4_X1
* cell instance $2560 r0 *1 14.25,51.8
X$2560 552 1491 85 109 1612 NAND2_X1
* cell instance $2561 r0 *1 14.82,51.8
X$2561 612 1612 1613 85 1667 109 AOI21_X1
* cell instance $2562 r0 *1 15.58,51.8
X$2562 659 1563 85 109 1613 NAND2_X1
* cell instance $2563 r0 *1 16.15,51.8
X$2563 1563 85 109 1451 INV_X2
* cell instance $2564 r0 *1 16.72,51.8
X$2564 1479 1493 85 109 1638 NAND2_X1
* cell instance $2566 r0 *1 17.67,51.8
X$2566 1372 1491 85 109 1564 NAND2_X2
* cell instance $2568 r0 *1 18.81,51.8
X$2568 1370 85 109 CLKBUF_X1
* cell instance $2569 m0 *1 20.71,51.8
X$2569 803 1544 109 85 1603 AND2_X1
* cell instance $2570 m0 *1 18.81,51.8
X$2570 1372 1538 1566 109 85 1580 HA_X1
* cell instance $2571 m0 *1 21.47,51.8
X$2571 1538 85 109 1493 CLKBUF_X2
* cell instance $2572 m0 *1 22.23,51.8
X$2572 85 1582 1581 1370 109 DFF_X1
* cell instance $2573 m0 *1 25.46,51.8
X$2573 1582 85 109 1545 BUF_X2
* cell instance $2575 r0 *1 19.38,51.8
X$2575 85 1538 1603 1370 109 DFF_X1
* cell instance $2577 r0 *1 22.99,51.8
X$2577 945 1614 1640 85 1581 109 AOI21_X1
* cell instance $2578 r0 *1 23.75,51.8
X$2578 1453 1123 1545 109 1640 85 OAI21_X1
* cell instance $2579 r0 *1 24.51,51.8
X$2579 965 85 109 1354 CLKBUF_X3
* cell instance $2581 r0 *1 25.84,51.8
X$2581 1545 1123 1453 85 109 1614 OR3_X1
* cell instance $2582 m0 *1 26.79,51.8
X$2582 1583 1545 85 109 1641 NAND2_X1
* cell instance $2584 m0 *1 27.36,51.8
X$2584 1494 803 109 85 1584 AND2_X1
* cell instance $2586 m0 *1 29.64,51.8
X$2586 827 1644 1169 1127 1545 1606 109 85 AOI221_X2
* cell instance $2587 m0 *1 31.73,51.8
X$2587 1615 1416 1654 85 1569 109 AOI21_X1
* cell instance $2589 m0 *1 32.68,51.8
X$2589 710 1585 1169 1127 1455 1572 109 85 AOI221_X2
* cell instance $2593 m0 *1 37.24,51.8
X$2593 85 1586 1547 1617 1266 109 DFF_X2
* cell instance $2594 m0 *1 40.85,51.8
X$2594 1354 85 109 1547 CLKBUF_X3
* cell instance $2595 m0 *1 41.8,51.8
X$2595 724 1648 109 85 1586 AND2_X1
* cell instance $2599 r0 *1 26.98,51.8
X$2599 1705 1641 1584 85 109 1642 MUX2_X1
* cell instance $2601 r0 *1 29.83,51.8
X$2601 1615 1416 1684 85 1644 109 AOI21_X1
* cell instance $2602 r0 *1 30.59,51.8
X$2602 1455 1494 1545 1497 85 1653 109 NAND4_X2
* cell instance $2604 r0 *1 32.68,51.8
X$2604 1615 1416 1685 85 1585 109 AOI21_X1
* cell instance $2605 r0 *1 33.44,51.8
X$2605 1615 1416 1616 85 1645 109 AOI21_X1
* cell instance $2606 r0 *1 34.2,51.8
X$2606 791 1645 1169 1127 1497 1646 109 85 AOI221_X2
* cell instance $2609 r0 *1 37.43,51.8
X$2609 1647 85 109 1498 CLKBUF_X2
* cell instance $2611 r0 *1 39.71,51.8
X$2611 1617 1526 1266 85 109 1648 MUX2_X1
* cell instance $2612 r0 *1 41.04,51.8
X$2612 1547 85 109 CLKBUF_X1
* cell instance $2614 r0 *1 41.8,51.8
X$2614 85 1678 1608 1547 109 DFF_X1
* cell instance $2615 m0 *1 45.03,51.8
X$2615 1029 1528 1587 85 109 1567 OR3_X1
* cell instance $2616 m0 *1 44.46,51.8
X$2616 1607 487 85 109 1608 NOR2_X1
* cell instance $2618 r0 *1 45.03,51.8
X$2618 1690 1129 85 109 1587 NOR2_X1
* cell instance $2620 m0 *1 47.31,51.8
X$2620 1029 1572 1649 85 109 1565 OR3_X1
* cell instance $2621 m0 *1 46.36,51.8
X$2621 1029 1606 1655 85 109 1599 OR3_X1
* cell instance $2623 m0 *1 48.83,51.8
X$2623 1548 1574 85 109 1605 XOR2_X1
* cell instance $2625 m0 *1 49.97,51.8
X$2625 1605 487 85 109 1588 NOR2_X1
* cell instance $2629 m0 *1 53.01,51.8
X$2629 85 1589 1604 1620 109 DFF_X1
* cell instance $2630 m0 *1 56.24,51.8
X$2630 1589 85 109 1505 INV_X1
* cell instance $2631 m0 *1 56.62,51.8
X$2631 1505 552 1590 85 109 1570 MUX2_X1
* cell instance $2632 m0 *1 57.95,51.8
X$2632 965 85 109 1463 CLKBUF_X3
* cell instance $2633 m0 *1 58.9,51.8
X$2633 85 1506 1602 565 1505 1396 109 NAND4_X4
* cell instance $2634 m0 *1 62.32,51.8
X$2634 1601 721 85 109 1600 NOR2_X1
* cell instance $2635 m0 *1 62.89,51.8
X$2635 85 1593 1592 1620 109 DFF_X1
* cell instance $2641 r0 *1 49.4,51.8
X$2641 85 1588 1692 2414 1548 109 DFF_X2
* cell instance $2645 r0 *1 55.1,51.8
X$2645 85 674 1589 1590 1591 109 NOR3_X4
* cell instance $2647 r0 *1 57.95,51.8
X$2647 1506 85 109 1590 INV_X1
* cell instance $2648 r0 *1 58.33,51.8
X$2648 1618 589 85 109 1650 NOR2_X1
* cell instance $2649 r0 *1 58.9,51.8
X$2649 1619 1659 1591 85 1618 109 AOI21_X1
* cell instance $2653 r0 *1 59.66,51.8
X$2653 1591 1270 85 109 1619 NOR2_X1
* cell instance $2658 r0 *1 63.08,51.8
X$2658 85 1600 1620 2419 1424 109 DFF_X2
* cell instance $2661 r0 *1 67.64,51.8
X$2661 745 1568 1695 1134 1704 1643 109 85 AOI221_X2
* cell instance $2664 r0 *1 70.68,51.8
X$2664 1622 448 85 109 1621 NOR2_X1
* cell instance $2665 r0 *1 71.25,51.8
X$2665 1643 85 109 1633 BUF_X1
* cell instance $2666 m0 *1 72.96,51.8
X$2666 1565 740 1625 1134 1598 85 109 1597 AOI221_X1
* cell instance $2667 m0 *1 71.82,51.8
X$2667 1599 741 1623 1134 1464 85 109 1596 AOI221_X1
* cell instance $2668 m0 *1 74.1,51.8
X$2668 1551 1238 1333 1396 85 109 1560 NOR4_X1
* cell instance $2669 m0 *1 75.05,51.8
X$2669 1552 1560 109 85 1594 XNOR2_X1
* cell instance $2670 m0 *1 76.19,51.8
X$2670 1594 448 85 109 1553 NOR2_X1
* cell instance $2671 m0 *1 76.76,51.8
X$2671 1597 85 109 1554 BUF_X1
* cell instance $2672 m0 *1 77.33,51.8
X$2672 1518 85 109 1511 BUF_X1
* cell instance $2674 r0 *1 71.82,51.8
X$2674 1624 1509 109 85 1622 XNOR2_X1
* cell instance $2675 r0 *1 72.96,51.8
X$2675 1639 1238 1333 1396 85 109 1669 NOR4_X1
* cell instance $2676 r0 *1 73.91,51.8
X$2676 1626 1238 1333 1396 85 109 1627 NOR4_X1
* cell instance $2677 r0 *1 74.86,51.8
X$2677 1628 1627 109 85 1629 XNOR2_X1
* cell instance $2678 r0 *1 76,51.8
X$2678 1629 448 85 109 1631 NOR2_X1
* cell instance $2679 r0 *1 76.57,51.8
X$2679 85 1632 1631 1670 109 DFF_X1
* cell instance $2680 m0 *1 78.47,51.8
X$2680 1596 85 109 1556 BUF_X1
* cell instance $2682 m0 *1 79.04,51.8
X$2682 1425 85 109 1555 BUF_X1
* cell instance $2683 m0 *1 79.61,51.8
X$2683 1510 85 109 1466 BUF_X1
* cell instance $2686 r0 *1 80.18,51.8
X$2686 1593 85 109 1635 BUF_X1
* cell instance $2690 m0 *1 2.85,35
X$2690 993 85 109 1034 BUF_X1
* cell instance $2691 m0 *1 2.28,35
X$2691 1011 85 109 991 BUF_X1
* cell instance $2692 m0 *1 3.42,35
X$2692 85 968 1012 726 109 DFF_X1
* cell instance $2693 m0 *1 6.65,35
X$2693 1011 85 109 881 BUF_X2
* cell instance $2695 m0 *1 7.6,35
X$2695 881 437 109 85 994 XNOR2_X1
* cell instance $2697 m0 *1 1.33,35
X$2697 968 85 109 992 BUF_X1
* cell instance $2701 r0 *1 1.33,35
X$2701 1042 85 109 1035 BUF_X1
* cell instance $2709 r0 *1 4.75,35
X$2709 85 1011 1091 726 109 DFF_X1
* cell instance $2710 r0 *1 7.98,35
X$2710 994 1036 85 109 1091 NOR2_X1
* cell instance $2711 r0 *1 8.55,35
X$2711 1038 85 109 1077 BUF_X1
* cell instance $2712 m0 *1 9.31,35
X$2712 800 1013 85 109 995 XOR2_X1
* cell instance $2714 m0 *1 10.45,35
X$2714 995 1001 85 109 997 NOR2_X1
* cell instance $2715 m0 *1 11.02,35
X$2715 969 1001 85 109 1012 NOR2_X1
* cell instance $2720 r0 *1 9.88,35
X$2720 85 997 1037 2404 800 109 DFF_X2
* cell instance $2721 r0 *1 13.49,35
X$2721 85 1094 1037 2406 1038 109 DFF_X2
* cell instance $2722 m0 *1 15.96,35
X$2722 970 971 85 109 927 NOR2_X1
* cell instance $2725 m0 *1 17.29,35
X$2725 411 85 109 1036 CLKBUF_X3
* cell instance $2728 m0 *1 19.19,35
X$2728 1018 971 85 109 1017 NOR2_X1
* cell instance $2732 r0 *1 17.29,35
X$2732 85 1039 666 2401 993 109 DFF_X2
* cell instance $2734 m0 *1 21.09,35
X$2734 705 1019 998 1000 999 1066 109 85 AOI221_X2
* cell instance $2736 m0 *1 23.18,35
X$2736 562 1040 998 1000 993 960 109 85 AOI221_X2
* cell instance $2739 r0 *1 21.28,35
X$2739 533 1118 998 1000 1038 1067 109 85 AOI221_X2
* cell instance $2740 r0 *1 23.37,35
X$2740 634 1120 998 1000 1070 1069 109 85 AOI221_X2
* cell instance $2741 r0 *1 25.46,35
X$2741 582 1068 1169 1000 1025 1071 109 85 AOI221_X2
* cell instance $2743 m0 *1 26.41,35
X$2743 1023 971 85 109 972 NOR2_X1
* cell instance $2745 r0 *1 27.55,35
X$2745 1025 1041 109 85 1023 XNOR2_X1
* cell instance $2747 r0 *1 28.88,35
X$2747 411 85 109 1001 CLKBUF_X3
* cell instance $2748 m0 *1 29.64,35
X$2748 411 109 183 85 BUF_X4
* cell instance $2749 m0 *1 28.88,35
X$2749 923 85 109 1025 CLKBUF_X2
* cell instance $2750 m0 *1 30.97,35
X$2750 1002 971 85 109 1072 NOR2_X1
* cell instance $2754 r0 *1 29.83,35
X$2754 1042 1084 109 85 1002 XNOR2_X1
* cell instance $2755 r0 *1 30.97,35
X$2755 85 1072 1043 2392 1042 109 DFF_X2
* cell instance $2758 m0 *1 38.95,35
X$2758 945 1031 989 85 1030 109 AOI21_X1
* cell instance $2760 m0 *1 39.71,35
X$2760 975 933 1003 85 109 1031 OR3_X1
* cell instance $2761 m0 *1 40.66,35
X$2761 1003 933 975 109 989 85 OAI21_X1
* cell instance $2764 r0 *1 39.33,35
X$2764 85 127 1109 829 109 DFF_X1
* cell instance $2765 m0 *1 41.8,35
X$2765 975 85 109 1033 INV_X1
* cell instance $2766 m0 *1 42.18,35
X$2766 1033 1044 932 1003 85 109 990 OR4_X1
* cell instance $2768 r0 *1 42.56,35
X$2768 127 85 109 1173 BUF_X1
* cell instance $2771 r0 *1 43.7,35
X$2771 1045 487 85 109 1109 NOR2_X1
* cell instance $2772 m0 *1 44.46,35
X$2772 128 976 85 109 1004 NOR2_X1
* cell instance $2773 m0 *1 43.7,35
X$2773 975 128 109 85 1047 AND2_X1
* cell instance $2776 r0 *1 44.46,35
X$2776 978 1075 1004 85 109 964 OR3_X1
* cell instance $2779 m0 *1 45.41,35
X$2779 978 1066 929 85 109 985 OR3_X1
* cell instance $2780 r0 *1 46.74,35
X$2780 1048 1005 1049 1047 85 886 109 NAND4_X2
* cell instance $2784 m0 *1 51.3,35
X$2784 978 1067 934 85 109 984 OR3_X1
* cell instance $2785 m0 *1 52.25,35
X$2785 1029 1071 977 85 109 1016 OR3_X1
* cell instance $2787 m0 *1 53.39,35
X$2787 1029 1069 1028 85 109 983 OR3_X1
* cell instance $2788 m0 *1 54.34,35
X$2788 1005 976 85 109 1026 NOR2_X1
* cell instance $2790 r0 *1 48.45,35
X$2790 1049 1005 1048 1047 109 85 1074 AND4_X1
* cell instance $2791 r0 *1 49.59,35
X$2791 1074 109 842 85 BUF_X4
* cell instance $2792 r0 *1 50.92,35
X$2792 1048 841 1049 844 85 109 1107 NAND4_X1
* cell instance $2794 r0 *1 52.25,35
X$2794 1005 1107 85 109 1073 XOR2_X1
* cell instance $2797 r0 *1 53.96,35
X$2797 1073 375 85 109 1051 NOR2_X1
* cell instance $2800 r0 *1 55.1,35
X$2800 85 1052 1051 774 109 DFF_X1
* cell instance $2802 m0 *1 55.29,35
X$2802 978 1027 1026 85 109 1022 OR3_X1
* cell instance $2803 m0 *1 56.43,35
X$2803 383 85 109 1049 BUF_X2
* cell instance $2805 m0 *1 57.76,35
X$2805 1052 85 109 1005 CLKBUF_X2
* cell instance $2808 m0 *1 60.04,35
X$2808 1024 721 85 109 986 NOR2_X1
* cell instance $2812 r0 *1 58.9,35
X$2812 85 986 774 2394 1053 109 DFF_X2
* cell instance $2816 m0 *1 62.13,35
X$2816 811 1022 1021 979 1054 550 109 85 AOI221_X2
* cell instance $2817 m0 *1 60.99,35
X$2817 1054 1065 109 85 1024 XNOR2_X1
* cell instance $2818 m0 *1 64.22,35
X$2818 813 985 1020 979 1056 549 109 85 AOI221_X2
* cell instance $2819 m0 *1 66.31,35
X$2819 846 984 1226 979 957 1009 109 85 AOI221_X2
* cell instance $2820 m0 *1 68.4,35
X$2820 847 1016 1276 979 941 1015 109 85 AOI221_X2
* cell instance $2824 m0 *1 72.96,35
X$2824 1014 935 891 727 85 109 1100 NAND4_X1
* cell instance $2825 m0 *1 73.91,35
X$2825 894 897 939 109 85 1014 AND3_X1
* cell instance $2826 m0 *1 74.86,35
X$2826 1014 935 889 85 109 980 NAND3_X1
* cell instance $2827 m0 *1 75.62,35
X$2827 1063 772 85 109 981 NOR2_X1
* cell instance $2828 m0 *1 76.19,35
X$2828 1010 85 109 1059 BUF_X1
* cell instance $2830 r0 *1 62.51,35
X$2830 1053 85 109 1054 INV_X2
* cell instance $2833 r0 *1 63.65,35
X$2833 1087 889 85 109 1065 NAND2_X1
* cell instance $2834 r0 *1 64.22,35
X$2834 1055 1086 85 109 1087 NOR2_X1
* cell instance $2836 r0 *1 65.17,35
X$2836 1056 1102 109 85 1064 XNOR2_X1
* cell instance $2838 r0 *1 66.5,35
X$2838 1064 772 85 109 1103 NOR2_X1
* cell instance $2840 r0 *1 67.45,35
X$2840 1133 85 109 1056 INV_X2
* cell instance $2845 r0 *1 73.15,35
X$2845 1057 1100 109 85 1063 XNOR2_X1
* cell instance $2846 r0 *1 74.29,35
X$2846 1062 85 109 1057 INV_X1
* cell instance $2847 r0 *1 74.67,35
X$2847 1098 85 109 1093 BUF_X1
* cell instance $2849 r0 *1 75.43,35
X$2849 85 1062 981 1088 109 DFF_X1
* cell instance $2850 m0 *1 77.33,35
X$2850 1009 85 109 982 BUF_X1
* cell instance $2852 m0 *1 77.9,35
X$2852 1053 85 109 1060 BUF_X1
* cell instance $2855 m0 *1 79.42,35
X$2855 1052 85 109 1007 BUF_X1
* cell instance $2857 m0 *1 80.18,35
X$2857 1006 85 109 1061 BUF_X1
* cell instance $2859 r0 *1 78.66,35
X$2859 1062 85 109 1008 BUF_X1
* cell instance $2860 r0 *1 79.23,35
X$2860 1058 85 109 1090 BUF_X1
* cell instance $2861 r0 *1 79.8,35
X$2861 1133 85 109 1092 BUF_X1
* cell instance $2864 m0 *1 1.9,60.2
X$2864 1714 85 109 1758 BUF_X1
* cell instance $2868 m0 *1 3.42,60.2
X$2868 1712 85 109 1757 BUF_X1
* cell instance $2878 r0 *1 3.61,60.2
X$2878 85 1851 1926 2393 1760 109 DFF_X2
* cell instance $2879 m0 *1 4.56,60.2
X$2879 1760 85 109 1809 BUF_X1
* cell instance $2883 m0 *1 5.51,60.2
X$2883 1875 183 85 109 1851 NOR2_X1
* cell instance $2884 m0 *1 6.65,60.2
X$2884 1766 85 109 1808 BUF_X1
* cell instance $2886 m0 *1 7.22,60.2
X$2886 1810 1761 1578 85 109 1838 NOR3_X1
* cell instance $2887 m0 *1 7.98,60.2
X$2887 1714 1838 109 85 1852 XNOR2_X1
* cell instance $2888 m0 *1 9.12,60.2
X$2888 1852 1036 85 109 1839 NOR2_X1
* cell instance $2895 r0 *1 11.4,60.2
X$2895 1716 85 109 CLKBUF_X1
* cell instance $2896 r0 *1 11.97,60.2
X$2896 85 1853 1716 2403 1892 109 DFF_X2
* cell instance $2897 m0 *1 12.92,60.2
X$2897 1811 552 1854 85 109 1877 MUX2_X1
* cell instance $2898 m0 *1 12.35,60.2
X$2898 1877 612 85 109 1853 NOR2_X1
* cell instance $2899 m0 *1 14.25,60.2
X$2899 1354 85 109 1716 CLKBUF_X3
* cell instance $2901 m0 *1 15.39,60.2
X$2901 1892 85 109 1811 INV_X2
* cell instance $2903 m0 *1 16.15,60.2
X$2903 1763 1811 567 85 109 1765 NAND3_X1
* cell instance $2904 m0 *1 16.91,60.2
X$2904 1762 1763 85 109 1895 NAND2_X1
* cell instance $2905 m0 *1 17.48,60.2
X$2905 1763 85 109 1854 INV_X1
* cell instance $2907 r0 *1 15.58,60.2
X$2907 674 1892 1854 1893 109 1894 85 OR4_X2
* cell instance $2909 m0 *1 18.43,60.2
X$2909 85 1812 1716 2368 1766 109 DFF_X2
* cell instance $2911 m0 *1 22.04,60.2
X$2911 1896 1001 85 109 1813 NOR2_X1
* cell instance $2917 r0 *1 20.9,60.2
X$2917 85 1767 1813 1910 109 DFF_X1
* cell instance $2919 m0 *1 26.03,60.2
X$2919 1768 1718 85 109 1879 NAND2_X1
* cell instance $2920 m0 *1 25.27,60.2
X$2920 1879 1453 1123 85 109 1855 NOR3_X1
* cell instance $2921 m0 *1 26.6,60.2
X$2921 85 1880 1652 2376 1720 109 DFF_X2
* cell instance $2923 m0 *1 30.97,60.2
X$2923 1846 1453 1123 85 109 1884 NOR3_X1
* cell instance $2927 m0 *1 34.2,60.2
X$2927 1772 1814 85 109 1847 NOR2_X1
* cell instance $2928 m0 *1 34.77,60.2
X$2928 1885 1884 1847 85 109 1886 MUX2_X1
* cell instance $2931 r0 *1 25.65,60.2
X$2931 1769 1815 109 85 1856 AND2_X1
* cell instance $2932 r0 *1 26.41,60.2
X$2932 1856 1855 1911 85 109 1912 MUX2_X1
* cell instance $2933 r0 *1 27.74,60.2
X$2933 1772 1769 85 109 1911 NOR2_X1
* cell instance $2936 r0 *1 28.88,60.2
X$2936 1897 85 109 1769 CLKBUF_X2
* cell instance $2938 r0 *1 29.83,60.2
X$2938 1960 1654 1684 85 109 1898 NOR3_X1
* cell instance $2939 r0 *1 30.59,60.2
X$2939 1652 85 109 CLKBUF_X1
* cell instance $2941 r0 *1 31.35,60.2
X$2941 1913 85 109 1794 INV_X1
* cell instance $2942 r0 *1 31.73,60.2
X$2942 85 1886 1652 2388 1814 109 DFF_X2
* cell instance $2945 m0 *1 38,60.2
X$2945 612 659 85 109 1815 NOR2_X1
* cell instance $2946 m0 *1 38.76,60.2
X$2946 1857 1815 109 85 1915 AND2_X1
* cell instance $2950 r0 *1 39.14,60.2
X$2950 1915 1916 1899 85 109 1917 MUX2_X1
* cell instance $2952 r0 *1 40.66,60.2
X$2952 1772 1857 85 109 1899 NOR2_X1
* cell instance $2954 m0 *1 41.99,60.2
X$2954 1888 1327 85 109 1773 NOR2_X1
* cell instance $2955 m0 *1 41.42,60.2
X$2955 1857 1327 85 109 1817 NOR2_X1
* cell instance $2956 m0 *1 42.56,60.2
X$2956 1963 1327 85 109 1848 NOR2_X1
* cell instance $2957 m0 *1 43.13,60.2
X$2957 1818 1690 1406 85 109 1920 OR3_X1
* cell instance $2959 m0 *1 44.27,60.2
X$2959 1753 85 109 1818 INV_X1
* cell instance $2962 r0 *1 42.94,60.2
X$2962 1818 1406 1690 109 1900 85 OAI21_X1
* cell instance $2964 r0 *1 43.89,60.2
X$2964 790 1920 1900 85 1921 109 AOI21_X1
* cell instance $2965 r0 *1 44.65,60.2
X$2965 1691 1819 1858 85 109 1923 OR3_X1
* cell instance $2967 m0 *1 45.03,60.2
X$2967 1690 1753 85 109 1858 NAND2_X1
* cell instance $2969 m0 *1 45.79,79.8
X$2969 2140 85 109 2316 BUF_X1
* cell instance $2972 m0 *1 42.75,79.8
X$2972 1933 85 109 2321 BUF_X1
* cell instance $2975 m0 *1 44.08,79.8
X$2975 1753 85 109 2317 BUF_X1
* cell instance $2976 m0 *1 44.65,79.8
X$2976 1678 85 109 2333 BUF_X1
* cell instance $2978 m0 *1 41.61,79.8
X$2978 1963 85 109 2319 BUF_X1
* cell instance $2981 m0 *1 78.85,46.2
X$2981 1335 85 109 1339 BUF_X1
* cell instance $2982 m0 *1 78.28,46.2
X$2982 1381 85 109 1380 BUF_X1
* cell instance $2983 m0 *1 79.42,46.2
X$2983 1381 85 109 1382 BUF_X1
* cell instance $2986 r0 *1 78.28,46.2
X$2986 1435 85 109 1433 BUF_X1
* cell instance $2989 r0 *1 79.42,46.2
X$2989 1429 85 109 1384 BUF_X1
* cell instance $2992 m0 *1 1.33,40.6
X$2992 1193 85 109 1190 BUF_X1
* cell instance $2994 m0 *1 1.9,40.6
X$2994 1234 85 109 1217 BUF_X1
* cell instance $3004 r0 *1 3.42,40.6
X$3004 1233 1252 85 109 1160 NOR2_X1
* cell instance $3005 m0 *1 3.8,40.6
X$3005 85 1234 1161 1037 109 DFF_X1
* cell instance $3007 m0 *1 7.03,40.6
X$3007 1167 85 109 1159 BUF_X1
* cell instance $3008 m0 *1 7.6,40.6
X$3008 85 1162 1037 2356 1193 109 DFF_X2
* cell instance $3012 r0 *1 3.99,40.6
X$3012 1219 85 109 1250 BUF_X1
* cell instance $3013 r0 *1 4.56,40.6
X$3013 1234 85 109 1253 BUF_X2
* cell instance $3015 r0 *1 5.7,40.6
X$3015 1254 1256 85 109 1233 XOR2_X1
* cell instance $3016 r0 *1 6.84,40.6
X$3016 1265 85 109 1249 BUF_X1
* cell instance $3017 r0 *1 7.41,40.6
X$3017 1193 1257 109 85 1218 XNOR2_X1
* cell instance $3018 r0 *1 8.55,40.6
X$3018 1218 1252 85 109 1162 NOR2_X1
* cell instance $3021 r0 *1 9.69,40.6
X$3021 1288 1252 85 109 1235 NOR2_X1
* cell instance $3024 r0 *1 11.21,40.6
X$3024 1163 1289 85 109 1288 XOR2_X1
* cell instance $3025 r0 *1 12.35,40.6
X$3025 1286 1252 85 109 1142 NOR2_X1
* cell instance $3026 r0 *1 12.92,40.6
X$3026 882 1324 1291 1221 1254 1237 109 85 AOI221_X2
* cell instance $3027 r0 *1 15.01,40.6
X$3027 85 1219 1293 1037 109 DFF_X1
* cell instance $3028 m0 *1 15.58,40.6
X$3028 1239 971 85 109 1293 NOR2_X1
* cell instance $3033 m0 *1 17.29,40.6
X$3033 1116 1164 109 85 1239 XNOR2_X1
* cell instance $3034 m0 *1 18.62,40.6
X$3034 716 85 109 1119 BUF_X2
* cell instance $3036 m0 *1 20.9,40.6
X$3036 787 1165 998 1000 1163 1197 109 85 AOI221_X2
* cell instance $3037 m0 *1 22.99,40.6
X$3037 1166 1119 1200 85 1040 109 AOI21_X1
* cell instance $3039 m0 *1 23.94,40.6
X$3039 1166 1119 1201 85 1068 109 AOI21_X1
* cell instance $3040 m0 *1 24.7,40.6
X$3040 85 1167 1202 1043 109 DFF_X1
* cell instance $3042 m0 *1 30.97,40.6
X$3042 85 1125 1168 1043 109 DFF_X1
* cell instance $3045 m0 *1 38.76,40.6
X$3045 945 1208 1209 85 1248 109 AOI21_X1
* cell instance $3046 m0 *1 39.52,40.6
X$3046 1171 933 1170 109 1209 85 OAI21_X1
* cell instance $3047 m0 *1 40.28,40.6
X$3047 1170 933 1171 85 109 1208 OR3_X1
* cell instance $3049 r0 *1 18.24,40.6
X$3049 1219 85 109 1116 CLKBUF_X2
* cell instance $3050 r0 *1 19,40.6
X$3050 1260 1220 1116 999 85 109 1195 NAND4_X1
* cell instance $3051 r0 *1 19.95,40.6
X$3051 1221 1119 1297 85 1019 109 AOI21_X1
* cell instance $3053 r0 *1 20.9,40.6
X$3053 823 1295 998 1000 1193 1241 109 85 AOI221_X2
* cell instance $3055 r0 *1 23.37,40.6
X$3055 1221 109 1000 85 BUF_X4
* cell instance $3057 r0 *1 25.08,40.6
X$3057 1080 1260 1220 85 109 1079 NAND3_X1
* cell instance $3060 r0 *1 26.98,40.6
X$3060 998 85 109 1224 INV_X1
* cell instance $3061 r0 *1 27.36,40.6
X$3061 1080 1222 109 85 1351 AND2_X1
* cell instance $3065 r0 *1 29.45,40.6
X$3065 1222 1080 1261 85 109 1262 NAND3_X1
* cell instance $3066 r0 *1 30.21,40.6
X$3066 1264 1356 109 85 1263 XNOR2_X1
* cell instance $3067 r0 *1 31.35,40.6
X$3067 711 1357 1169 1127 1261 1223 109 85 AOI221_X2
* cell instance $3068 r0 *1 33.44,40.6
X$3068 752 1306 1169 1127 1264 1245 109 85 AOI221_X2
* cell instance $3071 r0 *1 37.24,40.6
X$3071 85 1265 1248 1043 109 DFF_X1
* cell instance $3072 r0 *1 40.47,40.6
X$3072 1310 85 109 965 CLKBUF_X3
* cell instance $3073 r0 *1 41.42,40.6
X$3073 1265 85 109 1170 BUF_X2
* cell instance $3074 m0 *1 42.56,40.6
X$3074 1170 85 109 1172 INV_X1
* cell instance $3075 m0 *1 41.61,40.6
X$3075 1171 932 1044 1172 85 109 1156 NOR4_X1
* cell instance $3077 m0 *1 43.13,40.6
X$3077 1173 873 85 109 1171 NAND2_X1
* cell instance $3079 r0 *1 42.18,40.6
X$3079 1170 1224 85 109 1309 NOR2_X1
* cell instance $3080 r0 *1 42.75,40.6
X$3080 808 1237 1309 85 109 1243 OR3_X1
* cell instance $3081 r0 *1 43.7,40.6
X$3081 1224 85 109 1129 CLKBUF_X3
* cell instance $3083 m0 *1 44.08,40.6
X$3083 1224 85 109 976 CLKBUF_X3
* cell instance $3086 r0 *1 44.65,40.6
X$3086 978 1241 1307 85 109 1242 OR3_X1
* cell instance $3090 m0 *1 47.88,40.6
X$3090 1246 844 85 109 932 NAND2_X2
* cell instance $3092 m0 *1 48.83,40.6
X$3092 844 1247 1246 1048 109 85 1106 AND4_X1
* cell instance $3093 m0 *1 49.97,40.6
X$3093 1174 933 1130 85 109 1215 OR3_X1
* cell instance $3094 m0 *1 50.92,40.6
X$3094 790 1215 1216 85 1244 109 AOI21_X1
* cell instance $3096 r0 *1 47.69,40.6
X$3096 1029 1223 1305 85 109 1205 OR3_X1
* cell instance $3097 r0 *1 48.64,40.6
X$3097 1174 1129 85 109 1305 NOR2_X1
* cell instance $3098 r0 *1 49.21,40.6
X$3098 1029 1245 1268 85 109 1240 OR3_X1
* cell instance $3102 m0 *1 52.06,40.6
X$3102 85 430 1244 1177 109 DFF_X1
* cell instance $3105 m0 *1 57.76,40.6
X$3105 85 1176 1177 2343 390 109 DFF_X2
* cell instance $3106 m0 *1 61.37,40.6
X$3106 390 85 109 1225 INV_X1
* cell instance $3110 r0 *1 52.63,40.6
X$3110 1174 85 109 1329 INV_X1
* cell instance $3113 r0 *1 54.72,40.6
X$3113 808 85 109 978 BUF_X2
* cell instance $3116 r0 *1 57.76,40.6
X$3116 1304 721 85 109 1176 NOR2_X1
* cell instance $3117 r0 *1 58.33,40.6
X$3117 1225 1300 109 85 1304 XNOR2_X1
* cell instance $3121 r0 *1 59.47,40.6
X$3121 1153 1243 1303 1296 1225 1285 109 85 AOI221_X2
* cell instance $3123 r0 *1 61.75,40.6
X$3123 1332 891 1272 85 109 1300 NAND3_X1
* cell instance $3124 r0 *1 62.51,40.6
X$3124 857 1242 1299 979 1273 1236 109 85 AOI221_X2
* cell instance $3126 m0 *1 62.89,40.6
X$3126 1203 390 1272 1178 85 1055 109 NAND4_X2
* cell instance $3127 r0 *1 64.6,40.6
X$3127 1203 85 109 1273 INV_X1
* cell instance $3129 m0 *1 64.98,40.6
X$3129 1178 1274 109 85 1211 XNOR2_X1
* cell instance $3132 m0 *1 70.87,40.6
X$3132 1205 743 1206 1134 1136 85 109 1139 AOI221_X1
* cell instance $3133 m0 *1 72.01,40.6
X$3133 1228 1180 1183 1147 109 1238 85 OR4_X2
* cell instance $3134 m0 *1 73.34,40.6
X$3134 1138 1183 85 109 1184 NOR2_X1
* cell instance $3135 m0 *1 73.91,40.6
X$3135 1230 1138 1183 109 1229 85 NOR3_X2
* cell instance $3138 r0 *1 65.74,40.6
X$3138 1296 109 979 85 BUF_X4
* cell instance $3141 r0 *1 68.21,40.6
X$3141 1227 85 109 809 BUF_X2
* cell instance $3144 r0 *1 71.25,40.6
X$3144 1240 907 1294 1134 1228 85 109 1181 AOI221_X1
* cell instance $3146 r0 *1 72.77,40.6
X$3146 1089 85 109 1228 INV_X1
* cell instance $3147 r0 *1 73.15,40.6
X$3147 1184 935 891 1137 85 109 1182 NAND4_X1
* cell instance $3148 r0 *1 74.1,40.6
X$3148 1089 505 1137 85 109 1230 NAND3_X1
* cell instance $3149 r0 *1 74.86,40.6
X$3149 1184 935 889 85 109 1185 NAND3_X1
* cell instance $3150 r0 *1 75.62,40.6
X$3150 1236 85 109 1232 BUF_X1
* cell instance $3151 m0 *1 76.57,40.6
X$3151 85 1188 1088 2350 505 109 DFF_X2
* cell instance $3152 m0 *1 75.62,40.6
X$3152 1089 1185 1187 85 109 1231 OR3_X1
* cell instance $3153 m0 *1 80.18,40.6
X$3153 1181 85 109 1194 BUF_X1
* cell instance $3155 r0 *1 76.19,40.6
X$3155 928 1231 1186 85 1284 109 AOI21_X1
* cell instance $3157 r0 *1 77.33,40.6
X$3157 85 1089 1284 1088 109 DFF_X1
* cell instance $3160 m0 *1 54.91,79.8
X$3160 2249 85 109 2301 BUF_X1
* cell instance $3162 m0 *1 55.48,79.8
X$3162 2265 85 109 2299 BUF_X1
* cell instance $3164 m0 *1 57.76,79.8
X$3164 1919 85 109 2296 BUF_X1
* cell instance $3166 m0 *1 58.33,79.8
X$3166 1824 85 109 2279 BUF_X1
* cell instance $3168 m0 *1 59.09,79.8
X$3168 2218 85 109 2294 BUF_X1
* cell instance $3173 m0 *1 56.62,79.8
X$3173 1865 85 109 2297 BUF_X1
* cell instance $3176 m0 *1 62.32,79.8
X$3176 1867 85 109 2288 BUF_X1
* cell instance $3177 m0 *1 61.75,79.8
X$3177 1849 85 109 2290 BUF_X1
* cell instance $3181 m0 *1 66.88,79.8
X$3181 2219 85 109 2285 BUF_X1
* cell instance $3182 m0 *1 67.45,79.8
X$3182 2266 85 109 2282 BUF_X1
* cell instance $3183 m0 *1 68.02,79.8
X$3183 2254 85 109 2281 BUF_X1
* cell instance $3185 m0 *1 1.33,46.2
X$3185 1317 85 109 1314 BUF_X1
* cell instance $3187 m0 *1 1.9,46.2
X$3187 1388 85 109 1362 BUF_X1
* cell instance $3188 m0 *1 2.47,46.2
X$3188 85 1388 1385 1316 109 DFF_X1
* cell instance $3189 m0 *1 5.7,46.2
X$3189 1388 85 109 1365 CLKBUF_X2
* cell instance $3195 r0 *1 3.61,46.2
X$3195 1434 1252 85 109 1385 NOR2_X1
* cell instance $3196 r0 *1 4.18,46.2
X$3196 1325 85 109 1361 BUF_X1
* cell instance $3199 r0 *1 5.7,46.2
X$3199 1365 1470 109 85 1434 XNOR2_X1
* cell instance $3200 r0 *1 6.84,46.2
X$3200 1411 1323 85 109 1470 NOR2_X1
* cell instance $3202 r0 *1 7.6,46.2
X$3202 1413 1363 1412 85 109 1411 NAND3_X1
* cell instance $3203 r0 *1 8.36,46.2
X$3203 1412 1363 1413 1365 109 85 1319 AND4_X2
* cell instance $3204 m0 *1 8.55,46.2
X$3204 1373 85 109 1315 BUF_X1
* cell instance $3207 m0 *1 9.31,46.2
X$3207 996 1364 1390 1393 1365 1392 109 85 AOI221_X2
* cell instance $3208 m0 *1 11.4,46.2
X$3208 1114 1366 1291 1393 1255 1394 109 85 AOI221_X2
* cell instance $3209 m0 *1 13.49,46.2
X$3209 1367 443 1542 85 1368 109 AOI21_X1
* cell instance $3211 m0 *1 15.77,46.2
X$3211 85 1325 1345 1370 109 DFF_X1
* cell instance $3212 m0 *1 19,46.2
X$3212 1367 109 1221 85 BUF_X4
* cell instance $3213 m0 *1 20.33,46.2
X$3213 716 85 109 443 CLKBUF_X3
* cell instance $3214 m0 *1 21.28,46.2
X$3214 1221 109 1393 85 BUF_X4
* cell instance $3216 r0 *1 9.69,46.2
X$3216 1413 1363 1412 1365 85 1321 109 NAND4_X2
* cell instance $3219 r0 *1 11.97,46.2
X$3219 1448 85 109 1491 CLKBUF_X3
* cell instance $3222 r0 *1 14.63,46.2
X$3222 1258 1099 1163 1479 85 109 1369 NAND4_X1
* cell instance $3224 r0 *1 15.96,46.2
X$3224 1414 1437 1321 1369 85 109 1438 OR4_X1
* cell instance $3225 r0 *1 17.1,46.2
X$3225 1438 109 1123 85 BUF_X4
* cell instance $3228 r0 *1 19,46.2
X$3228 1415 1414 1372 85 109 1439 MUX2_X1
* cell instance $3230 r0 *1 20.52,46.2
X$3230 803 1439 109 85 1452 AND2_X1
* cell instance $3231 r0 *1 21.28,46.2
X$3231 928 85 109 1252 CLKBUF_X3
* cell instance $3232 r0 *1 22.23,46.2
X$3232 716 85 109 1486 CLKBUF_X3
* cell instance $3234 m0 *1 22.99,46.2
X$3234 1291 109 1390 85 BUF_X4
* cell instance $3237 r0 *1 23.75,46.2
X$3237 716 85 109 1416 CLKBUF_X3
* cell instance $3238 m0 *1 24.89,46.2
X$3238 1221 109 1127 85 BUF_X4
* cell instance $3240 m0 *1 26.22,46.2
X$3240 85 1373 1326 1043 109 DFF_X1
* cell instance $3242 m0 *1 30.21,46.2
X$3242 1166 1416 1408 85 1357 109 AOI21_X1
* cell instance $3244 m0 *1 31.16,46.2
X$3244 1166 1416 1409 85 1306 109 AOI21_X1
* cell instance $3248 r0 *1 24.7,46.2
X$3248 1166 1416 1487 85 1520 109 AOI21_X1
* cell instance $3251 r0 *1 27.36,46.2
X$3251 1166 1416 1441 85 1085 109 AOI21_X1
* cell instance $3252 r0 *1 28.12,46.2
X$3252 85 1456 1417 1043 109 DFF_X1
* cell instance $3253 r0 *1 31.35,46.2
X$3253 1166 1416 1443 85 1126 109 AOI21_X1
* cell instance $3256 r0 *1 33.25,46.2
X$3256 1484 487 85 109 1525 NOR2_X1
* cell instance $3260 r0 *1 38,46.2
X$3260 85 1418 1374 1547 109 DFF_X1
* cell instance $3262 m0 *1 39.14,46.2
X$3262 612 1483 1410 85 1374 109 AOI21_X1
* cell instance $3263 m0 *1 40.09,46.2
X$3263 659 1418 85 109 1410 NAND2_X1
* cell instance $3267 m0 *1 43.13,46.2
X$3267 808 1394 1407 85 109 1400 OR3_X1
* cell instance $3269 r0 *1 41.23,46.2
X$3269 1418 85 109 1445 INV_X1
* cell instance $3272 r0 *1 42.75,46.2
X$3272 1419 1445 565 85 109 1044 NAND3_X1
* cell instance $3273 r0 *1 43.51,46.2
X$3273 618 1445 1419 1246 109 85 1446 AND4_X1
* cell instance $3275 m0 *1 44.46,46.2
X$3275 1446 85 109 841 BUF_X2
* cell instance $3279 m0 *1 50.73,46.2
X$3279 808 1392 1405 85 109 1401 OR3_X1
* cell instance $3282 r0 *1 44.65,46.2
X$3282 565 1445 1419 109 85 1328 AND3_X1
* cell instance $3283 r0 *1 45.6,46.2
X$3283 1444 1044 85 109 1481 NOR2_X1
* cell instance $3284 r0 *1 46.17,46.2
X$3284 1420 1481 109 85 1529 XNOR2_X1
* cell instance $3285 r0 *1 47.31,46.2
X$3285 808 85 109 1457 BUF_X2
* cell instance $3287 r0 *1 48.45,46.2
X$3287 1420 85 109 1480 INV_X1
* cell instance $3288 r0 *1 48.83,46.2
X$3288 1444 955 1480 85 109 1478 NOR3_X1
* cell instance $3289 r0 *1 49.59,46.2
X$3289 1420 1327 85 109 1531 NOR2_X1
* cell instance $3291 r0 *1 50.35,46.2
X$3291 1458 1478 109 85 1442 XNOR2_X1
* cell instance $3293 r0 *1 52.25,46.2
X$3293 1442 487 85 109 1532 NOR2_X1
* cell instance $3294 m0 *1 53.77,46.2
X$3294 790 1403 1360 85 1402 109 AOI21_X1
* cell instance $3295 m0 *1 52.82,46.2
X$3295 1329 1330 1404 85 109 1403 OR3_X1
* cell instance $3298 r0 *1 52.82,46.2
X$3298 808 85 109 1029 BUF_X2
* cell instance $3300 r0 *1 55.1,46.2
X$3300 1050 1533 1459 1421 1440 1469 109 85 AOI221_X2
* cell instance $3301 m0 *1 56.62,46.2
X$3301 85 1399 1177 2373 1425 109 DFF_X2
* cell instance $3306 m0 *1 64.22,46.2
X$3306 1086 1396 85 109 1375 NOR2_X1
* cell instance $3308 r0 *1 57.19,46.2
X$3308 1175 1400 1422 1421 1460 1435 109 85 AOI221_X2
* cell instance $3310 r0 *1 59.66,46.2
X$3310 1425 85 109 1460 INV_X1
* cell instance $3312 r0 *1 60.42,46.2
X$3312 1423 85 109 889 BUF_X2
* cell instance $3314 r0 *1 61.37,46.2
X$3314 1426 1427 1424 1425 109 85 1332 AND4_X1
* cell instance $3315 r0 *1 62.51,46.2
X$3315 85 1424 1425 1426 1427 1086 109 NAND4_X4
* cell instance $3317 m0 *1 65.17,46.2
X$3317 1398 721 85 109 1334 NOR2_X1
* cell instance $3320 r0 *1 66.31,46.2
X$3320 1426 889 109 85 1428 XNOR2_X1
* cell instance $3321 r0 *1 67.45,46.2
X$3321 1428 721 85 109 1522 NOR2_X1
* cell instance $3322 m0 *1 67.83,46.2
X$3322 1333 1396 85 109 1275 NOR2_X1
* cell instance $3326 m0 *1 71.63,46.2
X$3326 85 1378 1395 1277 109 DFF_X1
* cell instance $3327 m0 *1 74.86,46.2
X$3327 1330 85 109 1383 BUF_X1
* cell instance $3329 m0 *1 76.19,46.2
X$3329 1380 1377 1431 85 109 1391 OR3_X1
* cell instance $3330 m0 *1 77.14,46.2
X$3330 928 1391 1379 85 1342 109 AOI21_X1
* cell instance $3334 r0 *1 69.73,46.2
X$3334 1429 85 109 1426 BUF_X2
* cell instance $3338 r0 *1 71.82,46.2
X$3338 1473 448 85 109 1395 NOR2_X1
* cell instance $3339 r0 *1 72.39,46.2
X$3339 1277 85 109 CLKBUF_X1
* cell instance $3340 r0 *1 72.96,46.2
X$3340 1463 85 109 1277 CLKBUF_X3
* cell instance $3341 r0 *1 73.91,46.2
X$3341 1472 1229 935 891 85 109 1509 NAND4_X1
* cell instance $3342 r0 *1 74.86,46.2
X$3342 1436 1471 109 85 1430 XNOR2_X1
* cell instance $3343 r0 *1 76,46.2
X$3343 1430 448 85 109 1465 NOR2_X1
* cell instance $3344 r0 *1 76.57,46.2
X$3344 1436 1378 85 109 1431 NAND2_X1
* cell instance $3345 r0 *1 77.14,46.2
X$3345 1431 1377 1380 109 1379 85 OAI21_X1
* cell instance $3371 r0 *1 19.95,1.4
X$3371 111 134 109 85 110 XNOR2_X1
* cell instance $3382 r0 *1 39.71,1.4
X$3382 102 85 109 141 BUF_X2
* cell instance $3385 m0 *1 1.71,32.2
X$3385 838 85 109 878 BUF_X1
* cell instance $3388 r0 *1 1.9,32.2
X$3388 923 85 109 967 BUF_X1
* cell instance $3389 r0 *1 2.47,32.2
X$3389 922 109 618 85 BUF_X4
* cell instance $3394 m0 *1 4.37,32.2
X$3394 800 85 109 920 BUF_X1
* cell instance $3396 m0 *1 4.94,32.2
X$3396 880 85 109 921 BUF_X1
* cell instance $3397 m0 *1 5.51,32.2
X$3397 726 85 109 CLKBUF_X1
* cell instance $3399 m0 *1 6.27,32.2
X$3399 880 903 85 109 946 XOR2_X1
* cell instance $3400 m0 *1 7.41,32.2
X$3400 946 945 85 109 924 NOR2_X1
* cell instance $3402 r0 *1 4.56,32.2
X$3402 968 85 109 879 CLKBUF_X2
* cell instance $3403 r0 *1 5.32,32.2
X$3403 206 85 109 726 CLKBUF_X3
* cell instance $3404 r0 *1 6.27,32.2
X$3404 85 880 924 726 109 DFF_X1
* cell instance $3406 m0 *1 8.36,32.2
X$3406 866 800 879 881 85 109 903 NAND4_X1
* cell instance $3407 r0 *1 9.5,32.2
X$3407 437 879 881 85 109 1013 NAND3_X1
* cell instance $3408 m0 *1 9.88,32.2
X$3408 881 786 85 109 948 NAND2_X1
* cell instance $3410 m0 *1 10.45,32.2
X$3410 836 948 729 109 996 85 OAI21_X1
* cell instance $3411 m0 *1 11.21,32.2
X$3411 879 786 85 109 925 NAND2_X1
* cell instance $3412 m0 *1 11.78,32.2
X$3412 881 879 800 880 109 85 883 AND4_X1
* cell instance $3413 m0 *1 12.92,32.2
X$3413 373 881 85 109 947 NAND2_X1
* cell instance $3417 r0 *1 10.45,32.2
X$3417 879 947 85 109 969 XOR2_X1
* cell instance $3418 r0 *1 11.59,32.2
X$3418 836 925 731 109 1114 85 OAI21_X1
* cell instance $3421 m0 *1 15.2,32.2
X$3421 838 926 85 109 970 XOR2_X1
* cell instance $3422 m0 *1 14.63,32.2
X$3422 883 437 85 109 926 NAND2_X1
* cell instance $3424 m0 *1 17.86,32.2
X$3424 373 883 838 85 109 911 NAND3_X1
* cell instance $3425 m0 *1 18.62,32.2
X$3425 884 911 85 109 1018 XOR2_X1
* cell instance $3429 r0 *1 15.01,32.2
X$3429 85 927 666 2407 838 109 DFF_X2
* cell instance $3430 r0 *1 18.62,32.2
X$3430 85 884 1017 666 109 DFF_X1
* cell instance $3431 m0 *1 21.85,32.2
X$3431 206 85 109 666 CLKBUF_X3
* cell instance $3433 m0 *1 22.8,32.2
X$3433 666 85 109 CLKBUF_X1
* cell instance $3435 m0 *1 23.56,32.2
X$3435 965 85 109 206 CLKBUF_X3
* cell instance $3440 r0 *1 22.99,32.2
X$3440 928 85 109 971 CLKBUF_X3
* cell instance $3442 r0 *1 25.46,32.2
X$3442 85 923 972 666 109 DFF_X1
* cell instance $3443 m0 *1 26.6,32.2
X$3443 928 916 867 85 914 109 AOI21_X1
* cell instance $3447 m0 *1 28.5,32.2
X$3447 789 786 85 109 949 NAND2_X1
* cell instance $3448 m0 *1 29.07,32.2
X$3448 769 786 85 109 973 NAND2_X1
* cell instance $3449 m0 *1 29.64,32.2
X$3449 836 949 719 109 918 85 OAI21_X1
* cell instance $3450 m0 *1 30.4,32.2
X$3450 836 919 913 109 915 85 OAI21_X1
* cell instance $3456 r0 *1 30.02,32.2
X$3456 836 973 917 109 987 85 OAI21_X1
* cell instance $3459 m0 *1 33.06,32.2
X$3459 928 85 109 487 CLKBUF_X3
* cell instance $3462 m0 *1 41.04,32.2
X$3462 85 950 617 2366 128 109 DFF_X2
* cell instance $3467 m0 *1 48.64,32.2
X$3467 843 933 886 85 109 956 OR3_X1
* cell instance $3468 m0 *1 49.59,32.2
X$3468 790 956 912 85 807 109 AOI21_X1
* cell instance $3469 m0 *1 50.35,32.2
X$3469 886 933 843 109 912 85 OAI21_X1
* cell instance $3474 r0 *1 35.91,32.2
X$3474 85 123 1030 829 109 DFF_X1
* cell instance $3475 r0 *1 39.14,32.2
X$3475 206 85 109 829 CLKBUF_X3
* cell instance $3476 r0 *1 40.09,32.2
X$3476 123 85 109 975 BUF_X1
* cell instance $3477 r0 *1 40.66,32.2
X$3477 829 85 109 2443 INV_X1
* cell instance $3481 r0 *1 43.13,32.2
X$3481 951 375 85 109 950 NOR2_X1
* cell instance $3482 r0 *1 43.7,32.2
X$3482 128 990 85 109 951 XOR2_X1
* cell instance $3484 r0 *1 45.03,32.2
X$3484 975 976 85 109 929 NOR2_X1
* cell instance $3487 r0 *1 46.55,32.2
X$3487 930 85 109 952 INV_X1
* cell instance $3488 r0 *1 46.93,32.2
X$3488 952 886 932 955 85 109 931 NOR4_X1
* cell instance $3491 r0 *1 48.45,32.2
X$3491 988 886 932 955 85 109 953 NOR4_X1
* cell instance $3493 r0 *1 49.59,32.2
X$3493 773 843 85 109 988 NAND2_X1
* cell instance $3496 r0 *1 51.3,32.2
X$3496 843 976 85 109 934 NOR2_X1
* cell instance $3498 m0 *1 51.49,32.2
X$3498 843 773 651 845 109 85 930 AND4_X1
* cell instance $3500 r0 *1 52.63,32.2
X$3500 845 976 85 109 977 NOR2_X1
* cell instance $3501 m0 *1 54.15,32.2
X$3501 887 375 85 109 910 NOR2_X1
* cell instance $3502 m0 *1 53.01,32.2
X$3502 651 953 109 85 887 XNOR2_X1
* cell instance $3504 m0 *1 55.48,32.2
X$3504 85 910 774 2369 651 109 DFF_X2
* cell instance $3505 m0 *1 59.09,32.2
X$3505 965 85 109 263 CLKBUF_X3
* cell instance $3506 m0 *1 60.04,32.2
X$3506 263 85 109 774 CLKBUF_X3
* cell instance $3509 r0 *1 53.58,32.2
X$3509 651 976 85 109 1028 NOR2_X1
* cell instance $3510 r0 *1 54.15,32.2
X$3510 773 976 85 109 961 NOR2_X1
* cell instance $3511 r0 *1 54.72,32.2
X$3511 978 960 961 85 109 954 OR3_X1
* cell instance $3513 r0 *1 58.71,32.2
X$3513 774 85 109 2442 INV_X1
* cell instance $3518 m0 *1 61.56,32.2
X$3518 962 966 109 85 888 XNOR2_X1
* cell instance $3520 m0 *1 62.7,32.2
X$3520 888 772 85 109 909 NOR2_X1
* cell instance $3522 m0 *1 63.46,32.2
X$3522 935 889 85 109 966 NAND2_X1
* cell instance $3525 m0 *1 64.98,32.2
X$3525 890 85 109 962 INV_X1
* cell instance $3527 m0 *1 65.55,32.2
X$3527 935 891 890 85 109 908 NAND3_X1
* cell instance $3528 m0 *1 66.31,32.2
X$3528 957 908 109 85 892 XNOR2_X1
* cell instance $3529 m0 *1 67.45,32.2
X$3529 892 772 85 109 856 NOR2_X1
* cell instance $3531 m0 *1 68.78,32.2
X$3531 700 85 109 957 INV_X1
* cell instance $3535 r0 *1 63.65,32.2
X$3535 776 964 963 979 962 782 109 85 AOI221_X2
* cell instance $3537 r0 *1 67.26,32.2
X$3537 777 983 959 979 940 904 109 85 AOI221_X2
* cell instance $3538 r0 *1 69.35,32.2
X$3538 744 954 958 979 936 899 109 85 AOI221_X2
* cell instance $3539 m0 *1 70.49,32.2
X$3539 938 772 85 109 893 NOR2_X1
* cell instance $3541 m0 *1 71.06,32.2
X$3541 890 700 109 85 939 AND2_X1
* cell instance $3542 m0 *1 71.82,32.2
X$3542 939 935 889 85 109 937 NAND3_X1
* cell instance $3543 m0 *1 72.58,32.2
X$3543 939 935 891 894 85 109 905 NAND4_X1
* cell instance $3544 m0 *1 73.53,32.2
X$3544 940 905 109 85 896 XNOR2_X1
* cell instance $3545 m0 *1 74.67,32.2
X$3545 896 772 85 109 895 NOR2_X1
* cell instance $3546 m0 *1 75.24,32.2
X$3546 897 85 109 940 INV_X1
* cell instance $3547 m0 *1 75.62,32.2
X$3547 85 898 620 2353 727 109 DFF_X2
* cell instance $3548 m0 *1 79.23,32.2
X$3548 897 85 109 900 BUF_X1
* cell instance $3550 r0 *1 71.44,32.2
X$3550 936 937 109 85 938 XNOR2_X1
* cell instance $3552 r0 *1 72.77,32.2
X$3552 894 85 109 936 INV_X1
* cell instance $3553 r0 *1 73.15,32.2
X$3553 894 700 890 897 85 1183 109 NAND4_X2
* cell instance $3554 r0 *1 74.86,32.2
X$3554 727 85 109 941 INV_X1
* cell instance $3555 r0 *1 75.24,32.2
X$3555 941 980 109 85 942 XNOR2_X1
* cell instance $3557 r0 *1 76.57,32.2
X$3557 942 772 85 109 898 NOR2_X1
* cell instance $3558 r0 *1 77.14,32.2
X$3558 890 85 109 901 BUF_X1
* cell instance $3561 r0 *1 78.28,32.2
X$3561 944 85 109 808 CLKBUF_X3
* cell instance $3563 r0 *1 79.61,32.2
X$3563 904 85 109 943 BUF_X1
* cell instance $3565 m0 *1 80.18,32.2
X$3565 899 85 109 902 BUF_X1
* cell instance $3570 m0 *1 19.19,79.8
X$3570 2134 85 109 2287 BUF_X1
* cell instance $3571 m0 *1 21.28,79.8
X$3571 2245 85 109 2289 BUF_X1
* cell instance $3572 m0 *1 21.85,79.8
X$3572 1988 85 109 2291 BUF_X1
* cell instance $3573 m0 *1 22.42,79.8
X$3573 1767 85 109 2295 BUF_X1
* cell instance $3574 m0 *1 22.99,79.8
X$3574 2246 85 109 2328 BUF_X1
* cell instance $3577 m0 *1 25.84,79.8
X$3577 2122 85 109 2298 BUF_X1
* cell instance $3578 m0 *1 26.41,79.8
X$3578 2063 85 109 2300 BUF_X1
* cell instance $3579 m0 *1 26.98,79.8
X$3579 2023 85 109 2302 BUF_X1
* cell instance $3580 m0 *1 27.55,79.8
X$3580 2149 85 109 2304 BUF_X1
* cell instance $3583 m0 *1 3.23,68.6
X$3583 2102 85 109 2084 BUF_X1
* cell instance $3585 m0 *1 5.51,68.6
X$3585 85 2102 2085 1926 109 DFF_X1
* cell instance $3586 m0 *1 8.74,68.6
X$3586 2102 85 109 1984 BUF_X1
* cell instance $3589 m0 *1 16.91,68.6
X$3589 2061 1036 85 109 2103 NOR2_X1
* cell instance $3590 m0 *1 17.48,68.6
X$3590 2062 2075 109 85 2104 XNOR2_X1
* cell instance $3592 m0 *1 18.81,68.6
X$3592 2022 1958 1348 85 109 2075 NOR3_X1
* cell instance $3593 m0 *1 19.57,68.6
X$3593 2106 85 109 1348 INV_X1
* cell instance $3595 m0 *1 22.99,68.6
X$3595 2086 2087 1986 85 109 2107 NOR3_X1
* cell instance $3596 m0 *1 23.75,68.6
X$3596 2110 2107 2108 85 109 2047 MUX2_X1
* cell instance $3608 r0 *1 13.87,68.6
X$3608 85 2106 2103 2014 109 DFF_X1
* cell instance $3609 r0 *1 17.1,68.6
X$3609 2104 1036 85 109 2159 NOR2_X1
* cell instance $3610 r0 *1 17.67,68.6
X$3610 2062 2106 85 109 2146 NAND2_X1
* cell instance $3611 r0 *1 18.24,68.6
X$3611 2120 2062 2106 2134 85 1987 109 NAND4_X2
* cell instance $3612 r0 *1 19.95,68.6
X$3612 2120 85 109 1297 INV_X1
* cell instance $3615 r0 *1 21.28,68.6
X$3615 1894 2145 2161 85 109 1960 OR3_X2
* cell instance $3617 r0 *1 22.61,68.6
X$3617 1767 1988 85 109 2121 NAND2_X1
* cell instance $3618 r0 *1 23.18,68.6
X$3618 1987 2121 85 109 2087 OR2_X1
* cell instance $3620 r0 *1 24.13,68.6
X$3620 1987 2121 2086 2137 109 2161 85 OR4_X2
* cell instance $3623 m0 *1 25.46,68.6
X$3623 1682 1408 85 109 2110 NOR2_X1
* cell instance $3625 r0 *1 25.84,68.6
X$3625 2122 2063 85 109 2137 NAND2_X1
* cell instance $3626 r0 *1 26.41,68.6
X$3626 2063 85 109 1408 INV_X1
* cell instance $3629 r0 *1 28.5,68.6
X$3629 85 2124 2123 1910 109 DFF_X1
* cell instance $3631 m0 *1 29.45,68.6
X$3631 2078 1001 85 109 2123 NOR2_X1
* cell instance $3632 m0 *1 30.59,68.6
X$3632 2122 85 109 1409 INV_X1
* cell instance $3635 m0 *1 31.73,68.6
X$3635 2113 1960 1961 85 109 2064 NOR3_X1
* cell instance $3637 m0 *1 32.68,68.6
X$3637 2065 85 109 1990 INV_X1
* cell instance $3639 r0 *1 31.73,68.6
X$3639 2138 85 109 1654 INV_X1
* cell instance $3640 r0 *1 32.11,68.6
X$3640 2124 2138 1952 2125 109 85 2150 AND4_X1
* cell instance $3641 r0 *1 33.25,68.6
X$3641 2150 2139 2089 85 109 1991 NAND3_X1
* cell instance $3643 m0 *1 33.44,68.6
X$3643 2139 85 109 1796 INV_X1
* cell instance $3645 r0 *1 34.01,68.6
X$3645 2165 1960 1616 85 109 2141 NOR3_X1
* cell instance $3646 r0 *1 34.77,68.6
X$3646 2125 85 109 1616 INV_X1
* cell instance $3647 m0 *1 35.15,68.6
X$3647 1682 1688 85 109 2090 NOR2_X1
* cell instance $3649 m0 *1 35.72,68.6
X$3649 2089 85 109 1688 INV_X1
* cell instance $3651 m0 *1 36.29,68.6
X$3651 1772 2089 85 109 2080 NOR2_X1
* cell instance $3657 r0 *1 35.53,68.6
X$3657 2090 2141 2080 85 109 2151 MUX2_X1
* cell instance $3659 r0 *1 37.05,68.6
X$3659 1354 85 109 1932 CLKBUF_X3
* cell instance $3662 r0 *1 39.9,68.6
X$3662 85 2114 1935 2420 1963 109 DFF_X2
* cell instance $3663 m0 *1 42.75,68.6
X$3663 790 2091 2115 85 2114 109 AOI21_X1
* cell instance $3667 m0 *1 44.46,68.6
X$3667 790 2118 2116 85 2142 109 AOI21_X1
* cell instance $3668 m0 *1 45.22,68.6
X$3668 1982 1819 2117 85 109 2118 OR3_X1
* cell instance $3670 m0 *1 46.36,68.6
X$3670 2117 1819 1982 109 2116 85 OAI21_X1
* cell instance $3671 m0 *1 47.12,68.6
X$3671 790 2082 2092 85 2119 109 AOI21_X1
* cell instance $3672 m0 *1 47.88,68.6
X$3672 2066 1406 1723 109 2092 85 OAI21_X1
* cell instance $3677 r0 *1 44.08,68.6
X$3677 85 2140 2142 1935 109 DFF_X1
* cell instance $3678 r0 *1 47.31,68.6
X$3678 2140 85 109 1982 CLKBUF_X2
* cell instance $3681 r0 *1 49.78,68.6
X$3681 2126 692 85 109 2170 NOR2_X1
* cell instance $3682 r0 *1 50.35,68.6
X$3682 1862 2129 85 109 2126 XOR2_X1
* cell instance $3685 m0 *1 52.82,68.6
X$3685 1891 1861 109 85 2128 AND2_X1
* cell instance $3686 m0 *1 52.06,68.6
X$3686 2067 85 109 1891 BUF_X2
* cell instance $3689 r0 *1 52.06,68.6
X$3689 1820 1862 109 85 2127 AND2_X1
* cell instance $3690 r0 *1 52.82,68.6
X$3690 2127 2128 1936 2069 85 109 2168 NAND4_X1
* cell instance $3692 r0 *1 53.96,68.6
X$3692 2128 2093 1936 1820 85 109 2129 NAND4_X1
* cell instance $3695 m0 *1 55.48,68.6
X$3695 2093 85 109 2059 CLKBUF_X3
* cell instance $3698 r0 *1 56.43,68.6
X$3698 2130 692 85 109 2153 NOR2_X1
* cell instance $3699 r0 *1 57,68.6
X$3699 1865 2166 85 109 2130 XOR2_X1
* cell instance $3700 r0 *1 58.14,68.6
X$3700 2036 2093 1864 1863 85 109 2166 NAND4_X1
* cell instance $3705 m0 *1 59.09,68.6
X$3705 1919 1889 109 85 2093 AND2_X1
* cell instance $3707 m0 *1 61.56,68.6
X$3707 2032 85 109 2094 BUF_X1
* cell instance $3712 r0 *1 60.99,68.6
X$3712 1779 2155 85 109 2131 XOR2_X1
* cell instance $3713 r0 *1 62.13,68.6
X$3713 2131 679 85 109 2164 NOR2_X1
* cell instance $3718 r0 *1 65.55,68.6
X$3718 1825 2135 85 109 2136 XOR2_X1
* cell instance $3719 m0 *1 65.74,68.6
X$3719 2034 2031 2058 2059 85 109 2135 NAND4_X1
* cell instance $3721 m0 *1 66.69,68.6
X$3721 1825 1905 2093 2031 109 85 2070 AND4_X1
* cell instance $3723 m0 *1 68.02,68.6
X$3723 2081 85 109 2035 BUF_X2
* cell instance $3726 m0 *1 69.73,68.6
X$3726 2071 2095 85 109 2054 NOR2_X1
* cell instance $3727 m0 *1 70.3,68.6
X$3727 2111 2071 2095 85 109 2112 NOR3_X1
* cell instance $3728 m0 *1 71.06,68.6
X$3728 2076 2111 2071 2095 85 109 2079 NOR4_X1
* cell instance $3729 m0 *1 72.01,68.6
X$3729 1940 2133 85 109 2109 XOR2_X1
* cell instance $3730 m0 *1 73.15,68.6
X$3730 2109 589 85 109 2077 NOR2_X1
* cell instance $3731 m0 *1 73.72,68.6
X$3731 85 2099 2077 2096 109 DFF_X1
* cell instance $3732 m0 *1 76.95,68.6
X$3732 2105 589 85 109 2098 NOR2_X1
* cell instance $3733 m0 *1 77.52,68.6
X$3733 1881 2005 85 109 2105 XOR2_X1
* cell instance $3734 m0 *1 78.66,68.6
X$3734 2099 85 109 1940 CLKBUF_X2
* cell instance $3735 m0 *1 79.42,68.6
X$3735 2100 85 109 1881 CLKBUF_X2
* cell instance $3736 m0 *1 80.18,68.6
X$3736 1836 85 109 2007 BUF_X1
* cell instance $3738 r0 *1 66.69,68.6
X$3738 2136 679 85 109 2163 NOR2_X1
* cell instance $3742 r0 *1 69.92,68.6
X$3742 1828 1887 1827 1883 85 2095 109 NAND4_X2
* cell instance $3743 r0 *1 71.63,68.6
X$3743 2112 2035 2036 2069 85 109 2133 NAND4_X1
* cell instance $3747 r0 *1 75.05,68.6
X$3747 1780 85 109 2074 BUF_X1
* cell instance $3748 r0 *1 75.62,68.6
X$3748 1825 85 109 2097 BUF_X1
* cell instance $3749 r0 *1 76.19,68.6
X$3749 85 2100 2098 2096 109 DFF_X1
* cell instance $3750 r0 *1 79.42,68.6
X$3750 2099 85 109 2073 BUF_X1
* cell instance $3751 r0 *1 79.99,68.6
X$3751 1785 85 109 2101 BUF_X1
* cell instance $3755 m0 *1 13.87,79.8
X$3755 2143 85 109 2283 BUF_X1
* cell instance $3758 m0 *1 16.91,79.8
X$3758 2120 85 109 2284 BUF_X1
* cell instance $3759 m0 *1 17.48,79.8
X$3759 2106 85 109 2286 BUF_X1
* cell instance $3777 m0 *1 3.8,43.4
X$3777 1264 85 109 1251 BUF_X1
* cell instance $3778 m0 *1 4.37,43.4
X$3778 1282 1252 85 109 1161 NOR2_X1
* cell instance $3779 m0 *1 4.94,43.4
X$3779 1253 1283 109 85 1282 XNOR2_X1
* cell instance $3780 m0 *1 6.08,43.4
X$3780 1255 85 109 1318 INV_X1
* cell instance $3781 m0 *1 6.46,43.4
X$3781 1321 1323 1318 85 109 1283 NOR3_X1
* cell instance $3783 m0 *1 7.41,43.4
X$3783 1319 1320 1253 1255 85 109 1256 NAND4_X1
* cell instance $3785 m0 *1 8.55,43.4
X$3785 1254 1253 1255 85 109 1322 NAND3_X1
* cell instance $3789 r0 *1 1.71,43.4
X$3789 85 1317 1386 1316 109 DFF_X1
* cell instance $3793 r0 *1 4.94,43.4
X$3793 1317 85 109 1255 CLKBUF_X2
* cell instance $3794 r0 *1 5.7,43.4
X$3794 1389 1252 85 109 1386 NOR2_X1
* cell instance $3796 r0 *1 6.46,43.4
X$3796 1318 1387 109 85 1389 XNOR2_X1
* cell instance $3797 r0 *1 7.6,43.4
X$3797 1319 1320 85 109 1387 NAND2_X1
* cell instance $3799 r0 *1 8.55,43.4
X$3799 1322 1321 1323 85 109 1257 NOR3_X1
* cell instance $3815 r0 *1 4.37,21
X$3815 529 85 109 573 BUF_X1
* cell instance $3817 r0 *1 5.32,21
X$3817 478 576 85 109 596 NAND2_X1
* cell instance $3818 m0 *1 5.7,21
X$3818 475 85 109 479 CLKBUF_X3
* cell instance $3821 r0 *1 5.89,21
X$3821 524 596 525 548 85 109 574 NOR4_X1
* cell instance $3822 r0 *1 6.84,21
X$3822 596 611 85 109 503 NOR2_X1
* cell instance $3823 m0 *1 8.17,21
X$3823 527 85 109 548 INV_X1
* cell instance $3824 m0 *1 7.03,21
X$3824 478 526 109 85 502 XNOR2_X1
* cell instance $3825 m0 *1 8.55,21
X$3825 527 503 109 85 504 XNOR2_X1
* cell instance $3827 r0 *1 7.41,21
X$3827 524 525 575 85 109 526 NOR3_X1
* cell instance $3828 r0 *1 8.17,21
X$3828 576 85 109 575 INV_X1
* cell instance $3830 r0 *1 8.93,21
X$3830 85 527 577 576 478 639 109 NAND4_X4
* cell instance $3831 m0 *1 10.26,21
X$3831 572 109 437 85 BUF_X4
* cell instance $3835 m0 *1 11.97,21
X$3835 552 480 85 109 528 NAND2_X1
* cell instance $3837 m0 *1 14.25,21
X$3837 529 599 85 109 409 XOR2_X1
* cell instance $3838 m0 *1 15.39,21
X$3838 578 85 109 531 INV_X2
* cell instance $3841 r0 *1 12.35,21
X$3841 85 578 598 441 109 DFF_X1
* cell instance $3842 r0 *1 15.58,21
X$3842 579 530 531 567 85 109 599 NAND4_X1
* cell instance $3843 r0 *1 16.53,21
X$3843 530 529 109 85 580 AND2_X2
* cell instance $3844 r0 *1 17.48,21
X$3844 85 579 580 565 531 203 109 NAND4_X4
* cell instance $3845 m0 *1 19.38,21
X$3845 479 85 109 442 BUF_X2
* cell instance $3846 m0 *1 20.9,21
X$3846 532 557 469 109 559 85 OAI21_X1
* cell instance $3848 m0 *1 21.85,21
X$3848 532 445 481 109 533 85 OAI21_X1
* cell instance $3849 m0 *1 22.61,21
X$3849 532 446 444 109 560 85 OAI21_X1
* cell instance $3850 m0 *1 23.37,21
X$3850 372 482 85 109 557 NAND2_X1
* cell instance $3851 m0 *1 23.94,21
X$3851 532 510 470 109 562 85 OAI21_X1
* cell instance $3852 m0 *1 24.7,21
X$3852 114 482 85 109 633 NAND2_X1
* cell instance $3854 m0 *1 25.46,21
X$3854 452 482 85 109 603 NAND2_X1
* cell instance $3856 m0 *1 26.22,21
X$3856 85 117 563 413 109 DFF_X1
* cell instance $3857 m0 *1 29.45,21
X$3857 117 85 109 513 INV_X1
* cell instance $3858 m0 *1 29.83,21
X$3858 483 484 85 109 534 NOR2_X1
* cell instance $3862 r0 *1 21.09,21
X$3862 532 602 558 109 705 85 OAI21_X1
* cell instance $3865 r0 *1 22.99,21
X$3865 376 482 85 109 602 NAND2_X1
* cell instance $3866 r0 *1 24.32,21
X$3866 479 85 109 584 CLKBUF_X3
* cell instance $3868 r0 *1 25.46,21
X$3868 532 603 566 109 582 85 OAI21_X1
* cell instance $3871 r0 *1 26.79,21
X$3871 607 268 85 109 563 NOR2_X1
* cell instance $3874 r0 *1 29.64,21
X$3874 513 608 109 85 607 XNOR2_X1
* cell instance $3876 r0 *1 31.16,21
X$3876 534 447 377 437 85 109 608 NAND4_X1
* cell instance $3877 m0 *1 32.11,21
X$3877 206 85 109 413 CLKBUF_X3
* cell instance $3878 m0 *1 31.54,21
X$3878 413 85 109 CLKBUF_X1
* cell instance $3879 m0 *1 33.06,21
X$3879 119 489 485 583 85 109 484 NAND4_X1
* cell instance $3880 m0 *1 34.01,21
X$3880 519 447 377 437 85 109 518 NAND4_X1
* cell instance $3881 m0 *1 34.96,21
X$3881 485 536 85 109 486 XOR2_X1
* cell instance $3882 m0 *1 36.1,21
X$3882 489 569 109 85 519 AND2_X1
* cell instance $3885 r0 *1 32.87,21
X$3885 537 584 154 85 535 109 AOI21_X1
* cell instance $3888 r0 *1 34.77,21
X$3888 447 414 572 583 85 109 536 NAND4_X1
* cell instance $3889 r0 *1 35.72,21
X$3889 583 485 109 85 569 AND2_X1
* cell instance $3891 r0 *1 36.67,21
X$3891 537 584 141 85 566 109 AOI21_X1
* cell instance $3892 m0 *1 38.19,21
X$3892 489 488 85 109 571 XOR2_X1
* cell instance $3893 m0 *1 37.24,21
X$3893 569 447 377 373 85 109 488 NAND4_X1
* cell instance $3894 m0 *1 39.33,21
X$3894 571 448 85 109 522 NOR2_X1
* cell instance $3896 r0 *1 37.43,21
X$3896 537 584 131 85 585 109 AOI21_X1
* cell instance $3900 m0 *1 40.47,21
X$3900 414 572 376 372 85 109 523 NAND4_X1
* cell instance $3904 r0 *1 41.61,21
X$3904 85 587 586 632 447 109 NOR3_X4
* cell instance $3906 m0 *1 42.56,21
X$3906 85 452 105 336 114 586 109 NAND4_X4
* cell instance $3907 m0 *1 46.17,21
X$3907 490 414 373 452 85 109 521 NAND4_X1
* cell instance $3909 m0 *1 47.31,21
X$3909 105 521 85 109 588 XOR2_X1
* cell instance $3911 m0 *1 49.4,21
X$3911 378 109 382 85 BUF_X4
* cell instance $3914 r0 *1 44.27,21
X$3914 586 587 538 85 109 615 NOR3_X1
* cell instance $3915 r0 *1 45.03,21
X$3915 586 587 85 109 681 NOR2_X1
* cell instance $3916 r0 *1 45.98,21
X$3916 615 377 373 85 109 609 NAND3_X1
* cell instance $3918 r0 *1 46.93,21
X$3918 570 609 85 109 606 XOR2_X1
* cell instance $3920 r0 *1 48.45,21
X$3920 606 589 85 109 605 NOR2_X1
* cell instance $3922 r0 *1 52.44,21
X$3922 85 604 630 335 109 DFF_X1
* cell instance $3924 r0 *1 55.86,21
X$3924 604 85 109 539 INV_X1
* cell instance $3925 r0 *1 56.24,21
X$3925 539 552 590 85 109 568 MUX2_X1
* cell instance $3926 m0 *1 57.38,21
X$3926 491 539 567 85 109 454 NAND3_X1
* cell instance $3929 r0 *1 57.57,21
X$3929 108 85 109 590 INV_X1
* cell instance $3931 r0 *1 58.33,21
X$3931 108 539 567 85 109 591 NAND3_X1
* cell instance $3932 m0 *1 58.71,21
X$3932 565 539 491 251 109 85 379 AND4_X2
* cell instance $3940 r0 *1 59.09,21
X$3940 108 668 109 85 491 AND2_X1
* cell instance $3945 r0 *1 62.7,21
X$3945 85 540 592 2430 541 109 DFF_X2
* cell instance $3946 m0 *1 64.03,21
X$3946 492 382 85 109 540 NOR2_X1
* cell instance $3947 m0 *1 62.7,21
X$3947 411 109 495 85 BUF_X4
* cell instance $3951 m0 *1 65.74,21
X$3951 467 85 109 457 INV_X2
* cell instance $3952 m0 *1 66.5,21
X$3952 564 354 255 214 85 109 601 NAND4_X1
* cell instance $3953 m0 *1 67.45,21
X$3953 307 253 561 109 85 564 AND3_X1
* cell instance $3954 m0 *1 68.4,21
X$3954 493 353 421 109 556 85 OAI21_X1
* cell instance $3955 m0 *1 69.16,21
X$3955 421 353 493 85 109 542 OR3_X1
* cell instance $3956 m0 *1 70.11,21
X$3956 423 421 85 109 459 NAND2_X1
* cell instance $3959 r0 *1 66.31,21
X$3959 541 601 85 109 492 XOR2_X1
* cell instance $3960 r0 *1 67.45,21
X$3960 85 561 541 307 253 493 109 NAND4_X4
* cell instance $3961 r0 *1 70.87,21
X$3961 495 542 556 85 600 109 AOI21_X1
* cell instance $3964 m0 *1 71.82,21
X$3964 555 382 85 109 554 NOR2_X1
* cell instance $3966 m0 *1 73.34,21
X$3966 494 507 85 109 555 XOR2_X1
* cell instance $3969 r0 *1 72.2,21
X$3969 85 494 554 592 109 DFF_X1
* cell instance $3970 m0 *1 76,21
X$3970 553 382 85 109 496 NOR2_X1
* cell instance $3971 m0 *1 74.86,21
X$3971 551 506 85 109 553 XOR2_X1
* cell instance $3974 m0 *1 78.28,21
X$3974 550 85 109 546 BUF_X1
* cell instance $3975 m0 *1 78.85,21
X$3975 549 85 109 545 BUF_X1
* cell instance $3976 m0 *1 79.42,21
X$3976 497 85 109 498 BUF_X1
* cell instance $3978 m0 *1 80.18,21
X$3978 497 85 109 547 BUF_X1
* cell instance $3981 r0 *1 75.81,21
X$3981 593 352 498 109 597 85 OAI21_X1
* cell instance $3982 r0 *1 76.57,21
X$3982 495 543 597 85 544 109 AOI21_X1
* cell instance $3985 r0 *1 77.9,21
X$3985 494 85 109 625 BUF_X1
* cell instance $3987 r0 *1 78.85,21
X$3987 541 85 109 595 BUF_X1
* cell instance $3989 r0 *1 79.61,21
X$3989 621 85 109 626 BUF_X1
* cell instance $3990 r0 *1 80.18,21
X$3990 594 85 109 698 BUF_X1
* cell instance $3999 r0 *1 1.9,15.4
X$3999 386 85 109 365 BUF_X1
* cell instance $4005 r0 *1 3.42,15.4
X$4005 85 386 385 236 109 DFF_X1
* cell instance $4006 m0 *1 6.84,15.4
X$4006 366 344 109 85 325 XNOR2_X1
* cell instance $4007 m0 *1 6.27,15.4
X$4007 325 268 85 109 385 NOR2_X1
* cell instance $4008 m0 *1 7.98,15.4
X$4008 206 85 109 236 CLKBUF_X3
* cell instance $4009 m0 *1 8.93,15.4
X$4009 327 144 85 109 344 NOR2_X1
* cell instance $4010 m0 *1 9.5,15.4
X$4010 327 143 387 85 109 388 NOR3_X1
* cell instance $4011 m0 *1 10.26,15.4
X$4011 366 85 109 387 INV_X1
* cell instance $4012 m0 *1 10.64,15.4
X$4012 367 388 109 85 464 XNOR2_X1
* cell instance $4015 r0 *1 6.65,15.4
X$4015 386 109 366 85 BUF_X4
* cell instance $4016 r0 *1 7.98,15.4
X$4016 428 85 109 408 BUF_X1
* cell instance $4018 r0 *1 8.93,15.4
X$4018 85 366 367 326 298 179 109 NAND4_X4
* cell instance $4021 r0 *1 13.49,15.4
X$4021 85 392 441 2427 368 109 DFF_X2
* cell instance $4022 m0 *1 13.68,15.4
X$4022 368 393 109 85 328 XNOR2_X1
* cell instance $4024 m0 *1 15.58,15.4
X$4024 329 179 144 85 109 393 NOR3_X1
* cell instance $4025 m0 *1 16.34,15.4
X$4025 368 85 109 394 INV_X1
* cell instance $4026 m0 *1 16.72,15.4
X$4026 394 329 85 109 330 OR2_X1
* cell instance $4027 m0 *1 17.48,15.4
X$4027 394 179 329 331 109 395 85 OR4_X2
* cell instance $4028 m0 *1 18.81,15.4
X$4028 330 179 239 370 85 109 433 NOR4_X1
* cell instance $4029 m0 *1 19.76,15.4
X$4029 300 85 109 370 INV_X1
* cell instance $4035 m0 *1 21.28,15.4
X$4035 85 210 109 395 BUF_X8
* cell instance $4043 r0 *1 25.65,15.4
X$4043 371 268 85 109 412 NOR2_X1
* cell instance $4046 r0 *1 28.5,15.4
X$4046 360 183 85 109 398 NOR2_X1
* cell instance $4049 m0 *1 38,15.4
X$4049 160 85 109 372 BUF_X2
* cell instance $4050 m0 *1 34.77,15.4
X$4050 85 160 400 97 109 DFF_X1
* cell instance $4053 m0 *1 39.71,15.4
X$4053 85 126 333 335 109 DFF_X1
* cell instance $4056 r0 *1 35.15,15.4
X$4056 377 437 85 109 435 NAND2_X1
* cell instance $4057 r0 *1 35.72,15.4
X$4057 372 435 85 109 401 XOR2_X1
* cell instance $4058 r0 *1 36.86,15.4
X$4058 401 487 85 109 400 NOR2_X1
* cell instance $4061 r0 *1 39.14,15.4
X$4061 377 373 372 85 109 436 NAND3_X1
* cell instance $4062 r0 *1 39.9,15.4
X$4062 376 436 85 109 402 XOR2_X1
* cell instance $4063 r0 *1 41.04,15.4
X$4063 402 375 85 109 374 NOR2_X1
* cell instance $4066 r0 *1 42.56,15.4
X$4066 126 85 109 415 BUF_X2
* cell instance $4068 m0 *1 43.51,15.4
X$4068 104 85 109 376 BUF_X2
* cell instance $4071 m0 *1 44.46,15.4
X$4071 112 403 85 109 364 XOR2_X1
* cell instance $4073 m0 *1 45.79,15.4
X$4073 85 407 335 2372 114 109 DFF_X2
* cell instance $4077 r0 *1 43.51,15.4
X$4077 372 376 415 109 85 438 AND3_X1
* cell instance $4079 r0 *1 44.65,15.4
X$4079 438 377 373 85 109 403 NAND3_X1
* cell instance $4081 r0 *1 45.79,15.4
X$4081 450 377 437 85 109 334 NAND3_X1
* cell instance $4082 r0 *1 46.55,15.4
X$4082 406 382 85 109 407 NOR2_X1
* cell instance $4083 r0 *1 47.12,15.4
X$4083 114 416 85 109 406 XOR2_X1
* cell instance $4085 r0 *1 48.64,15.4
X$4085 263 85 109 335 CLKBUF_X3
* cell instance $4086 r0 *1 49.59,15.4
X$4086 107 85 109 452 BUF_X2
* cell instance $4088 r0 *1 50.73,15.4
X$4088 378 85 109 166 CLKBUF_X3
* cell instance $4090 m0 *1 54.34,15.4
X$4090 252 296 212 295 85 109 362 NAND4_X1
* cell instance $4095 r0 *1 57,15.4
X$4095 419 213 85 109 405 NOR2_X1
* cell instance $4098 r0 *1 58.14,15.4
X$4098 317 456 85 109 404 XOR2_X1
* cell instance $4102 r0 *1 59.28,15.4
X$4102 404 213 85 109 420 NOR2_X1
* cell instance $4105 m0 *1 60.42,15.4
X$4105 85 361 146 2354 277 109 DFF_X2
* cell instance $4106 m0 *1 64.79,15.4
X$4106 85 291 397 252 251 352 109 NAND4_X4
* cell instance $4107 m0 *1 68.21,15.4
X$4107 307 353 85 109 337 XOR2_X1
* cell instance $4108 m0 *1 69.35,15.4
X$4108 337 166 85 109 309 NOR2_X1
* cell instance $4109 m0 *1 69.92,15.4
X$4109 284 85 109 307 BUF_X2
* cell instance $4111 m0 *1 71.44,15.4
X$4111 397 255 379 381 85 109 351 NAND4_X1
* cell instance $4112 m0 *1 72.39,15.4
X$4112 339 351 85 109 399 XOR2_X1
* cell instance $4113 m0 *1 73.53,15.4
X$4113 399 382 85 109 338 NOR2_X1
* cell instance $4114 m0 *1 74.1,15.4
X$4114 396 397 255 214 85 109 350 NAND4_X1
* cell instance $4115 m0 *1 75.05,15.4
X$4115 305 85 109 349 BUF_X1
* cell instance $4116 m0 *1 75.62,15.4
X$4116 346 350 85 109 340 XOR2_X1
* cell instance $4117 m0 *1 76.76,15.4
X$4117 263 85 109 310 CLKBUF_X3
* cell instance $4118 m0 *1 77.71,15.4
X$4118 340 382 85 109 348 NOR2_X1
* cell instance $4120 m0 *1 78.47,15.4
X$4120 278 85 109 381 BUF_X2
* cell instance $4121 m0 *1 79.23,15.4
X$4121 383 85 109 347 BUF_X1
* cell instance $4122 m0 *1 79.8,15.4
X$4122 391 382 85 109 315 NOR2_X1
* cell instance $4127 r0 *1 68.02,15.4
X$4127 379 109 214 85 BUF_X4
* cell instance $4129 r0 *1 70.11,15.4
X$4129 85 423 380 592 109 DFF_X1
* cell instance $4130 r0 *1 73.34,15.4
X$4130 381 339 389 109 85 396 AND3_X1
* cell instance $4131 r0 *1 74.29,15.4
X$4131 339 381 85 109 432 NAND2_X1
* cell instance $4134 r0 *1 75.81,15.4
X$4134 310 85 109 CLKBUF_X1
* cell instance $4137 r0 *1 76.95,15.4
X$4137 381 352 85 109 391 XOR2_X1
* cell instance $4138 r0 *1 78.09,15.4
X$4138 384 85 109 389 CLKBUF_X2
* cell instance $4139 r0 *1 78.85,15.4
X$4139 430 85 109 425 BUF_X1
* cell instance $4141 r0 *1 79.61,15.4
X$4141 390 85 109 426 BUF_X1
* cell instance $4142 r0 *1 80.18,15.4
X$4142 423 85 109 429 BUF_X1
* cell instance $4149 m0 *1 5.32,37.8
X$4149 1125 85 109 1112 BUF_X1
* cell instance $4154 r0 *1 1.71,37.8
X$4154 1191 85 109 1111 BUF_X1
* cell instance $4155 r0 *1 2.28,37.8
X$4155 85 1191 1160 726 109 DFF_X1
* cell instance $4159 r0 *1 5.51,37.8
X$4159 1191 85 109 1254 BUF_X2
* cell instance $4160 r0 *1 6.27,37.8
X$4160 1192 85 109 1158 BUF_X1
* cell instance $4162 r0 *1 7.6,37.8
X$4162 1113 85 109 1157 BUF_X1
* cell instance $4164 m0 *1 7.79,37.8
X$4164 1076 85 109 716 CLKBUF_X3
* cell instance $4166 m0 *1 11.02,37.8
X$4166 85 1192 1142 1037 109 DFF_X1
* cell instance $4169 r0 *1 8.17,37.8
X$4169 85 1113 1235 1037 109 DFF_X1
* cell instance $4171 r0 *1 11.59,37.8
X$4171 206 85 109 1037 CLKBUF_X3
* cell instance $4172 r0 *1 12.54,37.8
X$4172 1113 85 109 1163 BUF_X2
* cell instance $4173 r0 *1 13.3,37.8
X$4173 1037 85 109 CLKBUF_X1
* cell instance $4175 r0 *1 14.63,37.8
X$4175 1192 85 109 1099 BUF_X2
* cell instance $4176 m0 *1 15.96,37.8
X$4176 1038 1195 85 109 1146 XOR2_X1
* cell instance $4177 m0 *1 15.39,37.8
X$4177 1146 971 85 109 1094 NOR2_X1
* cell instance $4178 m0 *1 17.1,37.8
X$4178 993 1097 109 85 1115 XNOR2_X1
* cell instance $4179 m0 *1 18.24,37.8
X$4179 1115 971 85 109 1039 NOR2_X1
* cell instance $4180 m0 *1 18.81,37.8
X$4180 1096 1081 1078 85 109 1097 NOR3_X1
* cell instance $4181 m0 *1 19.57,37.8
X$4181 1038 1116 999 85 109 1096 NAND3_X1
* cell instance $4183 m0 *1 20.52,37.8
X$4183 559 1117 998 1000 1099 1027 109 85 AOI221_X2
* cell instance $4184 m0 *1 22.61,37.8
X$4184 560 1150 998 1000 1116 1075 109 85 AOI221_X2
* cell instance $4185 m0 *1 24.7,37.8
X$4185 1070 1079 85 109 1121 XOR2_X1
* cell instance $4187 m0 *1 26.6,37.8
X$4187 1080 1070 85 109 1122 NAND2_X1
* cell instance $4188 m0 *1 27.17,37.8
X$4188 1122 1081 1078 85 109 1041 NOR3_X1
* cell instance $4193 r0 *1 20.14,37.8
X$4193 1166 1119 1196 85 1150 109 AOI21_X1
* cell instance $4195 r0 *1 21.09,37.8
X$4195 1166 1119 1198 85 1118 109 AOI21_X1
* cell instance $4197 r0 *1 22.04,37.8
X$4197 999 1116 1038 993 109 85 1152 AND4_X1
* cell instance $4199 r0 *1 23.37,37.8
X$4199 1166 1119 1199 85 1120 109 AOI21_X1
* cell instance $4201 r0 *1 24.32,37.8
X$4201 1152 85 109 1080 BUF_X2
* cell instance $4202 r0 *1 25.08,37.8
X$4202 1121 971 85 109 1202 NOR2_X1
* cell instance $4204 r0 *1 27.17,37.8
X$4204 1167 85 109 1070 CLKBUF_X2
* cell instance $4206 m0 *1 29.07,37.8
X$4206 1080 1082 1025 1070 85 109 1083 NAND4_X1
* cell instance $4207 m0 *1 28.31,37.8
X$4207 1080 1025 1070 85 109 1105 NAND3_X1
* cell instance $4208 m0 *1 30.02,37.8
X$4208 1083 1081 1078 85 109 1084 NOR3_X1
* cell instance $4209 m0 *1 30.78,37.8
X$4209 1082 1123 1105 85 109 1124 OR3_X1
* cell instance $4212 r0 *1 29.07,37.8
X$4212 1070 1025 1082 1042 109 85 1222 AND4_X1
* cell instance $4214 r0 *1 30.59,37.8
X$4214 1105 1123 1082 109 1204 85 OAI21_X1
* cell instance $4215 r0 *1 31.35,37.8
X$4215 945 1124 1204 85 1168 109 AOI21_X1
* cell instance $4217 m0 *1 32.11,37.8
X$4217 1125 85 109 1082 BUF_X1
* cell instance $4218 m0 *1 34.2,37.8
X$4218 754 1085 1169 1127 1082 1155 109 85 AOI221_X2
* cell instance $4225 r0 *1 34.2,37.8
X$4225 771 1126 1169 1127 1042 1213 109 85 AOI221_X2
* cell instance $4229 r0 *1 38.38,37.8
X$4229 85 1207 829 2425 125 109 DFF_X2
* cell instance $4230 m0 *1 39.14,37.8
X$4230 1110 487 85 109 1207 NOR2_X1
* cell instance $4233 m0 *1 41.23,37.8
X$4233 125 1156 109 85 1110 XNOR2_X1
* cell instance $4235 m0 *1 43.13,37.8
X$4235 1173 1108 85 109 1045 XOR2_X1
* cell instance $4236 m0 *1 44.27,37.8
X$4236 841 873 844 85 109 1108 NAND3_X1
* cell instance $4240 r0 *1 43.13,37.8
X$4240 873 1173 1170 125 109 85 1048 AND4_X2
* cell instance $4242 r0 *1 44.65,37.8
X$4242 125 976 85 109 1307 NOR2_X1
* cell instance $4244 m0 *1 45.6,37.8
X$4244 1029 1155 1046 85 109 1101 OR3_X1
* cell instance $4246 m0 *1 46.55,37.8
X$4246 194 1129 85 109 1128 NOR2_X1
* cell instance $4249 r0 *1 45.79,37.8
X$4249 1029 1213 1128 85 109 1149 OR3_X1
* cell instance $4251 r0 *1 46.93,37.8
X$4251 955 932 85 109 1214 OR2_X1
* cell instance $4253 m0 *1 47.5,37.8
X$4253 1048 1005 1049 85 109 1003 NAND3_X1
* cell instance $4256 m0 *1 52.25,37.8
X$4256 1049 1106 109 85 1154 XNOR2_X1
* cell instance $4257 m0 *1 53.39,37.8
X$4257 1049 976 85 109 1131 NOR2_X1
* cell instance $4258 m0 *1 53.96,37.8
X$4258 1154 375 85 109 1104 NOR2_X1
* cell instance $4259 m0 *1 54.53,37.8
X$4259 85 383 1104 1177 109 DFF_X1
* cell instance $4262 m0 *1 59.47,37.8
X$4262 809 978 216 85 1132 109 AOI21_X1
* cell instance $4265 m0 *1 61.94,37.8
X$4265 85 1054 1056 1086 1055 935 109 NOR4_X4
* cell instance $4266 m0 *1 65.36,37.8
X$4266 1087 891 1053 85 109 1102 NAND3_X1
* cell instance $4267 m0 *1 66.12,37.8
X$4267 85 1133 1103 1088 109 DFF_X1
* cell instance $4269 r0 *1 47.69,37.8
X$4269 1214 85 109 933 BUF_X2
* cell instance $4272 r0 *1 50.35,37.8
X$4272 1032 842 85 109 1130 NAND2_X1
* cell instance $4274 r0 *1 51.11,37.8
X$4274 1130 933 1174 109 1216 85 OAI21_X1
* cell instance $4276 r0 *1 53.39,37.8
X$4276 978 1197 1131 85 109 1151 OR3_X1
* cell instance $4279 r0 *1 54.91,37.8
X$4279 430 85 109 1174 BUF_X1
* cell instance $4286 r0 *1 59.47,37.8
X$4286 809 978 317 85 1153 109 AOI21_X1
* cell instance $4291 r0 *1 63.08,37.8
X$4291 812 1151 1298 979 1212 1143 109 85 AOI221_X2
* cell instance $4292 r0 *1 65.17,37.8
X$4292 1178 85 109 1212 INV_X1
* cell instance $4294 r0 *1 65.74,37.8
X$4294 1211 721 85 109 1210 NOR2_X1
* cell instance $4296 r0 *1 66.69,37.8
X$4296 85 1098 1210 1088 109 DFF_X1
* cell instance $4298 m0 *1 69.73,37.8
X$4298 814 1101 1148 1134 1057 1010 109 85 AOI221_X2
* cell instance $4300 r0 *1 69.92,37.8
X$4300 1098 85 109 1178 BUF_X2
* cell instance $4301 r0 *1 70.68,37.8
X$4301 1149 778 1179 1134 1135 85 109 1006 AOI221_X1
* cell instance $4302 r0 *1 71.82,37.8
X$4302 1133 1053 1178 1203 85 109 1180 NAND4_X1
* cell instance $4304 m0 *1 73.15,37.8
X$4304 1137 85 109 1135 INV_X1
* cell instance $4306 m0 *1 73.53,37.8
X$4306 505 1137 1062 727 85 109 1147 NAND4_X1
* cell instance $4307 m0 *1 74.48,37.8
X$4307 1062 727 85 109 1138 NAND2_X1
* cell instance $4308 m0 *1 75.05,37.8
X$4308 1088 85 109 2440 INV_X1
* cell instance $4309 m0 *1 75.43,37.8
X$4309 1145 772 85 109 1095 NOR2_X1
* cell instance $4310 m0 *1 76,37.8
X$4310 85 1058 1095 1088 109 DFF_X1
* cell instance $4311 m0 *1 79.23,37.8
X$4311 1143 85 109 1141 BUF_X1
* cell instance $4313 r0 *1 72.96,37.8
X$4313 505 85 109 1136 INV_X1
* cell instance $4314 r0 *1 73.34,37.8
X$4314 1136 1182 109 85 1144 XNOR2_X1
* cell instance $4315 r0 *1 74.48,37.8
X$4315 1135 1185 109 85 1145 XNOR2_X1
* cell instance $4316 r0 *1 75.62,37.8
X$4316 263 85 109 1088 CLKBUF_X3
* cell instance $4317 r0 *1 76.57,37.8
X$4317 1187 1185 1089 109 1186 85 OAI21_X1
* cell instance $4318 r0 *1 77.33,37.8
X$4318 505 1137 85 109 1187 NAND2_X1
* cell instance $4319 r0 *1 77.9,37.8
X$4319 1144 772 85 109 1188 NOR2_X1
* cell instance $4321 r0 *1 78.85,37.8
X$4321 1058 109 1137 85 BUF_X4
* cell instance $4323 m0 *1 80.18,37.8
X$4323 1089 85 109 1140 BUF_X1
* cell instance $4324 r0 *1 80.18,37.8
X$4324 1139 85 109 1189 BUF_X1
* cell instance $4358 r0 *1 11.59,4.2
X$4358 85 133 148 200 109 DFF_X1
* cell instance $4359 r0 *1 14.82,4.2
X$4359 133 109 193 85 BUF_X4
* cell instance $4361 m0 *1 17.67,4.2
X$4361 85 90 200 2364 111 109 DFF_X2
* cell instance $4363 m0 *1 25.27,4.2
X$4363 85 93 113 115 109 DFF_X1
* cell instance $4368 r0 *1 20.52,4.2
X$4368 139 144 135 85 109 134 NOR3_X1
* cell instance $4369 r0 *1 21.28,4.2
X$4369 138 85 109 135 INV_X1
* cell instance $4371 r0 *1 23.18,4.2
X$4371 138 155 109 85 136 XNOR2_X1
* cell instance $4372 r0 *1 24.32,4.2
X$4372 139 143 85 109 155 NOR2_X1
* cell instance $4375 m0 *1 28.88,4.2
X$4375 93 85 109 154 BUF_X1
* cell instance $4378 m0 *1 33.63,4.2
X$4378 98 85 109 140 CLKBUF_X2
* cell instance $4380 m0 *1 34.58,4.2
X$4380 85 98 121 97 109 DFF_X1
* cell instance $4382 m0 *1 38,4.2
X$4382 85 102 124 97 109 DFF_X1
* cell instance $4384 r0 *1 29.45,4.2
X$4384 154 174 109 85 152 XNOR2_X1
* cell instance $4386 r0 *1 30.97,4.2
X$4386 153 156 139 144 85 109 174 NOR4_X1
* cell instance $4388 r0 *1 32.11,4.2
X$4388 95 140 85 109 153 NAND2_X1
* cell instance $4391 r0 *1 34.39,4.2
X$4391 140 151 109 85 99 XNOR2_X1
* cell instance $4392 r0 *1 35.53,4.2
X$4392 156 139 144 85 109 151 NOR3_X1
* cell instance $4395 r0 *1 38,4.2
X$4395 141 172 109 85 101 XNOR2_X1
* cell instance $4397 r0 *1 39.52,4.2
X$4397 162 142 139 143 85 109 163 NOR4_X1
* cell instance $4399 r0 *1 40.85,4.2
X$4399 100 163 109 85 150 XNOR2_X1
* cell instance $4400 m0 *1 41.61,4.2
X$4400 85 100 103 132 109 DFF_X1
* cell instance $4402 m0 *1 46.17,4.2
X$4402 106 85 109 131 BUF_X2
* cell instance $4403 m0 *1 46.93,4.2
X$4403 85 106 130 132 109 DFF_X1
* cell instance $4409 r0 *1 42.56,4.2
X$4409 142 139 144 85 109 170 NOR3_X1
* cell instance $4412 r0 *1 43.89,4.2
X$4412 131 170 109 85 147 XNOR2_X1
* cell instance $4416 r0 *1 47.12,4.2
X$4416 145 85 109 161 CLKBUF_X2
* cell instance $4424 r0 *1 2.09,12.6
X$4424 342 85 109 266 BUF_X1
* cell instance $4425 r0 *1 2.66,12.6
X$4425 85 342 313 236 109 DFF_X1
* cell instance $4429 r0 *1 5.89,12.6
X$4429 342 109 298 85 BUF_X4
* cell instance $4430 r0 *1 7.22,12.6
X$4430 343 268 85 109 313 NOR2_X1
* cell instance $4431 m0 *1 8.36,12.6
X$4431 299 144 109 85 281 XNOR2_X1
* cell instance $4432 m0 *1 7.79,12.6
X$4432 281 268 85 109 267 NOR2_X1
* cell instance $4433 m0 *1 9.5,12.6
X$4433 326 85 109 299 INV_X1
* cell instance $4436 m0 *1 11.59,12.6
X$4436 316 268 85 109 269 NOR2_X1
* cell instance $4441 r0 *1 7.98,12.6
X$4441 298 345 109 85 343 XNOR2_X1
* cell instance $4442 r0 *1 9.12,12.6
X$4442 298 326 85 109 327 NAND2_X1
* cell instance $4443 r0 *1 9.69,12.6
X$4443 143 299 85 109 345 NOR2_X1
* cell instance $4447 r0 *1 14.25,12.6
X$4447 193 177 199 89 85 329 109 NAND4_X2
* cell instance $4449 m0 *1 17.67,12.6
X$4449 300 319 109 85 286 XNOR2_X1
* cell instance $4452 m0 *1 19.76,12.6
X$4452 91 85 109 300 BUF_X1
* cell instance $4457 r0 *1 17.86,12.6
X$4457 330 179 143 85 109 319 NOR3_X1
* cell instance $4463 r0 *1 25.08,12.6
X$4463 239 85 109 144 CLKBUF_X3
* cell instance $4465 m0 *1 25.65,12.6
X$4465 115 85 109 CLKBUF_X1
* cell instance $4468 r0 *1 26.41,12.6
X$4468 322 183 85 109 301 NOR2_X1
* cell instance $4470 m0 *1 28.12,12.6
X$4470 293 156 210 239 85 109 294 NOR4_X1
* cell instance $4473 r0 *1 28.12,12.6
X$4473 356 156 210 239 85 109 355 NOR4_X1
* cell instance $4474 r0 *1 29.07,12.6
X$4474 244 184 242 85 109 356 NAND3_X1
* cell instance $4475 r0 *1 29.83,12.6
X$4475 271 244 85 109 359 NAND2_X1
* cell instance $4477 r0 *1 30.78,12.6
X$4477 359 156 210 203 85 109 332 NOR4_X1
* cell instance $4479 m0 *1 32.3,12.6
X$4479 86 273 109 85 272 XNOR2_X1
* cell instance $4481 m0 *1 33.44,12.6
X$4481 272 183 85 109 302 NOR2_X1
* cell instance $4484 m0 *1 41.61,12.6
X$4484 85 297 132 2374 112 109 DFF_X2
* cell instance $4485 m0 *1 45.22,12.6
X$4485 364 213 85 109 297 NOR2_X1
* cell instance $4488 r0 *1 32.49,12.6
X$4488 85 302 97 2395 86 109 DFF_X2
* cell instance $4491 r0 *1 40.66,12.6
X$4491 85 104 374 335 109 DFF_X1
* cell instance $4496 r0 *1 46.74,12.6
X$4496 336 334 85 109 363 XOR2_X1
* cell instance $4502 r0 *1 49.02,12.6
X$4502 363 166 85 109 324 NOR2_X1
* cell instance $4505 r0 *1 51.87,12.6
X$4505 85 323 169 2396 186 109 DFF_X2
* cell instance $4506 m0 *1 53.77,12.6
X$4506 186 362 85 109 303 XOR2_X1
* cell instance $4508 m0 *1 54.91,12.6
X$4508 295 212 296 186 109 85 304 AND4_X1
* cell instance $4509 m0 *1 56.05,12.6
X$4509 252 295 85 109 274 NAND2_X1
* cell instance $4511 m0 *1 56.81,12.6
X$4511 169 85 109 CLKBUF_X1
* cell instance $4512 m0 *1 57.38,12.6
X$4512 263 85 109 169 CLKBUF_X3
* cell instance $4513 m0 *1 58.33,12.6
X$4513 215 187 216 317 109 85 275 AND4_X1
* cell instance $4515 m0 *1 59.66,12.6
X$4515 275 214 85 109 292 NAND2_X1
* cell instance $4517 m0 *1 61.75,12.6
X$4517 250 277 275 109 85 291 AND3_X2
* cell instance $4520 r0 *1 55.48,12.6
X$4520 303 213 85 109 323 NOR2_X1
* cell instance $4522 r0 *1 56.24,12.6
X$4522 304 109 251 85 BUF_X4
* cell instance $4528 r0 *1 60.61,12.6
X$4528 275 251 252 250 85 109 357 NAND4_X1
* cell instance $4529 r0 *1 61.56,12.6
X$4529 358 166 85 109 361 NOR2_X1
* cell instance $4530 r0 *1 62.13,12.6
X$4530 277 357 85 109 358 XOR2_X1
* cell instance $4532 r0 *1 63.65,12.6
X$4532 291 379 217 219 85 109 320 NAND4_X1
* cell instance $4534 m0 *1 64.03,12.6
X$4534 305 320 85 109 288 XOR2_X1
* cell instance $4535 m0 *1 65.93,12.6
X$4535 288 166 85 109 318 NOR2_X1
* cell instance $4536 m0 *1 66.5,12.6
X$4536 85 318 146 2337 305 109 DFF_X2
* cell instance $4540 r0 *1 64.6,12.6
X$4540 291 251 252 354 85 353 109 NAND4_X2
* cell instance $4541 r0 *1 66.31,12.6
X$4541 219 217 305 109 85 306 AND3_X1
* cell instance $4542 r0 *1 67.26,12.6
X$4542 306 255 214 190 85 109 434 NAND4_X1
* cell instance $4543 r0 *1 68.21,12.6
X$4543 354 255 379 307 85 109 308 NAND4_X1
* cell instance $4544 r0 *1 69.16,12.6
X$4544 85 284 309 310 109 DFF_X1
* cell instance $4546 r0 *1 72.58,12.6
X$4546 85 283 338 310 109 DFF_X1
* cell instance $4547 m0 *1 74.48,12.6
X$4547 277 85 109 312 BUF_X1
* cell instance $4550 m0 *1 75.62,12.6
X$4550 284 85 109 314 BUF_X1
* cell instance $4553 r0 *1 75.81,12.6
X$4553 283 85 109 339 CLKBUF_X2
* cell instance $4554 m0 *1 76.76,12.6
X$4554 317 85 109 311 BUF_X1
* cell instance $4556 m0 *1 77.33,12.6
X$4556 85 278 315 310 109 DFF_X1
* cell instance $4559 r0 *1 76.57,12.6
X$4559 85 348 310 2417 346 109 DFF_X2
* cell instance $4560 r0 *1 80.18,12.6
X$4560 346 85 109 341 BUF_X1
* cell instance $4582 m0 *1 18.62,77
X$4582 85 2245 2207 2014 109 DFF_X1
* cell instance $4584 m0 *1 21.85,77
X$4584 2208 1001 85 109 2258 NOR2_X1
* cell instance $4589 r0 *1 19.95,77
X$4589 85 2246 2258 2014 109 DFF_X1
* cell instance $4590 r0 *1 23.18,77
X$4590 2246 109 2148 85 BUF_X4
* cell instance $4592 r0 *1 24.7,77
X$4592 85 2247 1910 2428 2149 109 DFF_X2
* cell instance $4593 m0 *1 25.27,77
X$4593 2209 1001 85 109 2247 NOR2_X1
* cell instance $4596 m0 *1 26.41,77
X$4596 85 2122 2210 1910 109 DFF_X1
* cell instance $4600 r0 *1 28.5,77
X$4600 85 2248 1910 2400 2138 109 DFF_X2
* cell instance $4601 m0 *1 30.21,77
X$4601 85 2180 2211 1910 109 DFF_X1
* cell instance $4603 m0 *1 33.44,77
X$4603 2261 945 85 109 2260 NOR2_X1
* cell instance $4605 m0 *1 34.2,77
X$4605 85 2263 2212 1932 109 DFF_X1
* cell instance $4606 m0 *1 37.43,77
X$4606 2271 109 659 85 BUF_X4
* cell instance $4611 m0 *1 51.87,77
X$4611 85 2249 2214 2154 109 DFF_X1
* cell instance $4614 m0 *1 56.81,77
X$4614 85 2218 2251 2154 109 DFF_X1
* cell instance $4617 m0 *1 60.99,77
X$4617 2243 679 85 109 2252 NOR2_X1
* cell instance $4618 m0 *1 61.56,77
X$4618 85 2253 2156 2367 1849 109 DFF_X2
* cell instance $4621 r0 *1 32.11,77
X$4621 85 2125 2260 1932 109 DFF_X1
* cell instance $4623 r0 *1 35.53,77
X$4623 1913 85 109 2270 BUF_X1
* cell instance $4628 r0 *1 40.47,77
X$4628 1266 85 109 2272 BUF_X1
* cell instance $4631 r0 *1 41.61,77
X$4631 1888 85 109 2273 BUF_X1
* cell instance $4634 r0 *1 44.46,77
X$4634 1691 85 109 2275 BUF_X1
* cell instance $4635 r0 *1 45.03,77
X$4635 1723 85 109 2276 BUF_X1
* cell instance $4637 r0 *1 45.98,77
X$4637 1724 85 109 2277 BUF_X1
* cell instance $4642 r0 *1 51.68,77
X$4642 2067 85 109 2278 BUF_X1
* cell instance $4644 r0 *1 52.44,77
X$4644 85 2265 2215 2154 109 DFF_X1
* cell instance $4646 r0 *1 55.86,77
X$4646 2265 85 109 1864 CLKBUF_X2
* cell instance $4648 r0 *1 56.81,77
X$4648 85 2250 2154 2429 1824 109 DFF_X2
* cell instance $4653 r0 *1 60.61,77
X$4653 85 2252 2156 2434 1867 109 DFF_X2
* cell instance $4655 r0 *1 64.6,77
X$4655 85 2266 2274 2156 109 DFF_X1
* cell instance $4656 m0 *1 70.3,77
X$4656 1827 2189 85 109 2264 XOR2_X1
* cell instance $4657 m0 *1 67.07,77
X$4657 85 2254 2220 2156 109 DFF_X1
* cell instance $4658 m0 *1 71.44,77
X$4658 1845 2189 2095 85 109 2262 OR3_X1
* cell instance $4660 m0 *1 73.91,77
X$4660 1966 2189 2225 85 109 2269 OR3_X1
* cell instance $4661 m0 *1 74.86,77
X$4661 2225 2189 1966 109 2255 85 OAI21_X1
* cell instance $4664 m0 *1 76.57,77
X$4664 2227 589 85 109 2257 NOR2_X1
* cell instance $4667 r0 *1 67.83,77
X$4667 2264 679 85 109 2274 NOR2_X1
* cell instance $4670 r0 *1 68.97,77
X$4670 2266 85 109 1827 BUF_X2
* cell instance $4671 r0 *1 69.73,77
X$4671 2254 85 109 1828 CLKBUF_X2
* cell instance $4673 r0 *1 70.68,77
X$4673 495 2262 2221 85 2267 109 AOI21_X1
* cell instance $4675 r0 *1 71.82,77
X$4675 2268 85 109 1845 CLKBUF_X2
* cell instance $4679 r0 *1 74.67,77
X$4679 495 2269 2255 85 2259 109 AOI21_X1
* cell instance $4680 r0 *1 75.43,77
X$4680 85 2256 2259 2096 109 DFF_X1
* cell instance $4697 r0 *1 15.77,74.2
X$4697 85 2226 2014 2423 2134 109 DFF_X2
* cell instance $4698 m0 *1 19.38,74.2
X$4698 2014 85 109 CLKBUF_X1
* cell instance $4699 m0 *1 18.43,74.2
X$4699 1354 85 109 2014 CLKBUF_X3
* cell instance $4700 m0 *1 19.95,74.2
X$4700 2177 1001 85 109 2226 NOR2_X1
* cell instance $4702 m0 *1 21.28,74.2
X$4702 2197 1001 85 109 2207 NOR2_X1
* cell instance $4708 r0 *1 21.47,74.2
X$4708 2245 85 109 2147 BUF_X2
* cell instance $4709 r0 *1 22.23,74.2
X$4709 2148 2178 109 85 2208 XNOR2_X1
* cell instance $4711 m0 *1 24.51,74.2
X$4711 2228 2087 2022 1958 85 109 2229 NOR4_X1
* cell instance $4712 m0 *1 23.75,74.2
X$4712 2023 2148 2147 85 109 2228 NAND3_X1
* cell instance $4715 r0 *1 24.32,74.2
X$4715 2149 2229 109 85 2209 XNOR2_X1
* cell instance $4718 m0 *1 25.84,74.2
X$4718 2122 2179 109 85 2230 XNOR2_X1
* cell instance $4720 m0 *1 29.26,74.2
X$4720 2138 2201 109 85 2231 XNOR2_X1
* cell instance $4723 r0 *1 26.6,74.2
X$4723 2230 1001 85 109 2210 NOR2_X1
* cell instance $4726 r0 *1 29.45,74.2
X$4726 2231 1001 85 109 2248 NOR2_X1
* cell instance $4728 r0 *1 30.78,74.2
X$4728 2232 945 85 109 2211 NOR2_X1
* cell instance $4730 m0 *1 30.78,74.2
X$4730 2180 2202 109 85 2232 XNOR2_X1
* cell instance $4731 m0 *1 32.11,74.2
X$4731 2180 85 109 1961 INV_X1
* cell instance $4734 m0 *1 33.44,74.2
X$4734 2139 2182 109 85 2233 XNOR2_X1
* cell instance $4737 m0 *1 35.53,74.2
X$4737 2263 85 109 2139 BUF_X1
* cell instance $4742 m0 *1 50.54,74.2
X$4742 2234 692 85 109 2183 NOR2_X1
* cell instance $4748 r0 *1 32.68,74.2
X$4748 2125 2181 109 85 2261 XNOR2_X1
* cell instance $4750 r0 *1 34.2,74.2
X$4750 2233 945 85 109 2212 NOR2_X1
* cell instance $4755 r0 *1 48.83,74.2
X$4755 85 2213 2183 2154 109 DFF_X1
* cell instance $4758 m0 *1 52.25,74.2
X$4758 2213 85 109 1820 BUF_X1
* cell instance $4761 r0 *1 53.01,74.2
X$4761 2237 692 85 109 2215 NOR2_X1
* cell instance $4762 r0 *1 53.58,74.2
X$4762 1463 85 109 2154 CLKBUF_X3
* cell instance $4763 m0 *1 54.53,74.2
X$4763 2249 85 109 1863 CLKBUF_X2
* cell instance $4764 m0 *1 53.96,74.2
X$4764 2238 692 85 109 2214 NOR2_X1
* cell instance $4766 r0 *1 54.53,74.2
X$4766 1863 2216 85 109 2238 XOR2_X1
* cell instance $4768 m0 *1 55.67,74.2
X$4768 2058 2059 85 109 2216 NAND2_X1
* cell instance $4769 r0 *1 55.67,74.2
X$4769 1864 2205 85 109 2237 XOR2_X1
* cell instance $4770 m0 *1 56.81,74.2
X$4770 2058 2069 1863 85 109 2205 NAND3_X1
* cell instance $4773 m0 *1 58.33,74.2
X$4773 2184 2058 2069 85 109 2217 NAND3_X1
* cell instance $4774 m0 *1 59.09,74.2
X$4774 1918 2185 85 109 2240 XOR2_X1
* cell instance $4775 m0 *1 60.23,74.2
X$4775 2031 2058 2059 85 109 2185 NAND3_X1
* cell instance $4778 r0 *1 57,74.2
X$4778 2239 692 85 109 2250 NOR2_X1
* cell instance $4779 r0 *1 57.57,74.2
X$4779 2240 692 85 109 2251 NOR2_X1
* cell instance $4781 r0 *1 58.33,74.2
X$4781 1824 2217 85 109 2239 XOR2_X1
* cell instance $4786 r0 *1 59.66,74.2
X$4786 2218 85 109 1918 CLKBUF_X2
* cell instance $4788 m0 *1 61.56,74.2
X$4788 1918 1779 109 85 2242 AND2_X1
* cell instance $4790 m0 *1 62.32,74.2
X$4790 2242 2031 2058 2059 85 109 2186 NAND4_X1
* cell instance $4791 m0 *1 63.27,74.2
X$4791 2187 2242 2031 2058 85 109 2244 NAND4_X1
* cell instance $4794 r0 *1 62.13,74.2
X$4794 1867 2186 85 109 2243 XOR2_X1
* cell instance $4795 r0 *1 63.27,74.2
X$4795 1849 2244 85 109 2241 XOR2_X1
* cell instance $4798 m0 *1 64.6,74.2
X$4798 85 2219 2188 2156 109 DFF_X1
* cell instance $4799 m0 *1 68.02,74.2
X$4799 2190 2035 2058 2069 85 109 2236 NAND4_X1
* cell instance $4801 m0 *1 69.16,74.2
X$4801 2035 2036 2094 85 109 2189 NAND3_X2
* cell instance $4802 m0 *1 70.49,74.2
X$4802 1827 1887 1828 1883 109 85 2222 AND4_X1
* cell instance $4804 r0 *1 65.17,74.2
X$4804 1463 85 109 2156 CLKBUF_X3
* cell instance $4805 r0 *1 66.12,74.2
X$4805 2241 679 85 109 2253 NOR2_X1
* cell instance $4806 r0 *1 66.69,74.2
X$4806 2156 85 109 CLKBUF_X1
* cell instance $4809 r0 *1 67.83,74.2
X$4809 2235 679 85 109 2220 NOR2_X1
* cell instance $4810 r0 *1 68.4,74.2
X$4810 1828 2236 85 109 2235 XOR2_X1
* cell instance $4813 r0 *1 70.68,74.2
X$4813 2095 2189 1845 109 2221 85 OAI21_X1
* cell instance $4815 r0 *1 71.63,74.2
X$4815 1845 2222 109 85 2223 AND2_X1
* cell instance $4816 m0 *1 72.96,74.2
X$4816 2224 2035 2036 2059 85 109 2191 NAND4_X1
* cell instance $4817 m0 *1 72.01,74.2
X$4817 2223 2035 2036 2059 85 109 2199 NAND4_X1
* cell instance $4819 r0 *1 72.39,74.2
X$4819 1845 1906 1966 2222 109 85 2224 AND4_X1
* cell instance $4820 r0 *1 73.53,74.2
X$4820 2223 1906 85 109 2225 NAND2_X1
* cell instance $4823 m0 *1 74.29,74.2
X$4823 1882 2191 85 109 2227 XOR2_X1
* cell instance $4824 r0 *1 75.62,74.2
X$4824 2256 85 109 1966 CLKBUF_X2
* cell instance $4826 m0 *1 75.81,74.2
X$4826 85 2192 2096 2339 1883 109 DFF_X2
* cell instance $4827 m0 *1 80.18,74.2
X$4827 2256 85 109 2193 BUF_X1
* cell instance $4829 r0 *1 76.38,74.2
X$4829 2096 85 109 CLKBUF_X1
* cell instance $4831 r0 *1 77.14,74.2
X$4831 85 2257 2096 2398 1882 109 DFF_X2
* cell instance $4834 m0 *1 1.71,54.6
X$4834 1666 85 109 1367 CLKBUF_X3
* cell instance $4840 r0 *1 1.33,54.6
X$4840 85 1679 1697 1316 109 DFF_X1
* cell instance $4844 r0 *1 4.56,54.6
X$4844 1679 109 1680 85 BUF_X4
* cell instance $4845 r0 *1 5.89,54.6
X$4845 1680 1738 109 85 1681 XNOR2_X1
* cell instance $4846 r0 *1 7.03,54.6
X$4846 1681 183 85 109 1697 NOR2_X1
* cell instance $4847 r0 *1 7.6,54.6
X$4847 1680 85 109 1698 INV_X1
* cell instance $4851 r0 *1 9.31,54.6
X$4851 1367 1486 1698 85 1699 109 AOI21_X1
* cell instance $4854 m0 *1 10.64,54.6
X$4854 1367 1486 1742 85 1490 109 AOI21_X1
* cell instance $4856 m0 *1 11.78,54.6
X$4856 835 1699 1390 1393 1412 1656 109 85 AOI221_X2
* cell instance $4857 m0 *1 14.06,54.6
X$4857 85 1667 1370 2352 1563 109 DFF_X2
* cell instance $4858 m0 *1 17.67,54.6
X$4858 858 1700 1390 1393 1479 1677 109 85 AOI221_X2
* cell instance $4860 m0 *1 20.52,54.6
X$4860 1354 85 109 1370 CLKBUF_X3
* cell instance $4861 m0 *1 21.47,54.6
X$4861 1367 85 109 1615 CLKBUF_X3
* cell instance $4862 m0 *1 22.42,54.6
X$4862 1717 85 109 1371 INV_X1
* cell instance $4867 r0 *1 16.91,54.6
X$4867 803 1701 109 85 1715 AND2_X1
* cell instance $4868 r0 *1 17.67,54.6
X$4868 1790 1765 1717 85 109 1701 MUX2_X1
* cell instance $4869 r0 *1 19,54.6
X$4869 1615 1486 1713 85 1700 109 AOI21_X1
* cell instance $4873 r0 *1 23.94,54.6
X$4873 1784 85 109 1718 CLKBUF_X2
* cell instance $4875 r0 *1 25.46,54.6
X$4875 1682 1718 85 109 1719 NOR2_X1
* cell instance $4877 r0 *1 26.22,54.6
X$4877 1768 1583 85 109 1749 NAND2_X1
* cell instance $4880 m0 *1 26.98,54.6
X$4880 85 1683 1642 1652 109 DFF_X1
* cell instance $4882 m0 *1 31.16,54.6
X$4882 1653 1453 1123 85 109 1687 NOR3_X1
* cell instance $4884 m0 *1 32.68,54.6
X$4884 974 1675 1390 1127 1686 1674 109 85 AOI221_X2
* cell instance $4885 m0 *1 34.77,54.6
X$4885 1615 1416 1688 85 1675 109 AOI21_X1
* cell instance $4889 r0 *1 26.98,54.6
X$4889 1682 1494 85 109 1705 NOR2_X1
* cell instance $4892 r0 *1 29.45,54.6
X$4892 1683 85 109 1494 BUF_X2
* cell instance $4893 r0 *1 30.21,54.6
X$4893 1653 1707 85 109 1768 NOR2_X2
* cell instance $4895 r0 *1 31.35,54.6
X$4895 987 1755 1390 1393 1718 1708 109 85 AOI221_X2
* cell instance $4897 r0 *1 33.82,54.6
X$4897 1686 85 109 1707 INV_X1
* cell instance $4898 r0 *1 34.2,54.6
X$4898 1682 1707 85 109 1799 NOR2_X1
* cell instance $4900 r0 *1 34.96,54.6
X$4900 85 1721 1547 2410 1686 109 DFF_X2
* cell instance $4902 r0 *1 38.95,54.6
X$4902 85 1689 1547 2421 1499 109 DFF_X2
* cell instance $4904 m0 *1 39.71,54.6
X$4904 724 1546 109 85 1689 AND2_X1
* cell instance $4907 m0 *1 45.22,54.6
X$4907 1678 85 109 1502 BUF_X2
* cell instance $4909 m0 *1 46.74,54.6
X$4909 1753 1129 85 109 1655 NOR2_X1
* cell instance $4910 m0 *1 47.31,54.6
X$4910 1691 1129 85 109 1649 NOR2_X1
* cell instance $4913 m0 *1 49.59,54.6
X$4913 1502 1327 85 109 1657 NOR2_X1
* cell instance $4914 m0 *1 50.16,54.6
X$4914 1548 1327 85 109 1676 NOR2_X1
* cell instance $4916 m0 *1 53.77,54.6
X$4916 1673 721 85 109 1658 NOR2_X1
* cell instance $4920 r0 *1 43.7,54.6
X$4920 85 1754 1692 2408 1753 109 DFF_X2
* cell instance $4921 r0 *1 47.31,54.6
X$4921 1457 1674 1752 85 109 1702 OR3_X1
* cell instance $4923 r0 *1 48.64,54.6
X$4923 1457 1646 1751 85 109 1703 OR3_X1
* cell instance $4924 r0 *1 49.59,54.6
X$4924 1457 1677 1657 85 109 1806 OR3_X1
* cell instance $4925 r0 *1 50.54,54.6
X$4925 1457 1656 1676 85 109 1750 OR3_X1
* cell instance $4928 r0 *1 52.44,54.6
X$4928 85 1693 1658 1692 109 DFF_X1
* cell instance $4929 m0 *1 55.86,54.6
X$4929 85 1650 1620 1659 1660 109 DFF_X2
* cell instance $4930 m0 *1 54.72,54.6
X$4930 1672 1709 109 85 1673 XNOR2_X1
* cell instance $4933 r0 *1 55.67,54.6
X$4933 1693 85 109 1672 INV_X1
* cell instance $4936 r0 *1 56.62,54.6
X$4936 1591 1706 85 109 1725 NAND2_X1
* cell instance $4937 r0 *1 57.19,54.6
X$4937 1706 1694 1693 109 85 1602 AND3_X1
* cell instance $4938 r0 *1 58.14,54.6
X$4938 1591 1660 1726 1694 85 109 1709 NAND4_X1
* cell instance $4942 r0 *1 59.09,54.6
X$4942 1694 1726 1660 1693 109 85 1549 AND4_X1
* cell instance $4954 m0 *1 11.02,71.4
X$4954 85 2143 2159 1926 109 DFF_X1
* cell instance $4957 m0 *1 15.01,71.4
X$4957 2160 1036 85 109 2194 NOR2_X1
* cell instance $4958 m0 *1 15.58,71.4
X$4958 2143 85 109 2062 BUF_X2
* cell instance $4959 m0 *1 16.34,71.4
X$4959 2120 2144 109 85 2160 XNOR2_X1
* cell instance $4960 m0 *1 17.48,71.4
X$4960 2146 2145 1894 85 109 2144 NOR3_X1
* cell instance $4963 r0 *1 14.25,71.4
X$4963 85 2194 2014 2424 2120 109 DFF_X2
* cell instance $4966 r0 *1 18.43,71.4
X$4966 2134 2171 109 85 2177 XNOR2_X1
* cell instance $4968 m0 *1 18.62,71.4
X$4968 2146 2022 1958 1297 85 109 2171 NOR4_X1
* cell instance $4972 r0 *1 21.28,71.4
X$4972 2147 2174 109 85 2197 XNOR2_X1
* cell instance $4974 m0 *1 21.47,71.4
X$4974 2087 2145 1894 85 109 2174 NOR3_X1
* cell instance $4975 r0 *1 22.42,71.4
X$4975 2087 2022 1958 1199 85 109 2178 NOR4_X1
* cell instance $4976 m0 *1 22.8,71.4
X$4976 2147 85 109 1199 INV_X1
* cell instance $4978 m0 *1 23.18,71.4
X$4978 2147 2148 2174 109 85 2088 AND3_X1
* cell instance $4979 m0 *1 24.13,71.4
X$4979 2148 85 109 1201 INV_X1
* cell instance $4981 m0 *1 24.7,71.4
X$4981 1408 2086 85 109 2200 OR2_X1
* cell instance $4986 m0 *1 30.97,71.4
X$4986 2149 85 109 1443 INV_X1
* cell instance $4987 m0 *1 31.35,71.4
X$4987 2124 85 109 1684 INV_X1
* cell instance $4988 m0 *1 31.73,71.4
X$4988 1952 2138 2124 85 109 2165 NAND3_X1
* cell instance $4990 m0 *1 33.25,71.4
X$4990 2150 2089 85 109 2203 NAND2_X1
* cell instance $4991 m0 *1 33.82,71.4
X$4991 2150 1913 2139 2089 85 109 2113 NAND4_X1
* cell instance $4993 r0 *1 23.37,71.4
X$4993 2023 2148 2147 2149 85 2086 109 NAND4_X2
* cell instance $4995 r0 *1 25.27,71.4
X$4995 2200 2087 2022 1958 85 109 2179 NOR4_X1
* cell instance $4999 r0 *1 27.55,71.4
X$4999 1354 85 109 1910 CLKBUF_X3
* cell instance $5000 r0 *1 28.5,71.4
X$5000 1910 85 109 CLKBUF_X1
* cell instance $5002 r0 *1 29.26,71.4
X$5002 2161 2022 1958 1684 85 109 2201 NOR4_X1
* cell instance $5004 r0 *1 31.73,71.4
X$5004 2113 2161 2022 1958 85 109 2202 NOR4_X1
* cell instance $5005 r0 *1 32.68,71.4
X$5005 2165 2161 2022 1958 85 109 2181 NOR4_X1
* cell instance $5006 r0 *1 33.63,71.4
X$5006 2203 2161 2022 1958 85 109 2182 NOR4_X1
* cell instance $5008 m0 *1 35.72,71.4
X$5008 1932 85 109 CLKBUF_X1
* cell instance $5009 m0 *1 35.15,71.4
X$5009 2152 85 109 2089 BUF_X1
* cell instance $5010 m0 *1 36.29,71.4
X$5010 85 2152 2151 1932 109 DFF_X1
* cell instance $5014 m0 *1 44.27,71.4
X$5014 85 2119 1935 2358 1723 109 DFF_X2
* cell instance $5018 m0 *1 51.87,71.4
X$5018 2128 1936 2069 85 109 2169 NAND3_X1
* cell instance $5019 m0 *1 48.26,71.4
X$5019 85 2170 2154 2360 1862 109 DFF_X2
* cell instance $5020 m0 *1 52.63,71.4
X$5020 1902 2168 85 109 2167 XOR2_X1
* cell instance $5021 m0 *1 53.77,71.4
X$5021 2167 692 85 109 2206 NOR2_X1
* cell instance $5027 r0 *1 51.87,71.4
X$5027 1820 2169 85 109 2234 XOR2_X1
* cell instance $5029 r0 *1 53.39,71.4
X$5029 85 2206 2154 2431 1902 109 DFF_X2
* cell instance $5030 m0 *1 56.43,71.4
X$5030 85 2153 2154 2359 1865 109 DFF_X2
* cell instance $5033 m0 *1 60.23,71.4
X$5033 85 2164 2156 2377 1779 109 DFF_X2
* cell instance $5038 r0 *1 57.95,71.4
X$5038 1863 1864 1865 109 85 2184 AND3_X1
* cell instance $5045 r0 *1 61.56,71.4
X$5045 2031 2036 2094 1918 85 109 2155 NAND4_X1
* cell instance $5047 r0 *1 62.89,71.4
X$5047 1867 2094 109 85 2187 AND2_X1
* cell instance $5049 r0 *1 64.41,71.4
X$5049 2094 85 109 2069 CLKBUF_X3
* cell instance $5050 r0 *1 65.36,71.4
X$5050 2176 679 85 109 2188 NOR2_X1
* cell instance $5051 m0 *1 65.93,71.4
X$5051 85 2163 2156 2340 1825 109 DFF_X2
* cell instance $5054 m0 *1 72.58,71.4
X$5054 85 2162 2173 2096 109 DFF_X1
* cell instance $5055 m0 *1 75.81,71.4
X$5055 2162 85 109 1906 CLKBUF_X2
* cell instance $5059 r0 *1 66.12,71.4
X$5059 1887 2204 85 109 2176 XOR2_X1
* cell instance $5061 r0 *1 67.45,71.4
X$5061 2219 85 109 1887 BUF_X2
* cell instance $5063 r0 *1 68.4,71.4
X$5063 2035 2036 2059 1827 85 109 2204 NAND4_X1
* cell instance $5065 r0 *1 70.11,71.4
X$5065 1827 1887 109 85 2190 AND2_X1
* cell instance $5066 r0 *1 70.87,71.4
X$5066 1828 2190 109 85 2175 AND2_X1
* cell instance $5067 r0 *1 71.63,71.4
X$5067 2175 2035 2036 2059 85 109 2196 NAND4_X1
* cell instance $5069 r0 *1 72.77,71.4
X$5069 1906 2199 85 109 2198 XOR2_X1
* cell instance $5070 r0 *1 73.91,71.4
X$5070 2198 589 85 109 2173 NOR2_X1
* cell instance $5072 r0 *1 74.67,71.4
X$5072 1883 2196 85 109 2195 XOR2_X1
* cell instance $5073 r0 *1 75.81,71.4
X$5073 1463 85 109 2096 CLKBUF_X3
* cell instance $5074 r0 *1 76.76,71.4
X$5074 2195 589 85 109 2192 NOR2_X1
* cell instance $5075 r0 *1 77.33,71.4
X$5075 1458 85 109 2172 BUF_X1
* cell instance $5076 m0 *1 77.9,71.4
X$5076 2162 85 109 2157 BUF_X1
* cell instance $5078 m0 *1 78.47,71.4
X$5078 1907 85 109 2072 BUF_X1
* cell instance $5079 m0 *1 79.04,71.4
X$5079 1883 85 109 2158 BUF_X1
* cell instance $5080 m0 *1 79.61,71.4
X$5080 2100 85 109 2132 BUF_X1
* cell instance $5094 r0 *1 54.34,4.2
X$5094 85 165 188 169 109 DFF_X1
* cell instance $5112 m0 *1 13.87,7
X$5112 193 223 109 85 192 XNOR2_X1
* cell instance $5124 r0 *1 11.21,7
X$5124 177 178 109 85 176 XNOR2_X1
* cell instance $5125 r0 *1 12.35,7
X$5125 179 143 180 85 109 178 NOR3_X1
* cell instance $5128 r0 *1 14.25,7
X$5128 89 201 109 85 181 XNOR2_X1
* cell instance $5129 r0 *1 15.39,7
X$5129 85 182 200 2380 89 109 DFF_X2
* cell instance $5131 m0 *1 18.43,7
X$5131 85 171 200 2379 137 109 DFF_X2
* cell instance $5137 r0 *1 21.09,7
X$5137 137 195 109 85 226 XNOR2_X1
* cell instance $5138 r0 *1 22.23,7
X$5138 204 139 143 85 109 195 NOR3_X1
* cell instance $5139 r0 *1 22.99,7
X$5139 111 138 85 109 204 NAND2_X1
* cell instance $5140 r0 *1 23.56,7
X$5140 137 85 109 205 INV_X1
* cell instance $5143 m0 *1 25.27,7
X$5143 85 197 115 2338 184 109 DFF_X2
* cell instance $5146 m0 *1 32.87,7
X$5146 95 175 109 85 157 XNOR2_X1
* cell instance $5150 r0 *1 26.03,7
X$5150 232 183 85 109 197 NOR2_X1
* cell instance $5153 r0 *1 28.31,7
X$5153 184 230 109 85 232 XNOR2_X1
* cell instance $5157 r0 *1 30.78,7
X$5157 85 96 209 97 109 DFF_X1
* cell instance $5158 r0 *1 34.01,7
X$5158 156 210 203 185 85 109 175 NOR4_X1
* cell instance $5160 m0 *1 34.39,7
X$5160 140 85 109 185 INV_X1
* cell instance $5162 m0 *1 36.48,7
X$5162 158 141 85 109 142 NAND2_X1
* cell instance $5163 m0 *1 37.05,7
X$5163 158 85 109 173 INV_X1
* cell instance $5164 m0 *1 37.43,7
X$5164 173 139 143 85 109 172 NOR3_X1
* cell instance $5167 m0 *1 39.14,7
X$5167 129 161 131 85 109 162 NAND3_X1
* cell instance $5172 r0 *1 35.15,7
X$5172 206 85 109 97 CLKBUF_X3
* cell instance $5174 r0 *1 36.29,7
X$5174 158 141 196 85 156 109 NAND3_X4
* cell instance $5175 r0 *1 38.76,7
X$5175 131 161 129 100 109 85 196 AND4_X1
* cell instance $5180 m0 *1 45.03,7
X$5180 85 145 231 132 109 DFF_X1
* cell instance $5186 m0 *1 54.91,7
X$5186 164 85 109 187 CLKBUF_X2
* cell instance $5187 m0 *1 51.68,7
X$5187 85 164 229 169 109 DFF_X1
* cell instance $5191 r0 *1 54.53,7
X$5191 228 213 85 109 188 NOR2_X1
* cell instance $5192 r0 *1 55.1,7
X$5192 215 214 109 85 228 XNOR2_X1
* cell instance $5193 m0 *1 56.81,7
X$5193 85 191 169 2342 216 109 DFF_X2
* cell instance $5194 m0 *1 56.05,7
X$5194 165 85 109 215 BUF_X2
* cell instance $5198 m0 *1 65.17,7
X$5198 218 166 85 109 168 NOR2_X1
* cell instance $5201 r0 *1 56.43,7
X$5201 216 227 85 109 225 XOR2_X1
* cell instance $5202 r0 *1 57.57,7
X$5202 225 213 85 109 191 NOR2_X1
* cell instance $5215 r0 *1 66.88,7
X$5215 222 85 109 219 BUF_X2
* cell instance $5216 r0 *1 67.64,7
X$5216 85 222 221 146 109 DFF_X1
.ENDS performance_counter

* cell INV_X8
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X8 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.37485P PS=6.86U PD=6.86U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 2 2 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.246925P PS=4.925U
+ PD=4.925U
.ENDS INV_X8

* cell AND3_X2
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 9 1 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 8 2 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND3_X2

* cell AOI21_X2
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X2 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 9 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X2

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell OAI21_X2
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X2 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 3 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 5 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 6 1 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 7 2 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 4 3 7 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI21_X2

* cell AND2_X2
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X2 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 3 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND2_X2

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell OR4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR4_X1 1 2 3 4 5 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 10 1 6 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 11 3 9 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 6 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 6 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 5 2 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 5 4 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 6 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR4_X1

* cell NAND2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 4 1 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 5 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND2_X4

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8

* cell OR3_X2
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 5 1 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 4 2 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 5 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR3_X2

* cell AND4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 11 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 10 2 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 9 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 7 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 8 5 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND4_X2

* cell NOR4_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin A4
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR4_X4 1 2 3 4 5 6 10
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 1.92,0.995 PMOS_VTL
M$1 8 4 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 2.68,0.995 PMOS_VTL
M$5 10 5 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.995 PMOS_VTL
M$9 6 2 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $13 r0 *1 0.93,0.995 PMOS_VTL
M$13 8 3 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.92,0.2975 NMOS_VTL
M$17 1 4 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.68,0.2975 NMOS_VTL
M$21 1 5 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.17,0.2975 NMOS_VTL
M$25 6 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.93,0.2975 NMOS_VTL
M$29 6 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NOR4_X4

* cell AND3_X1
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 4 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 8 1 4 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 9 2 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 6 3 9 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND3_X1

* cell NOR3_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR3_X4 1 2 3 4 5 8
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 ZN
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 2 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 6 3 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 6 4 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 5 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 5 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 5 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS NOR3_X4

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell NAND4_X4
* pin PWELL,VSS
* pin A3
* pin A4
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X4 1 2 3 7 8 9 10
* net 1 PWELL,VSS
* net 2 A3
* net 3 A4
* net 7 A1
* net 8 A2
* net 9 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 10 7 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 10 8 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.22365P PS=3.08U PD=3.23U
* device instance $9 r0 *1 1.885,0.995 PMOS_VTL
M$9 10 2 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.22365P AD=0.1764P PS=3.23U PD=3.08U
* device instance $13 r0 *1 2.645,0.995 PMOS_VTL
M$13 10 3 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.885,0.2975 NMOS_VTL
M$17 5 2 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.645,0.2975 NMOS_VTL
M$21 1 3 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.215,0.2975 NMOS_VTL
M$25 9 7 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.975,0.2975 NMOS_VTL
M$29 5 8 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND4_X4

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X2 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell DFF_X1
* pin PWELL,VSS
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 10 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell CLKBUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT CLKBUF_X1 1 3 4
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.19,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.38,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.19,0.2075 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.095U AS=0.009975P AD=0.01015P PS=0.4U PD=0.335U
* device instance $4 r0 *1 0.38,0.2575 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.195U AS=0.01015P AD=0.020475P PS=0.335U PD=0.6U
.ENDS CLKBUF_X1

* cell HA_X1
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin CO
.SUBCKT HA_X1 1 2 4 5 6 9
* net 1 A
* net 2 B
* net 4 S
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 9 CO
* device instance $1 r0 *1 0.785,1.0275 PMOS_VTL
M$1 10 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $2 r0 *1 0.975,1.0275 PMOS_VTL
M$2 7 1 10 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $3 r0 *1 0.21,0.995 PMOS_VTL
M$3 4 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $4 r0 *1 0.4,0.995 PMOS_VTL
M$4 3 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.59,0.995 PMOS_VTL
M$5 5 7 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0338625P PS=0.77U PD=0.775U
* device instance $6 r0 *1 1.345,1.0275 PMOS_VTL
M$6 8 1 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 1.535,1.0275 PMOS_VTL
M$7 8 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $8 r0 *1 1.725,0.995 PMOS_VTL
M$8 9 8 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.345,0.195 NMOS_VTL
M$9 12 1 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $10 r0 *1 1.535,0.195 NMOS_VTL
M$10 6 2 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $11 r0 *1 1.725,0.2975 NMOS_VTL
M$11 9 8 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $12 r0 *1 0.785,0.195 NMOS_VTL
M$12 7 2 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0224P AD=0.0147P PS=0.56U PD=0.35U
* device instance $13 r0 *1 0.975,0.195 NMOS_VTL
M$13 6 1 7 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $14 r0 *1 0.21,0.2975 NMOS_VTL
M$14 11 2 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $15 r0 *1 0.4,0.2975 NMOS_VTL
M$15 4 1 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.59,0.2975 NMOS_VTL
M$16 6 7 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0224P PS=0.555U PD=0.56U
.ENDS HA_X1

* cell OR4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OR4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 ZN
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 11 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 7 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 5 1 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 8 2 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 5 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 8 4 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 7 5 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR4_X2

* cell NOR4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 3 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 7 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 5 4 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR4_X1

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell AND4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X1 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 5 4 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 10 1 5 7 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 11 2 10 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 9 3 11 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 7 4 9 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 5 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND4_X1

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell NAND4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 4 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 7 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 13 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 12 1 13 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 11 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 6 3 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 8 3 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 9 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X2

* cell XOR2_X1
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT XOR2_X1 1 3 4 5 6
* net 1 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 8 1 2 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 7 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 6 1 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 7 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 2 1 4 4 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 4 3 2 4 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.555,0.2975 NMOS_VTL
M$8 6 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.745,0.2975 NMOS_VTL
M$9 9 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.935,0.2975 NMOS_VTL
M$10 4 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XOR2_X1

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell XNOR2_X1
* pin A
* pin B
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT XNOR2_X1 1 2 4 5 7
* net 1 A
* net 2 B
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.18,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.37,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 7 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 8 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 4 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.18,0.195 NMOS_VTL
M$6 9 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.37,0.195 NMOS_VTL
M$7 5 2 9 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.565,0.2975 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.755,0.2975 NMOS_VTL
M$9 7 1 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.945,0.2975 NMOS_VTL
M$10 6 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X1

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X4 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4

* cell NOR3_X2
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 10 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 9 2 10 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 3 9 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 8 3 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 4 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 5 1 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 6 2 5 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 5 3 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR3_X2

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1
