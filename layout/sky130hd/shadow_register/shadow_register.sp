* cell shadow_register
* pin shadow_data_out[5]
* pin main_data_out[5]
* pin main_data_in[31]
* pin shadow_data_in[4]
* pin shadow_data_out[30]
* pin shadow_data_out[31]
* pin shadow_data_in[31]
* pin main_data_out[4]
* pin main_data_out[30]
* pin main_data_out[31]
* pin shadow_data_in[28]
* pin shadow_data_out[28]
* pin main_data_out[28]
* pin main_data_in[27]
* pin main_data_in[22]
* pin shadow_data_in[26]
* pin shadow_data_out[26]
* pin shadow_data_in[27]
* pin shadow_data_out[27]
* pin main_data_in[20]
* pin main_data_out[27]
* pin main_data_out[26]
* pin main_data_in[24]
* pin shadow_data_in[24]
* pin main_data_out[24]
* pin main_data_in[21]
* pin rst_n
* pin main_data_in[4]
* pin shadow_data_out[4]
* pin main_data_in[26]
* pin shadow_data_out[24]
* pin main_data_in[5]
* pin main_data_out[21]
* pin shadow_data_out[21]
* pin main_data_in[29]
* pin shadow_data_in[21]
* pin shadow_data_in[5]
* pin shadow_data_out[29]
* pin main_data_out[29]
* pin main_data_in[25]
* pin main_data_out[25]
* pin shadow_data_in[29]
* pin shadow_data_out[25]
* pin shadow_data_in[25]
* pin main_data_in[1]
* pin main_data_in[2]
* pin shadow_data_in[1]
* pin shadow_data_in[2]
* pin main_data_out[1]
* pin shadow_data_out[2]
* pin main_data_out[2]
* pin shadow_data_out[20]
* pin shadow_data_out[1]
* pin main_data_in[28]
* pin shadow_data_in[20]
* pin main_data_in[30]
* pin main_data_out[20]
* pin shadow_data_in[30]
* pin shadow_data_out[22]
* pin shadow_data_in[3]
* pin shadow_data_out[3]
* pin main_data_out[22]
* pin shadow_data_in[22]
* pin main_data_out[3]
* pin main_data_in[3]
* pin main_data_in[23]
* pin shadow_data_out[23]
* pin shadow_data_in[23]
* pin main_data_out[23]
* pin main_data_in[8]
* pin shadow_data_in[19]
* pin main_data_out[7]
* pin shadow_data_out[19]
* pin clk
* pin main_load_en
* pin main_data_in[19]
* pin main_data_out[19]
* pin shadow_capture_en
* pin main_data_out[6]
* pin main_data_in[9]
* pin shadow_data_out[7]
* pin shadow_data_in[17]
* pin shadow_data_out[6]
* pin shadow_data_out[17]
* pin main_data_in[7]
* pin shadow_data_in[7]
* pin main_data_in[18]
* pin shadow_data_out[18]
* pin shadow_data_in[6]
* pin main_data_out[18]
* pin shadow_load_en
* pin main_data_in[6]
* pin shadow_data_in[18]
* pin main_data_in[17]
* pin main_data_out[17]
* pin use_shadow_out
* pin main_data_in[10]
* pin main_data_in[0]
* pin shadow_data_out[11]
* pin main_data_in[13]
* pin main_data_out[11]
* pin main_data_in[11]
* pin shadow_data_in[12]
* pin main_data_out[10]
* pin main_data_out[15]
* pin shadow_data_out[12]
* pin main_data_out[13]
* pin shadow_data_out[13]
* pin shadow_data_out[14]
* pin shadow_data_in[13]
* pin main_data_in[16]
* pin shadow_data_in[0]
* pin shadow_data_out[0]
* pin shadow_data_out[10]
* pin shadow_data_in[10]
* pin main_data_out[0]
* pin shadow_data_in[16]
* pin main_data_out[16]
* pin main_data_out[9]
* pin shadow_data_out[16]
* pin main_data_out[8]
* pin shadow_data_in[8]
* pin shadow_data_in[9]
* pin shadow_data_out[8]
* pin shadow_data_out[9]
* pin main_data_in[15]
* pin main_data_in[12]
* pin shadow_data_out[15]
* pin shadow_data_in[15]
* pin main_data_out[12]
* pin main_data_in[14]
* pin shadow_data_in[14]
* pin shadow_data_in[11]
* pin main_data_out[14]
.SUBCKT shadow_register 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 90 97 98 106 111 115 125 126 130 131 141 143
+ 144 149 157 161 164 168 172 173 175 176 183 186 191 197 198 204 209 210 211
+ 212 218 219 222 223 231 240 245 247 251 252 253 254 257 258 261 273 274 280
+ 282 284 292 297 298 301 302 311 316 321 323 325 335 336 343 349 359 362 370
+ 375 403 407 409 410 411 415 417 419 426 427 428 429 430 431 432 433 434 435
+ 436 437 438 439 440 441 442 443 444 445 446 447 448 449 450
* net 1 shadow_data_out[5]
* net 2 main_data_out[5]
* net 3 main_data_in[31]
* net 4 shadow_data_in[4]
* net 5 shadow_data_out[30]
* net 6 shadow_data_out[31]
* net 7 shadow_data_in[31]
* net 8 main_data_out[4]
* net 9 main_data_out[30]
* net 10 main_data_out[31]
* net 11 shadow_data_in[28]
* net 12 shadow_data_out[28]
* net 13 main_data_out[28]
* net 14 main_data_in[27]
* net 15 main_data_in[22]
* net 16 shadow_data_in[26]
* net 17 shadow_data_out[26]
* net 18 shadow_data_in[27]
* net 19 shadow_data_out[27]
* net 20 main_data_in[20]
* net 21 main_data_out[27]
* net 22 main_data_out[26]
* net 23 main_data_in[24]
* net 24 shadow_data_in[24]
* net 25 main_data_out[24]
* net 26 main_data_in[21]
* net 27 rst_n
* net 28 main_data_in[4]
* net 29 shadow_data_out[4]
* net 30 main_data_in[26]
* net 31 shadow_data_out[24]
* net 90 main_data_in[5]
* net 97 main_data_out[21]
* net 98 shadow_data_out[21]
* net 106 main_data_in[29]
* net 111 shadow_data_in[21]
* net 115 shadow_data_in[5]
* net 125 shadow_data_out[29]
* net 126 main_data_out[29]
* net 130 main_data_in[25]
* net 131 main_data_out[25]
* net 141 shadow_data_in[29]
* net 143 shadow_data_out[25]
* net 144 shadow_data_in[25]
* net 149 main_data_in[1]
* net 157 main_data_in[2]
* net 161 shadow_data_in[1]
* net 164 shadow_data_in[2]
* net 168 main_data_out[1]
* net 172 shadow_data_out[2]
* net 173 main_data_out[2]
* net 175 shadow_data_out[20]
* net 176 shadow_data_out[1]
* net 183 main_data_in[28]
* net 186 shadow_data_in[20]
* net 191 main_data_in[30]
* net 197 main_data_out[20]
* net 198 shadow_data_in[30]
* net 204 shadow_data_out[22]
* net 209 shadow_data_in[3]
* net 210 shadow_data_out[3]
* net 211 main_data_out[22]
* net 212 shadow_data_in[22]
* net 218 main_data_out[3]
* net 219 main_data_in[3]
* net 222 main_data_in[23]
* net 223 shadow_data_out[23]
* net 231 shadow_data_in[23]
* net 240 main_data_out[23]
* net 245 main_data_in[8]
* net 247 shadow_data_in[19]
* net 251 main_data_out[7]
* net 252 shadow_data_out[19]
* net 253 clk
* net 254 main_load_en
* net 257 main_data_in[19]
* net 258 main_data_out[19]
* net 261 shadow_capture_en
* net 273 main_data_out[6]
* net 274 main_data_in[9]
* net 280 shadow_data_out[7]
* net 282 shadow_data_in[17]
* net 284 shadow_data_out[6]
* net 292 shadow_data_out[17]
* net 297 main_data_in[7]
* net 298 shadow_data_in[7]
* net 301 main_data_in[18]
* net 302 shadow_data_out[18]
* net 311 shadow_data_in[6]
* net 316 main_data_out[18]
* net 321 shadow_load_en
* net 323 main_data_in[6]
* net 325 shadow_data_in[18]
* net 335 main_data_in[17]
* net 336 main_data_out[17]
* net 343 use_shadow_out
* net 349 main_data_in[10]
* net 359 main_data_in[0]
* net 362 shadow_data_out[11]
* net 370 main_data_in[13]
* net 375 main_data_out[11]
* net 403 main_data_in[11]
* net 407 shadow_data_in[12]
* net 409 main_data_out[10]
* net 410 main_data_out[15]
* net 411 shadow_data_out[12]
* net 415 main_data_out[13]
* net 417 shadow_data_out[13]
* net 419 shadow_data_out[14]
* net 426 shadow_data_in[13]
* net 427 main_data_in[16]
* net 428 shadow_data_in[0]
* net 429 shadow_data_out[0]
* net 430 shadow_data_out[10]
* net 431 shadow_data_in[10]
* net 432 main_data_out[0]
* net 433 shadow_data_in[16]
* net 434 main_data_out[16]
* net 435 main_data_out[9]
* net 436 shadow_data_out[16]
* net 437 main_data_out[8]
* net 438 shadow_data_in[8]
* net 439 shadow_data_in[9]
* net 440 shadow_data_out[8]
* net 441 shadow_data_out[9]
* net 442 main_data_in[15]
* net 443 main_data_in[12]
* net 444 shadow_data_out[15]
* net 445 shadow_data_in[15]
* net 446 main_data_out[12]
* net 447 main_data_in[14]
* net 448 shadow_data_in[14]
* net 449 shadow_data_in[11]
* net 450 main_data_out[14]
* cell instance $3 r0 *1 12.42,2.72
X$3 49 46 1 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $6 r0 *1 9.66,2.72
X$6 49 45 2 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $8 r0 *1 24.84,2.72
X$8 49 3 51 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $12 r0 *1 22.08,2.72
X$12 49 4 77 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $15 r0 *1 26.22,2.72
X$15 49 33 5 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $18 r0 *1 30.36,2.72
X$18 49 54 6 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $21 r0 *1 33.12,2.72
X$21 49 7 55 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $24 r0 *1 23.46,2.72
X$24 49 50 8 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $27 r0 *1 31.74,2.72
X$27 49 114 9 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $30 r0 *1 27.6,2.72
X$30 49 53 10 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $33 r0 *1 34.5,2.72
X$33 49 11 79 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $36 r0 *1 37.72,2.72
X$36 49 57 12 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $39 r0 *1 36.34,2.72
X$39 49 56 13 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $42 r0 *1 41.4,2.72
X$42 49 14 58 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $45 m0 *1 49.22,8.16
X$45 49 15 182 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $48 r0 *1 45.08,2.72
X$48 49 16 62 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $51 r0 *1 50.6,2.72
X$51 49 34 17 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $54 r0 *1 46.46,2.72
X$54 49 18 78 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $56 r0 *1 47.84,2.72
X$56 49 63 19 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $61 r0 *1 58.42,2.72
X$61 49 20 61 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $65 r0 *1 49.22,2.72
X$65 49 41 21 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $68 r0 *1 57.04,2.72
X$68 49 35 22 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $71 r0 *1 59.8,2.72
X$71 49 23 60 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $74 r0 *1 62.56,2.72
X$74 49 24 52 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $77 r0 *1 63.94,2.72
X$77 49 36 25 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $80 r0 *1 65.78,2.72
X$80 49 26 85 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $83 r0 *1 70.84,2.72
X$83 49 27 49 47 32 32 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $86 r0 *1 20.7,2.72
X$86 49 28 48 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $89 m0 *1 19.78,8.16
X$89 49 66 29 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $92 r0 *1 43.24,2.72
X$92 49 30 59 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $95 r0 *1 61.18,2.72
X$95 49 37 31 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $125 r0 *1 51.98,2.72
X$125 32 35 34 38 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $137 r0 *1 77.74,2.72
X$137 49 44 98 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $146 m0 *1 5.52,8.16
X$146 49 73 64 65 49 84 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $148 m0 *1 9.2,8.16
X$148 32 45 46 75 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $149 m0 *1 13.34,8.16
X$149 49 76 75 65 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $153 m0 *1 21.16,8.16
X$153 32 68 66 77 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $154 m0 *1 24.84,8.16
X$154 32 50 66 86 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $156 m0 *1 29.44,8.16
X$156 32 53 54 117 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $157 m0 *1 33.58,8.16
X$157 32 87 57 79 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $158 m0 *1 37.26,8.16
X$158 32 56 57 128 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $159 m0 *1 41.4,8.16
X$159 32 41 63 89 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $160 m0 *1 45.54,8.16
X$160 32 88 63 78 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $163 m0 *1 51.98,8.16
X$163 32 110 34 62 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $166 m0 *1 57.04,8.16
X$166 49 42 81 43 49 119 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $168 m0 *1 59.34,8.16
X$168 32 72 74 70 71 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $169 m0 *1 68.54,8.16
X$169 32 47 72 49 49 32 sky130_fd_sc_hd__buf_16
* cell instance $171 r0 *1 1.38,8.16
X$171 49 106 99 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $172 r0 *1 2.76,8.16
X$172 49 90 91 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $174 r0 *1 5.06,8.16
X$174 32 72 46 80 84 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $179 r0 *1 19.32,8.16
X$179 32 100 48 86 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $181 r0 *1 24.38,8.16
X$181 32 72 54 80 101 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $182 r0 *1 33.58,8.16
X$182 32 104 54 55 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $187 r0 *1 43.24,8.16
X$187 32 72 34 70 105 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $188 r0 *1 52.44,8.16
X$188 32 72 103 70 113 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $189 r0 *1 61.64,8.16
X$189 32 71 85 74 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $190 r0 *1 65.78,8.16
X$190 32 81 37 52 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $194 r0 *1 70.84,8.16
X$194 32 82 44 74 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $195 r0 *1 74.98,8.16
X$195 49 42 95 96 49 83 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $196 r0 *1 76.82,8.16
X$196 49 82 97 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $204 m0 *1 1.38,13.6
X$204 32 92 91 75 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $205 m0 *1 5.52,13.6
X$205 32 64 46 133 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $206 m0 *1 9.2,13.6
X$206 32 72 75 80 92 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $207 m0 *1 18.4,13.6
X$207 32 72 66 80 94 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $208 m0 *1 27.6,13.6
X$208 49 76 86 107 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $210 m0 *1 29.44,13.6
X$210 49 73 68 107 49 94 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $211 m0 *1 31.28,13.6
X$211 49 73 104 108 49 101 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $212 m0 *1 33.12,13.6
X$212 32 114 33 170 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $214 m0 *1 38.18,13.6
X$214 32 72 63 70 109 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $215 m0 *1 47.38,13.6
X$215 49 73 88 140 49 109 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $216 m0 *1 49.22,13.6
X$216 49 73 110 139 49 105 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $217 m0 *1 51.06,13.6
X$217 32 124 70 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $220 m0 *1 57.04,13.6
X$220 32 113 60 103 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $221 m0 *1 61.18,13.6
X$221 32 36 37 103 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $222 m0 *1 65.32,13.6
X$222 32 72 122 70 155 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $223 m0 *1 74.52,13.6
X$223 32 95 44 112 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $225 r0 *1 1.38,13.6
X$225 49 116 125 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $226 r0 *1 2.76,13.6
X$226 49 115 133 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $228 r0 *1 4.6,13.6
X$228 49 150 126 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $229 r0 *1 5.98,13.6
X$229 32 72 116 80 132 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $234 r0 *1 18.4,13.6
X$234 32 72 86 80 100 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $235 r0 *1 27.6,13.6
X$235 32 134 51 117 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $236 r0 *1 31.74,13.6
X$236 49 73 87 137 49 135 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $240 r0 *1 38.64,13.6
X$240 32 118 58 89 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $243 r0 *1 43.24,13.6
X$243 32 72 89 70 118 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $244 r0 *1 52.44,13.6
X$244 32 72 37 70 119 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $245 r0 *1 61.64,13.6
X$245 49 120 103 43 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $247 r0 *1 63.48,13.6
X$247 32 138 129 121 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $248 r0 *1 67.62,13.6
X$248 49 120 121 136 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $250 r0 *1 69,13.6
X$250 49 120 74 96 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $252 r0 *1 70.84,13.6
X$252 32 123 122 121 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $253 r0 *1 74.98,13.6
X$253 49 130 129 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $254 r0 *1 76.36,13.6
X$254 49 123 131 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $255 r0 *1 77.74,13.6
X$255 49 111 112 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $262 m0 *1 1.38,19.04
X$262 49 141 127 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $263 m0 *1 2.76,19.04
X$263 32 145 116 127 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $264 m0 *1 6.44,19.04
X$264 49 73 145 142 49 132 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $265 m0 *1 8.28,19.04
X$265 32 72 148 80 152 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $268 m0 *1 20.24,19.04
X$268 32 124 80 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $271 m0 *1 27.6,19.04
X$271 49 76 117 108 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $273 m0 *1 29.44,19.04
X$273 49 76 128 137 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $275 m0 *1 31.28,19.04
X$275 32 72 57 80 135 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $276 m0 *1 40.48,19.04
X$276 32 72 38 70 146 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $277 m0 *1 49.68,19.04
X$277 49 120 89 140 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $278 m0 *1 51.06,19.04
X$278 49 120 38 139 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $285 m0 *1 62.1,19.04
X$285 32 72 121 70 138 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $288 m0 *1 72.68,19.04
X$288 32 154 122 153 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $289 m0 *1 76.36,19.04
X$289 49 122 143 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $294 r0 *1 5.52,19.04
X$294 32 150 116 148 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $295 r0 *1 9.66,19.04
X$295 32 152 99 148 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $296 r0 *1 13.8,19.04
X$296 49 76 148 142 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $302 r0 *1 23.92,19.04
X$302 32 72 117 80 134 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $309 r0 *1 43.24,19.04
X$309 32 146 59 38 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $316 r0 *1 66.24,19.04
X$316 49 42 154 136 49 155 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $324 r0 *1 74.06,19.04
X$324 49 144 153 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $327 m0 *1 5.06,24.48
X$327 32 72 163 147 151 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $351 m0 *1 66.7,24.48
X$351 32 72 44 156 83 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $354 m0 *1 75.9,24.48
X$354 49 149 162 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $356 r0 *1 1.38,24.48
X$356 49 163 172 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $357 r0 *1 2.76,24.48
X$357 49 157 177 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $359 r0 *1 5.98,24.48
X$359 49 73 165 169 49 151 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $366 r0 *1 17.02,24.48
X$366 32 180 190 170 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $369 r0 *1 22.54,24.48
X$369 32 72 33 147 215 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $381 r0 *1 59.34,24.48
X$381 32 181 162 158 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $382 r0 *1 63.48,24.48
X$382 49 120 158 171 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $383 r0 *1 64.86,24.48
X$383 49 42 159 171 49 178 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $384 r0 *1 66.7,24.48
X$384 32 159 160 166 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $387 r0 *1 70.84,24.48
X$387 32 167 160 158 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $388 r0 *1 74.98,24.48
X$388 49 167 168 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $389 r0 *1 76.36,24.48
X$389 49 161 166 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $390 r0 *1 77.74,24.48
X$390 49 160 176 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $397 m0 *1 1.38,29.92
X$397 49 164 184 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $398 m0 *1 2.76,29.92
X$398 32 174 177 179 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $399 m0 *1 6.9,29.92
X$399 32 72 179 147 174 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $401 m0 *1 19.78,29.92
X$401 32 72 170 147 180 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $408 m0 *1 47.84,29.92
X$408 32 189 182 188 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $412 m0 *1 55.2,29.92
X$412 49 156 458 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $414 m0 *1 57.04,29.92
X$414 32 72 158 156 181 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $415 m0 *1 66.24,29.92
X$415 32 72 160 156 178 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $417 m0 *1 76.36,29.92
X$417 49 196 175 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $418 m0 *1 77.74,29.92
X$418 49 186 185 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $419 r0 *1 1.38,29.92
X$419 49 192 173 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $420 r0 *1 2.76,29.92
X$420 32 192 163 179 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $421 r0 *1 6.9,29.92
X$421 32 165 163 184 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $422 r0 *1 10.58,29.92
X$422 49 183 193 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $423 r0 *1 11.96,29.92
X$423 49 76 179 169 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $425 r0 *1 13.8,29.92
X$425 49 191 190 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $430 r0 *1 17.94,29.92
X$430 32 124 147 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $431 r0 *1 23,29.92
X$431 49 76 170 227 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $434 r0 *1 26.68,29.92
X$434 32 194 193 128 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $437 r0 *1 33.58,29.92
X$437 32 72 128 147 194 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $442 r0 *1 45.54,29.92
X$442 32 72 188 156 189 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $444 r0 *1 55.2,29.92
X$444 32 124 156 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $446 r0 *1 61.18,29.92
X$446 32 72 196 156 208 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $449 r0 *1 70.84,29.92
X$449 32 206 196 187 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $450 r0 *1 74.98,29.92
X$450 32 195 196 185 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $459 m0 *1 1.84,35.36
X$459 49 199 210 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $460 m0 *1 3.22,35.36
X$460 49 209 200 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $463 m0 *1 6.9,35.36
X$463 32 72 199 147 234 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $464 m0 *1 16.1,35.36
X$464 49 198 201 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $466 m0 *1 17.94,35.36
X$466 32 147 455 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $468 m0 *1 23.92,35.36
X$468 32 214 33 201 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $479 m0 *1 47.38,35.36
X$479 32 72 187 156 202 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $481 m0 *1 57.04,35.36
X$481 32 202 61 187 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $484 m0 *1 63.48,35.36
X$484 49 42 195 217 49 208 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $485 m0 *1 65.32,35.36
X$485 49 120 187 217 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $487 m0 *1 67.16,35.36
X$487 49 42 203 207 49 216 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $488 m0 *1 69,35.36
X$488 49 120 188 207 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $489 m0 *1 70.38,35.36
X$489 32 203 213 205 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $490 m0 *1 74.06,35.36
X$490 49 213 204 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $491 m0 *1 75.44,35.36
X$491 49 206 197 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $492 m0 *1 76.82,35.36
X$492 49 212 205 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $495 r0 *1 1.84,35.36
X$495 32 220 199 225 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $496 r0 *1 5.98,35.36
X$496 32 72 225 147 233 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $501 r0 *1 15.64,35.36
X$501 32 228 199 200 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $504 r0 *1 22.08,35.36
X$504 49 73 214 227 49 215 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $519 r0 *1 51.98,35.36
X$519 32 72 230 156 237 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $520 r0 *1 61.18,35.36
X$520 32 72 213 156 216 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $525 r0 *1 70.84,35.36
X$525 49 222 226 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $526 r0 *1 72.22,35.36
X$526 32 221 213 188 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $527 r0 *1 76.36,35.36
X$527 49 221 211 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $528 r0 *1 77.74,35.36
X$528 49 224 223 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $529 m0 *1 1.38,40.8
X$529 49 220 218 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $531 m0 *1 3.22,40.8
X$531 49 219 241 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $533 m0 *1 5.52,40.8
X$533 32 233 241 225 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $535 m0 *1 10.58,40.8
X$535 49 73 228 235 49 234 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $537 m0 *1 13.34,40.8
X$537 49 76 225 235 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $549 m0 *1 44.16,40.8
X$549 49 238 32 73 49 32 sky130_fd_sc_hd__buf_2
* cell instance $551 m0 *1 49.68,40.8
X$551 49 238 32 120 49 32 sky130_fd_sc_hd__clkbuf_4
* cell instance $555 m0 *1 57.04,40.8
X$555 32 237 226 230 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $557 m0 *1 62.1,40.8
X$557 49 42 229 236 49 243 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $558 m0 *1 63.94,40.8
X$558 49 120 230 236 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $560 m0 *1 67.16,40.8
X$560 49 120 239 244 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $562 m0 *1 69.46,40.8
X$562 32 242 224 230 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $563 m0 *1 73.6,40.8
X$563 32 229 224 232 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $565 m0 *1 77.74,40.8
X$565 49 231 232 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $574 r0 *1 16.1,40.8
X$574 49 76 260 276 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $577 r0 *1 23,40.8
X$577 32 250 102 49 49 32 sky130_fd_sc_hd__buf_8
* cell instance $581 r0 *1 36.8,40.8
X$581 32 253 124 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $592 r0 *1 61.18,40.8
X$592 32 72 224 249 243 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $595 r0 *1 70.84,40.8
X$595 49 242 240 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $596 r0 *1 72.22,40.8
X$596 32 248 246 239 40 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $597 r0 *1 76.36,40.8
X$597 49 246 252 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $601 m0 *1 1.84,46.24
X$601 49 255 251 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $602 m0 *1 3.22,46.24
X$602 32 255 259 260 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $604 m0 *1 8.28,46.24
X$604 49 261 32 238 49 32 sky130_fd_sc_hd__buf_2
* cell instance $605 m0 *1 10.12,46.24
X$605 49 245 262 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $607 m0 *1 11.96,46.24
X$607 49 238 32 76 49 32 sky130_fd_sc_hd__clkbuf_4
* cell instance $610 m0 *1 14.72,46.24
X$610 32 254 250 49 49 32 sky130_fd_sc_hd__buf_6
* cell instance $611 m0 *1 18.86,46.24
X$611 32 272 262 264 250 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $613 m0 *1 23.46,46.24
X$613 32 250 93 49 49 32 sky130_fd_sc_hd__buf_8
* cell instance $617 m0 *1 34.04,46.24
X$617 32 256 67 49 49 32 sky130_fd_sc_hd__buf_8
* cell instance $619 m0 *1 41.4,46.24
X$619 32 266 40 49 49 32 sky130_fd_sc_hd__buf_6
* cell instance $622 m0 *1 45.54,46.24
X$622 32 256 69 49 49 32 sky130_fd_sc_hd__buf_8
* cell instance $627 m0 *1 58.88,46.24
X$627 32 265 263 239 102 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $628 m0 *1 63.02,46.24
X$628 49 257 263 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $630 m0 *1 66.24,46.24
X$630 32 72 246 249 270 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $633 m0 *1 75.44,46.24
X$633 49 248 258 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $634 m0 *1 76.82,46.24
X$634 49 247 278 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $637 r0 *1 1.84,46.24
X$637 32 275 259 279 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $638 r0 *1 5.52,46.24
X$638 32 72 260 268 267 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $643 r0 *1 16.56,46.24
X$643 49 76 271 309 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $644 r0 *1 17.94,46.24
X$644 32 268 457 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $645 r0 *1 23,46.24
X$645 32 72 264 268 272 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $648 r0 *1 36.34,46.24
X$648 32 266 39 49 49 32 sky130_fd_sc_hd__buf_8
* cell instance $657 r0 *1 56.58,46.24
X$657 32 72 239 249 265 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $658 r0 *1 65.78,46.24
X$658 49 42 269 244 49 270 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $664 r0 *1 74.52,46.24
X$664 32 269 246 278 69 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $672 m0 *1 1.38,51.68
X$672 49 274 281 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $674 m0 *1 3.68,51.68
X$674 32 267 293 260 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $675 m0 *1 7.82,51.68
X$675 49 238 275 276 49 283 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $677 m0 *1 10.12,51.68
X$677 32 72 259 268 283 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $679 m0 *1 19.78,51.68
X$679 32 72 285 268 295 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $683 m0 *1 30.82,51.68
X$683 32 72 296 268 329 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $689 m0 *1 50.6,51.68
X$689 49 238 32 42 49 32 sky130_fd_sc_hd__buf_2
* cell instance $693 m0 *1 57.04,51.68
X$693 32 124 249 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $697 m0 *1 65.32,51.68
X$697 32 72 290 249 294 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $699 m0 *1 76.36,51.68
X$699 49 282 303 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $702 r0 *1 1.38,51.68
X$702 32 304 299 271 39 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $703 r0 *1 5.52,51.68
X$703 32 72 299 268 307 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $709 r0 *1 15.64,51.68
X$709 49 238 320 309 49 307 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $713 r0 *1 20.7,51.68
X$713 32 124 268 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $714 r0 *1 25.76,51.68
X$714 32 295 281 285 250 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $715 r0 *1 29.9,51.68
X$715 49 277 285 310 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $716 r0 *1 31.28,51.68
X$716 49 238 286 310 49 287 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $718 r0 *1 33.58,51.68
X$718 32 72 313 268 287 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $724 r0 *1 43.7,51.68
X$724 32 256 291 49 49 32 sky130_fd_sc_hd__buf_8
* cell instance $726 r0 *1 50.14,51.68
X$726 49 238 32 277 49 32 sky130_fd_sc_hd__buf_2
* cell instance $729 r0 *1 57.5,51.68
X$729 32 72 314 249 288 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $730 r0 *1 66.7,51.68
X$730 49 42 289 308 49 294 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $731 r0 *1 68.54,51.68
X$731 49 42 300 306 49 317 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $736 r0 *1 70.84,51.68
X$736 32 289 290 305 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $737 r0 *1 74.52,51.68
X$737 32 300 315 303 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $739 m0 *1 1.38,57.12
X$739 49 304 273 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $740 m0 *1 2.76,57.12
X$740 49 299 284 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $742 m0 *1 5.06,57.12
X$742 49 297 293 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $743 m0 *1 6.44,57.12
X$743 32 327 326 271 93 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $744 m0 *1 10.58,57.12
X$744 32 320 299 319 67 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $748 m0 *1 23.46,57.12
X$748 32 250 318 49 49 32 sky130_fd_sc_hd__buf_8
* cell instance $750 m0 *1 29.44,57.12
X$750 49 277 264 338 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $751 m0 *1 30.82,57.12
X$751 32 337 296 312 256 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $752 m0 *1 34.5,57.12
X$752 32 330 313 285 266 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $753 m0 *1 38.64,57.12
X$753 32 286 313 322 256 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $755 m0 *1 42.78,57.12
X$755 32 321 256 49 49 32 sky130_fd_sc_hd__buf_6
* cell instance $756 m0 *1 46.92,57.12
X$756 49 238 32 332 49 32 sky130_fd_sc_hd__buf_2
* cell instance $761 m0 *1 57.04,57.12
X$761 32 249 456 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $762 m0 *1 62.1,57.12
X$762 32 288 328 314 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $764 m0 *1 68.08,57.12
X$764 32 72 315 249 317 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $766 m0 *1 77.74,57.12
X$766 49 301 328 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $767 r0 *1 1.38,57.12
X$767 49 298 279 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $768 r0 *1 2.76,57.12
X$768 49 311 319 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $769 r0 *1 4.14,57.12
X$769 49 323 326 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $770 r0 *1 5.52,57.12
X$770 32 72 271 344 327 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $779 r0 *1 29.44,57.12
X$779 49 238 337 338 49 329 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $782 r0 *1 33.58,57.12
X$782 32 339 296 264 266 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $783 r0 *1 37.72,57.12
X$783 32 266 333 49 49 32 sky130_fd_sc_hd__buf_6
* cell instance $794 r0 *1 61.18,57.12
X$794 32 72 324 249 331 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $797 r0 *1 70.84,57.12
X$797 49 332 324 306 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $798 r0 *1 72.22,57.12
X$798 49 325 305 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $799 r0 *1 73.6,57.12
X$799 32 340 315 324 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $800 r0 *1 77.74,57.12
X$800 49 315 292 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $807 m0 *1 1.38,62.56
X$807 49 259 280 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $820 m0 *1 40.48,62.56
X$820 32 343 266 49 49 32 sky130_fd_sc_hd__buf_6
* cell instance $830 m0 *1 63.94,62.56
X$830 32 331 342 324 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $831 m0 *1 68.08,62.56
X$831 49 332 314 308 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $832 m0 *1 69.46,62.56
X$832 32 334 290 314 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $833 m0 *1 73.6,62.56
X$833 49 335 342 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $834 m0 *1 74.98,62.56
X$834 49 340 336 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $835 m0 *1 76.36,62.56
X$835 49 334 316 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $836 m0 *1 77.74,62.56
X$836 49 290 302 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $839 r0 *1 4.14,62.56
X$839 32 72 341 344 346 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $845 r0 *1 17.02,62.56
X$845 49 332 341 358 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $846 r0 *1 18.4,62.56
X$846 32 124 344 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $847 r0 *1 23.46,62.56
X$847 32 72 351 344 366 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $858 r0 *1 51.98,62.56
X$858 49 277 348 347 49 357 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $859 r0 *1 53.82,62.56
X$859 49 332 345 347 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $872 m0 *1 5.98,68
X$872 32 346 363 341 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $873 m0 *1 10.12,68
X$873 32 364 350 365 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $877 m0 *1 17.94,68
X$877 49 277 413 358 49 367 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $878 m0 *1 19.78,68
X$878 32 72 369 344 367 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $880 m0 *1 29.44,68
X$880 32 352 351 353 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $884 m0 *1 39.56,68
X$884 49 332 354 380 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $885 m0 *1 40.94,68
X$885 32 72 354 360 368 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $888 m0 *1 50.14,68
X$888 49 360 459 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $889 m0 *1 51.52,68
X$889 32 124 360 49 49 32 sky130_fd_sc_hd__clkbuf_8
* cell instance $892 m0 *1 57.96,68
X$892 32 72 394 360 406 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $893 m0 *1 67.16,68
X$893 32 72 356 360 355 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $896 m0 *1 76.36,68
X$896 49 356 362 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $900 r0 *1 1.84,68
X$900 32 382 376 373 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $901 r0 *1 5.98,68
X$901 32 72 365 344 364 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $904 r0 *1 15.64,68
X$904 32 385 393 365 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $905 r0 *1 19.78,68
X$905 49 277 398 378 49 388 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $909 r0 *1 24.84,68
X$909 49 277 352 372 49 366 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $911 r0 *1 27.14,68
X$911 49 332 373 372 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $912 r0 *1 28.52,68
X$912 49 332 371 374 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $913 r0 *1 29.9,68
X$913 49 277 418 374 49 381 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $914 r0 *1 31.74,68
X$914 32 72 392 344 381 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $915 r0 *1 40.94,68
X$915 49 277 379 380 49 391 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $918 r0 *1 43.24,68
X$918 32 72 390 360 391 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $919 r0 *1 52.44,68
X$919 32 72 387 360 357 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $922 r0 *1 63.02,68
X$922 32 384 402 361 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $923 r0 *1 67.16,68
X$923 49 277 400 377 49 355 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $925 r0 *1 69,68
X$925 49 332 361 377 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $929 r0 *1 74.98,68
X$929 32 397 356 361 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $936 m0 *1 1.38,73.44
X$936 49 370 350 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $937 m0 *1 2.76,73.44
X$937 49 349 376 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $938 m0 *1 4.14,73.44
X$938 49 359 363 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $939 m0 *1 5.52,73.44
X$939 32 72 373 344 382 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $940 m0 *1 14.72,73.44
X$940 32 395 396 371 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $942 m0 *1 19.78,73.44
X$942 32 72 393 344 388 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $944 m0 *1 29.44,73.44
X$944 32 401 369 341 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $945 m0 *1 33.58,73.44
X$945 32 453 392 371 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $948 m0 *1 39.1,73.44
X$948 32 368 404 354 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $949 m0 *1 43.24,73.44
X$949 32 72 345 360 405 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $950 m0 *1 52.44,73.44
X$950 32 348 387 389 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $954 m0 *1 57.96,73.44
X$954 49 277 422 383 49 386 32 32 sky130_fd_sc_hd__o21ai_0
* cell instance $955 m0 *1 59.8,73.44
X$955 32 72 399 360 386 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $956 m0 *1 69,73.44
X$956 32 72 361 360 384 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $960 r0 *1 5.98,73.44
X$960 32 72 371 344 395 49 49 32 sky130_fd_sc_hd__dfrtp_1
* cell instance $964 r0 *1 16.1,73.44
X$964 49 385 415 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $967 r0 *1 19.78,73.44
X$967 49 332 365 378 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $968 r0 *1 21.16,73.44
X$968 32 398 393 416 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $969 r0 *1 24.84,73.44
X$969 49 393 417 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $970 r0 *1 26.22,73.44
X$970 32 451 351 373 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $971 r0 *1 30.36,73.44
X$971 32 418 392 421 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $972 r0 *1 34.04,73.44
X$972 49 330 435 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $974 r0 *1 35.88,73.44
X$974 49 339 437 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $977 r0 *1 38.64,73.44
X$977 49 296 440 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $983 r0 *1 43.7,73.44
X$983 32 405 424 345 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $984 r0 *1 47.84,73.44
X$984 32 454 390 354 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $985 r0 *1 51.98,73.44
X$985 49 407 389 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $986 r0 *1 53.36,73.44
X$986 32 452 387 345 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $988 r0 *1 58.42,73.44
X$988 32 406 423 394 318 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $989 r0 *1 62.56,73.44
X$989 49 332 394 383 49 32 32 sky130_fd_sc_hd__nand2_1
* cell instance $990 r0 *1 63.94,73.44
X$990 49 403 402 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $992 r0 *1 66.24,73.44
X$992 32 420 399 394 333 49 49 32 sky130_fd_sc_hd__mux2_1
* cell instance $995 r0 *1 70.84,73.44
X$995 32 400 356 414 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $997 r0 *1 74.98,73.44
X$997 49 397 375 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1009 m0 *1 10.58,78.88
X$1009 49 427 396 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1014 m0 *1 15.64,78.88
X$1014 49 428 408 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1016 m0 *1 17.94,78.88
X$1016 32 413 369 408 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $1017 m0 *1 21.62,78.88
X$1017 49 426 416 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1019 m0 *1 23.92,78.88
X$1019 49 369 429 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1020 m0 *1 25.3,78.88
X$1020 49 451 409 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1022 m0 *1 27.6,78.88
X$1022 49 351 430 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1024 m0 *1 29.44,78.88
X$1024 49 431 353 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1025 m0 *1 30.82,78.88
X$1025 49 401 432 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1026 m0 *1 32.2,78.88
X$1026 49 433 421 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1027 m0 *1 33.58,78.88
X$1027 49 453 434 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1028 m0 *1 34.96,78.88
X$1028 49 392 436 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1029 m0 *1 36.34,78.88
X$1029 49 438 312 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1031 m0 *1 38.18,78.88
X$1031 49 439 322 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1032 m0 *1 39.56,78.88
X$1032 49 313 441 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1034 m0 *1 41.4,78.88
X$1034 49 442 404 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1037 m0 *1 45.08,78.88
X$1037 49 443 424 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1038 m0 *1 46.46,78.88
X$1038 49 390 444 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1039 m0 *1 47.84,78.88
X$1039 49 454 410 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1040 m0 *1 49.22,78.88
X$1040 49 445 425 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1041 m0 *1 50.6,78.88
X$1041 32 379 390 425 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $1042 m0 *1 54.28,78.88
X$1042 49 452 446 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1045 m0 *1 57.04,78.88
X$1045 49 387 411 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1047 m0 *1 60.26,78.88
X$1047 49 447 423 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1049 m0 *1 62.56,78.88
X$1049 49 448 412 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1050 m0 *1 63.94,78.88
X$1050 32 422 399 412 291 49 49 32 sky130_fd_sc_hd__mux2i_1
* cell instance $1051 m0 *1 67.62,78.88
X$1051 49 399 419 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1052 m0 *1 69,78.88
X$1052 49 420 450 32 49 32 sky130_fd_sc_hd__clkbuf_1
* cell instance $1054 m0 *1 70.84,78.88
X$1054 49 449 414 32 49 32 sky130_fd_sc_hd__clkbuf_1
.ENDS shadow_register

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__buf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_16 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=935000000000P
+ AD=810000000000P PS=8870000U PD=7620000U
* device instance $7 r0 *1 2.99,1.985 pfet_01v8_hvt
M$7 4 3 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $23 r0 *1 0.47,0.56 nfet_01v8
M$23 3 2 1 7 nfet_01v8 L=150000U W=3900000U AS=607750000000P AD=526500000000P
+ PS=6420000U PD=5520000U
* device instance $29 r0 *1 2.99,0.56 nfet_01v8
M$29 4 3 1 7 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__buf_16

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 0.47,0.445 nfet_01v8
M$16 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 0.89,0.445 nfet_01v8
M$17 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__clkbuf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 1.335,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.12e+12P AD=1.245e+12P
+ PS=10240000U PD=11490000U
* device instance $11 r0 *1 0.475,0.445 nfet_01v8
M$11 3 2 1 7 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=117600000000P
+ PS=2070000U PD=1400000U
* device instance $13 r0 *1 1.335,0.445 nfet_01v8
M$13 4 3 1 7 nfet_01v8 L=150000U W=3360000U AS=470400000000P AD=525000000000P
+ PS=5600000U PD=6280000U
.ENDS sky130_fd_sc_hd__clkbuf_8

* cell sky130_fd_sc_hd__clkbuf_4
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 6 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=165000000000P PS=2530000U PD=1330000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=4000000U AS=585000000000P
+ AD=720000000000P PS=5170000U PD=6440000U
* device instance $6 r0 *1 0.475,0.445 nfet_01v8
M$6 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=70350000000P
+ PS=1370000U PD=755000U
* device instance $7 r0 *1 0.96,0.445 nfet_01v8
M$7 5 2 4 7 nfet_01v8 L=150000U W=1680000U AS=246750000000P AD=298200000000P
+ PS=2855000U PD=3520000U
.ENDS sky130_fd_sc_hd__clkbuf_4

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 1.85,0.56 nfet_01v8
M$7 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.27,0.56 nfet_01v8
M$8 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 0.89,0.56 nfet_01v8
M$10 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__buf_2
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_2 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.125 pfet_01v8_hvt
M$1 2 3 6 1 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P AD=166400000000P
+ PS=1325000U PD=1800000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=284000000000P
+ AD=400000000000P PS=2595000U PD=3800000U
* device instance $4 r0 *1 0.47,0.445 nfet_01v8
M$4 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $5 r0 *1 0.945,0.56 nfet_01v8
M$5 5 2 4 7 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=260000000000P
+ PS=1895000U PD=2750000U
.ENDS sky130_fd_sc_hd__buf_2

* cell sky130_fd_sc_hd__mux2_1
* pin VGND
* pin X
* pin A1
* pin A0
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_1 1 2 3 5 9 10 11 14
* net 1 VGND
* net 2 X
* net 3 A1
* net 5 A0
* net 9 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.015,2.08 pfet_01v8_hvt
M$1 12 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=158350000000P
+ AD=76650000000P PS=1395000U PD=785000U
* device instance $2 r0 *1 1.53,2.08 pfet_01v8_hvt
M$2 4 5 12 11 pfet_01v8_hvt L=150000U W=420000U AS=76650000000P
+ AD=193200000000P PS=785000U PD=1340000U
* device instance $3 r0 *1 2.6,2.08 pfet_01v8_hvt
M$3 13 3 4 11 pfet_01v8_hvt L=150000U W=420000U AS=193200000000P
+ AD=44100000000P PS=1340000U PD=630000U
* device instance $4 r0 *1 2.96,2.08 pfet_01v8_hvt
M$4 10 6 13 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $5 r0 *1 3.44,2.08 pfet_01v8_hvt
M$5 6 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=117600000000P PS=750000U PD=1400000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=158350000000P PS=2520000U PD=1395000U
* device instance $7 r0 *1 1.015,0.445 nfet_01v8
M$7 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=112850000000P AD=69300000000P
+ PS=1045000U PD=750000U
* device instance $8 r0 *1 1.495,0.445 nfet_01v8
M$8 4 3 7 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=99750000000P
+ PS=750000U PD=895000U
* device instance $9 r0 *1 2.12,0.445 nfet_01v8
M$9 8 5 4 14 nfet_01v8 L=150000U W=420000U AS=99750000000P AD=69300000000P
+ PS=895000U PD=750000U
* device instance $10 r0 *1 2.6,0.445 nfet_01v8
M$10 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=144900000000P
+ PS=750000U PD=1110000U
* device instance $11 r0 *1 3.44,0.445 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=420000U AS=144900000000P AD=109200000000P
+ PS=1110000U PD=1360000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112850000000P
+ PS=1820000U PD=1045000U
.ENDS sky130_fd_sc_hd__mux2_1

* cell sky130_fd_sc_hd__buf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 2 3 6 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.08e+12P AD=1.205e+12P
+ PS=10160000U PD=11410000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 2 3 7 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $15 r0 *1 1.73,0.56 nfet_01v8
M$15 4 3 1 7 nfet_01v8 L=150000U W=5200000U AS=702000000000P AD=783250000000P
+ PS=7360000U PD=8260000U
.ENDS sky130_fd_sc_hd__buf_8

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6
