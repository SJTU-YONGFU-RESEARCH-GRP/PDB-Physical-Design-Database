* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT sequence_detector_fsm clk config_pattern[0] config_pattern[1]
+ config_pattern[2] config_pattern[3] enable load_pattern pattern_detected
+ rst_n serial_in
X_49_ pattern_reg\[2\] shift_reg\[1\] VSS VSS VDD VDD _12_
+ sky130_fd_sc_hd__xnor2_1
X_50_ pattern_reg\[1\] shift_reg\[0\] _12_ VSS VSS VDD VDD
+ _13_ sky130_fd_sc_hd__nand3_1
X_51_ pattern_reg\[0\] pattern_reg\[2\] shift_reg\[1\] VSS
+ VSS VDD VDD _14_ sky130_fd_sc_hd__and3b_1
X_52_ pattern_reg\[2\] shift_reg\[1\] VSS VSS VDD VDD _15_
+ sky130_fd_sc_hd__nor2_1
X_53_ pattern_reg\[1\] shift_reg\[0\] VSS VSS VDD VDD _16_
+ sky130_fd_sc_hd__nor2_1
X_54_ _14_ _15_ _16_ VSS VSS VDD VDD _17_ sky130_fd_sc_hd__o21ai_0
X_55_ pattern_reg\[3\] shift_reg\[2\] VSS VSS VDD VDD _18_
+ sky130_fd_sc_hd__xor2_1
X_56_ pattern_reg\[0\] net8 VSS VSS VDD VDD _19_ sky130_fd_sc_hd__xor2_1
X_57_ _13_ _17_ _18_ _19_ VSS VSS VDD VDD _20_ sky130_fd_sc_hd__a211o_1
X_58_ pattern_reg\[2\] pattern_reg\[1\] VSS VSS VDD VDD _21_
+ sky130_fd_sc_hd__nor2b_1
X_59_ _47_ _42_ input_count\[2\] VSS VSS VDD VDD _22_ sky130_fd_sc_hd__mux2i_1
X_60_ input_count\[3\] pattern_reg\[1\] shift_reg\[0\] net8
+ VSS VSS VDD VDD _23_ sky130_fd_sc_hd__or4b_1
X_61_ pattern_reg\[2\] shift_reg\[1\] shift_reg\[2\] VSS VSS
+ VDD VDD _24_ sky130_fd_sc_hd__nand3_1
X_62_ _22_ _23_ _24_ VSS VSS VDD VDD _25_ sky130_fd_sc_hd__nor3_1
X_63_ _21_ _25_ pattern_reg\[0\] pattern_reg\[3\] VSS VSS
+ VDD VDD _26_ sky130_fd_sc_hd__o211ai_1
X_64_ net6 VSS VSS VDD VDD _27_ sky130_fd_sc_hd__buf_4
X_65_ enable VSS VSS VDD VDD _28_ sky130_fd_sc_hd__buf_4
X_66_ input_count\[3\] _45_ VSS VSS VDD VDD _29_ sky130_fd_sc_hd__nand2_1
X_67_ input_count\[2\] _29_ _21_ pattern_reg\[3\] pattern_reg\[0\]
+ VSS VSS VDD VDD _30_ sky130_fd_sc_hd__o2111ai_1
X_68_ _27_ _28_ _30_ VSS VSS VDD VDD _31_ sky130_fd_sc_hd__nand3b_1
X_69_ _20_ _26_ _31_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__a21oi_1
X_70_ input_count\[0\] VSS VSS VDD VDD _41_ sky130_fd_sc_hd__inv_1
X_71_ input_count\[1\] VSS VSS VDD VDD _44_ sky130_fd_sc_hd__inv_1
X_72_ _28_ input_count\[0\] VSS VSS VDD VDD _32_ sky130_fd_sc_hd__xnor2_1
X_73_ _27_ _32_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__nor2_1
X_74_ _44_ _43_ _28_ VSS VSS VDD VDD _33_ sky130_fd_sc_hd__mux2_1
X_75_ _27_ _33_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__nor2_1
X_76_ _28_ _47_ VSS VSS VDD VDD _34_ sky130_fd_sc_hd__nand2_1
X_77_ input_count\[2\] _34_ VSS VSS VDD VDD _35_ sky130_fd_sc_hd__xor2_1
X_78_ _27_ _35_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__nor2_1
X_79_ _28_ input_count\[2\] input_count\[0\] input_count\[1\]
+ VSS VSS VDD VDD _36_ sky130_fd_sc_hd__nand4_1
X_80_ input_count\[3\] _36_ VSS VSS VDD VDD _37_ sky130_fd_sc_hd__xor2_1
X_81_ _27_ _37_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__nor2_1
X_82_ pattern_reg\[0\] net2 _27_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__mux2_1
X_83_ pattern_reg\[1\] net3 _27_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__mux2_1
X_84_ pattern_reg\[2\] net4 net6 VSS VSS VDD VDD _07_ sky130_fd_sc_hd__mux2_1
X_85_ pattern_reg\[3\] net5 net6 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__mux2_1
X_86_ shift_reg\[0\] net8 _28_ VSS VSS VDD VDD _38_ sky130_fd_sc_hd__mux2i_1
X_87_ _27_ _38_ VSS VSS VDD VDD _09_ sky130_fd_sc_hd__nor2_1
X_88_ shift_reg\[1\] shift_reg\[0\] _28_ VSS VSS VDD VDD _39_
+ sky130_fd_sc_hd__mux2i_1
X_89_ _27_ _39_ VSS VSS VDD VDD _10_ sky130_fd_sc_hd__nor2_1
X_90_ shift_reg\[2\] shift_reg\[1\] _28_ VSS VSS VDD VDD _40_
+ sky130_fd_sc_hd__mux2i_1
X_91_ _27_ _40_ VSS VSS VDD VDD _11_ sky130_fd_sc_hd__nor2_1
X_92_ _41_ input_count\[1\] VSS VSS VDD VDD _42_ _43_ sky130_fd_sc_hd__ha_1
X_93_ input_count\[0\] _44_ VSS VSS VDD VDD _45_ _46_ sky130_fd_sc_hd__ha_1
X_94_ input_count\[0\] input_count\[1\] VSS VSS VDD VDD _47_
+ _48_ sky130_fd_sc_hd__ha_1
Xinput_count\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1
+ VSS VSS VDD VDD input_count\[0\] sky130_fd_sc_hd__dfrtp_1
Xinput_count\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD input_count\[1\] sky130_fd_sc_hd__dfrtp_1
Xinput_count\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _03_ net1
+ VSS VSS VDD VDD input_count\[2\] sky130_fd_sc_hd__dfrtp_1
Xinput_count\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _04_ net1
+ VSS VSS VDD VDD input_count\[3\] sky130_fd_sc_hd__dfrtp_1
Xpattern_detected$_DFF_PN0_ clknet_1_1__leaf_clk _00_ net1
+ VSS VSS VDD VDD net9 sky130_fd_sc_hd__dfrtp_1
Xpattern_reg\[0\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _05_ net7
+ VSS VSS VDD VDD pattern_reg\[0\] sky130_fd_sc_hd__dfstp_1
Xpattern_reg\[1\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _06_ net7
+ VSS VSS VDD VDD pattern_reg\[1\] sky130_fd_sc_hd__dfstp_1
Xpattern_reg\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _07_ net1
+ VSS VSS VDD VDD pattern_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xpattern_reg\[3\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _08_ net7
+ VSS VSS VDD VDD pattern_reg\[3\] sky130_fd_sc_hd__dfstp_1
Xshift_reg\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _09_ net1
+ VSS VSS VDD VDD shift_reg\[0\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _10_ net1
+ VSS VSS VDD VDD shift_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _11_ net1
+ VSS VSS VDD VDD shift_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net7 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 config_pattern[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput2 config_pattern[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 config_pattern[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 config_pattern[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 load_pattern VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 net10 VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_2
Xinput7 serial_in VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xoutput8 net9 VSS VSS VDD VDD pattern_detected sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkinv_1
Xhold2 rst_n VSS VSS VDD VDD net10 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS sequence_detector_fsm
