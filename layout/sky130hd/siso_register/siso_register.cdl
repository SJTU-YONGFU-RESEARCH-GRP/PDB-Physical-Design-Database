* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT siso_register clk enable rst_n serial_in serial_out
X_09_ enable VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_6
X_10_ net3 shift_reg\[1\] _08_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__mux2_1
X_11_ shift_reg\[1\] shift_reg\[2\] _08_ VSS VSS VDD VDD _01_
+ sky130_fd_sc_hd__mux2_1
X_12_ shift_reg\[2\] shift_reg\[3\] _08_ VSS VSS VDD VDD _02_
+ sky130_fd_sc_hd__mux2_1
X_13_ shift_reg\[3\] shift_reg\[4\] _08_ VSS VSS VDD VDD _03_
+ sky130_fd_sc_hd__mux2_1
X_14_ shift_reg\[4\] shift_reg\[5\] _08_ VSS VSS VDD VDD _04_
+ sky130_fd_sc_hd__mux2_1
X_15_ shift_reg\[5\] shift_reg\[6\] _08_ VSS VSS VDD VDD _05_
+ sky130_fd_sc_hd__mux2_1
X_16_ shift_reg\[6\] shift_reg\[7\] _08_ VSS VSS VDD VDD _06_
+ sky130_fd_sc_hd__mux2_1
X_17_ shift_reg\[7\] net2 _08_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__mux2_1
Xshift_reg\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _00_ net1
+ VSS VSS VDD VDD net3 sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _01_ net1
+ VSS VSS VDD VDD shift_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _02_ net1
+ VSS VSS VDD VDD shift_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _03_ net1
+ VSS VSS VDD VDD shift_reg\[3\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _04_ net1
+ VSS VSS VDD VDD shift_reg\[4\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _05_ net1
+ VSS VSS VDD VDD shift_reg\[5\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[6\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _06_ net1
+ VSS VSS VDD VDD shift_reg\[6\] sky130_fd_sc_hd__dfrtp_1
Xshift_reg\[7\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _07_ net1
+ VSS VSS VDD VDD shift_reg\[7\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net4 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 serial_in VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xoutput2 net3 VSS VSS VDD VDD serial_out sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xhold2 rst_n VSS VSS VDD VDD net4 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS siso_register
